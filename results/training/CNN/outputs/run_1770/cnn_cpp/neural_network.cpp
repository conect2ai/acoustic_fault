#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.44593892f, -0.14110944f, 0.80074155f, -0.26709139f, 0.37265140f, 0.16769898f, 0.32979238f, 0.25871184f, 
    -0.47918558f, 0.38473180f, 0.43547681f, 0.77102923f, -0.01064218f, -0.90234745f, -0.42577568f, 0.24877502f, 
    0.22263087f, 0.15560327f, 0.66640675f, 0.40347970f, -0.25450733f, -0.15557908f, 0.44302896f, 0.42605156f, 
    0.15730895f, 0.36305666f, -0.29800609f, -0.05640771f, -0.60412794f, -0.22818625f, -0.41228619f, -0.42347381f, 
    -0.56937158f, -0.14213076f, -0.28612205f, -0.54727626f, -0.51701158f, -0.08345821f, 0.42070454f, 0.91677338f, 
    -0.16189070f, -0.92227441f, -0.24916442f, 0.44811761f, -0.36426544f, -0.78708732f, -0.95833093f, -0.59799951f, 
    0.31240082f, 1.02875519f, 0.29587510f, -0.01800367f, 0.03189490f, -0.31611711f, 0.53912592f, -0.46276405f, 
    -0.21680087f, 0.44509175f, -0.11052378f, 0.41522622f, -0.21907297f, 0.62889665f, -0.69589293f, 0.76287943f, 
    0.21199556f, -0.29120961f, 0.63251561f, -0.35245225f, 0.65624630f, -0.32708403f, -0.21663508f, -0.53514415f, 
    -0.18804030f, 0.25903684f, -0.03204706f, -1.12608206f, 1.28688788f, -0.09679127f, -0.16866884f, 0.11522792f, 
    0.10705180f, 0.43347141f, 0.70300055f, -0.58686948f, -0.53465676f, -0.02704641f, 0.38975960f, -0.40842491f, 
    -0.15041408f, 0.73516417f, -0.43399483f, 1.19098806f, -0.83737409f, 0.08077270f, 0.04807601f, -0.36730132f, 
    -0.26572919f, 0.33375305f, 0.23919362f, 0.00408600f, 0.24641512f, -0.27421907f, -0.74263644f, -0.77894276f, 
    -0.72670293f, -0.18184616f, 0.85377783f, -0.22358862f, 0.38272211f, 0.02959033f, 0.27700937f, 0.02387770f, 
    0.32738882f, 0.75911725f, -0.05359476f, 0.20172152f, 0.41817799f, -0.85661858f, -0.88460940f, 0.02083981f, 
    0.24377151f, 0.17625383f, -0.55080229f, 0.05559597f, -0.40999669f, -0.50241798f, -0.94403416f, -0.06100407f, 
    0.75977105f, -0.84187919f, -0.54444629f, -0.20153619f, 0.69042575f, 0.32657796f, -0.09516124f, -0.03964234f, 
    0.66824669f, -0.52403617f, -0.22901906f, -0.25373036f, -0.34559169f, 0.39215818f, 0.29431641f, 0.71274245f, 
    0.72532547f, 0.14218517f, 0.45788884f, 0.09536716f, 0.07115670f, -0.17942527f, 0.18580543f, 0.42337584f, 
    0.54996264f, 0.04726912f, -0.40834993f, -0.62773913f, -0.68572849f, 0.31018525f, 1.23651981f, -0.03606217f, 
    -0.03574188f, -0.24956110f, 0.31912035f, 0.70103776f, -0.57267797f, -0.26856783f, -0.15420893f, 0.33704847f, 
    -0.23779558f, 0.28890643f, 0.06714780f, 0.58127874f, -0.16679417f, 0.72812635f, -0.14603460f, -0.21248697f, 
    0.40510032f, 0.32433909f, -0.22218740f, 0.12843956f, 0.60603774f, -0.06928622f, -0.96811855f, -0.20729873f, 
    -0.26848406f, -0.41309148f, -0.43081039f, -0.57424438f, -0.35808927f, 0.03402689f, -0.05799477f, -0.40053895f, 
    0.65927136f, 0.81130499f, 0.48129955f, 0.21669790f, 0.52362299f, 0.18305315f, -1.28045774f, 0.62745363f, 
    0.59432459f, -0.25841573f, -0.12459174f, 0.60433167f, -0.22135332f, 0.40226421f, -0.45956859f, 0.23282410f, 
    -0.39144540f, 0.40067527f, -0.04707677f, 0.58520204f, -0.44091794f, 0.47903332f, -0.47382891f, 0.00392736f, 
    -0.44521588f, -0.34526786f, 0.18497817f, -0.38193607f, -0.59378380f, 0.15545096f, -0.39022517f, -0.49048838f, 
    0.18902390f, -0.02985740f, -0.40254593f, -0.98923975f, 0.58331883f, 0.44641373f, -0.55398124f, -0.07489982f, 
    0.10237709f, -0.09088738f, -0.12101494f, 0.33985072f, 0.04894762f, 0.74919736f, -0.64512295f, -0.36412904f, 
    0.03566031f, -0.57441777f, 0.15424906f, -0.40940136f, -0.57868582f, -0.39548901f, -0.50621933f, -0.46612823f, 
    -0.41130522f, 0.27139103f, 0.12914380f, 0.87381595f, -0.07344665f, 0.47396663f, 0.52375001f, 0.26521581f, 
    0.36174375f, -0.35462454f, -0.38198814f, -0.35206431f, -0.13599898f, -0.15905426f, -0.71520197f, 1.13316619f, 
    -0.41603673f, -0.56408948f, -0.42483729f, 0.19655390f, -0.37801629f, -0.19104630f, 0.75005025f, 0.75429201f, 
    -0.09299529f, -0.49173424f, -0.34675461f, -0.23270345f, -0.06277061f, -0.10189894f, -0.39732999f, 0.46303454f, 
    0.34080482f, 0.24454065f, -0.31372386f, 0.51579863f, -0.82604712f, 0.13801350f, -0.03170641f, 0.61555392f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.16073784f, -0.03154143f, -0.30932632f, -0.31136850f, 0.25125989f, -0.17712933f, 0.35376972f, 0.13597852f, 
    0.07686075f, 0.31672949f, -0.00581227f, 0.29768544f, 0.36199167f, 0.28219420f, -0.07877088f, 0.30069715f, 
    0.39303365f, -0.12698747f, 0.28178850f, 0.24333169f, -0.09857461f, -0.07150190f, -0.04374922f, 0.41662654f, 
    -0.37054431f, 0.37863949f, -0.01607740f, -0.05032339f, 0.28609309f, 0.08986375f, 0.06598470f, -0.15493669f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.16663031f, 0.06180143f, 0.03997700f, -0.17555349f, -0.14981911f, -0.17095551f, -0.30976614f, -0.14606392f, 
    0.09767899f, -0.32218173f, -0.27117819f, -0.19263902f, 0.02741891f, -0.05730188f, -0.07793697f, -0.04048201f, 
    -0.07291643f, -0.07056507f, 0.13514502f, 0.06242479f, 0.05422695f, -0.15847895f, -0.14230478f, -0.25445276f, 
    -0.47775963f, -0.16348958f, -0.13221447f, -0.24963787f, -0.40535834f, -0.46024132f, 0.01914873f, -0.02574619f, 
    -0.10907114f, 0.05969018f, -0.09435687f, 0.14187239f, 0.20272858f, -0.03526482f, -0.01918738f, 0.20439732f, 
    0.24696979f, 0.09697840f, 0.11282011f, 0.04264034f, 0.03902846f, -0.48634726f, -0.03191137f, 0.41691825f, 
    -0.10826799f, -0.01521095f, -0.37910780f, -0.15218838f, -0.17805219f, -0.09950786f, 0.07781999f, 0.04198249f, 
    0.07995304f, 0.14643906f, 0.10052090f, 0.12048954f, 0.20796959f, -0.11788841f, 0.12366835f, -0.22947671f, 
    0.08654936f, 0.08332253f, -0.00609412f, -0.07242149f, -0.08204306f, 0.14905901f, -0.14504229f, -0.28401870f, 
    0.07505587f, -0.06775814f, 0.26110467f, -0.07468887f, 0.07407781f, 0.06425313f, 0.01223478f, 0.00505626f, 
    -0.06708661f, 0.21570680f, 0.06756711f, 0.24274877f, 0.01939025f, 0.16958040f, 0.07854571f, 0.07999803f, 
    0.10344213f, -0.11193449f, 0.20903726f, -0.42201552f, -0.11680843f, 0.12126956f, 0.09521725f, -0.01742917f, 
    0.25764909f, 0.08009244f, 0.05657609f, -0.04555166f, -0.26106870f, -0.27941510f, 0.06202431f, 0.15887056f, 
    -0.05740042f, 0.09654254f, 0.10581051f, 0.23440599f, -0.01973367f, 0.10438498f, 0.13431592f, -0.02572206f, 
    -0.05276575f, 0.05768164f, -0.14972296f, -0.11051559f, 0.11712603f, 0.01238563f, -0.08432359f, 0.24007210f, 
    -0.10470176f, 0.00725722f, 0.08005960f, -0.05097952f, -0.00990186f, -0.13695523f, -0.03965351f, -0.20792152f, 
    -0.37474230f, -0.01823204f, -0.01316817f, -0.19204208f, -0.06836020f, 0.06843995f, -0.04596311f, -0.00809438f, 
    -0.19720288f, -0.26395547f, 0.00877830f, -0.05045992f, 0.04315366f, 0.10686768f, 0.05985487f, 0.22246346f, 
    0.09481111f, -0.06865690f, 0.03723926f, -0.08703383f, -0.06850194f, -0.00801947f, -0.14625581f, 0.03361496f, 
    0.15463972f, -0.15906206f, 0.08057467f, 0.09818308f, -0.08233153f, 0.10102544f, -0.09788807f, 0.08503837f, 
    0.07017262f, 0.01556727f, 0.37798643f, 0.10116430f, 0.08691046f, 0.03736538f, 0.15747799f, 0.09564560f, 
    0.05295786f, 0.19921041f, 0.14884128f, 0.12983778f, 0.16296434f, 0.12230004f, -0.00490568f, -0.08856876f, 
    0.10654744f, -0.24226311f, 0.07664380f, 0.14818175f, -0.31120282f, -0.11085067f, -0.41921946f, -0.00119008f, 
    0.07228579f, -0.07692390f, 0.12746352f, -0.08223387f, 0.13064116f, -0.19427416f, 0.03133472f, 0.16952057f, 
    0.07218495f, 0.02826933f, -0.17349853f, -0.14839034f, -0.03870167f, 0.13697152f, 0.07035141f, -0.08258022f, 
    0.08001021f, -0.03793201f, -0.05719810f, 0.14787285f, -0.02401927f, -0.12437315f, 0.04643991f, 0.13937613f, 
    0.11855543f, 0.13773037f, 0.16714150f, 0.05303224f, 0.11481974f, 0.09548826f, 0.24687402f, 0.22738340f, 
    -0.05750120f, -0.29684409f, -0.33996403f, 0.00679506f, 0.09732296f, -0.01986684f, 0.00968217f, 0.00004232f, 
    -0.10332038f, -0.02236659f, 0.08311076f, 0.36527053f, 0.12310451f, 0.02520286f, 0.04704508f, 0.11171924f, 
    -0.06005962f, 0.03649628f, -0.21865745f, -0.05913600f, -0.08076762f, 0.06811140f, 0.05775927f, -0.04749457f, 
    0.12268372f, 0.05057929f, 0.14582497f, -0.43340403f, 0.04570503f, -0.16854754f, -0.16321523f, 0.14532334f, 
    -0.01974215f, 0.03252519f, 0.03168239f, 0.09492760f, -0.22337933f, 0.18057016f, 0.32924363f, 0.03520782f, 
    0.06491651f, -0.04522407f, 0.03525573f, 0.04225025f, -0.26498598f, 0.11329430f, 0.00324265f, -0.43152943f, 
    0.16982320f, -0.10571434f, 0.12179806f, 0.23392640f, -0.04845060f, 0.09110685f, -0.17038867f, -0.16821140f, 
    0.20308065f, -0.06888038f, 0.09505316f, -0.04591634f, -0.24104388f, 0.09243061f, -0.13843752f, 0.02917541f, 
    -0.46518180f, -0.03531493f, -0.01248397f, -0.19543724f, -0.04200349f, -0.05650870f, 0.13517314f, -0.04424682f, 
    -0.10221282f, -0.12297622f, -0.30950263f, -0.11189836f, -0.12097221f, 0.04383070f, -0.03322281f, 0.06592380f, 
    0.04922296f, -0.11195503f, 0.06104990f, -0.03476556f, 0.00477593f, 0.00015089f, 0.06931527f, 0.17518392f, 
    0.06808709f, -0.26463085f, -0.12606853f, -0.09141064f, -0.31243175f, -0.05760080f, 0.07031143f, -0.14759955f, 
    -0.13462625f, -0.05824311f, -0.15385632f, -0.18613221f, -0.06353445f, 0.15454237f, 0.12779541f, 0.00770860f, 
    0.02262378f, -0.03627029f, 0.18442295f, 0.08212081f, 0.01473861f, 0.10457538f, 0.26660740f, 0.14272621f, 
    -0.03505024f, 0.17054619f, 0.26570493f, -0.14578158f, 0.06477982f, -0.19178140f, 0.21505779f, 0.04946563f, 
    -0.13198216f, -0.04765987f, 0.07642768f, -0.10006477f, 0.03222793f, -0.07081122f, 0.13147964f, 0.08271157f, 
    -0.04619649f, -0.04521267f, 0.19095875f, 0.25800219f, 0.00663185f, 0.01192338f, -0.17213708f, 0.08320515f, 
    -0.13728274f, -0.19989888f, -0.26208156f, 0.02806968f, 0.14854187f, -0.17393395f, -0.23299582f, -0.52192271f, 
    0.20564601f, -0.00683374f, -0.08733145f, 0.05395374f, 0.21945293f, 0.10713200f, -0.10194822f, 0.06825286f, 
    -0.09828200f, 0.34171191f, -0.04551222f, 0.02634441f, -0.07719237f, -0.02169926f, 0.11334366f, 0.18759899f, 
    -0.06448740f, -0.07492165f, -0.22470245f, 0.06467277f, 0.39531690f, 0.09515288f, -0.10063543f, 0.01414648f, 
    0.14735149f, -0.08787822f, 0.26822838f, 0.06139104f, 0.03970473f, 0.32577500f, 0.09090745f, 0.00733675f, 
    0.18472123f, 0.08184149f, 0.11110450f, 0.28178129f, 0.05380967f, -0.09498242f, -0.17762184f, 0.10132129f, 
    0.00302525f, 0.10692696f, -0.07667461f, -0.06930754f, -0.05847151f, -0.30266747f, -0.00669977f, 0.12844504f, 
    -0.03461192f, 0.04266210f, 0.03494801f, -0.20113255f, 0.11152487f, -0.08562530f, -0.07672683f, 0.04130068f, 
    -0.02950318f, 0.01202563f, -0.24244912f, 0.23026317f, 0.07419855f, 0.15755314f, 0.16496591f, -0.15939216f, 
    -0.07663778f, 0.08500914f, 0.00329623f, 0.03400396f, -0.09152102f, 0.26660979f, 0.25780821f, 0.11879645f, 
    -0.19125542f, -0.14696093f, -0.21885268f, -0.00291155f, 0.01788365f, -0.11581527f, 0.21985230f, 0.03970026f, 
    0.15502329f, 0.35630646f, -0.05030150f, 0.04367373f, -0.03242090f, 0.13647972f, -0.03616882f, -0.27045107f, 
    -0.02490334f, -0.11901906f, 0.46743050f, 0.10818844f, 0.26753423f, 0.04292136f, 0.10801879f, 0.01859180f, 
    0.20388262f, -0.02044767f, 0.08179680f, -0.04222497f, -0.21798889f, -0.18057148f, -0.12218252f, 0.08116350f, 
    -0.10488415f, -0.03749891f, -0.07419620f, 0.00969683f, 0.02644600f, -0.19189964f, -0.02605873f, 0.05713563f, 
    0.04826784f, 0.09012283f, -0.00663350f, 0.12552910f, 0.10191867f, -0.02603004f, -0.05127109f, -0.23176871f, 
    0.12716141f, 0.14684068f, -0.05378947f, 0.11521801f, 0.04518286f, 0.05548752f, 0.21221948f, -0.13366233f, 
    -0.11480886f, 0.07066201f, -0.02154818f, 0.05854029f, 0.13372082f, -0.36877817f, -0.35438630f, 0.20538795f, 
    0.15636012f, 0.01499254f, 0.08617076f, 0.12882201f, 0.00959550f, 0.18060359f, 0.08306190f, 0.09370350f, 
    -0.11992657f, -0.18862386f, -0.02558389f, 0.08964925f, 0.12103599f, -0.00308316f, -0.02399862f, 0.15556729f, 
    -0.10157137f, -0.11653928f, 0.28214425f, 0.23949923f, -0.21319973f, 0.04521733f, 0.24123889f, 0.02251021f, 
    0.04060527f, 0.29505035f, 0.18996632f, -0.01566822f, 0.13475977f, 0.12558599f, 0.26035529f, 0.05997246f, 
    0.03952174f, -0.22415747f, -0.07795557f, 0.08443282f, -0.14803644f, -0.16232985f, -0.07759202f, -0.10807706f, 
    0.02755330f, 0.13264233f, 0.16443090f, 0.15496571f, -0.05534121f, -0.11183864f, -0.16172040f, 0.00447707f, 
    0.04633833f, 0.10454503f, -0.06801120f, -0.20489444f, -0.20599039f, -0.14674626f, -0.04925272f, 0.09945606f, 
    0.01893038f, 0.00179876f, 0.13542832f, 0.13502559f, 0.07550371f, -0.03878836f, 0.13830888f, -0.30223045f, 
    0.04054230f, -0.08702248f, 0.09573323f, 0.10288855f, -0.04940770f, 0.04738120f, -0.00897580f, -0.04809301f, 
    -0.29223788f, -0.40177789f, -0.07581183f, 0.04056534f, -0.18388245f, 0.36076799f, 0.18575929f, 0.10424226f, 
    0.27052528f, -0.19003534f, -0.03350992f, -0.18575148f, -0.09729984f, -0.03897484f, -0.13739994f, -0.07318530f, 
    0.09008507f, -0.11531333f, -0.39285940f, 0.10349175f, 0.06231309f, 0.08072911f, -0.05865077f, 0.07199583f, 
    -0.14073876f, 0.11197765f, 0.36393908f, 0.01795749f, -0.14825326f, -0.02702237f, -0.45909074f, -0.03226220f, 
    -0.01975619f, -0.10266133f, -0.12599395f, 0.14148062f, -0.29047364f, -0.18666661f, -0.02385014f, -0.11037321f, 
    -0.05776613f, 0.02534911f, -0.05092186f, -0.06326907f, 0.05383432f, -0.12656794f, 0.00172354f, 0.23153538f, 
    -0.00412761f, -0.03993278f, 0.25479054f, 0.04657649f, 0.16557510f, -0.15989205f, -0.42817611f, -0.43823233f, 
    -0.31001738f, -0.01851795f, 0.17130192f, -0.00058510f, -0.05059331f, -0.00464958f, 0.32199773f, 0.24158712f, 
    0.11626758f, 0.22679485f, 0.12669398f, 0.20357819f, 0.13732192f, 0.12447968f, 0.15715161f, 0.17594680f, 
    0.08358774f, 0.07945122f, -0.01996443f, -0.05624255f, -0.07851351f, 0.14009653f, -0.00880336f, 0.33709076f, 
    -0.43400308f, 0.00405147f, 0.23875159f, -0.30729449f, 0.07096508f, -0.09020149f, 0.39735094f, 0.11441109f, 
    -0.24768673f, 0.10872515f, 0.02232122f, 0.00198955f, -0.02432424f, 0.09615447f, 0.28398469f, 0.07683843f, 
    0.14217706f, -0.11914309f, 0.26708543f, 0.47285727f, -0.17142013f, 0.07274440f, 0.20087937f, 0.19330885f, 
    -0.06938300f, 0.15396221f, 0.07139867f, -0.89721400f, -0.20534576f, -0.43740749f, 0.00595882f, 0.08910156f, 
    -0.17696810f, 0.09289952f, -0.13134380f, 0.17364042f, 0.17148726f, 0.02654986f, 0.02653968f, -0.09662271f, 
    -0.15372053f, -0.17688483f, -0.10297534f, -0.03574788f, -0.06855850f, 0.16130045f, -0.79136872f, -0.64175862f, 
    -0.09913146f, -0.07766269f, -0.01460225f, 0.15058368f, -0.02097376f, -0.31181917f, -1.13784683f, -0.36205932f, 
    0.31663996f, -0.04393714f, 0.16251685f, -0.04804738f, -0.01743650f, -0.10026104f, 0.14300749f, 0.12296002f, 
    0.21838103f, -0.07201491f, -0.08497638f, 0.13848896f, 0.17171635f, -0.04038429f, -0.12723599f, -0.00825702f, 
    0.21979928f, -0.00686829f, -0.07757373f, -0.04489133f, -0.07012390f, -0.02039445f, 0.05350801f, -0.07408020f, 
    0.04285711f, -0.60822010f, -0.40239805f, -0.67436230f, -0.17077243f, -0.07434291f, 0.18879561f, -0.03000086f, 
    0.07226962f, -0.06924843f, 0.28461242f, 0.14896500f, -0.36805618f, 0.04664859f, 0.07602485f, 0.28780472f, 
    0.08567507f, -0.10996527f, -0.12344907f, 0.23190713f, -0.03993212f, -0.03193816f, -0.00392631f, -0.00053234f, 
    -0.10460962f, -0.19180746f, 0.08784302f, -0.06679516f, -0.22325668f, -0.14628333f, -0.29274714f, 0.17651972f, 
    -0.13305458f, -0.03941224f, -0.17973652f, -0.12179415f, 0.07709458f, 0.10108228f, 0.06446341f, -0.07054735f, 
    -0.15069108f, -0.34135878f, -0.26995116f, 0.04621240f, -0.12666519f, 0.02952233f, 0.24811788f, 0.24642448f, 
    0.37555188f, -0.15612197f, 0.18342482f, -0.21071446f, 0.09848953f, 0.10615679f, -0.08902101f, 0.23406805f, 
    0.11203916f, -0.08297545f, 0.11721642f, 0.11663092f, 0.04883562f, 0.21287203f, -0.13697539f, 0.10037757f, 
    -0.16546503f, -0.16525023f, 0.11785853f, -0.06842931f, -0.04834650f, -0.26245654f, -0.19089493f, 0.00875022f, 
    -0.01343632f, -0.18388230f, -0.29438558f, -0.24359973f, 0.05542091f, -0.04182392f, 0.15500034f, 0.08552504f, 
    0.07512897f, -0.02583787f, 0.03943521f, 0.04402666f, -0.01564244f, 0.08522026f, 0.10366344f, -0.06467122f, 
    0.08648431f, 0.35183233f, -0.12448806f, -0.20770593f, 0.30304918f, -0.54650640f, -0.17150915f, 0.05680541f, 
    -0.02441546f, 0.00064093f, -0.10705496f, -0.18724808f, 0.13779345f, 0.06141954f, 0.01771376f, -0.05251325f, 
    0.01695064f, 0.01667252f, -0.01157698f, -0.05888668f, 0.13943632f, -0.23343892f, -0.35579628f, -0.04466095f, 
    0.10832817f, 0.16755846f, -0.01840743f, -0.00499669f, -0.01482368f, -0.09277803f, 0.12702616f, -0.08638778f, 
    -0.47658911f, 0.07011869f, 0.10747763f, 0.10335426f, 0.01427879f, -0.04025650f, 0.07747755f, 0.16149610f, 
    0.00290614f, 0.11201811f, -0.06036557f, -0.01635130f, 0.00577755f, 0.04804569f, -0.08351482f, -0.03835487f, 
    0.04565759f, 0.16931787f, -0.21680364f, -0.11399323f, 0.06392383f, -0.06222689f, 0.09819413f, 0.02117163f, 
    -0.05998759f, 0.27707145f, 0.23256257f, 0.12432273f, -0.11993002f, -0.14381592f, -0.06031065f, 0.18342684f, 
    0.14331618f, 0.14836633f, 0.13281852f, 0.00116872f, -0.10005757f, -0.22107451f, 0.03769018f, -0.09979493f, 
    0.14235093f, 0.15398309f, 0.06857462f, 0.40985879f, 0.11312190f, -0.16210745f, -0.21727815f, 0.00742459f, 
    -0.08857405f, 0.07785789f, -0.03048429f, 0.02830967f, -0.53007203f, 0.19852135f, 0.00059817f, 0.05296234f, 
    -0.09465631f, 0.08678486f, 0.01952764f, 0.00414710f, -0.26777428f, -0.43388855f, -0.76517761f, -0.72721660f, 
    -0.03280424f, 0.00563601f, 0.17981279f, 0.04261313f, -0.02111375f, 0.13083126f, -0.22797292f, 0.17239805f, 
    0.09856259f, -0.01445910f, 0.18112300f, -0.21008474f, -0.11898769f, 0.02566130f, 0.13819984f, 0.00621952f, 
    -0.08169001f, 0.12457744f, -0.02799493f, 0.01234556f, -0.14438896f, -0.06639441f, -0.06495188f, 0.05876964f, 
    -0.02987969f, -0.42196190f, 0.07185390f, -0.01752569f, 0.01472947f, -0.28616327f, 0.20297101f, 0.13158616f, 
    -0.19528948f, 0.19306770f, -0.05335946f, 0.32970095f, 0.06204257f, 0.13131560f, -0.06972656f, 0.03930612f, 
    0.11433104f, 0.00452958f, -0.17433564f, -0.22827381f, -0.26065877f, -0.28577125f, 0.23193629f, 0.17976470f, 
    0.18285365f, 0.25542420f, -0.19181238f, -0.22597355f, 0.09946091f, 0.43940532f, -0.12285201f, 0.00701271f, 
    -0.09795015f, 0.10796259f, 0.22199564f, 0.16940968f, 0.08726794f, -0.06920450f, 0.04848117f, -0.02290718f, 
    0.01416284f, -0.06040960f, 0.11483150f, 0.00223834f, 0.02818750f, 0.13653117f, -0.23876396f, -0.39519662f, 
    -0.07950681f, 0.04323959f, 0.13316579f, 0.09731668f, -0.11793592f, 0.06794120f, -0.50064576f, -0.32164150f, 
    0.01494468f, -0.15445919f, -0.10958700f, -0.06584909f, 0.16036068f, 0.00985047f, 0.05968164f, -0.06280422f, 
    0.10323647f, 0.05603760f, -0.07398852f, 0.00097590f, 0.10383577f, 0.08904535f, 0.15846549f, 0.08612188f, 
    0.25406212f, 0.14003421f, 0.03323783f, -0.11049272f, 0.06314414f, 0.00763609f, 0.13468978f, 0.01045853f, 
    0.06911965f, -0.43471816f, -0.72193414f, -0.07755496f, 0.01215337f, 0.09102309f, -0.13056344f, 0.03149869f, 
    -0.11021779f, 0.03540804f, 0.19938672f, -0.28040528f, 0.13217740f, -0.00495699f, 0.14717020f, -0.09490218f, 
    0.07231021f, 0.01419004f, -0.01713627f, 0.16133964f, 0.16545159f, 0.02202857f, -0.03472275f, -0.13420561f, 
    -0.01694602f, -0.01205738f, 0.01176903f, 0.09132429f, -0.02025866f, -0.12902744f, -0.26513717f, 0.05686526f, 
    -0.06468515f, 0.00494125f, 0.01818668f, -0.00110136f, -0.06419384f, -0.01590112f, -0.07364039f, -0.18454430f, 
    -0.19915853f, 0.03552334f, -0.06624467f, 0.15347792f, 0.09953662f, 0.09879463f, 0.11514944f, -0.06442414f, 
    0.05116457f, 0.14656483f, -0.12136334f, -0.14264761f, -0.05768228f, -0.00947754f, 0.00118524f, -0.10403503f, 
    0.07545654f, -0.01525951f, 0.05098484f, -0.03845727f, 0.01046296f, 0.05205026f, -0.09891313f, 0.14278169f, 
    0.02360415f, 0.06848364f, 0.34241995f, -0.14357741f, -0.16009946f, -0.07569090f, 0.08663480f, 0.10844887f, 
    0.06021955f, -0.44257417f, 0.06511088f, -0.27046576f, -0.00923704f, 0.15528825f, 0.09405691f, -0.00535616f, 
    -0.07024475f, -0.12432299f, -0.23386739f, 0.15114027f, -0.05995532f, -0.01202365f, -0.11663770f, -0.06835785f, 
    0.14873898f, 0.09034596f, 0.03716123f, -0.02029635f, -0.28759998f, -0.02035025f, -0.11566372f, -0.03174740f, 
    -0.08795791f, 0.03239949f, -0.14831768f, 0.07536372f, -0.02447069f, -0.02260704f, -0.01859351f, 0.00049136f, 
    -0.02551872f, -0.14473143f, -0.05854525f, 0.05333712f, 0.00793118f, -0.06060374f, 0.14109387f, 0.24054691f, 
    -0.08753287f, -0.05752335f, 0.04624694f, 0.15932253f, -0.11258028f, -0.00668513f, 0.30713871f, -0.04391686f, 
    0.06844161f, -0.06233872f, -0.11619315f, -0.14423616f, -0.05200425f, 0.10196445f, 0.03473039f, 0.24745065f, 
    0.25196561f, 0.15220217f, -0.13938886f, -0.10246825f, -0.11566388f, -0.02429199f, 0.15417281f, -0.02068149f, 
    -0.68125480f, -0.27609643f, -0.17718938f, -0.18350950f, 0.12003518f, -0.15849800f, -0.00237141f, -0.10833014f, 
    0.25972903f, -0.06023800f, -0.15519950f, 0.12249315f, -0.04509385f, 0.00294475f, -0.15092136f, 0.03090345f, 
    0.05267455f, 0.25682053f, -0.19508646f, 0.19052739f, -0.52726692f, -0.29153520f, 0.07409398f, 0.03101166f, 
    -0.11239422f, 0.18859406f, 0.02352168f, 0.22268496f, 0.08552132f, 0.18501039f, 0.02075845f, -0.06271979f, 
    -0.03172414f, -0.01042666f, -0.02192051f, 0.00693199f, 0.17652376f, 0.09825311f, -0.00948887f, 0.09235623f, 
    -0.02429008f, -0.09226299f, -0.12390564f, -0.03432893f, -0.08364502f, 0.43353352f, -0.17852283f, 0.11280170f, 
    0.02062674f, -0.04111591f, 0.20457336f, -0.08022306f, 0.12049934f, 0.10469642f, 0.28223920f, -0.13469127f, 
    -0.14263342f, -0.19946899f, 0.09502810f, -0.12615299f, -0.02973494f, -0.06666242f, 0.02354820f, 0.14414066f, 
    0.25624022f, 0.10311637f, -0.20804451f, -0.05544858f, -0.18612242f, 0.06860393f, -0.07584956f, 0.03113958f, 
    -0.33971426f, -0.61155790f, -0.05713008f, -0.15103845f, -0.13332066f, 0.14381079f, 0.21843922f, 0.09065180f, 
    0.01926480f, -0.56139195f, -0.29781410f, -0.20767008f, 0.12601021f, -0.11444751f, -0.05891644f, 0.10753322f, 
    0.02076536f, -0.13529579f, -0.10265313f, -0.69241655f, -0.75513095f, -0.02535509f, -0.11255047f, 0.10708328f, 
    0.29324040f, 0.31920829f, -0.21424434f, 0.07916214f, 0.03858249f, 0.01825516f, -0.05576409f, -0.05982244f, 
    -0.15070739f, -0.11305183f, -0.03932235f, 0.04497378f, 0.21561889f, -0.44359282f, -0.35854432f, -0.18260172f, 
    -0.10964762f, -0.06804517f, 0.04930355f, -0.21159035f, -0.06391024f, 0.43457776f, 0.01839340f, 0.13917980f, 
    -0.05958791f, -0.00078810f, -0.08003949f, -0.04767243f, -0.00503929f, -0.12932368f, 0.15818106f, 0.37334085f, 
    0.39072874f, -0.24757475f, 0.02143169f, -0.23118460f, 0.12858704f, 0.22973049f, 0.01128816f, 0.19128732f, 
    -0.18523367f, -0.22303446f, 0.02296886f, -0.05634662f, -0.21079269f, 0.04462072f, 0.23346415f, 0.06335664f, 
    0.29383177f, -0.34125748f, 0.00919149f, 0.05752819f, -0.07161789f, -0.14908895f, -0.02547467f, 0.08320713f, 
    0.06490549f, 0.35980582f, 0.02249161f, 0.04653554f, -0.02889885f, 0.10762419f, 0.33876184f, 0.12506844f, 
    0.14912423f, 0.01880981f, -0.79015291f, -0.34859464f, -0.50686383f, -0.15013911f, 0.06722630f, 0.05272857f, 
    0.07162050f, -0.07629079f, -0.16534108f, -0.33533922f, -0.06446666f, -0.08297899f, -0.00825823f, 0.08757946f, 
    -0.05181974f, 0.10599417f, -0.00295729f, -0.10044376f, -0.03007932f, 0.16525142f, 0.20872138f, -0.02308091f, 
    -0.02937711f, -0.00228484f, -0.11874841f, -0.13874759f, -0.01855513f, 0.24683063f, 0.08189451f, -0.12165526f, 
    -0.22511701f, -0.14976843f, 0.08600000f, 0.00321310f, 0.00649525f, -0.11097675f, -0.90120691f, -0.58224875f, 
    0.16062821f, -0.05886471f, 0.05859616f, 0.06523985f, -0.06323387f, 0.27066693f, 0.23259287f, -0.16988626f, 
    -0.39636317f, 0.11501452f, -0.16175164f, 0.02488964f, -0.08349366f, 0.03574752f, 0.02730054f, -0.11304138f, 
    0.22691052f, 0.14478466f, 0.13485140f, -0.09229099f, 0.10783555f, -0.05350966f, -0.06875306f, -0.07825616f, 
    0.01482615f, 0.15429141f, -0.02584248f, 0.06349714f, 0.12077039f, -0.16072458f, 0.09301315f, 0.06820539f, 
    -0.01008959f, 0.04376523f, -0.02108222f, 0.12799761f, -0.13493504f, -0.26724383f, -0.03773177f, -0.13016057f, 
    0.10170823f, 0.28925300f, -0.02575215f, 0.28795448f, 0.35903168f, 0.22588930f, -0.00285327f, 0.03447675f, 
    0.04740583f, -0.00353876f, 0.14952627f, -0.07586604f, 0.09451162f, -0.23758039f, -0.21593279f, -0.01693958f, 
    -0.10301309f, -0.25193456f, 0.05649152f, 0.00813436f, -0.17281087f, 0.18935478f, 0.11738864f, -0.25623125f, 
    0.01800986f, 0.05020067f, -0.09955991f, 0.12875554f, -0.04169120f, -0.04764155f, -0.32697320f, 0.32621098f, 
    -0.02005914f, 0.05504520f, 0.20802779f, 0.01513062f, -0.06980217f, -0.01659562f, -0.02859083f, 0.52189815f, 
    -0.31832483f, 0.61163127f, 0.12449086f, -0.05237669f, -0.28411132f, -0.05534384f, 0.08281254f, 0.00697222f, 
    0.05450531f, -0.18602858f, -0.15584242f, 0.05708260f, -0.08646420f, -0.01162385f, 0.07842555f, 0.03474570f, 
    0.12760939f, 0.15187581f, 0.12680404f, -0.25202832f, 0.05631027f, -0.06124697f, 0.17866379f, 0.07234388f, 
    0.05912463f, -0.00837777f, -0.02087782f, 0.01362180f, -0.10216991f, -0.00783023f, -0.02890980f, -0.00710343f, 
    -0.00650683f, 0.05556758f, 0.01871204f, -0.19045976f, 0.09175913f, 0.15032749f, 0.12290464f, -0.03189373f, 
    0.01747272f, -0.05028099f, -0.01496789f, 0.05135830f, 0.08510143f, -0.05998613f, -0.08368799f, -0.11097216f, 
    0.00648767f, 0.04419126f, 0.01779873f, -0.02281772f, 0.16534543f, 0.06169768f, -0.15552787f, 0.09117545f, 
    -0.00709349f, 0.20082654f, -0.04384488f, 0.06931391f, 0.13995421f, 0.03605091f, -0.24070081f, 0.02246326f, 
    -0.05656218f, 0.18492800f, 0.03975028f, 0.13790265f, -0.02119789f, 0.01934863f, 0.18950695f, -0.11622556f, 
    0.06722933f, -0.19490911f, 0.15846436f, 0.06738447f, 0.16109647f, 0.08662593f, 0.08663140f, 0.11628054f, 
    -0.02021525f, 0.09863479f, 0.06310493f, 0.15108955f, 0.15399908f, -0.02102255f, -0.28905150f, 0.04658407f, 
    0.04781810f, -0.29063964f, 0.02577795f, -0.19260405f, 0.06457867f, -0.07430081f, -0.17443147f, 0.14768341f, 
    -0.02555513f, -0.00890903f, 0.21497171f, 0.05392251f, -0.12781663f, 0.14752716f, -0.17549396f, -0.09057585f, 
    0.17099610f, -0.23459800f, 0.07887931f, -0.04386536f, -0.01354736f, 0.08377858f, 0.27039784f, 0.10619110f, 
    0.20397817f, 0.00611743f, -0.22310059f, 0.08155165f, 0.09041826f, -0.00319439f, -0.01681395f, 0.14142436f, 
    0.07545184f, 0.10536753f, -0.10341226f, -0.08390951f, -0.13746209f, -0.06962904f, -0.03614900f, -0.07824134f, 
    -0.07436364f, -0.05749698f, -0.06602018f, 0.08875377f, 0.12475869f, 0.12741716f, 0.07349140f, -0.10015745f, 
    -0.23770536f, 0.21407863f, -0.06700752f, 0.02822175f, 0.09299442f, -0.08054519f, -0.00086553f, 0.02642269f, 
    0.05250374f, -0.07528417f, 0.18374708f, -0.09305601f, -0.12869783f, -0.04535457f, -0.56304091f, -0.26707667f, 
    0.00296523f, -0.03128809f, -0.06946533f, -0.03774376f, 0.05055700f, -0.01365843f, 0.00715646f, -0.04960282f, 
    -0.26359174f, 0.04226232f, -0.15185115f, -0.16774173f, 0.03966370f, 0.20829663f, 0.09302532f, 0.08932349f, 
    0.23890913f, 0.07928950f, -0.09691009f, 0.00287789f, -0.30712223f, -0.11156621f, 0.07916095f, -0.29763424f, 
    0.23884428f, -0.01447816f, -0.05273180f, 0.03368745f, -0.06798159f, -0.20419927f, 0.05268515f, -0.04233414f, 
    0.08349766f, 0.11021487f, 0.08979157f, -0.08880691f, -0.11933493f, 0.05883377f, 0.27338544f, 0.17129096f, 
    0.23898289f, 0.06434209f, -0.06896143f, 0.02328632f, 0.05761952f, -0.01676016f, -0.09172752f, 0.05924749f, 
    0.03805231f, 0.07681423f, 0.11707868f, -0.22743814f, -0.35344458f, -0.28815365f, 0.45127892f, 0.02956238f, 
    -0.19506830f, -0.04436241f, -0.04994901f, 0.15563159f, 0.07295642f, -0.09293605f, 0.06201433f, 0.23435104f, 
    -0.12416762f, -0.13505936f, 0.07851923f, -0.01517863f, 0.04080637f, 0.12417445f, -0.15806049f, -0.01570891f, 
    0.03795199f, 0.02688432f, 0.14278759f, -0.21104513f, -0.02265326f, -0.08662170f, -0.16968510f, -0.10305898f, 
    0.00672225f, 0.06728931f, -0.00816478f, 0.00141448f, -0.04523094f, 0.00949156f, 0.01483556f, -0.03244529f, 
    0.25886571f, 0.22047856f, 0.16164596f, 0.30171183f, 0.22563428f, -0.18380505f, 0.24571501f, 0.14539383f, 
    0.04369443f, 0.14434636f, -0.00038881f, -0.10442041f, -0.09690166f, -0.06571711f, 0.19719219f, 0.20864075f, 
    0.09007429f, 0.05461606f, -0.15959534f, -0.18938561f, 0.17513619f, 0.09726766f, -0.29332274f, 0.17741552f, 
    0.13758436f, 0.02185796f, 0.00064744f, -0.01140296f, -0.07654619f, 0.16228026f, 0.12821585f, 0.14407016f, 
    0.09740275f, -0.06393486f, -0.06133346f, 0.03331023f, 0.10658641f, 0.14325888f, 0.18222369f, 0.11632135f, 
    0.07728818f, 0.08661593f, -0.08936655f, 0.14313282f, 0.13123469f, 0.13477482f, 0.14307804f, -0.01339020f, 
    0.01684896f, 0.03273846f, 0.03990234f, 0.14559461f, 0.11969802f, 0.04787155f, -0.02051280f, -0.11009784f, 
    0.11640879f, 0.12266589f, -0.03595199f, -0.12480350f, -0.24896325f, -0.18696384f, 0.08140940f, -0.24920444f, 
    -0.11526478f, 0.28016615f, 0.35736930f, 0.09908665f, 0.09249469f, -0.08946377f, -0.19102302f, -0.16840386f, 
    0.04586219f, -0.27250350f, -0.17247498f, 0.14790133f, 0.05584542f, -0.10226169f, -0.03771078f, -0.11492346f, 
    -0.03524580f, 0.12196834f, 0.14446518f, 0.10736696f, 0.11351153f, 0.39125249f, 0.00798487f, 0.11087272f, 
    -0.01481231f, -0.21768759f, -0.09471332f, 0.19110560f, 0.18747826f, -0.11152238f, 0.17432714f, -0.23036210f, 
    0.15579891f, 0.04855055f, 0.14409880f, -0.00936117f, 0.17428370f, -0.39473534f, -0.31123820f, 0.28646019f, 
    -0.13897616f, 0.18210278f, 0.14714353f, -0.01930295f, -0.14149021f, 0.12107663f, -0.16521397f, 0.04302454f, 
    0.08651917f, 0.11384297f, 0.01089901f, 0.10305361f, 0.17368974f, 0.05479084f, 0.26190373f, -0.21281396f, 
    -0.11842602f, -0.20980544f, 0.06005560f, -0.04785332f, -0.02718136f, -0.01845219f, 0.09755245f, 0.01089739f, 
    -0.05845906f, -0.06935093f, 0.04244468f, -0.01080349f, -0.03325888f, 0.27878964f, -0.17997085f, -0.04184649f, 
    0.06175046f, -0.01325442f, 0.07414267f, 0.02877668f, 0.02242889f, -0.00686659f, -0.06194199f, -0.04072643f, 
    0.04667576f, 0.03017325f, 0.12328796f, 0.17267336f, 0.20510206f, -0.15190956f, -0.03499763f, -0.04888812f, 
    0.03407930f, -0.11973839f, 0.09768189f, 0.04834299f, 0.18836676f, 0.38613895f, 0.04493495f, 0.07143792f, 
    0.02564443f, -0.05990800f, -0.03706625f, 0.09258011f, -0.07991344f, 0.02017692f, 0.07981890f, 0.05826956f, 
    0.00740631f, -0.12112885f, 0.05545722f, 0.10708020f, -0.19571929f, -0.14705919f, -0.02696802f, 0.14160925f, 
    -0.03041347f, -0.03803855f, 0.02270500f, -0.01708943f, -0.13506915f, 0.23532335f, 0.36763775f, -0.17762671f, 
    -0.06203655f, -0.04671199f, -0.00630972f, -0.13462022f, 0.02548146f, 0.01114538f, -0.03068237f, -0.16362780f, 
    0.13593921f, -0.08265787f, -0.04757638f, -0.12388593f, -0.28979012f, -0.24444316f, -0.14352007f, -0.25189993f, 
    -0.06480820f, 0.01135310f, 0.01691630f, -0.20123850f, -0.01123474f, -0.24782160f, -0.06473904f, -0.01113793f, 
    -0.14915124f, -0.24114940f, -0.48534814f, 0.01211914f, 0.04991806f, 0.14225496f, 0.02773358f, -0.04187205f, 
    0.10967880f, -0.06512247f, 0.17306866f, 0.23795769f, 0.07198104f, -0.12998320f, 0.15115269f, -0.13586444f, 
    -0.07788979f, 0.14257737f, 0.00413114f, 0.15050232f, 0.11287580f, -0.16136308f, -0.02321517f, -0.17378537f, 
    -0.13486949f, 0.04558194f, 0.09414360f, -0.23722571f, 0.15774897f, 0.00977070f, 0.21923359f, 0.09108432f, 
    0.15502229f, -0.04160191f, -0.11901905f, 0.00665928f, 0.11398984f, -0.15743928f, -0.23791423f, 0.04828483f, 
    -0.16122922f, 0.06649150f, -0.18059763f, -0.19736561f, -0.17014979f, -0.03224639f, 0.42257538f, -0.01542957f, 
    -0.36918160f, -0.09635755f, 0.05991197f, -0.01864272f, 0.12992343f, -0.27629855f, 0.02831081f, 0.10040489f, 
    -0.08034300f, -0.09220459f, 0.19854261f, -0.02066060f, 0.15523784f, 0.10511554f, 0.03670931f, -0.09214189f, 
    0.25655058f, 0.05487588f, 0.34593517f, -0.02636851f, -0.10430843f, -0.02017240f, -0.06666227f, -0.07914951f, 
    -0.00787433f, -0.20679240f, -0.03370602f, 0.31338543f, -0.10835480f, 0.08229330f, 0.06973146f, -0.01156610f, 
    0.11381963f, 0.35326880f, 0.34952915f, 0.13069925f, 0.39413977f, 0.01286110f, -0.13753603f, 0.16409698f, 
    0.01029913f, -0.04886638f, -0.21498689f, 0.18646584f, -0.21149027f, 0.13556239f, 0.02647578f, -0.02036346f, 
    -0.25420061f, 0.00173809f, 0.05515741f, -0.21925837f, 0.11952366f, -0.04972183f, -0.11951717f, -0.20429802f, 
    0.14466640f, 0.05243698f, -0.02168756f, -0.10010711f, -0.12577623f, 0.29908153f, 0.14013676f, 0.43068987f, 
    0.09996708f, -0.07199648f, 0.04316179f, 0.17876007f, -0.02457094f, -0.05524681f, 0.41264394f, 0.10784625f, 
    0.04412104f, 0.07544189f, -0.10117390f, -0.06278395f, -0.10385735f, -0.03132847f, 0.06354329f, -0.07824574f, 
    0.12006470f, -0.00003759f, 0.13171944f, -0.14328946f, -0.16545370f, -0.16517182f, -0.18003185f, -0.15262766f, 
    0.00817332f, 0.00980444f, 0.01389852f, 0.00110851f, 0.00130176f, -0.03242082f, -0.05229951f, 0.03706006f, 
    -0.02251411f, 0.02346729f, 0.03796476f, -0.01085012f, 0.04027421f, -0.01924571f, -0.05220077f, 0.01647431f, 
    -0.04836093f, -0.05522358f, -0.01037848f, -0.01799002f, -0.04191143f, -0.04210238f, -0.00141450f, 0.02474313f, 
    0.03731634f, -0.02412672f, -0.01142081f, 0.02557563f, 0.02200997f, 0.04794402f, 0.00507498f, -0.01717902f, 
    -0.01267890f, -0.00915586f, 0.02051050f, -0.06228454f, -0.05082854f, -0.05948144f, -0.05776701f, -0.04672957f, 
    0.04621699f, -0.03604658f, -0.04965147f, -0.02182134f, 0.03284408f, 0.03467114f, 0.01704176f, 0.02125504f, 
    0.02603493f, -0.03333112f, -0.00786001f, 0.04503697f, 0.02757902f, -0.00033019f, 0.00843026f, -0.02542654f, 
    -0.00709618f, 0.03786977f, -0.03958322f, -0.01401689f, -0.00383959f, 0.05045295f, -0.03054976f, -0.04844384f, 
    -0.04797430f, -0.00718898f, 0.05103055f, 0.00432095f, 0.03087929f, -0.02572479f, -0.03445108f, -0.04066138f, 
    -0.05862883f, -0.06383335f, -0.00551766f, 0.00178773f, -0.05147843f, -0.02273238f, -0.03301874f, -0.01541781f, 
    0.03649355f, 0.01810777f, 0.03255934f, -0.04875682f, -0.05177752f, -0.00036077f, -0.05392065f, 0.03189318f, 
    -0.02404672f, 0.04450136f, -0.04544099f, 0.00016987f, -0.04316550f, -0.03597001f, -0.02376247f, -0.02272669f, 
    0.01074006f, -0.03106251f, 0.03308854f, 0.04321859f, 0.00850290f, 0.01545643f, -0.05633134f, 0.01342222f, 
    0.04751655f, 0.00076612f, 0.04578292f, -0.05270894f, -0.05930717f, -0.01162864f, -0.05867340f, -0.02727306f, 
    0.02007276f, -0.00375152f, 0.03506970f, -0.01972299f, -0.06006034f, -0.00442664f, -0.00129509f, -0.06063785f, 
    -0.04555688f, -0.01266181f, 0.04483461f, 0.04550064f, 0.03860120f, 0.04248762f, -0.05950965f, -0.03312957f, 
    0.04596567f, -0.04566327f, -0.00526111f, -0.03946980f, 0.01245786f, 0.03821229f, -0.02998001f, -0.04160397f, 
    0.02866044f, 0.02331309f, -0.00163519f, 0.04945130f, 0.02783691f, -0.03080116f, 0.03356797f, 0.02374424f, 
    0.02718200f, -0.04781399f, -0.04107326f, -0.03904903f, 0.01883163f, 0.01333664f, -0.03389991f, 0.03831568f, 
    -0.04719700f, -0.01096289f, 0.01569775f, 0.04496263f, -0.00826268f, -0.00633402f, -0.05084002f, 0.02227445f, 
    -0.02010699f, 0.01814980f, 0.02350501f, 0.01064910f, 0.00742390f, -0.01793036f, -0.01187494f, -0.06420427f, 
    -0.00350215f, -0.03622779f, 0.04527899f, -0.05963076f, 0.01796054f, -0.00195563f, -0.02917116f, 0.03969418f, 
    0.01608961f, 0.01720972f, 0.04267481f, 0.00322809f, -0.05377661f, 0.02852508f, 0.00992240f, -0.03743564f, 
    -0.05472537f, -0.01579547f, -0.02560282f, 0.01886539f, -0.04022972f, 0.00192897f, 0.03180058f, -0.03769723f, 
    -0.05920667f, -0.04498865f, 0.03723665f, 0.00755516f, -0.01163333f, -0.02191992f, 0.01273253f, -0.01007023f, 
    -0.01708964f, 0.02166178f, -0.05831523f, 0.02580516f, -0.02680957f, -0.02960243f, 0.03764896f, -0.06092578f, 
    0.03452188f, -0.06300495f, -0.05754019f, -0.00497466f, -0.03910029f, 0.03823727f, 0.00898162f, -0.01770496f, 
    -0.00627260f, -0.03459488f, -0.05643126f, 0.00784053f, -0.06510373f, -0.05894443f, 0.02814131f, -0.00098266f, 
    0.05034528f, -0.06503451f, -0.00256850f, -0.04808562f, -0.01768116f, 0.04905687f, -0.00211648f, -0.00878105f, 
    -0.01750227f, -0.05898654f, 0.03424892f, 0.02928058f, -0.05023120f, -0.02341679f, -0.06165629f, -0.03554294f, 
    0.04109568f, 0.02379904f, -0.04216592f, -0.02672021f, -0.05256012f, 0.03095548f, 0.02609001f, -0.05914433f, 
    -0.06028754f, -0.01888196f, 0.00560918f, -0.05628294f, 0.04828734f, 0.00889180f, -0.01817629f, 0.03093888f, 
    0.01638583f, -0.05663577f, -0.00051238f, -0.01381498f, -0.05771288f, -0.04684235f, -0.06137566f, -0.00002473f, 
    0.02969061f, -0.04407546f, -0.06270261f, -0.04470956f, 0.00217703f, 0.01995437f, -0.02006567f, -0.02660131f, 
    0.01810427f, -0.05304236f, 0.04240092f, 0.02255353f, 0.05006228f, 0.02792797f, -0.00024524f, -0.04089199f, 
    0.03788874f, -0.01905389f, -0.03237139f, -0.03684705f, 0.02915750f, 0.01735992f, -0.01228904f, -0.00569190f, 
    -0.05556048f, 0.00093699f, -0.03464358f, 0.05023194f, 0.05166773f, 0.00040614f, 0.00042298f, 0.01063589f, 
    0.01092276f, 0.01507140f, -0.03420972f, -0.00829847f, 0.02099119f, 0.01875225f, -0.03964514f, -0.03111751f, 
    -0.00668416f, -0.02874327f, 0.00331219f, 0.04079118f, -0.00645157f, 0.04294454f, 0.02009722f, 0.01711317f, 
    -0.02748467f, 0.00623616f, 0.04603409f, 0.01919361f, -0.02703344f, 0.00395159f, -0.01144570f, 0.00338950f, 
    -0.02148009f, -0.01072131f, 0.02899618f, 0.04170382f, 0.03054975f, 0.03078815f, 0.02223785f, 0.02663125f, 
    -0.05249409f, 0.01210606f, -0.00191307f, -0.02952490f, -0.01980599f, -0.01046005f, 0.04231062f, 0.04477565f, 
    -0.05291921f, 0.01859680f, 0.04616585f, -0.03154495f, -0.00457230f, 0.02740051f, 0.03954921f, 0.00652644f, 
    0.05363057f, 0.05154095f, -0.03025513f, -0.04449405f, -0.01006790f, 0.01555794f, -0.06466623f, -0.07114893f, 
    0.01084095f, 0.04666968f, -0.03881111f, 0.04258062f, 0.03597859f, 0.03128729f, 0.01892932f, 0.04713416f, 
    0.03851723f, 0.01489982f, -0.05289522f, 0.00766743f, -0.04749244f, -0.03494961f, 0.04101414f, 0.02298318f, 
    -0.02107603f, -0.00507471f, -0.04565933f, -0.01910096f, 0.00664214f, 0.02041272f, 0.02451338f, -0.03442272f, 
    -0.04113552f, 0.02317410f, -0.06404392f, -0.00777246f, -0.04196466f, 0.00781329f, -0.00199838f, -0.05386674f, 
    0.03874548f, 0.03954028f, -0.01248863f, -0.04986585f, -0.00200680f, -0.02727356f, 0.01976109f, -0.02653194f, 
    -0.00115530f, 0.00381181f, 0.02809355f, -0.03862666f, -0.04421875f, 0.02732394f, -0.01753199f, -0.04447724f, 
    -0.02454111f, -0.04169897f, -0.03475126f, -0.03437728f, -0.03547396f, -0.04578107f, 0.04370339f, 0.03799181f, 
    -0.01040862f, -0.06098517f, 0.04497995f, 0.05465497f, 0.03839196f, -0.00643872f, 0.03208540f, -0.03553859f, 
    0.03998994f, 0.03490544f, -0.04023598f, 0.05806710f, -0.05341199f, -0.05434537f, -0.03004471f, 0.02645050f, 
    -0.03603034f, 0.01570680f, -0.00989149f, 0.03212915f, -0.05587274f, 0.02573044f, 0.00717987f, -0.04575369f, 
    0.00137256f, 0.00980871f, -0.01080503f, -0.02838172f, 0.04474179f, -0.01513865f, 0.00440555f, -0.05912116f, 
    -0.00385065f, -0.04042263f, 0.02841620f, -0.02795185f, -0.00079308f, -0.00488859f, 0.04615377f, -0.04790343f, 
    -0.01202962f, -0.06139105f, 0.04856205f, -0.06501261f, 0.02949813f, -0.00180220f, -0.05940420f, 0.01721739f, 
    -0.00771728f, -0.05027315f, -0.00212344f, 0.02786167f, -0.03148538f, 0.01236573f, -0.06374460f, 0.00292420f, 
    0.01018175f, -0.00716407f, -0.01661907f, 0.00000309f, -0.06244571f, -0.01840119f, -0.01471456f, -0.01739989f, 
    0.04763616f, 0.01522554f, -0.01654187f, -0.00974572f, -0.03133053f, -0.02095211f, -0.05513385f, -0.05873799f, 
    0.03555587f, 0.04509475f, -0.02192155f, 0.01495605f, 0.04780942f, 0.01031295f, -0.01877787f, 0.00851298f, 
    0.00743748f, -0.01440322f, 0.00195532f, 0.01166719f, -0.01161555f, -0.00305489f, 0.03575680f, 0.02524724f, 
    -0.02951401f, -0.01440135f, -0.02539599f, -0.06444229f, -0.04124561f, -0.01209896f, 0.01630185f, -0.03307720f, 
    0.02893878f, 0.01583981f, -0.02201015f, -0.06240395f, -0.01921682f, 0.04835716f, 0.00435268f, 0.01143772f, 
    -0.04180711f, -0.01800445f, -0.03519113f, -0.04141837f, -0.05840560f, -0.04039330f, -0.04718321f, 0.03437895f, 
    -0.03822932f, 0.03282872f, 0.03938261f, 0.02584178f, 0.00400971f, -0.00058332f, 0.01464980f, -0.01432472f, 
    0.02467892f, 0.05066204f, -0.03368934f, -0.02915568f, 0.03463749f, -0.06647497f, -0.04576763f, 0.02273620f, 
    -0.02948974f, -0.01874188f, 0.00448303f, 0.00322770f, 0.00271855f, 0.01679651f, 0.00733392f, 0.05230029f, 
    -0.01966383f, 0.01881336f, 0.01021509f, -0.05579734f, 0.02164664f, 0.01676211f, 0.02347129f, -0.06377054f, 
    -0.02299342f, -0.05061289f, -0.00169759f, 0.02114256f, -0.03115627f, -0.01304497f, 0.04346887f, 0.00832497f, 
    -0.03450334f, -0.04312504f, -0.04955069f, -0.03498337f, 0.05697519f, -0.00239614f, 0.03886061f, -0.06396224f, 
    0.00622449f, -0.04054488f, -0.02792215f, 0.01778642f, -0.01717634f, -0.03346036f, -0.00897932f, 0.01075143f, 
    -0.00053368f, -0.13642782f, -0.07945625f, 0.02664894f, 0.15664341f, 0.13182101f, 0.07021306f, -0.02473260f, 
    -0.02968707f, 0.11404265f, 0.22740959f, -0.12526017f, -0.10998929f, 0.20802233f, 0.07514964f, -0.09321546f, 
    -0.03839098f, -0.01348932f, 0.13464956f, -0.05447930f, 0.04559965f, 0.01156432f, 0.04132334f, 0.13207112f, 
    0.04599708f, -0.00374382f, -0.07994697f, 0.06111604f, -0.09804705f, 0.03924645f, 0.21348310f, 0.05350330f, 
    -0.18058932f, 0.00461364f, 0.13968791f, 0.11755420f, 0.07678474f, 0.02553246f, -0.01898995f, -0.23380494f, 
    0.14879550f, -0.04017819f, -0.01932773f, 0.03535056f, 0.11283144f, 0.17463158f, 0.19049676f, 0.15007916f, 
    -0.17905898f, -0.01140225f, -0.06648008f, 0.04151350f, 0.07100635f, 0.20646657f, -0.20764637f, 0.19819330f, 
    0.00170391f, 0.03657075f, -0.08497142f, 0.17496088f, 0.11232311f, 0.24609269f, 0.24458411f, -0.07361352f, 
    -0.05695637f, -0.06466221f, 0.08706403f, 0.01290773f, 0.10652462f, 0.10533598f, 0.09297474f, 0.13761522f, 
    -0.00793490f, 0.06562212f, 0.19568199f, 0.14459895f, 0.12049986f, -0.04693594f, 0.00143822f, -0.01336451f, 
    0.09520734f, -0.31179422f, 0.10177926f, -0.02283913f, 0.06443428f, 0.01745967f, -0.03819313f, 0.08463757f, 
    0.05962265f, -0.01597395f, 0.01171394f, 0.24583311f, 0.08037483f, 0.16809757f, -0.07723504f, -0.02921249f, 
    0.05902282f, -0.16487551f, 0.01823362f, -0.09910814f, -0.10127071f, -0.01619054f, 0.08239041f, -0.15908217f, 
    -0.06901523f, 0.03312899f, -0.11498629f, -0.10445963f, 0.09606646f, -0.07538106f, -0.04198691f, 0.00927685f, 
    0.13817541f, 0.07592576f, 0.09919902f, 0.00997426f, -0.24451368f, -0.02498724f, -0.02638865f, -0.04038877f, 
    -0.02699006f, 0.26940253f, -0.12862816f, 0.01898987f, 0.12145963f, 0.07299845f, -0.38954350f, -0.06090270f, 
    -0.23820010f, 0.00868986f, 0.07286256f, -0.00894515f, -0.03970646f, 0.04194659f, -0.27048144f, -0.04377247f, 
    0.14582223f, 0.13948706f, 0.01598524f, -0.05300137f, -0.11170163f, -0.26307708f, -0.65777206f, -0.39334425f, 
    0.12781584f, -0.02535735f, 0.00894669f, 0.03811181f, 0.05068801f, 0.14467226f, -0.04246769f, -0.08522614f, 
    -0.30659646f, 0.23130040f, 0.03152774f, -0.23652944f, -0.02718407f, -0.09978209f, 0.03238333f, 0.17248400f, 
    0.22257893f, 0.03908830f, -0.11464967f, 0.09435717f, -0.04459569f, 0.02965968f, 0.05277191f, -0.06853726f, 
    0.03311430f, 0.20591350f, 0.01461603f, 0.02512492f, -0.01567593f, -0.06205911f, -0.05238785f, 0.16695644f, 
    0.09943889f, 0.03627278f, -0.06316717f, -0.19002889f, -0.07565424f, -0.21227522f, 0.14158322f, 0.01325249f, 
    0.15474883f, -0.13175549f, -0.06171742f, 0.12065746f, 0.17318057f, 0.04822284f, -0.01919897f, 0.16420434f, 
    0.01049678f, -0.12199987f, 0.02378780f, -0.06519467f, -0.09605899f, -0.19376384f, -0.20263542f, 0.42375264f, 
    -0.16783719f, -0.09546109f, 0.11538772f, 0.13124876f, 0.05228202f, 0.15385710f, 0.11962061f, -0.04318050f, 
    0.01647326f, 0.06969478f, 0.03996760f, 0.06067387f, 0.17414422f, -0.06091731f, 0.10768346f, -0.03705429f, 
    -0.03567581f, 0.11904445f, -0.11806678f, -0.22949779f, 0.11400381f, 0.03076555f, -0.00695886f, 0.07454667f, 
    0.03699789f, -0.00925699f, -0.09906574f, -0.02775250f, -0.01065370f, -0.15106235f, 0.04396054f, -0.04246159f, 
    0.09861601f, 0.25532708f, -0.05364921f, -0.00196046f, 0.23027605f, -0.02570818f, 0.30799970f, 0.01718939f, 
    0.06901605f, 0.14800598f, 0.06896528f, -0.18837872f, 0.14752184f, 0.12953824f, 0.11238760f, 0.01726145f, 
    -0.11717356f, -0.00593589f, -0.04969498f, -0.23729609f, -0.03525976f, 0.11879944f, -0.23984487f, 0.02916900f, 
    0.12968278f, 0.03233315f, 0.12471563f, 0.04809580f, 0.04280791f, -0.12757273f, 0.06043816f, -0.06953186f, 
    0.10684697f, 0.08283588f, -0.06378055f, 0.01812007f, 0.20058352f, 0.10729157f, -0.14110722f, -0.05199144f, 
    0.16378959f, -0.03957533f, 0.03944901f, 0.00088014f, 0.11409287f, 0.05475774f, -0.00147476f, 0.04332501f, 
    0.04406901f, 0.11554125f, 0.00348943f, -0.01143606f, 0.12728548f, -0.09785827f, -0.21761218f, -0.05878255f, 
    -0.12511557f, -0.02781417f, 0.05677610f, -0.03980361f, -0.00084873f, 0.12535451f, -0.27677783f, 0.11332837f, 
    -0.03871441f, -0.21824042f, -0.32615924f, -0.05137530f, 0.05590770f, 0.19952011f, 0.16240869f, 0.02844741f, 
    0.00530898f, 0.03954695f, -0.19248103f, -0.05834991f, -0.22640763f, 0.05547183f, -0.04662027f, 0.19172478f, 
    -0.31327051f, -0.18751529f, 0.10519014f, 0.04560418f, -0.16038147f, -0.23244160f, -0.04807824f, 0.01837325f, 
    -0.21561500f, -0.20850489f, 0.04916372f, -0.09560674f, 0.17303701f, 0.14965989f, 0.24864583f, 0.13430768f, 
    0.14266278f, 0.19006100f, 0.08888685f, -0.02787112f, 0.01187078f, -0.10654429f, 0.08855557f, 0.02685886f, 
    0.19851731f, -0.20006987f, 0.09693553f, -0.16464104f, -0.33225474f, -0.08816387f, 0.01943830f, 0.06133006f, 
    0.02939564f, 0.01335512f, 0.20534225f, 0.19833408f, -0.11817215f, 0.04710780f, 0.05065404f, -0.07536672f, 
    -0.02048882f, -0.02359045f, -0.27715236f, 0.07562584f, -0.06760264f, -0.16139862f, -0.36710420f, -0.23207782f, 
    0.11207813f, 0.15190385f, 0.03747390f, 0.34659430f, -0.01017052f, 0.03290086f, 0.26087934f, -0.01768721f, 
    0.27597165f, 0.15565771f, 0.24965015f, 0.24946898f, 0.05074348f, 0.24927899f, 0.05901453f, 0.17869353f, 
    0.04683424f, 0.21530521f, 0.06724857f, 0.10239926f, 0.56585079f, 0.23628296f, -0.26324832f, 0.13633676f, 
    0.29467398f, 0.09988096f, 0.09261730f, 0.18680416f, -0.13063464f, -0.15442619f, 0.06614253f, -0.04454025f, 
    0.12100958f, 0.18262264f, 0.16812316f, 0.07933865f, -0.06121717f, -0.13436598f, -0.07035655f, 0.13622636f, 
    0.06347699f, -0.00286307f, -0.07365452f, -0.04181062f, 0.07988209f, 0.14291282f, 0.19520856f, 0.18038386f, 
    -0.06721659f, -0.21464972f, -0.13448174f, -0.16250283f, -0.15669261f, -0.19599771f, 0.09511714f, 0.02920889f, 
    0.02326216f, 0.03679229f, -0.10663305f, 0.11042177f, -0.08227347f, 0.11749266f, 0.13049723f, -0.13793360f, 
    -0.01341905f, 0.18972057f, 0.04834479f, -0.04249496f, 0.15474136f, 0.23553005f, 0.29651636f, 0.24879034f, 
    -0.11708105f, -0.04828091f, 0.01228881f, 0.06162816f, 0.11776833f, -0.04008286f, -0.01949594f, 0.05589921f, 
    0.30673584f, 0.28461930f, 0.20217162f, 0.06282370f, 0.24324545f, -0.03070912f, 0.21161172f, -0.24191995f, 
    -0.09296584f, 0.17882438f, 0.29665640f, 0.33510011f, 0.26025155f, 0.15104240f, 0.20223077f, 0.15489097f, 
    0.17523772f, 0.03545902f, 0.38024506f, -0.08049083f, 0.07345139f, 0.06132204f, -0.06446006f, 0.20229289f, 
    0.08099114f, -0.10761931f, 0.17378385f, 0.02307769f, 0.06444518f, 0.06042928f, -0.08283198f, -0.02405406f, 
    0.02842356f, -0.02458427f, -0.15652652f, 0.02165719f, 0.02218844f, -0.17731352f, -0.11766403f, -0.05024316f, 
    0.07276361f, 0.00925086f, 0.03821490f, -0.15777287f, -0.07471974f, 0.05919684f, 0.22533494f, 0.16318871f, 
    0.23436095f, 0.30809736f, 0.21497072f, 0.12577705f, 0.13485223f, -0.01489101f, 0.16150668f, 0.13210535f, 
    0.27446142f, 0.10439592f, -0.01219103f, 0.29576632f, 0.24160071f, 0.08044319f, 0.30343270f, 0.22763021f, 
    0.28831363f, 0.01098734f, -0.30821854f, -0.00573863f, 0.08330281f, -0.20480298f, -0.06877331f, -0.08424973f, 
    -0.23096466f, 0.35701832f, 0.34386474f, 0.30203071f, -0.11626300f, 0.06886180f, 0.01817755f, -0.09689924f, 
    -0.25218645f, 0.11708034f, 0.15999678f, -0.22274287f, -0.05706216f, 0.07180630f, 0.02824453f, 0.06776168f, 
    0.15317649f, -0.15365940f, -0.03483158f, 0.13811205f, 0.11761828f, -0.10442166f, -0.08402225f, -0.08905217f, 
    -0.04150708f, 0.25376308f, 0.00386719f, -0.09996399f, -0.12455175f, -0.16241406f, -0.13127616f, 0.02519414f, 
    -0.01595539f, 0.08707226f, 0.10218497f, -0.21366462f, -0.29511249f, 0.21288346f, 0.15971404f, 0.00772696f, 
    0.02862086f, 0.05274234f, -0.02727970f, -0.11385468f, 0.13038963f, -0.26489273f, -0.16856124f, -0.10030709f, 
    -0.25928637f, -0.29369116f, -0.02263283f, 0.09948284f, -0.04504048f, -0.23213106f, -0.22265688f, 0.00444345f, 
    -0.25416198f, -0.15312846f, 0.02898567f, 0.10690328f, -0.05319400f, 0.14738402f, 0.14192006f, 0.29042101f, 
    0.00337646f, -0.16027954f, -0.00393869f, 0.01931743f, 0.02971669f, 0.04314066f, -0.11564431f, 0.03194164f, 
    0.08295645f, -0.20236447f, -0.10586495f, 0.08183936f, -0.17043084f, -0.46875730f, -0.26157877f, 0.04322160f, 
    0.06908257f, 0.07019120f, 0.12549682f, -0.09839675f, 0.02873874f, -0.01826099f, -0.00455374f, 0.08602076f, 
    0.04163625f, 0.19337520f, 0.10868224f, 0.18900050f, 0.11476551f, -0.03663675f, 0.19822393f, -0.01299677f, 
    0.00067831f, 0.03642188f, 0.03233110f, 0.22127540f, -0.13564502f, 0.16523847f, -0.03058570f, 0.01139864f, 
    -0.11528213f, 0.11965057f, 0.02974804f, 0.05476477f, 0.24527998f, -0.01957562f, -0.32661217f, -0.33881247f, 
    0.03985747f, 0.17910860f, 0.08289891f, 0.18119329f, -0.06107300f, -0.06700564f, 0.65937561f, -0.11614255f, 
    -0.16864792f, -0.15786546f, -0.03689863f, -0.10581077f, -0.02015139f, 0.05276350f, -0.06431644f, 1.05599511f, 
    0.00282013f, 0.03391318f, 0.04679288f, -0.06979339f, 0.01658039f, 0.04972704f, 0.00783572f, 0.02245249f, 
    -0.19706726f, -0.79380447f, -0.17128207f, -0.14134851f, -0.03184766f, -0.20234878f, -0.07520092f, 0.21014597f, 
    0.07732156f, 0.11942384f, -0.22972310f, -0.09443069f, 0.02843234f, -0.07747196f, -0.02190852f, 0.16403709f, 
    -0.00336200f, 0.07575586f, -0.40735167f, -0.33064252f, -0.54897296f, 0.08483264f, -0.21232435f, -0.06114656f, 
    -0.15457042f, -0.05420397f, -0.14993040f, 0.05800496f, -0.00070509f, -0.09403399f, -0.21938318f, -0.18992822f, 
    -0.43634102f, -0.00533663f, 0.02057418f, 0.07790783f, -0.02137575f, -0.20098747f, -0.00300434f, -0.06555122f, 
    -0.04274797f, -0.12276130f, -0.04128305f, 0.09751285f, 0.02570522f, 0.32721913f, 0.21803939f, 0.10622305f, 
    0.13133535f, 0.14399524f, 0.20834966f, 0.22868131f, -0.01795881f, -0.09015536f, -0.13835657f, 0.18180631f, 
    0.28532404f, -0.13089681f, -0.05363027f, -0.04890566f, 0.05002395f, 0.15607487f, -0.12243070f, 0.07498771f, 
    -0.08048665f, -0.10227148f, 0.12691022f, -0.07205682f, 0.06257027f, -0.21848866f, -0.00778585f, -0.02961906f, 
    0.05387909f, -0.01366394f, -0.07570581f, -0.06329164f, 0.05504363f, 0.03250926f, 0.09372624f, 0.05483735f, 
    0.06472895f, 0.09648921f, 0.13552529f, 0.09805647f, 0.08280197f, -0.16961019f, 0.11384912f, 0.17924514f, 
    0.05151937f, -0.08501677f, 0.15831684f, -0.35575190f, -0.07535570f, 0.01227721f, -0.00045366f, 0.08368634f, 
    0.06970412f, -0.03922217f, -0.00261276f, 0.03608146f, -0.10064188f, -0.08037226f, -0.03406985f, 0.02120163f, 
    -0.08456054f, 0.04855403f, 0.01047402f, -0.05062107f, 0.10136397f, 0.26129937f, 0.10944617f, 0.19751953f, 
    0.07382532f, 0.31988382f, 0.09038124f, -0.01081048f, 0.18667269f, -0.10611126f, -0.24444096f, -0.17344154f, 
    -0.01913236f, 0.02982824f, -0.07188757f, -0.05007792f, 0.24401872f, 0.10319369f, -1.81356657f, -0.11737392f, 
    0.26195195f, -0.17889982f, -0.13638370f, 0.00545060f, -0.11012211f, 0.07065007f, 0.10765448f, 0.08316170f, 
    -0.02367876f, -0.08693513f, -0.18580945f, 0.06561759f, 0.01128640f, -0.03640743f, -0.02207443f, 0.05319643f, 
    0.01518636f, 0.16464186f, 0.05531827f, 0.00748775f, -0.00867887f, -0.00176349f, 0.07340913f, 0.05046243f, 
    0.18086252f, 0.03467138f, 0.04970411f, -0.30716988f, 0.06904129f, 0.09435371f, 0.21081743f, 0.12854016f, 
    -0.00534837f, -0.02788374f, -0.34862763f, 0.23766504f, -0.44340649f, -0.04576455f, -0.21731126f, -0.02239532f, 
    0.03659413f, 0.11711745f, 0.07021282f, 0.01965459f, 0.05304307f, 0.04464851f, -0.06881045f, -0.00840929f, 
    -0.05488181f, -0.01922604f, -0.03845958f, 0.05133409f, 0.01096347f, -0.13319984f, -0.06086852f, 0.03940576f, 
    -0.08779351f, -0.11158131f, 0.11989431f, 0.14119194f, 0.07016257f, -0.05954104f, 0.05723685f, -0.47253281f, 
    0.10559106f, -0.02204952f, 0.17358527f, 0.02839395f, 0.03122710f, 0.02348551f, -0.15728797f, 0.02699288f, 
    0.01626185f, 0.04340876f, -0.17326519f, -0.11437220f, 0.05780455f, 0.09629985f, 0.05544863f, 0.13276166f, 
    0.04666492f, -0.06203917f, -0.10682917f, -0.14052102f, -0.11167046f, -0.01600691f, 0.04703890f, -0.00222654f, 
    -0.10813785f, 0.08155978f, 0.11540642f, 0.03598001f, 0.11519773f, -0.08950624f, 0.19004864f, -0.06987413f, 
    0.04412039f, -0.29029164f, 0.32156169f, -0.04194714f, -0.09884012f, 0.06379676f, 0.17420903f, 0.09819812f, 
    -0.01314482f, 0.04603995f, 0.02751918f, -0.00332497f, 0.11724275f, -0.00153139f, -0.08380985f, -0.07129225f, 
    0.26222545f, 0.12972651f, -0.01945668f, 0.20718729f, -0.00725256f, -0.17085774f, 0.08689206f, 0.05589689f, 
    0.06301428f, 0.00115870f, -0.08890539f, -0.18276681f, 0.31220749f, -0.00329697f, -0.10738920f, -0.03940193f, 
    0.10000729f, -0.09767362f, 0.17574720f, -0.10819377f, -0.15199488f, 0.49047041f, -0.02281251f, 0.18615380f, 
    0.10823907f, 0.02506714f, -0.22740215f, 0.01373706f, 0.01161299f, 0.02676342f, -0.33645862f, -0.03246427f, 
    0.06410191f, -0.16131729f, 0.20433190f, -0.23228532f, 0.09205079f, -0.00439725f, -0.00187708f, -0.13172986f, 
    -0.08982550f, 0.01919171f, -0.04016443f, -0.12431585f, -0.03934545f, -0.04702861f, -0.16646889f, -0.09104964f, 
    -0.25359130f, 0.16076708f, -0.13462013f, -0.58696759f, -0.33210075f, -0.29507419f, 0.10530762f, 0.06439503f, 
    -0.21411687f, -0.02493038f, 0.01632378f, -0.13510159f, -0.05874864f, 0.08261806f, -0.01604572f, -0.06340264f, 
    -0.00724861f, 0.16592443f, -0.07623798f, 0.14512722f, -0.26547515f, -0.16591406f, 0.28420705f, -0.17698549f, 
    0.06555512f, -0.11891117f, 0.03269746f, 0.29766506f, 0.17415707f, 0.09722977f, -0.13609548f, 0.10137986f, 
    0.00459555f, 0.00143789f, -0.15487537f, 0.00150509f, -0.01669712f, -0.08164971f, 0.07936171f, -0.00901248f, 
    -0.18462905f, -0.27878770f, 0.13620023f, 0.00327337f, 0.07449326f, 0.31156540f, -0.22778808f, -0.30799446f, 
    0.11151727f, 0.11017846f, -0.05804897f, 0.13612513f, 0.01217009f, 0.08542260f, 0.63115525f, 0.38843888f, 
    -0.35015604f, -0.04429245f, -0.05149566f, 0.01119446f, 0.08757443f, 0.06852736f, 0.07291067f, 0.02144287f, 
    0.03080170f, 0.05760253f, -0.17494680f, -0.04282170f, 0.06279393f, 0.04095152f, -0.00804985f, 0.01039247f, 
    -0.19155984f, 0.02929565f, 0.00933704f, 0.08878423f, -0.01992435f, 0.00581863f, 0.10479815f, 0.06326366f, 
    -0.01492215f, 0.17132191f, 0.05147837f, -0.01647007f, 0.00741503f, -0.24737488f, 0.03803799f, -0.12704675f, 
    -0.16630270f, -0.08979166f, -0.27991542f, -0.04099756f, -0.09354100f, -0.00077593f, -0.07468154f, -0.02280487f, 
    -0.05165833f, 0.10463063f, -0.06258778f, -0.26649815f, -0.01916650f, 0.12902257f, 0.12386070f, -0.03108290f, 
    0.00046882f, 0.08002723f, -0.15476581f, 0.10698498f, 0.08528329f, -0.03561405f, 0.09692737f, -0.03196951f, 
    -0.02739292f, 0.17462572f, -0.08524440f, 0.19065769f, -0.19608231f, 0.21778917f, 0.16395363f, 0.19981599f, 
    -0.08692719f, -0.30575281f, -0.21702567f, -0.01635368f, 0.06010456f, 0.01076580f, 1.00153053f, 0.25203127f, 
    -0.17278509f, -0.12278782f, 0.21945110f, -0.20412351f, -0.10971750f, -0.05877483f, -0.12579386f, -0.41215670f, 
    -0.06946357f, -0.02755087f, -0.02983205f, -0.00209872f, -0.00388841f, 0.01111121f, -0.03028526f, 0.03772769f, 
    0.45209730f, 0.27090815f, -0.28834513f, 0.10542384f, -0.00090319f, -0.03566132f, -0.07401545f, -0.04545778f, 
    0.04417276f, -0.06616181f, -0.32005817f, -0.07298889f, 0.01176347f, -0.01420344f, -0.06459865f, 0.01088065f, 
    -0.00270227f, -0.04138764f, -0.20265076f, 0.09506882f, -0.29872566f, -0.11385148f, 0.02291331f, -0.03315623f, 
    0.00674100f, 0.13807072f, 0.03709628f, 0.52311605f, 0.00125774f, 0.03842551f, 0.08607679f, 0.06043736f, 
    -0.09622303f, -0.00180273f, 0.00482711f, 0.22643600f, -0.03200849f, 0.00109496f, -0.02766906f, -0.06614891f, 
    -0.04416873f, 0.13250962f, -0.13582250f, -0.01283431f, -0.20233686f, 0.11940986f, 0.08366221f, -0.27507964f, 
    0.09369776f, 0.04577159f, 0.00611318f, 0.00841312f, -0.02794498f, -0.17151362f, -0.12943284f, 0.06545891f, 
    0.18254085f, -0.08669458f, 0.05829851f, 0.14055549f, 0.02838718f, -0.05812455f, 0.08941671f, -0.26346928f, 
    0.06025913f, 0.08944167f, -0.03187791f, 0.22148637f, 0.07560274f, 0.12002542f, 0.15859999f, 0.10428731f, 
    -0.06147257f, -0.05673019f, -0.02671732f, 0.00113368f, -0.02424754f, 0.03315964f, -0.04019989f, -0.01540841f, 
    0.03344385f, -0.01131438f, -0.00897275f, -0.00461756f, -0.03190461f, 0.03943199f, -0.00703769f, -0.05758836f, 
    -0.04921689f, 0.04628400f, 0.03627745f, -0.01081045f, -0.02644935f, 0.00908946f, -0.02133820f, 0.02126690f, 
    0.02590674f, -0.02101161f, -0.03507940f, 0.05622982f, 0.00352481f, 0.00814802f, -0.00895985f, -0.05963479f, 
    0.00122889f, 0.02733968f, -0.01254754f, -0.02859602f, 0.03542257f, -0.01128901f, 0.00913098f, -0.02940768f, 
    -0.02078099f, -0.03142462f, -0.00805884f, -0.04073461f, 0.03363161f, 0.03521954f, -0.03831679f, 0.03451336f, 
    -0.04375625f, 0.03536844f, -0.05394851f, -0.01003524f, 0.04633377f, -0.04838295f, -0.05137078f, 0.04036045f, 
    -0.02736864f, -0.02958933f, -0.00098296f, 0.02834023f, -0.03599775f, -0.06919277f, 0.03925618f, 0.01434743f, 
    -0.06747039f, -0.00889947f, 0.01020068f, -0.04711985f, -0.01205660f, -0.04877141f, -0.00937017f, -0.00961845f, 
    -0.01564083f, -0.00680359f, -0.02198007f, 0.03259717f, -0.00125372f, -0.02123667f, -0.00122974f, 0.01701796f, 
    0.02755298f, 0.01552182f, -0.03204263f, 0.04267915f, -0.00635091f, -0.01505194f, -0.01594787f, -0.03937681f, 
    -0.05353278f, -0.01536957f, -0.06186919f, -0.05700700f, -0.03364594f, 0.04187538f, 0.01994214f, 0.01612306f, 
    -0.06856759f, 0.01926904f, -0.02856067f, -0.05941741f, -0.03285640f, 0.03595289f, -0.05974455f, -0.00699009f, 
    -0.03862011f, -0.01083733f, -0.01692702f, 0.03758786f, -0.02715749f, 0.03430488f, 0.04126431f, 0.02218416f, 
    -0.02735369f, 0.00644175f, -0.05980115f, -0.01290524f, -0.04280500f, -0.05260433f, -0.02524319f, 0.01657374f, 
    0.02570813f, -0.03771843f, 0.02196915f, 0.01220305f, -0.00814332f, -0.05635846f, -0.05306318f, 0.04609238f, 
    0.00212762f, 0.02839702f, -0.03357231f, 0.00741413f, -0.01425279f, 0.03578804f, -0.06107954f, -0.05504611f, 
    -0.01404292f, 0.00751869f, 0.03632621f, -0.03791534f, -0.04315512f, -0.01996366f, -0.01339569f, 0.02272558f, 
    0.00217260f, 0.02250279f, 0.00854289f, 0.04551689f, -0.03977890f, -0.06528663f, -0.06802219f, 0.01260387f, 
    0.02233825f, 0.05230374f, -0.01467357f, -0.00965833f, -0.00548028f, -0.00889269f, -0.01711480f, -0.00218369f, 
    -0.05174948f, 0.03055464f, -0.04028951f, -0.00339887f, 0.01894175f, -0.04230678f, -0.04044658f, -0.06017537f, 
    -0.02241142f, -0.03316599f, -0.00652845f, -0.00159890f, -0.01161590f, 0.03917071f, -0.04483213f, -0.00971430f, 
    -0.05970224f, -0.04820476f, 0.03976755f, 0.01668031f, -0.01807167f, 0.01582500f, -0.06126964f, 0.00679765f, 
    0.02443050f, 0.03509004f, -0.05892188f, -0.00143677f, 0.04035165f, 0.01211763f, 0.01661165f, 0.00037740f, 
    0.01165090f, 0.00785340f, -0.00761831f, -0.05445950f, -0.03667981f, 0.02950594f, -0.06830285f, -0.02728752f, 
    0.00835836f, -0.05758960f, -0.03323190f, -0.03263216f, -0.00905259f, -0.03540522f, 0.04135819f, -0.05799783f, 
    -0.06739940f, 0.01838747f, 0.01971852f, -0.06054709f, -0.01442656f, -0.04171632f, -0.05634006f, -0.05797146f, 
    0.02911285f, -0.05946196f, -0.03742677f, 0.01126560f, 0.00762894f, -0.05960681f, -0.05427779f, 0.02110616f, 
    -0.02504640f, -0.03116564f, 0.00483523f, 0.03534468f, 0.03343680f, 0.03851610f, -0.01472404f, 0.00976150f, 
    -0.06613488f, 0.00026145f, -0.01978709f, -0.00182688f, -0.00806029f, -0.02010300f, -0.00230082f, -0.03880953f, 
    -0.01260563f, -0.00179734f, 0.04362883f, 0.03005838f, -0.02013042f, 0.01939687f, -0.04251647f, 0.01438136f, 
    -0.03302711f, -0.02928768f, -0.00487131f, -0.00215597f, 0.04649334f, 0.03310421f, -0.05200067f, -0.04709680f, 
    -0.00783716f, -0.03227483f, -0.02035136f, -0.01292184f, 0.04666221f, 0.00827337f, -0.05924814f, 0.01830335f, 
    0.04473317f, -0.01931950f, 0.04238005f, 0.00488133f, 0.03700040f, -0.05320095f, -0.02145264f, 0.03605558f, 
    0.03385771f, -0.02897582f, -0.03695454f, 0.01811905f, -0.04252438f, -0.01240200f, 0.03506962f, -0.04846102f, 
    -0.00225225f, -0.05670707f, -0.04937711f, -0.05742833f, 0.01949215f, 0.04386453f, -0.00850671f, -0.03392140f, 
    -0.05928044f, 0.38011903f, 0.05970420f, 0.07511712f, 0.13361341f, -0.10846271f, 0.06355539f, -0.20530117f, 
    -0.18146098f, -0.02415699f, 0.40806702f, 0.09490724f, -0.07023287f, -0.03063898f, -0.07316354f, 0.04912644f, 
    0.01406763f, 0.12842631f, 0.03504273f, -0.07558032f, -0.07893357f, 0.05264971f, 0.12993303f, 0.09851388f, 
    0.15412137f, 0.02822892f, -0.38795933f, 0.01988950f, -0.30799890f, 0.00283460f, 0.00816975f, 0.08053344f, 
    0.19184142f, -0.08138547f, -0.21362633f, 0.16174468f, -0.26219451f, 0.18008934f, -0.25399587f, 0.10419193f, 
    0.11159438f, 0.04874985f, 0.17680964f, 0.05391124f, -0.04302483f, 0.34175566f, -0.45843002f, -0.41358593f, 
    -0.08171845f, -0.31907755f, 0.08367956f, -0.07789770f, -0.00617096f, -0.00067882f, 0.00155266f, 0.13459335f, 
    0.14623745f, 0.02584593f, 0.16218333f, -0.08202341f, 0.06022760f, -0.09489653f, 0.03852735f, 0.07213858f, 
    -0.14507627f, 0.22857681f, -0.10699374f, 0.05607351f, -0.01172787f, 0.15900092f, -0.06870017f, -0.13623445f, 
    0.17128421f, 0.16251615f, -0.01282277f, 0.01407848f, -0.11272861f, 0.05763089f, -0.00346717f, 0.16694683f, 
    -0.16859813f, 0.18649755f, 0.01183323f, 0.15408438f, -0.06405411f, 0.15606351f, -0.01614973f, -0.10185976f, 
    0.07069584f, -0.06607406f, -0.03165938f, 0.66699958f, 0.22666414f, 0.03441778f, 0.26561069f, 0.10081529f, 
    0.00331933f, 0.30022755f, -0.20933689f, -0.14977419f, 0.02839677f, 0.11066111f, 0.05830301f, 0.09581841f, 
    -0.03185359f, -0.10732019f, 0.02440237f, 0.16400449f, 0.06637602f, -0.06068754f, 0.09220460f, 0.01672184f, 
    -0.10173459f, 0.06387956f, -0.07741157f, -0.10567384f, -0.03711638f, 0.00696634f, -0.18722177f, -0.45287672f, 
    0.11471089f, -0.08245803f, -0.00094784f, 0.04786666f, -0.07963797f, 0.02103674f, -0.27926773f, 0.20527582f, 
    0.07424426f, 0.10765708f, 0.17597307f, 0.09651905f, 0.02796675f, -0.06022664f, -0.06106953f, 0.01839715f, 
    0.18440081f, 0.04656311f, 0.08302265f, 0.13441586f, 0.07155142f, -0.02675084f, 0.13022938f, -0.02181963f, 
    0.13207912f, 0.08482891f, 0.05587803f, -0.11402038f, 0.06672583f, -0.06690238f, 0.09270047f, -0.08437110f, 
    -0.00260025f, 0.23525536f, -0.50116032f, -0.19007307f, -0.20273532f, -0.00861564f, 0.10297343f, -0.21422943f, 
    -0.10289363f, 0.03785863f, 0.12549850f, 0.12353302f, 0.14375138f, 0.03680547f, 0.22059400f, -0.07407366f, 
    -0.01901618f, 0.05741065f, -0.14468160f, 0.02171054f, 0.31504637f, 0.17470481f, -0.08114791f, -0.07245239f, 
    -0.15378571f, -0.02175961f, -0.02356265f, -0.04806889f, 0.06932712f, -0.14951448f, 0.05454474f, -0.01931933f, 
    0.05433432f, 0.05374446f, -0.02772451f, 0.02169481f, -0.09242579f, -0.01810823f, -0.06933694f, -0.09315210f, 
    -0.14543195f, -0.10200266f, -0.12834182f, -0.02467362f, -0.03739341f, 0.04253990f, -0.16151589f, 0.38492963f, 
    -0.12212437f, 0.02926613f, 0.16109419f, -0.00200225f, -0.01414257f, 0.00604389f, -0.06468052f, 0.01342601f, 
    0.28325707f, 0.14123102f, 0.24642189f, -0.04755637f, 0.09308562f, 0.07388427f, -0.18201859f, 0.08557262f, 
    0.12467108f, 0.14063932f, 0.03579539f, 0.08496142f, 0.03003726f, 0.04246159f, -0.06134007f, -0.00523788f, 
    0.07379406f, -0.10630657f, 0.01085804f, -0.15155123f, -0.10699068f, 0.04789614f, 0.14898837f, -0.07822473f, 
    0.02140014f, -0.04745271f, -0.06733695f, 0.36866027f, -0.02069856f, 0.11468814f, -0.12042883f, -0.16462651f, 
    -0.05418994f, -0.03595701f, 0.21016018f, 0.15361157f, -0.22455764f, -0.20822819f, -0.06229561f, -0.06987920f, 
    -0.16602354f, 0.04245966f, -0.24292763f, 0.02243355f, -0.03265377f, 0.23657271f, 0.14797112f, -0.05035510f, 
    -0.13529889f, -0.03360159f, -0.02263816f, -0.00593483f, 0.12908316f, -0.16951802f, 0.38636047f, 0.02524755f, 
    -0.04923153f, 0.03053797f, -0.00389567f, 0.03931543f, -0.10432909f, 0.08929147f, 0.13423994f, -0.00915588f, 
    0.03095721f, 0.00580742f, 0.04739849f, -0.10046963f, 0.13518634f, 0.15821105f, -0.06911551f, 0.28509018f, 
    0.21041597f, 0.05144760f, -0.08490925f, -0.08921349f, -0.09414233f, -0.18240482f, 0.17186360f, -0.01665394f, 
    -0.06073156f, -0.05834129f, 0.06567621f, 0.07197137f, 0.08859473f, -0.15110038f, 0.16086709f, 0.05229526f, 
    -0.22325368f, -0.23308583f, -0.39321950f, -0.23003151f, 0.14656352f, -0.08258399f, 0.06295305f, -0.00071762f, 
    0.11482295f, -0.04938996f, -0.04772039f, -0.10934445f, 0.03822948f, 0.06042808f, -0.04440842f, 0.08523878f, 
    -0.11300708f, -0.15254526f, -0.00275782f, 0.05279026f, 0.23102699f, 0.14344808f, -0.05643580f, -0.16187136f, 
    0.02955960f, 0.12908329f, -0.05844733f, -0.18343513f, -0.37318885f, 0.01842606f, 0.26054251f, -0.02208662f, 
    -0.22688453f, -0.15884565f, 0.07141523f, 0.06597552f, -0.00939002f, -0.14823569f, 0.13543835f, 0.01254271f, 
    -0.11102132f, -0.35470840f, -0.11100625f, 0.02794892f, -0.01684398f, 0.00991707f, -0.01525757f, 0.03598696f, 
    -0.08239201f, 0.11691535f, 0.15677084f, -0.00322777f, 0.03375712f, -0.24547146f, -0.36279273f, 0.09853829f, 
    -0.20114423f, -0.18334559f, -0.01360177f, 0.13230985f, 0.07055039f, -0.12557822f, -0.26091149f, -0.26677838f, 
    -0.16513792f, -0.01019399f, 0.10088859f, 0.11539485f, 0.00692872f, -0.06703492f, 0.01507228f, 0.03959205f, 
    0.20947216f, 0.15168700f, -0.16536273f, -0.07068297f, -0.01195600f, 0.11040872f, -0.02469519f, -0.18262003f, 
    -0.09052055f, 0.08348311f, 0.22034432f, 0.10972374f, -0.12181871f, -0.02914480f, 0.22061737f, 0.05586899f, 
    0.03982548f, 0.18011737f, 0.15098342f, 0.18274942f, 0.24725462f, 0.23939453f, 0.05064344f, 0.21244615f, 
    -0.04758582f, 0.06261062f, 0.08157882f, -0.12649436f, 0.00095946f, -0.02116970f, 0.03632610f, -0.03271521f, 
    -0.05342862f, -0.02668163f, -0.07023662f, -0.05936190f, 0.10857465f, -0.15075536f, 0.05164971f, 0.13915144f, 
    0.00464550f, -0.23277697f, 0.05318078f, -0.03061099f, -0.08354836f, -0.03497695f, -0.23614982f, -0.15019834f, 
    0.65863729f, 0.10024811f, 0.08894892f, 0.12462742f, -0.05358768f, 0.16213022f, 0.00222330f, 0.08132202f, 
    0.01694258f, 0.01668497f, 0.07001954f, 0.00673429f, 0.02644214f, 0.09891417f, 0.08568802f, 0.13792071f, 
    -0.00828128f, -0.19303639f, 0.00914444f, 0.05296494f, -0.09947372f, 0.03626352f, -0.03998549f, -0.12387179f, 
    0.09112497f, -0.33255607f, 0.08466237f, -0.03863767f, -0.11643873f, -0.16299453f, -0.05299910f, -0.10356674f, 
    -0.05555629f, -0.01264887f, 0.11013748f, -0.24043626f, -0.20575371f, 0.08548974f, 0.19837752f, 0.11558047f, 
    -0.16539031f, -0.00239959f, -0.00761044f, -0.08293737f, -0.22320662f, 0.03256612f, 0.10909961f, -0.00635510f, 
    0.08174648f, -0.13666873f, -0.15267323f, 0.12567419f, 0.19319282f, 0.11706094f, -0.04980095f, 0.07031990f, 
    0.06317569f, 0.04430208f, 0.16271737f, -0.04383431f, -0.29701647f, 0.09620215f, 0.04028789f, -0.00020707f, 
    -0.08359528f, 0.02859772f, -0.02262572f, 0.10260496f, 0.03105085f, 0.10636719f, -0.58675289f, -0.14066364f, 
    0.08152068f, 0.15674904f, -0.19848016f, -0.09884263f, -0.37678093f, -0.05744258f, -0.18121360f, -0.08543619f, 
    0.10641962f, 0.07922049f, -0.19448461f, 0.14698967f, 0.06507309f, 0.06996023f, -0.04309801f, -0.01151918f, 
    -0.06474859f, 0.03155790f, 0.20990090f, 0.05245853f, 0.02953357f, 0.07197387f, 0.19399500f, 0.05593252f, 
    -0.25865251f, 0.06575239f, 0.22008534f, 0.14638668f, -0.05926923f, -0.09583276f, 0.02174709f, 0.01003373f, 
    -0.06581095f, 0.12497637f, -0.04604579f, -0.08064566f, 0.01128970f, -0.12159263f, 0.06942161f, 0.05146211f, 
    0.06146891f, -0.11389600f, -0.22905734f, -0.04468961f, 0.17389162f, 0.30443504f, -0.02108801f, -0.03775136f, 
    0.01661476f, 0.00341435f, 0.02540231f, 0.23192675f, -0.08591133f, -0.15566967f, 0.02392786f, -0.04218760f, 
    -0.07514701f, 0.18829109f, 0.11639384f, -0.16258353f, -0.21899721f, -0.25180438f, -0.14988896f, 0.10006635f, 
    0.07466082f, 0.03070070f, 0.15251736f, -0.05929554f, 0.01420498f, -0.20021178f, 0.44342169f, -0.48808646f, 
    -0.27318653f, 0.09766853f, 0.02846591f, 0.12794034f, 0.02029168f, 0.20797624f, -0.00635265f, 0.01442011f, 
    -0.14868531f, -0.01392160f, 0.07229957f, -0.01833261f, -0.11300069f, 0.06082550f, -0.03537573f, 0.18500069f, 
    0.06271379f, -0.12867936f, -0.33543396f, -0.10241424f, -0.31138957f, -0.03574966f, -0.12108878f, -0.07812443f, 
    -0.12091298f, 0.13446711f, -0.31782952f, 0.18510666f, -0.05589433f, -0.12118702f, 0.02805445f, 0.12964752f, 
    0.06676465f, -0.29639727f, -0.14331907f, 0.14373392f, -0.22891794f, -0.16735479f, -0.14220795f, -0.12993932f, 
    0.11801282f, -0.19996947f, -0.01717029f, 0.12410264f, 0.08648514f, 0.06242453f, -0.01207355f, -0.06888526f, 
    0.01776359f, 0.07900625f, 0.19015867f, -0.16804348f, 0.09199261f, 0.21872480f, 0.12340403f, 0.11377665f, 
    0.00450551f, 0.12996377f, 0.22045788f, 0.15271640f, -0.05645687f, -0.47854334f, -0.09680425f, 0.17410675f, 
    0.21132268f, 0.03430607f, 0.24501866f, -0.19430341f, -0.09430370f, -0.10476603f, -0.14197916f, 0.11394101f, 
    -0.09679288f, 0.18844609f, 0.01707615f, 0.17919752f, 0.17477247f, 0.18885191f, 0.20290048f, 0.22635666f, 
    0.01908926f, 0.10278424f, -0.05997465f, 0.00237081f, -0.12815857f, 0.11817206f, 0.01780609f, 0.04883424f, 
    -0.10538270f, 0.33393127f, 0.06387619f, -0.17784876f, 0.27263516f, 0.04266462f, 0.13628964f, -0.00290560f, 
    0.32317686f, 0.09689508f, 0.11122061f, 0.07892320f, 0.04823990f, 0.11722900f, -0.19382893f, 0.23745371f, 
    -0.10211826f, 0.11835218f, -0.39132556f, -0.06371677f, -0.10997006f, -0.33497381f, 0.08432744f, -0.01858135f, 
    0.00876403f, -0.21843348f, -0.05607470f, 0.27902693f, 0.12548423f, 0.24299240f, -0.12801135f, -0.06218475f, 
    0.12973234f, 0.11500722f, 0.11970925f, 0.04756630f, 0.04599136f, 0.02911931f, -0.09703249f, -0.00709563f, 
    0.05091181f, -0.19165248f, 0.15498061f, 0.04116716f, 0.18685830f, 0.00290560f, 0.08425824f, -0.01264568f, 
    0.20414200f, 0.02636346f, 0.12379470f, -0.12541372f, -0.03328732f, -0.05695836f, 0.48059684f, -0.14030923f, 
    -0.21405670f, 0.03405512f, 0.04084915f, 0.16682594f, -0.09209943f, 0.16715196f, -0.46592754f, 0.05172582f, 
    -0.14066291f, -0.01957955f, -0.12262014f, 0.04753062f, -0.04434979f, 0.05016262f, -0.21825956f, -0.20201363f, 
    -0.09692623f, -0.07566384f, -0.09365471f, -0.06173749f, -0.05760157f, -0.09262698f, 0.14841717f, -0.04704546f, 
    -0.04802198f, 0.15597270f, -0.26313564f, 0.08955139f, -0.01648830f, 0.15186866f, -0.01999929f, 0.00834470f, 
    -0.07540626f, 0.01675831f, 0.19930322f, 0.06966442f, 0.09019084f, -0.05612575f, 0.11537107f, 0.04263382f, 
    0.17668739f, -0.18375009f, 0.19074097f, 0.11648051f, -0.15708998f, -0.32260358f, -0.11054964f, 0.11259577f, 
    -0.01085705f, 0.01302603f, 0.19418240f, -0.12210207f, 0.28338346f, 0.04134594f, 0.10139522f, 0.02989214f, 
    -0.06964205f, 0.10925326f, 0.17449299f, 0.10981325f, 0.01493378f, -0.13805668f, -0.07461963f, -0.14562947f, 
    -0.03152923f, -0.08711348f, -0.10358686f, 0.06038694f, -0.06229457f, -0.09295882f, 0.36525390f, 0.33143225f, 
    -0.35345292f, 0.20200947f, -0.12966266f, 0.01648077f, 0.18243833f, 0.03905457f, -0.10599820f, -0.00220032f, 
    0.14089388f, -0.17696065f, 0.05996190f, 0.22275649f, 0.10954155f, 0.22373922f, 0.02956251f, 0.08214735f, 
    0.27784276f, -0.02147292f, 0.07368846f, -0.06760106f, -0.20268524f, -0.08616718f, -0.06962481f, 0.25154498f, 
    -0.00835899f, -0.07391349f, 0.06992318f, 0.08761370f, 0.02786316f, 0.00476037f, 0.15898673f, -0.04720411f, 
    0.00626199f, 0.02345659f, 0.07448953f, 0.08237603f, 0.20863324f, -0.08266823f, 0.00342195f, 0.14854468f, 
    0.28011781f, -0.03884633f, -0.01558510f, 0.10007836f, -0.26429304f, 0.05729750f, 0.15327777f, 0.09177085f, 
    0.09440610f, -0.16374339f, -0.08779367f, -0.28268304f, 0.07513350f, 0.01848634f, 0.19723041f, -0.15986653f, 
    -0.16700533f, -0.04207232f, 0.08244939f, -0.12428112f, 0.20220365f, 0.31334248f, -0.10584152f, 0.14769901f, 
    0.05127359f, 0.00326109f, -0.00068492f, 0.08701683f, 0.29653558f, -0.16005255f, 0.06807783f, 0.01916427f, 
    0.27017373f, 0.01554578f, -0.20908229f, -0.07031281f, 0.06893476f, -0.02228541f, 0.07375627f, -0.21844389f, 
    -0.07220091f, -0.11376111f, -0.01095944f, -0.03970321f, -0.00421347f, 0.18772776f, -0.23268579f, 0.11708841f, 
    0.03937587f, -0.01708607f, 0.01962437f, 0.04128112f, -0.03392703f, 0.03895095f, -0.02561261f, 0.01893876f, 
    -0.00593469f, -0.05109790f, 0.02015916f, -0.04690342f, -0.04321517f, 0.05359032f, -0.04799594f, -0.02034397f, 
    -0.04754015f, -0.04636995f, 0.02723449f, 0.04694550f, 0.05240351f, -0.00354689f, -0.03814688f, 0.00291495f, 
    -0.00570280f, 0.04168249f, 0.02798158f, 0.02460389f, 0.04174617f, -0.01207064f, -0.01053113f, -0.03519926f, 
    0.02174510f, 0.01420937f, 0.04305583f, -0.04283489f, -0.03191822f, 0.04641945f, 0.00567383f, 0.04940950f, 
    -0.02447818f, 0.05311293f, 0.04602639f, -0.04402918f, -0.01965498f, -0.02459723f, -0.04743109f, -0.01557067f, 
    -0.03309105f, -0.00516936f, -0.01698644f, -0.05970452f, -0.00385775f, -0.00788831f, -0.05080533f, -0.00394149f, 
    0.01319211f, -0.03529635f, -0.02823576f, 0.03250687f, -0.05522663f, -0.03448339f, -0.05129830f, 0.02204723f, 
    0.00643142f, 0.03214109f, -0.03242385f, -0.04809223f, -0.06307078f, 0.05578338f, -0.03660395f, -0.02690067f, 
    0.02861085f, 0.03724441f, -0.02857922f, 0.02122417f, 0.05131476f, -0.01721033f, 0.00123860f, -0.01357344f, 
    -0.01689555f, -0.00225032f, -0.02679466f, -0.03554135f, -0.04815471f, -0.04138518f, -0.00551175f, 0.04181888f, 
    -0.04121200f, 0.01379057f, -0.00956767f, -0.05417385f, -0.00650168f, -0.03610258f, 0.02925596f, 0.02849398f, 
    0.02483550f, -0.01700342f, -0.02508982f, -0.02597680f, -0.05125827f, -0.05397912f, 0.02831374f, 0.01684432f, 
    -0.01934565f, 0.00765711f, 0.00668580f, 0.04059280f, -0.02081552f, -0.06352115f, -0.04129484f, -0.04300043f, 
    0.02463065f, -0.03106993f, -0.05571749f, -0.03963432f, 0.04338931f, 0.03683748f, 0.05552672f, 0.03534107f, 
    0.03739539f, -0.00815867f, 0.00392310f, 0.04415835f, -0.06400121f, -0.06156241f, -0.03464610f, 0.02213208f, 
    -0.03389819f, 0.04376808f, 0.00481262f, 0.00703968f, 0.01149133f, 0.04268744f, 0.03977273f, -0.04747721f, 
    -0.03541867f, -0.01439619f, -0.00324851f, -0.03257244f, 0.02335955f, -0.02921821f, 0.02894951f, -0.05192751f, 
    -0.03497723f, 0.04202352f, 0.03869661f, 0.03417967f, -0.02506888f, -0.01757184f, -0.00830122f, 0.01252468f, 
    -0.04245153f, 0.03594859f, 0.01350770f, 0.03186730f, 0.02290182f, 0.01872502f, 0.02882898f, 0.01743469f, 
    0.03662354f, -0.02217081f, 0.00330600f, -0.05661734f, 0.00666167f, 0.04036187f, -0.04830589f, 0.00258039f, 
    -0.06343336f, -0.02348764f, -0.00460434f, -0.01562587f, -0.05189143f, -0.04234626f, 0.00332008f, -0.02620397f, 
    0.03968741f, 0.01290124f, -0.02125687f, -0.03847608f, -0.05689075f, -0.04601142f, -0.00716670f, 0.00071001f, 
    -0.06116005f, -0.05166518f, 0.04141485f, -0.03162196f, -0.03341192f, 0.00220029f, -0.05619481f, 0.01261425f, 
    0.02489148f, -0.01104847f, -0.01665966f, 0.05322296f, 0.04424375f, -0.03888718f, -0.03768833f, 0.02277822f, 
    -0.01197229f, -0.04250537f, -0.02730864f, -0.02015901f, 0.03878959f, -0.02704652f, -0.01191327f, 0.03993528f, 
    -0.06237540f, 0.03546190f, -0.01050507f, 0.03001411f, -0.05790333f, -0.04232468f, -0.01345343f, -0.05022018f, 
    0.00548279f, 0.02664932f, -0.05172146f, -0.04162764f, -0.04632691f, -0.03748004f, 0.05081595f, -0.02818657f, 
    -0.04526443f, -0.04601733f, -0.02698609f, -0.01684782f, 0.00471158f, -0.06260620f, 0.01670946f, -0.00014872f, 
    0.05059099f, -0.03143778f, 0.02209354f, -0.03617418f, -0.05730179f, -0.04120644f, -0.06251971f, -0.04549569f, 
    -0.02468222f, -0.00774065f, -0.02706083f, -0.00573351f, -0.03909286f, 0.01228798f, -0.01226840f, -0.01450345f, 
    0.04677120f, 0.04065235f, -0.04484695f, 0.05272570f, 0.03499777f, 0.03980452f, 0.02575098f, 0.05083503f, 
    -0.04519109f, -0.03496666f, 0.02517029f, 0.00695077f, 0.03595865f, -0.00905530f, -0.04324027f, -0.05078889f, 
    -0.05141331f, -0.03473324f, 0.02009792f, 0.05147105f, 0.03499525f, -0.03023133f, 0.00580831f, -0.00083295f, 
    0.02817282f, -0.04591205f, 0.04774476f, 0.02453391f, -0.04697908f, 0.02425964f, -0.04454295f, -0.05371753f, 
    0.02042464f, -0.04067077f, 0.01264039f, 0.03622558f, 0.00834626f, 0.03951850f, 0.00092583f, -0.00228403f, 
    0.07901952f, 0.09810057f, -0.13070238f, -0.05740989f, 0.02601560f, 0.09378063f, -0.11851038f, 0.06978475f, 
    0.00050634f, -0.57143003f, -0.42720291f, -0.38703775f, -0.08261798f, -0.11982168f, 0.09537149f, -0.01607668f, 
    0.10772868f, 0.01130647f, 0.01112259f, -0.22421122f, -0.24280749f, -0.06972115f, -0.15061384f, -0.11741558f, 
    -0.22405307f, 0.13760771f, -0.10074242f, 0.10980058f, 0.24952963f, -0.23515981f, -0.04816693f, -0.04311696f, 
    -0.20860487f, 0.09458318f, 0.06081805f, -0.01280230f, 0.14296010f, -0.10735927f, 0.27575964f, -0.02980028f, 
    0.08829873f, 0.05686534f, -0.00672799f, -0.10527440f, 0.13903242f, -0.12656726f, 0.02545824f, -0.09737942f, 
    -0.03529868f, -0.06086638f, -0.04800178f, 0.10535187f, 0.14716977f, -0.10621642f, 0.09440895f, 0.14426838f, 
    0.29576087f, 0.09418748f, 0.04668172f, -0.03811538f, 0.09859747f, -0.10372865f, 0.17248081f, 0.04551551f, 
    -0.05589521f, -0.06277966f, -0.10509596f, 0.07214257f, -0.20318858f, 0.13924862f, 0.01326136f, -0.08755799f, 
    -0.59716350f, -0.06940943f, 0.50555336f, -0.04726735f, 0.02635240f, -0.10535091f, -0.03797813f, 0.06671717f, 
    -0.15301375f, 0.09215216f, -0.07307172f, -0.07655663f, -0.06044672f, 0.06583407f, 0.17227629f, 0.00450476f, 
    -0.06483328f, 0.08657856f, -0.05023712f, -0.49864185f, 0.06681751f, 0.04651222f, 0.15069216f, 0.52950865f, 
    -0.17364526f, -0.14992715f, 0.10174256f, -0.24923022f, -0.06878334f, 0.22406712f, 0.01045434f, -0.21521869f, 
    0.02532361f, 0.04474064f, -0.09503021f, 0.14108749f, 0.14704801f, -0.28997779f, -0.18062912f, -0.09939248f, 
    -0.15030053f, -0.06983373f, 0.07199400f, -0.09687322f, 0.09336887f, 0.15607400f, 0.07104360f, -0.07128058f, 
    0.05131321f, -0.00509593f, -0.04365404f, 0.13472331f, 0.07845673f, -0.12564875f, -0.48856574f, 0.28425136f, 
    -0.23304403f, -0.00475262f, 0.02215649f, 0.10169999f, -0.13143885f, -0.01605718f, 0.04225179f, -0.25503272f, 
    -0.30028731f, -0.00756829f, 0.22059534f, 0.07897956f, 0.12537330f, -0.03192798f, -0.05236145f, 0.24703741f, 
    -0.14885727f, 0.01830615f, -0.23145907f, 0.04449973f, 0.08797745f, 0.11487237f, 0.13359407f, -0.05507800f, 
    -0.00654063f, -0.26274607f, 0.06381854f, 0.15433760f, 0.10581172f, -0.12675914f, -0.06347027f, 0.06181742f, 
    -0.04938251f, -0.15174419f, -0.25859135f, -0.07778663f, -0.14853555f, 0.11534113f, 0.08856567f, 0.26650742f, 
    -0.15041606f, 0.06232691f, -0.00586231f, 0.02422431f, -0.24609552f, 0.01124059f, 0.05009019f, 0.01229937f, 
    0.15079452f, -0.11855089f, 0.04020606f, -0.01169575f, 0.17164572f, 0.27875572f, -0.08108158f, -0.10804547f, 
    0.13203858f, 0.00570364f, 0.06345963f, 0.05838994f, -0.08427916f, 0.29933050f, -0.10675811f, -0.12962180f, 
    -0.12392782f, 0.01239155f, -0.16995858f, -0.00863772f, 0.13266464f, 0.04399334f, -0.23886739f, -0.28163064f, 
    0.35822156f, -0.14262754f, 0.15819630f, 0.03433383f, 0.08814833f, 0.04732425f, 0.08508246f, 0.05890251f, 
    0.12430610f, 0.30452704f, 0.06611487f, -0.09750085f, 0.05925318f, -0.14397429f, -0.03683713f, -0.01891382f, 
    -0.07148060f, 0.04186461f, 0.26025093f, -0.18246751f, 0.11448030f, 0.07290023f, -0.00754680f, 0.13983700f, 
    0.12630230f, 0.14492653f, 0.30701762f, 0.11240963f, 0.07349115f, 0.10089630f, 0.00204102f, 0.05261181f, 
    0.03859747f, 0.10516074f, 0.16461855f, -0.29372150f, -0.15354902f, -0.01913907f, 0.01774546f, -0.07679547f, 
    0.02173247f, -0.10618263f, 0.02844872f, -0.15897621f, 0.09141835f, 0.22031052f, -0.07029400f, -0.04984562f, 
    -0.17059788f, -0.01394674f, -0.10360146f, 0.26866499f, 0.15190780f, -0.27113062f, -0.03087666f, 0.07956975f, 
    -0.06233948f, -0.09967314f, 0.20071848f, -0.00420123f, -0.12150022f, -0.24069791f, -0.07727114f, -0.52371705f, 
    -0.09510073f, -0.10853229f, 0.10713940f, -0.17939574f, 0.04822504f, -0.07439876f, 0.10705236f, 0.15380645f, 
    -0.15066037f, -0.05873689f, -0.14880891f, -0.07180727f, -0.12280344f, -0.09021351f, 0.08331884f, -0.03105515f, 
    -0.01290282f, 0.19684051f, -0.10834438f, 0.13089846f, -0.24689068f, -0.09370837f, -0.22316138f, 0.03582580f, 
    -0.39194602f, -0.38231811f, 0.14288302f, -0.08587293f, -0.20673941f, -0.09875125f, 0.06291290f, -0.07497155f, 
    0.28601232f, -0.31336850f, -0.25454131f, -0.15144035f, -0.11282596f, 0.13281910f, 0.01198165f, -0.11772806f, 
    -0.04980695f, -0.05479066f, -0.20361604f, -0.24853033f, -0.19544539f, 0.01120684f, -0.09233773f, -0.19386141f, 
    0.27631870f, 0.04208775f, 0.12632386f, -0.09038436f, 0.10136417f, 0.14793517f, 0.09867028f, 0.12564053f, 
    -0.11468311f, 0.12280817f, -0.11752618f, -0.16846801f, -0.05388974f, 0.10633080f, 0.17689128f, -0.04598667f, 
    0.25705597f, 0.01600175f, 0.30695954f, -0.10097301f, 0.24064113f, -0.44453263f, -0.00731674f, 0.05884585f, 
    0.00385118f, -0.13704015f, 0.02644127f, -0.04839422f, 0.01280297f, 0.06021351f, -0.24395946f, -0.00497089f, 
    -0.02310566f, 0.07009535f, 0.06731216f, -0.00574363f, 0.09355902f, -0.07156514f, 0.26988173f, -0.11657101f, 
    -0.36533159f, -0.16972522f, 0.04162294f, -0.12168556f, -0.11111680f, 0.08148032f, -0.04762955f, -0.21188223f, 
    0.01484925f, -0.29000318f, -0.11036316f, -0.15847558f, -0.18050788f, 0.09378841f, 0.10196586f, 0.35394239f, 
    0.07159385f, 0.02235518f, -0.08726076f, -0.33348256f, -0.10453318f, -0.04424110f, 0.04584701f, 0.11384428f, 
    0.29885811f, -0.13190062f, 0.42218980f, -0.06305765f, 0.31519949f, 0.02113831f, -0.08456609f, 0.11928382f, 
    0.02680587f, 0.02102382f, 0.00010739f, 0.04442662f, 0.14071587f, 0.36864099f, 0.13983335f, 0.01016733f, 
    0.15640071f, 0.01176460f, -0.14977285f, -0.19523765f, -0.17167933f, -0.16767572f, -0.19971445f, -0.04307686f, 
    -0.18299441f, -0.05066446f, 0.10642408f, 0.27277410f, 0.16126800f, -0.27394912f, 0.20500939f, 0.12623744f, 
    0.00624720f, 0.01351573f, 0.05344155f, 0.26486415f, 0.05096487f, -0.02854902f, 0.31171334f, -0.21074477f, 
    -0.19024894f, -0.05154999f, 0.03976050f, 0.05324519f, -0.02749345f, -0.09511352f, 0.04118031f, 0.05921181f, 
    -0.01617264f, -0.11922991f, -0.12499806f, -0.01614591f, 0.29160973f, 0.02961286f, 0.28285170f, -0.04885158f, 
    -0.26874265f, -0.15771629f, -0.28258914f, 0.01856690f, -0.00371580f, -0.00499830f, 0.08910663f, 0.15407459f, 
    0.02032135f, -0.12168258f, -0.16098224f, 0.05609204f, -0.18865766f, -0.09665957f, 0.03644828f, -0.02778995f, 
    -0.02124617f, -0.12784344f, 0.33247328f, 0.04157739f, -0.11653820f, -0.00969972f, -0.00725436f, -0.02160843f, 
    0.05653335f, 0.30272818f, 0.00525170f, -0.38975507f, -0.25831980f, -0.22006580f, 0.14242525f, -0.01500355f, 
    -0.13882397f, -0.04676066f, 0.12410571f, 0.26546159f, 0.11319270f, 0.07564504f, 0.21375138f, 0.03792993f, 
    0.09327905f, -0.07061470f, 0.14381260f, -0.10255983f, -0.03058678f, -0.07097290f, -0.28134874f, -0.16743273f, 
    -0.03401057f, -0.12682365f, -0.07363398f, -0.16973032f, 0.05497742f, 0.14144796f, 0.51269686f, 0.17202751f, 
    -0.08089795f, -0.33956423f, -0.26828915f, -0.19338225f, 0.20370181f, -0.16148601f, 0.10357247f, 0.00946230f, 
    0.09771207f, 0.15922581f, 0.18657984f, 0.09082424f, 0.06513210f, 0.25157109f, -0.09953716f, 0.19110683f, 
    -0.19034131f, 0.09311051f, 0.07569063f, 0.05218289f, -0.01318265f, -0.18619606f, 0.15585263f, 0.29190782f, 
    -0.45646906f, -0.03032843f, 0.11014976f, 0.34430733f, -0.03205897f, -0.02270309f, -0.05521455f, 0.08553290f, 
    0.06620366f, 0.11455555f, 0.06609990f, -0.18516070f, 0.08564927f, 0.01223153f, -0.09311160f, -0.16235332f, 
    0.15305099f, 0.14853919f, -0.17857069f, -0.13885598f, -0.16448824f, 0.23819493f, -0.02703410f, 0.04449777f, 
    0.06672472f, 0.07479726f, 0.11294477f, -0.16178106f, -0.03487337f, -0.09230044f, 0.23663706f, 0.08184059f, 
    -0.15355898f, -0.10047670f, -0.10422872f, -0.07965806f, -0.09515651f, -0.11356666f, 0.13202782f, 0.26887819f, 
    0.04272991f, 0.17342897f, -0.07801502f, 0.06728098f, 0.11806147f, -0.11854170f, -0.06154112f, -0.24601081f, 
    0.33510470f, 0.00645488f, -0.04193350f, -0.04427094f, -0.04792412f, -0.13031144f, -0.06878096f, -0.52969253f, 
    -0.45356002f, -0.19884713f, -0.08984412f, 0.10434862f, 0.15519433f, 0.04417660f, 0.26672280f, -0.02762456f, 
    -0.30470374f, -0.10724518f, 0.00915942f, 0.18268783f, 0.21573256f, -0.12316854f, -0.14167780f, 0.08884972f, 
    -0.20356753f, -0.31757489f, -0.19438645f, -0.03293292f, -0.00572486f, 0.16462223f, 0.00492921f, -0.00097512f, 
    -0.06890053f, 0.06947145f, -0.39724618f, -0.16101213f, -0.12031224f, 0.08798730f, 0.05268115f, 0.10290048f, 
    -0.12609294f, -0.02853765f, -0.12247081f, 0.17242843f, 0.25836369f, 0.17106982f, 0.05634685f, 0.09981751f, 
    -0.04182668f, 0.02553362f, -0.27715412f, -0.28047615f, 0.05525067f, 0.01548867f, 0.18951631f, 0.02528879f, 
    0.16934948f, 0.04533860f, 0.11641966f, -0.00595337f, 0.03280484f, 0.34329945f, -0.14725800f, -0.27110276f, 
    -0.01910926f, -0.01825753f, -0.09232881f, 0.06641033f, -0.04027683f, 0.10039796f, -0.10490648f, -0.05635029f, 
    -0.05919227f, 0.22952032f, 0.25329807f, -0.08096272f, 0.05975858f, -0.15001270f, 0.02692982f, -0.13859202f, 
    -0.11068540f, -0.19580245f, 0.07109687f, -0.10391688f, -0.05527679f, -0.03871157f, -0.10162729f, -0.08636006f, 
    -0.20276903f, -0.25318569f, 0.15834102f, -0.04244423f, -0.01506174f, 0.14784284f, 0.08934072f, 0.05377607f, 
    0.05232818f, -0.14259046f, -0.14687103f, -0.11411294f, -0.05136154f, 0.16798086f, 0.19824648f, 0.03007022f, 
    -0.16899523f, 0.11277141f, -0.03324130f, 0.23497692f, 0.05512966f, -0.25754893f, -0.04442443f, 0.07854097f, 
    0.20301430f, 0.17892638f, -0.00076086f, 0.08660006f, 0.05917377f, 0.25248039f, -0.04175307f, 0.15077919f, 
    -0.07468240f, -0.01761637f, -0.04415209f, 0.12695780f, -0.21033442f, -0.18376760f, -0.31828266f, -0.09093974f, 
    -0.08624460f, -0.20177309f, -0.01130805f, -0.10581300f, 0.04982115f, 0.24884729f, 0.06158059f, 0.02537095f, 
    0.02772799f, -0.06909264f, 0.03255776f, 0.07943879f, -0.09170391f, -0.10917336f, 0.11845276f, 0.10863809f, 
    0.39210013f, 0.11838078f, 0.03892594f, 0.10068750f, -0.00170034f, 0.22222200f, -0.05895281f, 0.02743001f, 
    0.03499698f, 0.05636296f, -0.08518727f, 0.02236614f, 0.10212607f, 0.11559561f, 0.14533724f, 0.12449880f, 
    -0.22001918f, -0.04447189f, -0.17547129f, -0.04412645f, 0.01282714f, -0.00882918f, 0.11581929f, -0.00137662f, 
    -0.03042512f, 0.10979498f, -0.13671070f, 0.07618172f, 0.10250614f, 0.03808537f, -0.02034553f, 0.03813003f, 
    0.07182207f, -0.03946961f, -0.10178717f, 0.08506387f, -0.18713737f, -0.07046121f, 0.11409120f, 0.12161686f, 
    0.13678661f, -0.00843120f, 0.03519351f, -0.25567657f, -0.20200087f, -0.02859413f, 0.14512965f, 0.13173251f, 
    -0.14477485f, -0.01425245f, -0.07043424f, 0.12713416f, -0.01176895f, 0.38155070f, 0.05354354f, 0.15018560f, 
    -0.01752757f, 0.00388690f, 0.11061256f, -0.14702070f, -0.21137214f, -0.22259274f, -0.18911941f, -0.32128078f, 
    -0.14736544f, -0.00764672f, -0.08185047f, -0.04681657f, -0.10855940f, -0.09262045f, -0.32915726f, -0.40349445f, 
    0.38560858f, 0.06441817f, -0.15239839f, -0.17819932f, -0.01269334f, -0.04913722f, 0.07345459f, 0.12297443f, 
    0.18262215f, 0.05729685f, 0.02774260f, -0.02245738f, 0.00053811f, 0.05132153f, 0.12195023f, 0.02114072f, 
    0.08052649f, 0.14498562f, 0.26110172f, 0.12335148f, 0.03732032f, -0.06857498f, 0.27921724f, -0.05962855f, 
    -0.36821094f, 0.06022040f, 0.19762486f, -0.15275969f, -0.01855317f, 0.05119819f, 0.11747660f, 0.05938286f, 
    -0.06430881f, 0.11234871f, -0.13375053f, -0.09242309f, -0.03570474f, -0.02835941f, 0.09566922f, 0.04022314f, 
    -0.04339952f, 0.02882926f, -0.12819277f, 0.09327912f, 0.07060965f, 0.30756980f, -0.14004305f, 0.19498272f, 
    -0.07896170f, 0.13542540f, 0.00647849f, 0.02912857f, -0.27876675f, -0.24408855f, -0.04038354f, 0.01326742f, 
    0.01778211f, -0.03134474f, -0.05708984f, -0.14716455f, -0.24410887f, 0.03668914f, 0.01455277f, -0.08791836f, 
    0.16609509f, 0.12193790f, -0.05574868f, -0.02094919f, -0.00079157f, -0.24284282f, -0.26031095f, -0.08134676f, 
    -0.02997488f, 0.19057935f, 0.04833121f, 0.14339742f, 0.08172239f, 0.04349783f, -0.09727454f, -0.15073293f, 
    0.05657644f, -0.15459017f, 0.06870321f, 0.01660997f, -0.03131871f, 0.07339057f, 0.02806794f, 0.09246968f, 
    0.04449922f, 0.20847610f, 0.21312451f, 0.08835853f, -0.05450063f, 0.03059785f, -0.12339367f, 0.03636457f, 
    -0.35176355f, 0.24846809f, 0.27264512f, 0.08324041f, -0.00570262f, 0.04955554f, 0.04839219f, -0.15221778f, 
    -0.05733737f, -0.00164379f, 0.18046567f, -0.10147648f, 0.26129028f, 0.09661689f, -0.13753326f, 0.07109495f, 
    -0.11966249f, 0.19510692f, -0.13551481f, -0.07038379f, -0.19617946f, 0.23925143f, 0.26215902f, 0.10198087f, 
    0.04540558f, -0.13679373f, -0.05182948f, 0.10152770f, -0.16200726f, 0.15086299f, -0.11395201f, -0.23824167f, 
    0.04499147f, 0.10073815f, -0.00218383f, 0.23836179f, 0.09082235f, -0.13507073f, -0.23916472f, 0.01909259f, 
    -0.08209244f, -0.25798106f, 0.15731184f, 0.06269302f, -0.07032513f, 0.12539311f, 0.01624512f, -0.03603963f, 
    0.17923546f, -0.13183527f, -0.09287414f, 0.14158030f, 0.18699440f, 0.16446283f, 0.23245190f, -0.01026899f, 
    -0.20141734f, 0.20185888f, -0.06511392f, -0.02973146f, 0.01885751f, 0.08565733f, 0.06818905f, 0.15947571f, 
    0.34228906f, 0.23730999f, -0.01705137f, 0.09935836f, -0.11194763f, 0.10165344f, -0.02566365f, 0.07109890f, 
    0.05222002f, 0.01900629f, -0.07901701f, 0.14942174f, 0.18808113f, 0.00017159f, -0.03968803f, 0.05576169f, 
    -0.06016693f, -0.03281015f, 0.14716451f, 0.10661418f, 0.16636652f, 0.11396290f, -0.04295330f, -0.12473223f, 
    0.12658976f, -0.04313718f, -0.07840441f, -0.12638150f, -0.23213436f, -0.10906497f, -0.11553884f, -0.02535009f, 
    0.02787445f, -0.24534965f, -0.06894622f, 0.02391018f, 0.11924607f, 0.10573541f, 0.02838553f, -0.02840350f, 
    0.05927315f, -0.02562749f, -0.00879700f, 0.02762173f, -0.26079440f, -0.22393754f, 0.00411549f, 0.16229995f, 
    0.13159929f, 0.07768562f, 0.05007473f, 0.11257695f, 0.04107434f, 0.19678935f, -0.07160880f, 0.23491825f, 
    -0.29088616f, 0.10573375f, -0.07051283f, -0.05943650f, -0.19503900f, -0.07777976f, -0.24469279f, 0.10937499f, 
    0.00134658f, 0.10773347f, 0.05877448f, -0.08345966f, -0.16400580f, -0.17750069f, -0.26900342f, -0.28607261f, 
    0.13863273f, 0.18198708f, 0.08113153f, 0.04607883f, 0.11759041f, 0.01500820f, -0.07048570f, 0.03444029f, 
    -0.23410949f, 0.64978445f, -0.11496233f, 0.09163789f, -0.15657599f, 0.09754384f, -0.03197835f, -0.11341325f, 
    0.09555295f, -0.04101891f, 0.10482974f, -0.04876810f, 0.33667669f, 0.12887019f, -0.02966135f, 0.06972980f, 
    -0.00803300f, 0.12326143f, -0.03594618f, -0.08916538f, 0.24796838f, 0.05225724f, 0.05225007f, 0.00123415f, 
    -0.01128443f, 0.03939523f, -0.09033620f, -0.21766387f, -0.06772617f, -0.25198460f, 0.11889996f, 0.16876091f, 
    0.03327037f, 0.13421422f, -0.03903016f, 0.04197237f, 0.03565785f, 0.13709347f, -0.05670293f, 0.02727550f, 
    -0.02782197f, -0.06492466f, 0.09900221f, -0.08171459f, -0.02897333f, -0.35018426f, -0.18379635f, 0.21949597f, 
    0.31613871f, 0.10776725f, 0.16331345f, 0.18397529f, 0.14946158f, 0.10394296f, -0.14222237f, -0.04907778f, 
    0.18315881f, -0.03269963f, -0.05225654f, 0.07588630f, 0.04105610f, -0.03890203f, 0.19202334f, -0.08562165f, 
    0.03641542f, 0.11305091f, -0.02097183f, 0.12877399f, -0.04918953f, 0.12773442f, -0.03122067f, -0.17782706f, 
    0.02365482f, -0.04780929f, -0.19027893f, 0.31705230f, 0.04709742f, -0.08745933f, 0.19516982f, -0.04398149f, 
    0.07303949f, 0.01644254f, 0.02665014f, -0.10850574f, 0.32067311f, -0.12564017f, 0.39846128f, 0.10766305f, 
    0.01184495f, 0.01863979f, 0.11342925f, -0.09517287f, 0.10296960f, -0.09997121f, 0.14465690f, 0.10938312f, 
    -0.08927435f, -0.09217724f, -0.03111730f, -0.26966360f, -0.00773745f, 0.07072689f, 0.05703370f, 0.01587754f, 
    0.14886777f, -0.15206037f, 0.11950207f, 0.12545176f, 0.03609254f, -0.18577725f, 0.26061028f, -0.05058957f, 
    0.11780982f, 0.04935805f, 0.03790844f, 0.00649316f, 0.09434070f, 0.14034279f, -0.10787950f, -0.29366541f, 
    0.21766576f, 0.17217757f, -0.16521278f, 0.09237444f, 0.01869472f, -0.02600296f, 0.01228981f, 0.24529402f, 
    -0.00665970f, 0.06347036f, 0.14171563f, -0.10424693f, 0.02734485f, -0.07690860f, -0.07210866f, -0.05610630f, 
    0.01174464f, 0.09441826f, -0.06634840f, -0.16212454f, 0.07086772f, -0.08444270f, -0.06746033f, 0.15075135f, 
    -0.12062253f, -0.28983280f, -0.16349885f, 0.07636824f, 0.09699052f, 0.08592696f, -0.29954594f, 0.04227327f, 
    0.11613452f, 0.08837708f, -0.09844267f, -0.39604896f, 0.09480306f, -0.09088496f, 0.03951208f, -0.20083372f, 
    -0.10153750f, 0.13299391f, -0.08962151f, -0.09478501f, -0.52253097f, -0.29730910f, -0.12112582f, -0.18219526f, 
    -0.09386840f, 0.07992827f, -0.04986876f, -0.04464744f, 0.14330970f, 0.20626514f, 0.22852027f, 0.07775990f, 
    0.13742955f, -0.24307771f, 0.06190436f, 0.13440840f, 0.02869218f, -0.44928697f, -0.20377798f, 0.23799494f, 
    -0.13358240f, -0.09602748f, 0.03601580f, -0.10183359f, 0.03184720f, 0.08040170f, -0.07824422f, 0.05718622f, 
    0.41780314f, -0.02960206f, -0.02804651f, 0.24758612f, -0.02598426f, 0.09880950f, 0.22893277f, -0.21517117f, 
    -0.05211881f, 0.21026807f, -0.01653585f, -0.08853640f, -0.14120552f, -0.03068604f, 0.06454176f, 0.09804767f, 
    -0.15260009f, -0.24937765f, 0.46269083f, -0.09590110f, 0.01265469f, -0.09736448f, 0.01076345f, -0.07373428f, 
    -0.27882612f, 0.13948375f, 0.24329482f, -0.17283492f, 0.14786249f, -0.02213600f, 0.03816496f, 0.12463495f, 
    -0.12931949f, 0.07756807f, 0.23840396f, -0.31831977f, -0.03929923f, 0.24227424f, 0.22270051f, 0.23316245f, 
    0.13640925f, -0.07204781f, -0.16847715f, -0.42806703f, -0.61743736f, 0.25399247f, -0.05299761f, -0.06461856f, 
    -0.18088773f, 0.05790071f, 0.07174548f, 0.13849084f, 0.01844437f, -0.08394611f, -0.24821705f, -0.06500103f, 
    -0.04571283f, 0.29479495f, 0.05659049f, -0.09855277f, -0.02606994f, -0.20847544f, 0.14384528f, 0.22982749f, 
    -0.09962240f, -0.08673104f, 0.02189641f, -0.06468321f, 0.24514079f, 0.11633150f, -0.48200265f, -0.37203816f, 
    -0.24411882f, 0.08039176f, 0.19755046f, -0.26929355f, -0.01927496f, 0.15889472f, -0.02610401f, 0.02911505f, 
    -0.25695691f, -0.12855929f, -0.00338549f, 0.15275764f, -0.00338584f, -0.00515718f, 0.01349600f, 0.02184153f, 
    0.01024253f, 0.01190135f, -0.11383350f, 0.01245609f, -0.08704150f, 0.03788977f, -0.04534563f, -0.04513763f, 
    0.10314829f, -0.06203774f, 0.59089303f, -0.00093297f, 0.02432623f, -0.19367954f, -0.00662069f, -0.07062934f, 
    0.06138512f, 0.17017806f, 0.05026529f, -0.01355603f, 0.15731502f, 0.14779750f, 0.07813781f, 0.12921205f, 
    0.07700691f, 0.06491640f, 0.08541184f, 0.07226777f, 0.16944607f, 0.05748672f, -0.02720860f, -0.06752428f, 
    0.16517402f, -0.00406627f, 0.12250471f, -0.01159068f, -0.18743469f, -0.27502406f, 0.10007772f, -0.09990017f, 
    -0.00237388f, 0.07524167f, 0.01830174f, 0.03086346f, 0.04741897f, -0.10867353f, -0.48445934f, -0.06012155f, 
    -0.05324562f, 0.06529567f, 0.13934156f, 0.09513036f, -0.11466640f, -0.13241737f, 0.02455872f, 0.42085195f, 
    -0.22178142f, -0.14321460f, 0.00512865f, 0.12956248f, 0.01136661f, -0.09363475f, -0.03884095f, -0.02843867f, 
    0.08938348f, 0.31194341f, 0.00562320f, 0.13140659f, -0.09260267f, -0.01450768f, 0.21001296f, 0.23656462f, 
    -0.06403573f, -0.04013685f, -0.54703349f, -0.14646296f, -0.24752699f, 0.03032584f, 0.01613947f, -0.05185982f, 
    0.03621606f, 0.25502533f, 0.36878973f, 0.62411112f, 0.12549454f, -0.02407521f, 0.00127294f, 0.07705564f, 
    0.04781589f, 0.02269784f, -0.16751443f, 0.07924698f, 0.34355742f, -0.08554433f, -0.06666891f, 0.05595017f, 
    0.05626735f, 0.14194219f, 0.09925754f, -0.10451874f, 0.06264795f, -0.06226270f, -0.05770612f, 0.00017720f, 
    -0.11967373f, 0.11540364f, -0.17140016f, 0.11903588f, -0.00915255f, -0.10247745f, 0.03484764f, 0.06090046f, 
    0.03225141f, -0.18587406f, 0.01635902f, 0.04707841f, 0.02631452f, -0.25515959f, -0.01658344f, -0.11123080f, 
    0.00943982f, 0.25249866f, -0.20959038f, -0.02240715f, -0.04940807f, -0.04477552f, -0.11243191f, 0.11066718f, 
    0.30415076f, -0.13025445f, 0.00694295f, -0.08012934f, -0.03971835f, -0.11657579f, -0.00327495f, 0.06798816f, 
    -0.09583709f, 0.30343246f, -0.06893288f, -0.26647604f, -0.29885474f, -0.04005301f, -0.06836316f, 0.00868470f, 
    0.16313513f, -0.17606880f, -0.13450925f, 0.00741901f, -0.13564815f, -0.26641753f, -0.01663335f, -0.19152109f, 
    0.08534465f, 0.33942589f, 0.12421485f, 0.14952938f, -0.07019924f, -0.28490856f, -0.03193129f, -0.16176167f, 
    -0.13261250f, -0.07577426f, -0.25678298f, -0.19386569f, -0.13466495f, 0.07812048f, -0.07096972f, -0.01784238f, 
    0.09983216f, -0.11175947f, 0.05487323f, 0.06710397f, 0.19111720f, 0.20509535f, 0.04048409f, 0.04914119f, 
    -0.09931087f, 0.09603484f, -0.12490618f, 0.16400011f, 0.03913893f, -0.20603715f, 0.32731882f, 0.01671729f, 
    -0.01490582f, 0.09675153f, 0.02190372f, -0.01054717f, 0.10320716f, 0.19390550f, -0.40836683f, 0.60165095f, 
    -0.09228405f, 0.01097913f, 0.09450284f, -0.03881431f, 0.08631369f, 0.22168252f, 0.18535353f, 0.02163147f, 
    0.00564143f, 0.02353907f, -0.00955818f, -0.05914246f, 0.04716254f, 0.05034712f, 0.14446032f, -0.08156455f, 
    0.31214547f, -0.06327713f, -0.10124366f, -0.14002870f, 0.03133422f, 0.06206632f, 0.11911738f, 0.04942345f, 
    0.09925889f, -0.54410291f, -0.09644669f, 0.13705438f, 0.13881911f, 0.08923694f, 0.11530270f, 0.09218055f, 
    0.11958366f, -0.55288810f, 0.13177563f, -0.17122294f, 0.26914787f, -0.12596086f, 0.01544697f, 0.09353322f, 
    -0.05646684f, 0.02426968f, -0.19917831f, -0.46472883f, -0.06266390f, 0.09842927f, 0.13897909f, 0.05728798f, 
    0.01506232f, 0.00868007f, -0.21217042f, 0.06577929f, 0.00961505f, 0.26757336f, -0.12510066f, -0.05818767f, 
    -0.01995638f, 0.10196169f, 0.01795249f, 0.01389210f, -0.08386147f, -0.11508340f, -0.38064426f, 0.14885700f, 
    -0.00210097f, -0.00721448f, 0.07635076f, -0.02341314f, -0.05824853f, 0.21193406f, 0.06894594f, 0.33810163f, 
    0.00659340f, -0.00540467f, -0.00202527f, 0.20887631f, -0.08960941f, 0.10292781f, -0.18055978f, 0.36480609f, 
    0.15729947f, -0.04356713f, -0.07665838f, -0.10528578f, 0.02551646f, -0.01389892f, -0.03460462f, -0.10749361f, 
    0.00182812f, -0.01338853f, 0.07209521f, -0.06312352f, -0.16150123f, 0.07056046f, -0.09510210f, -0.12074330f, 
    0.03099127f, -0.03498691f, -0.06226951f, -0.01059710f, -0.07367685f, -0.04764124f, 0.05312961f, -0.01930913f, 
    -0.04684150f, -0.35885996f, 0.17417781f, 0.13336979f, 0.00322280f, 0.12191383f, 0.06646790f, -0.08485994f, 
    0.26160473f, 0.26660192f, -0.51800638f, 0.15613158f, -0.17502365f, 0.16647565f, -0.09977490f, 0.00704031f, 
    0.20644292f, -0.16617833f, 0.09766803f, 0.05769418f, -0.06759870f, -0.23472589f, -0.05254759f, 0.02655057f, 
    -0.16560772f, 0.10483170f, -0.10534773f, -0.13123573f, -0.06403536f, 0.29873997f, 0.27451697f, -0.02370070f, 
    -0.07949410f, -0.13295841f, -0.03958327f, -0.06116854f, 0.12103447f, -0.34899923f, -0.42609680f, -0.22872403f, 
    0.01392058f, -0.11089893f, -0.17017178f, -0.17106931f, -0.02512464f, -0.09793883f, -0.39402148f, -0.28134617f, 
    -0.37331158f, 0.00378543f, 0.04104771f, 0.18794818f, 0.09244282f, 0.00540816f, 0.27881342f, -0.14907449f, 
    -0.22088899f, -0.01124373f, -0.01642836f, -0.00626173f, -0.02660530f, -0.01651749f, -0.00843666f, 0.09743638f, 
    -0.17935650f, 0.19852503f, -0.13728715f, 0.03156408f, 0.16912083f, 0.01721044f, 0.01492434f, 0.02778497f, 
    -0.17858511f, 0.16954719f, -0.10047630f, 0.26656520f, 0.17949504f, -0.01106721f, 0.00797941f, 0.09884574f, 
    -0.02559725f, 0.06913912f, -0.04506946f, 0.31786528f, 0.08775119f, -0.20760985f, 0.03866664f, 0.18894853f, 
    -0.00407864f, 0.09684788f, 0.08590809f, 0.09839628f, 0.29870656f, 0.33120045f, 0.06918374f, 0.11241158f, 
    -0.02996513f, -0.00154545f, -0.03736345f, -0.15220626f, 0.09355957f, -0.08263285f, -0.11243730f, 0.16153994f, 
    0.00702873f, 0.09615969f, 0.13367525f, 0.11584196f, -0.03785548f, 0.13632770f, 0.13719165f, -0.12774122f, 
    0.06093169f, 0.03550074f, 0.05488222f, -0.02684782f, -0.00058500f, -0.02419946f, -0.00716598f, 0.26902407f, 
    0.02702337f, 0.00908934f, -0.28712618f, 0.06350107f, 0.16542152f, -0.04772119f, 0.04068105f, 0.26172614f, 
    -0.16593121f, 0.13669957f, 0.06264845f, -0.06763867f, 0.00926040f, -0.09287158f, -0.04237590f, -0.13114494f, 
    0.14743210f, -0.06183978f, -0.03825042f, -0.22617672f, 0.02466927f, -0.20882359f, -0.08428595f, 0.07146235f, 
    0.10615356f, 0.08451728f, -0.56952983f, 0.03817821f, 0.06463798f, 0.01963091f, -0.03656520f, 0.23199160f, 
    -0.02392352f, 0.04587651f, 0.21575734f, -0.06428468f, 0.00319614f, -0.09005640f, -0.14466488f, -0.19764787f, 
    -0.31760466f, 0.06269457f, 0.03802456f, -0.07525521f, -0.05589084f, -0.10167936f, -0.01478309f, -0.09188665f, 
    0.01187656f, -0.03315958f, 0.06523836f, 0.10420567f, 0.10127633f, -0.23178391f, 0.09430797f, 0.13930859f, 
    0.15042977f, 0.04511004f, 0.26243252f, 0.11299025f, 0.02370850f, -0.32253003f, 0.11997057f, 0.30614945f, 
    0.05591118f, -0.18251093f, -0.17260166f, 0.03523343f, -0.15033214f, -0.02359047f, 0.19853197f, 0.05186266f, 
    0.00288984f, 0.06186634f, -0.06379393f, 0.25561249f, 0.17834322f, 0.01020133f, -0.00745576f, 0.03102124f, 
    -0.03211727f, 0.11973420f, -0.03504393f, -0.09551898f, -0.09849095f, 0.13303377f, -0.14952950f, 0.03796300f, 
    -0.04904046f, -0.30126792f, 0.08710685f, -0.17098820f, 0.06761027f, -0.00279195f, 0.05556868f, -0.08476815f, 
    0.01980520f, 0.32678902f, -0.05376816f, 0.08231699f, 0.04147145f, -0.06732425f, 0.25086766f, 0.06851558f, 
    -0.07965973f, 0.00788771f, -0.13246444f, -0.11281633f, -0.23672159f, 0.04021474f, 0.07067788f, -0.00173154f, 
    -0.22303826f, 0.05786895f, -0.04324584f, -0.17318511f, -0.28416303f, -0.43283361f, -0.06867540f, 0.05896372f, 
    0.00071568f, 0.01425981f, 0.03854133f, -0.13271531f, 0.07121156f, 0.04578780f, -0.01512166f, 0.07280057f, 
    0.02115133f, 0.11220817f, -0.14547293f, 0.06749988f, 0.00677569f, -0.07415126f, 0.00837596f, 0.29739046f, 
    0.09242999f, -0.07737631f, -0.05509270f, -0.19052458f, 0.02919827f, -0.02693581f, -0.34971648f, -0.07016329f, 
    -0.00075760f, -0.12121801f, 0.03170970f, -0.04725296f, -0.01551503f, -0.03772163f, 0.10912152f, 0.08118384f, 
    -0.15201735f, -0.17050461f, 0.14641045f, 0.20711164f, 0.12736619f, -0.01903033f, 0.03828011f, 0.05387571f, 
    0.16721798f, -0.15347664f, 0.01234933f, 0.10745034f, 0.07127813f, -0.03168537f, -0.04607777f, 0.17307639f, 
    0.17006259f, -0.04916245f, -0.08918509f, -0.21453626f, -0.09519740f, -0.34142688f, -0.02701390f, -0.05149374f, 
    0.01979941f, -0.05475233f, 0.52213544f, 0.09957809f, 0.00374456f, 0.09899643f, -0.03922652f, 0.07843252f, 
    0.01700062f, -0.02767413f, 0.16630298f, 0.18938459f, 0.07932026f, 0.14474335f, 0.04930812f, 0.03322962f, 
    0.15368451f, -0.05893319f, 0.11587510f, 0.08003422f, -0.14011087f, 0.05135643f, -0.33771977f, -0.02621404f, 
    -0.04655344f, 0.07490044f, -0.04788597f, 0.22145666f, 0.05012036f, 0.08767925f, 0.05754267f, -0.06699803f, 
    -0.00141432f, -0.03435147f, -0.07580446f, -0.11578597f, 0.02914455f, -0.02291415f, -0.36561719f, -0.33998969f, 
    0.32266271f, -0.03078569f, -0.03615683f, -0.04742574f, 0.23920347f, -0.12079491f, 0.12699477f, 0.14614880f, 
    -0.05801691f, 0.07769002f, 0.06842415f, 0.12199283f, -0.03729397f, 0.23826759f, 0.03330272f, 0.21175326f, 
    0.03958074f, -0.07136857f, 0.06015586f, 0.10362964f, -0.06122487f, 0.19927385f, -0.08577774f, -0.11944951f, 
    0.12851185f, -0.08710939f, 0.31283122f, 0.03401620f, 0.20946701f, 0.02080526f, -0.01939405f, 0.09599002f, 
    0.14650974f, 0.07398841f, 0.12029248f, -0.41610065f, 0.03767170f, -0.02598259f, -0.01466879f, -0.05929270f, 
    0.20287336f, -0.08087806f, 0.06713096f, -0.21255808f, 0.21626323f, -0.13336168f, -0.03855407f, -0.01405426f, 
    0.02320276f, 0.01479031f, -0.08008303f, -0.03976156f, -0.00333858f, -0.02806917f, 0.18539803f, -0.12004691f, 
    0.08152710f, -0.08318245f, -0.13361795f, 0.05671166f, 0.01791756f, -0.05204508f, -0.07977159f, -0.28116500f, 
    0.14984125f, 0.17808104f, 0.12252451f, -0.01586450f, -0.10402173f, 0.04068096f, 0.34717980f, -0.37334031f, 
    -0.24977413f, 0.00170280f, 0.03423594f, 0.06985662f, -0.05104584f, 0.02107695f, -0.22782260f, 0.15181243f, 
    -0.49431288f, -0.06382870f, -0.03940658f, -0.02291794f, -0.07699111f, -0.01259753f, 0.15199816f, 0.03472361f, 
    -0.14530468f, -0.25621608f, -0.39468613f, -0.04563501f, 0.09832576f, -0.05919284f, 0.15952455f, -0.12067319f, 
    0.18592744f, 0.40804875f, -0.25253731f, -0.42362490f, -0.19845048f, 0.16569731f, -0.13644278f, 0.23595089f, 
    0.06816432f, -0.06392710f, -0.02501349f, 0.00678671f, -0.10621497f, -0.08334264f, -0.08903591f, -0.02611379f, 
    -0.00754349f, 0.08154528f, 0.10256767f, 0.05097977f, 0.05707198f, 0.10910205f, 0.10046805f, -0.10029469f, 
    -0.12979333f, 0.09045149f, -0.00403873f, 0.10835203f, -0.22709788f, -0.55036420f, -0.06692214f, -0.22137116f, 
    0.12798935f, -0.00975394f, 0.36421967f, 0.01812677f, 0.01922429f, -0.14228736f, 0.10509973f, 0.81819826f, 
    -0.14197843f, 0.10588060f, -0.08845296f, 0.15785162f, 0.06351873f, 0.16683072f, 0.26517648f, -0.03255760f, 
    -0.09683227f, 0.08087324f, -0.06336851f, 0.08360890f, 0.09646992f, -0.08307631f, 0.22250903f, 0.08351049f, 
    -0.11038670f, -0.20245141f, -0.00365030f, -0.04613720f, 0.10849161f, 0.00848956f, 0.06275420f, 0.11780288f, 
    -0.56901157f, -0.53878641f, -0.11204307f, 0.15870437f, 0.03533593f, 0.03796568f, 0.19835538f, 0.11207258f, 
    -0.04124905f, -0.11650173f, -0.05325271f, -0.11144507f, -0.02992840f, -0.15627840f, 0.17592910f, 0.00563352f, 
    0.05643882f, -0.04802175f, -0.25063685f, -0.13680491f, -0.25688577f, 0.00282407f, -0.07647400f, -0.06556469f, 
    0.14619896f, -0.15815574f, -0.08748972f, -0.15420315f, -0.09431410f, -0.35435101f, 0.01130119f, -0.00374299f, 
    -0.02255402f, 0.07386589f, -0.05367656f, 0.02108606f, -0.08961263f, 0.08910308f, 0.07238806f, -0.00064725f, 
    0.09283894f, 0.16624409f, 0.07771119f, 0.27034020f, 0.02880416f, -0.08709543f, 0.06062818f, 0.46901080f, 
    0.12243557f, 0.16737147f, 0.02060835f, 0.03640601f, 0.06723627f, 0.20268062f, -0.30981442f, -0.28861704f, 
    -0.53787547f, -0.29281062f, -0.13853247f, -0.04260286f, -0.12401673f, -0.09533294f, 0.02218948f, 0.18495819f, 
    0.17722720f, -0.04497917f, -0.10440184f, -0.16568075f, 0.05409506f, 0.22975612f, 0.00181109f, -0.15970206f, 
    0.20838290f, -0.08018324f, -0.06561864f, 0.04930048f, 0.03550868f, 0.06889826f, 0.13996495f, 0.14758269f, 
    -0.04005440f, -0.28784373f, -0.24088065f, 0.20931897f, -0.22998160f, -0.02762088f, -0.05432751f, 0.16459152f, 
    0.20803039f, 0.15147382f, 0.13225001f, 0.12398030f, -0.06489260f, -0.04558631f, -0.06472146f, 0.15004069f, 
    0.10875177f, 0.02382215f, -0.08656959f, 0.18146706f, -0.07154788f, -0.11953846f, 0.09076325f, 0.14212173f, 
    0.04612529f, 0.08211674f, 0.07253018f, 0.04932477f, 0.22273494f, -0.06288340f, -0.17225796f, 0.14424214f, 
    -0.07121659f, -0.06390121f, 0.00612777f, 0.07989705f, 0.00570363f, -0.03282433f, 0.14955254f, 0.11508624f, 
    0.05687309f, -0.04692408f, 0.09459598f, 0.02187674f, 0.15166558f, 0.11127555f, -0.55057305f, -0.04034361f, 
    -0.65426469f, -0.13959774f, -0.20082140f, -0.12365007f, 0.17034991f, -0.01343170f, 0.08044668f, 0.16765098f, 
    -0.36331004f, 0.04501594f, 0.05128552f, 0.05801107f, 0.00045193f, 0.15037772f, -0.03351962f, -0.01228896f, 
    -0.18710010f, 0.00949425f, 0.01879726f, -0.14108662f, 0.05017508f, 0.09629393f, -0.04897267f, 0.01963492f, 
    0.14926165f, -0.09129923f, -0.11385427f, 0.28320146f, -0.06722093f, 0.17144264f, -0.00045190f, 0.17197630f, 
    0.21201974f, 0.12211082f, -0.35869634f, -0.44021979f, -0.13938247f, 0.02784017f, 0.02988889f, -0.09563701f, 
    0.09470915f, -0.02842565f, 0.07669965f, -0.50200087f, 0.13951099f, 0.16848098f, 0.00101495f, -0.06050032f, 
    -0.27005616f, -0.03752909f, -0.11931314f, -0.03807400f, -0.11957236f, -0.06025998f, 0.17970018f, 0.06096229f, 
    -0.02247014f, -0.03401779f, -0.03619270f, 0.10414056f, 0.21117216f, 0.22622579f, -0.15353967f, -0.63488024f, 
    0.10912215f, -0.00018584f, 0.03901968f, -0.07137406f, 0.16422194f, -0.00901245f, -0.03610121f, -0.34249932f, 
    -0.55770653f, 0.19674620f, 0.14576839f, 0.07818983f, 0.09802344f, 0.04076161f, 0.03297386f, 0.21203148f, 
    -0.29560038f, -0.05860656f, 0.08047403f, 0.04720873f, 0.05721243f, 0.04358670f, 0.08610999f, -0.24692342f, 
    0.44328973f, 0.04908557f, -0.18904771f, -0.05969926f, 0.03110451f, -0.02617000f, -0.08401681f, 0.09428041f, 
    0.08057769f, 0.59014928f, -0.02553599f, -0.20386036f, -0.22260025f, -0.05870488f, -0.38285276f, 0.05342870f, 
    0.05543634f, 0.11444170f, 0.24601284f, 0.12163478f, -0.07432683f, -0.16175894f, -0.13682753f, -0.07536565f, 
    -0.24413623f, 0.08817384f, 0.04241396f, 0.38297230f, -0.23807706f, -0.53495336f, -0.31452125f, -0.01201827f, 
    -0.17265281f, 0.07406838f, -0.00164116f, 0.06510580f, 0.19821088f, 0.16425985f, -0.07267325f, -0.05855662f, 
    0.08646111f, -0.06482586f, 0.10616967f, -0.06518470f, 0.20641556f, -0.51053423f, -0.45800832f, -0.26819691f, 
    -0.04696142f, 0.09198601f, 0.12236925f, -0.27954665f, 0.00831631f, 0.07596580f, -0.05435234f, 0.09284839f, 
    0.09820432f, -0.06070373f, 0.04944604f, -0.05633495f, -0.06749569f, -0.01532409f, 0.27148300f, -0.21564016f, 
    0.22200687f, 0.12957305f, -0.07387064f, -0.12360766f, -0.10719652f, -0.13656163f, -0.01987993f, 0.12841424f, 
    0.15914364f, -0.28519523f, 0.30924803f, 0.17161924f, 0.17725143f, 0.00795501f, 0.18490633f, -0.04125827f, 
    -0.09536972f, 0.32406670f, 0.12092900f, 0.02323568f, 0.11242597f, 0.06573963f, 0.12603030f, 0.02721245f, 
    0.08027896f, -0.00914860f, -0.47169626f, -0.47185159f, -0.26539230f, 0.24071282f, 0.04177300f, 0.15958813f, 
    0.31484872f, -0.27469492f, -0.17565705f, -0.10614192f, -0.07741923f, -0.03490977f, 0.04987940f, -0.01030737f, 
    -0.09732932f, -0.05838758f, -0.01321456f, 0.06975468f, 0.16600800f, 0.25360319f, -0.01603638f, -0.10662683f, 
    0.01591222f, 0.12335154f, 0.08646399f, 0.03614158f, -0.01573184f, 0.35135520f, -0.37286815f, -0.16165577f, 
    -0.06537958f, 0.12544975f, 0.00148876f, -0.03139810f, 0.02745456f, 0.14897300f, -0.52980071f, -0.73390496f, 
    -0.11835590f, -0.09720499f, 0.07893936f, 0.01657288f, 0.04127857f, 0.23431557f, 0.00343169f, -0.01652534f, 
    -0.09069078f, -0.24321322f, 0.02087910f, -0.06500228f, -0.07178406f, 0.06283320f, -0.14310145f, -0.20297281f, 
    0.38066378f, 0.16637425f, -0.10751205f, -0.08741477f, -0.14828685f, -0.04732556f, -0.02750489f, -0.06264492f, 
    -0.03009182f, -0.42376423f, 0.24511936f, -0.33205226f, -0.00481702f, 0.13427840f, -0.04754711f, -0.06382807f, 
    0.02471976f, -0.09055680f, 0.39606369f, -0.02333268f, 0.10850876f, -0.00231335f, -0.05502928f, 0.09774277f, 
    -0.07129575f, 0.06257725f, 0.01538996f, 0.48078993f, 0.15929815f, 0.05323976f, -0.08083364f, 0.04639144f, 
    -0.01227985f, 0.00286571f, -0.02848381f, -0.03147443f, -0.25394675f, -0.18175486f, -0.32582968f, -0.16859418f, 
    -0.03215018f, -0.32049134f, 0.10279599f, -0.06611644f, 0.12245286f, -0.21285804f, -0.09875484f, -0.09070869f, 
    -0.08834317f, 0.12092043f, 0.15891302f, 0.22139892f, 0.09926275f, 0.09598510f, -0.09498044f, -0.08932126f, 
    -0.43564391f, 0.07803000f, 0.04351969f, -0.04202089f, -0.04536599f, 0.09524649f, 0.16997594f, 0.01510301f, 
    -0.04786023f, 0.05140084f, 0.04107006f, 0.08076530f, -0.03123703f, 0.12030707f, 0.10887235f, -0.03545903f, 
    0.20291407f, -0.14311396f, -0.24493191f, -0.33467588f, -0.16367111f, -0.02227950f, 0.04696938f, 0.04510286f, 
    -0.09344688f, -0.35293841f, -0.14437288f, 0.19588508f, -0.00555459f, 0.22076410f, -0.10323684f, 0.04387632f, 
    -0.08820160f, 0.12196974f, -0.17470691f, 0.12018569f, 0.11389115f, -0.23337287f, 0.03989979f, 0.07228656f, 
    0.27956739f, 0.12311759f, 0.03519264f, -0.18351959f, -0.09660191f, -0.27771586f, -0.14071234f, 0.11842074f, 
    -0.07684381f, 0.06839599f, 0.08671456f, -0.03406588f, 0.09176199f, 0.04573225f, 0.01637508f, -0.07881854f, 
    0.09868055f, -0.00830111f, 0.03568156f, -0.08558551f, 0.19407581f, -0.11399731f, 0.06945470f, -0.12954696f, 
    -0.17310452f, 0.20557687f, -0.24781981f, 0.14026332f, 0.03399583f, 0.02448627f, 0.43503240f, 0.13425684f, 
    -0.15429203f, -0.17528015f, -0.12248661f, 0.01334708f, -0.05937660f, 0.10885585f, 0.08085021f, 0.32934088f, 
    0.08851455f, 0.02870814f, -0.04201438f, -0.24167353f, -0.29117277f, -0.00506835f, -0.08355269f, -0.13536702f, 
    0.15657136f, 0.26166803f, 0.33665678f, 0.08488817f, 0.03847457f, 0.16280502f, -0.02855788f, 0.02170023f, 
    -0.00574312f, -0.33378056f, 0.07663142f, 0.24398725f, 0.02923792f, 0.14826004f, 0.00108629f, 0.03778726f, 
    0.02486148f, 0.06736765f, 0.10718397f, 0.16209491f, 0.30002695f, -0.00167470f, -0.04430053f, 0.07792529f, 
    0.13410459f, -0.07678035f, 0.07216384f, 0.20982763f, 0.03361528f, -0.17459093f, 0.05801840f, 0.06110887f, 
    0.08070951f, 0.05883896f, 0.25499734f, 0.09238620f, -0.09583011f, 0.05874351f, 0.00061317f, -0.08608957f, 
    0.02217175f, -0.12944612f, 0.17408502f, 0.07756703f, -0.11297953f, 0.11935525f, 0.01567605f, -0.01515419f, 
    -0.20171496f, -0.32456049f, -0.14519885f, 0.08134436f, -0.06681778f, -0.19230750f, 0.01147760f, 0.19770056f, 
    -0.01198443f, 0.00776780f, -0.25286421f, -0.03430441f, -0.03325322f, 0.03131978f, -0.23816608f, 0.15005280f, 
    0.05887582f, 0.18479025f, 0.08515367f, 0.05560946f, 0.09414536f, -0.17644343f, -0.12374394f, 0.19285920f, 
    -0.09969824f, 0.18754993f, 0.07929026f, 0.16604154f, 0.16549668f, -0.01547491f, -0.19316481f, -0.13335530f, 
    -0.24835345f, -0.01894829f, 0.02714561f, 0.09917255f, -0.03920355f, 0.06938026f, 0.16204359f, 0.04292541f, 
    -0.20998722f, 0.11653348f, 0.00006770f, 0.03225625f, -0.10792723f, 0.00963195f, 0.12618174f, -0.10285906f, 
    0.18985224f, -0.39466304f, -0.14416271f, 0.02712846f, -0.15190695f, 0.16202180f, 0.09907519f, 0.06440325f, 
    -0.00525634f, 0.00374998f, 0.04093254f, 0.12166280f, 0.12345050f, 0.22173028f, 0.23340878f, 0.05959918f, 
    -0.17158024f, -0.02642830f, -0.13341132f, -0.09005465f, 0.03412060f, 0.14388986f, -0.11967397f, -0.15552938f, 
    -0.01993479f, -0.00332980f, 0.04599370f, 0.14091726f, -0.04630864f, -0.12110999f, 0.16089411f, 0.22241084f, 
    0.17889109f, 0.19939511f, -0.00983126f, 0.12891658f, 0.03594843f, -0.00204173f, 0.03228225f, 0.08082041f, 
    0.15486600f, 0.05144334f, 0.13117458f, -0.00211821f, 0.14232145f, -0.09617244f, 0.02321154f, 0.05527513f, 
    0.12619494f, 0.10632575f, 0.21181394f, 0.09198477f, -0.03500691f, 0.03231063f, 0.02236544f, 0.04858510f, 
    0.09131550f, -0.13443077f, 0.01436979f, -0.11466301f, -0.20142141f, -0.19833726f, -0.03952445f, 0.03692422f, 
    0.05307575f, -0.10507448f, 0.05171425f, 0.06796132f, 0.14923489f, -0.09168681f, 0.04517783f, 0.05062081f, 
    -0.00001474f, -0.27144980f, 0.15683286f, 0.15028709f, 0.19958724f, 0.15435129f, 0.11708194f, -0.01071824f, 
    -0.00624982f, 0.14395286f, -0.04556672f, 0.03572499f, 0.14088808f, -0.15890238f, -0.22534257f, 0.01304461f, 
    -0.03619915f, 0.08205973f, -0.25365898f, 0.07315854f, -0.17406386f, 0.13677269f, 0.13851877f, 0.20289063f, 
    -0.16328262f, -0.20061858f, -0.10304336f, -0.02584941f, -0.15564336f, -0.08519378f, -0.06871600f, 0.39554429f, 
    0.15444468f, 0.05066903f, -0.11125740f, -0.10818558f, 0.05660069f, 0.13741250f, -0.04372205f, 0.15378721f, 
    0.01848249f, 0.06244508f, -0.02484583f, -0.02717362f, -0.02891148f, -0.15774736f, -0.01533879f, -0.05838367f, 
    0.14798121f, 0.34073871f, -0.13748600f, -0.00089676f, 0.04120009f, -0.09361313f, -0.02790390f, 0.05012616f, 
    0.12618901f, -0.09654392f, -0.29189390f, -0.35183823f, -0.10300262f, -0.02314755f, 0.03545639f, 0.01136222f, 
    -0.23709098f, -0.06031514f, -0.19903968f, -0.08802480f, 0.12268221f, 0.12965414f, 0.03740688f, -0.08760269f, 
    -0.00089910f, -0.13266097f, -0.01469759f, 0.13540661f, 0.09346442f, -0.20222755f, -0.29540727f, 0.10616086f, 
    0.09016297f, 0.08570973f, -0.01128872f, 0.06017508f, 0.03478300f, 0.10289820f, 0.10966472f, 0.15461040f, 
    0.00033654f, 0.09064852f, -0.05688795f, -0.07616770f, 0.07877049f, -0.18935332f, 0.29101521f, 0.05621289f, 
    -0.08611185f, -0.02574123f, -0.05349825f, 0.06112539f, 0.07329595f, -0.08371881f, 0.06432847f, -0.19963180f, 
    0.29423773f, 0.01560798f, 0.05174296f, 0.05799842f, 0.06469987f, 0.02199247f, 0.12592116f, 0.11728417f, 
    0.02307824f, 0.08086006f, 0.10968262f, 0.06948898f, 0.05678565f, 0.00353992f, -0.03926490f, -0.04739640f, 
    -0.11088777f, -0.12180949f, -0.01522312f, 0.18543442f, -0.00318027f, -0.12783121f, -0.02799860f, 0.07981925f, 
    0.04460642f, 0.17316152f, -0.09551372f, 0.25460699f, 0.02629215f, 0.04428656f, 0.06269152f, -0.09312972f, 
    -0.07875267f, -0.08538064f, -0.01338264f, -0.02808428f, -0.03020113f, -0.03293068f, -0.17374744f, -0.02603248f, 
    -0.19769341f, -0.01327367f, -0.03926979f, -0.46440244f, -0.05537687f, -0.22701527f, -0.46280968f, -0.47095144f, 
    0.03951652f, 0.07575955f, 0.04038594f, 0.07409371f, -0.32616517f, -0.05599003f, 0.08012471f, 0.02351883f, 
    -0.15420288f, -0.03337472f, 0.21793097f, 0.15828006f, 0.13071929f, -0.01905849f, 0.53303021f, 0.35102135f, 
    -0.14088863f, -0.17508465f, 0.02295088f, -0.22890431f, -0.06108858f, -0.06015368f, 0.52136368f, 0.27859285f, 
    -0.02411280f, 0.07529812f, -0.04653206f, 0.02513530f, 0.29218322f, 0.24795038f, 0.25865880f, 0.26567426f, 
    0.00201611f, 0.11307062f, -0.03536973f, 0.03188736f, 0.00378772f, -0.08716738f, 0.06532676f, 0.00324734f, 
    -0.23908940f, -0.09896228f, -0.16265588f, 0.14452948f, 0.00425757f, -0.00519788f, 0.07430086f, -0.14128305f, 
    -0.01471406f, -0.01468241f, 0.10941380f, -0.26229015f, 0.04581441f, 0.03802418f, 0.09491272f, 0.08120893f, 
    -0.00564724f, -0.02545069f, 0.00414143f, -0.10908647f, -0.22885461f, -0.08659379f, -0.05751126f, 0.04821729f, 
    -0.01176487f, 0.03467570f, -0.10163906f, 0.10542313f, 0.11443594f, -0.08751123f, -0.11155230f, 0.04777844f, 
    -0.02227609f, -0.08422872f, -0.03857540f, -0.15628323f, 0.03942486f, 0.03079952f, 0.09499802f, 0.03513229f, 
    0.06806248f, -0.07644103f, -0.05926888f, 0.16748989f, 0.00102941f, -0.41441974f, 0.18121581f, 0.12202022f, 
    -0.14158356f, -0.11723071f, -0.00180653f, -0.08749441f, 0.05388512f, 0.05318137f, -0.00927163f, 0.05182812f, 
    -0.03363172f, -0.31277323f, -0.15366820f, -0.36774775f, -0.18965082f, 0.01367887f, -0.04378733f, 0.29161954f, 
    0.10279167f, -0.00292895f, -0.09022315f, 0.02743636f, 0.07356743f, 0.18906558f, 0.00712551f, 0.15011491f, 
    0.05255047f, 0.02476314f, 0.07436679f, -0.00813081f, 0.03739467f, 0.09977838f, 0.01966847f, -0.00990608f, 
    -0.04943356f, 0.05403271f, -0.06320917f, 0.02639060f, -0.42708096f, -0.21190718f, 0.06937732f, 0.21456814f, 
    -0.03097386f, 0.08756341f, 0.00694200f, -0.03900370f, -0.05412553f, -0.04845354f, 0.12134318f, 0.06670113f, 
    0.11331859f, 0.00979830f, -0.01748414f, -0.07514383f, -0.06283145f, -0.01939419f, 0.12212275f, 0.06337994f, 
    -0.00826017f, -0.00496436f, 0.01354583f, -0.06710435f, -0.07421349f, -0.20547314f, -0.41417176f, -0.32942218f, 
    -0.06905182f, -0.03464891f, 0.02518145f, 0.04805688f, 0.04347990f, 0.19261201f, 0.04131435f, 0.00410137f, 
    -0.12950468f, -0.11570928f, 0.05492401f, 0.08660298f, 0.02566296f, 0.07392637f, -0.51192421f, -0.32789427f, 
    0.06970594f, -0.07935852f, -0.20330153f, -0.00270163f, 0.27024403f, -0.07137019f, -0.22301170f, 0.03765901f, 
    0.04976489f, 0.23047048f, 0.09771496f, 0.09623670f, 0.14316793f, 0.19175519f, -0.02372620f, 0.02157416f, 
    -0.59441936f, 0.04483715f, -0.16466774f, -0.45582965f, -0.53178388f, -0.21604301f, 0.04342645f, -0.04667690f, 
    0.05800590f, -0.09020267f, 0.14197858f, -0.43428323f, 0.06633673f, -0.15993607f, -0.04475480f, -0.00459255f, 
    0.14755054f, 0.11305466f, -0.21167721f, -0.40400994f, 0.11992501f, 0.13908325f, 0.06574381f, 0.03442426f, 
    -0.07023101f, 0.00444237f, -0.04176997f, 0.01459008f, 0.30819234f, 0.15600477f, -0.16763249f, 0.03502033f, 
    -0.00426371f, -0.07632707f, 0.04299111f, -0.04286478f, 0.05945464f, 0.07174110f, 0.35064095f, 0.05293326f, 
    0.07701588f, 0.00661280f, -0.05021662f, -0.02636142f, -0.00888447f, -0.15103312f, -0.17864557f, -0.26805180f, 
    0.04210220f, -0.19099531f, -0.14547022f, 0.00519932f, 0.11944041f, 0.05661382f, -0.09055646f, -0.32686159f, 
    0.32236788f, 0.19664657f, 0.03083359f, 0.03917919f, -0.01958506f, -0.00282067f, 0.02885111f, 0.08528816f, 
    -0.00148008f, -0.04610833f, 0.04930846f, 0.05305251f, 0.12056533f, 0.00193597f, -0.11945397f, -0.09293047f, 
    -0.39447299f, -0.70673883f, 0.05370987f, 0.13121204f, 0.10667709f, -0.14160018f, -0.00033589f, 0.04825266f, 
    -0.01586516f, -0.06765269f, -0.33854234f, -0.24883643f, -0.18345937f, 0.11561240f, -0.10932157f, -0.14310208f, 
    -0.06660260f, -0.17967770f, -0.22947015f, -0.05998549f, -0.13701089f, 0.08933497f, -0.25829002f, 0.17222545f, 
    0.20889246f, 0.10635771f, 0.04169070f, 0.18117398f, 0.05847529f, 0.30469844f, -0.13101842f, 0.01282949f, 
    0.03034499f, 0.13334569f, -0.07603520f, 0.00640774f, -0.19039144f, -0.13708436f, 0.05348476f, -0.01059448f, 
    -0.03607796f, 0.14208539f, 0.15048745f, 0.08949401f, -0.14147106f, 0.14409105f, -0.59905761f, 0.09474660f, 
    -0.08811534f, -0.03493600f, 0.17047466f, -0.03924527f, 0.01608634f, -0.06065141f, 0.02796237f, -0.04470798f, 
    0.02136687f, 0.01446774f, 0.09838410f, 0.03881334f, 0.08413042f, 0.04140167f, -0.05822244f, 0.03486191f, 
    -0.02534952f, -0.42712101f, -0.11567685f, -0.06028145f, -0.03003057f, 0.17044733f, -0.25976118f, -0.13541879f, 
    -0.44933754f, -0.47761497f, -0.13273183f, 0.06026299f, -0.08459865f, 0.14798839f, 0.26860845f, 0.20129067f, 
    -0.02500153f, 0.26894355f, -0.23479408f, -0.19735932f, -0.08230776f, 0.10058872f, 0.19490066f, 0.10717092f, 
    -0.04658821f, -0.06884575f, 0.01922729f, -0.14200583f, -0.68803912f, -0.04141152f, -0.09957007f, 0.18416207f, 
    -0.06355662f, 0.29705799f, 0.06602211f, 0.12791921f, 0.10232422f, 0.21220540f, -0.12970646f, 0.10768512f, 
    0.02036615f, 0.07336945f, 0.01359673f, 0.01507253f, -0.03939031f, -0.33707318f, -0.15865184f, -0.07034986f, 
    0.00695193f, 0.22587554f, 0.01824208f, 0.19048993f, 0.02035420f, 0.23537421f, -0.10898528f, 0.06217418f, 
    0.04016988f, -0.05292607f, 0.07919521f, 0.08941372f, 0.08312396f, 0.00932194f, -0.10157337f, 0.19082576f, 
    0.30404562f, -0.16061246f, 0.08647814f, -0.17179628f, 0.04973855f, 0.05282556f, 0.01508472f, 0.30384615f, 
    -0.04930704f, -0.24477522f, -0.14285655f, 0.06026212f, -0.04856326f, 0.12624717f, 0.06287501f, 0.14409547f, 
    -0.04434134f, -0.46153191f, -0.32513404f, -0.03554354f, 0.03694523f, 0.05504815f, 0.10636801f, 0.13022713f, 
    0.19245732f, -0.37803638f, -0.65107834f, 0.03563264f, 0.00947030f, 0.17763063f, 0.17028399f, 0.13093252f, 
    0.09193397f, 0.07073526f, 0.10741441f, -0.19925337f, -0.32881999f, -0.10090220f, 0.08513870f, 0.21458571f, 
    0.00389941f, -0.03608115f, -0.02200457f, -0.37660515f, -0.64596617f, -0.02752699f, 0.13500378f, 0.05545687f, 
    0.09511623f, 0.04956032f, -0.02765198f, 0.07666544f, 0.10422409f, 0.13458051f, 0.31650284f, -0.03577034f, 
    0.05161820f, 0.05514150f, 0.17062037f, -0.06136101f, -0.13589746f, -0.02719531f, -0.17758065f, -0.39692163f, 
    -0.21541084f, -0.23062721f, 0.15265131f, 0.13899815f, 0.18123423f, 0.04186329f, -0.68925118f, -0.40872735f, 
    -0.08224250f, -0.15358138f, -0.01527121f, -0.20932801f, 0.04961954f, -0.03353091f, -0.04786066f, -0.15277158f, 
    -0.21275726f, 0.02557545f, 0.06617323f, 0.02104992f, 0.06411239f, -0.02034405f, 0.02136992f, -0.15342072f, 
    0.17008527f, 0.03249560f, 0.09262715f, -0.06595445f, 0.13174076f, 0.18632895f, 0.16298816f, 0.12654750f, 
    0.02761180f, -0.04711796f, -0.11956526f, -0.07508924f, -0.00229602f, -0.05567190f, -0.01080576f, 0.11390183f, 
    0.00629944f, -0.02522791f, -0.12705545f, 0.11440700f, 0.14159590f, -0.13745224f, -0.07594643f, 0.04629537f, 
    0.12888657f, -0.04591062f, -0.19978210f, 0.42656764f, 0.25461993f, 0.31335047f, -0.18571952f, -0.14579828f, 
    -0.08241961f, 0.05894215f, 0.06344128f, 0.17132157f, -0.21408623f, 0.01487642f, -0.24685356f, 0.03767536f, 
    -0.25090823f, 0.13875420f, 0.10881671f, -0.06623216f, -0.13700528f, 0.14464934f, 0.06899825f, -0.06210322f, 
    0.00703474f, 0.12859558f, 0.19763975f, -0.11663378f, -0.00319566f, -0.11918050f, 0.29866216f, 0.16903980f, 
    -0.37655044f, 0.07012291f, -0.07875730f, -0.00050615f, 0.05345977f, -0.10567714f, -0.05027103f, 0.01188290f, 
    -0.18180342f, 0.09004000f, -0.09302359f, 0.07978027f, 0.02435737f, 0.11469159f, -0.03203095f, -0.01891137f, 
    0.15852910f, 0.25230271f, 0.00636526f, 0.03420515f, 0.15532808f, -0.09338723f, 0.13777827f, -0.11756941f, 
    -0.08241776f, -0.16012794f, -0.04715705f, 0.02042279f, -0.00242413f, 0.06806776f, -0.03127364f, -0.08734378f, 
    -0.01883001f, -0.02828307f, 0.07570135f, 0.17830788f, -0.07494434f, 0.00359261f, 0.06475996f, -0.07099015f, 
    0.17840074f, 0.10743654f, 0.06744228f, 0.09584992f, 0.03385111f, 0.14610517f, 0.00110024f, 0.07547148f, 
    0.13389795f, 0.13449745f, 0.00984817f, 0.02121728f, -0.24316514f, 0.08976749f, 0.23720078f, 0.07220573f, 
    -0.02353832f, -0.00154496f, -0.00613883f, 0.01041913f, -0.38045967f, 0.45533165f, -0.23921429f, -0.02767956f, 
    -0.12250402f, -0.08236462f, -0.12106320f, -0.01969454f, 0.05215002f, 0.00364443f, 0.01920184f, 0.11975393f, 
    -0.01676907f, 0.03931039f, 0.20957954f, 0.10581086f, -0.09403025f, -0.16364902f, -0.22858849f, 0.08082578f, 
    0.10097814f, -0.01538839f, 0.19016361f, 0.10960498f, -0.01218266f, -0.00468629f, -0.19611329f, -0.30487642f, 
    0.07284599f, 0.06350932f, 0.32996711f, 0.28009436f, -0.13877787f, -0.11204300f, 0.08973885f, 0.15519798f, 
    0.11362495f, 0.02646438f, 0.01442967f, 0.11317767f, -0.17794493f, 0.20189460f, -0.10467827f, -0.00186588f, 
    -0.18124966f, -0.09462935f, 0.17550623f, 0.35416043f, 0.05905227f, 0.15642135f, 0.34977663f, -0.00456389f, 
    -0.04795889f, 0.26386440f, 0.16314645f, -0.09505688f, 0.20555213f, 0.23702687f, -0.06181877f, 0.16830462f, 
    0.06248057f, 0.05609314f, -0.06039334f, -0.04782763f, 0.04631979f, -0.01250492f, 0.06036180f, -0.00021525f, 
    -0.12476353f, -0.19357094f, -0.00169976f, -0.04145375f, 0.01889835f, 0.19848078f, -0.12215725f, -0.18213154f, 
    -0.10814696f, -0.10011182f, 0.05645119f, 0.02830641f, 0.05538887f, -0.06096623f, -0.27099368f, -0.00765918f, 
    0.32974964f, 0.06298826f, 0.13187675f, 0.11753342f, -0.06260133f, 0.10286319f, 0.00377061f, -0.03411188f, 
    0.27356556f, -0.02400941f, -0.22838157f, 0.06225468f, -0.06942619f, -0.04199848f, 0.12089451f, 0.01761883f, 
    0.03928781f, 0.10728770f, 0.04719738f, -0.16273156f, -0.02127841f, -0.15235589f, 0.07022564f, 0.02654239f, 
    -0.02672190f, 0.02390135f, -0.32621384f, -0.04481780f, -0.16052121f, -0.02881973f, 0.03491769f, 0.06520046f, 
    -0.08136097f, -0.12009788f, 0.16739382f, 0.01666210f, -0.17469381f, -0.15783431f, 0.23541312f, -0.06288557f, 
    0.02318477f, -0.12186996f, -0.23801114f, 0.06829729f, 0.07553284f, 0.08321606f, 0.09027380f, -0.06979234f, 
    0.05119772f, -0.03858643f, -0.22210428f, -0.01054696f, -0.00524977f, -0.01789249f, 0.01167972f, 0.09353301f, 
    0.12741071f, 0.02307343f, 0.11870261f, -0.00846153f, -0.22665609f, 0.12413912f, 0.07867294f, 0.06271874f, 
    -0.11637043f, -0.14837259f, -0.08989246f, -0.08775899f, 0.08840119f, 0.00884545f, 0.23346987f, 0.12396301f, 
    0.19538571f, 0.02499111f, -0.07507591f, 0.12102164f, 0.10322555f, -0.08500830f, -0.10821906f, 0.09236321f, 
    0.11403742f, 0.08411131f, 0.11342175f, -0.07069113f, 0.06708398f, -0.21948965f, -0.08285286f, -0.21848126f, 
    0.11729784f, -0.02642002f, 0.25946689f, -0.02640774f, 0.14021930f, 0.15183896f, 0.23327544f, -0.02858146f, 
    0.16958173f, -0.05686131f, 0.21253228f, -0.17980608f, -0.13810469f, -0.00994114f, -0.07669413f, -0.13438073f, 
    0.03983611f, -0.13437377f, -0.01616927f, 0.03304517f, 0.06351008f, 0.08587994f, -0.00861188f, -0.07502235f, 
    -0.23715352f, 0.01693641f, -0.11424699f, 0.07536887f, -0.02506028f, -0.12099656f, -0.07644753f, -0.08105673f, 
    0.00280486f, 0.04356093f, -0.01293442f, -0.02006409f, 0.07955557f, 0.03216757f, 0.02669518f, 0.13306127f, 
    -0.04393820f, -0.06560697f, -0.28889120f, 0.10870477f, -0.27112302f, -0.05666697f, 0.07889836f, 0.17787313f, 
    -0.05651273f, 0.02519196f, -0.00156079f, -0.04430983f, -0.04221399f, 0.01887819f, 0.03941145f, 0.07666413f, 
    -0.23648700f, -0.00476814f, 0.12828526f, -0.03928913f, 0.01721554f, -0.01377200f, 0.08153823f, 0.07068774f, 
    0.30037579f, -0.08511207f, -0.10061304f, -0.12048380f, -0.02236501f, -0.06727388f, -0.04319292f, -0.06398355f, 
    0.16851579f, 0.14361644f, -0.37369207f, -0.02285082f, -0.04364061f, 0.23123914f, -0.05785490f, -0.19284800f, 
    0.05521477f, 0.05664495f, -0.28526723f, -0.00735368f, 0.01918034f, 0.16055979f, -0.02268066f, 0.15553766f, 
    0.04500403f, -0.13161401f, 0.09918336f, 0.38917246f, -0.14170158f, 0.14141953f, -0.05225714f, -0.21728417f, 
    0.11350787f, 0.02152720f, 0.09835503f, 0.03329869f, 0.08401778f, 0.30639005f, -0.25792184f, -0.08210365f, 
    0.01246991f, -0.27938339f, -0.03729291f, -0.09202155f, 0.01144798f, -0.33368313f, 0.21571487f, -0.03856238f, 
    -0.05217177f, 0.21393861f, 0.19330679f, -0.13319351f, 0.02393681f, -0.06668416f, -0.07387035f, -0.30121464f, 
    -0.00758049f, 0.07275668f, 0.14759830f, -0.11888948f, -0.02911245f, 0.29642233f, -0.21606794f, 0.00097015f, 
    -0.12008360f, 0.04590067f, -0.17231429f, 0.12849706f, 0.04134262f, 0.01148929f, 0.28089219f, 0.01177749f, 
    0.20474164f, -0.31281307f, 0.05144897f, -0.15037258f, -0.03851118f, 0.12856205f, 0.01960292f, 0.13510945f, 
    -0.58468789f, 0.07744760f, -0.07848158f, -0.02990963f, -0.10955455f, 0.18031831f, 0.01214585f, -0.04914891f, 
    0.14827511f, 0.30601299f, 0.26142985f, -0.26072744f, 0.07302357f, 0.08093509f, 0.16479476f, -0.02727233f, 
    0.06470847f, -0.04133048f, 0.04041074f, 0.25959736f, -0.01990850f, -0.11311606f, -0.41889560f, 0.19025734f, 
    -0.16566670f, -0.11341973f, 0.13854437f, -0.03566499f, -0.00317147f, 0.14748999f, 0.07316294f, -0.13232255f, 
    0.12501787f, 0.01510372f, -0.15008363f, -0.04363154f, 0.00595800f, -0.03822983f, -0.30907249f, 0.08061212f, 
    -0.03355676f, 0.11509567f, -0.05049460f, 0.05566257f, 0.05082188f, -0.04506510f, -0.12903322f, 0.23890005f, 
    -0.01311296f, -0.03960128f, -0.02022187f, -0.24431810f, -0.02549127f, 0.05270584f, 0.20135416f, -0.02474127f, 
    0.13446489f, -0.01367841f, -0.00025683f, -0.12603804f, 0.14525694f, -0.06498298f, 0.02876934f, 0.17918427f, 
    0.13910386f, 0.03152197f, -0.00029750f, -0.12610762f, -0.17348464f, -0.18212490f, -0.24602424f, -0.29062951f, 
    -0.07549591f, 0.00518384f, -0.07604162f, 0.06411267f, 0.03800605f, -0.02731466f, -0.10428195f, -0.24717647f, 
    -0.17158180f, -0.12030305f, -0.38886806f, -0.40719822f, -0.17015128f, 0.35114858f, 0.30971387f, 0.09104859f, 
    -0.08677068f, 0.30831891f, 0.30367243f, 0.23705746f, -0.52632099f, 0.06060600f, -0.07898741f, 0.05134689f, 
    0.09979973f, -0.02553855f, -0.16247220f, 0.11082285f, -0.09720702f, -0.32388318f, 0.01073035f, -0.10654748f, 
    0.18600228f, 0.01301633f, 0.00799112f, -0.15894347f, 0.06639226f, 0.22998290f, 0.21650662f, -0.03213687f, 
    0.09977588f, 0.07473525f, -0.10176111f, 0.07246409f, -0.06430927f, -0.00016666f, -0.08545602f, -0.42806622f, 
    -0.01055912f, 0.05355720f, -0.05710162f, -0.07516704f, -0.12646510f, 0.06337170f, -0.23264214f, 0.33316004f, 
    0.01231134f, -0.05514382f, -0.12367388f, -0.06441946f, 0.25348148f, 0.02285648f, 0.24129833f, 0.06580729f, 
    -0.25609693f, 0.06715569f, 0.06206212f, -0.18571994f, 0.16493295f, 0.07291550f, -0.13241316f, -0.03914555f, 
    0.20103474f, 0.11812155f, 0.23843949f, -0.14350069f, -0.05687251f, -0.16400361f, -0.17848870f, -0.08340394f, 
    -0.10788295f, -0.05266780f, 0.05663105f, 0.02358957f, 0.03166898f, 0.06522813f, -0.02950801f, -0.04829121f, 
    0.11620454f, 0.06945103f, -0.19493155f, -0.06234817f, 0.19265282f, -0.14829952f, -0.06051721f, -0.04813711f, 
    0.00317792f, -0.00529345f, 0.13651946f, 0.05175877f, -0.00849637f, 0.11423451f, 0.14414304f, -0.11178590f, 
    -0.07813028f, -0.05993896f, -0.01699495f, -0.17045933f, -0.06277121f, -0.15239322f, -0.04080273f, 0.12242485f, 
    -0.14272404f, -0.18176706f, 0.04147446f, -0.10649406f, 0.01632526f, 0.12082326f, 0.02585215f, 0.05893075f, 
    0.03613404f, -0.02836639f, 0.17877048f, 0.09845165f, -0.00295021f, 0.06813467f, 0.36918300f, 0.26076761f, 
    -0.07502273f, 0.26295850f, -0.03558337f, -0.25388768f, -0.03558067f, 0.14024730f, 0.10977470f, -0.16853100f, 
    -0.00868325f, 0.17356403f, 0.09732696f, 0.09439199f, -0.02044082f, -0.17822655f, -0.15091808f, -0.10127340f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.31315085f, 0.15676807f, 0.19382426f, 0.04237465f, -0.09065515f, -0.02670408f, 0.05799553f, -0.01579403f, 
    -0.02359982f, -0.05104821f, 0.13009083f, 0.03977712f, -0.20082292f, 0.03054732f, 0.09607089f, 0.12380756f, 
    0.15842552f, 0.01450185f, 0.11018264f, 0.17489178f, 0.11707390f, 0.00037216f, 0.03568671f, 0.04084666f, 
    0.29651484f, 0.30955434f, 0.14370258f, -0.10588227f, 0.32758775f, 0.09535422f, -0.07929366f, -0.03243714f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.12217367f, -0.03701333f, 0.08597784f, -0.22091973f, -0.09907560f, -0.01143432f, -0.04201616f, 0.08504789f, 
    -0.07413068f, -0.07847900f, -0.15390827f, 0.17941476f, -0.18748704f, 0.05642657f, 0.24197567f, 0.35467625f, 
    -0.03913932f, -0.02801940f, 0.36672828f, 0.50202239f, 0.31390476f, -0.01560985f, -0.21753921f, 0.11722617f, 
    0.10600565f, 0.13764770f, -0.17625864f, 0.06050826f, 0.22953005f, 0.51915199f, 0.09063551f, 0.38548273f, 
    0.03157557f, -0.03530205f, -0.03363957f, 0.13753681f, -0.54749984f, -0.08473980f, -0.17365299f, -0.00863075f, 
    -0.17077236f, -0.05792432f, -0.09986233f, 0.27056029f, -0.22283679f, -0.10615773f, 0.11276454f, 0.09250385f, 
    0.06897466f, 0.00269483f, -0.27796042f, 0.37889737f, -0.10245337f, 0.16741291f, 0.02290606f, -0.07255442f, 
    0.16491570f, -0.25387537f, 0.08458946f, 0.10443445f, 0.06534921f, 0.34972695f, 0.21529129f, 0.22790365f, 
    -0.01401580f, 0.10786721f, -0.16943583f, 0.00552817f, -0.47730044f, 0.28966755f, 0.58051568f, 0.13775285f, 
    -0.03756498f, 0.37295699f, 0.05884152f, -0.50975996f, 0.04246968f, -0.05898473f, 0.01144553f, -0.29788572f, 
    0.30118880f, -0.11809606f, -0.18009862f, -0.14865744f, -0.42504048f, 0.28941831f, 0.45829913f, 0.02780197f, 
    0.24059264f, 0.23692569f, 0.03847275f, -0.20038198f, -0.04161381f, -0.24077757f, -0.27016014f, 0.05981049f, 
    0.09819385f, -0.10907789f, -0.20713452f, -0.11958765f, -0.15724739f, 0.00197371f, -0.05507099f, 0.17435715f, 
    -0.01156199f, -0.06392669f, -0.18575454f, 0.00723992f, -0.13739155f, 0.14202967f, 0.01382291f, -0.16504577f, 
    0.02696037f, 0.03638693f, -0.02724141f, -0.17878476f, 0.05830161f, -0.09785818f, -0.05468367f, 0.04243108f, 
    0.01859942f, 0.11322946f, -0.03275343f, -0.10169710f, 0.13452372f, -0.02252583f, -0.02067271f, 0.01465304f, 
    -0.16302210f, -0.20833072f, 0.36078748f, 0.17238134f, 0.62240338f, 0.09550255f, -0.05773651f, 0.12464738f, 
    -0.12549524f, 0.05076273f, 0.05860580f, 0.03426749f, -0.06093287f, 0.16944474f, 0.21139748f, -0.04655413f, 
    -0.15853496f, 0.14822951f, 0.51483959f, 0.02480775f, 0.13412851f, -0.00821545f, 0.26591361f, 0.44771826f, 
    -0.17393845f, -0.31557313f, -0.32655048f, 0.16823547f, -0.18914847f, 0.07970045f, 0.01798542f, -0.08703890f, 
    -0.53585404f, 0.05318415f, -0.51832598f, -0.34412158f, 0.12668662f, 0.20730045f, 0.13376011f, 0.08167130f, 
    -0.03200917f, 0.22597419f, -0.16767937f, -0.06270322f, 0.05721526f, -0.15919006f, 0.26768664f, 0.12827674f, 
    0.14665155f, -0.17258927f, -0.11563741f, 0.42065659f, 0.17749028f, 0.21971700f, -0.49886870f, 0.49135619f, 
    -0.19298063f, -0.03679250f, -0.44893473f, 0.03268819f, 0.45779675f, 0.37003493f, -0.06230458f, -0.16562329f, 
    0.41818416f, 0.17953186f, -0.25613853f, -0.30917436f, -0.55231571f, -0.06982957f, 0.26746222f, -0.02962738f, 
    -0.05872458f, -0.15494835f, 0.37776437f, 0.17693903f, -0.15622213f, -0.10142936f, -0.40455994f, 0.03249912f, 
    0.20754935f, 0.16366839f, 0.04487729f, 0.58860922f, 0.15523511f, -0.13760793f, 0.33968511f, -0.20716004f, 
    0.38410306f, -0.18844333f, 0.00814739f, -0.54601479f, 0.06627490f, -0.29737243f, -0.30903521f, 0.16325286f, 
    0.06827632f, -0.25555208f, -1.06648874f, -0.19095460f, 0.39652351f, 0.39763492f, 0.38695896f, -0.12322023f, 
    0.07932716f, 0.33940089f, -0.34724367f, -0.11628949f, 0.04992671f, -0.03178057f, -0.00496914f, 0.13625450f, 
    0.26616386f, -0.01178547f, 0.08819561f, 0.11262662f, -0.16737439f, 0.35342246f, 0.55271250f, 0.17803495f, 
    -0.15854533f, -0.17110249f, 0.02005737f, -0.47679681f, 0.19110000f, 0.04604582f, -0.45536715f, 0.60190636f, 
    0.13021018f, -0.06444109f, -0.05688908f, -0.16174005f, -0.09626092f, 0.02911915f, -0.05364202f, 0.16480052f, 
    -0.07709444f, -0.22491315f, -0.10512363f, -0.14859059f, -0.03362766f, 0.09695709f, -0.18888022f, 0.01886143f, 
    -0.08557206f, 0.09323630f, -0.17081113f, -0.19045693f, -0.12643136f, 0.00991770f, -0.03167124f, 0.01517279f, 
    0.09099638f, 0.12979650f, 0.08958128f, -0.08199257f, 0.09683409f, 0.05947339f, -0.06596624f, 0.03113686f, 
    -0.34874293f, -0.02819170f, 0.23829390f, 0.36372727f, 0.39754033f, 0.13193572f, 0.08905239f, -0.04819501f, 
    -0.00397408f, -0.19491510f, -0.02535342f, 0.08462530f, -0.14039771f, -0.12885988f, 0.21294282f, 0.23354600f, 
    0.07197199f, -0.15334481f, -0.06478234f, -0.16103797f, 0.04113669f, 0.06896432f, -0.31546089f, 0.11173628f, 
    -0.04704847f, -0.24761949f, 0.09311741f, -0.03125017f, -0.11604394f, 0.69217873f, 0.23279779f, 0.59919530f, 
    -0.07188260f, -0.07231375f, -0.23042768f, 0.30917260f, 0.29714081f, 0.05133425f, -0.06957608f, -0.05847072f, 
    0.03904941f, 0.09587833f, 0.03837993f, 0.10105966f, 0.09892233f, 0.16813879f, 0.22989056f, -0.10603270f, 
    0.05217418f, 0.07559427f, 0.43737125f, 0.05993773f, 0.05651610f, 0.00018227f, 0.43682021f, -0.10381134f, 
    -0.17587912f, -0.27583364f, -0.24753495f, 0.01209410f, -0.27176210f, -0.00460003f, 0.15322585f, 0.50795186f, 
    0.17907739f, 0.21713273f, 0.10217944f, 0.38435450f, -0.41054174f, -0.05661550f, 0.01150583f, 0.02154431f, 
    -0.13933638f, -0.21251923f, 0.01852548f, -0.09248190f, -0.14601529f, -0.04813733f, 0.12938137f, 0.27228206f, 
    0.21777871f, 0.10225717f, -0.59392947f, -0.32360092f, 0.15203442f, -0.19805887f, -0.35941565f, -0.00716466f, 
    0.13021579f, 0.02449558f, 0.57870251f, 0.00511726f, 0.02185819f, 0.21618904f, -0.14488173f, 0.18083298f, 
    0.00073628f, 0.31096020f, -0.04912172f, 0.22733380f, -0.39695030f, -0.03486050f, 0.35944507f, -0.00784386f, 
    -0.16502072f, -0.10355721f, 0.21762772f, -0.34245116f, -0.44324127f, -0.12559609f, 0.13028137f, 0.29807407f, 
    0.25264278f, 0.03418063f, -0.33251125f, -0.18458867f, -0.11006134f, -0.04890484f, 0.00248276f, 0.18901786f, 
    -0.03037246f, 0.20281841f, 0.47180843f, -0.27519301f, -0.39054212f, 0.08201870f, -0.17106479f, 0.10923390f, 
    0.01855173f, 0.03203139f, 0.27575427f, 0.04689633f, -0.36649689f, -0.16030718f, 0.09549082f, 0.17073883f, 
    -0.02059978f, 0.03401834f, 0.16117446f, -0.24770817f, 0.36003950f, -0.00047145f, 0.25607115f, 0.10286009f, 
    0.20836943f, -0.07462893f, 0.09783439f, 0.11083784f, 0.05765960f, -0.20778669f, -0.15056768f, -0.28961751f, 
    0.07614790f, -0.10148256f, -0.41092247f, -0.11445992f, -0.12632890f, 0.06253557f, 0.25067967f, 0.40163422f, 
    0.27820376f, 0.12353260f, 0.14667000f, 0.02357572f, 0.13188721f, -0.03535298f, -0.14840916f, 0.05598219f, 
    -0.04869550f, 0.23232938f, 0.20809151f, 0.25594980f, -0.27596068f, -0.16652648f, -0.06342570f, 0.03275434f, 
    -0.25378665f, -0.11627950f, 0.69429862f, -0.25837418f, 0.06155357f, 0.18651861f, 0.35526153f, 0.03617415f, 
    0.32210609f, -0.09852397f, 0.24692084f, -0.17266977f, 0.07945474f, -0.01021631f, 0.11923838f, -0.20723428f, 
    0.26652968f, 0.13422076f, -0.42164123f, 0.00842842f, -0.34481758f, 0.00789169f, -0.05253429f, -0.10075102f, 
    0.06924515f, -0.09287004f, 0.20725811f, -0.12646021f, 0.14210525f, -0.07260140f, 0.15575603f, 0.39028940f, 
    0.22382358f, -0.11298755f, -0.04241884f, 0.33824015f, 0.34366852f, -0.27629146f, -0.32069373f, -0.37658033f, 
    -0.27712911f, -0.30493826f, -0.11011137f, -0.09112454f, 0.12362414f, 0.11479232f, 0.23526922f, 0.58965659f, 
    -0.18802805f, 0.12045991f, 0.33243701f, 0.16539657f, 0.43988895f, -0.27024683f, -0.22720909f, -0.04777819f, 
    -0.16694379f, -0.27461341f, 0.21511543f, 0.71822923f, -0.25061908f, 0.16837759f, -0.03408757f, -0.31688100f, 
    0.01659158f, -0.03047683f, 0.05643666f, -0.22913957f, 0.16800262f, 0.24380055f, 0.15352970f, 0.35624623f, 
    0.05808695f, -0.51247603f, 0.27037755f, 0.07712441f, -0.08335770f, 0.30037531f, -0.06957825f, 0.31524906f, 
    -0.15595582f, -0.17114545f, -0.12389885f, -0.36627841f, 0.40352458f, 0.28140920f, 0.03361149f, -0.09723657f, 
    0.04502721f, 0.04849629f, -0.03049235f, 0.37285742f, 0.14560564f, 0.03865122f, -0.36254001f, -0.03476258f, 
    0.16747126f, 0.03127262f, -0.53041106f, 0.35879925f, 0.20560448f, 0.03569492f, -0.16737060f, 0.12310684f, 
    0.09193194f, 0.05407578f, -0.31448355f, 0.26312882f, 0.26658422f, 0.41093177f, -0.09917301f, 0.31557485f, 
    0.10903967f, 0.01654237f, -0.10995895f, 0.21769507f, 0.07139567f, 0.17046900f, 0.22300950f, -0.09183798f, 
    0.05789603f, -0.14206874f, 0.04945897f, -0.54760307f, -0.27578756f, -0.16131477f, -0.08958040f, 0.26896873f, 
    0.13701776f, -0.01829574f, -0.19635177f, -0.07648262f, -0.07800184f, -0.00664981f, -0.04477045f, 0.10995127f, 
    -0.11031632f, -0.03167674f, 0.18889675f, 0.03078273f, -0.03112770f, 0.00809073f, 0.05183135f, -0.10662696f, 
    0.11766207f, 0.04309889f, 0.26991296f, 0.09111141f, 0.31087169f, -0.25762692f, -0.40843862f, -0.07898201f, 
    -0.17790115f, -0.29944813f, 0.24733923f, 0.34365320f, 0.03262283f, 0.17117369f, 0.15962623f, 0.26939562f, 
    0.10136805f, 0.09063393f, 0.40342867f, -0.12615974f, 0.37717164f, -0.25060752f, -0.22978970f, -0.00247696f, 
    0.19395384f, -0.06541707f, 0.07038606f, 0.00532521f, -0.19975334f, 0.04918462f, 0.21002860f, 0.12391576f, 
    -0.09996350f, -0.22300310f, -0.52476335f, -0.65394771f, 0.58291876f, 0.04303836f, -0.42481247f, -0.07097529f, 
    -0.12216450f, 0.01302894f, 0.25538516f, 0.42219698f, 0.36261359f, -0.15011977f, -0.86443412f, -0.30871215f, 
    0.21195948f, -0.16398883f, 0.22205126f, -0.15609249f, 0.21041301f, -0.01912896f, -0.19280331f, 0.17143227f, 
    -0.09975374f, -0.19324900f, -0.88777685f, 0.20342322f, -0.04445304f, 0.01387356f, -0.14708123f, -0.12307896f, 
    -0.01130570f, -0.13499379f, 0.10191293f, -0.15246379f, -0.18167101f, -0.18234983f, 0.00647371f, 0.08400813f, 
    0.04690477f, -0.12893111f, 0.01711816f, 0.01230207f, 0.00155803f, -0.05591540f, -0.02868242f, -0.17422467f, 
    -0.01359069f, -0.09887396f, -0.18507023f, -0.19372140f, 0.13738105f, -0.08182827f, 0.13014539f, 0.11829336f, 
    -0.08443358f, -0.13143176f, -0.08863960f, -0.04777804f, 0.06128374f, 0.08809288f, -0.20111093f, -0.09056794f, 
    0.16471758f, -0.11727449f, 0.19065914f, -0.59084266f, 0.16147050f, 0.24604429f, 0.23008478f, 0.02606964f, 
    -0.06635176f, 0.23338373f, 0.13374282f, 0.06459223f, 0.53166479f, 0.15752432f, -0.44651842f, -0.62379462f, 
    0.30008131f, 0.06452592f, -0.16843639f, 0.04354306f, -0.23132512f, -0.12238895f, 0.43730146f, 0.08017721f, 
    0.09751678f, -0.22551778f, 0.20450675f, -0.38389286f, -0.14929189f, -0.33642146f, -0.43666577f, 0.00414725f, 
    -0.14432192f, -0.02249484f, -0.04056237f, 0.10939234f, -0.08167621f, -0.07267745f, 0.08233844f, -0.13797991f, 
    -0.14403470f, -0.05519430f, -0.05020919f, 0.15296081f, -0.07235585f, 0.07951694f, -0.10759746f, -0.05821184f, 
    -0.11804614f, 0.13093257f, -0.13807455f, 0.00192284f, -0.01796163f, -0.05790920f, 0.09001727f, 0.05018190f, 
    -0.14437480f, 0.04012670f, 0.00996104f, -0.11125907f, 0.11582688f, 0.06580527f, -0.13072717f, -0.10734601f, 
    -0.05747649f, -0.17261575f, 0.02609348f, 0.17190753f, 0.17027307f, -0.00835293f, 0.28271985f, 0.14782247f, 
    0.01746128f, -0.01815197f, 0.04423580f, -0.45898172f, -0.38108608f, -0.01799251f, 0.37358478f, 0.22849411f, 
    -0.12939508f, 0.15574038f, -0.00683188f, -0.14458878f, -0.12308215f, 0.23279589f, 0.03301046f, 0.40602353f, 
    -0.09738447f, 0.24235420f, 0.12986325f, -0.21475562f, 0.17325607f, 0.13171761f, -0.08775818f, -0.09587146f, 
    -0.22631186f, 0.24025060f, -0.08822607f, 0.45123410f, 0.19169438f, 0.17371432f, 0.20759450f, 0.01720262f, 
    0.07929253f, 0.08276670f, 0.04972574f, -0.19293027f, 0.60489410f, 0.14785764f, 0.20932147f, -0.27786276f, 
    0.03709524f, -0.08616152f, -0.37454814f, 0.05834225f, 0.12626171f, 0.08956188f, 0.26593119f, 0.29254904f, 
    -0.48837891f, -0.89810294f, 0.20230484f, -0.20202021f, -0.33106232f, -0.09673519f, 0.07295012f, 0.18005921f, 
    0.56809497f, 0.35354045f, -0.10825164f, -0.11514009f, -0.24302712f, -0.28293851f, -0.09900093f, -0.16749339f, 
    0.00323024f, -0.17310506f, 0.39371127f, 0.40513465f, -0.41727680f, 0.07700592f, -0.22451687f, 0.08641453f, 
    0.25199896f, 0.13003439f, 0.16086139f, 0.01367958f, 0.06884901f, 0.18293329f, 0.52955258f, -0.17764582f, 
    0.31620347f, 0.04357478f, 0.53087610f, -0.18789096f, -0.40797049f, -0.58788007f, -0.27794454f, -0.32401454f, 
    -0.13571762f, 0.22556835f, -0.70542783f, 0.27548122f, -0.21780489f, 0.02846163f, 0.26652426f, -0.09825429f, 
    0.06260251f, 0.19068682f, 0.25315037f, -0.52476549f, 0.36757642f, -0.11876187f, 0.04553180f, 0.24707562f, 
    0.11303919f, -0.09691294f, 0.03437558f, 0.50337386f, 0.21933778f, -0.12431609f, 0.26261193f, -0.36452088f, 
    -0.20651634f, -0.33675170f, -0.38522542f, 0.03454885f, 0.31255269f, 0.02828811f, -0.02243609f, 0.12539884f, 
    0.23022887f, 0.16657384f, -0.22270204f, -0.06108676f, -0.01167001f, -0.10990645f, -0.29268807f, -0.00927764f, 
    -0.11818766f, -0.07787105f, 0.19323592f, 0.11257920f, 0.02170872f, -0.11243711f, 0.10961463f, 0.14300731f, 
    0.16368520f, 0.13692795f, 0.30092737f, 0.42089668f, 0.37211680f, 0.07217110f, -0.03624927f, -0.07569931f, 
    -0.03786794f, -0.42818519f, 0.05524910f, 0.24055564f, -0.02355224f, -0.34170601f, -0.08977930f, -0.39583915f, 
    0.10613345f, 0.15089983f, 0.14684483f, -0.47137836f, -0.47643423f, 0.08443365f, 0.20431946f, 0.09367836f, 
    -0.08285607f, 0.08466797f, 0.21535933f, 0.16894710f, -0.46244493f, 0.14780404f, -0.28839314f, -0.26847997f, 
    0.34147239f, 0.00998227f, -0.17001010f, 0.45769385f, -0.18652594f, 0.02749472f, -0.45387030f, 0.17278425f, 
    0.23087451f, 0.43543935f, -0.30947167f, -0.13514915f, 0.23545517f, -0.05480861f, -0.39896977f, -0.03402768f, 
    0.23626646f, -0.04182786f, -0.04135460f, 0.00690071f, -0.48753023f, 0.01154087f, 0.06388940f, -0.02116203f, 
    0.13208163f, 0.20466213f, -0.00254073f, -0.02078657f, -0.28726012f, -0.09021328f, -0.02280290f, -0.54710221f, 
    -0.09428529f, 0.04595692f, 0.09224539f, 0.09285785f, -0.15480191f, 0.22273840f, 0.47535715f, 0.02616338f, 
    0.08031023f, -0.24713789f, 0.22513177f, -0.02602205f, 0.06140519f, -0.52886796f, -0.27656659f, 0.10689684f, 
    -0.22155915f, 0.09569317f, 0.20186965f, -0.15067843f, -0.12139547f, 0.07248502f, 0.40363729f, 0.11709063f, 
    0.00175701f, 0.13834023f, -0.16186537f, 0.08392792f, -0.30642185f, -0.11154757f, 0.27759773f, -0.21281587f, 
    0.06773207f, -0.06880747f, -0.25962818f, 0.01217657f, -0.10090537f, -0.10983741f, -0.13414074f, 0.16390657f, 
    0.25828546f, 0.41867915f, -0.30412862f, -0.34174499f, 0.36568293f, 0.56412780f, -0.00815713f, 0.38583970f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.42432445f, -0.23379259f, 0.10619270f, -0.20996071f, -0.01513663f, 0.15960465f, 0.13030502f, 0.14243290f, 
    -0.05274932f, -0.03127574f, -0.15286729f, -0.00864763f, 0.05290414f, -0.08391398f, 0.08309925f, -0.04153967f, 
    -0.12214791f, 0.18680458f, 0.10426787f, 0.03530937f, 0.01129210f, -0.09630910f, -0.10051523f, -0.17423718f, 
    0.18207680f, -0.10247017f, 0.36018023f, 0.14265431f, 0.14624678f, 0.13828240f, 0.08971838f, 0.15358484f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.05814970f, 0.08395055f, -0.44424370f, 0.06069302f, 0.30111888f, -0.11849299f, -0.94039023f, 0.13363409f, 
    -0.11818050f, 0.16966504f, 0.20853345f, -0.15403622f, -0.57758152f, -0.00128220f, -0.14447524f, -0.09204442f, 
    0.31176138f, 0.28713092f, -0.16698001f, 0.26681963f, 0.35943010f, -0.08605797f, 0.23246001f, -0.18413255f, 
    -0.42440042f, 0.21058726f, -0.27019477f, -0.10230799f, -0.09730585f, -0.59324872f, -0.31774262f, -0.16042940f, 
    0.17617920f, 0.02376930f, -0.35791355f, -0.14058821f, 0.12034819f, -0.05512939f, -0.05880267f, -0.72733402f, 
    0.04533891f, -0.10134353f, -0.22403672f, 0.05163281f, -0.17437904f, -0.14829212f, 0.15842317f, -0.28571337f, 
    0.58471543f, 0.00381616f, -0.06502244f, 0.28892204f, 0.51469111f, 0.13179094f, -0.09301160f, 0.14289847f, 
    0.10760158f, -0.53232229f, 0.19070978f, -0.45165110f, 0.19526535f, 0.23571850f, 0.15300770f, -0.17641079f, 
    0.11798648f, 0.18103063f, 0.11349596f, -0.16696610f, -0.23462310f, -0.37340042f, 0.44452116f, 0.53205186f, 
    0.06228467f, -0.48899132f, -0.19116749f, -0.28997451f, -0.20139235f, -0.07318734f, 0.01342947f, -0.04547666f, 
    -0.64700806f, 0.23604932f, -0.01577516f, -0.29108894f, -0.07366122f, -0.15126342f, 0.66416228f, -0.10413498f, 
    -0.47380692f, -0.74664325f, 0.19377644f, -0.06100153f, 0.09393643f, 0.09479540f, 0.16463090f, -0.30360478f, 
    -0.12052967f, -0.24769457f, 0.13266797f, -0.13240507f, -0.13094695f, 0.22949310f, 0.03496026f, 0.04118123f, 
    -0.07744527f, -0.18223697f, -0.09722205f, -0.35591492f, -0.24882752f, 0.09890009f, -0.59724313f, 0.08624727f, 
    -0.21356149f, 0.12259969f, -0.06821968f, -0.46078607f, 0.06660792f, -0.09366556f, 0.46974730f, -0.05956725f, 
    -0.76280934f, 0.45780197f, -0.50575930f, 0.38683522f, 0.13182187f, 0.09958638f, -0.44104379f, -0.10160656f, 
    0.25297821f, -0.10137494f, -0.23825634f, -0.17500962f, 0.15044706f, 0.39960000f, -0.39894199f, 0.19606836f, 
    -0.16507266f, 0.25597361f, -0.04089622f, 0.04210088f, -0.19996679f, -0.26992199f, -0.00323055f, 0.06649332f, 
    -0.17270970f, 0.05192091f, 0.04370531f, -0.17527628f, -0.23553079f, -0.06378225f, -0.58963269f, 0.00644893f, 
    0.23954323f, -0.12266678f, -1.06602752f, 0.15774624f, -0.07870822f, -0.13136621f, -0.22197780f, 0.08179446f, 
    0.20097111f, 0.21089631f, -0.16760901f, 0.12938699f, -0.30536813f, -0.19735152f, 0.29621145f, -0.20522602f, 
    -0.22297838f, 0.27781442f, 0.00330772f, 0.12817389f, -0.05468128f, 0.14764737f, -0.00647192f, 0.33127904f, 
    0.21180554f, 0.00673487f, -0.05712571f, 0.11511880f, -0.18729612f, -0.03439968f, -0.49177060f, -0.03901479f, 
    -0.63325506f, -0.17876476f, -0.22076555f, 0.17041895f, -0.16894850f, 0.06775154f, -0.18103077f, 0.22022559f, 
    -0.17050955f, -0.31089744f, 0.44066137f, -0.03556614f, -0.29596251f, -1.15189040f, 0.17087375f, -0.09157484f, 
    -0.12546532f, -0.27784842f, -0.74557567f, -0.00455812f, 0.10905081f, -0.05363410f, 0.33730006f, -0.55305064f, 
    -0.40248284f, -0.25742996f, -0.01107279f, -0.32242033f, -0.55157399f, 0.13993949f, 0.58244997f, -0.16732976f, 
    0.11148060f, -0.93181461f, 0.10030726f, -1.11167443f, -0.62556946f, 0.25198218f, 0.18444112f, 0.39865723f, 
    -0.15067300f, -0.18626872f, -0.00047162f, -0.12304736f, 0.42932987f, -0.43152755f, -0.72803515f, -0.16430829f, 
    -0.01080724f, 0.34860092f, 0.09452209f, 0.03088850f, 0.20447844f, 0.18278100f, -0.14074744f, -0.13488977f, 
    0.12593320f, -0.38651454f, 0.01802305f, 0.11293144f, -0.37291974f, -0.15161489f, 0.23393925f, 0.10058841f, 
    0.02730271f, 0.71072048f, -0.46125692f, -0.04929550f, -0.31706759f, -0.97202408f, -0.26991308f, -0.04859310f, 
    -0.29373249f, -0.12132738f, -0.04893821f, -0.01513306f, -0.70077515f, -0.60893106f, 0.21287844f, -0.66718090f, 
    -0.16432667f, -0.15909690f, -0.37012726f, 0.39594284f, 0.40539032f, -0.11088733f, -0.07714171f, 0.45016214f, 
    -0.15727992f, -0.14886998f, 0.28261685f, 0.21326697f, -0.52315307f, -0.04069896f, -0.04247525f, -0.01259006f, 
    0.00619576f, 0.04561087f, 0.36064819f, 0.26978818f, 0.28196681f, -0.32369697f, -0.18008894f, -0.67757803f, 
    0.26951745f, -0.23787615f, 0.27653176f, 0.02101917f, -0.20741619f, 0.30552149f, -0.39281970f, 0.06039726f, 
    0.09409644f, -0.05427137f, -0.46371359f, 0.10429388f, 0.17609490f, 0.00292554f, -0.28457585f, -0.17920907f, 
    -0.45849416f, 0.02080794f, 0.06030344f, -0.35918000f, -0.72182107f, -0.03139820f, -0.47144040f, -0.04509889f, 
    0.38909113f, -0.63157475f, -0.20931517f, -0.10685837f, -0.31030297f, 0.47357678f, -0.28027403f, 0.34545934f, 
    0.24568400f, -0.82118285f, -0.10874742f, 0.04683717f, 0.29907390f, -0.32984719f, 0.13493314f, -0.32172257f, 
    -0.16090350f, -0.64545649f, 0.42215222f, -0.87050802f, -0.26348266f, 0.39666754f, 0.25232810f, 0.17449744f, 
    -0.40580812f, -0.80995452f, -0.13547106f, 0.27704039f, -0.11697523f, -0.05029691f, -0.45985347f, -0.04280365f, 
    -0.17536768f, -0.40048978f, 0.09450483f, 0.41926691f, 0.28243306f, -0.18917885f, -0.14646766f, -0.33583182f, 
    -0.70698196f, 0.06785008f, 0.27096850f, 0.08007120f, -0.11561994f, -0.06922111f, -0.08172533f, 0.12524758f, 
    -0.08079422f, -0.22478981f, 0.04903166f, -0.16789947f, 0.15915327f, -0.82596689f, 0.19710220f, -0.57959056f, 
    0.43570521f, -0.44131240f, -0.00827866f, -0.70511132f, -0.42617109f, 0.11829187f, -0.25663078f, 0.04525853f, 
    0.15050197f, 0.26870313f, 0.26092443f, -0.02126282f, 0.00716459f, -0.19925593f, 0.51519126f, -0.47019577f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.27544245f, 0.15703613f, -0.09671652f, -0.16631414f, 0.08946288f, -0.09026012f, 0.04894190f, -0.09021346f, 
    0.10395933f, 0.25209334f, -0.04387046f, -0.00629695f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
