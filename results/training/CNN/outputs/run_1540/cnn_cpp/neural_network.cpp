#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.14416437f, -0.07324952f, -0.15593562f, 0.28000066f, 0.09378693f, 0.25573659f, -0.27068129f, -0.01472901f, 
    0.42624265f, 0.06439197f, 0.11173756f, -0.13173628f, -0.00229481f, -0.17565416f, 0.49132460f, -0.39740410f, 
    0.06711931f, 0.26153240f, -0.44341382f, 0.24777693f, -0.37348330f, -0.00564490f, 0.08595591f, 0.43669546f, 
    0.16557914f, -1.08217442f, -0.48885345f, -0.26300868f, -0.09580036f, -0.57422602f, 0.36244678f, 0.41840398f, 
    0.22591525f, 0.30198109f, 0.42435852f, -0.07115132f, -0.09734989f, 0.30094880f, 0.38740513f, -0.20145731f, 
    -0.06277288f, -0.18814325f, -0.12036147f, -0.17359835f, -0.03972383f, 0.15667494f, 0.17687415f, 0.43353131f, 
    0.13241334f, -0.11996946f, 0.67024398f, 0.97879618f, -0.40927389f, -0.03014766f, 0.35808089f, -0.46248040f, 
    -0.34692457f, 0.10836378f, 0.06516651f, -0.28949586f, -0.12896788f, 0.02969653f, -0.08575794f, -0.09396660f, 
    -0.18873566f, 0.00671778f, -0.07443772f, 0.01550622f, -0.06489567f, -0.06290603f, -0.02152225f, 0.14982662f, 
    -0.01134490f, -0.09682783f, -0.00899374f, 0.09854812f, 0.74635100f, 0.50084031f, -0.14149074f, -0.45931211f, 
    0.15882026f, 0.21639445f, -0.40261376f, -0.13143578f, -0.27342069f, -0.14105460f, -0.30977434f, -0.15580070f, 
    -0.22390655f, -0.22091274f, 0.28683925f, 0.03136675f, -0.14916764f, 0.05697529f, 0.25971785f, 0.10382745f, 
    -0.15352584f, -0.14931503f, 0.25745022f, 0.35370785f, -1.01352942f, -0.43811369f, 0.59717506f, 0.68953282f, 
    -0.55654979f, -0.21226549f, -0.93056989f, -0.54879165f, 0.41814208f, 0.53764069f, 0.22377515f, 0.09923755f, 
    0.00242109f, 0.49145472f, 0.27936849f, -0.05907870f, 0.00823577f, 0.06224003f, -0.24888445f, -0.00704678f, 
    0.04687065f, -0.06643286f, -0.06420667f, 0.03182116f, -0.00831318f, 0.69276220f, -0.12914410f, 0.49012047f, 
    -0.36789057f, -0.73598272f, 0.01482688f, -0.15856659f, -0.33080989f, 0.09244966f, 0.28088075f, -0.17582989f, 
    -0.26002461f, -0.08331384f, -0.07794642f, 0.28843924f, -0.32797033f, 0.06949963f, 0.06394583f, -0.09206919f, 
    -0.02054891f, -0.11794710f, -0.36133263f, -0.33120030f, -0.52011961f, -0.47075769f, -0.47483316f, 0.00243853f, 
    -0.47161067f, -0.51778537f, -0.50340736f, 0.15593961f, -0.05830862f, -0.38211134f, -0.39889601f, -0.44351855f, 
    -0.04648991f, -0.40531307f, 0.00546683f, -0.29128438f, -0.14106540f, -0.06205208f, 0.02434898f, -0.02679495f, 
    0.03690725f, 0.01587101f, 0.01993014f, -0.09504736f, 0.07726515f, 0.15206480f, 0.59124887f, -0.27539569f, 
    0.00203361f, 0.43292347f, 0.14578593f, 0.02938603f, -0.95180398f, -0.53813028f, -0.27623004f, -0.19728187f, 
    -0.20567133f, 0.08875024f, 0.54310238f, 0.28180149f, -0.09713896f, 0.00291127f, -0.10945498f, 0.22026391f, 
    0.13956374f, -0.36638659f, -0.00503861f, 0.09234447f, 0.17888334f, 0.02540101f, -0.14819257f, 0.29201210f, 
    -0.13678709f, 0.26902747f, 0.12696476f, 0.01796638f, 0.47391436f, 0.29000035f, 0.64914536f, 0.41143915f, 
    0.23335086f, 0.26872298f, -0.30062237f, 0.48375934f, 0.01567344f, -0.48764029f, -0.20693666f, 0.37208337f, 
    -0.05351481f, -0.30861840f, -0.30030417f, -0.17215906f, -0.04481933f, 0.17547417f, 0.06557243f, -0.12973003f, 
    -0.12604019f, 0.54441887f, 0.79183108f, 0.40346476f, 0.21774657f, -0.14019606f, -0.28819892f, -0.33260378f, 
    -0.16536066f, 0.02838845f, -0.11390863f, 0.15229011f, -0.24924713f, 0.02182499f, 0.40871042f, 0.11169117f, 
    0.08573869f, 0.27154636f, 0.12629820f, -0.16914855f, -0.11118973f, 0.18380038f, -0.10481627f, -0.06255674f, 
    0.03062405f, -0.22125110f, 0.30021936f, 0.43703216f, 0.50463384f, -0.01818182f, 0.24082713f, -0.23405795f, 
    -0.05537632f, -0.13771318f, -0.17037486f, 0.39114219f, 0.28211385f, -0.15927406f, 0.16284762f, -0.24365120f, 
    -0.35796967f, -0.00229941f, -0.04797309f, 0.10158928f, 0.22665846f, -0.30378148f, -0.13843791f, -0.21603872f, 
    0.04974755f, 0.06401198f, 0.24296996f, -0.45732614f, -0.36445221f, -0.20400150f, 0.20796496f, 0.42032897f, 
    0.76706827f, -0.45092660f, 0.02028668f, 0.09893256f, 0.19686797f, 0.12818369f, 0.22711240f, -0.48016593f, 
    -0.20623286f, -0.10750041f, -0.09339044f, 0.13381308f, 0.10800895f, 0.12344634f, -0.12012231f, -0.21077655f, 
    0.22256154f, 0.17434207f, 0.07771623f, 0.22379129f, -1.00454962f, -0.66158175f, 0.12735517f, 0.48487356f, 
    0.86452591f, 0.31231371f, 0.19219048f, -0.31988609f, 0.05433735f, 0.31926343f, -0.07272686f, -0.35130280f, 
    0.52402449f, -0.11698395f, -0.13061522f, -0.14389767f, 0.00196448f, 0.00025020f, 0.06805035f, -0.15672414f, 
    0.20171466f, -0.15672600f, -0.22138450f, 0.04360597f, -0.01527116f, -0.91802597f, -0.22717127f, -0.18076393f, 
    0.10911333f, -0.29321778f, -0.35339886f, -0.40830848f, -0.76051563f, -0.60835743f, -0.10368884f, 0.12559760f, 
    0.01993833f, -0.43953177f, -0.66641545f, -0.14419666f, -0.08322783f, -0.11397932f, -0.07275072f, -0.10615537f, 
    -0.32678542f, 0.16972953f, -0.37403053f, -0.19570076f, 0.12941580f, -0.22698428f, 0.59157032f, 0.06372765f, 
    -0.35654390f, -0.17152558f, -0.31604341f, 0.30608425f, 0.17867453f, -0.13924940f, -0.33118957f, 0.09659524f, 
    0.69562393f, -0.62129366f, 0.30291751f, -0.20720194f, 0.01255053f, -0.20306474f, 0.09796699f, 0.02405047f, 
    -0.14053883f, 0.07190958f, -0.03308390f, -0.18262455f, 0.06389090f, 0.34813464f, 0.16170818f, 0.06806667f, 
    0.13768697f, 0.16534442f, -0.06169644f, -0.33709708f, -0.55508035f, -0.38528988f, -0.51787496f, -0.46853521f, 
    -0.55002868f, 0.58011949f, -0.25109744f, -0.05582261f, 0.35808003f, 0.28906882f, -0.07739174f, -0.03646354f, 
    0.03412210f, 0.18808879f, -0.24549438f, -0.24451473f, 0.02218227f, -0.08266857f, -0.35963389f, -0.28420386f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.23728190f, 0.17730886f, 0.38191217f, 0.06706624f, 0.31922898f, 0.31873271f, 0.11992863f, 0.32449025f, 
    0.21756567f, 0.00685387f, 0.13822041f, 0.19082285f, 0.13940324f, -0.10603106f, 0.20416071f, 0.05127252f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.01693872f, 0.19618821f, -0.03230573f, 0.23075607f, 0.03406584f, 0.03957568f, 0.05987743f, 0.01907847f, 
    0.14967939f, -0.00008184f, -0.03598355f, -0.01947388f, -0.12059419f, 0.29087713f, -0.05130232f, 0.13939208f, 
    -0.03308214f, -0.07074887f, 0.04637431f, -0.01029059f, -0.11108936f, -0.10897938f, -0.06650072f, -0.05208356f, 
    0.19237576f, -0.00391269f, -0.02710366f, -0.02574501f, 0.02092832f, 0.00826310f, -0.06725287f, 0.07011811f, 
    -0.09772170f, -0.01974343f, -0.10388528f, 0.04970849f, -0.11114819f, -0.06753471f, 0.00520474f, -0.04187650f, 
    -0.05455868f, -0.05167339f, 0.11077835f, -0.03246493f, -0.11719307f, -0.10091694f, -0.20247787f, -0.06512059f, 
    -0.18719955f, 0.17927219f, 0.00323990f, 0.12720807f, 0.00573164f, 0.02119447f, 0.21049227f, 0.05803901f, 
    0.12269040f, -0.08329897f, 0.11839819f, 0.04106813f, 0.21589357f, 0.26002005f, -0.08806840f, -0.17391878f, 
    0.20008819f, 0.00505729f, 0.07593652f, -0.03282784f, 0.07208675f, 0.00351220f, 0.12783962f, 0.27589503f, 
    0.05534159f, 0.12779929f, 0.07726973f, -0.19147983f, -0.19055276f, 0.01081973f, -0.02746762f, 0.01388258f, 
    -0.08189202f, -0.09276458f, -0.03564874f, -0.11995350f, -0.10613286f, 0.25428110f, -0.19961172f, -0.13858628f, 
    0.10292542f, 0.07093782f, 0.03291537f, -0.08002943f, 0.03884022f, 0.08475849f, -0.02717273f, 0.02802585f, 
    -0.02704174f, -0.03286460f, 0.01423034f, 0.08059237f, -0.01404142f, 0.05634712f, -0.05365520f, 0.09938591f, 
    0.08095933f, 0.13655005f, 0.15864035f, 0.10552700f, 0.21729960f, 0.06085769f, -0.04504574f, -0.00324524f, 
    0.04360376f, -0.05940473f, -0.02211506f, -0.05695877f, 0.11372618f, 0.03488236f, -0.06473284f, 0.12543999f, 
    0.07233714f, -0.14205085f, 0.14995424f, -0.03866632f, 0.02593162f, 0.06891588f, 0.03248474f, -0.01148494f, 
    -0.04380627f, 0.05120226f, -0.06721104f, -0.08319400f, -0.20586972f, 0.04625408f, -0.13777931f, 0.34770897f, 
    -0.08646562f, 0.11797458f, -0.02916024f, 0.02297411f, -0.03484697f, -0.05406357f, -0.13488066f, -0.09329945f, 
    -0.02221964f, -0.17715640f, -0.13784017f, 0.53955942f, 0.03071789f, 0.12697479f, 0.00285157f, 0.06676531f, 
    0.06304210f, 0.13825944f, 0.08543235f, 0.05732899f, 0.07277164f, 0.07860891f, 0.00654187f, -0.11742996f, 
    -0.03438778f, -0.23324898f, 0.00518192f, 0.00331298f, 0.02350419f, 0.03643236f, 0.12153944f, 0.02611149f, 
    -0.01367669f, -0.00493029f, 0.12584081f, -0.11863729f, -0.01057457f, -0.16424643f, 0.09682618f, 0.18845250f, 
    -0.12089621f, 0.00894844f, -0.01396422f, 0.00051335f, 0.03654645f, 0.02124381f, -0.01562007f, -0.12340372f, 
    -0.12446799f, -0.05251002f, -0.02225390f, 0.00506614f, 0.12788323f, 0.03121700f, 0.08175991f, 0.00442778f, 
    0.26368824f, -0.16087581f, 0.02889675f, -0.22330412f, 0.03838389f, -0.03435773f, -0.05906163f, 0.00613213f, 
    -0.04976998f, -0.10400143f, 0.05741615f, -0.02870969f, 0.17455873f, -0.04587284f, -0.20601380f, -0.21721020f, 
    0.02706916f, 0.19428772f, 0.04128085f, 0.06407278f, 0.05514899f, 0.03604333f, -0.09526020f, 0.10214361f, 
    -0.28011885f, 0.25668982f, -0.24971372f, 0.08050288f, 0.17975059f, -0.08224449f, 0.15741248f, -0.16857722f, 
    0.02514684f, -0.03878250f, -0.00710502f, -0.00393906f, -0.39528826f, 0.19718947f, -0.09417287f, 0.35365999f, 
    -0.08758570f, -0.00559988f, 0.05111909f, -0.06761418f, -0.06035583f, -0.14513431f, 0.08918255f, -0.12083428f, 
    0.62101531f, 0.05278825f, 0.04652212f, -0.29461157f, -0.08609070f, 0.09734931f, 0.06565207f, -0.05903770f, 
    0.12692896f, 0.04155176f, -0.09822127f, -0.02617915f, -0.05368865f, -0.20351627f, -0.07772918f, 0.06506511f, 
    -0.13022603f, -0.02145387f, 0.15703927f, 0.09157715f, -0.02659456f, 0.14010353f, 0.05233496f, 0.06338546f, 
    0.12869245f, 0.01816717f, -0.24026024f, -0.10397129f, 0.04257036f, -0.22995946f, -0.12683456f, -0.05887722f, 
    -0.08426143f, -0.11887456f, 0.08119322f, 0.00367652f, 0.06592159f, 0.11399035f, -0.01169857f, 0.12354150f, 
    0.04847695f, -0.03454584f, 0.13245124f, -0.00938130f, -0.05538591f, 0.01175858f, 0.03070879f, -0.09695576f, 
    -0.06116018f, 0.19410290f, 0.09177166f, -0.13943830f, 0.03322903f, -0.09014867f, -0.03934599f, -0.00921081f, 
    -0.06712576f, 0.11972760f, 0.20886150f, 0.07152200f, -0.03715345f, 0.01786300f, -0.17146866f, 0.12433146f, 
    -0.02161186f, 0.11186827f, 0.21921828f, -0.03804171f, 0.04783934f, -0.03493977f, 0.06194892f, 0.04075870f, 
    -0.03360480f, 0.05338746f, -0.19064270f, 0.11865927f, 0.06833173f, 0.02941735f, 0.04452648f, -0.00360622f, 
    -0.17183036f, 0.04425269f, 0.02864574f, 0.12992346f, 0.33288920f, -0.23685643f, 0.31315315f, -0.27292705f, 
    -0.03466709f, -0.00769168f, -0.07085565f, -0.04721626f, -0.06609612f, 0.13913821f, 0.17389347f, -0.07413383f, 
    0.46458483f, 0.29176143f, 0.05122127f, -0.21606733f, -0.07055195f, -0.11159875f, -0.09598469f, 0.01936093f, 
    0.12972012f, 0.15844414f, 0.09703296f, 0.16561136f, 0.19350131f, 0.25176230f, -0.07275573f, -0.06064522f, 
    0.03665741f, 0.23483869f, 0.11405154f, -0.10915557f, -0.00540695f, 0.04246422f, 0.16713853f, 0.10185401f, 
    0.07069434f, -0.01713234f, -0.05373701f, 0.05900112f, 0.03655611f, -0.01531240f, 0.03463091f, -0.11462528f, 
    0.12632728f, 0.05509392f, -0.14947660f, -0.15731776f, 0.36341649f, 0.02607988f, 0.03722965f, 0.13973042f, 
    0.21664114f, 0.19556364f, 0.25138184f, 0.14605220f, 0.08775271f, 0.08216177f, -0.05402360f, 0.00754659f, 
    0.00256500f, -0.01448522f, 0.01515791f, 0.01701422f, 0.00238299f, -0.02397591f, 0.04367254f, -0.01645739f, 
    -0.06677113f, -0.03882358f, 0.00547916f, 0.00277339f, -0.07924416f, -0.02248279f, 0.01203099f, 0.03037144f, 
    0.00094257f, -0.05831526f, 0.05873734f, -0.00116537f, 0.05292596f, -0.02205054f, -0.03469307f, -0.05722778f, 
    0.01109139f, -0.01240559f, -0.07007933f, -0.00823845f, -0.06395376f, -0.05952447f, -0.04929842f, -0.03006557f, 
    -0.03626516f, 0.03527568f, -0.01011722f, -0.01005398f, -0.03622417f, 0.03111971f, 0.03707319f, 0.03033066f, 
    0.04820858f, -0.04871963f, 0.01453479f, -0.03684238f, -0.04550729f, 0.04409130f, -0.05823826f, -0.01885551f, 
    -0.04512963f, 0.03059328f, -0.06266882f, 0.04217772f, -0.07432110f, -0.02244334f, -0.07205959f, -0.01264859f, 
    0.05580679f, -0.04602250f, -0.05808227f, -0.02942715f, -0.05479594f, -0.06823051f, 0.04567549f, 0.05772992f, 
    -0.04897805f, -0.01677178f, 0.03946486f, 0.01694119f, 0.00830890f, -0.05676686f, -0.05489174f, -0.07605314f, 
    -0.03140203f, -0.05853171f, -0.02827499f, 0.00679191f, -0.04508549f, -0.04907033f, -0.06058724f, -0.05833080f, 
    0.02350131f, -0.00259288f, 0.02819216f, -0.02227022f, 0.01664628f, -0.07347317f, 0.02723232f, 0.01320710f, 
    -0.02481684f, -0.07877088f, 0.03602358f, -0.02553280f, -0.02519855f, 0.00815814f, 0.04121625f, -0.00051561f, 
    -0.06276774f, -0.05539068f, 0.04679622f, -0.02189884f, 0.00923196f, 0.04060176f, 0.00422469f, -0.04028313f, 
    0.00920449f, -0.04845455f, -0.00977990f, 0.02052203f, -0.01418526f, -0.06736325f, -0.03008624f, -0.06336502f, 
    0.03288169f, 0.04640634f, -0.07908579f, 0.00495271f, -0.00797667f, -0.08000757f, 0.03006032f, -0.04151634f, 
    -0.04179525f, -0.06491002f, 0.03239051f, -0.01010213f, -0.00903276f, 0.02188874f, 0.05137547f, -0.02666424f, 
    -0.02089361f, -0.02796685f, 0.01754424f, 0.03386052f, -0.02988412f, 0.05101325f, -0.02046165f, 0.04769860f, 
    -0.04363025f, 0.02543753f, -0.06627104f, 0.03501529f, -0.02714529f, -0.07120480f, -0.01478835f, -0.07067244f, 
    -0.06605826f, 0.04957180f, -0.03213917f, 0.02265568f, 0.00202412f, 0.02622635f, 0.00039072f, -0.07470852f, 
    -0.08123509f, 0.04003957f, 0.01714318f, -0.03921507f, 0.02285352f, -0.03020273f, -0.06818996f, -0.01391026f, 
    0.06614384f, -0.05909437f, 0.01660337f, -0.08091057f, -0.01360986f, -0.03603349f, 0.06994766f, 0.00004994f, 
    -0.02175503f, 0.01901511f, -0.04559415f, -0.06522623f, 0.04315465f, -0.06112597f, -0.02132853f, 0.00318411f, 
    0.00933954f, 0.04356391f, 0.01501285f, -0.01857614f, 0.01465369f, -0.01049058f, -0.05451678f, 0.05593143f, 
    -0.07715971f, -0.07244531f, 0.02660800f, -0.07506658f, -0.02150059f, 0.00700923f, 0.02390447f, 0.02661080f, 
    -0.15985408f, -0.08756453f, -0.05390109f, -0.00847766f, 0.01710404f, -0.07515841f, 0.03997864f, 0.08022478f, 
    0.11148355f, 0.03963286f, 0.11009764f, 0.08699930f, -0.15288296f, 0.07683889f, 0.09924483f, 0.08228443f, 
    -0.07677990f, 0.02443874f, -0.01389508f, 0.01302422f, 0.11393604f, 0.03553904f, 0.10329878f, 0.02447689f, 
    0.07324281f, 0.18294452f, -0.11653531f, -0.19977984f, 0.13280033f, 0.09176468f, 0.10453818f, -0.07657616f, 
    0.01681677f, 0.02040883f, -0.00743526f, 0.04992338f, -0.00203951f, 0.00452256f, 0.08744655f, -0.24219996f, 
    0.08896733f, -0.08693077f, 0.02003134f, -0.08099570f, 0.06543575f, -0.02867727f, 0.00788411f, 0.08948673f, 
    0.02903324f, -0.14791360f, -0.14931209f, 0.25722176f, -0.14545219f, 0.04539401f, -0.05073068f, 0.10224097f, 
    0.10925713f, 0.07932295f, 0.02925151f, -0.00042743f, 0.32668579f, 0.12621018f, -0.08796584f, 0.12686691f, 
    0.00575698f, 0.05897914f, 0.04325517f, 0.06910364f, -0.06266234f, -0.04861434f, 0.01170428f, -0.08919637f, 
    -0.20500876f, -0.00211989f, 0.18294002f, -0.01199125f, -0.00656115f, -0.10236486f, 0.11687967f, -0.11654015f, 
    0.12827136f, 0.06075652f, 0.05241742f, 0.18454312f, -0.22540577f, -0.12405304f, -0.16188718f, 0.11985929f, 
    0.11215593f, 0.09157615f, 0.07922591f, -0.08965802f, 0.07120810f, -0.01350630f, -0.01208264f, 0.14673306f, 
    0.02902454f, -0.02135926f, 0.14654672f, 0.04486761f, 0.01631231f, -0.02950178f, -0.00096108f, -0.09690979f, 
    0.05865536f, 0.05622832f, 0.03853855f, 0.16289645f, -0.17611423f, -0.11180728f, -0.18440706f, -0.11485866f, 
    -0.02553390f, 0.00393283f, 0.02594403f, -0.07593599f, -0.16302504f, -0.11647440f, -0.15410478f, -0.09537730f, 
    -0.05119278f, -0.05411061f, -0.16939241f, -0.06131213f, 0.04751537f, -0.05286872f, 0.10580122f, -0.01568262f, 
    -0.02740228f, -0.02923389f, -0.01249469f, -0.01224944f, 0.05305602f, -0.13471900f, -0.04923573f, 0.05088735f, 
    0.14147644f, -0.14743650f, -0.02585307f, -0.05856721f, 0.04289536f, 0.01024004f, -0.10010290f, 0.11291147f, 
    -0.00594359f, -0.49946162f, 0.27377546f, 0.36459270f, -0.11073464f, -0.19535445f, -0.05561411f, -0.01695650f, 
    0.10499088f, 0.09024577f, -0.12363964f, 0.02417024f, -0.18310364f, -0.22506389f, 0.04916672f, 0.04068398f, 
    -0.02431031f, 0.02668094f, 0.00690528f, 0.09432119f, 0.08907437f, 0.17177179f, 0.21204546f, 0.04839089f, 
    0.00130823f, -0.01986255f, -0.10133819f, -0.10836349f, 0.08165228f, -0.11352320f, 0.09238621f, 0.10824603f, 
    0.24754076f, 0.05424001f, -0.03591547f, -0.00447844f, -0.09682073f, 0.12274341f, 0.09249971f, 0.03676948f, 
    0.05807294f, -0.01914630f, 0.01772913f, -0.03164749f, -0.00779572f, -0.03371733f, 0.09486659f, 0.01464693f, 
    0.31188458f, -0.02367244f, 0.06509997f, -0.25041631f, -0.06408528f, -0.06298919f, -0.05396352f, -0.20941527f, 
    0.05131875f, -0.07646871f, -0.19634737f, -0.29493961f, -0.00826778f, 0.12817235f, -0.12538069f, -0.08711169f, 
    -0.04814050f, -0.09304731f, -0.19995464f, -0.02907410f, 0.16147345f, -0.08611220f, -0.11134793f, 0.04213170f, 
    -0.08395373f, -0.06854860f, -0.46336877f, 0.06088733f, -0.10133819f, -0.09490830f, 0.10294339f, -0.04826744f, 
    0.00864312f, -0.17794052f, -0.16460581f, -0.13066705f, -0.30840966f, 0.06618382f, -0.58034015f, 0.23951232f, 
    0.00503289f, 0.11697276f, 0.14701121f, -0.06410671f, -0.22492696f, -0.20403369f, -0.21662219f, -0.16101062f, 
    0.14838713f, 0.33213246f, 0.18665251f, -0.39780331f, 0.10008406f, 0.06209128f, 0.04306886f, 0.03987283f, 
    0.10764223f, 0.10830088f, -0.03916236f, 0.02840954f, 0.04873557f, 0.08772040f, -0.12921223f, -0.03369667f, 
    -0.12374108f, -0.23076232f, 0.05503642f, 0.00818333f, 0.17642249f, -0.06140387f, 0.15936734f, 0.28070536f, 
    0.24910153f, 0.19472674f, -0.21823035f, -0.12047037f, 0.11250761f, 0.11738854f, 0.07513049f, 0.27215666f, 
    0.05751084f, -0.05194100f, 0.12685537f, -0.02928134f, -0.08672599f, 0.18551585f, -0.00632617f, -0.09436850f, 
    0.25760230f, 0.06855994f, 0.18796559f, -0.02610072f, -0.08851026f, -0.05334579f, 0.04574773f, -0.04623022f, 
    -0.17224105f, 0.28922540f, 0.10376529f, 0.14768672f, -0.22748940f, -0.10728406f, -0.12499723f, -0.36086166f, 
    -0.03812000f, 0.03326365f, 0.20957957f, 0.00618868f, 0.03387273f, 0.14688359f, -0.44160962f, 0.40730867f, 
    0.16125296f, 0.37858233f, 0.07805063f, -0.07765353f, 0.07965360f, 0.05166128f, 0.06798536f, 0.00894796f, 
    -0.07973030f, -0.23725295f, -0.32044002f, 0.24342163f, 0.05720478f, 0.02807370f, 0.03112007f, 0.08847679f, 
    -0.26185876f, 0.02524634f, -0.11894438f, 0.02567478f, -0.04742994f, -0.15671878f, 0.15658355f, 0.01661623f, 
    -0.05333472f, 0.10768943f, -0.06649492f, -0.18093544f, 0.06974597f, -0.12388544f, -0.10362630f, -0.28765085f, 
    0.14812183f, 0.17343496f, 0.19827251f, 0.36153901f, -0.14629573f, -0.07760137f, -0.04133880f, -0.08606327f, 
    0.02146900f, 0.05106478f, -0.09402522f, 0.16147605f, 0.25707427f, 0.42904887f, -0.01186595f, -0.08957741f, 
    0.20644934f, 0.15540069f, 0.08024342f, 0.04978427f, 0.08177219f, 0.01639811f, 0.08845720f, 0.19922872f, 
    -0.19432999f, -0.32555228f, -0.15763354f, -0.04269926f, -0.00914231f, 0.08826105f, -0.02606102f, -0.04579097f, 
    -0.20113590f, 0.05451948f, -0.22017288f, -0.26670140f, 0.19137947f, 0.23029500f, 0.08895045f, 0.13161962f, 
    0.00653942f, -0.00411870f, 0.12457120f, 0.18918423f, 0.07084552f, 0.20839357f, 0.08664667f, -0.03377124f, 
    -0.12204869f, 0.19320175f, -0.16654488f, 0.09246954f, -0.09135825f, 0.01652659f, 0.00186565f, 0.02308138f, 
    -0.00368116f, 0.19341393f, 0.05048939f, -0.00988682f, 0.04165746f, 0.15194456f, 0.37801033f, -0.17223929f, 
    -0.03220611f, 0.02379650f, 0.12024502f, 0.06396645f, -0.06954058f, -0.06918462f, 0.07053775f, -0.07058562f, 
    -0.12960774f, -0.10695984f, 0.06015914f, 0.09447903f, -0.02371781f, -0.05368832f, -0.03000305f, 0.03464847f, 
    -0.06729081f, 0.10937713f, 0.04605367f, 0.04446443f, 0.36167026f, -0.15568402f, 0.09418330f, -0.18094797f, 
    -0.04029629f, -0.05674262f, 0.00485716f, -0.04601323f, 0.05924033f, 0.00546734f, 0.02297259f, 0.06048745f, 
    -0.62306225f, 0.25061673f, 0.13053410f, -0.20934963f, 0.21749900f, 0.04076986f, 0.05296298f, 0.22165048f, 
    0.04411256f, -0.01667222f, -0.07348377f, 0.00169138f, -0.11618393f, 0.07689387f, 0.13322888f, -0.05943931f, 
    0.02540527f, 0.00507178f, -0.11984736f, 0.09035421f, -0.03688417f, 0.13659193f, -0.07837538f, -0.05977579f, 
    0.13581897f, -0.03088901f, 0.09185532f, 0.22611222f, 0.15175280f, 0.28987789f, 0.18695807f, -0.06392425f, 
    -0.04211408f, 0.04269074f, -0.06040092f, -0.02966842f, -0.05017860f, -0.00836899f, 0.28620914f, -0.07916807f, 
    0.05630645f, 0.10560337f, 0.01961780f, -0.01373773f, -0.08414893f, -0.11069169f, 0.02401916f, 0.08084310f, 
    0.16940346f, -0.15336820f, 0.02126612f, -0.00447264f, -0.06771246f, 0.04737831f, 0.09177069f, 0.07570519f, 
    0.04192167f, -0.18396586f, -0.15519565f, -0.01580558f, 0.04180277f, -0.09001014f, 0.00304961f, -0.01602854f, 
    -0.00970506f, -0.03321642f, -0.16721211f, 0.06485700f, -0.08763290f, 0.03167542f, -0.08239505f, -0.02769455f, 
    0.04850998f, 0.10785366f, 0.09971225f, 0.02348025f, -0.06386694f, -0.02758063f, -0.09161795f, -0.10859733f, 
    0.04080574f, -0.06701793f, 0.04980129f, 0.06862802f, -0.02737803f, 0.15814660f, -0.00576746f, 0.11077433f, 
    -0.05321432f, 0.16982423f, 0.00010548f, 0.02721982f, -0.07803313f, 0.06069551f, 0.01968818f, -0.05174638f, 
    -0.16787559f, 0.08636216f, 0.08144297f, -0.16231227f, -0.01446354f, 0.13188702f, 0.06282944f, 0.05773082f, 
    -0.03111684f, -0.00541067f, 0.01047491f, 0.00218716f, 0.24691632f, 0.06472745f, -0.00548903f, 0.05924225f, 
    0.11575517f, 0.17588665f, -0.03532971f, 0.12194061f, -0.04515347f, -0.01458671f, -0.13167581f, -0.02587195f, 
    0.09274406f, 0.09604137f, -0.01233759f, 0.13529365f, -0.05541334f, -0.09039477f, -0.07906170f, -0.10050147f, 
    0.00747684f, -0.05157477f, 0.09223468f, -0.01348117f, 0.06560216f, -0.00544106f, 0.13525391f, 0.04356211f, 
    0.08131783f, -0.05708836f, -0.00579967f, 0.03333815f, 0.02295719f, -0.00976337f, 0.04988485f, 0.12445057f, 
    -0.07252243f, 0.02809474f, 0.07048298f, -0.00550402f, -0.04439412f, -0.01442222f, 0.03917930f, 0.02437689f, 
    0.00441535f, -0.05686118f, 0.06198718f, 0.02996463f, 0.01172673f, 0.00822373f, 0.02469748f, -0.04570808f, 
    -0.07048728f, 0.01839625f, -0.01918488f, 0.02478964f, -0.06782652f, 0.01815338f, -0.04309021f, -0.03250953f, 
    0.03853258f, -0.07973184f, -0.04061314f, -0.04888054f, 0.04033862f, -0.05260915f, -0.00684131f, -0.05054420f, 
    -0.05161192f, 0.04818892f, 0.06659617f, 0.05587664f, 0.04409255f, -0.02093449f, -0.02734663f, -0.06892732f, 
    -0.04203435f, 0.07036436f, 0.01592683f, 0.05688087f, 0.06295939f, -0.04890865f, 0.02673573f, 0.03765163f, 
    -0.01039989f, 0.04240679f, -0.06745552f, 0.05882288f, -0.03501058f, -0.01440212f, 0.06140227f, -0.04438340f, 
    -0.01672581f, -0.05864053f, 0.05820150f, 0.01207485f, -0.05894804f, 0.04917264f, -0.04746901f, -0.02976464f, 
    -0.01942957f, 0.03271990f, 0.00124539f, -0.04101831f, -0.04182855f, -0.05865538f, 0.00363852f, -0.04496244f, 
    0.02089454f, -0.03962395f, -0.06008033f, -0.01951934f, -0.00086677f, -0.07337778f, 0.03044381f, -0.02731486f, 
    0.01101792f, 0.05019215f, 0.00910062f, -0.02951441f, -0.07579370f, 0.06198118f, 0.05415061f, -0.01165580f, 
    -0.05827283f, -0.04523864f, 0.02708105f, 0.02002821f, -0.02530572f, -0.03011260f, -0.01101769f, 0.02151165f, 
    -0.03632582f, -0.00927142f, 0.05622438f, 0.05660837f, -0.01743989f, -0.03918042f, 0.04600473f, -0.04393972f, 
    0.05196246f, 0.01396656f, -0.01944291f, -0.04607797f, -0.01311876f, -0.05636372f, -0.06261013f, -0.00076045f, 
    -0.06642731f, 0.02280877f, -0.06464204f, -0.02060281f, 0.06507086f, 0.05872979f, -0.06429832f, -0.05253584f, 
    0.03981148f, -0.04210802f, -0.05377493f, 0.02103111f, -0.01145053f, -0.01962537f, 0.01431235f, 0.04137120f, 
    0.00720453f, -0.06603147f, -0.04965219f, -0.03598807f, 0.05604956f, -0.07077842f, 0.01827842f, 0.04442775f, 
    -0.07257040f, 0.02084483f, -0.03886042f, 0.02015324f, -0.00803794f, 0.04433229f, 0.04351287f, 0.02380173f, 
    -0.04739774f, -0.00848723f, 0.02178237f, 0.05233962f, -0.05578011f, 0.05941280f, -0.04809699f, 0.03862946f, 
    -0.03983531f, 0.02162649f, -0.06861176f, -0.06703591f, -0.07105764f, -0.07312591f, -0.00702694f, -0.00837167f, 
    -0.02873685f, -0.06175378f, -0.00492846f, 0.02910996f, 0.01471929f, -0.03230599f, -0.03698539f, 0.05694309f, 
    -0.01792699f, 0.00844467f, 0.02096566f, -0.01930669f, -0.07047277f, -0.07357524f, -0.01659558f, -0.07381413f, 
    0.00279088f, -0.00295019f, 0.01354014f, -0.05713305f, 0.04478753f, -0.02209994f, -0.01677498f, -0.07500620f, 
    0.04792292f, -0.07011272f, -0.06628174f, -0.01918201f, 0.01318671f, -0.01689849f, -0.00687200f, -0.07143295f, 
    -0.04120794f, 0.09604071f, -0.08878606f, 0.16792327f, -0.05268512f, -0.04699319f, -0.04008973f, 0.10139959f, 
    0.01948945f, 0.12637664f, -0.11200208f, -0.00901690f, -0.15405869f, -0.09447263f, 0.19686396f, 0.04468995f, 
    0.03338287f, -0.14122869f, 0.01476392f, 0.03618356f, 0.02982892f, 0.17396502f, 0.04164108f, -0.04505198f, 
    0.41399154f, -0.02322603f, 0.43277836f, -0.00005180f, -0.08625404f, 0.17473587f, -0.16304362f, 0.05251791f, 
    -0.15905063f, -0.02135375f, 0.05448928f, -0.00687544f, 0.21818955f, -0.32983518f, 0.33875126f, -0.10185514f, 
    0.13311803f, -0.05518367f, -0.04473794f, -0.01718214f, 0.01854756f, 0.02785566f, 0.03049302f, -0.01328736f, 
    -0.25697970f, -0.04507703f, -0.11566343f, 0.26522580f, 0.18522656f, -0.00581459f, 0.03537688f, -0.05209443f, 
    0.07684040f, 0.10444903f, -0.13859962f, 0.07484145f, -0.00294795f, 0.13826524f, 0.13051125f, 0.24555102f, 
    -0.02090471f, -0.02066598f, 0.11119269f, 0.08977044f, 0.01462976f, 0.16021949f, -0.02033302f, -0.05633586f, 
    -0.09309147f, -0.19905363f, 0.08138154f, 0.21944462f, 0.08680744f, -0.01159865f, -0.04517280f, -0.08284659f, 
    0.05246013f, 0.05714159f, -0.10193320f, -0.02398642f, 0.17891859f, -0.16163449f, 0.11975512f, -0.03325617f, 
    0.01063723f, 0.09628616f, 0.06239518f, 0.09259473f, -0.01591343f, 0.00071372f, 0.07291256f, 0.01480129f, 
    0.00842781f, -0.08995382f, -0.03202654f, 0.04670404f, -0.01798625f, -0.04195357f, -0.08517224f, -0.02107791f, 
    -0.09005346f, -0.03350484f, 0.03232551f, 0.08942077f, 0.26467264f, -0.11322615f, 0.20953502f, -0.05385651f, 
    -0.11241580f, -0.03457810f, -0.04578799f, 0.02376389f, -0.11556562f, -0.05581301f, -0.00161546f, -0.03477787f, 
    0.06678578f, 0.18631092f, 0.33465308f, 0.06298750f, -0.02181466f, -0.09004807f, -0.05300026f, -0.00936841f, 
    -0.06935296f, 0.03783516f, -0.00287487f, -0.07462797f, -0.16537489f, 0.11541275f, -0.18909881f, 0.21734025f, 
    0.19681098f, -0.00097245f, -0.08003125f, -0.00415768f, -0.14905658f, -0.06035404f, 0.04325046f, 0.04424118f, 
    -0.46754512f, -0.00347215f, -0.04928320f, -0.03679815f, 0.10110550f, -0.08180071f, -0.03743530f, -0.08439820f, 
    -0.03167115f, -0.01342319f, 0.15051137f, 0.00641555f, -0.10003886f, -0.25600249f, 0.00355785f, 0.10621241f, 
    -0.00182004f, 0.03824724f, 0.16024734f, 0.00808220f, 0.07084118f, 0.04538104f, 0.02556469f, -0.00794729f, 
    -0.14628170f, 0.16285554f, 0.10770554f, 0.28645477f, 0.08082424f, 0.04444885f, 0.07875045f, -0.07759561f, 
    -0.04796558f, 0.02580017f, 0.15390976f, 0.28573677f, -0.11806322f, -0.10656974f, 0.07544284f, 0.24669056f, 
    -0.15953493f, 0.00088249f, -0.18889627f, -0.05696184f, 0.10171880f, -0.06534862f, 0.08975449f, 0.06299280f, 
    0.01204818f, 0.06085084f, -0.00594693f, -0.06904081f, -0.00217472f, -0.05186962f, -0.00953821f, 0.04524811f, 
    -0.01427920f, 0.00772210f, -0.05512477f, 0.01488854f, -0.07591588f, -0.03335766f, 0.06572366f, 0.00928401f, 
    -0.06359679f, -0.04795530f, -0.00936351f, 0.00853902f, 0.00517752f, -0.05312726f, 0.04219103f, 0.01736357f, 
    0.04629965f, -0.00725132f, -0.01757072f, -0.03199566f, -0.00890710f, 0.02206642f, -0.02608982f, -0.01651486f, 
    -0.06838617f, -0.03352522f, -0.04553955f, -0.06066129f, 0.01968027f, -0.00153599f, 0.05038030f, -0.03593421f, 
    -0.07587490f, 0.00164170f, -0.03216910f, -0.06380561f, -0.02251542f, 0.00487080f, 0.03985424f, -0.02404418f, 
    -0.04277643f, -0.06597653f, 0.02283556f, -0.03592571f, 0.05733005f, -0.04196679f, 0.02512063f, 0.04879503f, 
    -0.05006051f, -0.01266545f, -0.06767658f, 0.02936956f, 0.04579224f, -0.05773001f, 0.05054047f, 0.05866548f, 
    -0.01125272f, 0.03458871f, 0.03754038f, -0.03517700f, -0.06513263f, -0.01649031f, -0.06216971f, 0.03909428f, 
    -0.04076772f, 0.05333151f, 0.05798582f, -0.06974438f, 0.02139418f, -0.01174296f, 0.06398001f, -0.02341675f, 
    -0.03578580f, 0.00413739f, -0.05168522f, 0.01574187f, 0.00700990f, 0.01664581f, 0.04199727f, 0.05471267f, 
    -0.07613565f, -0.04040623f, 0.03644500f, -0.03875764f, -0.03826899f, 0.00321982f, -0.00311806f, -0.07253332f, 
    -0.01215318f, -0.05786430f, -0.00106936f, 0.04143020f, 0.05569215f, 0.00005646f, -0.02964235f, -0.03137471f, 
    0.05307065f, 0.02547328f, -0.02270453f, -0.00947616f, 0.00453238f, -0.02398202f, -0.02934447f, -0.02646849f, 
    -0.05283201f, -0.02927322f, 0.00617098f, -0.03291157f, 0.02483606f, 0.00894357f, 0.02286310f, -0.00791127f, 
    0.03864679f, -0.06762888f, -0.04680201f, -0.00225423f, -0.00798957f, 0.06228403f, 0.01043868f, 0.03742836f, 
    -0.05088012f, -0.06413136f, -0.00280464f, -0.06957629f, -0.02203351f, -0.06720084f, -0.01720887f, -0.05035949f, 
    -0.05409583f, -0.01810410f, 0.02908571f, 0.01172936f, -0.03087910f, -0.00385840f, 0.01240011f, -0.04618820f, 
    0.00461935f, -0.04245695f, 0.06610666f, 0.00985217f, -0.06529500f, -0.05427473f, 0.00256023f, -0.02292727f, 
    0.04681964f, -0.01805414f, -0.00495291f, -0.07244248f, 0.00348390f, -0.03816231f, 0.01565595f, 0.04060361f, 
    -0.03541241f, -0.01778328f, -0.05222493f, 0.04728503f, -0.06267211f, -0.06666525f, -0.02434544f, -0.03123155f, 
    -0.04983257f, -0.03781278f, 0.05254699f, 0.03081175f, -0.07505343f, -0.01244542f, 0.06610593f, -0.04069096f, 
    -0.07346065f, 0.00033762f, 0.02714629f, 0.04714877f, -0.06742253f, -0.04136401f, 0.02857649f, 0.02689600f, 
    -0.02265455f, -0.03702112f, 0.00037152f, -0.02572709f, 0.03665562f, -0.00324850f, -0.02137787f, 0.04134317f, 
    0.10519753f, 0.16536516f, 0.10363153f, 0.11252033f, 0.05585318f, -0.01783405f, 0.15893455f, -0.11020332f, 
    0.19884396f, 0.01663885f, 0.14553568f, 0.07714205f, -0.32811025f, -0.26186019f, -0.35444745f, -0.17078935f, 
    0.00960220f, 0.05533844f, 0.08049522f, 0.01324066f, 0.16644879f, 0.01059788f, 0.06000439f, -0.19133328f, 
    0.39335337f, 0.17211781f, 0.10633295f, -0.07819349f, -0.08660436f, 0.05606646f, -0.04608305f, 0.02214141f, 
    0.05714250f, -0.00472149f, 0.05252511f, -0.01634019f, -0.12781203f, 0.18910903f, 0.02152285f, 0.08787948f, 
    -0.11118413f, -0.21216299f, -0.22718720f, -0.03410908f, 0.02953700f, 0.00681549f, 0.01366487f, 0.06000943f, 
    0.01682781f, 0.08657493f, 0.13344486f, 0.00600816f, 0.20805572f, -0.03975201f, 0.20175754f, -0.00639290f, 
    -0.01143541f, -0.08452050f, 0.17872761f, 0.02260385f, -0.05088156f, -0.00809093f, 0.05666561f, 0.00887960f, 
    0.22533968f, 0.03401678f, 0.07781381f, 0.05085347f, -0.08578095f, -0.07820050f, -0.04661454f, -0.17844492f, 
    0.05173016f, 0.21131168f, -0.03976638f, -0.12698087f, 0.10378052f, 0.18772741f, 0.13994101f, 0.05792798f, 
    -0.01680055f, 0.06898667f, 0.02544689f, 0.14276999f, 0.08884285f, 0.29194430f, -0.02564577f, -0.17679776f, 
    0.07602352f, -0.02508636f, -0.01719935f, 0.07684553f, 0.00215746f, 0.14509664f, 0.07643633f, 0.08720689f, 
    -0.15588656f, 0.09467148f, -0.02591502f, 0.18540536f, -0.19967453f, -0.06112035f, -0.04243971f, -0.08047822f, 
    0.10574193f, 0.02786426f, -0.09276909f, 0.15116875f, -0.05097276f, 0.23340583f, 0.28118494f, -0.06740928f, 
    0.03469334f, -0.13791777f, -0.09981240f, -0.05463038f, -0.21705824f, 0.07020539f, 0.06341632f, -0.11553095f, 
    0.22565116f, 0.23653695f, 0.19491050f, 0.13529210f, -0.11356895f, -0.13061717f, -0.11323772f, -0.10741304f, 
    0.06481162f, -0.14648315f, -0.05726198f, -0.13740800f, -0.09144179f, 0.01054153f, -0.24397770f, 0.20597088f, 
    -0.18438862f, 0.04604613f, 0.04920897f, -0.05151245f, 0.05631198f, 0.04261571f, 0.02869848f, 0.20078960f, 
    0.21289811f, -0.07817389f, -0.14247863f, 0.19500351f, -0.13511632f, -0.12510303f, -0.06234048f, -0.17720625f, 
    0.12097772f, -0.11905184f, 0.07735289f, -0.01383149f, 0.05639614f, 0.16875982f, 0.20899494f, -0.18077217f, 
    0.07223438f, -0.17029217f, -0.06612997f, 0.09110558f, 0.16508605f, -0.08439167f, -0.09542245f, -0.11008496f, 
    -0.18327267f, -0.06261935f, 0.08089207f, -0.00415336f, 0.04206667f, -0.05535170f, 0.03661703f, 0.24102037f, 
    -0.02703717f, -0.03738494f, 0.07840926f, 0.12354362f, 0.04044126f, 0.16833504f, 0.07149176f, -0.11647534f, 
    -0.03669335f, -0.13062273f, -0.01458299f, 0.04164663f, -0.13551854f, 0.01340196f, 0.03506382f, -0.04330477f, 
    0.20129816f, 0.11621042f, 0.09581692f, -0.01554869f, -0.03033484f, -0.08174209f, -0.01056298f, -0.11346120f, 
    -0.04137022f, -0.13816746f, -0.13627759f, -0.07800001f, 0.01605609f, 0.04614869f, -0.25913239f, -0.01314873f, 
    -0.12727994f, -0.13221911f, -0.14005154f, -0.08254351f, -0.05043867f, -0.11292133f, -0.16560087f, -0.06592713f, 
    0.28545648f, 0.24293247f, -0.16484921f, -0.03175266f, 0.00419000f, -0.03505338f, 0.04357813f, -0.00820887f, 
    0.01841760f, -0.02369336f, -0.02520973f, 0.03432573f, -0.01516454f, -0.04776593f, -0.07396699f, 0.28483099f, 
    -0.13364375f, -0.05389152f, 0.14428940f, -0.11941247f, -0.04514688f, -0.13586064f, -0.09750129f, 0.01066339f, 
    -0.05700450f, -0.02702028f, -0.22224744f, -0.21657892f, -0.00431321f, 0.07192272f, 0.11799416f, 0.04335998f, 
    0.10618616f, -0.04213693f, -0.06828132f, -0.13667975f, 0.23167419f, -0.26045290f, -0.04748482f, 0.04654322f, 
    0.01891520f, 0.05791204f, 0.06234842f, -0.01246547f, -0.04093970f, 0.06698498f, 0.17948766f, 0.21721175f, 
    -0.09609707f, -0.10750746f, -0.23494513f, -0.33298188f, 0.00002257f, -0.25177994f, -0.12766407f, 0.13553873f, 
    -0.01846080f, -0.06404828f, -0.03396293f, 0.04661369f, -0.05670884f, 0.10390870f, -0.19244607f, -0.02440571f, 
    0.08211025f, -0.03957348f, 0.12145240f, -0.05868127f, -0.17170832f, -0.09660334f, -0.13791279f, -0.01227149f, 
    0.03301980f, 0.27629089f, 0.30788183f, 0.16803624f, 0.01382841f, -0.02202054f, 0.01648610f, 0.00210059f, 
    0.05851125f, 0.13160373f, 0.04917830f, 0.10404877f, 0.28556928f, 0.12275799f, 0.08186595f, 0.06400687f, 
    0.09895438f, 0.21826097f, 0.05017416f, -0.08944935f, -0.09938809f, -0.11120743f, 0.12105528f, 0.03682634f, 
    0.20296758f, 0.23496839f, -0.01509685f, 0.15429845f, 0.03182113f, 0.03444978f, -0.04657861f, -0.06842609f, 
    -0.05048783f, 0.03787843f, 0.00108412f, -0.01630935f, -0.02325482f, -0.04589593f, 0.07164714f, 0.02477305f, 
    -0.09072313f, 0.05854518f, -0.11614782f, -0.02946033f, -0.08780047f, -0.04920685f, 0.01437632f, 0.07945289f, 
    0.34100157f, 0.16590847f, 0.09252348f, 0.15198372f, 0.00723778f, 0.15943158f, -0.00174751f, -0.05380329f, 
    0.00730739f, 0.12764254f, 0.00681069f, -0.02471034f, -0.11185476f, -0.13816682f, -0.22478999f, 0.11878859f, 
    0.06050431f, -0.01455814f, 0.13959268f, 0.13072604f, 0.06105514f, 0.04811398f, 0.19777651f, 0.06765208f, 
    0.13961442f, 0.05964048f, 0.10110354f, 0.03851192f, -0.03442040f, -0.00922196f, 0.07552621f, 0.10431501f, 
    0.09492186f, 0.05828129f, -0.03981236f, -0.06083516f, 0.19812542f, -0.20509422f, -0.08471432f, 0.02723096f, 
    -0.03077811f, 0.04977164f, 0.26708969f, 0.30167007f, -0.03493878f, 0.02210984f, 0.09202679f, 0.00233233f, 
    -0.03876770f, 0.09918395f, 0.01266360f, 0.02566594f, 0.07156909f, -0.02553858f, -0.05002940f, 0.05137330f, 
    0.02035637f, 0.02800979f, 0.19680099f, -0.00287619f, -0.02527380f, 0.21086538f, 0.09336349f, 0.15005618f, 
    -0.04608884f, -0.09340183f, 0.01637639f, 0.00981230f, -0.04032049f, 0.06659687f, 0.09787241f, 0.03059066f, 
    0.35310686f, 0.09867161f, -0.47364488f, -0.22682035f, 0.07896296f, 0.13432236f, 0.14425530f, 0.01432007f, 
    -0.04099599f, -0.07608078f, -0.01358937f, 0.07080273f, -0.03077055f, -0.07627728f, -0.10898088f, -0.33375227f, 
    0.10267504f, 0.09789746f, 0.06030644f, -0.09768364f, -0.09956437f, -0.03343156f, 0.00507635f, 0.13250794f, 
    -0.13398904f, -0.26305681f, -0.06590649f, 0.44510847f, -0.08987569f, 0.08459323f, -0.04191954f, 0.12835214f, 
    0.09983356f, 0.08487175f, 0.18237270f, -0.02772326f, 0.53203458f, 0.17412047f, -0.07468259f, -0.04014144f, 
    -0.05935594f, 0.08005817f, 0.21369129f, 0.06336423f, 0.10606199f, 0.02888197f, -0.02592750f, 0.13833998f, 
    -0.11213989f, 0.09440241f, 0.14472017f, -0.18907049f, -0.16783604f, -0.04149342f, 0.08269322f, 0.01101553f, 
    0.06201551f, 0.07848505f, -0.03319477f, -0.03671975f, -0.33347458f, -0.09583359f, 0.03511522f, 0.17706153f, 
    0.12710702f, -0.03659201f, 0.17695463f, -0.07432162f, 0.07720298f, 0.06826623f, 0.00578919f, 0.12416205f, 
    0.15817185f, 0.06297477f, 0.12801279f, 0.15839708f, 0.03508515f, -0.05676365f, -0.11511824f, -0.12159887f, 
    0.16262032f, 0.01621553f, 0.13765244f, 0.11842456f, 0.14696582f, -0.06261697f, -0.14806883f, -0.05355799f, 
    0.02297359f, 0.16858020f, 0.18071926f, -0.01086982f, -0.04171158f, -0.06658547f, -0.06444896f, -0.11301903f, 
    -0.08039648f, -0.02059462f, 0.01217760f, 0.00062205f, 0.11187992f, 0.11539976f, 0.04517621f, 0.04805273f, 
    -0.06834999f, 0.03453999f, -0.09382772f, -0.04468314f, -0.13180150f, -0.07890905f, 0.05005881f, 0.20867197f, 
    0.19176455f, -0.07943076f, 0.01832237f, -0.03310421f, -0.10725232f, -0.00953117f, 0.03303474f, -0.00082819f, 
    0.11291719f, -0.43711290f, 0.12216161f, 0.50449961f, 0.02460470f, 0.02381557f, -0.09007083f, 0.12185409f, 
    0.03255143f, 0.11560795f, 0.06039719f, -0.01590663f, -0.19095284f, -0.13698617f, 0.03700965f, -0.05931040f, 
    -0.14646640f, 0.07141152f, -0.11262771f, 0.04009063f, -0.02549182f, -0.05203208f, 0.13729422f, -0.12318034f, 
    0.11300026f, 0.10212497f, 0.07542764f, -0.14281759f, -0.00866834f, -0.09081276f, 0.14719722f, 0.13496307f, 
    0.04673556f, 0.14076960f, -0.05346004f, 0.14484362f, -0.11531416f, -0.03452116f, -0.13893031f, -0.02264517f, 
    -0.09868982f, 0.00913656f, 0.18184488f, -0.12319798f, -0.01728445f, -0.02986229f, -0.06904449f, 0.03406468f, 
    0.02773765f, -0.05588244f, -0.03723998f, -0.25258580f, -0.05246779f, -0.13780425f, 0.04627685f, 0.10283346f, 
    -0.22020301f, -0.15270887f, -0.10012913f, -0.15468027f, 0.30156958f, 0.30412886f, -0.05273668f, 0.07711381f, 
    -0.30864912f, -0.06446873f, -0.02826399f, -0.07150905f, -0.01249588f, -0.08289774f, -0.04975611f, 0.17441110f, 
    -0.06878956f, 0.28741205f, -0.01475658f, 0.00373738f, 0.07707740f, -0.04213569f, 0.00742990f, -0.12592557f, 
    0.11314642f, -0.14996976f, 0.14143874f, 0.03144156f, 0.02667727f, 0.15261517f, 0.25653157f, 0.29254413f, 
    0.15739493f, 0.08189298f, 0.20771836f, -0.06812067f, -0.07153197f, -0.10575060f, -0.11273418f, -0.24997912f, 
    0.07201716f, 0.00880558f, -0.23878536f, 0.20073654f, -0.04375849f, 0.01409944f, 0.08221073f, -0.13974580f, 
    0.00019807f, 0.13434874f, -0.15115063f, 0.04633086f, 0.13621476f, -0.00581799f, -0.05705265f, 0.02836668f, 
    -0.05172440f, -0.01884922f, 0.03395748f, -0.11261779f, 0.05235267f, 0.12859201f, 0.17879145f, 0.28860524f, 
    -0.25360996f, -0.16114140f, 0.00121683f, 0.08433113f, -0.17627013f, -0.07661816f, 0.10903478f, 0.18003248f, 
    0.00834296f, -0.13474387f, -0.06412211f, -0.08879500f, -0.24404798f, -0.04045620f, -0.06822570f, 0.22992280f, 
    -0.10267616f, 0.02323352f, 0.05722745f, 0.06502945f, -0.11230528f, -0.05623256f, -0.05920997f, -0.21285842f, 
    0.06071756f, 0.15479693f, 0.05500931f, -0.25790107f, 0.18407808f, 0.06155366f, 0.00819732f, 0.01965792f, 
    0.13118404f, 0.20870143f, 0.08973502f, 0.01383709f, 0.11745018f, 0.07470825f, -0.29865286f, 0.02878652f, 
    0.00029802f, 0.04773270f, 0.14216213f, -0.06371561f, 0.02625967f, -0.14147057f, -0.07943635f, -0.06092220f, 
    -0.12213328f, -0.15493010f, -0.10023272f, -0.11937995f, -0.01860369f, 0.17858128f, 0.01252515f, 0.12217581f, 
    0.07187527f, 0.04899582f, -0.07744762f, -0.08976437f, 0.27408835f, -0.15967619f, 0.08108829f, -0.00994000f, 
    0.03805152f, -0.06051750f, -0.08810548f, 0.04513012f, 0.04812787f, -0.01325034f, 0.09746620f, -0.17484072f, 
    0.15718071f, -0.04459686f, -0.18740126f, 0.09686036f, -0.09238772f, 0.21943229f, -0.12054363f, -0.03935048f, 
    0.06504001f, 0.21555717f, 0.07701864f, 0.16288821f, -0.10053153f, -0.18114263f, -0.06491782f, 0.33509275f, 
    -0.05101669f, -0.02518421f, 0.15766494f, 0.04092715f, -0.03986900f, -0.02634357f, 0.15333283f, 0.12455776f, 
    0.05185567f, 0.04611379f, 0.06135726f, -0.00953097f, 0.02205986f, -0.04706423f, 0.15467127f, -0.01416422f, 
    -0.01394291f, -0.04824876f, -0.18480751f, -0.11704269f, -0.00890693f, 0.09437748f, -0.07010194f, 0.17551655f, 
    0.02284274f, 0.08236737f, 0.12907074f, 0.12433792f, 0.23769157f, 0.09895042f, 0.00974813f, 0.00532309f, 
    -0.04923357f, -0.01924537f, -0.04154996f, -0.07771888f, 0.03609880f, 0.03149819f, 0.03971198f, 0.04167634f, 
    0.05690961f, -0.06837148f, -0.05538857f, 0.03929476f, -0.05001289f, -0.09313542f, -0.08509956f, -0.02022069f, 
    -0.05093069f, -0.02115533f, 0.02797141f, -0.04205817f, -0.00826591f, 0.03289673f, 0.03563931f, -0.00939056f, 
    -0.05666919f, 0.02823415f, -0.05756363f, 0.00231548f, 0.04499169f, 0.00708718f, -0.04218969f, 0.05289416f, 
    -0.08333191f, -0.05833831f, 0.02486250f, -0.06562125f, -0.03749222f, -0.07009601f, -0.04729959f, 0.01926154f, 
    0.05676018f, 0.03419586f, -0.05036241f, 0.02297573f, -0.07211315f, 0.06627555f, 0.04355827f, 0.02827589f, 
    0.02831495f, -0.05378213f, 0.06000184f, 0.06742479f, -0.06331935f, 0.06137596f, 0.03785571f, -0.01317536f, 
    0.01090054f, -0.02702883f, -0.04553027f, -0.02930203f, -0.02066785f, -0.03715510f, -0.04276175f, -0.03301629f, 
    0.01330454f, 0.05712271f, 0.01890920f, -0.03635136f, -0.07573417f, 0.04199278f, -0.04220760f, -0.00913755f, 
    0.01847116f, -0.04141519f, 0.05364015f, -0.00597501f, 0.00647856f, 0.03040047f, -0.07269596f, -0.05129948f, 
    0.03740033f, 0.04860159f, 0.06025723f, 0.05563981f, -0.06675531f, -0.01549491f, -0.07065271f, -0.00028338f, 
    -0.05838633f, -0.06549276f, -0.01813716f, -0.05212661f, -0.07697509f, -0.07915616f, -0.05278468f, -0.03218913f, 
    -0.05918178f, -0.06414761f, 0.04524760f, 0.04730512f, -0.02512086f, 0.04027418f, -0.05099782f, -0.00641999f, 
    -0.05346304f, 0.03189455f, 0.05454662f, 0.03006494f, 0.04021386f, -0.04411680f, -0.00717502f, -0.05866382f, 
    -0.05484116f, -0.08387212f, -0.04061696f, -0.03892479f, 0.04047005f, -0.08284835f, -0.03556946f, -0.07355509f, 
    -0.04917775f, 0.02117483f, 0.05428440f, 0.05006368f, -0.03864428f, 0.03962995f, -0.04216269f, -0.00025438f, 
    -0.07422253f, 0.03321914f, -0.03993882f, 0.03317373f, -0.01899788f, -0.06006226f, -0.02068176f, 0.00954095f, 
    -0.06494422f, -0.06824958f, -0.09951167f, 0.04171009f, -0.07628864f, -0.05077248f, -0.07161883f, 0.00149642f, 
    -0.08131372f, -0.08039897f, -0.00482379f, 0.04733283f, -0.07108872f, -0.06914531f, -0.05601928f, -0.06475306f, 
    -0.05097964f, -0.02260797f, -0.01432695f, -0.00954815f, 0.05476509f, 0.05795616f, 0.03725358f, -0.01687035f, 
    -0.01003574f, 0.03791856f, -0.03926458f, 0.05116913f, -0.02203588f, -0.04606577f, 0.01047174f, 0.01363762f, 
    -0.08925469f, 0.02550813f, 0.05183568f, -0.02152172f, -0.05475026f, -0.05920301f, -0.07679112f, -0.00666666f, 
    0.02903441f, 0.05940239f, -0.03384381f, 0.03912865f, -0.05483604f, -0.04970408f, 0.03092013f, -0.05037431f, 
    0.02298234f, 0.03797254f, -0.05135556f, 0.04210027f, 0.02036987f, 0.05619469f, -0.05447612f, 0.02642660f, 
    0.00467100f, -0.07173426f, 0.04725690f, -0.02654726f, -0.05234597f, 0.03793436f, -0.06105142f, 0.04558892f, 
    0.03534447f, 0.05122745f, -0.00656716f, -0.03824068f, 0.01142269f, 0.02339084f, 0.05659860f, -0.02876599f, 
    -0.02790006f, -0.00305054f, -0.01470581f, -0.00907893f, -0.03263848f, -0.00166648f, 0.01854079f, 0.00839189f, 
    0.05350283f, -0.01857792f, -0.07186919f, 0.07327954f, -0.03332444f, -0.00474660f, -0.06669803f, 0.03916938f, 
    0.02644075f, -0.06026479f, -0.02865494f, 0.06382918f, -0.03450098f, 0.01883315f, 0.06004921f, 0.00684090f, 
    -0.06258889f, -0.06396645f, -0.00701004f, -0.04925936f, -0.05946790f, 0.00079495f, -0.05942002f, -0.07134738f, 
    0.02958954f, -0.03575955f, 0.04635004f, 0.05122508f, 0.03452221f, -0.02055120f, -0.01847630f, -0.02392535f, 
    -0.01506885f, 0.04380827f, -0.02839835f, 0.03709680f, 0.03098437f, 0.02709293f, 0.01167420f, -0.02566003f, 
    -0.02874870f, -0.05842881f, 0.06209898f, -0.05928313f, 0.02582852f, 0.06010761f, -0.02046871f, -0.07582758f, 
    0.06154185f, -0.00721226f, 0.02167704f, -0.06543004f, 0.01962706f, -0.01635857f, 0.02546443f, -0.05059102f, 
    -0.01511317f, 0.01721498f, 0.06123504f, -0.05403162f, -0.01073480f, -0.03330882f, -0.01109111f, 0.04486993f, 
    -0.01224904f, 0.04066045f, -0.06781919f, -0.07509099f, -0.01466926f, -0.00884705f, -0.06901522f, -0.01596576f, 
    -0.03421988f, 0.03421356f, -0.01651975f, -0.03625680f, -0.05785571f, 0.04072938f, -0.05463941f, -0.05292109f, 
    -0.02401765f, 0.01426921f, 0.05141315f, -0.07455061f, -0.00665953f, -0.04814997f, -0.02217650f, -0.01621992f, 
    -0.05787115f, 0.03821574f, 0.02797013f, 0.00331291f, 0.02313289f, 0.02222692f, -0.05967201f, -0.01245117f, 
    -0.00523537f, -0.06782994f, 0.03799303f, -0.04798843f, -0.04918320f, -0.00669988f, 0.02583895f, -0.07842665f, 
    0.03888607f, -0.04553217f, 0.05488936f, -0.06685185f, -0.01868501f, -0.03764055f, 0.00924286f, -0.06074551f, 
    -0.06657492f, -0.03763800f, 0.05261106f, -0.04966698f, 0.05435196f, -0.04775513f, -0.03768729f, 0.00602877f, 
    0.04704783f, 0.01762128f, -0.05625795f, 0.03821325f, -0.00874714f, 0.01265098f, 0.02580423f, -0.02068527f, 
    0.04803561f, 0.04662594f, -0.04095272f, -0.00119554f, 0.03720365f, 0.02433862f, -0.02964544f, -0.09327766f, 
    -0.00250578f, -0.03263753f, 0.00229045f, -0.03827422f, -0.03239863f, 0.02485949f, 0.04713087f, -0.05534539f, 
    0.00707616f, -0.03978438f, -0.01182800f, 0.02862833f, -0.01836899f, 0.00005752f, 0.01220703f, 0.02028674f, 
    0.03399221f, 0.00789913f, -0.07439003f, 0.05102808f, -0.08513764f, 0.03254154f, -0.00499515f, -0.03660748f, 
    -0.05742912f, -0.03102222f, -0.04774147f, -0.06849504f, 0.03928018f, -0.02624823f, 0.02612130f, 0.01199242f, 
    -0.06435316f, -0.01198042f, -0.07565272f, -0.04057099f, -0.02778404f, -0.06495968f, -0.06758585f, 0.06087431f, 
    0.01445686f, -0.07618202f, -0.00132770f, -0.07297370f, 0.01501096f, 0.04800604f, -0.06000557f, 0.04980936f, 
    0.04316061f, -0.03009249f, -0.03072107f, -0.06907466f, 0.04639309f, 0.01574389f, -0.01421308f, -0.02447844f, 
    -0.01302195f, 0.00195942f, -0.06271795f, 0.00789032f, -0.00369540f, 0.02096337f, 0.01791739f, -0.05977882f, 
    0.04690033f, 0.01391649f, -0.01946867f, 0.06261735f, -0.01533516f, -0.06778987f, 0.02676854f, 0.04911795f, 
    0.02551132f, -0.01389008f, -0.03892102f, 0.04404037f, -0.06178967f, -0.05855135f, -0.01513439f, -0.02987185f, 
    -0.05393412f, 0.03251219f, 0.04254635f, -0.01657463f, 0.03619852f, -0.04265010f, -0.03939665f, -0.04548910f, 
    -0.04965430f, -0.08156589f, -0.06881553f, 0.01004101f, 0.02596882f, -0.02469160f, -0.05696201f, 0.01311822f, 
    -0.03364002f, 0.05396088f, 0.04200912f, -0.02317803f, 0.00143741f, 0.01347336f, 0.01109231f, -0.03888882f, 
    -0.02631755f, 0.02708602f, 0.00551620f, 0.00836811f, -0.06721823f, -0.03410374f, -0.05606664f, 0.03940822f, 
    0.05932778f, 0.04038101f, -0.02455253f, 0.01078946f, -0.06819533f, 0.05047267f, -0.00755978f, 0.00642099f, 
    -0.00528693f, 0.00804489f, -0.04076366f, 0.05579962f, -0.07498929f, -0.00030107f, -0.01858685f, -0.06402197f, 
    0.06586343f, 0.01490346f, -0.03410485f, -0.03740522f, 0.01075963f, 0.00355268f, 0.06683309f, -0.04595639f, 
    0.01588589f, -0.03201633f, -0.07763016f, -0.05040060f, -0.05565459f, -0.03332224f, 0.06061384f, 0.05114183f, 
    -0.04731740f, -0.03921548f, 0.02637081f, 0.03817912f, 0.01776626f, -0.05445282f, 0.04916428f, -0.00522328f, 
    0.06118476f, -0.01402599f, -0.07572427f, -0.01301348f, -0.02750859f, -0.05303328f, 0.01143491f, -0.00831498f, 
    -0.04768267f, 0.00409422f, 0.02068142f, 0.05595760f, -0.03407439f, 0.02890291f, -0.04372564f, -0.02296860f, 
    -0.08483462f, -0.00173282f, 0.03062026f, -0.03694690f, -0.00232381f, -0.00490714f, -0.01923609f, -0.05472917f, 
    0.04029154f, -0.00953896f, 0.00850230f, 0.04883465f, 0.01868265f, 0.01939053f, 0.02501757f, -0.05500174f, 
    0.04824475f, 0.02635499f, 0.04478743f, 0.04140025f, 0.03536490f, -0.05423240f, 0.01594245f, 0.00022217f, 
    -0.03232102f, 0.04841316f, -0.05256635f, 0.01257881f, -0.01814338f, 0.05503773f, -0.00502743f, -0.06279467f, 
    -0.07161124f, -0.03250066f, 0.05763939f, -0.00256119f, 0.04566101f, 0.06153056f, -0.05298579f, 0.01363144f, 
    0.01227623f, -0.01390363f, -0.04416322f, -0.06567901f, -0.06235180f, -0.02257609f, -0.07021142f, 0.00396640f, 
    0.06395090f, 0.00484285f, -0.07165961f, 0.04275673f, -0.00382870f, 0.04079952f, -0.06300427f, 0.01696375f, 
    0.02723079f, -0.03563453f, 0.01242474f, -0.07112090f, 0.10317042f, -0.03649243f, -0.01599329f, 0.11467808f, 
    0.03293722f, 0.02614874f, -0.09049983f, 0.03652693f, 0.03425787f, 0.18097399f, 0.00286448f, 0.13199370f, 
    0.00241715f, 0.09392787f, 0.07101603f, -0.00559687f, 0.09965988f, 0.11056629f, 0.12612060f, 0.04288047f, 
    0.03722888f, 0.16925299f, 0.20849392f, 0.00161095f, 0.00872863f, 0.06424415f, -0.04873971f, 0.03733075f, 
    -0.02776232f, 0.01657036f, -0.03655649f, 0.04038548f, -0.22342452f, -0.18923406f, 0.15029848f, -0.01266968f, 
    0.02405285f, 0.11630031f, 0.11817956f, 0.06414272f, -0.07148747f, -0.00813424f, 0.02742261f, -0.13724975f, 
    0.17757882f, -0.06513120f, -0.28161520f, 0.35146487f, -0.04370519f, 0.16187404f, 0.01001515f, -0.15453187f, 
    0.02347081f, 0.05920747f, 0.11379122f, 0.03930131f, 0.37060338f, 0.21848173f, 0.02050548f, 0.10718472f, 
    0.09298118f, -0.04595368f, 0.16842274f, 0.05631625f, 0.18820578f, 0.06204499f, 0.12948813f, 0.23258485f, 
    -0.26957700f, -0.33562726f, 0.09746656f, 0.03052319f, -0.03887042f, -0.12855655f, -0.01504485f, -0.01142474f, 
    -0.05644939f, -0.03534436f, 0.01520355f, -0.12811619f, 0.12434132f, -0.09834389f, -0.11366878f, 0.07989724f, 
    -0.03039528f, -0.03851160f, 0.07558663f, -0.06504528f, 0.01433073f, 0.06301193f, 0.04821507f, -0.01922107f, 
    -0.02926479f, 0.13419464f, 0.13582104f, -0.12218180f, 0.02400364f, 0.00708945f, -0.10262346f, -0.03447029f, 
    -0.01192010f, 0.22090082f, 0.07900836f, 0.13831829f, 0.08231219f, -0.01947608f, -0.11383486f, -0.03814821f, 
    -0.10926835f, 0.03147167f, 0.06984606f, -0.05618642f, 0.00985351f, -0.13130993f, -0.04142937f, -0.02387215f, 
    0.03012005f, -0.09707389f, 0.04392536f, -0.10654933f, 0.01615806f, -0.01804745f, 0.03113487f, 0.01595046f, 
    -0.02011374f, 0.01561282f, -0.06252710f, -0.15981796f, -0.01747814f, -0.07381403f, -0.10294658f, 0.11992664f, 
    0.12540895f, 0.00966022f, -0.05251196f, 0.00810456f, -0.03382771f, -0.01209385f, 0.03329696f, 0.11189827f, 
    -0.05481586f, -0.18280993f, -0.21895911f, 0.29733208f, -0.01109400f, -0.06662532f, -0.02984522f, -0.04004085f, 
    0.09794360f, 0.19974823f, 0.10231906f, 0.14993076f, -0.16307838f, -0.41913709f, -0.14201911f, 0.11486038f, 
    -0.16086103f, -0.10946160f, 0.16422816f, -0.14687322f, 0.04979936f, 0.10465535f, 0.11661586f, 0.01511441f, 
    -0.14282219f, 0.09078842f, 0.16547810f, 0.04909515f, 0.12424597f, -0.09046033f, 0.14249608f, 0.24345802f, 
    0.06059157f, 0.09690236f, 0.04363024f, 0.11037058f, -0.08495101f, -0.14763053f, -0.14897504f, 0.17194381f, 
    0.05130342f, 0.09127767f, 0.01371925f, 0.03368506f, 0.06484422f, 0.02660959f, 0.04868139f, 0.09053491f, 
    0.26458746f, -0.03673466f, 0.02193210f, -0.10130624f, -0.05337712f, 0.11501180f, -0.07459417f, -0.04853886f, 
    0.15266815f, 0.12691122f, 0.10781050f, 0.17240879f, -0.33489841f, -0.11333929f, -0.21613723f, -0.13485144f, 
    0.11572587f, 0.11601532f, -0.10859035f, -0.03867837f, 0.05763717f, 0.06884895f, -0.10214283f, -0.01529045f, 
    0.10411606f, 0.04522032f, 0.00658598f, 0.16739281f, -0.03786889f, 0.05240808f, -0.00087806f, -0.04131882f, 
    0.06869671f, -0.03046933f, -0.03504812f, 0.05263135f, -0.17963848f, 0.06659032f, -0.16182183f, 0.09381527f, 
    -0.28147402f, -0.08765836f, 0.11917938f, -0.13787116f, 0.09254856f, -0.02567576f, 0.00773763f, 0.10571676f, 
    0.24769023f, 0.14603443f, 0.22942202f, -0.39511696f, 0.19794744f, 0.11352869f, 0.05616377f, -0.00028374f, 
    -0.04002227f, -0.09647767f, -0.00956958f, -0.05815175f, -0.21784300f, -0.00286277f, -0.00268235f, 0.12744835f, 
    -0.05828977f, -0.11964247f, 0.08707045f, 0.03879597f, -0.12760700f, -0.06514937f, -0.11333223f, -0.21089436f, 
    0.18483235f, 0.10757168f, -0.15842393f, -0.11244842f, 0.13465519f, 0.00182949f, 0.12935184f, 0.02780427f, 
    0.08702400f, -0.05609823f, 0.12035982f, 0.12639035f, 0.25589749f, 0.06546579f, 0.03354948f, -0.12302397f, 
    0.08868732f, 0.11495969f, 0.09704421f, 0.16346721f, -0.02263223f, 0.11996254f, 0.10722115f, 0.03402982f, 
    -0.27421230f, 0.31087485f, 0.18915789f, 0.02707325f, -0.15462278f, -0.12467247f, -0.07818674f, -0.22453238f, 
    -0.05687199f, -0.00058634f, 0.09312575f, 0.07589347f, -0.17729606f, 0.03831715f, -0.20536208f, 0.03436761f, 
    -0.05801386f, 0.06623092f, 0.05803118f, 0.00284459f, -0.14330611f, -0.01173293f, 0.06281978f, -0.08441333f, 
    0.05162499f, 0.01850505f, -0.12940304f, 0.29028544f, -0.00011911f, 0.04419568f, 0.11962387f, -0.05216390f, 
    -0.00574336f, -0.07099367f, -0.11413133f, 0.05994348f, -0.00445892f, -0.03933778f, 0.01388651f, -0.05321628f, 
    0.01776802f, 0.08093238f, -0.03664870f, -0.15768653f, 0.05879752f, 0.11761601f, 0.12359599f, 0.24220820f, 
    0.07430266f, 0.17094566f, 0.23965482f, 0.04965851f, -0.02999548f, -0.13283865f, -0.14170717f, -0.16362752f, 
    0.08071378f, 0.03132299f, -0.03822016f, 0.00536507f, 0.05181621f, 0.14389969f, 0.07201574f, -0.14097545f, 
    0.17012586f, 0.24764988f, -0.05930713f, 0.06362461f, 0.12826526f, 0.00972134f, -0.08948884f, -0.20454454f, 
    -0.05043844f, -0.08014113f, -0.04799949f, 0.18888965f, -0.08527365f, 0.17812508f, -0.09980445f, -0.06454144f, 
    0.12475713f, 0.15112589f, -0.03676165f, 0.16506538f, 0.19581668f, 0.01717201f, 0.07687099f, -0.06375497f, 
    0.03903193f, 0.09023964f, 0.16311477f, -0.01039517f, -0.09480365f, 0.02300113f, -0.06881683f, -0.09478875f, 
    -0.12701736f, -0.06181600f, -0.20572039f, -0.04606615f, -0.00986179f, -0.11996914f, 0.01460812f, -0.06995170f, 
    -0.22091509f, -0.11894055f, -0.22652248f, -0.15261810f, 0.36778501f, 0.28909528f, 0.18330355f, 0.14095917f, 
    -0.00176395f, -0.05107964f, -0.04208510f, -0.06003872f, -0.06227047f, -0.17107897f, 0.03375271f, -0.06007960f, 
    -0.53724653f, -0.19851184f, -0.03825664f, 0.12407412f, 0.05817701f, -0.07275476f, -0.18174815f, -0.01359989f, 
    0.00518769f, -0.01900142f, 0.02448414f, 0.05484453f, -0.05171993f, -0.06886500f, -0.19109726f, -0.15312475f, 
    0.04692522f, 0.02351584f, 0.01442974f, 0.14612551f, -0.06077994f, 0.02294265f, -0.05464597f, -0.06854685f, 
    -0.01132371f, 0.27241212f, 0.09508593f, 0.09682826f, -0.06604892f, -0.02735608f, 0.06668926f, 0.02525353f, 
    0.09455866f, 0.03470288f, 0.16235176f, 0.00668205f, 0.16080859f, 0.00178344f, 0.17077716f, -0.16851074f, 
    0.00925811f, 0.04616841f, 0.01221643f, -0.24839412f, -0.02304682f, 0.03087163f, 0.31453401f, 0.30098066f, 
    0.21853015f, 0.22635446f, 0.31742126f, 0.11131109f, 0.05870961f, 0.12586519f, 0.07546195f, 0.09331565f, 
    -0.00843996f, -0.04595210f, -0.07835870f, -0.11488177f, 0.19623025f, 0.37958694f, -0.04138178f, 0.12545691f, 
    -0.07558667f, 0.05846904f, -0.00612057f, 0.14930858f, 0.14697090f, -0.04778921f, -0.09889673f, -0.01110546f, 
    -0.21851197f, -0.37073955f, -0.26836821f, -0.03025233f, -0.03787822f, 0.04871055f, -0.05125962f, -0.02236462f, 
    -0.06672420f, 0.26563531f, 0.01106975f, 0.00099250f, -0.17656757f, -0.06532535f, -0.30535719f, -0.09590030f, 
    0.14179331f, 0.01197944f, -0.10455817f, -0.03644130f, 0.09716789f, -0.04681649f, 0.11032645f, 0.25132361f, 
    -0.50533831f, -0.41778395f, 0.03629357f, -0.16369808f, 0.02816788f, -0.06837436f, -0.08811518f, -0.07951254f, 
    0.00627437f, -0.03842513f, 0.11502996f, -0.00410104f, 0.04955470f, 0.07685085f, 0.01101354f, -0.00098041f, 
    -0.10126246f, 0.00196323f, 0.06868115f, 0.18538818f, -0.06236129f, 0.04571601f, -0.14636241f, -0.23278342f, 
    -0.36305812f, -0.07592320f, -0.37265226f, 0.10035198f, 0.01031467f, 0.02153449f, 0.05794015f, -0.01313926f, 
    0.08910521f, 0.06278459f, 0.06224975f, 0.10954712f, 0.20774192f, 0.14073566f, 0.24569985f, 0.30183131f, 
    0.02269057f, -0.17108984f, 0.00166332f, 0.23994650f, 0.12587334f, 0.09852230f, 0.00957777f, 0.14915346f, 
    -0.12183087f, 0.03180005f, -0.12031025f, -0.33386007f, -0.03909536f, -0.11929823f, 0.12886144f, 0.09157963f, 
    -0.22754455f, -0.05142213f, -0.05943368f, -0.19907795f, 0.12953910f, 0.18964009f, 0.08184530f, -0.04889403f, 
    0.11018592f, 0.14422400f, 0.03698459f, 0.23877591f, 0.04285241f, 0.10084394f, 0.19216056f, 0.20852974f, 
    -0.01664081f, 0.01148859f, 0.05880088f, -0.04714371f, 0.05094667f, -0.06977560f, -0.00254390f, 0.05486627f, 
    0.03800378f, -0.07722199f, -0.02991703f, -0.04081495f, -0.01214164f, 0.04177662f, 0.06544883f, 0.03116690f, 
    -0.03735063f, 0.04292174f, -0.07380818f, -0.05093416f, 0.03475957f, -0.03393919f, -0.02017084f, -0.03402185f, 
    0.03261778f, -0.06650010f, -0.06370264f, 0.04785645f, 0.05078085f, 0.05970836f, -0.06499999f, -0.05757912f, 
    -0.04083563f, -0.04174523f, 0.00895769f, -0.07103401f, -0.03685957f, -0.00504594f, -0.06291784f, -0.04880705f, 
    0.05403106f, 0.01950572f, -0.03471908f, -0.00826479f, 0.04810812f, 0.05857138f, -0.01459301f, -0.03004744f, 
    -0.02683721f, 0.03627443f, 0.06007751f, 0.00703843f, -0.02284293f, -0.00635546f, 0.04929586f, 0.01791086f, 
    0.03028684f, 0.03265137f, -0.03268209f, -0.07046812f, -0.07036676f, 0.00387518f, -0.02918943f, 0.02693546f, 
    0.07061133f, 0.01743908f, -0.04042320f, -0.06288315f, -0.02807803f, -0.05973148f, -0.02125546f, 0.05253691f, 
    0.01934647f, -0.00841631f, -0.01127068f, -0.06917392f, 0.04783694f, -0.03097717f, -0.01368483f, 0.04006533f, 
    0.01729136f, -0.00065095f, 0.04386185f, -0.07737951f, -0.02507170f, -0.04901886f, -0.06505720f, -0.03572986f, 
    0.05141012f, 0.06494136f, 0.04199007f, -0.06374833f, 0.02826814f, -0.04533663f, 0.03804811f, -0.03708440f, 
    -0.03863707f, 0.00451673f, 0.01121996f, -0.04425369f, 0.06220317f, 0.04642566f, -0.04103714f, 0.04562538f, 
    -0.04109827f, -0.02746215f, -0.01589362f, -0.06951777f, -0.00998490f, 0.05083482f, 0.03524251f, -0.00816024f, 
    -0.00525926f, 0.04603901f, -0.04222778f, -0.06787616f, -0.00739560f, -0.00259962f, -0.00129596f, -0.05380498f, 
    -0.06741771f, -0.00745706f, -0.02185247f, -0.03377829f, -0.07131481f, -0.07074514f, 0.02973217f, 0.00672750f, 
    0.03463316f, -0.04141381f, -0.00814622f, 0.00818678f, -0.00713436f, -0.00451657f, 0.02945990f, -0.02561419f, 
    -0.04738901f, 0.00088397f, -0.06921037f, 0.05792787f, 0.05645462f, -0.01163248f, 0.00322884f, 0.04340366f, 
    -0.04254203f, 0.00896469f, -0.03577931f, -0.00876696f, 0.02899637f, -0.01629243f, 0.02906998f, -0.02497126f, 
    -0.02727508f, -0.04121976f, -0.02043743f, -0.03976307f, -0.00335440f, 0.02258668f, -0.01748030f, -0.06740774f, 
    0.06672745f, -0.05277021f, 0.03443272f, 0.04756667f, -0.04211957f, 0.02550714f, -0.06306850f, -0.04540771f, 
    0.02930276f, 0.05829589f, 0.03753800f, -0.03094281f, 0.05343425f, -0.00007805f, -0.07394095f, -0.07345047f, 
    0.05679634f, -0.06812717f, -0.04491251f, 0.01159132f, -0.04809429f, 0.05934737f, 0.04961380f, -0.02033549f, 
    -0.04099715f, -0.05868870f, 0.01236403f, 0.00687919f, -0.04813242f, 0.02383263f, -0.01757500f, -0.04628949f, 
    -0.19914836f, 0.04288416f, 0.00303367f, 0.07819320f, 0.01252106f, -0.04597680f, 0.11553784f, -0.02372665f, 
    0.07115357f, 0.15485828f, -0.09341707f, 0.16782814f, -0.09430121f, -0.28866488f, 0.08791595f, 0.13976577f, 
    0.21948968f, 0.12225762f, 0.18340856f, -0.00880086f, 0.17202494f, -0.13074540f, -0.03886790f, -0.12257223f, 
    0.07825997f, -0.20480993f, 0.58492929f, 0.28481862f, 0.05282366f, 0.10555691f, -0.13177702f, 0.14355713f, 
    -0.02699234f, 0.04055395f, -0.05196759f, -0.02319636f, 0.08147798f, 0.14393377f, 0.21202144f, -0.05765973f, 
    -0.00658196f, -0.15464960f, -0.05104761f, 0.12804218f, -0.03499224f, 0.02717686f, 0.02399045f, -0.11961580f, 
    0.14395840f, 0.01040383f, 0.12664288f, 0.09164289f, 0.17658484f, -0.05062545f, -0.07031722f, -0.07230601f, 
    0.05596538f, -0.03326776f, -0.01935540f, 0.02047626f, -0.24300453f, 0.09985761f, 0.05064700f, 0.06353792f, 
    0.05956762f, 0.09699344f, -0.19167511f, -0.06772266f, 0.12290166f, 0.15076785f, 0.05017605f, -0.06792998f, 
    0.06335854f, -0.05547751f, -0.03141874f, 0.11289465f, 0.17095207f, 0.10561033f, -0.07359549f, -0.03621003f, 
    -0.07814047f, 0.04932142f, -0.09252730f, -0.05497124f, 0.40864041f, 0.01236327f, 0.00377268f, -0.19786771f, 
    0.02276252f, 0.15564023f, -0.08297177f, 0.10994382f, 0.06851016f, -0.05323890f, -0.10312255f, 0.04329065f, 
    -0.13623956f, -0.25276589f, -0.24539268f, 0.03468209f, -0.00218935f, 0.03882910f, 0.04440891f, 0.06656568f, 
    -0.05448431f, -0.06012611f, 0.02581170f, 0.07188582f, -0.18909855f, -0.05267867f, 0.32455426f, 0.05221418f, 
    -0.03379668f, -0.12487449f, -0.10717523f, 0.03039638f, 0.02214913f, 0.11381994f, 0.00349020f, 0.06147021f, 
    -0.02608151f, 0.13065901f, 0.24932428f, -0.07171682f, -0.00781407f, -0.13532309f, -0.00706226f, -0.00712284f, 
    -0.01183236f, -0.02491547f, 0.16635081f, -0.00223911f, -0.15499172f, 0.17662910f, -0.04963345f, -0.09331363f, 
    0.07233382f, 0.12631187f, -0.09883235f, -0.09455776f, -0.01915490f, 0.02590418f, 0.00578934f, 0.07989728f, 
    -0.36913383f, 0.31831363f, -0.21031456f, -0.21818346f, 0.01115243f, -0.00554973f, 0.10631238f, 0.06099722f, 
    -0.01278707f, -0.02488385f, 0.07514114f, -0.14575940f, 0.05085041f, 0.00300068f, -0.01321582f, -0.04261045f, 
    0.13679986f, -0.03962839f, 0.12970994f, -0.01642621f, 0.00758667f, 0.08430432f, -0.07098720f, 0.02723685f, 
    -0.27705348f, -0.01467282f, -0.06418762f, 0.02611306f, 0.01225385f, -0.16942905f, 0.02232561f, -0.06887254f, 
    0.02532031f, -0.01165447f, 0.23226228f, 0.04467946f, -0.02309552f, -0.03562465f, 0.28760597f, -0.02370536f, 
    0.05677371f, 0.01489057f, -0.11683244f, 0.06988014f, 0.03925434f, -0.01686580f, 0.13728997f, 0.06210255f, 
    0.07792549f, -0.13314034f, 0.11298703f, -0.13838151f, -0.03577087f, -0.02186954f, -0.06476746f, -0.02485696f, 
    0.05968475f, 0.11457598f, 0.05775359f, 0.05300271f, -0.02815431f, -0.26585183f, -0.00340071f, 0.10442507f, 
    0.03171175f, -0.07721749f, 0.03883086f, 0.06283413f, 0.02609001f, 0.16618179f, 0.04830417f, -0.07442817f, 
    0.30670160f, 0.04669907f, 0.39047346f, 0.05932776f, 0.01286435f, 0.03356217f, -0.02385640f, 0.12426296f, 
    -0.06056875f, -0.01028301f, 0.02200742f, -0.02065394f, -0.04204363f, -0.01680082f, 0.28507635f, 0.12489957f, 
    0.16022161f, -0.12051144f, -0.11005630f, 0.10880946f, -0.04110894f, 0.01548172f, 0.09559259f, 0.05311253f, 
    0.29597461f, -0.24995714f, 0.00852843f, 0.45282564f, 0.11016040f, 0.03603207f, 0.08131133f, -0.01873473f, 
    0.09790635f, 0.08880291f, -0.08501490f, -0.01086033f, -0.21006359f, 0.08373287f, -0.04166911f, 0.14373185f, 
    0.00446094f, 0.06699894f, 0.03581847f, 0.17241423f, 0.16020121f, 0.12117860f, -0.00206874f, -0.17603691f, 
    -0.17122926f, -0.16263635f, -0.01193814f, 0.17291842f, -0.03986273f, -0.01338859f, -0.07050596f, 0.08929881f, 
    0.02088600f, -0.07954328f, 0.00246459f, 0.04381255f, 0.20965563f, -0.14463246f, 0.19056694f, 0.14805138f, 
    -0.00374544f, 0.03498264f, 0.09465665f, 0.10708261f, 0.00968541f, -0.00947142f, -0.00610741f, -0.08690520f, 
    -0.10846373f, 0.12275600f, -0.05986067f, -0.04738200f, -0.06546157f, 0.00536061f, -0.03983305f, 0.00404425f, 
    -0.01933818f, -0.02731447f, 0.00153375f, 0.07450143f, -0.17083317f, -0.04205150f, 0.20920792f, -0.11625531f, 
    -0.07662882f, -0.07053389f, 0.00616848f, 0.00959320f, -0.14138320f, -0.09465893f, 0.05964390f, -0.12944140f, 
    -0.04890035f, 0.10243861f, 0.22038600f, 0.05395693f, -0.06326967f, -0.08487959f, 0.00570710f, 0.03911662f, 
    -0.06133797f, 0.02173642f, 0.08285130f, -0.11402815f, -0.06315110f, -0.04441809f, 0.02223150f, -0.05996869f, 
    0.02872610f, 0.03618088f, 0.02198073f, -0.11461556f, -0.00598881f, -0.07358562f, 0.06453490f, 0.03167172f, 
    -0.35493857f, 0.00515948f, -0.00734039f, -0.22273040f, 0.08726011f, -0.06785739f, -0.12872046f, -0.11179966f, 
    0.04766589f, -0.05067416f, 0.12902468f, -0.03610209f, -0.23150091f, -0.28345239f, 0.01415163f, 0.05495067f, 
    -0.05863037f, 0.07905394f, 0.17651299f, 0.02833819f, 0.13626872f, 0.16474746f, -0.07207365f, -0.07435589f, 
    -0.14214100f, 0.01831413f, 0.10175004f, 0.22853267f, 0.07118367f, 0.06590071f, -0.00798497f, -0.06785896f, 
    0.02593761f, -0.05639008f, 0.12128165f, 0.11297744f, -0.09201349f, 0.00385832f, 0.05249304f, 0.24677211f, 
    -0.02692147f, 0.05390340f, -0.00716471f, 0.05050815f, 0.06814497f, 0.00312702f, 0.01534504f, 0.07776706f, 
    -0.08303732f, 0.00703365f, -0.11692995f, 0.00995413f, -0.06531170f, -0.07550271f, -0.02195163f, -0.04236577f, 
    0.02958474f, 0.04154943f, 0.15426253f, 0.00415286f, -0.04206032f, 0.29823613f, 0.02714470f, 0.15540715f, 
    -0.04642393f, -0.14880843f, 0.01196518f, 0.04020578f, 0.16659537f, -0.09856181f, -0.06062957f, 0.03658202f, 
    0.26519576f, 0.23981389f, -0.08031265f, 0.14190003f, -0.02288959f, 0.03540501f, 0.19082913f, -0.05672934f, 
    0.00912364f, -0.01236122f, 0.03415402f, 0.09656072f, -0.13074954f, -0.07238363f, 0.35488045f, -0.04626193f, 
    0.17646742f, 0.11280199f, 0.00047064f, -0.01540583f, 0.04538085f, 0.01619890f, -0.05929795f, -0.00423890f, 
    -0.05394182f, 0.04923563f, -0.13018683f, 0.25967693f, -0.11466711f, 0.10833897f, 0.07234751f, -0.03030305f, 
    -0.10659492f, -0.02465495f, 0.02589191f, 0.14584331f, 0.14450489f, 0.26279339f, -0.14915708f, 0.12224922f, 
    0.10059375f, 0.04800397f, 0.11541134f, 0.02378136f, 0.02766290f, -0.04065387f, 0.00603293f, 0.02598158f, 
    -0.12166806f, -0.14559540f, 0.11675790f, 0.06289653f, -0.05303035f, 0.02072790f, 0.04086078f, 0.00079140f, 
    -0.03291054f, 0.03830833f, 0.08310732f, 0.03508443f, -0.21911041f, -0.06408068f, 0.13051942f, 0.15505682f, 
    0.10091633f, 0.13089797f, 0.15547651f, -0.05068388f, -0.08283193f, -0.00163549f, 0.13191952f, 0.02651215f, 
    -0.01748953f, -0.00665977f, -0.00439615f, -0.07169291f, -0.05893765f, -0.06663809f, -0.07548179f, -0.13061979f, 
    0.22393604f, 0.02387482f, 0.04120539f, 0.20200689f, -0.03609161f, -0.01690970f, -0.21001142f, 0.04426273f, 
    0.08025075f, 0.06795027f, 0.04096676f, -0.11588705f, -0.04754782f, -0.03179302f, -0.17398617f, -0.11178688f, 
    -0.06705629f, -0.18728042f, 0.02077211f, 0.20500337f, -0.00442697f, 0.08852956f, 0.09827071f, 0.01647364f, 
    0.04765808f, 0.01187287f, -0.12257019f, 0.00670489f, -0.04105693f, -0.18677114f, -0.05038216f, 0.34999195f, 
    0.03716034f, -0.10711404f, -0.02237101f, -0.15944386f, -0.06782695f, -0.03169008f, -0.00983359f, 0.03482642f, 
    -0.17120096f, -0.55034840f, 0.13496289f, 0.54009926f, -0.03895264f, -0.08650406f, -0.08948707f, 0.00448749f, 
    -0.01321593f, 0.08685159f, 0.00029500f, 0.15160601f, -0.18643455f, -0.11641741f, -0.09454862f, -0.00745108f, 
    -0.07839269f, -0.09996366f, -0.05295526f, -0.06210719f, 0.11231153f, 0.07821872f, 0.21643916f, 0.03955258f, 
    -0.08719531f, 0.01412238f, 0.09103136f, 0.09574783f, 0.14702226f, 0.03011410f, -0.08684482f, -0.04035392f, 
    -0.01400637f, 0.09754866f, -0.01832136f, 0.07826206f, -0.11217987f, 0.16126938f, 0.00251294f, 0.17881921f, 
    0.03106779f, 0.02312416f, 0.06605806f, -0.15162285f, 0.04957862f, 0.08027928f, 0.05892899f, -0.03891680f, 
    -0.12820336f, -0.13166009f, -0.04191796f, 0.06808496f, -0.06341385f, 0.01563553f, 0.03463470f, 0.11910819f, 
    0.11190671f, 0.15219322f, 0.27327520f, 0.10452755f, -0.05785949f, 0.06098316f, 0.01735090f, -0.14612383f, 
    -0.01969785f, -0.06111337f, 0.05686160f, 0.14366263f, 0.06184787f, 0.14388953f, 0.12086564f, -0.00436172f, 
    0.19716284f, 0.27457666f, -0.52184826f, -0.19826703f, 0.04167188f, -0.05020679f, 0.20085278f, -0.06635227f, 
    -0.02974852f, 0.03585404f, 0.00580099f, 0.13849789f, 0.09695612f, -0.06300001f, -0.09688631f, -0.08195439f, 
    -0.08289257f, -0.09943953f, -0.10981768f, -0.14776137f, -0.02485467f, -0.06376260f, -0.11038642f, 0.04719687f, 
    -0.30516946f, -0.18066224f, -0.09495751f, 0.23574571f, -0.11856911f, 0.07796404f, -0.01133307f, 0.05378647f, 
    0.08730039f, -0.02936483f, -0.03922381f, -0.09027733f, 0.28954545f, -0.12277760f, -0.19124283f, 0.03316374f, 
    0.09352641f, 0.00602392f, 0.05278794f, 0.06014673f, -0.06438784f, -0.10904266f, 0.04404151f, -0.20870493f, 
    -0.05833747f, 0.04720743f, 0.17336412f, 0.01248189f, -0.00203714f, -0.05996690f, 0.22475161f, 0.02218659f, 
    0.04343967f, -0.07285939f, 0.10785219f, 0.11123763f, -0.27157652f, -0.17172645f, -0.01628446f, 0.21920046f, 
    0.06715340f, -0.03149426f, 0.02636746f, -0.06713405f, 0.11321857f, 0.00070032f, 0.12683211f, 0.15420935f, 
    0.13461402f, -0.03987686f, 0.14065138f, -0.08486126f, 0.01490733f, -0.12347676f, -0.15139289f, -0.15779084f, 
    0.14815460f, -0.04276237f, 0.05602130f, 0.02357160f, -0.12134328f, -0.08750407f, -0.20374390f, -0.16199985f, 
    -0.10878761f, 0.08714716f, 0.12240371f, -0.06063641f, -0.03118891f, -0.07567193f, -0.06253624f, -0.17632741f, 
    0.00447127f, 0.01207416f, -0.24231744f, 0.00833395f, -0.01098334f, -0.07296626f, 0.01784352f, -0.00562539f, 
    0.10129305f, -0.02511865f, -0.13584028f, 0.09381821f, -0.03491639f, -0.05533165f, -0.00292190f, 0.23045425f, 
    0.06700808f, -0.12128344f, 0.01792144f, -0.15840542f, 0.00212832f, 0.11464737f, 0.03029539f, 0.07815945f, 
    0.14247411f, -0.38900727f, 0.36156815f, 0.10183068f, -0.03905849f, -0.01118673f, -0.03728203f, -0.12212674f, 
    0.03628431f, 0.15534194f, 0.07702749f, 0.04673062f, -0.04827365f, -0.16091265f, 0.19558631f, 0.14394556f, 
    -0.02396374f, 0.08714952f, -0.06933261f, 0.15846920f, 0.12336713f, 0.04924130f, 0.05426805f, 0.00185329f, 
    0.24528123f, 0.05820712f, 0.12336453f, -0.00753449f, 0.04735816f, -0.08488341f, -0.02101067f, -0.00329988f, 
    0.16270585f, 0.02269651f, 0.07258265f, 0.15424013f, -0.14880851f, 0.00625402f, -0.09682827f, 0.09252758f, 
    -0.01046157f, 0.00046330f, 0.18230712f, -0.08491738f, -0.12279814f, -0.06953488f, -0.17520066f, 0.09125989f, 
    0.01454518f, -0.07176153f, -0.03548478f, -0.00735412f, -0.05171085f, -0.03572977f, -0.04846898f, 0.00719773f, 
    0.03237168f, -0.01662021f, -0.02492723f, -0.02710412f, -0.06436769f, -0.02531779f, 0.05436924f, -0.05882880f, 
    -0.05246172f, -0.03658723f, 0.02124156f, -0.02203806f, 0.06222078f, -0.00505899f, -0.02829730f, -0.06465679f, 
    -0.04866114f, 0.04434390f, -0.04169500f, -0.00406553f, -0.00111275f, -0.02368574f, -0.03756652f, 0.04151458f, 
    -0.00006337f, 0.00033765f, -0.01491314f, -0.03421580f, -0.06678528f, -0.06630957f, 0.05167271f, -0.07142350f, 
    -0.01341965f, 0.01897365f, -0.02007704f, 0.05817041f, 0.01248730f, 0.05100758f, -0.06916922f, -0.02529211f, 
    -0.05404853f, 0.00606407f, 0.06155565f, -0.07591373f, -0.07383280f, 0.03581785f, -0.06965631f, 0.00081503f, 
    -0.01187028f, -0.03156413f, -0.01009082f, 0.00640654f, 0.02597949f, 0.00419870f, 0.02062909f, -0.00691114f, 
    0.00615695f, -0.01524203f, -0.00580557f, -0.02870966f, -0.02431579f, 0.00539393f, -0.07158758f, -0.02297727f, 
    -0.06259569f, 0.02220989f, 0.00057294f, 0.00974587f, 0.05235656f, -0.06126291f, 0.00083740f, 0.01727602f, 
    0.00234152f, -0.05018894f, -0.02288017f, -0.03516741f, 0.02375035f, 0.02336357f, -0.07512658f, -0.06949969f, 
    0.03390334f, -0.03693504f, -0.05053139f, -0.02614106f, -0.06888386f, -0.07875397f, 0.03908053f, -0.07523058f, 
    0.06446558f, 0.05003352f, -0.06788295f, -0.06214030f, -0.01764676f, -0.06624191f, -0.01151709f, -0.06991135f, 
    0.00091486f, 0.05963442f, 0.05195067f, -0.07203586f, -0.02699293f, -0.02111902f, 0.03587430f, -0.04871326f, 
    0.01687288f, 0.04401791f, -0.04799326f, -0.03737810f, -0.01666467f, -0.04188214f, 0.01688187f, 0.02801675f, 
    0.00183699f, 0.03150221f, 0.00559419f, 0.04162853f, 0.00832381f, 0.02753902f, -0.00429874f, -0.05537364f, 
    -0.08104067f, 0.01742253f, 0.06024747f, 0.03801150f, -0.00370210f, 0.04251150f, 0.01886905f, 0.04177452f, 
    0.02491362f, -0.06799816f, -0.03588666f, 0.00195684f, -0.08106040f, -0.06523024f, 0.02729810f, -0.07512641f, 
    -0.06461821f, 0.02457399f, -0.00801922f, -0.01296842f, -0.02904086f, -0.05274368f, -0.01754724f, -0.02208748f, 
    0.05477578f, -0.01708193f, 0.05131288f, 0.05256687f, 0.00305444f, -0.07349990f, 0.02534171f, 0.03060442f, 
    -0.05421685f, -0.02610106f, -0.04113884f, -0.00539938f, -0.04366691f, -0.04493706f, -0.01997290f, 0.00759836f, 
    0.02488769f, -0.03921303f, -0.08052154f, -0.04935039f, -0.04416637f, -0.07825934f, 0.01507345f, 0.03352084f, 
    -0.00211429f, -0.05101516f, 0.01113800f, 0.04300037f, -0.01608018f, -0.07409714f, 0.05218688f, 0.00269411f, 
    0.01578149f, -0.04137461f, -0.05404506f, -0.03971629f, -0.04108820f, 0.05040215f, -0.02229405f, -0.05274758f, 
    0.04133744f, 0.02651702f, 0.04096783f, 0.06974936f, -0.05807951f, -0.02493741f, 0.03147627f, -0.02308707f, 
    -0.03551590f, -0.04943436f, -0.05478321f, -0.04031451f, -0.06655272f, -0.01362398f, 0.00928746f, -0.04993552f, 
    0.03623439f, -0.05352603f, -0.01542920f, 0.04010301f, -0.05932515f, -0.01014353f, 0.06923389f, -0.06828547f, 
    -0.05208369f, 0.05374981f, -0.06451507f, -0.06149467f, -0.00916887f, -0.06248654f, -0.05912028f, -0.07234583f, 
    -0.06201814f, -0.01854177f, 0.06854475f, -0.06496254f, 0.03288984f, -0.05462537f, -0.05588422f, -0.04985464f, 
    0.04975816f, -0.06946488f, -0.01194270f, -0.02981202f, 0.02384783f, 0.05497740f, -0.05700620f, 0.02650201f, 
    -0.03980350f, 0.07086578f, 0.02787314f, -0.01487382f, 0.07039934f, -0.02682462f, 0.05020511f, 0.04181712f, 
    -0.06115393f, 0.00165617f, 0.02233603f, 0.00986082f, -0.05603169f, -0.03794908f, 0.04820786f, -0.04445854f, 
    0.00686112f, 0.05505377f, -0.06053661f, -0.05876946f, -0.05659434f, -0.06451899f, -0.03948950f, 0.04859719f, 
    -0.04825387f, 0.01726072f, -0.00624946f, -0.05664099f, -0.01630376f, -0.07174437f, 0.04874459f, -0.06892706f, 
    -0.01097011f, -0.00242216f, -0.00102801f, -0.07125435f, 0.06731158f, 0.02764150f, 0.03503791f, -0.02549773f, 
    0.03985693f, 0.00132682f, 0.05744497f, -0.06266231f, -0.02237901f, 0.06846429f, -0.06273977f, -0.05885892f, 
    -0.02011172f, -0.07204884f, 0.00955122f, 0.03100443f, 0.04841073f, 0.04060987f, 0.00028918f, 0.02479363f, 
    -0.05111510f, -0.03126728f, 0.02416489f, -0.01005505f, -0.00392490f, 0.03121983f, 0.03724560f, -0.02152040f, 
    0.03179781f, 0.04853316f, -0.03708094f, -0.00712991f, 0.06313182f, -0.03866326f, 0.06714130f, 0.01709618f, 
    -0.06082634f, -0.01744068f, -0.03201550f, 0.03225062f, -0.04178375f, -0.07299688f, -0.00843157f, -0.02185393f, 
    -0.06557276f, 0.01986903f, 0.03295297f, 0.04196848f, -0.01192468f, 0.02606110f, 0.00246892f, 0.03602549f, 
    -0.04719241f, -0.06584357f, -0.00206500f, -0.00109834f, -0.01408562f, 0.00439417f, -0.05195245f, 0.01262360f, 
    0.01425480f, 0.06475209f, 0.00892293f, -0.00976821f, -0.05106165f, -0.04922085f, 0.06136488f, -0.05550647f, 
    0.03213120f, -0.03808160f, -0.03891847f, -0.06214869f, 0.06210228f, -0.02006092f, 0.00464189f, 0.04510545f, 
    0.00283573f, -0.03490740f, 0.02174040f, -0.06423645f, 0.04051765f, -0.04626295f, 0.02073214f, -0.05286803f, 
    -0.05807008f, -0.05539566f, 0.06927728f, 0.05263761f, -0.06684288f, -0.02334015f, 0.06878684f, 0.04252560f, 
    -0.06086962f, 0.00957582f, -0.03321026f, -0.00917573f, 0.06011032f, 0.01585965f, -0.03393209f, 0.04850248f, 
    -0.00095889f, 0.01494106f, 0.04253023f, -0.01930813f, -0.06323346f, -0.00670659f, 0.05659766f, -0.06806817f, 
    -0.06499351f, -0.04582503f, 0.04499309f, 0.02476193f, -0.06910911f, -0.03551432f, -0.06273423f, 0.01480735f, 
    -0.06097364f, 0.05479155f, -0.01282103f, 0.05475681f, -0.00423870f, -0.02845471f, 0.02682564f, -0.07605771f, 
    -0.06403586f, -0.05868764f, -0.03893629f, -0.07329863f, 0.04658535f, 0.02155637f, 0.03967243f, -0.06508993f, 
    0.00694532f, 0.03563693f, 0.03946920f, -0.02842090f, -0.06273755f, -0.03193808f, -0.04524129f, -0.02362567f, 
    -0.03098311f, -0.07569857f, 0.04421515f, -0.05947876f, -0.01780493f, 0.03974772f, -0.07038132f, -0.02473432f, 
    -0.04221512f, 0.01917503f, -0.04109864f, -0.07385211f, -0.07061752f, 0.04769493f, -0.01073166f, -0.05128102f, 
    0.00155421f, 0.05581508f, 0.04731176f, 0.00341024f, 0.01761814f, -0.00601186f, -0.06679417f, -0.02790296f, 
    0.03699949f, 0.01135171f, -0.03924092f, 0.01029251f, 0.05390113f, 0.01742474f, -0.07096568f, 0.04670689f, 
    -0.04070826f, 0.00039337f, 0.01503979f, 0.05210191f, 0.04764646f, -0.02344722f, -0.00659908f, -0.06090117f, 
    -0.01316625f, 0.00949718f, -0.04284285f, -0.06550110f, 0.00278812f, -0.04712851f, -0.02894543f, -0.00981999f, 
    -0.02768341f, 0.00384277f, -0.03878250f, 0.06164328f, 0.05687284f, 0.02737340f, 0.02478939f, -0.02008140f, 
    -0.01378935f, 0.03714501f, -0.01974967f, -0.02908797f, -0.02566636f, -0.00856170f, -0.08218502f, -0.03839769f, 
    0.01852020f, -0.04243229f, 0.05095647f, -0.06278169f, 0.03658831f, -0.05860887f, 0.05263765f, -0.00609412f, 
    0.04880514f, -0.04413311f, 0.00894375f, 0.05576424f, 0.02109539f, 0.04929871f, 0.01296695f, 0.05447853f, 
    0.06120013f, 0.00959263f, -0.03602443f, 0.04055274f, -0.01800078f, 0.06252278f, -0.03105875f, 0.05479551f, 
    -0.04498978f, -0.05747296f, 0.01492817f, -0.00089152f, 0.04146292f, -0.00554871f, -0.01142585f, 0.04402567f, 
    -0.01139730f, -0.04878919f, -0.07304138f, -0.02756662f, -0.06381613f, -0.05290669f, 0.01492633f, -0.03962770f, 
    -0.02097345f, -0.02434692f, -0.08077525f, -0.06898072f, -0.05201868f, -0.02331861f, 0.04047640f, -0.04519338f, 
    0.03177786f, -0.03806929f, 0.00055206f, -0.05631008f, 0.02896046f, 0.02425539f, 0.00683214f, -0.04496981f, 
    0.00329245f, -0.05830140f, -0.00773524f, 0.02006570f, 0.03846635f, -0.07109889f, -0.05879538f, 0.05076484f, 
    -0.01941487f, -0.00906518f, 0.04381378f, 0.02759420f, -0.02439487f, 0.04917056f, -0.04084813f, -0.05760708f, 
    0.00500745f, -0.07298296f, -0.04056528f, 0.00845105f, -0.05366389f, 0.05341937f, 0.02565664f, 0.03755905f, 
    0.02058495f, -0.00620535f, -0.02779708f, 0.01074877f, 0.04876149f, -0.00190873f, -0.05928727f, 0.03453524f, 
    0.05577726f, 0.05351057f, -0.06139262f, -0.06340646f, -0.01263471f, -0.04361928f, -0.05707925f, -0.00797236f, 
    0.12974459f, -0.18997844f, 0.04244656f, 0.08111563f, -0.01243859f, 0.03054017f, -0.10322573f, -0.21953046f, 
    -0.02211627f, -0.08331056f, -0.06186166f, -0.01255051f, 0.16842704f, 0.11536816f, -0.08987047f, 0.05335991f, 
    -0.07323642f, 0.03971706f, -0.03941991f, -0.05793811f, 0.13606837f, -0.10910232f, 0.03816006f, 0.08426266f, 
    -0.21401982f, -0.05838391f, -0.02750778f, 0.23022564f, 0.15489934f, -0.12081696f, 0.16805628f, -0.16203673f, 
    0.03084143f, -0.09625995f, -0.16092232f, -0.12063465f, -0.21170273f, 0.02719774f, -0.30531615f, -0.00760737f, 
    0.01546571f, 0.02759927f, 0.19461054f, 0.14824122f, -0.14007081f, -0.17879903f, -0.15663710f, -0.14021762f, 
    0.28863254f, 0.13560380f, 0.14628707f, -0.03040925f, -0.11910234f, -0.03678227f, -0.07003564f, 0.09480294f, 
    0.22423968f, 0.09427288f, 0.08366725f, 0.10318907f, 0.10468635f, -0.00503347f, 0.01228661f, -0.19463342f, 
    0.00222729f, 0.03066753f, -0.02038214f, -0.03829954f, 0.13150434f, 0.00723294f, 0.17666645f, 0.02916917f, 
    0.09907277f, 0.28252968f, 0.12719473f, -0.14675656f, -0.08356410f, 0.02385460f, 0.15111423f, 0.14609744f, 
    0.00128516f, -0.08025336f, 0.00678988f, 0.00816666f, -0.20719673f, 0.21534447f, -0.30706295f, 0.06717880f, 
    0.06491004f, 0.00714252f, 0.10209873f, 0.00886253f, 0.10175677f, -0.04428694f, -0.09984586f, 0.01836164f, 
    0.10328432f, 0.16585402f, 0.19507389f, 0.14952883f, -0.03222670f, -0.07577381f, 0.02651838f, -0.07914590f, 
    0.13508219f, 0.13434918f, 0.02902936f, 0.11103692f, -0.28114131f, 0.07454381f, -0.31156969f, 0.11054663f, 
    -0.03086851f, 0.09812074f, 0.10344239f, -0.14220774f, 0.04202591f, -0.00776068f, -0.02816622f, 0.12122727f, 
    -0.21496725f, -0.17929476f, -0.08690642f, 0.07945203f, 0.15699451f, 0.06288232f, 0.09764715f, -0.03373704f, 
    -0.06633369f, -0.08961318f, -0.02411350f, 0.10605701f, 0.25366974f, -0.17307723f, 0.24928316f, -0.22341228f, 
    -0.01920407f, 0.06424882f, -0.04784516f, 0.13748685f, 0.13762657f, -0.01036243f, -0.08149341f, -0.01045878f, 
    0.27274793f, -0.04315932f, 0.16989477f, 0.31713015f, -0.12743971f, 0.01099164f, -0.14296886f, 0.14346611f, 
    0.11314747f, 0.11275362f, -0.05935980f, 0.05270620f, 0.03204048f, 0.22605534f, 0.23672687f, -0.12725967f, 
    0.00950508f, 0.10639677f, -0.01005147f, 0.11274675f, 0.11606339f, -0.03548814f, 0.06382682f, 0.13043587f, 
    0.27512610f, -0.17389551f, -0.12702990f, -0.58219379f, -0.00042038f, 0.14651607f, -0.03598342f, -0.01659385f, 
    0.06333686f, 0.11909439f, -0.15589607f, -0.24843043f, 0.13256121f, 0.20191292f, -0.05908781f, -0.35449132f, 
    0.13615879f, -0.09770336f, 0.18270355f, 0.11757570f, 0.01381156f, 0.06026466f, 0.03303191f, -0.02063441f, 
    -0.08383583f, -0.08199114f, -0.03545456f, 0.22759783f, 0.00830152f, -0.05347713f, 0.06375193f, 0.01262938f, 
    0.20615175f, -0.05424998f, 0.13254687f, 0.17602809f, -0.25068420f, -0.04107402f, 0.04437962f, 0.00496073f, 
    -0.06476471f, -0.05687597f, 0.02354296f, 0.01896840f, 0.06656770f, 0.15973857f, 0.16019554f, -0.06948214f, 
    0.34766638f, 0.10224657f, -0.23089293f, -0.23068868f, 0.02904308f, 0.06475785f, -0.00467200f, -0.00071849f, 
    -0.02633094f, 0.07194588f, -0.07958376f, 0.03693640f, -0.11574315f, 0.09877176f, -0.14629970f, -0.22929832f, 
    0.04402436f, -0.19166259f, -0.07355034f, -0.01730396f, -0.07668947f, -0.02637175f, -0.01302997f, 0.04203593f, 
    -0.08404742f, -0.43188682f, -0.01219651f, 0.26578507f, 0.08727708f, 0.04242893f, 0.02058951f, 0.14197093f, 
    0.28015140f, -0.09569570f, 0.10946953f, -0.02842319f, 0.41379213f, -0.04331192f, -0.01900109f, -0.02302826f, 
    0.15543580f, 0.13894661f, 0.03430203f, 0.19627148f, 0.01474941f, 0.00469841f, 0.05390818f, 0.01207910f, 
    -0.14064674f, 0.15054187f, 0.17213228f, -0.12553930f, 0.03903711f, 0.04538322f, 0.09094725f, -0.06887026f, 
    -0.11745904f, -0.04517227f, -0.05276753f, -0.00656519f, -0.10670871f, -0.09119405f, -0.17004953f, 0.02734009f, 
    0.18971233f, 0.08129517f, -0.04223654f, -0.10792937f, 0.11758020f, 0.05729134f, 0.05333444f, 0.05034414f, 
    0.11687412f, -0.13722068f, 0.05656098f, 0.07615145f, -0.05073346f, -0.02157530f, -0.07586229f, -0.05918278f, 
    0.12775652f, 0.06275864f, 0.04717334f, 0.11795872f, -0.07209864f, -0.01746355f, 0.15830694f, -0.23649728f, 
    0.03491886f, -0.12342680f, -0.04365001f, -0.06717329f, -0.06206796f, -0.10545086f, -0.00239113f, -0.04401692f, 
    0.11757337f, 0.03350814f, 0.01324086f, -0.20138855f, 0.07297739f, -0.12072819f, -0.05404959f, 0.00663964f, 
    -0.02764580f, -0.05196781f, -0.06894693f, 0.02788887f, -0.10250507f, -0.07988183f, 0.02514498f, 0.14876039f, 
    -0.00128836f, -0.19968644f, -0.02035901f, -0.09175941f, 0.04722884f, 0.01624400f, 0.01668952f, 0.17383100f, 
    0.23906331f, -0.43161073f, 0.19877601f, 0.35648969f, 0.01440488f, -0.16781014f, -0.12586473f, 0.03850610f, 
    0.20037894f, 0.09003279f, -0.01557131f, 0.01515095f, -0.10372418f, 0.02499659f, 0.24882357f, -0.13093944f, 
    -0.08625410f, 0.04384084f, -0.01519316f, 0.22643767f, 0.08568379f, 0.04448720f, 0.16509365f, 0.02878242f, 
    0.20480366f, -0.07164416f, 0.10646022f, -0.28764302f, 0.09833101f, -0.14344513f, -0.02106725f, 0.11150654f, 
    0.31071237f, 0.00426121f, 0.05514606f, 0.03602662f, -0.10543319f, 0.04504590f, 0.01077730f, -0.17218636f, 
    -0.01923637f, -0.08616763f, -0.00115562f, -0.15288782f, -0.01723250f, -0.06847926f, 0.03689976f, 0.04287025f, 
    0.03645570f, 0.20305209f, -0.00871756f, 0.08011898f, 0.02052862f, 0.12359488f, 0.05932414f, -0.09057394f, 
    0.22163939f, 0.11830053f, 0.01298070f, -0.02823394f, -0.13932902f, 0.26280248f, 0.06529053f, 0.06543749f, 
    -0.07200406f, -0.12110746f, 0.05060317f, -0.03269846f, -0.02690534f, -0.16354674f, -0.06017896f, -0.07298084f, 
    0.03039081f, 0.00466133f, -0.13072678f, 0.17039897f, -0.07766225f, -0.04228476f, 0.01872249f, -0.02066043f, 
    -0.04985923f, -0.00137717f, -0.18917550f, -0.05010515f, -0.04978585f, -0.21209386f, -0.04079301f, -0.12967801f, 
    -0.15457651f, -0.00222885f, 0.10649689f, -0.00246298f, -0.05009455f, -0.12612125f, -0.16179906f, 0.05808533f, 
    -0.12655844f, 0.28652906f, 0.04918981f, -0.12509197f, 0.03792743f, -0.02888131f, -0.03933867f, 0.09744631f, 
    0.01343822f, 0.07302277f, 0.10882963f, -0.02737324f, 0.12610526f, 0.25661013f, 0.09053227f, -0.24025621f, 
    -0.02643237f, -0.02633107f, 0.07081117f, -0.04989331f, 0.12767097f, 0.01106543f, 0.11593479f, 0.17262569f, 
    0.20457622f, 0.21989153f, 0.10431709f, -0.12602599f, -0.04156322f, 0.11990233f, 0.18343699f, 0.08765101f, 
    0.02393257f, 0.01502424f, 0.05508868f, -0.00827338f, -0.08532625f, 0.22088824f, -0.13795657f, -0.13708240f, 
    0.08573484f, 0.03185188f, -0.02200164f, -0.04684408f, 0.00798285f, 0.14166898f, -0.02821368f, 0.08677971f, 
    -0.00303147f, 0.02703408f, 0.13951965f, 0.16549537f, -0.16495632f, -0.08691676f, 0.00186523f, -0.09078221f, 
    0.10956106f, 0.02762103f, -0.02664112f, 0.11838776f, 0.05010394f, 0.10326585f, -0.18146996f, 0.08770629f, 
    -0.01850636f, 0.00603522f, 0.14826380f, 0.01593282f, -0.02235130f, -0.02833519f, -0.14989898f, -0.02839437f, 
    -0.04561258f, -0.19046916f, 0.15890132f, 0.04927591f, 0.03800995f, 0.03615513f, 0.00324263f, -0.06582174f, 
    -0.03317529f, -0.10793119f, -0.11912893f, 0.04668134f, -0.07144141f, 0.16841924f, -0.07600845f, 0.26346964f, 
    -0.10834290f, 0.09856933f, 0.01380867f, -0.04441970f, -0.03881772f, -0.03882080f, -0.08769134f, -0.02070104f, 
    0.00351042f, -0.11384630f, 0.05686285f, 0.55665064f, -0.00222680f, 0.09148470f, -0.03552346f, 0.09950262f, 
    -0.01607041f, 0.02026923f, -0.06120775f, 0.00618374f, 0.24487747f, 0.11659580f, -0.02215008f, -0.22354947f, 
    0.04999859f, -0.01276869f, -0.06358626f, 0.21568972f, 0.02303167f, -0.01978118f, -0.02057832f, 0.08107606f, 
    0.06584416f, -0.01840177f, -0.03928796f, -0.08681111f, -0.04863041f, 0.04170568f, 0.00920301f, 0.03811971f, 
    -0.08053690f, -0.03084468f, -0.05529037f, 0.04327423f, 0.06168116f, 0.14598614f, -0.12083371f, -0.15906309f, 
    -0.00633896f, -0.09038963f, 0.09946615f, 0.07845655f, 0.04636874f, 0.13785167f, 0.00110988f, -0.01794470f, 
    0.02003257f, -0.06871174f, -0.02214508f, 0.01975917f, -0.00948265f, 0.05760760f, 0.04904469f, 0.02623785f, 
    0.03758012f, -0.03286249f, 0.00325503f, 0.05364929f, -0.06748477f, -0.00239463f, 0.01767302f, 0.05443313f, 
    0.01537207f, 0.05047486f, 0.04099626f, -0.01955666f, -0.02352480f, 0.03437199f, -0.00465486f, -0.06147593f, 
    0.02019457f, -0.04874139f, 0.00816995f, -0.07953570f, -0.07916192f, -0.00883623f, -0.00982115f, -0.00580081f, 
    -0.02026986f, 0.00945302f, -0.00869474f, 0.02818778f, 0.05697033f, -0.04871609f, -0.03039961f, -0.03246321f, 
    0.05421913f, 0.02630303f, 0.03914077f, -0.02233576f, -0.00906854f, -0.06232569f, 0.05426683f, -0.05558228f, 
    -0.05297175f, 0.03031644f, -0.07757415f, -0.07813491f, -0.05856511f, 0.00743751f, 0.01611454f, -0.06456307f, 
    -0.06424461f, -0.03924456f, -0.03360431f, -0.07045624f, -0.00557811f, 0.05835018f, 0.03284234f, -0.01918118f, 
    -0.00689713f, 0.05913687f, -0.07685169f, -0.01658262f, 0.00048536f, -0.07189808f, -0.04150354f, -0.02554957f, 
    0.01227959f, -0.04326782f, 0.02548901f, -0.06697297f, 0.02821447f, -0.00689953f, 0.04427006f, -0.00145924f, 
    -0.00629886f, 0.06160342f, -0.00777456f, 0.04664720f, 0.05238214f, -0.01307308f, -0.07135316f, -0.07888801f, 
    0.04903404f, -0.04328377f, 0.03739352f, -0.05197152f, 0.04933906f, 0.01343869f, 0.01838056f, 0.02223043f, 
    0.03339944f, 0.05954260f, -0.00950056f, 0.00506874f, 0.01950638f, -0.02336225f, 0.05464337f, -0.04241581f, 
    -0.06991669f, -0.04409013f, -0.00366481f, -0.07942560f, 0.02654034f, -0.03355950f, -0.05333930f, -0.01569333f, 
    -0.06489196f, -0.03376015f, -0.02190913f, -0.07955674f, -0.04320837f, 0.01005103f, -0.00360721f, 0.05668720f, 
    0.03145322f, 0.01365699f, -0.02791866f, 0.02317723f, 0.04897081f, -0.04266645f, -0.05171352f, -0.06083221f, 
    -0.04969420f, 0.06352425f, 0.04987674f, -0.00676175f, 0.02881093f, -0.03060464f, -0.03984770f, 0.05117127f, 
    -0.06616059f, 0.03236278f, -0.03541256f, -0.03526653f, 0.04762866f, 0.00693079f, -0.04382501f, -0.06621313f, 
    -0.03650310f, 0.05609422f, 0.04122935f, -0.03995502f, 0.02399355f, 0.04721710f, -0.06202099f, 0.04534867f, 
    -0.02865319f, -0.06558525f, 0.04453161f, -0.06547937f, -0.00447014f, 0.05952325f, 0.01912102f, 0.03701592f, 
    0.00122642f, 0.00989766f, -0.05981206f, 0.02141460f, -0.07224717f, -0.07192341f, 0.04512550f, -0.02121488f, 
    0.04367274f, -0.05554849f, -0.07352442f, -0.04211983f, -0.03503682f, -0.03071388f, -0.00372334f, -0.00854795f, 
    -0.07159868f, 0.04864890f, -0.02315642f, 0.06277983f, 0.01700613f, -0.06185976f, -0.06003757f, -0.01123061f, 
    -0.07784575f, 0.05457858f, 0.04469857f, 0.03867880f, -0.07407394f, 0.01351632f, 0.03837980f, -0.08205369f, 
    0.26427671f, -0.16146085f, 0.22169843f, -0.05463947f, -0.00619792f, -0.16339281f, -0.17601819f, -0.15176697f, 
    0.06668584f, 0.11130764f, 0.09702813f, -0.02086438f, 0.08857942f, -0.32535118f, -0.10740110f, 0.04414252f, 
    0.10123099f, -0.01216226f, -0.10956660f, 0.11949904f, 0.03828590f, 0.12169269f, 0.05159650f, -0.00263788f, 
    0.32847598f, -0.02373969f, 0.38471839f, 0.27511740f, -0.02510916f, 0.03042307f, -0.17193833f, 0.03627700f, 
    0.04386766f, 0.06673017f, 0.05800925f, 0.03373884f, -0.10110966f, 0.04629492f, 0.16887547f, -0.19875360f, 
    -0.08069115f, -0.09638018f, -0.14893223f, 0.07535172f, 0.01740273f, 0.15524215f, 0.22896253f, 0.19259761f, 
    0.32451397f, -0.18656723f, 0.11756958f, 0.25834340f, 0.14317518f, 0.03884707f, -0.01529120f, 0.07673720f, 
    0.02608658f, 0.04587960f, 0.05117018f, 0.02685053f, -0.27806193f, -0.02580760f, 0.22659317f, 0.16912937f, 
    -0.00170284f, 0.10121806f, 0.02080295f, -0.04117584f, 0.13725936f, 0.08760876f, -0.07038155f, -0.10936465f, 
    -0.09023319f, -0.05242277f, 0.00308733f, -0.02852386f, -0.02336463f, 0.15548275f, 0.07598415f, 0.01093655f, 
    -0.04556804f, 0.06627723f, 0.01190644f, 0.07419246f, 0.27985799f, 0.10337389f, 0.05083880f, 0.08935191f, 
    0.00662470f, 0.12743598f, 0.02055048f, 0.18266557f, -0.11387306f, 0.00400745f, -0.09515347f, 0.03987646f, 
    -0.16881180f, 0.14994054f, -0.14657483f, 0.21695819f, -0.14874528f, -0.04956933f, -0.14198762f, -0.15641233f, 
    -0.06826111f, 0.05461355f, 0.08509850f, -0.01117515f, -0.35621724f, -0.13668725f, 0.29398620f, -0.48571908f, 
    -0.13245139f, -0.20930341f, -0.16682866f, 0.00394039f, -0.09664111f, -0.05266351f, 0.12699807f, -0.02051862f, 
    -0.03163076f, 0.18384409f, 0.30886066f, -0.04488354f, 0.00063681f, -0.16991480f, -0.18423072f, -0.09148169f, 
    0.00034280f, -0.02161071f, 0.02366338f, -0.12270766f, -0.03222713f, -0.13118167f, 0.04810666f, -0.14370048f, 
    -0.02123653f, 0.06798603f, -0.02332962f, 0.05483019f, -0.01145992f, 0.07396848f, 0.04148122f, 0.11104356f, 
    -0.30802622f, 0.20052196f, -0.20426731f, -0.05574283f, 0.09083753f, -0.00889825f, -0.04471315f, -0.03340018f, 
    -0.02154269f, -0.11704436f, 0.04229193f, -0.04293974f, -0.20474733f, -0.14364386f, 0.11591251f, 0.03203866f, 
    0.02365414f, 0.09760713f, 0.08687196f, 0.07937338f, -0.00226473f, 0.10870269f, -0.12090947f, -0.12419283f, 
    -0.05600442f, 0.08547657f, 0.09342175f, -0.08337708f, -0.04002324f, 0.29875350f, 0.14967830f, -0.16362175f, 
    0.03156105f, 0.04264411f, 0.11006697f, 0.12540005f, -0.08094134f, -0.16277376f, 0.06503427f, 0.05811752f, 
    0.06090094f, 0.03624618f, 0.04177068f, 0.08175690f, -0.10861659f, -0.08299659f, 0.02373780f, -0.05982366f, 
    -0.00062297f, -0.00222894f, 0.01782655f, -0.01462459f, 0.02235181f, 0.05779218f, 0.01836946f, -0.01531667f, 
    -0.01214880f, -0.01262549f, -0.02782964f, -0.03412110f, -0.02310272f, -0.01914885f, -0.05407841f, -0.01526724f, 
    0.02639667f, 0.04234935f, -0.00718842f, -0.07537032f, 0.03368351f, -0.07879085f, -0.06153553f, -0.02691933f, 
    0.02341586f, 0.05860285f, 0.05068118f, -0.01353010f, 0.04589035f, -0.02078348f, -0.07065558f, -0.06944300f, 
    -0.03466062f, 0.04546942f, 0.05772471f, 0.05359505f, 0.05540463f, -0.08192953f, -0.03442016f, 0.03536727f, 
    -0.02847238f, 0.03398237f, 0.03894093f, 0.04463722f, -0.07610534f, 0.01737025f, -0.01441620f, -0.01219100f, 
    -0.05527270f, 0.07412338f, -0.07002569f, -0.03762797f, -0.07755686f, -0.00938327f, -0.03285692f, 0.05264091f, 
    0.04273504f, -0.01298808f, 0.01906197f, -0.00251262f, -0.05848544f, -0.00406102f, -0.02747862f, 0.03136009f, 
    -0.04166502f, -0.04111787f, 0.00259950f, -0.00903172f, -0.06607340f, 0.02055771f, 0.06515821f, 0.02296500f, 
    -0.05858697f, -0.04103267f, 0.03326524f, -0.07890432f, 0.03355320f, -0.07974324f, -0.01844886f, -0.05518117f, 
    0.04178177f, 0.02205138f, 0.05753626f, -0.06836367f, -0.06143596f, 0.04346074f, -0.01996564f, -0.00770466f, 
    -0.02196479f, 0.03745176f, -0.07400479f, 0.04328294f, -0.05865425f, -0.02118488f, 0.00222707f, 0.01570100f, 
    0.05732785f, 0.01205834f, 0.03357349f, 0.00716496f, -0.05184603f, 0.03248432f, 0.03820232f, -0.01331940f, 
    0.02261054f, -0.05694046f, -0.07334358f, 0.00322530f, -0.06773977f, -0.06859436f, -0.00550946f, -0.02077987f, 
    -0.05977868f, 0.02949299f, 0.01445171f, -0.01848017f, 0.05516915f, -0.03145621f, -0.01979729f, 0.02765128f, 
    0.02931356f, -0.03903478f, -0.00186551f, -0.06623445f, 0.00329494f, -0.00385074f, 0.03572089f, -0.06450853f, 
    -0.08038697f, -0.00913446f, 0.00479757f, 0.02395096f, -0.07085021f, -0.03318404f, -0.03340277f, 0.05741923f, 
    0.00344916f, 0.01322841f, 0.02296199f, -0.04460419f, -0.05965196f, -0.07467070f, 0.04307390f, -0.07782592f, 
    0.04353955f, 0.04993593f, 0.05915749f, 0.02491105f, -0.02841954f, 0.01002126f, 0.02006832f, -0.07621300f, 
    -0.01232588f, -0.01995141f, -0.05469013f, 0.04885568f, -0.04607517f, -0.06167566f, -0.03034732f, -0.05495413f, 
    0.01204727f, 0.01521893f, -0.00891316f, -0.01717406f, 0.02262251f, -0.06259464f, 0.06029213f, -0.00407998f, 
    -0.05654681f, 0.02936560f, -0.07685210f, 0.00170127f, -0.06652316f, -0.03340654f, 0.05101249f, 0.05352298f, 
    -0.04356286f, -0.00236837f, -0.06800646f, -0.02338438f, 0.05505253f, -0.00698204f, -0.05264078f, -0.05065491f, 
    0.06342675f, 0.00265562f, -0.01181458f, 0.00268657f, -0.04828905f, -0.00124066f, 0.00443491f, -0.05475831f, 
    0.14675841f, -0.05854198f, -0.06183377f, -0.06338348f, 0.09271133f, -0.01418134f, -0.05602521f, 0.02292813f, 
    -0.05517465f, 0.00036024f, -0.18077229f, -0.10409234f, 0.02284331f, 0.08996089f, 0.14904793f, 0.28575203f, 
    0.06417376f, -0.18609191f, -0.13439709f, 0.02154739f, -0.08446299f, 0.06452310f, -0.16663730f, 0.02253437f, 
    0.29443857f, 0.06003074f, 0.22728224f, 0.09248471f, 0.03264176f, 0.14547087f, -0.18771785f, 0.04870562f, 
    -0.07980752f, -0.11163623f, 0.10400803f, -0.01413315f, -0.07210156f, 0.05551772f, 0.24047212f, 0.13526504f, 
    0.07366684f, 0.09337786f, 0.07628529f, 0.02899695f, -0.20579575f, 0.01138381f, -0.01952231f, -0.15143894f, 
    0.20377620f, -0.25810373f, -0.06945953f, 0.42231226f, -0.02262385f, 0.10842837f, -0.03739117f, -0.01719745f, 
    0.24489379f, 0.09405052f, -0.27404299f, -0.01249641f, 0.17713280f, -0.00775884f, -0.03898823f, 0.08724132f, 
    0.00108097f, 0.12607187f, 0.09350657f, 0.14369729f, 0.23453221f, 0.23425376f, 0.16039047f, 0.36588043f, 
    -0.30618536f, -0.25340194f, 0.07746524f, 0.02001810f, -0.14059709f, -0.13306198f, -0.06621221f, 0.16428277f, 
    -0.07812909f, -0.15631373f, -0.19990374f, -0.15201436f, 0.01022969f, -0.19730400f, 0.02857376f, 0.20618266f, 
    0.03740070f, 0.06365357f, 0.11552070f, 0.05288242f, 0.04639875f, -0.17310117f, -0.13750885f, -0.24067536f, 
    0.02015313f, 0.09886202f, -0.10527882f, -0.14013121f, 0.03605628f, -0.03110244f, -0.03331574f, 0.21621524f, 
    0.11322338f, 0.14698681f, 0.23539294f, 0.10174275f, 0.22870460f, -0.16302522f, 0.06448880f, -0.14063533f, 
    -0.01240852f, 0.16200297f, 0.04544599f, 0.04860017f, 0.04893633f, -0.03305095f, 0.05798680f, -0.02333978f, 
    0.05340898f, -0.05283211f, -0.04182129f, -0.08491782f, -0.02428800f, 0.07982836f, -0.06808200f, 0.12228119f, 
    -0.21197163f, 0.04553860f, 0.03938184f, -0.05831520f, -0.02505437f, -0.29028669f, 0.20437935f, 0.04225104f, 
    0.16618718f, -0.05521366f, -0.10052027f, -0.06165798f, -0.00203270f, -0.12141100f, -0.01072692f, -0.07965661f, 
    -0.33621773f, -0.11373620f, -0.02378544f, 0.01054169f, 0.15103859f, 0.07631833f, -0.15296119f, -0.04309781f, 
    0.01521591f, 0.11356859f, 0.13348261f, 0.11849629f, -0.24564970f, -0.33474880f, -0.09723514f, 0.33596620f, 
    -0.07363259f, 0.00628729f, 0.21768984f, -0.00911199f, -0.00177636f, 0.17254105f, 0.00407728f, 0.12444802f, 
    -0.04546352f, 0.18469785f, 0.21217531f, 0.02060654f, 0.03130724f, 0.09841863f, 0.16058522f, -0.11810930f, 
    -0.13969737f, 0.05812984f, -0.18242671f, -0.04420716f, -0.03522135f, -0.16223478f, -0.03136868f, 0.31145939f, 
    0.04157054f, 0.14072390f, 0.00693583f, 0.13857336f, 0.20551901f, -0.00554602f, 0.04461320f, 0.09659825f, 
    0.03821875f, -0.00014456f, 0.03567401f, 0.01331284f, 0.04652821f, 0.05078088f, 0.04075196f, -0.04580974f, 
    -0.05111969f, -0.04935148f, 0.01562026f, 0.02861396f, 0.04861159f, -0.07625766f, -0.07496002f, -0.02496266f, 
    0.01033590f, -0.06271625f, -0.02733842f, 0.04982488f, -0.07188246f, -0.04377004f, 0.04291573f, 0.06307913f, 
    0.03002061f, 0.00877799f, -0.05578282f, 0.00778568f, -0.00968824f, -0.03497938f, 0.01706350f, 0.01225028f, 
    -0.01635375f, 0.00565343f, -0.04940772f, 0.04343630f, -0.03559022f, 0.00699171f, 0.01307481f, 0.05940183f, 
    -0.03637026f, 0.02968086f, -0.01133124f, -0.08142543f, 0.02950203f, -0.01625971f, 0.03853549f, -0.02967159f, 
    -0.00037932f, -0.03224449f, 0.00322574f, 0.05541332f, 0.05346539f, -0.01681704f, 0.00983974f, -0.05424577f, 
    0.03775852f, -0.04464853f, 0.00232855f, 0.05000961f, -0.00450690f, -0.01958209f, 0.05459633f, -0.02918073f, 
    -0.01472642f, -0.06575394f, 0.01465405f, 0.02892334f, -0.05720979f, 0.02083413f, 0.01548926f, 0.01671571f, 
    0.02860990f, -0.05380262f, -0.07105915f, -0.03187632f, -0.04285706f, -0.03338213f, 0.06276055f, -0.01514565f, 
    -0.07055232f, -0.07541544f, -0.05860638f, -0.05093741f, 0.06194631f, 0.03647195f, -0.05836029f, -0.01702984f, 
    -0.03008366f, 0.01832391f, -0.00668447f, -0.03485261f, 0.05307237f, -0.04643760f, -0.05696595f, -0.00851461f, 
    0.04663052f, -0.06967051f, -0.04476631f, -0.00930735f, -0.02052413f, 0.02160683f, 0.05989215f, 0.03783832f, 
    -0.02282162f, -0.01160424f, -0.02896889f, 0.04191370f, -0.06922513f, -0.07073477f, 0.00222766f, 0.02311486f, 
    -0.05927408f, -0.06780611f, 0.00701410f, -0.04879891f, -0.00257943f, -0.00687212f, 0.01111201f, -0.03770931f, 
    0.04111177f, 0.01059195f, 0.05010341f, -0.05607298f, -0.04720528f, -0.02120678f, 0.01003870f, -0.04188892f, 
    -0.06834313f, 0.04903219f, 0.06345724f, -0.04217726f, 0.04497074f, -0.01742856f, 0.01093110f, 0.03336266f, 
    0.01791091f, 0.06099244f, -0.03565062f, 0.02496234f, -0.01929584f, -0.05471556f, -0.00675640f, -0.01470015f, 
    -0.05214055f, 0.02466066f, -0.00623119f, 0.04346662f, 0.01324662f, 0.04082318f, -0.06247133f, 0.02628410f, 
    0.03690887f, 0.02670571f, 0.03708871f, -0.05996948f, -0.01456436f, 0.06411447f, -0.02429507f, -0.00022647f, 
    -0.07755422f, 0.00517060f, -0.05672681f, 0.02297298f, -0.00139703f, -0.04945778f, 0.02925452f, -0.02359939f, 
    -0.00372728f, 0.04730746f, -0.03245023f, -0.07009103f, -0.04544097f, 0.00358565f, -0.03495871f, 0.03351543f, 
    -0.04077807f, -0.06746859f, 0.05179481f, 0.00826246f, -0.02832146f, -0.05538211f, 0.03723963f, 0.03042341f, 
    0.06614770f, 0.01191474f, -0.03365685f, -0.01317219f, 0.02724694f, -0.07971679f, -0.01281310f, -0.07274101f, 
    0.02142367f, -0.03704856f, 0.02258373f, 0.05275385f, 0.01450209f, -0.04420053f, -0.04386116f, 0.04470593f, 
    -0.02358200f, 0.04995524f, -0.02229799f, 0.03035705f, -0.00498849f, -0.00981475f, 0.04911392f, 0.05078142f, 
    0.04309794f, -0.04328508f, 0.05692964f, -0.03385835f, -0.00603820f, -0.03260957f, -0.04783634f, 0.00315274f, 
    -0.03571037f, -0.00884114f, -0.00304112f, 0.02975431f, -0.04349581f, -0.07673465f, -0.07895388f, 0.03104195f, 
    -0.01854657f, 0.02100737f, -0.05963377f, -0.07216519f, -0.06864519f, -0.03653759f, 0.03889414f, 0.00093886f, 
    -0.01508404f, -0.04141072f, 0.00380295f, -0.04206705f, -0.02566779f, 0.04448123f, 0.01264561f, 0.00012042f, 
    -0.04518104f, -0.07262573f, -0.01733627f, 0.00592815f, -0.04781321f, 0.00000469f, 0.05609309f, 0.00208751f, 
    -0.03854458f, -0.07945058f, -0.02055456f, 0.01630065f, -0.02463904f, -0.02943846f, -0.02091801f, -0.06286729f, 
    0.02728215f, 0.02448896f, 0.06054572f, -0.05982651f, -0.00103789f, -0.04148541f, -0.01249046f, 0.01470681f, 
    0.00483469f, 0.05694995f, -0.03248153f, 0.02149333f, -0.02777263f, 0.02613663f, 0.01073769f, 0.00180256f, 
    -0.04224493f, -0.04883231f, -0.03785941f, -0.02602954f, -0.00902461f, 0.05311167f, -0.01764059f, 0.01711029f, 
    0.04668626f, 0.04522997f, -0.03322662f, 0.03908978f, -0.02541387f, -0.03191823f, -0.05945396f, -0.06065262f, 
    -0.00703659f, -0.00966096f, 0.01511913f, 0.01627158f, 0.03678690f, -0.07263010f, -0.02260254f, -0.06224332f, 
    -0.00099025f, -0.01925370f, -0.00457200f, -0.01293375f, -0.06245522f, 0.02792796f, 0.02877498f, -0.04031877f, 
    0.06608602f, 0.04635990f, 0.05363842f, -0.00356330f, -0.06839961f, 0.02660990f, 0.00065263f, -0.02550428f, 
    -0.07685696f, -0.00145471f, -0.02142435f, 0.01779555f, -0.02220762f, -0.03836300f, -0.05839225f, -0.04008681f, 
    0.04584872f, 0.01344493f, -0.00613986f, -0.02148546f, -0.04170089f, 0.02405570f, 0.05262872f, 0.00710058f, 
    -0.03912773f, 0.00989698f, -0.06190519f, 0.05057083f, -0.08396760f, -0.04247442f, -0.02459861f, -0.00766289f, 
    -0.06140771f, 0.01989604f, -0.03954587f, -0.00117001f, -0.06196630f, 0.02801533f, 0.00075251f, -0.04060935f, 
    -0.00066579f, 0.05585418f, -0.05537582f, 0.06058474f, 0.03566010f, 0.03640234f, -0.02781335f, 0.02613710f, 
    0.00265666f, -0.03790105f, -0.01165093f, -0.05269992f, 0.04060501f, 0.04792434f, -0.06980640f, -0.03781953f, 
    -0.05240901f, -0.05822528f, 0.01156406f, 0.04874099f, -0.07622086f, -0.06814728f, 0.05161629f, -0.04375249f, 
    -0.06838275f, -0.00965250f, -0.07085209f, 0.00850873f, -0.04017127f, -0.02500344f, 0.03711165f, -0.04597612f, 
    -0.06778054f, 0.00906995f, -0.04846875f, 0.00479146f, 0.03016933f, -0.03532261f, 0.03759735f, -0.02466524f, 
    0.04301994f, -0.01142053f, 0.01798081f, -0.06873856f, -0.07602417f, -0.06209999f, -0.07246835f, -0.04566235f, 
    -0.05937633f, -0.05671149f, 0.02613411f, 0.00969075f, -0.05549703f, -0.00703058f, -0.01261407f, -0.07267325f, 
    -0.00797510f, 0.02761518f, -0.00256376f, 0.03624731f, -0.06298902f, -0.06655932f, 0.05548269f, 0.03281407f, 
    -0.04374080f, -0.02810824f, -0.03668310f, 0.02050176f, 0.00811306f, -0.04411257f, -0.00849086f, 0.05440812f, 
    -0.01149081f, -0.02287181f, -0.05599432f, -0.00004160f, -0.04838488f, -0.08417190f, -0.04264071f, 0.04712572f, 
    0.02187944f, -0.04091361f, -0.06889176f, 0.01592945f, -0.05896285f, -0.04554094f, -0.01206724f, 0.05185627f, 
    -0.02847391f, -0.07569459f, -0.05345364f, -0.03446639f, -0.01508356f, -0.05926760f, -0.00931923f, 0.04268223f, 
    0.01920860f, -0.01728475f, -0.00400401f, 0.03004026f, 0.00971176f, -0.01982481f, -0.00056538f, 0.02605188f, 
    0.04421598f, -0.03698041f, 0.00850439f, -0.02238141f, 0.05462987f, -0.07749800f, 0.02500732f, -0.05013865f, 
    0.01337288f, -0.03268120f, -0.03418681f, 0.00005485f, 0.06374817f, -0.01811360f, -0.06276398f, -0.05215714f, 
    -0.07178898f, -0.05206884f, 0.01406773f, 0.00791748f, -0.01591834f, -0.01173631f, 0.03665933f, 0.02876613f, 
    -0.05029264f, -0.00809054f, 0.01800258f, 0.04645691f, -0.03016106f, 0.06038840f, 0.00768299f, 0.00455118f, 
    0.02161968f, 0.00951914f, -0.06179738f, 0.05663749f, -0.01532393f, -0.01475482f, 0.02329185f, 0.01305335f, 
    0.06056803f, 0.02871780f, -0.02988767f, -0.00242380f, 0.02283515f, 0.02547047f, 0.01311931f, 0.02841827f, 
    -0.01303931f, -0.04539469f, 0.05009543f, 0.02305569f, 0.04060660f, 0.00346388f, 0.05837668f, -0.02012536f, 
    0.00344013f, 0.04856040f, -0.05107521f, -0.06826764f, -0.04999621f, -0.05667878f, -0.08220678f, -0.05011611f, 
    0.00657893f, 0.00207706f, -0.07668801f, 0.06165856f, 0.02451357f, -0.06680378f, 0.00618655f, 0.05151075f, 
    0.05071650f, 0.01974977f, 0.02357374f, -0.02795712f, 0.01451492f, -0.02249330f, 0.01305226f, -0.00668783f, 
    0.04747832f, 0.00655722f, 0.02422318f, 0.05717939f, -0.04471758f, -0.00765506f, 0.04014144f, -0.03421578f, 
    0.01965058f, 0.02194653f, -0.07906716f, 0.00064013f, -0.07615156f, 0.01798888f, -0.01390435f, 0.04421134f, 
    0.05307334f, -0.07089118f, 0.01168190f, -0.05925628f, 0.05667065f, 0.02789476f, -0.06718992f, 0.04755927f, 
    -0.06239570f, 0.01334356f, 0.04524191f, -0.06557437f, 0.04782888f, 0.00553220f, -0.07285715f, -0.04177801f, 
    -0.06060190f, -0.06756289f, 0.04309548f, -0.05533655f, 0.03828371f, 0.01998861f, -0.00220954f, -0.04508569f, 
    0.00492570f, -0.06352967f, 0.03713927f, 0.00911768f, -0.00512584f, -0.02484680f, -0.06301774f, 0.02622748f, 
    -0.00571735f, 0.04377832f, -0.00932042f, -0.07557556f, -0.01086374f, 0.03621736f, -0.04954437f, -0.00745453f, 
    -0.00590656f, -0.07702579f, 0.05964725f, 0.05550747f, -0.02818263f, -0.02462843f, 0.01293923f, -0.02790296f, 
    0.00416832f, -0.04093593f, 0.05464918f, 0.00852331f, 0.04443583f, 0.01576340f, -0.06293738f, -0.03854483f, 
    -0.05661156f, 0.05001099f, 0.04854198f, -0.03627840f, -0.03429839f, -0.00812334f, -0.00472427f, 0.00860794f, 
    -0.04366137f, 0.05459058f, -0.04570084f, 0.01696654f, -0.04145950f, 0.01825089f, -0.03510585f, -0.06035060f, 
    -0.00081003f, -0.05631950f, -0.00167238f, 0.02560524f, 0.01202406f, 0.06645657f, 0.05427461f, 0.03292295f, 
    -0.05644168f, 0.05855453f, 0.05762668f, 0.00099121f, 0.00217274f, 0.02817341f, -0.02864915f, -0.07146498f, 
    -0.02825669f, -0.04019269f, -0.03033053f, -0.05985671f, -0.03818272f, 0.03964481f, -0.04506883f, 0.04813634f, 
    0.02841719f, -0.03819947f, -0.07472242f, 0.04790395f, -0.07276312f, -0.04646868f, -0.01665266f, -0.07223301f, 
    0.00123782f, 0.04712884f, 0.03278219f, -0.02819670f, -0.01560158f, 0.00801350f, 0.05491120f, -0.06928952f, 
    -0.00340834f, 0.02156436f, 0.01821295f, 0.02613220f, -0.00206601f, -0.03380290f, -0.02122006f, 0.03474413f, 
    -0.00693090f, 0.06323539f, 0.01459157f, 0.04240463f, 0.02513190f, -0.04773813f, -0.04011252f, -0.03351592f, 
    -0.07470344f, -0.07269942f, -0.04893221f, -0.05737052f, -0.01997440f, 0.04923657f, -0.03137272f, -0.03017976f, 
    -0.05874678f, 0.06196668f, -0.00568996f, -0.01389948f, 0.05152336f, 0.01928151f, -0.01782630f, -0.05221746f, 
    -0.02229476f, 0.06608578f, 0.03896251f, -0.04834215f, 0.03447755f, -0.00424735f, -0.05735783f, -0.01842662f, 
    -0.01261286f, -0.03275973f, -0.06501620f, 0.04906620f, -0.02190182f, -0.04445930f, -0.03089268f, 0.05091973f, 
    -0.07648041f, 0.03763044f, -0.00282936f, -0.01897635f, -0.01983272f, -0.05591760f, -0.06920432f, 0.04709716f, 
    -0.02941739f, 0.06274509f, 0.05084704f, -0.01992073f, -0.07737608f, -0.05652842f, -0.01600141f, -0.05216316f, 
    0.05806981f, -0.01424562f, -0.03943950f, -0.04156627f, -0.04071825f, -0.03697563f, -0.07100718f, -0.05241330f, 
    0.05256746f, -0.02524315f, 0.00517037f, -0.04223996f, -0.02388467f, -0.03074512f, -0.06930356f, -0.03936224f, 
    0.04905531f, -0.04386983f, -0.02067000f, 0.01898426f, -0.03356884f, -0.05081170f, 0.05797797f, 0.03619571f, 
    -0.07357384f, 0.00372424f, 0.02862592f, 0.01409917f, 0.06905568f, 0.04554651f, 0.02564525f, -0.06479713f, 
    0.04547137f, -0.05925937f, -0.05069340f, -0.00546182f, -0.06384600f, -0.06809259f, -0.04070874f, -0.02311731f, 
    0.05402714f, 0.01962716f, -0.03293581f, -0.07244671f, 0.06344295f, 0.00528437f, 0.04657457f, 0.03523339f, 
    -0.03860809f, 0.01055505f, 0.02609586f, -0.01936112f, -0.06344061f, -0.07103731f, 0.06147388f, -0.06804115f, 
    -0.07729305f, 0.00044298f, -0.05580929f, 0.05528743f, -0.00364679f, -0.03445536f, -0.00652737f, -0.01028408f, 
    -0.02701710f, -0.02772263f, -0.00916142f, -0.03213652f, -0.01523242f, 0.02438010f, 0.01306672f, 0.00992220f, 
    0.04836952f, 0.01189765f, -0.02123139f, 0.01046292f, -0.00504621f, -0.00307475f, 0.04638905f, 0.01100124f, 
    -0.03414525f, -0.08067912f, 0.04187796f, -0.01749991f, -0.01987910f, -0.05338557f, 0.04720116f, -0.00705016f, 
    -0.01351475f, -0.00262869f, 0.01487397f, -0.08123205f, 0.01260224f, -0.04156696f, -0.03867045f, -0.03263389f, 
    0.03520851f, -0.00829941f, -0.05623202f, -0.03246473f, 0.05654444f, -0.00523459f, -0.01975556f, -0.03981021f, 
    0.02099947f, -0.07923044f, 0.05362371f, -0.06672794f, -0.04311866f, 0.02265870f, 0.02010332f, -0.04275025f, 
    -0.03182590f, 0.04405317f, -0.02107403f, 0.02576618f, -0.01331458f, 0.00335941f, 0.01388952f, 0.03284565f, 
    0.01816225f, -0.03220694f, -0.07055462f, 0.01355643f, 0.05376847f, -0.03219018f, 0.03813684f, 0.03186902f, 
    0.06538414f, 0.00860030f, 0.03028487f, -0.04017264f, -0.07849639f, -0.07147932f, 0.00914761f, -0.07365557f, 
    -0.06932113f, 0.04831295f, 0.00986146f, -0.06315456f, -0.05184899f, 0.01236064f, -0.03471265f, 0.04254342f, 
    -0.00348697f, -0.08267698f, -0.07168645f, -0.06787732f, -0.03505957f, -0.03321210f, -0.04025130f, 0.01034035f, 
    0.02613021f, -0.08290218f, -0.07890264f, -0.02775054f, -0.08127959f, -0.01802958f, 0.04510908f, -0.04266470f, 
    -0.07789561f, -0.03699212f, -0.00152781f, -0.00974831f, 0.03911943f, -0.08557858f, -0.05706086f, 0.00572097f, 
    -0.03151978f, 0.02224249f, 0.01004655f, 0.04212539f, -0.04229233f, 0.02963335f, 0.02026335f, -0.03634321f, 
    0.05321658f, 0.02107492f, -0.00251205f, -0.06152262f, -0.03240995f, 0.05486029f, -0.07486425f, 0.00492534f, 
    -0.01338489f, -0.00972219f, -0.01886826f, 0.02602881f, -0.01673947f, -0.01463833f, -0.02563722f, -0.06071791f, 
    -0.01768746f, -0.01923812f, 0.04887497f, 0.03370515f, 0.01374662f, -0.04155817f, -0.02720558f, -0.05441535f, 
    -0.02868125f, -0.04394366f, 0.01005905f, 0.04097555f, -0.01521334f, -0.01845163f, 0.03996743f, -0.01277761f, 
    -0.08452901f, -0.07209916f, 0.02507699f, 0.00802982f, 0.05510305f, -0.04971987f, 0.02101479f, 0.05210579f, 
    0.00631387f, -0.05596493f, -0.03942396f, 0.06873076f, -0.01780899f, 0.02869485f, -0.01346432f, -0.00747704f, 
    -0.06204854f, 0.03537249f, -0.05008446f, 0.06298456f, 0.02807449f, 0.03246187f, 0.01848938f, -0.05419464f, 
    -0.04259678f, 0.02141519f, 0.05191084f, 0.01690141f, 0.02232914f, -0.03959876f, 0.05275894f, 0.02310103f, 
    0.02783025f, 0.00260051f, 0.05400437f, 0.00399821f, 0.03674617f, -0.04206607f, 0.03417492f, -0.01546030f, 
    0.06269331f, 0.05958516f, -0.05083681f, -0.00504568f, 0.00162751f, 0.05983691f, 0.03717325f, -0.00310543f, 
    -0.01894521f, 0.05678608f, 0.00911488f, -0.06074685f, -0.02033516f, -0.04306988f, -0.00135284f, -0.04475344f, 
    0.01731464f, -0.03749435f, -0.05602007f, -0.05880098f, 0.06033368f, 0.01645152f, -0.00162357f, -0.01030016f, 
    -0.02621071f, -0.00490559f, 0.05336863f, 0.02368490f, -0.04838063f, -0.04087491f, 0.03334932f, 0.00194387f, 
    -0.01216986f, 0.02243141f, -0.06974208f, 0.05293219f, -0.00727335f, 0.05141460f, -0.02929541f, -0.04208087f, 
    -0.07358283f, -0.03091815f, -0.00828253f, -0.01617373f, -0.03043143f, 0.03782065f, -0.00976897f, -0.07470964f, 
    -0.01135734f, -0.05316746f, -0.03401421f, -0.03893662f, -0.03304974f, -0.01455754f, 0.04344754f, 0.00317320f, 
    0.01780744f, -0.03694136f, -0.07317570f, 0.00563146f, 0.00078805f, 0.04824599f, 0.03249240f, 0.03856359f, 
    -0.05197859f, -0.02822785f, 0.00607033f, -0.03594219f, -0.03516380f, -0.02697567f, 0.01313130f, -0.05957905f, 
    0.03051595f, 0.01689738f, 0.04083136f, 0.04454387f, 0.01013567f, 0.01440604f, -0.03898378f, -0.01389126f, 
    -0.02113895f, -0.06837704f, 0.01881796f, -0.00447306f, -0.06908635f, -0.00973578f, -0.06448525f, -0.07816299f, 
    0.04310570f, -0.04548623f, -0.05488329f, 0.04154080f, 0.03887992f, 0.01638960f, 0.03352488f, 0.02170665f, 
    -0.07263989f, -0.03088858f, -0.07413186f, -0.04974103f, 0.00751196f, -0.03661765f, -0.04936296f, 0.04099433f, 
    0.03739096f, -0.04087273f, 0.04696967f, -0.05564608f, 0.04720471f, -0.04298684f, -0.02410591f, 0.03722648f, 
    0.05089701f, 0.06040256f, 0.02051798f, -0.05521867f, -0.01190809f, -0.07643133f, -0.01013647f, -0.04488854f, 
    0.02179443f, -0.04415729f, -0.05541098f, -0.01765955f, -0.07866280f, -0.05622355f, -0.06939565f, -0.00473253f, 
    -0.03726472f, -0.03110111f, -0.02349667f, 0.05677056f, 0.05811527f, 0.00973009f, -0.01729230f, -0.02967817f, 
    -0.02494209f, -0.03448662f, 0.05843942f, 0.00408359f, -0.05971549f, -0.01540422f, -0.05894028f, -0.04832256f, 
    0.04917873f, 0.01973644f, -0.06121562f, -0.04152927f, 0.02127286f, -0.06264956f, -0.05223762f, 0.01384995f, 
    0.03952787f, -0.00786954f, 0.03858929f, 0.01824198f, -0.03641081f, -0.06049320f, -0.04098314f, -0.02724626f, 
    0.06221254f, 0.03448255f, -0.01410169f, -0.07396832f, 0.02639762f, -0.04778201f, 0.00718241f, -0.06040166f, 
    0.04724182f, 0.04373981f, -0.03902770f, -0.05224368f, 0.06946718f, -0.03259557f, 0.07217100f, 0.03156726f, 
    -0.06248482f, 0.05850405f, -0.07659139f, -0.07738685f, -0.02975895f, -0.04865326f, 0.00033567f, -0.02553024f, 
    0.10279917f, 0.19936597f, 0.01892059f, 0.11343925f, -0.05615897f, 0.04166671f, -0.02013484f, -0.16054507f, 
    0.20360398f, 0.16544022f, 0.08408303f, 0.12433987f, -0.09639204f, -0.32352364f, -0.17926160f, -0.07267649f, 
    0.03618474f, 0.05410512f, 0.08731931f, -0.00575097f, -0.02870003f, 0.00992925f, 0.06765334f, -0.06709848f, 
    0.05417859f, -0.02030334f, 0.16861928f, 0.15949707f, -0.03374904f, -0.11692244f, -0.08506905f, 0.01711868f, 
    0.03116559f, -0.00277715f, -0.09632584f, 0.00366796f, -0.11552055f, 0.00648460f, -0.15162022f, -0.24773073f, 
    -0.09197616f, 0.03304896f, -0.09506354f, 0.10773502f, 0.00300616f, -0.04763981f, 0.00960415f, 0.14727177f, 
    0.18164860f, -0.00401987f, 0.24844040f, -0.14097340f, 0.18731914f, -0.00003879f, -0.03582409f, 0.15215617f, 
    -0.05178565f, -0.04876572f, 0.15446235f, 0.02682273f, -0.06604733f, 0.17033869f, 0.27591118f, -0.07772810f, 
    0.09404402f, 0.02403990f, -0.04975268f, 0.09984019f, 0.04244747f, -0.08070070f, 0.08694270f, -0.18826541f, 
    0.17844449f, 0.25046700f, 0.02885086f, -0.08272350f, 0.11388308f, 0.22385626f, 0.17514515f, 0.11056464f, 
    0.00052177f, -0.00283981f, -0.01223083f, 0.08871348f, 0.13602230f, 0.13804220f, -0.07684074f, -0.15797241f, 
    0.02727150f, 0.03910907f, -0.03890814f, 0.06651613f, -0.06093996f, 0.05999267f, -0.03187667f, 0.14283068f, 
    0.09997900f, 0.06400397f, 0.08476004f, 0.29193631f, -0.23385185f, -0.04512434f, -0.10828879f, -0.17242323f, 
    -0.00148610f, -0.12109220f, -0.02069994f, 0.17735586f, -0.28522626f, 0.06798078f, 0.30876377f, -0.14462642f, 
    -0.06304790f, -0.24256018f, -0.14109084f, -0.01892584f, -0.13835926f, -0.01277593f, 0.05617430f, -0.02703503f, 
    0.09769792f, 0.11343389f, 0.28025857f, 0.06479740f, -0.04797073f, -0.12589301f, -0.03287482f, -0.17598325f, 
    -0.02723479f, -0.12965949f, -0.06252472f, -0.01218155f, -0.11750213f, 0.03038915f, -0.00709087f, -0.05898988f, 
    -0.17671627f, -0.08130255f, -0.06984188f, 0.09537754f, 0.11546287f, -0.05987728f, 0.10096151f, 0.21710826f, 
    0.31122813f, 0.04542581f, -0.08331563f, 0.29979539f, -0.08514397f, 0.00922987f, -0.07605307f, 0.03442989f, 
    0.11831753f, -0.21007344f, 0.01786383f, -0.08938245f, -0.00445809f, 0.12105232f, 0.14615686f, -0.24177119f, 
    0.10790619f, 0.00984696f, -0.09352194f, 0.21243292f, 0.11731027f, 0.02242869f, -0.14667323f, -0.08205236f, 
    0.06207121f, -0.04610586f, 0.01067809f, -0.27374184f, -0.12297473f, 0.03089469f, 0.09620716f, 0.08496964f, 
    0.05029828f, -0.00010847f, 0.17110014f, 0.10390485f, -0.02783332f, 0.07352120f, 0.12794338f, -0.23647001f, 
    -0.03809021f, -0.08487769f, 0.05173528f, 0.12654608f, -0.16028798f, 0.03020259f, -0.04832897f, -0.01609249f, 
    0.11778710f, -0.30441922f, 0.08205900f, -0.05392601f, 0.01999244f, 0.04588702f, -0.03330905f, -0.23675761f, 
    -0.02546933f, -0.01881367f, -0.12041128f, -0.09549502f, 0.05810082f, -0.21907018f, -0.12645620f, 0.18307370f, 
    0.15023969f, -0.03213840f, -0.13321844f, 0.02747262f, 0.01023589f, 0.02207868f, -0.07216543f, -0.09852723f, 
    0.41596237f, -0.14317563f, 0.05655542f, 0.12954293f, -0.06716984f, -0.06462049f, -0.14641336f, -0.03619356f, 
    0.03850952f, -0.13152161f, -0.05008505f, -0.13258414f, -0.00117156f, 0.23461206f, -0.14949444f, -0.06929153f, 
    0.19006997f, -0.04072730f, 0.04838973f, 0.19370331f, -0.10355569f, 0.00699833f, 0.00362179f, -0.00835678f, 
    0.44409934f, -0.10834218f, 0.28745598f, 0.41238159f, 0.01357578f, 0.00745073f, -0.07796051f, 0.02344832f, 
    0.14698081f, 0.09753800f, -0.10930557f, 0.02242751f, -0.16397284f, -0.04588094f, 0.06735699f, -0.03831596f, 
    -0.05270494f, -0.04882033f, -0.05371474f, 0.08437278f, 0.17829625f, 0.10147069f, 0.05354394f, 0.01376830f, 
    -0.01017123f, 0.27686417f, 0.05746717f, -0.04505145f, -0.02720140f, 0.07871637f, 0.01536899f, 0.16603865f, 
    -0.01773249f, 0.01443263f, -0.04410521f, -0.05913983f, 0.03642596f, 0.10527182f, 0.02942556f, 0.02383043f, 
    0.00904360f, -0.00794798f, 0.04664970f, 0.18116805f, -0.08697256f, 0.02836462f, -0.12291551f, -0.01595190f, 
    -0.15697311f, 0.11088797f, -0.11780367f, 0.22933145f, 0.11048571f, 0.06273384f, -0.15180957f, -0.11870234f, 
    0.08308196f, 0.02244265f, 0.21360086f, 0.07752477f, -0.26306817f, 0.00385950f, 0.23120347f, -0.11837134f, 
    -0.00310014f, -0.06562313f, -0.14280988f, 0.06528269f, 0.08630379f, 0.03529360f, 0.14254926f, 0.01022935f, 
    -0.09697062f, -0.02950108f, 0.06562530f, -0.01125973f, 0.02250655f, -0.15256386f, -0.09558574f, 0.00048786f, 
    -0.02823418f, -0.05007844f, 0.01663812f, -0.12256030f, -0.00719006f, -0.19622780f, 0.24765198f, -0.23572527f, 
    0.05147541f, 0.12488335f, 0.12101731f, -0.17606652f, 0.05815511f, -0.20035280f, -0.03754734f, -0.03622700f, 
    -0.16829942f, 0.00008467f, -0.04481822f, 0.21496773f, 0.04029690f, -0.02373873f, -0.19700158f, 0.08086985f, 
    0.11352507f, -0.14226164f, -0.03542235f, -0.01241266f, -0.22781904f, 0.08590252f, 0.26642916f, 0.12964389f, 
    0.20049289f, 0.04427212f, 0.09053621f, 0.00704818f, 0.09533697f, 0.08080114f, 0.01448501f, 0.13373934f, 
    0.10038185f, -0.16657338f, 0.01194217f, -0.38416910f, 0.13542175f, 0.15129277f, -0.02201173f, -0.18730472f, 
    0.02706782f, -0.07217495f, -0.11653567f, -0.04329711f, 0.05322063f, 0.19921198f, 0.20355518f, 0.08746396f, 
    0.04844292f, -0.00799531f, -0.00766731f, 0.07782840f, -0.00043740f, -0.03539733f, 0.09148619f, 0.12338831f, 
    -0.13204119f, 0.05937856f, 0.02692164f, 0.02823118f, 0.02447250f, -0.06832995f, 0.10758712f, 0.06431427f, 
    0.10144868f, 0.03704076f, -0.10348053f, 0.15300940f, -0.16047280f, -0.00386212f, 0.35585573f, 0.14282177f, 
    -0.12993117f, 0.06886428f, 0.10728945f, 0.00738457f, -0.06357597f, -0.14600441f, 0.07422003f, 0.02399323f, 
    -0.39924893f, -0.08379264f, 0.09412211f, 0.09634869f, 0.07915226f, 0.00691544f, 0.11769693f, -0.05841707f, 
    -0.03635970f, 0.07221583f, -0.03278493f, 0.03995476f, -0.13159296f, -0.06926951f, -0.01351094f, -0.30247214f, 
    -0.06461545f, 0.00276602f, 0.09389697f, 0.05923548f, -0.06524252f, 0.00254899f, 0.03665258f, -0.06240673f, 
    0.19556667f, 0.00986199f, -0.08674957f, -0.17749168f, -0.04288783f, -0.05912313f, -0.04557787f, 0.18940057f, 
    0.09249672f, 0.02435739f, 0.00715046f, 0.06620197f, 0.17383243f, 0.08727164f, 0.00058020f, -0.05722308f, 
    0.06719890f, 0.11571681f, -0.00726968f, -0.00590530f, 0.06449362f, -0.01964091f, 0.21012571f, 0.10457325f, 
    -0.04432609f, 0.05615764f, -0.00026801f, -0.06400353f, 0.09183840f, 0.06888656f, 0.12832227f, -0.01299510f, 
    -0.00192851f, 0.03540475f, -0.01750196f, 0.11022896f, -0.00492283f, -0.07791960f, -0.39023206f, -0.08207634f, 
    0.14897870f, 0.14487867f, -0.08901018f, -0.08171090f, 0.14736171f, 0.04501248f, -0.14640346f, 0.05904418f, 
    -0.01165104f, -0.14137065f, 0.08401863f, 0.04742163f, -0.12093414f, 0.01535808f, -0.05548830f, 0.08117123f, 
    0.02547214f, 0.08992343f, 0.02447767f, 0.11317683f, -0.25280935f, -0.14091790f, -0.10005556f, -0.07718065f, 
    0.08454735f, -0.08583833f, -0.08966219f, 0.06818130f, -0.09215432f, 0.01215086f, -0.10913443f, 0.06595971f, 
    -0.13197374f, -0.11586604f, -0.00768435f, -0.07406146f, 0.09262439f, 0.05205324f, 0.10693589f, -0.01868418f, 
    -0.10167842f, -0.07408679f, 0.01952930f, -0.01800390f, -0.00596790f, 0.04817304f, -0.02150933f, 0.06108584f, 
    -0.13193686f, -0.14918178f, -0.00583232f, 0.12702058f, 0.08811529f, 0.13422674f, -0.06284011f, 0.14543971f, 
    0.29136726f, 0.03017041f, 0.06535283f, 0.29075968f, -0.08274105f, -0.06267504f, -0.00683140f, 0.08842054f, 
    0.17580619f, 0.02373974f, 0.09298178f, -0.04511043f, 0.18598385f, 0.09139355f, 0.07655885f, -0.21957839f, 
    -0.02939976f, 0.07640176f, -0.01623916f, 0.08879504f, 0.02390779f, 0.06152680f, -0.11503681f, -0.04570289f, 
    0.09764735f, -0.07789454f, -0.07967638f, -0.31369698f, 0.03840884f, -0.07700719f, 0.10494903f, 0.08946691f, 
    0.13511634f, 0.01935228f, 0.06110408f, -0.13565673f, -0.02958139f, -0.01164478f, 0.00539633f, -0.46603423f, 
    0.19334504f, -0.02266928f, 0.04026972f, 0.07735508f, -0.07492108f, 0.03907054f, 0.09393298f, 0.08731495f, 
    -0.00082760f, 0.13161366f, -0.04924165f, 0.04709841f, -0.09021810f, 0.04417893f, -0.02806239f, 0.04370731f, 
    -0.10078657f, -0.00001327f, -0.16948967f, -0.12389215f, 0.03069230f, 0.18785062f, 0.06415115f, 0.09790385f, 
    0.02170348f, -0.08554012f, -0.00528898f, -0.00388084f, -0.02799225f, 0.09521154f, -0.06810828f, 0.01263450f, 
    0.38984415f, -0.09613355f, -0.00207212f, -0.02954084f, -0.14869106f, 0.05456034f, -0.01903223f, 0.09216371f, 
    0.02936173f, -0.02297442f, 0.03337225f, -0.09006635f, 0.31349352f, -0.21854748f, 0.08894446f, 0.02142961f, 
    0.10819954f, 0.03670026f, 0.09191148f, 0.06448753f, -0.06428287f, -0.08802973f, -0.17848755f, -0.07124239f, 
    -0.26148027f, 0.19584700f, 0.11779463f, 0.17558281f, 0.05753533f, 0.12690225f, 0.14283374f, -0.08653841f, 
    0.11112978f, -0.01143611f, -0.08127452f, 0.07609123f, 0.05681862f, 0.16697052f, -0.02329938f, 0.16267349f, 
    0.05779883f, 0.00817345f, 0.16812399f, 0.08362181f, -0.03119816f, 0.14521360f, -0.00063280f, 0.23887751f, 
    0.20912562f, 0.16344444f, 0.13027124f, 0.11207784f, -0.00644650f, 0.07541528f, -0.17090496f, -0.03745051f, 
    0.00745965f, -0.06961381f, -0.10651755f, -0.09244706f, 0.17113450f, 0.16744193f, 0.35901687f, -0.07477622f, 
    -0.04563153f, 0.16763523f, 0.16415867f, 0.12463330f, -0.06314667f, -0.03860181f, 0.06419938f, -0.22026424f, 
    -0.07164595f, -0.02362702f, -0.20633465f, -0.06274108f, 0.07620248f, -0.02359175f, -0.09688473f, 0.03672450f, 
    -0.06760064f, -0.04302934f, 0.15422492f, -0.09883246f, 0.35795254f, 0.00777524f, 0.02248386f, 0.01069971f, 
    -0.02344299f, 0.11194678f, 0.10161944f, 0.03687747f, 0.11531662f, 0.07295214f, -0.10319784f, -0.08588588f, 
    0.02866119f, 0.01715759f, 0.06501778f, 0.07341975f, -0.00973315f, 0.05522016f, -0.05854893f, -0.06943250f, 
    -0.01605385f, 0.00248933f, -0.02815221f, -0.11043797f, -0.22416703f, -0.01771636f, -0.10675298f, 0.13906221f, 
    0.01143702f, 0.16190965f, -0.00906385f, -0.13530470f, -0.09461923f, -0.11046014f, -0.04356846f, -0.16980641f, 
    -0.37577274f, -0.08116080f, 0.16606018f, 0.02435070f, 0.05505247f, 0.00565712f, 0.07241935f, -0.16170038f, 
    0.01598912f, 0.12382211f, -0.02398867f, -0.00935797f, -0.00668944f, 0.19385260f, 0.02996037f, 0.09836265f, 
    0.02373961f, -0.02629114f, 0.03256257f, -0.05468995f, 0.00480890f, 0.16422644f, 0.11525727f, 0.11155110f, 
    -0.08555940f, 0.04934313f, 0.02050781f, 0.37180719f, 0.03493565f, 0.07927544f, -0.05789799f, -0.00580663f, 
    -0.25139320f, 0.03133209f, -0.18841596f, -0.04649547f, 0.15803967f, 0.05995578f, 0.25450683f, 0.29859644f, 
    -0.15033054f, 0.03263793f, -0.05568963f, -0.08521842f, 0.11428520f, 0.05493353f, 0.07124396f, 0.14479555f, 
    -0.05128981f, -0.06711056f, 0.07784527f, -0.13261764f, 0.05407768f, -0.08495161f, -0.06835083f, 0.00215337f, 
    0.15787598f, 0.15235986f, 0.02766032f, -0.01250183f, 0.16522419f, -0.24245605f, 0.06975867f, -0.13177222f, 
    0.10563707f, 0.02784901f, -0.01623692f, 0.06260217f, -0.07482769f, 0.25064632f, 0.22814505f, 0.05028121f, 
    -0.12461052f, -0.05013115f, 0.31420416f, 0.06887684f, -0.04763739f, -0.18608119f, -0.16375680f, 0.01747139f, 
    -0.09883036f, 0.12431300f, -0.05060253f, -0.07712191f, 0.06595962f, 0.06038828f, -0.03611942f, -0.06072141f, 
    -0.28577545f, 0.00562176f, 0.02214244f, 0.02907234f, -0.00726955f, 0.02436177f, 0.03790934f, 0.06279756f, 
    -0.02647300f, -0.07087059f, 0.05170226f, -0.10282725f, 0.26159826f, -0.07214532f, -0.01632049f, 0.21304537f, 
    0.01739265f, 0.04665437f, 0.17194791f, 0.01048874f, -0.01411881f, -0.21810676f, 0.16312967f, -0.04515018f, 
    -0.04022809f, 0.15686604f, -0.04889035f, 0.01355204f, 0.02655024f, -0.00484399f, -0.02345980f, -0.16014497f, 
    0.05126100f, -0.06849099f, -0.01450838f, 0.04302783f, 0.20075075f, 0.13475257f, 0.04200898f, -0.01363840f, 
    0.04420773f, -0.03672035f, -0.00835297f, -0.04953188f, 0.17176676f, -0.07849006f, -0.01497684f, 0.09749150f, 
    0.07789753f, -0.05592901f, -0.09484643f, 0.06089551f, -0.07525138f, 0.02026757f, -0.02079509f, 0.21882568f, 
    0.17882274f, -0.01443675f, 0.13386925f, 0.02496545f, -0.07653116f, -0.04912298f, -0.06722676f, -0.03949034f, 
    -0.13615479f, -0.03743511f, -0.12934928f, -0.00332594f, -0.00222244f, -0.03580659f, 0.16070072f, -0.12539189f, 
    -0.17213908f, -0.15459417f, -0.02278690f, 0.10580615f, -0.01404642f, -0.01932997f, 0.13656223f, -0.05349745f, 
    0.13891920f, 0.34298769f, 0.19446358f, -0.18130575f, -0.09385186f, -0.15861988f, -0.11141358f, -0.18650256f, 
    0.04232818f, -0.09261155f, 0.10665283f, -0.00400886f, 0.12916602f, 0.18439837f, -0.08660080f, -0.31465060f, 
    0.04945863f, 0.06705344f, 0.08516088f, 0.12351082f, -0.03276334f, 0.18051624f, 0.17830321f, 0.04561937f, 
    0.22894558f, 0.54113299f, -0.15146449f, -0.45875108f, 0.03783450f, 0.10715047f, 0.05318933f, 0.00717495f, 
    0.13428497f, -0.07756561f, 0.03654554f, -0.07714523f, -0.00693953f, -0.03123773f, 0.09455637f, 0.12783952f, 
    0.05599891f, 0.02765595f, 0.01405832f, 0.08134133f, 0.00921741f, -0.11789317f, -0.15445979f, -0.07382201f, 
    -0.03217838f, 0.04455221f, -0.04552874f, -0.07526196f, -0.13886601f, -0.07550557f, 0.23252593f, 0.06178799f, 
    0.28805232f, 0.14589956f, 0.31462523f, 0.05698542f, -0.05000036f, -0.25303137f, 0.01750492f, -0.03902640f, 
    0.08415867f, 0.04535577f, 0.06796113f, 0.06092004f, -0.09780709f, -0.05367811f, 0.00694366f, -0.01793762f, 
    -0.00798041f, -0.15782943f, -0.02669091f, 0.04066290f, -0.03725349f, 0.07968353f, -0.05745627f, 0.08773012f, 
    0.04739340f, 0.05785198f, 0.15068531f, 0.03842504f, -0.24942897f, -0.14942607f, 0.01905857f, -0.03354273f, 
    0.12084806f, -0.00248878f, -0.05395394f, 0.00731190f, 0.07493788f, 0.25554210f, 0.08076919f, 0.00797017f, 
    0.21075130f, -0.03999574f, -0.39726353f, -0.16748795f, 0.16939580f, 0.08617629f, 0.12574944f, 0.02622536f, 
    -0.00295518f, -0.06802611f, -0.04899634f, -0.04749977f, -0.10696822f, 0.02837281f, -0.20839381f, -0.03241493f, 
    0.11752164f, -0.10820662f, 0.00544483f, -0.01202651f, 0.00626161f, -0.01209675f, 0.04548889f, 0.11537779f, 
    0.09984313f, -0.45640957f, 0.17055450f, 0.21675284f, -0.07081833f, 0.08774775f, -0.10218734f, 0.12394810f, 
    0.13980022f, -0.05217206f, -0.03716263f, -0.08252062f, 0.13347182f, -0.18431659f, -0.18963580f, 0.27452424f, 
    0.01680926f, 0.00177039f, 0.22659603f, 0.28670675f, -0.00606604f, -0.08074071f, 0.07733414f, -0.12488437f, 
    -0.12867984f, 0.04607286f, -0.02280128f, -0.10940678f, 0.03218402f, -0.05701804f, -0.06493910f, -0.04414210f, 
    -0.04795045f, -0.07907877f, 0.06984000f, 0.04468580f, -0.08027082f, -0.33155659f, 0.13625954f, 0.13703588f, 
    0.04889235f, -0.00283375f, 0.12684563f, -0.00899067f, 0.05030428f, -0.06554268f, 0.04319685f, -0.04896880f, 
    -0.00553837f, 0.04804267f, -0.05171856f, -0.08893598f, -0.04586233f, -0.02228034f, -0.06397730f, -0.03847221f, 
    0.09396886f, 0.03007980f, 0.18829204f, 0.07931806f, 0.00549816f, -0.25243777f, -0.02576001f, -0.14996658f, 
    -0.03818271f, 0.11503426f, 0.18451726f, -0.06584742f, -0.06692670f, -0.02626646f, 0.04068780f, -0.20428121f, 
    0.03788982f, -0.04872908f, -0.19414309f, 0.00172853f, 0.12995811f, -0.04064759f, 0.00476890f, 0.09401633f, 
    -0.12868552f, -0.05186089f, -0.00559905f, 0.04681794f, -0.04674717f, -0.15369929f, 0.20107321f, -0.08103668f, 
    0.03443614f, -0.08934924f, 0.06970912f, -0.01884874f, 0.05573696f, -0.03436520f, 0.13175696f, 0.09871300f, 
    0.00779602f, -0.17538987f, 0.32822567f, -0.15515503f, -0.00756915f, -0.12564428f, -0.13918662f, -0.00240017f, 
    0.08571193f, 0.08678347f, 0.00792742f, 0.04093048f, -0.20446216f, -0.07252361f, 0.11217648f, -0.09231638f, 
    -0.02424047f, 0.19859357f, -0.01248690f, -0.01755754f, 0.00362861f, -0.05751753f, 0.08454998f, -0.02905838f, 
    0.20779094f, 0.00011410f, 0.11511185f, 0.02994465f, 0.06580393f, 0.01474946f, 0.01955235f, -0.02678326f, 
    0.20908137f, 0.11383979f, -0.01604483f, 0.08445696f, -0.15641245f, -0.09709416f, 0.04135290f, -0.02154554f, 
    0.06702980f, 0.16086495f, 0.15783860f, -0.11927075f, -0.12721187f, -0.07651944f, -0.00298593f, 0.12842460f, 
    -0.22584607f, 0.20806830f, -0.06712577f, 0.08495327f, -0.00130771f, -0.03992315f, 0.06966470f, -0.05106870f, 
    0.15626740f, 0.18475270f, 0.26036510f, 0.18775375f, -0.18926181f, -0.10983089f, -0.16556221f, -0.17086098f, 
    -0.14635293f, 0.01075071f, 0.14129899f, 0.06157657f, 0.12115634f, -0.07489797f, 0.15154029f, -0.05391163f, 
    -0.01301159f, 0.34120685f, 0.02225263f, 0.06163919f, -0.08651496f, -0.05146381f, -0.09715431f, -0.02669819f, 
    -0.06605859f, -0.07316321f, -0.00859573f, 0.02023964f, 0.35010177f, 0.12895606f, 0.00614696f, -0.02914616f, 
    0.06676248f, -0.06104624f, -0.05128633f, 0.02712971f, 0.11773562f, -0.02384351f, -0.05750789f, 0.04061327f, 
    -0.60784417f, 0.09002172f, -0.07747541f, -0.06124614f, -0.06270462f, 0.01199636f, 0.09636673f, 0.02784373f, 
    0.06568705f, 0.05473170f, 0.02618513f, 0.04874261f, 0.08434759f, 0.03685618f, 0.07958858f, -0.04125403f, 
    0.09711962f, 0.09785632f, -0.14963634f, -0.01578077f, -0.15248501f, -0.12967166f, 0.01716941f, -0.21351247f, 
    0.13238652f, 0.14585318f, 0.22141075f, 0.14265622f, 0.06416971f, 0.21655899f, 0.37623626f, 0.16416633f, 
    0.06065645f, 0.06645833f, 0.09594601f, 0.09042207f, -0.11936180f, 0.05751686f, -0.00040782f, 0.04377666f, 
    0.04645497f, -0.07260625f, -0.07752690f, 0.10360201f, 0.01094608f, -0.01559933f, 0.08342557f, 0.11394943f, 
    0.17330697f, -0.18356095f, 0.16058469f, 0.06579563f, -0.12660211f, -0.11817456f, -0.02005921f, -0.12521710f, 
    0.14405715f, -0.18629283f, -0.14948860f, 0.17857119f, -0.14833981f, -0.01067142f, 0.01939535f, -0.02591812f, 
    0.08737639f, -0.25710499f, -0.27154255f, -0.11115397f, -0.10641391f, -0.07234766f, -0.01626865f, 0.01308347f, 
    0.23590811f, 0.22293790f, 0.19774704f, 0.12635189f, -0.08747234f, -0.06843764f, -0.09838489f, -0.16512150f, 
    0.12179650f, -0.12674624f, -0.08187813f, 0.00177648f, -0.02340450f, 0.18299295f, -0.24248262f, 0.19489196f, 
    -0.06944552f, -0.01243066f, -0.04360865f, -0.01163562f, 0.11776149f, 0.05292472f, 0.06955793f, 0.15726295f, 
    0.16731088f, -0.12798823f, -0.06580008f, -0.00419540f, -0.20513731f, 0.04948484f, -0.02566770f, 0.00344852f, 
    0.09261210f, -0.17019427f, 0.07209772f, -0.10584515f, 0.17507505f, -0.03411534f, 0.12216597f, 0.05095271f, 
    0.03012175f, -0.09229194f, -0.13502719f, 0.25868687f, 0.01366689f, -0.04612906f, 0.03795360f, 0.05944311f, 
    0.08441941f, 0.00279783f, -0.12116572f, 0.05873463f, 0.03818984f, -0.06660798f, -0.01487038f, 0.07026334f, 
    0.10465860f, 0.00641437f, 0.20597357f, 0.02009911f, -0.15682204f, 0.14908375f, -0.01683621f, 0.03808922f, 
    0.02752569f, -0.19992515f, -0.02762305f, 0.05326657f, -0.02201374f, -0.02912167f, -0.11618693f, 0.05245890f, 
    -0.05631919f, -0.04586666f, -0.06360421f, 0.01352881f, -0.01924651f, -0.00052754f, 0.01197383f, -0.02322765f, 
    -0.07987565f, -0.07254755f, 0.05688678f, -0.07719326f, -0.06127232f, 0.04768137f, 0.03277329f, 0.03423254f, 
    0.03326884f, -0.02711345f, 0.05020839f, -0.04407454f, -0.01330496f, 0.00967252f, 0.03896213f, 0.06102791f, 
    -0.02517926f, 0.03422581f, -0.07235691f, -0.04750089f, -0.06996807f, -0.00484427f, 0.04267095f, 0.02337459f, 
    -0.03358312f, -0.04221396f, -0.04701751f, -0.00663516f, -0.04448966f, -0.00256745f, 0.03506862f, 0.06050204f, 
    0.04879098f, 0.01787377f, -0.05965854f, 0.05003093f, 0.04757114f, -0.06749659f, 0.03838039f, -0.07896899f, 
    0.02403522f, -0.06167453f, 0.06871179f, 0.02047002f, 0.05846856f, -0.00349819f, -0.07327382f, 0.06062368f, 
    0.05461421f, 0.03128110f, 0.03170389f, 0.00768788f, -0.03041295f, -0.01328607f, -0.03909953f, -0.03504109f, 
    -0.02800975f, 0.01124580f, -0.06908055f, 0.04281704f, 0.01492865f, 0.00643109f, -0.02770604f, -0.02665055f, 
    -0.05557334f, 0.03979516f, -0.03397329f, 0.06867552f, -0.06690232f, -0.05019294f, 0.02352223f, -0.07390861f, 
    -0.02984840f, 0.04366821f, -0.06329890f, 0.00900090f, 0.03342013f, -0.03533067f, -0.03592326f, -0.02130126f, 
    -0.02621510f, -0.06968788f, 0.05696319f, -0.05608588f, -0.04125737f, 0.04075032f, -0.03459215f, -0.04464738f, 
    0.01104153f, -0.06329396f, 0.01963795f, -0.01770283f, -0.07709204f, -0.06111300f, -0.00167585f, 0.03424794f, 
    -0.03474286f, 0.04455113f, -0.05513979f, 0.01895667f, 0.03198169f, 0.06079995f, -0.06421148f, -0.07868645f, 
    0.05833863f, -0.00546659f, -0.01880812f, 0.00469606f, 0.02037927f, 0.00100451f, -0.04122459f, 0.00253987f, 
    -0.04307081f, -0.04421246f, 0.04413731f, 0.02499277f, 0.00478621f, 0.01941774f, 0.05055066f, -0.01331317f, 
    -0.05066999f, -0.03070545f, 0.00571553f, -0.01960182f, 0.00199425f, -0.04082409f, -0.06726933f, 0.02943183f, 
    -0.06341426f, 0.06041224f, 0.01257493f, -0.01169693f, 0.03928808f, 0.03826998f, 0.05798516f, -0.02681541f, 
    -0.02113103f, -0.03328638f, -0.04412345f, 0.02987402f, -0.01353076f, 0.04451980f, 0.00664594f, 0.01806623f, 
    0.00147894f, -0.05388183f, -0.04475470f, -0.06367820f, -0.02515614f, -0.04548829f, -0.03080361f, 0.06124398f, 
    -0.01375210f, -0.00621854f, -0.01350704f, -0.04699666f, -0.02257597f, 0.03929179f, 0.03494057f, 0.03334938f, 
    0.03534800f, -0.01367161f, 0.04602390f, -0.07538100f, -0.06564666f, -0.01871786f, -0.04209485f, 0.04822297f, 
    0.02544557f, 0.06174893f, -0.05512932f, -0.06715479f, -0.03736556f, -0.06391744f, 0.00858732f, -0.04723352f, 
    0.02540861f, 0.01870463f, 0.04670649f, 0.02266552f, -0.07384016f, -0.03254986f, 0.04479459f, -0.04170342f, 
    0.06954637f, -0.15642273f, 0.08435296f, 0.05593779f, -0.01323691f, 0.15236877f, -0.02217147f, -0.00520790f, 
    -0.05994301f, -0.04396025f, 0.00050509f, -0.03252440f, -0.34783694f, -0.13651361f, -0.00288761f, 0.19045377f, 
    0.22980036f, 0.01742820f, 0.00623585f, -0.10738114f, 0.01563540f, 0.06699886f, -0.11022333f, 0.02758557f, 
    0.47786090f, -0.26962131f, 0.04998465f, 0.03907099f, 0.13350862f, 0.09557480f, 0.02035644f, 0.00767339f, 
    0.06920622f, -0.04255221f, -0.02814407f, -0.06470126f, -0.17115618f, 0.14416096f, -0.11663634f, -0.21817251f, 
    0.20093551f, 0.04999662f, -0.05991457f, 0.15731202f, -0.04336278f, -0.02056675f, -0.05408278f, 0.00389627f, 
    0.47297135f, -0.04484562f, 0.30189762f, 0.20576458f, 0.00172131f, -0.03266826f, 0.06138271f, 0.07123620f, 
    0.14319669f, 0.02141882f, 0.04520065f, 0.03945956f, -0.02575656f, 0.02137283f, -0.09317473f, 0.04583245f, 
    -0.01195103f, -0.05092750f, 0.07593255f, -0.02153211f, 0.25772524f, 0.10386123f, 0.00434785f, 0.14398472f, 
    -0.04704744f, 0.09259539f, -0.13549541f, -0.24894777f, 0.00345613f, 0.05402991f, -0.14258377f, 0.03701619f, 
    -0.02980627f, 0.02967006f, -0.02078331f, -0.13056070f, 0.13480002f, 0.07278506f, -0.02298521f, -0.04080781f, 
    0.13643070f, 0.10340095f, 0.07019766f, -0.01126914f, 0.08831908f, 0.03170765f, 0.06100288f, -0.11919114f, 
    -0.28785762f, -0.13602090f, -0.25972053f, 0.19330387f, 0.00399903f, 0.00899766f, -0.05274046f, -0.03797614f, 
    0.06358454f, -0.01096622f, 0.16889761f, 0.08365943f, 0.00218712f, -0.01316630f, 0.09967460f, -0.16531856f, 
    0.07406774f, 0.10294662f, 0.11275518f, 0.01510208f, 0.04212362f, 0.04208218f, 0.08333932f, 0.15116978f, 
    -0.05839414f, -0.29336911f, -0.00162609f, -0.09677429f, 0.11889382f, 0.09809268f, 0.01085857f, 0.08289149f, 
    -0.13451152f, -0.03552945f, 0.01724460f, -0.08660576f, -0.08919930f, -0.03474415f, -0.01574421f, -0.01477573f, 
    0.15146177f, -0.11914080f, -0.00441975f, 0.00607474f, 0.10792285f, -0.06963642f, 0.01480703f, -0.04937092f, 
    -0.04432784f, -0.04693204f, 0.02564893f, 0.27686507f, -0.01515308f, 0.04421566f, -0.06337011f, 0.17635286f, 
    0.06368157f, 0.02859813f, 0.01500010f, 0.02130586f, -0.07662646f, 0.28275064f, 0.02544397f, -0.25248575f, 
    0.02577475f, 0.02363526f, 0.13443629f, 0.01562513f, -0.07524872f, -0.05013007f, -0.01752535f, -0.06385504f, 
    0.01695798f, -0.03941773f, 0.03310936f, -0.10185584f, 0.01482685f, 0.05536656f, -0.00869594f, -0.04823866f, 
    -0.00401097f, 0.02204830f, -0.15535438f, -0.09076342f, 0.12657903f, 0.06558567f, 0.02605055f, -0.26522028f, 
    -0.07495238f, -0.00322757f, 0.01204559f, 0.04466897f, 0.01611865f, 0.07087813f, 0.06742719f, 0.01022948f, 
    0.06416171f, -0.03377996f, -0.06346230f, -0.05694300f, -0.02728460f, -0.07418676f, -0.03541159f, -0.06813281f, 
    0.06436638f, -0.00754310f, 0.05561554f, -0.03409931f, -0.02570108f, 0.06703152f, 0.04939179f, 0.03514856f, 
    -0.06671697f, -0.04635657f, -0.06940123f, -0.03442175f, -0.00543009f, -0.06755824f, -0.05831416f, -0.01635179f, 
    -0.03970233f, -0.00300849f, 0.06711746f, 0.03352726f, -0.05471642f, 0.05137664f, -0.06259605f, 0.06442232f, 
    -0.07302576f, 0.03277355f, -0.01614637f, -0.07297057f, -0.05122893f, -0.02426468f, -0.03616368f, -0.03255945f, 
    -0.04756973f, 0.06662550f, -0.06144507f, -0.05026143f, -0.06464276f, -0.02069888f, 0.04080740f, 0.02712786f, 
    0.07150219f, -0.00166346f, 0.05522863f, 0.06467147f, 0.02385653f, -0.04349554f, -0.02266853f, -0.05061858f, 
    0.01764264f, 0.03442587f, 0.05731767f, -0.02729026f, -0.04126716f, 0.01330625f, -0.07511983f, -0.03549575f, 
    -0.05571403f, 0.01510850f, -0.03833403f, -0.04319020f, -0.05560841f, 0.02113391f, -0.06274522f, -0.03542658f, 
    -0.01463526f, -0.00174754f, 0.05707343f, 0.00408958f, 0.04388012f, -0.03873754f, -0.00764109f, -0.06723679f, 
    0.04945178f, -0.00168245f, 0.06565875f, 0.03120553f, -0.05318467f, -0.03717115f, -0.06963523f, 0.06474935f, 
    0.03182596f, 0.00001509f, 0.03317459f, 0.03808019f, -0.04119857f, 0.06357829f, 0.04983698f, 0.02570913f, 
    0.01187254f, 0.06707463f, 0.00849712f, -0.06989169f, -0.03099664f, -0.03175020f, 0.01197721f, -0.05725835f, 
    0.04263353f, -0.05635154f, -0.07305914f, 0.00205610f, -0.05111561f, -0.02628043f, 0.01004685f, 0.00832883f, 
    0.06523011f, 0.06078203f, 0.05257199f, -0.03592111f, -0.04324443f, 0.05072357f, 0.00020999f, 0.03319637f, 
    -0.01316803f, -0.07598928f, -0.05507085f, 0.03866165f, -0.07561563f, -0.03989676f, -0.00763063f, -0.03048057f, 
    0.03102790f, 0.01380495f, 0.01490149f, -0.01110375f, 0.03475188f, 0.02929683f, 0.02235277f, 0.02886153f, 
    -0.00388356f, 0.01227026f, -0.07442898f, -0.04122169f, 0.00703248f, -0.03965933f, -0.02354889f, 0.02508951f, 
    -0.03847864f, -0.01991286f, 0.01055286f, 0.03246711f, 0.04819158f, -0.03953604f, -0.00148703f, 0.04692983f, 
    -0.02061542f, 0.03024693f, -0.07585239f, 0.03858688f, -0.06777722f, 0.04372599f, 0.01496774f, 0.00479224f, 
    -0.04275336f, -0.01365155f, 0.04844542f, -0.00824752f, -0.05106001f, -0.00712821f, -0.02448560f, -0.04955615f, 
    -0.06950000f, -0.04857734f, -0.03683330f, -0.02874546f, -0.03730199f, 0.02894041f, 0.03013426f, -0.01748206f, 
    -0.04906822f, 0.06125266f, -0.07756774f, -0.06895430f, -0.02795286f, 0.00694603f, -0.06772549f, -0.05529553f, 
    0.02596800f, -0.02516153f, -0.06363045f, 0.00829763f, 0.04747250f, 0.05474889f, -0.01093793f, -0.00173211f, 
    0.00766136f, -0.23427606f, -0.00054036f, -0.18560617f, -0.12819298f, 0.08193766f, -0.15184279f, 0.07646691f, 
    -0.01654542f, -0.02742026f, 0.16195863f, 0.12439410f, 0.12317113f, -0.20296741f, 0.05832482f, 0.12128751f, 
    0.13584630f, 0.00917992f, 0.02763369f, 0.05006931f, 0.13031459f, 0.08524323f, -0.00126271f, -0.07860415f, 
    0.20986725f, 0.03075024f, 0.17923433f, 0.15449765f, 0.01257372f, -0.01984350f, 0.07757959f, -0.11310710f, 
    0.09355028f, -0.02009535f, 0.06009767f, -0.02496540f, -0.09927692f, 0.17918997f, 0.11390278f, -0.02802493f, 
    0.16073056f, -0.18173121f, -0.09347331f, 0.10290277f, -0.03553629f, 0.03284536f, 0.12440623f, 0.03298235f, 
    0.51793295f, -0.30637556f, 0.10080479f, 0.37261704f, -0.04527767f, 0.13412386f, -0.02252061f, 0.11044663f, 
    0.02755485f, 0.06878600f, -0.05615108f, 0.05021311f, -0.13584064f, -0.00909408f, 0.00066264f, 0.24975805f, 
    -0.01050417f, 0.17928630f, -0.00076938f, 0.17651990f, 0.18838662f, 0.08703806f, 0.02542311f, -0.16362283f, 
    -0.21142891f, 0.00548927f, 0.00482159f, 0.02290080f, -0.14370850f, -0.01358451f, 0.00627801f, 0.03123697f, 
    -0.07112455f, -0.06019231f, 0.09495094f, 0.05442772f, -0.05190758f, -0.16259702f, 0.18811177f, 0.26324099f, 
    0.11598711f, 0.14522983f, 0.08214112f, 0.12614183f, -0.03525620f, -0.02336459f, 0.05839160f, -0.01399643f, 
    -0.00821347f, 0.03268551f, -0.05969393f, -0.09117850f, -0.06170927f, -0.12756014f, -0.07241179f, -0.05297783f, 
    0.17995004f, -0.08659157f, 0.13671775f, 0.12577894f, -0.60820985f, -0.21086670f, 0.34401429f, -0.23338351f, 
    -0.10801375f, 0.01794774f, -0.23711541f, -0.01823035f, -0.00131551f, -0.02203498f, -0.00815460f, -0.09800933f, 
    -0.17910188f, 0.08063153f, 0.01782067f, 0.03970197f, -0.03274314f, -0.19930470f, 0.09296925f, 0.13619316f, 
    0.02709595f, -0.09116238f, 0.15183616f, -0.00907628f, -0.01983817f, -0.32035789f, 0.20450500f, -0.15722522f, 
    0.10472192f, -0.05923207f, -0.01399232f, -0.04563676f, -0.03991845f, -0.05395432f, -0.00900473f, 0.02360316f, 
    -0.01157798f, -0.05711065f, 0.07197462f, -0.16030608f, -0.08450045f, -0.15453859f, -0.26867548f, 0.11944982f, 
    0.09312267f, -0.00378298f, 0.16652256f, -0.02553491f, -0.22704214f, -0.08785930f, 0.01615706f, -0.04789728f, 
    0.13301738f, 0.02539399f, 0.11822025f, -0.11244256f, 0.11658619f, 0.10719945f, -0.06150053f, 0.08644113f, 
    0.02892144f, -0.10132264f, 0.05465058f, -0.08614013f, 0.13492283f, 0.14925723f, -0.08975690f, -0.20607112f, 
    0.05127742f, -0.05565151f, -0.01927155f, 0.03369515f, -0.12857577f, -0.08025658f, 0.09685425f, 0.08286822f, 
    0.13983983f, -0.03295816f, -0.03625411f, -0.06145252f, 0.03819386f, 0.01409251f, 0.01905737f, 0.05727585f, 
    0.07962067f, 0.02761984f, 0.08198505f, -0.11884826f, 0.03308280f, -0.03984949f, -0.08154860f, -0.01448889f, 
    0.04667766f, 0.23650980f, 0.10272655f, 0.11247307f, 0.02094984f, 0.02987917f, 0.01241992f, -0.16374367f, 
    -0.01301932f, 0.04184639f, -0.09981266f, 0.00789720f, 0.01608202f, 0.24994250f, 0.00034264f, 0.11422271f, 
    0.24198471f, -0.03598380f, -0.04752311f, -0.03790946f, -0.14093915f, 0.01056996f, -0.14481471f, -0.06304575f, 
    -0.01996343f, -0.00559841f, -0.09718680f, -0.02509079f, 0.06959860f, -0.29325506f, 0.09355868f, 0.04244087f, 
    -0.13521816f, -0.07907539f, 0.07803140f, -0.20702165f, 0.10953181f, -0.02600888f, 0.00310036f, 0.09244267f, 
    -0.12822224f, 0.02067337f, -0.10156188f, 0.03789730f, 0.15311038f, 0.08825797f, 0.10740028f, 0.05970988f, 
    0.04085066f, 0.00379740f, 0.03333823f, -0.03720184f, -0.03310714f, -0.11184074f, 0.16485330f, 0.08033027f, 
    -0.05983567f, 0.01872659f, 0.21772128f, 0.07136069f, -0.00359000f, -0.05249292f, -0.08067489f, -0.10942616f, 
    0.12419986f, -0.09611350f, 0.15741000f, 0.06146129f, -0.01183575f, -0.06649905f, 0.11359669f, 0.06320232f, 
    0.03166265f, 0.01621736f, -0.02796788f, 0.11627785f, 0.01495905f, -0.18783447f, -0.02274000f, -0.05289731f, 
    0.03562705f, 0.00178109f, 0.20107009f, 0.11756399f, -0.02959164f, 0.09662921f, -0.01280143f, 0.10287418f, 
    -0.17913051f, 0.31753683f, 0.18164508f, -0.04612725f, -0.01062355f, 0.00314743f, -0.05996149f, -0.12787393f, 
    -0.08371776f, -0.02986374f, 0.03519391f, 0.08108246f, 0.14721589f, -0.02436061f, -0.08672360f, -0.19399938f, 
    -0.19701734f, 0.03941994f, 0.16183691f, -0.01971048f, -0.11138400f, -0.00317674f, -0.00845200f, -0.06116386f, 
    0.08162193f, 0.16684857f, -0.07271653f, 0.08387494f, -0.18284766f, -0.06365555f, -0.02934380f, -0.03905385f, 
    0.01040066f, 0.02603712f, -0.02734183f, -0.08686719f, -0.05219539f, -0.06026990f, -0.03617840f, -0.01185644f, 
    0.19786489f, 0.05554833f, -0.02497932f, -0.10528190f, -0.11705203f, 0.08328565f, 0.30704084f, 0.15927731f, 
    -0.43782932f, 0.09150662f, 0.09792060f, -0.13893519f, -0.00679717f, 0.11618980f, -0.06709214f, -0.21792923f, 
    0.06547289f, -0.01740223f, 0.12015051f, -0.00590930f, -0.12238751f, -0.25505382f, 0.03621339f, 0.07625144f, 
    -0.06191824f, 0.11282907f, 0.03768232f, 0.16659470f, 0.14697903f, 0.04866311f, 0.08664570f, -0.10087404f, 
    0.04656515f, 0.14296421f, 0.03898735f, 0.38591373f, 0.01989709f, 0.06114512f, 0.09436952f, 0.03436953f, 
    0.11726520f, 0.05074506f, 0.22476353f, 0.25113344f, -0.05351722f, -0.17290202f, -0.02539228f, 0.15755737f, 
    -0.07468788f, 0.15119705f, 0.07479414f, 0.10190167f, -0.03760319f, -0.07046371f, -0.16742957f, 0.02676354f, 
    0.18243146f, -0.07800025f, 0.12232770f, -0.15154605f, -0.11625073f, -0.11904319f, -0.09828858f, -0.07912217f, 
    0.02279310f, 0.06706039f, 0.04187950f, 0.01783631f, 0.03510088f, -0.05354905f, 0.10972749f, 0.10324553f, 
    0.09958426f, 0.00325493f, -0.08033308f, -0.00594872f, 0.02882068f, 0.09200870f, 0.01711962f, 0.12859024f, 
    0.14066640f, 0.05846669f, 0.40008450f, 0.27327773f, 0.02310847f, 0.09918743f, -0.01582496f, 0.01385151f, 
    -0.04080127f, 0.09167720f, 0.04798510f, 0.11372139f, -0.26163778f, -0.17738739f, 0.32425481f, -0.07802241f, 
    -0.17371172f, -0.10365064f, 0.06356508f, 0.03017320f, -0.08786651f, 0.02619931f, 0.12059507f, 0.00647718f, 
    0.35278481f, -0.14039016f, -0.02935850f, 0.13054016f, 0.10516613f, 0.00203211f, -0.02567736f, 0.00034066f, 
    -0.00039824f, -0.01602659f, -0.04406651f, 0.05534978f, -0.04444415f, 0.07347435f, 0.14349021f, 0.14691387f, 
    -0.01380352f, 0.04776231f, 0.03635200f, 0.11073319f, 0.07924611f, 0.10642184f, -0.04768135f, -0.04995460f, 
    -0.06044793f, -0.30696738f, -0.03243131f, 0.06551977f, -0.01156892f, -0.06936090f, 0.03403380f, -0.03667803f, 
    0.09926043f, 0.05286975f, -0.04223505f, -0.01930011f, 0.21883678f, -0.06784701f, -0.04846499f, -0.03486227f, 
    -0.00730658f, 0.15873376f, 0.12743869f, 0.14997432f, 0.00250304f, 0.12116417f, 0.06646578f, 0.12736575f, 
    -0.17218621f, 0.31313390f, 0.00915020f, -0.13934100f, -0.00133714f, -0.03300560f, -0.06035922f, -0.10478600f, 
    -0.10006601f, -0.00367840f, 0.03923538f, -0.01680254f, -0.32968736f, 0.05031367f, 0.00574925f, -0.17734078f, 
    -0.08861291f, -0.09357368f, -0.02578538f, -0.04546677f, -0.18996091f, -0.01686306f, -0.00501398f, -0.04259448f, 
    -0.03782597f, 0.06506380f, 0.05635371f, 0.01626726f, -0.14406818f, -0.04070678f, -0.02230033f, -0.02866584f, 
    -0.11960359f, 0.04572417f, 0.09992833f, -0.01181937f, 0.08526245f, -0.09144756f, 0.09317859f, -0.10961544f, 
    0.13030015f, -0.01179388f, -0.02530937f, 0.01479495f, -0.06399903f, 0.02845230f, 0.07909914f, 0.12134083f, 
    -0.23221907f, 0.06577671f, -0.10764935f, -0.01526563f, 0.14514783f, 0.05827469f, -0.17343980f, -0.05277711f, 
    -0.05217146f, 0.00786838f, 0.15584657f, -0.01115350f, -0.22270872f, -0.30818024f, -0.06776240f, -0.07532630f, 
    0.08547516f, 0.14779037f, 0.14317667f, 0.01339032f, -0.00688837f, 0.17413443f, -0.11993323f, 0.02293106f, 
    -0.26813224f, 0.13390377f, -0.00645242f, 0.06588821f, -0.12085817f, 0.25371662f, 0.05931052f, -0.14584477f, 
    -0.00343578f, 0.05779892f, 0.14291750f, 0.15702505f, 0.05022095f, -0.20535156f, -0.01006074f, 0.13197586f, 
    -0.01816371f, 0.06706454f, 0.15396090f, 0.00574293f, 0.08079048f, 0.05748436f, 0.06048077f, 0.01233422f, 
    0.02770631f, -0.05469237f, -0.06705125f, 0.01347110f, -0.04980034f, 0.00490498f, 0.00430441f, 0.00590497f, 
    0.02540615f, -0.03082332f, -0.07062082f, -0.02238873f, -0.06437286f, -0.02992443f, -0.03329373f, 0.03672471f, 
    -0.07946911f, -0.03325265f, 0.04901482f, -0.00502311f, 0.05216374f, -0.00982350f, 0.04919223f, -0.00639189f, 
    0.06180492f, -0.05970992f, 0.03017450f, -0.04797776f, 0.05520535f, -0.06433928f, -0.07574221f, -0.06892028f, 
    0.04337209f, 0.04956260f, -0.06326883f, 0.00143698f, 0.04351775f, -0.06551234f, -0.06400230f, -0.04088540f, 
    -0.01839701f, 0.03045925f, -0.04744593f, -0.04946194f, -0.03755356f, 0.00867141f, -0.06383540f, -0.06405799f, 
    0.04173728f, -0.01724748f, -0.01625836f, -0.06159352f, -0.08016750f, -0.00163324f, -0.06326975f, 0.05135652f, 
    -0.07378495f, -0.03030480f, -0.04333382f, 0.02620887f, -0.00647829f, -0.02423325f, -0.01644941f, -0.07930237f, 
    -0.05338880f, -0.07720775f, 0.03070081f, -0.05718818f, 0.03351884f, 0.03115623f, 0.00741970f, -0.03638032f, 
    0.01843751f, 0.00928406f, 0.01245085f, -0.04764489f, -0.00955427f, 0.05865506f, -0.03081464f, 0.03335641f, 
    -0.06880071f, -0.03643119f, -0.07487982f, -0.03816622f, 0.04573662f, -0.01574640f, -0.02836202f, 0.04903245f, 
    0.03474997f, 0.05537145f, 0.00932557f, 0.04826010f, -0.05601717f, 0.05694878f, 0.04545962f, 0.06349020f, 
    0.05040141f, 0.01531312f, 0.01086819f, 0.04427835f, -0.01602278f, -0.05541270f, 0.00207919f, -0.00116477f, 
    0.05214824f, -0.06744581f, -0.00502956f, 0.03474185f, -0.07624853f, 0.03107201f, -0.03977288f, -0.01530231f, 
    0.02229766f, -0.01201340f, -0.03455420f, -0.05685652f, 0.04840463f, -0.05513494f, -0.06468694f, -0.01411767f, 
    -0.06078641f, -0.07750406f, 0.06173308f, -0.07813037f, 0.02200083f, 0.02121295f, 0.02349594f, -0.04693970f, 
    -0.07990762f, -0.07428347f, -0.05908085f, -0.03906779f, -0.00683535f, -0.06932709f, -0.05960653f, 0.01430284f, 
    -0.05959952f, -0.01529275f, 0.05062874f, 0.04035608f, -0.04064250f, -0.02030074f, -0.03978095f, -0.02181245f, 
    0.01915531f, -0.01823910f, -0.00165097f, -0.00612770f, 0.06032006f, -0.04846758f, -0.05780945f, -0.05819667f, 
    -0.05503270f, -0.03602249f, -0.04443644f, -0.06499117f, 0.03065323f, -0.02841474f, 0.00922462f, -0.06473510f, 
    0.02119826f, -0.06608284f, -0.03593001f, -0.01939736f, -0.02686000f, 0.06557280f, 0.05928695f, -0.01703687f, 
    -0.03447547f, 0.00222508f, 0.04339320f, -0.04219890f, 0.04354306f, -0.03551713f, 0.02856485f, 0.03816270f, 
    -0.01111529f, -0.02948905f, 0.02898280f, 0.02530572f, -0.08014603f, -0.05779264f, -0.00585454f, -0.07282797f, 
    0.04258815f, -0.01256116f, 0.02167076f, -0.01461660f, -0.03873894f, -0.01906127f, -0.05209428f, 0.03641227f, 
    -0.10954592f, 0.13235116f, -0.11756080f, -0.03001126f, -0.15014456f, 0.15510620f, 0.02789857f, 0.02283815f, 
    -0.03804351f, 0.32883167f, 0.30458683f, 0.06222014f, 0.08797443f, -0.00112860f, 0.03878822f, -0.07235515f, 
    0.04924491f, -0.06080091f, 0.02903477f, -0.00474029f, 0.10036976f, 0.02638961f, 0.03771075f, -0.01859407f, 
    0.17313381f, -0.08825148f, -0.22610198f, 0.03581854f, -0.02266247f, 0.09903894f, 0.09486210f, -0.04872171f, 
    0.04964278f, -0.05829372f, -0.09287967f, -0.08577716f, 0.33816874f, -0.17895052f, -0.03015749f, -0.04636800f, 
    0.14704533f, 0.11310468f, -0.06993948f, 0.11724419f, 0.20469378f, -0.10421087f, -0.15038711f, 0.06735611f, 
    -0.18340410f, 0.18212655f, 0.26179180f, 0.15254262f, -0.02037008f, 0.09649307f, -0.01368974f, -0.08904807f, 
    -0.10399200f, 0.01448880f, -0.13488887f, -0.00390945f, -0.15917119f, 0.10296683f, -0.01760285f, 0.03184520f, 
    -0.04192860f, -0.04582395f, -0.06283920f, -0.03035431f, -0.13628724f, 0.05625075f, -0.18432523f, -0.10377039f, 
    0.05719127f, 0.15099932f, 0.10812614f, 0.15482244f, 0.08424688f, 0.26125920f, 0.14051530f, 0.06592283f, 
    0.05843362f, 0.03715074f, 0.05385220f, -0.01074043f, -0.17104629f, 0.10235804f, 0.49757093f, 0.07165053f, 
    0.13070102f, 0.23938374f, 0.15899754f, 0.17325900f, -0.01834128f, -0.08693792f, 0.03172533f, 0.03121229f, 
    0.06870396f, -0.19559596f, -0.00781831f, 0.10876431f, 0.00840980f, -0.07843959f, -0.07890243f, -0.09282976f, 
    0.16431147f, -0.14894430f, -0.00025508f, 0.07263954f, -0.28811181f, -0.18727465f, 0.05680348f, 0.06607318f, 
    -0.04750564f, 0.12957503f, 0.01205503f, -0.07206352f, -0.04154108f, 0.09079064f, -0.04073520f, -0.02342713f, 
    -0.21779625f, -0.04841626f, -0.02119428f, 0.23760216f, -0.00362021f, -0.03980939f, 0.14000295f, 0.05019221f, 
    0.08108795f, 0.01657550f, -0.07927865f, 0.06990301f, -0.12281364f, -0.05811229f, 0.08475924f, 0.09986618f, 
    -0.00712903f, 0.11263328f, 0.07261426f, -0.24019660f, 0.05849019f, -0.02596343f, 0.05800900f, 0.11108529f, 
    -0.22887333f, -0.34074485f, 0.27270597f, 0.13733836f, -0.03608981f, -0.05151221f, -0.09174815f, -0.14303829f, 
    0.01936205f, -0.10599118f, -0.13125920f, -0.01028335f, -0.09863864f, 0.08739584f, 0.13441651f, 0.12577412f, 
    0.13886698f, 0.05112592f, -0.13693561f, 0.12264799f, -0.04114307f, -0.05699265f, -0.08773950f, -0.02002099f, 
    0.09202754f, -0.00316991f, -0.04776387f, 0.22023717f, 0.03364395f, 0.15846796f, -0.16046874f, -0.10495666f, 
    -0.00055340f, -0.00643889f, 0.00393644f, 0.12292281f, 0.07478494f, 0.26657042f, 0.05806165f, 0.21477807f, 
    0.04319937f, -0.02635318f, 0.04770427f, 0.02816377f, -0.05911949f, -0.13226044f, -0.13664190f, -0.14424764f, 
    0.01430327f, 0.04374852f, -0.03529343f, 0.02121602f, -0.00330898f, -0.07907189f, -0.04316974f, 0.02640406f, 
    -0.00897221f, -0.03997926f, -0.06852541f, -0.06477846f, 0.03175575f, -0.08379353f, -0.04402197f, -0.01419880f, 
    0.04318318f, -0.02131676f, 0.02322727f, -0.05714818f, -0.09692017f, -0.09668507f, 0.03938524f, -0.01095778f, 
    -0.05561078f, -0.00941888f, -0.09307885f, -0.08509721f, -0.00902940f, 0.01062603f, -0.00704182f, 0.03819841f, 
    0.00481067f, -0.04163227f, -0.07748499f, 0.02105015f, -0.03807332f, -0.02905111f, 0.02870275f, -0.04042841f, 
    -0.03350869f, -0.02748005f, 0.01016956f, 0.03412445f, 0.05809888f, -0.05728939f, 0.00852602f, -0.01551532f, 
    0.01667261f, 0.01136072f, -0.01669318f, -0.07611344f, -0.02762010f, -0.05263316f, -0.07363703f, -0.06227692f, 
    -0.05951897f, 0.02742620f, -0.07076580f, -0.01090465f, 0.03437141f, 0.05372152f, 0.00351886f, 0.00460661f, 
    -0.07851845f, -0.07703240f, -0.02208970f, -0.00225701f, 0.01553290f, -0.06593727f, -0.00365220f, 0.06328654f, 
    -0.02248080f, 0.07986452f, -0.03958571f, -0.06002853f, -0.00248165f, 0.06800935f, 0.00523105f, -0.08755491f, 
    -0.03891599f, -0.07455312f, 0.02655426f, 0.06623709f, -0.03286339f, 0.05055459f, 0.01400493f, -0.02933003f, 
    -0.00551684f, 0.03888364f, 0.05622938f, 0.05167827f, -0.09333190f, -0.04606928f, -0.03458573f, -0.02755594f, 
    -0.05825064f, 0.04086372f, 0.04088165f, -0.04077749f, 0.01172154f, -0.01501298f, 0.03652428f, 0.02567981f, 
    0.03009464f, -0.07244354f, 0.04640261f, 0.03478658f, -0.05432821f, 0.05744889f, -0.03165552f, -0.05257366f, 
    0.04186105f, -0.00314646f, -0.02371787f, -0.03418255f, -0.06481410f, 0.01777622f, -0.03386949f, -0.00013935f, 
    0.05160225f, 0.00315519f, -0.05881818f, 0.04319744f, -0.04808349f, 0.03144116f, -0.01959822f, -0.07497752f, 
    -0.01172926f, -0.04465906f, -0.03666643f, -0.00216670f, -0.06043941f, 0.03721660f, -0.05551473f, -0.02663816f, 
    0.00213980f, -0.02551880f, -0.00189555f, 0.01068972f, -0.06107635f, -0.05879966f, -0.00216689f, -0.02114030f, 
    -0.06701440f, -0.03182830f, -0.04121443f, -0.07052697f, -0.00235129f, -0.05428244f, 0.04554387f, 0.05365897f, 
    -0.06750127f, -0.00787863f, -0.04618169f, -0.06020842f, -0.04007916f, 0.07537471f, 0.03598404f, -0.04203975f, 
    0.02414371f, 0.03510835f, 0.02416451f, -0.02591928f, 0.03285599f, 0.01151965f, -0.04685066f, 0.04024932f, 
    -0.01014209f, 0.06158671f, 0.02063499f, 0.01612999f, 0.03789170f, -0.05120482f, 0.03013223f, -0.00790798f, 
    -0.05619448f, -0.02267068f, -0.03008068f, 0.02363232f, 0.07851078f, 0.01783026f, -0.02770185f, -0.01718765f, 
    -0.03922321f, 0.03542491f, -0.04181113f, -0.03067238f, -0.02180423f, 0.01368192f, -0.07319208f, -0.05829543f, 
    0.10330265f, -0.05635409f, 0.05796277f, -0.00741007f, -0.07110288f, 0.01357914f, -0.03961543f, 0.08148360f, 
    0.07234241f, -0.04859144f, 0.00063588f, -0.02202635f, -0.05372690f, -0.02129882f, 0.01213687f, 0.05420160f, 
    -0.02857357f, 0.04238185f, -0.05091770f, 0.02103464f, 0.13344178f, 0.28190398f, 0.09234238f, 0.11377756f, 
    0.12365064f, 0.05637210f, 0.08485144f, -0.05546141f, -0.01368990f, 0.03600159f, -0.03618931f, -0.03497477f, 
    -0.04965172f, -0.04555175f, 0.00410616f, -0.04843180f, -0.30070829f, 0.05765130f, 0.10009507f, 0.00633519f, 
    0.21769089f, 0.01343855f, 0.03397113f, 0.05393589f, -0.05943016f, 0.01932469f, 0.02694996f, -0.09533472f, 
    0.23300731f, -0.39340663f, -0.07398333f, 0.20741770f, 0.06353333f, 0.03889338f, 0.01521116f, 0.02332003f, 
    0.18632567f, 0.11048019f, 0.05084760f, 0.00411527f, 0.20790192f, -0.15454625f, -0.00056875f, 0.26246575f, 
    0.02255458f, 0.04191170f, 0.03941505f, 0.15126950f, 0.19753243f, 0.16240093f, 0.06843070f, 0.11699605f, 
    -0.28762683f, -0.30064443f, -0.26948720f, -0.20390047f, 0.03653096f, -0.09742859f, -0.06041493f, 0.02536878f, 
    -0.06291924f, 0.02542044f, 0.00213883f, -0.01526429f, 0.01241670f, -0.30145285f, -0.01610536f, 0.07300721f, 
    0.05548397f, 0.11780822f, 0.17151324f, -0.04584928f, 0.07163335f, 0.07825591f, -0.00836716f, 0.05457794f, 
    -0.10279168f, 0.01917103f, 0.06069318f, -0.03002387f, 0.03063997f, -0.03288345f, -0.10022334f, -0.09093679f, 
    -0.08743422f, 0.09005338f, 0.19110903f, 0.09454458f, 0.08098274f, -0.09641892f, -0.05347759f, -0.01449028f, 
    0.03500887f, 0.14638509f, 0.04338523f, -0.01633997f, -0.05457541f, -0.10183160f, -0.04015533f, -0.09770692f, 
    -0.08516610f, -0.01411980f, 0.09475294f, -0.12434290f, 0.01504527f, 0.04203932f, -0.07906407f, 0.06251077f, 
    -0.08939990f, -0.00126241f, -0.04564024f, -0.07238596f, -0.05910313f, -0.08474826f, 0.00392105f, -0.11803693f, 
    0.31709564f, -0.02352588f, 0.03284364f, 0.09155536f, 0.00385154f, 0.02409112f, 0.12885247f, -0.07838064f, 
    0.15482411f, 0.07900467f, 0.05137933f, -0.09197830f, 0.03074650f, -0.09149288f, -0.03176231f, -0.01310344f, 
    0.16774292f, 0.09630054f, 0.23354733f, 0.08082938f, -0.30152380f, -0.11908923f, -0.18920222f, -0.16285284f, 
    -0.08492699f, 0.25597534f, 0.11099034f, 0.02867556f, -0.10744146f, 0.02367078f, 0.17062524f, -0.00643317f, 
    0.03866133f, -0.02983306f, 0.02911784f, 0.08194876f, 0.08661707f, 0.04372086f, 0.06080526f, 0.15814556f, 
    0.13180242f, 0.02409524f, -0.00087950f, 0.04972986f, -0.15017492f, -0.18517044f, -0.07254615f, -0.15086852f, 
    0.11351372f, 0.21610434f, 0.09866266f, -0.08693005f, -0.01185134f, -0.14039217f, 0.03121661f, 0.03438257f, 
    -0.04417549f, -0.09074728f, -0.10575951f, -0.17257474f, -0.09124272f, 0.00382515f, -0.10070562f, 0.06685468f, 
    0.13181169f, 0.02051411f, 0.14539933f, 0.18805164f, 0.03164907f, 0.18852235f, -0.12306102f, -0.04727275f, 
    0.04089427f, 0.15373334f, 0.02929353f, 0.07222366f, -0.00812866f, 0.08438919f, -0.00925305f, 0.14631136f, 
    -0.24884382f, -0.03333114f, -0.49241766f, -0.25221229f, -0.07688242f, -0.09023129f, -0.02942267f, -0.00576073f, 
    0.00233396f, -0.05236518f, -0.10744884f, 0.01424291f, -0.02334514f, -0.09931049f, -0.19635624f, 0.30530643f, 
    -0.07235483f, -0.13150018f, 0.04893825f, -0.09125908f, 0.09842978f, 0.01619853f, 0.03171610f, 0.00214162f, 
    -0.18313679f, 0.34271780f, 0.10854249f, -0.06360568f, -0.10866518f, 0.15436763f, 0.00849105f, -0.03623936f, 
    -0.00476747f, 0.09568585f, 0.03890921f, -0.02464628f, 0.00038304f, -0.11981863f, -0.05093646f, -0.13093370f, 
    0.07220932f, -0.04556702f, 0.05840378f, -0.01891556f, -0.01588813f, -0.07681757f, -0.00235639f, -0.17712082f, 
    0.24678239f, 0.19566536f, 0.14175977f, 0.17462438f, 0.24545994f, 0.15923312f, 0.28630182f, 0.07162979f, 
    0.13378638f, 0.02054645f, 0.00531605f, 0.06363925f, -0.00213640f, 0.35353827f, 0.19870134f, 0.00060186f, 
    0.01197478f, -0.15152441f, 0.12141877f, 0.17817010f, -0.09212097f, -0.03272175f, 0.03245918f, 0.00408566f, 
    -0.12735751f, -0.09644536f, -0.02953825f, -0.08979871f, -0.11166263f, -0.00107354f, 0.03635971f, -0.05953990f, 
    -0.03738008f, 0.03392413f, 0.01908525f, -0.02849347f, -0.10743025f, -0.04421742f, -0.32257175f, -0.00788201f, 
    -0.07869524f, 0.08792458f, 0.04512691f, -0.04194925f, -0.12153535f, -0.05979389f, -0.09416873f, -0.03435751f, 
    -0.27277756f, -0.05996991f, -0.39455485f, 0.07978467f, -0.07231274f, -0.06224325f, -0.00467171f, -0.05402442f, 
    0.06294367f, -0.02625834f, -0.10961168f, 0.08125537f, 0.10446664f, 0.01682513f, 0.01980272f, 0.10918406f, 
    -0.00845721f, 0.10570103f, -0.01440720f, -0.06254527f, 0.06121895f, 0.19383869f, 0.04223052f, 0.12385744f, 
    0.02170495f, -0.12911193f, 0.15020591f, -0.16734287f, -0.04622779f, 0.02401559f, -0.01564456f, -0.13057461f, 
    -0.06941465f, 0.13150996f, 0.03124097f, 0.17305113f, 0.30629179f, 0.28893641f, 0.20271476f, 0.22619192f, 
    0.13435720f, 0.09609786f, -0.03657351f, 0.21620680f, 0.02557339f, -0.04183964f, 0.09523848f, -0.02970625f, 
    0.11468056f, -0.07128654f, -0.05778598f, 0.07077607f, -0.01594252f, -0.02848782f, -0.00634339f, 0.11517847f, 
    0.11232579f, 0.08632231f, 0.08985259f, 0.15880264f, 0.23693754f, 0.31799841f, 0.04412254f, 0.23140699f, 
    -0.02382472f, -0.01558135f, 0.08149464f, 0.06963945f, -0.10167484f, -0.09148490f, -0.10239445f, -0.05593236f, 
    -0.00788773f, -0.04701913f, 0.06050624f, -0.03030976f, 0.00294124f, 0.02170420f, -0.02484387f, -0.06315577f, 
    -0.04049196f, -0.07014006f, -0.03846224f, -0.04897441f, 0.03753848f, 0.01078697f, -0.02887963f, 0.05454782f, 
    0.03978239f, -0.05595962f, -0.04637770f, -0.04104295f, -0.01564946f, 0.02889891f, -0.00001353f, -0.05729951f, 
    -0.02106675f, 0.05876393f, -0.07415441f, -0.02615359f, 0.03456286f, -0.03205595f, -0.03505104f, 0.02964314f, 
    -0.03923048f, -0.05774981f, 0.05440868f, 0.05517050f, -0.07818823f, 0.05866178f, -0.04310077f, -0.05454390f, 
    -0.06426100f, -0.02743762f, -0.00822494f, 0.06544788f, 0.01637147f, 0.04347203f, -0.04666693f, -0.04461084f, 
    -0.07897429f, -0.07002448f, 0.00745370f, 0.00474768f, -0.05765495f, 0.01834729f, -0.05534904f, 0.02783144f, 
    0.04899159f, 0.01522796f, -0.04964542f, 0.05509679f, -0.04958372f, 0.03966410f, 0.00622668f, 0.02440033f, 
    -0.00302424f, 0.04954988f, -0.08603038f, -0.01713064f, 0.02924436f, -0.05314547f, 0.01551263f, 0.05680306f, 
    -0.00790083f, 0.01041818f, -0.03441612f, -0.07259499f, -0.00606622f, -0.01937722f, 0.03009340f, -0.05513509f, 
    -0.06604566f, 0.06173683f, -0.07952768f, -0.08555707f, 0.05958049f, 0.03439837f, -0.00512571f, -0.06101933f, 
    0.04843800f, -0.01358084f, -0.05608959f, 0.00783129f, -0.00629575f, -0.00105225f, -0.01571115f, -0.04132748f, 
    -0.04919733f, 0.06015168f, -0.06591859f, -0.03283880f, 0.00809110f, -0.06749105f, -0.07749177f, -0.01587066f, 
    -0.05363023f, 0.05856876f, -0.01024771f, 0.02186258f, 0.02689689f, 0.03731016f, -0.01575199f, -0.05444399f, 
    0.02521179f, -0.00822980f, 0.06206764f, 0.06404603f, 0.03751206f, -0.00236823f, -0.02156738f, -0.02729843f, 
    -0.00382804f, 0.01466857f, -0.00379086f, 0.01491106f, -0.01665170f, 0.04680107f, 0.02939995f, -0.06042578f, 
    0.03240136f, -0.04026154f, 0.03107177f, -0.03616082f, -0.03773789f, -0.00285797f, -0.07149832f, -0.06529640f, 
    -0.02010676f, -0.03168279f, 0.02332573f, 0.02097428f, -0.05723106f, -0.02348824f, -0.03858463f, -0.02723374f, 
    0.05226479f, 0.06210425f, -0.03492798f, -0.05509686f, 0.02736256f, -0.07798339f, -0.03217503f, -0.01389887f, 
    -0.02530462f, 0.02816507f, -0.05551281f, 0.04948907f, 0.03245588f, 0.00456405f, -0.05062048f, -0.00902298f, 
    0.01782550f, -0.08146208f, -0.05786408f, -0.07828189f, -0.07544258f, 0.00205928f, 0.05089346f, 0.04067960f, 
    -0.07352944f, 0.05716406f, -0.01686322f, 0.00181877f, 0.00040373f, 0.01668558f, -0.04500169f, 0.00552913f, 
    -0.07063028f, 0.04515429f, -0.00859346f, -0.03389971f, -0.01725117f, 0.01369107f, 0.03700354f, 0.02876920f, 
    -0.08082031f, -0.00186760f, -0.03055266f, -0.01326485f, 0.00471234f, 0.00950982f, 0.02549457f, 0.05456394f, 
    -0.05773687f, 0.16122743f, 0.18521102f, 0.04115817f, 0.01501151f, -0.03701404f, 0.06998671f, -0.07480021f, 
    -0.01523200f, 0.30373639f, -0.08044371f, 0.11911818f, 0.09124475f, 0.22062032f, 0.01512001f, 0.20635504f, 
    0.07472540f, 0.01110952f, 0.06274677f, 0.06697606f, 0.04519502f, -0.08806413f, 0.14946787f, -0.00804777f, 
    -0.19629365f, 0.01495389f, 0.00287158f, 0.16682383f, -0.02205423f, -0.11814960f, 0.03336412f, 0.02614621f, 
    -0.10174088f, -0.04185703f, 0.01805501f, 0.07818791f, 0.29518405f, 0.00154148f, 0.09161588f, -0.12367522f, 
    -0.14821321f, 0.03963496f, 0.08314427f, 0.01281405f, 0.04391426f, -0.03803614f, -0.06895860f, -0.03843984f, 
    -0.36095479f, 0.18071051f, -0.10182807f, 0.04730389f, 0.18866980f, -0.00997869f, -0.07390941f, 0.14337845f, 
    0.09583709f, -0.15251319f, -0.07708141f, -0.14619632f, -0.01489780f, 0.09331322f, -0.09904179f, -0.50705892f, 
    -0.07493232f, -0.20981367f, -0.23581129f, -0.23123085f, 0.08183513f, 0.16086543f, -0.07253741f, 0.19675921f, 
    0.01174598f, -0.06253796f, 0.06181696f, 0.03225441f, -0.04450024f, 0.01993707f, -0.01427415f, -0.02498347f, 
    -0.12016457f, -0.10845952f, -0.17593829f, -0.08900014f, -0.09852017f, 0.24318248f, -0.15851328f, 0.06535774f, 
    0.04520575f, 0.04197397f, -0.08674555f, 0.09720901f, -0.09813990f, -0.10696311f, -0.04949974f, 0.06856596f, 
    0.21971866f, -0.13586122f, -0.05616996f, 0.01965881f, 0.05273332f, -0.01581683f, -0.00008307f, -0.01586167f, 
    0.08559559f, 0.17953174f, 0.00404655f, 0.11725941f, -0.02789447f, 0.19217782f, -0.08581457f, 0.10333462f, 
    -0.08334202f, -0.06079469f, -0.00538132f, -0.03605899f, 0.10454717f, 0.08194682f, 0.03797657f, 0.16845162f, 
    -0.02744105f, -0.07021072f, 0.10882984f, -0.05808114f, -0.07196162f, 0.02942939f, 0.02658046f, 0.08984996f, 
    0.07809545f, 0.11754972f, 0.04372483f, -0.03204776f, -0.08392885f, 0.14469656f, 0.08032732f, 0.10467584f, 
    0.24322888f, 0.19353116f, -0.10940500f, 0.00299165f, -0.04040641f, -0.03128993f, -0.05215959f, -0.00171107f, 
    -0.27083722f, 0.00971168f, -0.01612992f, 0.26300222f, 0.02332394f, 0.22679755f, 0.16318502f, 0.05325641f, 
    0.01669453f, 0.18782060f, 0.14943960f, -0.07440982f, 0.08579285f, -0.13324673f, -0.00476942f, 0.11291564f, 
    -0.21222273f, -0.24349567f, -0.12428241f, 0.12389912f, -0.15220378f, -0.27194870f, -0.09757992f, 0.01985674f, 
    0.01533768f, 0.05608807f, 0.13686644f, -0.05440017f, 0.08563022f, -0.14085016f, 0.00981454f, 0.01570624f, 
    -0.11989328f, 0.26953641f, 0.21073878f, 0.00067013f, -0.14599279f, -0.17129447f, -0.07337697f, 0.02626638f, 
    0.01460999f, -0.02655508f, -0.02119173f, -0.03729321f, 0.03961248f, -0.31646100f, -0.13527517f, -0.12916811f, 
    -0.32344496f, -0.06077455f, -0.02198511f, -0.11135130f, -0.03904594f, -0.26630810f, 0.04283132f, -0.08780388f, 
    -0.20023027f, -0.06260285f, -0.19236429f, -0.09717032f, 0.38901740f, 0.36378640f, 0.27125511f, 0.26917970f, 
    -0.01755890f, 0.07495189f, 0.10575032f, 0.00370786f, -0.02472921f, -0.16215481f, 0.17071608f, 0.04026888f, 
    -0.50434721f, -0.26010573f, 0.22798419f, 0.23629940f, 0.07988016f, 0.03814961f, -0.08654005f, 0.00211460f, 
    -0.01673268f, -0.11328796f, 0.06556375f, 0.05990668f, -0.03292673f, -0.08118127f, 0.16952433f, 0.01331358f, 
    0.13837872f, 0.06102490f, 0.01139511f, 0.08664819f, -0.04514575f, -0.00129023f, -0.02479048f, -0.14444853f, 
    0.03393590f, 0.10624949f, -0.20218986f, 0.14239366f, 0.07851544f, -0.04120333f, 0.06724725f, 0.11239673f, 
    -0.00798907f, 0.12083467f, -0.03668742f, 0.07241002f, 0.13612385f, 0.17822680f, 0.12303557f, -0.03029060f, 
    -0.01849045f, 0.06984738f, -0.09696242f, -0.16151613f, 0.00340457f, 0.14430922f, 0.12122393f, 0.23426291f, 
    0.00069041f, -0.02739516f, 0.19912554f, 0.22923702f, 0.06241189f, 0.09618133f, -0.00263967f, -0.01028383f, 
    0.01267564f, -0.04457822f, -0.10979701f, -0.01635345f, 0.02792151f, 0.13382182f, -0.13272238f, 0.04197460f, 
    0.04023219f, 0.10552305f, -0.08643385f, 0.12995945f, -0.00939185f, -0.01477077f, -0.07885884f, -0.01708061f, 
    -0.06523937f, -0.15719351f, -0.17139165f, -0.13042423f, 0.11152480f, 0.01765841f, 0.10690117f, 0.10885175f, 
    -0.13062696f, 0.19545196f, -0.09893815f, 0.07330298f, -0.23668492f, -0.10088609f, -0.39327425f, -0.01548395f, 
    0.04432866f, -0.08079901f, -0.05361845f, -0.08669104f, 0.04757925f, -0.07918602f, 0.03501305f, 0.13442528f, 
    -0.42795855f, -0.43456060f, 0.09588708f, -0.25399348f, -0.03520535f, 0.00489865f, -0.09934074f, -0.09101786f, 
    -0.07577609f, -0.07692499f, 0.14876671f, -0.10012800f, 0.03885771f, 0.00463992f, -0.11908263f, -0.06923162f, 
    0.15972954f, -0.05168893f, -0.07898667f, 0.17188197f, 0.07576985f, -0.00514919f, -0.05714744f, -0.03754588f, 
    -0.34456173f, 0.00729934f, -0.38589001f, 0.01084184f, 0.01529530f, 0.02299444f, 0.09871252f, -0.06019545f, 
    0.01993501f, 0.05974411f, 0.06869936f, 0.10256565f, 0.12387968f, -0.16305332f, 0.04917916f, 0.18674110f, 
    -0.04288972f, -0.05584850f, -0.03055880f, 0.08234869f, 0.03052692f, 0.15499528f, -0.01613942f, 0.28261906f, 
    -0.15543240f, 0.09250096f, -0.09470981f, -0.23535627f, -0.02852950f, -0.17092304f, 0.18957904f, 0.03077553f, 
    -0.09211690f, 0.16467187f, -0.01271458f, -0.08841009f, 0.04338122f, 0.00415029f, -0.02207235f, 0.01735006f, 
    0.05514643f, 0.06109444f, -0.02590856f, 0.13217165f, 0.01567828f, 0.11143669f, 0.11477878f, 0.11850064f, 
    -0.06886613f, -0.02141212f, -0.02744628f, 0.10104129f, 0.02953175f, -0.00260588f, -0.01521121f, 0.11692980f, 
    -0.15576351f, -0.05212827f, -0.08982443f, -0.10675271f, -0.03760268f, 0.20550528f, 0.18230338f, -0.03250028f, 
    -0.12950814f, -0.05268572f, -0.03283537f, 0.01805531f, -0.20220725f, 0.08475839f, 0.12131570f, 0.09061673f, 
    -0.00755714f, 0.05462760f, -0.13477948f, -0.21663697f, 0.08550493f, -0.01344250f, 0.08528322f, -0.03859393f, 
    0.02883128f, 0.03541911f, -0.04409992f, -0.04512914f, 0.05245730f, 0.03332282f, -0.17922162f, -0.17071219f, 
    0.00394787f, 0.19074562f, 0.15640695f, 0.05170817f, -0.13094911f, 0.07785105f, -0.05512317f, 0.01227361f, 
    -0.17719516f, -0.16750702f, -0.00823901f, 0.07763683f, -0.01923105f, 0.03323434f, 0.04408423f, 0.28258213f, 
    0.04431663f, 0.05668662f, 0.04533549f, -0.04483314f, 0.27691808f, -0.05525744f, -0.05057668f, -0.15236230f, 
    0.00883519f, 0.07263050f, 0.01029825f, -0.03399938f, 0.15024553f, 0.01764853f, 0.05721225f, 0.18470959f, 
    0.00638362f, 0.15089735f, 0.07893336f, -0.05577530f, -0.04200824f, -0.08506746f, 0.05649180f, -0.02132946f, 
    -0.04988979f, 0.05657911f, -0.11422561f, -0.07461050f, -0.24602862f, 0.02269793f, -0.19537212f, 0.06933672f, 
    0.08557775f, -0.06799053f, -0.15520898f, -0.14433660f, 0.03606140f, 0.00699460f, -0.06575446f, 0.03957262f, 
    0.15622769f, -0.02626380f, 0.13022120f, 0.11724046f, 0.04560750f, 0.02693571f, -0.00640588f, 0.03196090f, 
    0.18648504f, -0.01049502f, 0.01845227f, -0.08462442f, 0.25650024f, -0.11931848f, -0.03794390f, -0.10821451f, 
    0.00756725f, 0.14867218f, 0.11279418f, 0.04883587f, 0.07915656f, -0.07017962f, -0.05336478f, 0.00631172f, 
    0.03760810f, -0.05050604f, -0.02969276f, -0.09480299f, 0.16020417f, 0.12067015f, -0.02844018f, 0.03005988f, 
    -0.04553897f, -0.06535517f, 0.00151697f, 0.05586185f, -0.01976465f, -0.04930516f, -0.01097197f, 0.02311791f, 
    0.03289445f, 0.01053704f, 0.01931309f, 0.13553376f, -0.12091960f, -0.12207223f, -0.06616178f, -0.18418384f, 
    0.28235999f, 0.02982257f, 0.25259179f, 0.27313730f, 0.08450304f, 0.08162959f, 0.00437014f, 0.09704074f, 
    0.06620410f, 0.07254696f, 0.04259436f, 0.13108477f, 0.19710854f, 0.18348917f, 0.10545573f, 0.04557034f, 
    -0.04893148f, 0.06972393f, 0.05267412f, 0.05351867f, -0.05614530f, -0.09508391f, -0.01060727f, -0.13073015f, 
    0.29698923f, 0.00443855f, 0.07869580f, -0.26236111f, -0.07376201f, -0.09166671f, 0.08201364f, -0.01625422f, 
    0.06172584f, 0.15842877f, -0.16867432f, -0.13287489f, -0.03355896f, -0.15165345f, -0.04613433f, -0.18366557f, 
    -0.04753976f, 0.01960168f, -0.00583268f, 0.02248815f, -0.01498721f, -0.13213396f, 0.00057637f, 0.01434248f, 
    0.03289650f, 0.06899442f, 0.00272264f, 0.02468322f, -0.03480721f, 0.05044627f, -0.02995579f, -0.04750738f, 
    0.10977287f, 0.11561894f, 0.21710886f, 0.05751295f, 0.13930057f, 0.23055750f, 0.03868204f, -0.08523821f, 
    -0.21054010f, -0.09499678f, -0.03806749f, -0.02795965f, -0.08264387f, -0.06258928f, 0.01536784f, -0.00543187f, 
    -0.08793236f, 0.20502311f, -0.27905685f, 0.07844576f, 0.05586766f, -0.06917185f, 0.07359149f, -0.04212047f, 
    0.08684211f, -0.05844419f, -0.05388529f, 0.01041170f, 0.02950001f, -0.01544308f, -0.13420512f, -0.05369939f, 
    0.02378199f, -0.02813948f, 0.13390283f, -0.07247064f, 0.02552862f, -0.03730071f, -0.07166974f, 0.07220637f, 
    -0.06255744f, 0.06452589f, 0.05013583f, -0.05239338f, -0.16319232f, 0.10340746f, -0.04981187f, 0.06320184f, 
    0.12252250f, 0.01042299f, 0.01163570f, 0.01143818f, 0.14650913f, 0.09321862f, -0.08583516f, -0.08394315f, 
    -0.08755116f, -0.04226581f, 0.02599351f, -0.05497181f, -0.06592929f, -0.08906106f, -0.01128885f, -0.08048780f, 
    -0.01469217f, 0.20148346f, 0.17124861f, -0.06888389f, -0.15822485f, 0.17310877f, 0.35545740f, 0.12557919f, 
    -0.02946278f, 0.05015831f, 0.02778714f, 0.04108195f, -0.34960982f, 0.04046983f, -0.11025687f, 0.03227093f, 
    0.05725580f, -0.03138383f, 0.07389915f, -0.00082966f, -0.01127021f, -0.03693778f, -0.05090455f, 0.13823810f, 
    0.25629359f, 0.01185044f, 0.26113573f, 0.18055628f, 0.00218173f, -0.11324202f, 0.04841512f, -0.02022327f, 
    0.19252947f, -0.11281332f, -0.00818032f, -0.00023308f, -0.18648997f, -0.00398126f, -0.21863644f, 0.08415325f, 
    0.07310911f, 0.08463451f, 0.01888613f, -0.09090471f, 0.06091315f, -0.08882675f, -0.06468425f, 0.06020198f, 
    -0.08539081f, -0.13816290f, -0.00862036f, 0.15063991f, -0.06369882f, -0.02467334f, 0.09822040f, -0.07149322f, 
    0.09393747f, -0.07786020f, -0.07115154f, 0.04925349f, 0.01393045f, -0.13741328f, 0.17449328f, -0.03469699f, 
    0.02242371f, 0.05575922f, -0.00882804f, -0.05180351f, 0.11090130f, -0.03323532f, 0.05097843f, 0.06923646f, 
    0.24309893f, -0.14250097f, 0.23908409f, 0.33463743f, -0.12802903f, 0.01374832f, -0.18184097f, 0.09068852f, 
    0.06144589f, -0.01557343f, 0.05887799f, -0.01046667f, -0.04094709f, 0.02622421f, 0.23521921f, 0.04373295f, 
    0.02968361f, 0.12993883f, -0.17506021f, 0.15750775f, 0.07350996f, -0.05019108f, 0.04951644f, 0.04497672f, 
    0.36411205f, -0.03016421f, -0.05065002f, -0.18206485f, -0.06581715f, 0.12187782f, -0.07605200f, -0.05397830f, 
    0.12238018f, 0.02254500f, 0.01070417f, -0.03648257f, -0.06980785f, 0.15665649f, -0.19436075f, -0.08195899f, 
    0.02511397f, -0.11231460f, 0.17016575f, 0.13832277f, -0.03220499f, -0.01398592f, -0.08223634f, -0.07434346f, 
    0.17838582f, -0.28781724f, 0.13894905f, -0.20404626f, -0.08911942f, 0.01826009f, -0.21766907f, -0.24446596f, 
    -0.16929694f, -0.13414106f, -0.03351602f, -0.17867796f, 0.22651184f, -0.32962310f, -0.16413161f, -0.01622866f, 
    0.01335688f, 0.16031912f, -0.00463169f, -0.03193748f, -0.00033896f, 0.02725134f, -0.03175462f, 0.10129730f, 
    -0.03724514f, -0.02635624f, 0.03742465f, 0.14441559f, 0.09282890f, -0.13446407f, -0.04699244f, -0.08445553f, 
    0.00651553f, -0.13401094f, -0.09944858f, -0.08336737f, 0.16678779f, 0.21310547f, -0.19893345f, 0.17883627f, 
    0.11197422f, -0.02742427f, 0.06703096f, 0.21932600f, -0.11649286f, -0.10039364f, 0.03852783f, -0.01036073f, 
    0.39594713f, 0.05662756f, 0.38531497f, 0.01343210f, 0.02792732f, 0.02800509f, -0.17500119f, 0.05914112f, 
    0.18591923f, 0.00105297f, 0.05912244f, 0.08086342f, -0.13593085f, -0.08692980f, 0.12664533f, 0.05288558f, 
    0.00060196f, 0.13141219f, 0.00932534f, -0.04953024f, 0.02028994f, 0.10056066f, 0.04487290f, -0.06240538f, 
    0.11424676f, 0.27687255f, -0.09732582f, 0.03720783f, 0.10412073f, 0.09685156f, -0.05945927f, 0.19815068f, 
    -0.09551369f, 0.00125323f, -0.00316835f, 0.04323122f, 0.03570034f, 0.06627228f, 0.12496917f, 0.06502519f, 
    0.09751459f, 0.03552361f, -0.04375819f, 0.15445825f, 0.03988333f, -0.05599103f, -0.15894575f, -0.11190698f, 
    0.12199172f, 0.11570859f, -0.09832168f, 0.14061761f, -0.07484042f, -0.08001740f, 0.04490666f, -0.02157832f, 
    -0.03402299f, 0.04747465f, 0.12030742f, 0.02144036f, -0.28644776f, -0.03755573f, 0.00769998f, 0.00039592f, 
    -0.25886273f, 0.05786650f, -0.04203138f, -0.01228103f, 0.09055639f, -0.00474705f, 0.00664973f, 0.13788743f, 
    -0.09881923f, 0.06897598f, -0.10196427f, -0.03410775f, 0.11387535f, -0.14756639f, -0.06830001f, -0.08591134f, 
    -0.05271487f, -0.04041397f, 0.11932876f, -0.01192834f, 0.27402586f, -0.08315814f, 0.28946072f, -0.46232271f, 
    0.00732422f, 0.07843137f, -0.05822696f, -0.07739116f, 0.13171510f, -0.10752561f, 0.01834874f, -0.11067796f, 
    0.19593237f, 0.40766621f, 0.10003845f, -0.36386785f, -0.11905260f, -0.03848787f, 0.00206909f, 0.11255521f, 
    0.05316168f, 0.12011057f, -0.11658504f, 0.00047241f, 0.14878386f, 0.21948317f, 0.19524193f, 0.08074627f, 
    0.10399804f, 0.05087135f, 0.01440080f, 0.08738099f, -0.02550527f, 0.06151978f, 0.08172125f, 0.17509173f, 
    0.08400649f, -0.22748573f, -0.17750408f, -0.31808761f, -0.03468459f, -0.06096644f, -0.21698391f, -0.09330189f, 
    -0.03657335f, 0.04150781f, -0.08744228f, -0.27129415f, 0.14491735f, 0.14825067f, 0.21944897f, 0.03361879f, 
    0.14551590f, 0.11351273f, 0.09334660f, 0.08233245f, 0.17580800f, 0.09228071f, 0.11848143f, 0.05622112f, 
    0.13159361f, -0.00130502f, 0.14897783f, -0.01293925f, -0.04944570f, -0.21269728f, 0.06746727f, 0.13778795f, 
    -0.18918294f, -0.20171462f, -0.23060217f, -0.03570554f, 0.08039627f, 0.10745612f, -0.10508449f, 0.09118194f, 
    -0.08255734f, -0.13053752f, -0.14272574f, -0.07429845f, -0.12202241f, -0.05630942f, -0.22720420f, 0.12012376f, 
    0.31169856f, 0.32232302f, 0.22217922f, -0.01577843f, -0.01201864f, 0.11260330f, -0.02533384f, 0.07911557f, 
    -0.01150464f, -0.12357146f, 0.13439360f, -0.18886282f, 0.30914557f, -0.00889011f, 0.31321961f, 0.18077376f, 
    0.19190095f, 0.20050965f, 0.09946205f, -0.05486709f, -0.13217688f, -0.05872408f, -0.02140116f, -0.09112396f, 
    -0.12059242f, 0.01780173f, -0.30696335f, 0.22199582f, 0.06136104f, -0.07917427f, 0.12323401f, -0.22457834f, 
    0.08748232f, 0.08572122f, 0.00573150f, 0.10797650f, 0.09564130f, -0.11315409f, 0.05613786f, 0.07248144f, 
    0.02096840f, -0.08632724f, 0.14642082f, -0.17454369f, 0.06581731f, 0.29765943f, 0.13743056f, 0.19411777f, 
    -0.10894204f, -0.18208623f, -0.04122532f, 0.09050424f, 0.01722680f, -0.00702723f, 0.08179421f, 0.16035777f, 
    -0.04595146f, 0.04553986f, -0.06976969f, -0.15334572f, -0.01543860f, 0.04711321f, 0.10816476f, 0.05654540f, 
    -0.21013382f, 0.03114578f, 0.02308333f, -0.01762902f, -0.04687537f, -0.26541981f, -0.20237510f, -0.25665849f, 
    -0.08806199f, 0.19020551f, 0.04525854f, -0.19495328f, 0.06687931f, 0.10976444f, -0.13643692f, 0.15543063f, 
    0.03375159f, 0.24429594f, 0.02276595f, -0.12964404f, 0.55348897f, 0.05198335f, 0.07324258f, 0.05899400f, 
    -0.05340222f, 0.09199366f, 0.09680566f, -0.03286681f, 0.02094806f, -0.11331578f, -0.12016774f, -0.12152623f, 
    0.18849386f, 0.16613841f, 0.03483464f, -0.03201928f, -0.10266897f, 0.02227397f, -0.05741329f, -0.04272586f, 
    -0.12128613f, 0.06583147f, -0.15071169f, -0.14572842f, -0.06568734f, -0.09310148f, -0.18590778f, 0.01459798f, 
    0.00093044f, -0.02275691f, -0.02027285f, 0.03463279f, -0.01937621f, -0.12625210f, 0.01362882f, -0.08309915f, 
    -0.11835626f, 0.18769453f, -0.23013911f, -0.00077998f, 0.10457606f, 0.11553703f, 0.02186453f, -0.12913199f, 
    -0.10674919f, 0.18268260f, 0.02979223f, 0.04618514f, 0.05020843f, -0.14809181f, 0.01174975f, 0.27377987f, 
    -0.01297131f, -0.02592769f, 0.24392420f, 0.03169850f, -0.01896420f, 0.08236986f, 0.07326987f, 0.08284233f, 
    -0.21338396f, 0.16802198f, 0.14572416f, 0.08727437f, -0.11036046f, -0.26870421f, 0.16016649f, 0.02251274f, 
    -0.17089143f, -0.04227699f, -0.11004142f, 0.00674487f, -0.01775623f, 0.05588131f, -0.05200279f, 0.20961536f, 
    0.06219235f, 0.10102608f, 0.03205834f, 0.12464833f, 0.22230142f, 0.11068894f, 0.11875837f, 0.10368463f, 
    -0.03032251f, -0.01311810f, -0.02934208f, 0.06626134f, -0.06494034f, -0.05953218f, -0.00571099f, 0.05361410f, 
    0.03723486f, -0.04907570f, -0.00312535f, -0.05380856f, -0.06357072f, -0.07169906f, 0.04285503f, 0.00899243f, 
    -0.05735039f, 0.04383336f, -0.00723703f, -0.04862144f, 0.02370194f, -0.02475106f, -0.01742936f, -0.00698285f, 
    0.00497405f, -0.01856974f, -0.02351018f, 0.01645360f, 0.04136550f, -0.06124566f, -0.03343149f, -0.01618429f, 
    -0.06607012f, 0.00777764f, 0.03171951f, -0.04263490f, 0.00818720f, -0.05236343f, 0.07053786f, -0.06132715f, 
    -0.03539148f, 0.04853773f, 0.00262711f, 0.01254469f, -0.05841518f, 0.00277887f, -0.02739940f, -0.01389058f, 
    0.00486980f, -0.02303297f, 0.05645102f, 0.00498724f, -0.04795234f, -0.03507996f, 0.00390572f, -0.04404159f, 
    -0.02346766f, 0.02870664f, -0.06669906f, -0.03286546f, -0.07164260f, -0.05728621f, -0.05892460f, -0.06684133f, 
    -0.03967793f, -0.02744926f, -0.04766615f, -0.05307973f, 0.03621469f, 0.05819801f, 0.00709415f, 0.02711479f, 
    0.05619832f, -0.01979928f, 0.06042791f, -0.02028968f, -0.01211083f, 0.04139572f, 0.01513871f, -0.06189031f, 
    -0.07174929f, 0.01884800f, -0.05274054f, -0.04548511f, -0.02154338f, -0.06784789f, 0.04713704f, -0.06269351f, 
    0.02116069f, -0.02697604f, -0.02732813f, -0.06801881f, 0.04021536f, 0.02902214f, -0.03857173f, -0.06354699f, 
    0.02591705f, 0.01765117f, 0.06943536f, -0.04134983f, -0.00229383f, -0.05065015f, 0.03619521f, -0.01942954f, 
    -0.02484843f, 0.05995898f, -0.06710978f, -0.05734596f, 0.06980806f, 0.01748483f, -0.03163033f, 0.02612710f, 
    -0.03461536f, 0.03380099f, 0.01866622f, -0.01679177f, 0.00441474f, -0.01721074f, 0.02351544f, 0.03994616f, 
    0.00905997f, -0.03718267f, -0.06438177f, 0.02054709f, -0.05316052f, -0.00170755f, -0.03901951f, -0.00137353f, 
    0.06430069f, 0.03673306f, 0.01075794f, -0.02371522f, -0.01917850f, -0.02483398f, 0.01350173f, 0.03895713f, 
    -0.00502530f, 0.01083412f, -0.01644562f, 0.04669832f, -0.06784068f, -0.04311088f, -0.01474259f, -0.01493285f, 
    0.04319765f, 0.02660277f, -0.02420229f, 0.01458857f, 0.04179311f, 0.02625467f, -0.01613922f, 0.00167130f, 
    0.06234071f, 0.03066755f, 0.00413561f, 0.02164018f, 0.02553939f, -0.06166224f, 0.06743838f, -0.07129258f, 
    0.04489734f, 0.03870435f, 0.00173919f, -0.01196840f, -0.06763298f, 0.02463020f, -0.05409018f, -0.04558704f, 
    0.03869547f, -0.05926448f, -0.04855446f, -0.06422202f, 0.03193199f, -0.01876723f, 0.03716768f, -0.01398199f, 
    -0.04568208f, -0.01325573f, 0.05473098f, 0.00540339f, -0.01662817f, -0.04928426f, -0.01895994f, 0.03931906f, 
    0.01745894f, -0.00968593f, -0.06909335f, 0.01953389f, -0.04304167f, 0.01116714f, -0.02663303f, 0.06828408f, 
    -0.06849211f, -0.06074224f, -0.04675314f, -0.00276561f, -0.04118678f, 0.02316875f, -0.02253194f, -0.03652509f, 
    -0.00315113f, 0.03408973f, 0.01630675f, 0.02324977f, -0.04807601f, -0.02910323f, 0.04534839f, 0.06326545f, 
    0.04070840f, -0.04062015f, -0.03476504f, -0.02744839f, -0.00769661f, 0.01601243f, 0.02408273f, -0.00743809f, 
    -0.02997340f, -0.02115988f, 0.04109862f, -0.07003364f, -0.04080911f, -0.05045754f, 0.03697242f, -0.06484477f, 
    0.01668361f, 0.04239221f, -0.04685003f, 0.05528595f, -0.02341726f, -0.04516638f, -0.03245075f, -0.01023916f, 
    0.02115506f, -0.06819839f, 0.00043462f, -0.07496835f, -0.04402272f, 0.04698936f, 0.06101631f, 0.00936291f, 
    -0.05697868f, -0.04847801f, 0.01237911f, -0.05867703f, 0.00297702f, -0.03284720f, -0.07104279f, -0.02307922f, 
    0.03099985f, 0.02726286f, 0.05987325f, 0.02272097f, -0.06812342f, 0.00902078f, -0.04936036f, 0.01973017f, 
    0.03870402f, -0.04102386f, -0.05668966f, -0.04992393f, -0.05704157f, -0.02836647f, 0.00838315f, -0.00769108f, 
    -0.03882799f, 0.05336960f, -0.03983017f, 0.04376806f, -0.05315046f, 0.04155973f, -0.01060858f, -0.01600614f, 
    0.03178281f, 0.04168663f, -0.01075805f, 0.02722859f, -0.04991610f, -0.03564691f, -0.03827362f, -0.04592857f, 
    0.01349030f, -0.04780496f, 0.00310402f, -0.06412148f, -0.01317687f, -0.05013803f, 0.03925240f, -0.06601073f, 
    0.01132534f, -0.05002887f, -0.00167189f, -0.05062467f, 0.01963564f, -0.03103299f, 0.00460917f, -0.02757317f, 
    0.05149357f, -0.04776005f, -0.00908661f, -0.04395451f, 0.03711646f, -0.06922284f, 0.00262377f, 0.04143135f, 
    0.03766968f, -0.02304146f, -0.07039504f, 0.03260523f, 0.05703150f, -0.02295694f, 0.02752556f, -0.01193502f, 
    0.02566832f, -0.00347444f, -0.01512865f, -0.02466452f, -0.06967781f, -0.06333205f, -0.00043028f, 0.03717485f, 
    -0.06414197f, -0.02482014f, -0.04543817f, -0.02742921f, -0.04110285f, 0.02749073f, -0.05517231f, 0.04041322f, 
    0.03676830f, 0.03463317f, 0.05541627f, -0.02035861f, 0.05696410f, -0.06327680f, 0.05868581f, 0.02257675f, 
    0.05791012f, 0.03269641f, 0.02661526f, -0.03340197f, 0.04290238f, 0.01695645f, 0.00191382f, -0.05330144f, 
    -0.04499873f, 0.01721928f, 0.06470183f, 0.01100893f, -0.06173538f, 0.01365612f, 0.01357743f, -0.06344182f, 
    0.02337841f, 0.03831056f, -0.01566853f, -0.05615154f, 0.00172050f, -0.04389831f, -0.06699240f, -0.04515481f, 
    0.03036812f, 0.00616038f, -0.00786518f, 0.01708071f, 0.02958176f, -0.03692796f, 0.01949939f, -0.06952561f, 
    -0.02643813f, -0.02774017f, 0.06036643f, -0.04199858f, 0.02866465f, -0.05539553f, -0.06243647f, -0.07125636f, 
    -0.01002325f, 0.04470817f, 0.03122610f, -0.03518823f, -0.05532377f, 0.04619139f, 0.05619740f, -0.00417228f, 
    -0.19793718f, -0.05123317f, -0.01089606f, 0.07687967f, -0.07050604f, 0.02120714f, 0.02921560f, 0.04244763f, 
    0.08138154f, 0.14177215f, -0.08951827f, 0.06760006f, -0.22454239f, -0.29991922f, 0.15299004f, 0.04326232f, 
    0.09471333f, 0.17863926f, 0.06140805f, 0.02028026f, 0.03815963f, 0.17017585f, 0.09848832f, -0.05764136f, 
    0.05539784f, -0.14894575f, 0.43662813f, 0.06492666f, -0.07616805f, 0.15431046f, -0.17243636f, 0.07683827f, 
    -0.04088906f, 0.10849286f, 0.00916263f, -0.05955742f, -0.02442633f, -0.10269785f, 0.14786829f, -0.04045018f, 
    -0.05849642f, -0.06416372f, -0.04052715f, -0.03988040f, 0.07367739f, 0.01444170f, 0.09574448f, 0.02960728f, 
    -0.05174715f, -0.12930772f, -0.06012524f, -0.05621867f, 0.32486862f, -0.06064043f, 0.02196029f, 0.11176111f, 
    0.07924151f, -0.10020724f, 0.08142074f, -0.05922115f, -0.08134243f, -0.07648209f, 0.23323976f, 0.19327188f, 
    0.07246825f, 0.09978817f, -0.07530565f, 0.20839673f, 0.02906700f, 0.06512620f, 0.02662376f, -0.06220135f, 
    0.16128536f, -0.14278011f, -0.06993224f, 0.12799402f, 0.15138644f, 0.11993607f, -0.00965865f, -0.16288404f, 
    -0.04040782f, 0.03748221f, 0.02399950f, 0.06702555f, 0.37042210f, -0.05990933f, -0.13812977f, -0.19280353f, 
    0.07327282f, 0.15316750f, 0.02079395f, 0.09355563f, 0.07547460f, 0.02618156f, -0.01165401f, 0.18754517f, 
    0.01102935f, -0.03654988f, -0.09513791f, -0.00545326f, -0.18710841f, -0.00623930f, 0.02383022f, 0.02584247f, 
    -0.10235851f, 0.08441728f, -0.09693921f, 0.11217813f, -0.10786346f, -0.26643044f, 0.13977428f, -0.14676455f, 
    -0.20072684f, -0.16465895f, -0.06980462f, -0.01548347f, -0.09744446f, 0.00448911f, -0.01322986f, -0.12384112f, 
    0.14921410f, 0.23062521f, 0.14243126f, 0.04096770f, 0.02411147f, -0.12794444f, -0.14257765f, -0.12676355f, 
    -0.06984101f, -0.12239394f, 0.06945994f, -0.05794410f, -0.05676505f, 0.27494478f, -0.18623734f, -0.13419975f, 
    0.14330094f, 0.05314343f, -0.03348203f, 0.00726443f, -0.02875844f, 0.06908984f, 0.14872135f, 0.20254055f, 
    -0.13610478f, 0.42580131f, 0.04169409f, -0.30373138f, 0.11024296f, -0.11339661f, 0.12741087f, -0.00724871f, 
    -0.00536187f, -0.00983796f, 0.07569984f, 0.05291627f, 0.02184624f, -0.02070433f, -0.04358103f, -0.10302347f, 
    0.10797565f, 0.12348233f, 0.17018417f, -0.01893515f, -0.02391984f, 0.06383293f, -0.06712393f, -0.03150318f, 
    -0.19470167f, -0.02987495f, -0.08391647f, 0.19608758f, 0.02181052f, 0.00514623f, -0.00248570f, 0.07114790f, 
    0.19287351f, 0.07978127f, 0.31077102f, 0.12744150f, 0.00781237f, -0.24455236f, 0.08389816f, -0.04732956f, 
    0.00899991f, 0.10144336f, -0.00877288f, 0.00598349f, -0.08258384f, -0.12029736f, 0.09507502f, 0.06882043f, 
    0.01409049f, -0.38078249f, -0.04343479f, -0.23998578f, -0.11829253f, 0.10928144f, -0.20340709f, 0.05934502f, 
    -0.04122923f, -0.16803205f, -0.00965060f, 0.07084969f, -0.20258816f, -0.31688663f, -0.11983410f, -0.04238084f, 
    0.30644915f, -0.00942515f, -0.14980084f, -0.10596652f, 0.02054824f, 0.02384816f, -0.12429734f, -0.00253418f, 
    0.40789348f, 0.02532188f, 0.10992320f, -0.01759021f, -0.22917233f, -0.04059224f, -0.09809793f, 0.07505032f, 
    0.02003016f, -0.02214411f, 0.13494700f, -0.02791554f, 0.11808053f, 0.32039517f, 0.03615971f, 0.40768260f, 
    -0.00813620f, -0.42317033f, 0.04029768f, -0.05922236f, 0.02145045f, 0.01534853f, 0.08089858f, 0.04373271f, 
    0.44618410f, -0.20121753f, 0.21114810f, 0.01127005f, 0.18078189f, 0.15411536f, 0.08227083f, -0.09640229f, 
    -0.06171835f, -0.06247013f, -0.14336026f, -0.07704114f, -0.24010539f, -0.10078426f, -0.17702585f, 0.23642687f, 
    -0.04366677f, -0.04937794f, -0.02015934f, 0.23250365f, 0.04122508f, -0.02487802f, 0.09587399f, -0.03855244f, 
    0.25463691f, 0.23585801f, -0.02424450f, 0.21709120f, -0.01743234f, -0.18933293f, -0.18513158f, 0.04227336f, 
    0.02866816f, 0.01332674f, 0.03035050f, 0.03585856f, 0.18489236f, -0.03549244f, 0.23775865f, -0.00072690f, 
    0.03526242f, 0.05050473f, 0.10764612f, 0.14316037f, 0.00597389f, -0.12363923f, 0.00705766f, -0.21749596f, 
    -0.29386973f, 0.06418257f, -0.15305941f, -0.15069418f, -0.02665702f, 0.02249965f, -0.05502931f, 0.02514702f, 
    0.08297013f, 0.13031785f, 0.30617729f, -0.02521094f, 0.00110472f, -0.23402230f, 0.16234908f, 0.09062137f, 
    -0.36873287f, 0.04841794f, 0.00601742f, -0.06865251f, 0.14309251f, 0.17280407f, 0.08651759f, -0.09423178f, 
    -0.07949375f, 0.06599552f, -0.19000986f, 0.18065143f, -0.26366371f, -0.21692578f, 0.15223312f, 0.08759420f, 
    -0.06535637f, 0.16495797f, -0.02558101f, 0.04609504f, -0.04633960f, -0.13519281f, 0.12464724f, -0.18237008f, 
    0.10717592f, -0.05042064f, -0.16763243f, -0.14560708f, -0.06035515f, -0.08579980f, 0.08287622f, -0.04164997f, 
    -0.09335522f, 0.27461693f, 0.19101505f, -0.46094134f, -0.01243301f, -0.14856416f, -0.03408242f, -0.01216162f, 
    -0.11295816f, 0.16234829f, 0.03488356f, 0.01645573f, 0.01465799f, 0.31541067f, 0.11462812f, 0.10580314f, 
    0.10795541f, 0.05887457f, 0.08610537f, -0.06887291f, -0.02803615f, 0.16994457f, 0.00233036f, -0.04336660f, 
    -0.22554851f, -0.18844922f, -0.24138042f, 0.18347825f, 0.13030709f, 0.00171923f, -0.19623369f, -0.21131161f, 
    0.14709361f, 0.05051392f, -0.32780576f, -0.19404818f, 0.27450940f, 0.04661029f, 0.15155134f, 0.23612364f, 
    0.21628530f, 0.15519170f, 0.04807589f, 0.10606556f, -0.01677012f, -0.13548706f, 0.11854474f, -0.05504506f, 
    -0.05077422f, 0.15314411f, 0.03526251f, 0.00479601f, 0.03972652f, -0.07911907f, 0.09586909f, -0.04526907f, 
    -0.01818893f, 0.21788956f, -0.02859753f, 0.03970248f, 0.21318954f, 0.17203784f, 0.06686080f, 0.01062973f, 
    -0.08156743f, 0.02237059f, 0.09573462f, 0.03548811f, -0.14253013f, -0.16245262f, 0.10390566f, -0.08336065f, 
    0.01477798f, 0.00310836f, 0.27016005f, 0.12276292f, -0.13602144f, -0.08349195f, -0.10621250f, 0.02659997f, 
    -0.03956600f, 0.03125153f, -0.08348916f, 0.02031930f, 0.21853821f, -0.13042170f, 0.18228185f, -0.05672702f, 
    -0.31070843f, -0.05460164f, 0.05946733f, -0.02091921f, -0.00734048f, -0.03391601f, 0.00344011f, 0.00716291f, 
    -0.23684087f, 0.48677531f, -0.08424427f, -0.08469935f, 0.24605712f, -0.02719334f, 0.10400065f, -0.14489341f, 
    -0.03803268f, 0.04593116f, 0.00366772f, 0.00248672f, -0.14598253f, 0.21577673f, 0.20499702f, -0.09659236f, 
    0.07432281f, 0.01763922f, -0.03415267f, -0.02947287f, -0.01363922f, 0.11182286f, 0.01063266f, 0.10019143f, 
    0.23781595f, -0.06224481f, 0.03030004f, 0.22166596f, 0.01853798f, 0.09204295f, 0.07810119f, 0.07793930f, 
    0.03949586f, -0.03149639f, -0.05226305f, -0.11493693f, 0.20165417f, 0.05218824f, 0.06152530f, -0.12105387f, 
    -0.03778996f, 0.01611517f, -0.02681903f, 0.01389130f, -0.04697252f, 0.03638611f, 0.02839231f, 0.00409808f, 
    -0.15048449f, -0.08444003f, -0.03088446f, -0.04498783f, 0.00658904f, 0.09206872f, 0.09307573f, 0.01484924f, 
    -0.10671195f, 0.07824624f, -0.17687134f, 0.00388032f, 0.03007369f, 0.06573445f, 0.02036957f, 0.02582249f, 
    -0.10413475f, -0.16286881f, 0.01796182f, 0.04508732f, 0.04718126f, 0.02562807f, 0.07653239f, -0.00668632f, 
    0.10810533f, -0.07691013f, 0.16189271f, -0.06995954f, -0.11243434f, 0.03735131f, 0.06752281f, -0.00139016f, 
    -0.02275933f, 0.01372652f, 0.13223416f, -0.09127097f, -0.01683565f, 0.12280308f, -0.17478314f, 0.14791982f, 
    -0.11322022f, 0.19056931f, 0.02976108f, 0.03242514f, -0.08927092f, 0.04373596f, -0.02433059f, 0.08139648f, 
    -0.34390789f, 0.25231144f, -0.21461642f, 0.04110644f, -0.03256605f, 0.23317482f, -0.01571316f, -0.10840155f, 
    0.00918892f, 0.02831464f, 0.12128302f, -0.14611755f, 0.11610109f, -0.03924105f, -0.10910118f, 0.01717192f, 
    0.07245138f, -0.13310488f, -0.05312449f, 0.14999187f, 0.09719691f, 0.05078517f, -0.10558857f, 0.03019414f, 
    -0.11858539f, 0.07702529f, -0.02097356f, 0.20138544f, -0.05835816f, -0.04117957f, 0.16356836f, -0.07415205f, 
    -0.13023309f, -0.03028783f, 0.07892829f, 0.03414554f, 0.03378028f, -0.18415336f, 0.07998019f, 0.09222477f, 
    -0.04473573f, 0.04506030f, -0.02180986f, 0.12893675f, 0.04987320f, 0.05051665f, -0.00405778f, 0.03527293f, 
    -0.20336178f, 0.05161705f, -0.06581198f, -0.10118619f, -0.02963754f, 0.01802708f, -0.00373380f, 0.15267053f, 
    0.10397711f, 0.20394097f, 0.17531224f, 0.08870126f, -0.13096666f, -0.01798143f, 0.28278625f, -0.10472210f, 
    0.11253118f, 0.12877840f, 0.19688812f, 0.07116024f, 0.06779363f, 0.05343228f, -0.10483630f, -0.05471845f, 
    -0.20750010f, 0.03263144f, 0.31059077f, 0.07925014f, -0.03347703f, 0.05505597f, 0.02831659f, 0.02844742f, 
    -0.04363269f, 0.03973297f, 0.00225283f, 0.09599573f, 0.04544727f, 0.03991608f, 0.17848948f, 0.11259361f, 
    -0.00264800f, -0.06459960f, -0.13078986f, -0.01594222f, 0.12007000f, 0.05038785f, 0.02091206f, -0.00629664f, 
    0.12765333f, 0.03526747f, 0.21569528f, -0.31966361f, 0.14722961f, 0.01257028f, 0.09298731f, 0.08305558f, 
    -0.07956453f, -0.13053314f, -0.10290179f, 0.03462816f, -0.22412235f, 0.06799209f, 0.01594533f, 0.20482375f, 
    -0.00633149f, 0.04486464f, -0.07807887f, 0.07450356f, 0.00578441f, 0.09473283f, 0.01622333f, -0.08575066f, 
    0.10425264f, -0.06192656f, -0.10004041f, 0.17184870f, 0.22891666f, 0.15783828f, 0.02497241f, -0.09020650f, 
    0.04152180f, -0.02343872f, 0.11610726f, 0.04893932f, 0.17482220f, -0.16445082f, 0.33379513f, -0.05826166f, 
    0.06699254f, 0.14595081f, 0.07040218f, -0.02422999f, 0.03628829f, 0.02156110f, 0.00881429f, 0.03004533f, 
    -0.02594308f, -0.11788712f, -0.00280602f, -0.10930346f, -0.13437606f, -0.05627662f, 0.01458927f, 0.02867376f, 
    -0.04579413f, -0.08812711f, -0.02830920f, 0.19072001f, -0.26844487f, -0.18118437f, 0.18355788f, 0.03223013f, 
    -0.07737304f, -0.06735701f, -0.12264115f, 0.04374807f, -0.15472543f, 0.18449266f, -0.05920381f, -0.07955881f, 
    0.08127443f, 0.00229115f, -0.05292947f, 0.08500307f, -0.02788652f, 0.01627109f, -0.04998425f, 0.03697732f, 
    -0.01735589f, -0.01049826f, -0.03635908f, 0.07539249f, -0.03980291f, 0.17342800f, -0.10709829f, 0.08861125f, 
    0.03726668f, -0.10879524f, -0.00919154f, 0.00353358f, -0.05555963f, 0.15498175f, 0.08682619f, 0.03757359f, 
    0.08785902f, 0.24182630f, -0.04235739f, -0.44356754f, -0.04978541f, 0.00912782f, 0.14411296f, 0.09749066f, 
    0.08027595f, -0.00064155f, 0.12480093f, -0.01893691f, 0.21027637f, 0.23131061f, -0.20972137f, -0.22386836f, 
    0.08287414f, 0.29575324f, 0.02313325f, 0.00596861f, -0.10937743f, -0.06793953f, 0.04695379f, -0.00707002f, 
    -0.08657891f, -0.12733111f, -0.12023151f, 0.42801198f, -0.08519111f, -0.08432535f, -0.03609468f, -0.06633767f, 
    0.01863783f, -0.09615485f, 0.15687642f, 0.19908707f, 0.04276792f, -0.04263480f, 0.17441233f, -0.04629718f, 
    0.19038609f, 0.15245801f, 0.04030231f, -0.10253197f, -0.02328779f, -0.01652534f, -0.03790857f, 0.05649289f, 
    -0.24266449f, 0.05496314f, -0.25661942f, -0.16870166f, -0.09036020f, -0.05755789f, -0.01253612f, -0.07697121f, 
    -0.12028473f, 0.14011507f, 0.01293533f, 0.08709643f, 0.48195159f, 0.38220093f, 0.29719517f, 0.16038637f, 
    -0.06791166f, 0.04173642f, 0.12877606f, 0.12261642f, 0.09131420f, -0.02500241f, 0.18395634f, 0.12975991f, 
    -0.52570194f, -0.28525206f, 0.00287101f, 0.17725979f, 0.01366624f, -0.06901978f, -0.07320192f, -0.16126278f, 
    0.02945159f, -0.01507792f, 0.00505660f, -0.01714158f, 0.06450546f, -0.25795779f, 0.07729782f, -0.09797522f, 
    0.03330263f, 0.13720316f, 0.04442932f, 0.05093658f, 0.21018298f, -0.03725504f, -0.05321043f, -0.09650338f, 
    -0.22180568f, 0.17609990f, -0.18037431f, 0.14681865f, -0.07281230f, 0.02822119f, 0.06532127f, 0.13404903f, 
    -0.02547390f, 0.10734464f, -0.00828319f, 0.07195364f, 0.15276757f, 0.14488390f, 0.06684368f, -0.19515368f, 
    -0.12736550f, -0.01617788f, -0.11608028f, -0.11222681f, -0.00336950f, 0.00701683f, -0.03898202f, 0.06056597f, 
    0.01125313f, -0.10370533f, 0.26731235f, 0.23270911f, 0.01841468f, 0.10364573f, 0.13863103f, 0.03215822f, 
    0.04743354f, 0.01867568f, -0.05541379f, -0.03258859f, -0.05543327f, 0.05013288f, 0.18567938f, 0.19683099f, 
    0.00679715f, 0.04432986f, -0.03418773f, 0.10100702f, 0.02095124f, -0.05264855f, -0.15284231f, 0.07493771f, 
    0.12093691f, -0.12262949f, -0.06952267f, -0.08724131f, 0.07241477f, -0.02954155f, -0.01414754f, -0.00129078f, 
    -0.14308515f, 0.04414879f, 0.03307300f, 0.08411057f, -0.21186937f, -0.24718603f, -0.50974298f, 0.02129976f, 
    0.02948774f, 0.01130595f, -0.08474948f, -0.00459039f, 0.00658006f, 0.00142885f, 0.00848385f, 0.15134659f, 
    -0.47277245f, -0.27362573f, 0.02139081f, -0.10429099f, -0.03997508f, -0.03428851f, -0.01393310f, -0.00164193f, 
    0.13173921f, 0.07903603f, -0.00180695f, 0.03924479f, 0.13280550f, 0.07752465f, 0.03023594f, 0.06225326f, 
    0.19039911f, 0.13865197f, 0.04499256f, 0.07128991f, 0.04534987f, 0.06283423f, 0.07083756f, 0.07120775f, 
    -0.52555239f, -0.18716574f, -0.11241400f, -0.05292606f, 0.06714020f, 0.13083002f, -0.04272360f, -0.03829169f, 
    -0.17217116f, -0.01321391f, -0.05516121f, -0.00520893f, 0.00009295f, -0.23022173f, 0.02256812f, 0.28514287f, 
    -0.03058019f, -0.03160185f, -0.02711479f, 0.12801231f, 0.02272007f, 0.09796072f, -0.10172602f, 0.06581005f, 
    0.06474384f, 0.11474764f, -0.03584987f, 0.04081514f, 0.04440617f, 0.03083144f, 0.12099102f, -0.08401091f, 
    0.01904222f, 0.11015903f, 0.15572608f, 0.09844811f, 0.00795992f, -0.00118767f, 0.01821584f, 0.18371741f, 
    -0.06396676f, 0.04915374f, 0.04317303f, 0.10306879f, -0.04591880f, -0.02585484f, 0.01759111f, 0.08251076f, 
    -0.03192318f, -0.07579585f, 0.03802101f, -0.05776206f, -0.13386406f, 0.00494369f, -0.20962219f, 0.00608076f, 
    -0.09049524f, 0.00950666f, -0.03323072f, -0.02137693f, 0.18705003f, -0.08411974f, -0.28376517f, -0.48249388f, 
    -0.05735222f, 0.02810973f, -0.06486598f, -0.19790313f, 0.10917524f, 0.07939634f, 0.10051102f, -0.03095918f, 
    0.20080094f, 0.35390192f, -0.08077554f, 0.08746213f, -0.01504296f, -0.11906348f, 0.15441191f, -0.08783618f, 
    0.00015272f, -0.05566465f, -0.04957457f, 0.01980812f, 0.41359690f, -0.04397168f, -0.20185190f, 0.13837673f, 
    0.08664155f, 0.08910462f, 0.21699618f, 0.04997572f, -0.05889576f, -0.13063113f, -0.05300521f, 0.07260863f, 
    -0.37764019f, 0.05304192f, -0.20445804f, -0.25156927f, -0.03639417f, 0.18958677f, -0.15580954f, -0.08294357f, 
    0.14118254f, 0.01482514f, -0.01098062f, -0.12369917f, 0.36371166f, -0.28828645f, 0.12280497f, 0.15791054f, 
    -0.15977156f, 0.04325555f, 0.08949116f, 0.08535912f, 0.11273471f, 0.09600578f, 0.04809762f, 0.09006477f, 
    -0.34215769f, -0.48008111f, -0.37376007f, -0.21664204f, 0.11059227f, -0.15926708f, 0.09536016f, 0.20734358f, 
    0.01569336f, 0.02339046f, 0.06558760f, 0.10999059f, -0.22787941f, -0.18093622f, 0.13575117f, 0.14120379f, 
    0.17633340f, -0.01024751f, 0.05539011f, 0.08084112f, -0.00705746f, -0.11103788f, -0.09990544f, 0.01065099f, 
    0.25761753f, -0.02169043f, 0.29154795f, 0.08912644f, -0.00466366f, -0.10348582f, -0.01497345f, -0.05302817f, 
    0.14581852f, -0.12772997f, 0.16543451f, -0.07940710f, 0.18350346f, -0.07331621f, -0.13840792f, 0.13921650f, 
    -0.25422430f, 0.03696156f, 0.12460687f, -0.02421672f, 0.13059343f, -0.07872827f, -0.01369718f, -0.08035382f, 
    0.16294360f, 0.26977381f, 0.00628415f, 0.11867909f, 0.05332376f, -0.08175141f, -0.03181326f, -0.03491413f, 
    0.02772981f, -0.05215616f, -0.14549063f, 0.06316379f, 0.10362995f, -0.17063187f, 0.16743314f, -0.28202963f, 
    0.05656514f, 0.04370512f, -0.01928594f, -0.01608168f, -0.00435750f, 0.07341673f, 0.13298480f, 0.02862725f, 
    0.40960068f, 0.40609422f, 0.26588199f, -0.19896209f, -0.13417991f, 0.20960966f, 0.03131117f, 0.02739918f, 
    0.00428664f, 0.14290148f, 0.12174299f, 0.02218891f, -0.31336132f, -0.40670258f, -0.10974652f, 0.13363987f, 
    0.02843199f, 0.05975028f, 0.00434941f, 0.14973176f, -0.02762947f, 0.09797630f, 0.18324755f, 0.06839486f, 
    0.36275184f, 0.02041314f, -0.04516833f, -0.12188254f, 0.03818237f, 0.01719196f, -0.03092015f, -0.00278159f, 
    0.28566575f, 0.00718537f, -0.03539046f, -0.18752135f, 0.23704028f, -0.08404225f, -0.06530387f, 0.11194024f, 
    0.11657524f, 0.10873646f, 0.28107119f, 0.00134281f, 0.18002088f, 0.01408806f, 0.05759670f, -0.02459628f, 
    0.09891324f, -0.14673077f, 0.03402643f, 0.01706767f, 0.00328007f, -0.07172277f, 0.09801083f, 0.07296088f, 
    0.00747230f, -0.02607981f, 0.10037179f, 0.04999966f, 0.07835067f, -0.26702371f, 0.03238431f, 0.12037638f, 
    0.04254387f, 0.07101005f, 0.10160641f, 0.07382683f, 0.15068716f, 0.20020418f, 0.00624734f, 0.03412779f, 
    0.05939902f, 0.01549878f, 0.27066085f, 0.02071990f, -0.05337423f, 0.06882509f, -0.03248607f, 0.03749457f, 
    -0.01256444f, -0.01180641f, 0.08277645f, -0.13432676f, -0.06367882f, 0.15277512f, 0.22287226f, 0.13813917f, 
    0.20101815f, -0.11167002f, -0.11303865f, 0.02897378f, -0.04878602f, -0.03027133f, 0.06389054f, -0.12035254f, 
    0.17601490f, -0.32106850f, -0.04418119f, 0.32138714f, -0.03352481f, 0.06848143f, 0.02199923f, -0.12284678f, 
    0.02123313f, -0.00868445f, -0.03396912f, -0.06941099f, -0.03846793f, -0.09627143f, -0.18112655f, 0.18181594f, 
    0.07614128f, 0.10859160f, -0.00988015f, 0.16577233f, 0.09308912f, 0.08976563f, 0.13195001f, -0.06584546f, 
    -0.16659692f, -0.14898360f, 0.03013155f, 0.21383171f, 0.03021727f, -0.11130958f, -0.18168214f, -0.15509042f, 
    -0.07964513f, -0.08245041f, -0.13369386f, -0.10296039f, 0.20281532f, -0.10444773f, 0.13724309f, 0.25170431f, 
    0.01358259f, 0.04200851f, 0.06279789f, 0.01528369f, 0.07065124f, -0.05086126f, -0.00477741f, -0.10908274f, 
    0.04805319f, -0.02978044f, -0.09551346f, -0.13875528f, 0.04445257f, -0.00133046f, -0.03620864f, -0.05808540f, 
    0.06530131f, 0.01365420f, 0.12564249f, 0.04759641f, -0.03980446f, -0.06286904f, 0.07690919f, -0.01229655f, 
    -0.05013144f, -0.01050234f, 0.04381745f, 0.03827221f, -0.02325716f, -0.09415514f, 0.03535581f, -0.06008560f, 
    0.04923846f, 0.20277876f, 0.00424786f, 0.03261273f, -0.01127478f, -0.09614651f, -0.06214883f, 0.01837953f, 
    0.04149301f, 0.03501008f, 0.06341573f, -0.03618774f, -0.01867605f, 0.04754366f, -0.03659558f, 0.03947361f, 
    0.14562765f, -0.07551610f, 0.00768983f, 0.04415048f, 0.03916759f, 0.11542004f, 0.07034069f, 0.05709341f, 
    0.03994429f, 0.08104968f, 0.01516848f, -0.32773253f, 0.04393253f, -0.14882870f, -0.03840896f, -0.04073383f, 
    0.11851742f, 0.03535101f, 0.10228130f, 0.13043542f, -0.17850026f, -0.15773110f, -0.04254347f, 0.07269030f, 
    -0.07713434f, 0.02743967f, 0.12914604f, -0.15521811f, -0.02366893f, 0.02367096f, 0.03341739f, -0.02798570f, 
    -0.05469958f, -0.03029873f, -0.00070151f, 0.12422512f, 0.14718539f, 0.03962316f, 0.08966548f, 0.07114042f, 
    0.09747398f, -0.05382685f, 0.05579598f, 0.01825787f, -0.05349170f, -0.06867856f, 0.14018588f, 0.14332166f, 
    0.12533629f, 0.06856164f, -0.03721577f, -0.02184707f, -0.08565640f, -0.08940689f, 0.07794300f, -0.06089412f, 
    0.11728515f, 0.04872193f, 0.05532759f, -0.00339489f, -0.03709587f, -0.08366654f, 0.08848614f, -0.03370160f, 
    0.08479044f, 0.07014445f, 0.11595160f, 0.11356779f, 0.12052912f, -0.01672545f, -0.31455162f, -0.12765868f, 
    0.00804390f, -0.14570053f, 0.05990404f, 0.02441839f, 0.22684968f, -0.10281207f, 0.01532524f, -0.02014995f, 
    0.26119003f, 0.27303457f, -0.05125347f, 0.06283283f, -0.01798938f, 0.04400231f, -0.01142132f, 0.00837110f, 
    -0.03804360f, -0.06495657f, -0.07359820f, -0.11104713f, 0.22581439f, 0.02165562f, 0.15242960f, 0.16609514f, 
    0.17293829f, -0.06910784f, -0.15703154f, -0.03068817f, 0.00136994f, 0.04107776f, -0.12162291f, 0.01475356f, 
    -0.13367105f, 0.18504064f, -0.00575667f, 0.06979284f, 0.14770395f, -0.04311755f, 0.18025878f, -0.19606173f, 
    -0.11572923f, -0.06554729f, 0.01441768f, 0.05994969f, -0.17498155f, -0.03735333f, 0.01232066f, 0.01335243f, 
    0.13591751f, -0.05865490f, -0.01032721f, -0.05761742f, -0.18980369f, -0.07557330f, -0.03016353f, -0.16733985f, 
    0.05259788f, 0.02551851f, 0.06611764f, 0.13281050f, 0.05111103f, 0.12631941f, 0.11985482f, 0.18416928f, 
    0.11089154f, -0.02868317f, 0.03619986f, 0.10341821f, -0.00692551f, 0.19824539f, 0.28788882f, 0.06703094f, 
    -0.01044908f, -0.00117963f, 0.18364795f, 0.22489160f, -0.10552542f, 0.02815920f, 0.04157163f, -0.00630114f, 
    -0.12651920f, 0.07129527f, 0.01532080f, 0.01581960f, -0.14821801f, 0.01547096f, -0.09233271f, -0.06531034f, 
    0.09798435f, -0.03080802f, -0.06573169f, 0.07565872f, 0.02714852f, 0.20633250f, 0.16078392f, 0.19566098f, 
    0.08414881f, 0.04153341f, -0.08947366f, -0.00933256f, -0.04724474f, 0.08855698f, 0.08847588f, -0.03235815f, 
    0.17988092f, 0.23159601f, 0.14085169f, 0.30679303f, -0.09494080f, -0.12833098f, -0.07238270f, -0.05614994f, 
    0.03079355f, -0.02162929f, -0.06770045f, -0.05884627f, -0.03707051f, -0.01969188f, -0.14626664f, 0.07734494f, 
    -0.14845198f, 0.04989402f, 0.02192084f, -0.13658912f, 0.09218128f, 0.06022345f, -0.02738486f, 0.00112655f, 
    -0.17468296f, -0.18864107f, -0.05130925f, 0.13854660f, -0.02029901f, -0.10986143f, -0.01476418f, -0.23807554f, 
    -0.05936073f, 0.06795286f, 0.00462175f, 0.04060597f, 0.09250303f, -0.13498867f, 0.01250095f, 0.23826611f, 
    0.12064204f, -0.10280014f, -0.07281628f, 0.00968935f, 0.07972239f, 0.07444425f, 0.01325499f, -0.04761296f, 
    -0.17540455f, -0.00782246f, 0.03858197f, 0.30086234f, 0.02927786f, 0.09251044f, 0.05464856f, 0.05037374f, 
    -0.12346490f, 0.03827554f, 0.07165649f, 0.13159385f, 0.02601759f, 0.22179154f, 0.08245106f, 0.37711287f, 
    0.08045076f, -0.10202114f, -0.03759858f, 0.01654685f, -0.03217404f, -0.05440621f, -0.12046188f, -0.07985991f, 
    -0.05835777f, -0.06908780f, 0.02488837f, 0.03981766f, -0.01282637f, -0.05977529f, 0.00001437f, 0.02647947f, 
    -0.07006176f, -0.05512728f, 0.04811254f, -0.07887094f, -0.05405584f, 0.01451733f, 0.03292743f, -0.02558313f, 
    0.03758169f, -0.00475147f, 0.05088143f, -0.07379404f, -0.01022106f, -0.05529986f, -0.03481218f, 0.01261749f, 
    0.05061886f, -0.00776373f, 0.00720616f, 0.02698210f, 0.03727380f, 0.00226476f, 0.01464680f, -0.05768503f, 
    0.03040640f, -0.04167384f, 0.02518144f, 0.01235309f, 0.02148581f, -0.03873554f, -0.01893982f, -0.05276679f, 
    0.03264728f, 0.01044261f, -0.02176806f, -0.05149235f, 0.03534314f, 0.06074787f, -0.02192815f, -0.04322692f, 
    0.01172201f, -0.01498214f, -0.01867181f, 0.01528243f, 0.02388889f, 0.04306211f, -0.05968418f, -0.00434114f, 
    -0.01887397f, -0.05804171f, 0.05206002f, -0.04348817f, -0.00225784f, -0.01891748f, 0.04070314f, 0.00315906f, 
    -0.04595559f, -0.00527560f, -0.03780327f, -0.04288268f, -0.07683875f, -0.05209174f, -0.02287476f, -0.08237817f, 
    -0.06486705f, 0.01446999f, -0.06653938f, 0.06247637f, 0.01646789f, -0.01705969f, -0.03186278f, -0.00577695f, 
    -0.00926896f, -0.04347971f, -0.04301605f, 0.00486099f, -0.07419525f, 0.00132877f, -0.03453202f, 0.03100543f, 
    -0.03364668f, 0.02591274f, 0.00816430f, -0.05049203f, 0.01143428f, -0.00222509f, -0.05540718f, 0.01380987f, 
    0.00040533f, 0.03786417f, 0.01657614f, -0.03107456f, -0.00134752f, 0.05751527f, 0.04949449f, -0.03939751f, 
    -0.04640591f, 0.02937946f, 0.05286584f, 0.00860967f, -0.04663135f, -0.07545654f, -0.03149625f, -0.05037941f, 
    -0.03286684f, -0.04284852f, -0.02152585f, -0.07533169f, -0.04213205f, -0.03594932f, 0.00449151f, 0.05803885f, 
    -0.06436214f, -0.05895409f, 0.02787099f, -0.02674474f, 0.05060117f, -0.03073115f, -0.06303395f, 0.04568847f, 
    -0.00475723f, -0.04485131f, -0.04802218f, 0.00221361f, 0.05248292f, -0.06077376f, -0.01688474f, -0.03129926f, 
    0.05311568f, -0.04305771f, 0.00089225f, 0.03763723f, -0.05445616f, 0.06386866f, 0.02143854f, -0.06993106f, 
    -0.03295026f, 0.05499732f, -0.02547450f, 0.05000164f, -0.07146532f, 0.00323344f, -0.06967724f, -0.01955715f, 
    0.00338540f, -0.00361024f, -0.04073194f, -0.00327993f, -0.02628919f, -0.02712296f, -0.02824078f, 0.02853952f, 
    -0.04791063f, 0.04996824f, -0.07774471f, 0.04949728f, -0.02554959f, -0.08248146f, -0.03025975f, 0.05278003f, 
    0.05620618f, -0.00616473f, 0.04884068f, 0.03842826f, 0.04770055f, 0.03914909f, 0.02758688f, -0.07101972f, 
    -0.07608439f, 0.02449881f, -0.04194033f, 0.04640718f, -0.00942013f, -0.06805053f, 0.03582910f, 0.00254095f, 
    0.03249483f, -0.06109260f, 0.05059277f, -0.02262783f, -0.02897501f, 0.01490838f, 0.01930162f, 0.06093572f, 
    -0.10007166f, -0.04083938f, -0.15527792f, -0.07144569f, -0.16256897f, -0.10045813f, -0.04061761f, 0.11321069f, 
    -0.20835805f, 0.01690098f, -0.12851189f, -0.28106955f, 0.33321786f, 0.22851814f, 0.26285005f, 0.26721817f, 
    -0.19766457f, -0.22619160f, 0.00969400f, -0.00066070f, -0.01144451f, -0.10593557f, -0.10421422f, -0.07514559f, 
    0.09966227f, -0.00514264f, 0.15791979f, 0.08673725f, -0.06588091f, 0.09445961f, -0.02091585f, 0.00896179f, 
    -0.23463155f, -0.17748246f, 0.05238774f, -0.03303066f, -0.01390460f, 0.08765581f, 0.14903222f, 0.06662256f, 
    0.26428956f, 0.11235283f, -0.07675137f, 0.05756861f, -0.30953640f, -0.10045287f, -0.05665470f, -0.35333332f, 
    0.14034942f, -0.01281906f, -0.06318094f, 0.15231346f, -0.04388076f, 0.04962179f, -0.04492505f, -0.02160961f, 
    0.09805109f, 0.19531290f, -0.10945208f, 0.05124074f, 0.15365221f, 0.35389429f, -0.03699447f, 0.18192716f, 
    0.06892347f, 0.04872327f, 0.04536111f, 0.15899099f, 0.21944644f, 0.18736771f, 0.09318949f, 0.29670805f, 
    -0.19358082f, -0.02159093f, -0.01644602f, 0.11728761f, -0.12095045f, -0.12520942f, -0.16540222f, 0.12516433f, 
    -0.14985345f, -0.13228746f, -0.07783680f, -0.30691487f, -0.17977600f, -0.12020888f, 0.36747816f, 0.18698946f, 
    0.15344360f, 0.17389707f, -0.02100893f, -0.07409590f, -0.08119339f, -0.10472465f, -0.02175350f, -0.30715856f, 
    0.25623694f, -0.06869934f, -0.05992275f, -0.12468603f, 0.00148205f, -0.05934206f, 0.07047913f, 0.11326452f, 
    0.09387174f, -0.01069163f, 0.11193045f, 0.11224520f, -0.12390522f, -0.17328386f, 0.24841319f, 0.06708542f, 
    0.13453732f, 0.20158435f, -0.03025648f, 0.10046688f, -0.00185558f, -0.03510534f, -0.12317389f, -0.01838091f, 
    -0.05803069f, 0.02474430f, 0.14297290f, 0.00753437f, 0.02466270f, -0.10953736f, -0.01844154f, 0.09207529f, 
    -0.26395091f, -0.08142417f, 0.06786575f, 0.04407288f, -0.21071479f, -0.06144280f, 0.10515937f, 0.12370926f, 
    0.03964471f, -0.04769637f, -0.10372521f, 0.02480237f, -0.10577209f, -0.11331998f, -0.10851754f, -0.25942966f, 
    0.00545327f, 0.13668309f, -0.02022131f, -0.16499861f, -0.05173691f, -0.02373851f, -0.13240235f, 0.06929102f, 
    -0.03451486f, 0.16750082f, 0.14822698f, 0.06255377f, 0.05562472f, 0.12240333f, -0.08476352f, 0.22296675f, 
    0.06187705f, -0.04507238f, 0.08530252f, -0.03437062f, 0.01745385f, 0.10365380f, 0.02376356f, 0.14240277f, 
    -0.23051704f, 0.04994278f, 0.14135817f, 0.21849033f, 0.07291023f, -0.00547125f, -0.11879074f, -0.05967615f, 
    -0.14362831f, 0.08745487f, -0.20936278f, -0.03217895f, -0.04145336f, 0.10656275f, 0.12038656f, 0.34833151f, 
    0.07766653f, 0.11552036f, 0.02040614f, 0.08169913f, 0.29618874f, 0.07667691f, 0.16016449f, 0.06361557f, 
    0.01376742f, -0.15031637f, 0.01630684f, -0.13372421f, 0.01542896f, -0.17526542f, -0.09014945f, 0.02671920f, 
    -0.09449497f, -0.13634606f, -0.02763149f, -0.07128758f, 0.09360155f, 0.20012774f, 0.03665034f, 0.17876092f, 
    -0.13584526f, -0.09323516f, -0.28636798f, -0.14545983f, -0.05695930f, -0.16198260f, 0.08409313f, 0.18628548f, 
    -0.03156119f, 0.20331004f, 0.02066488f, 0.21926206f, -0.03030673f, -0.05844877f, 0.14212854f, 0.01280745f, 
    0.07471900f, -0.06018033f, 0.02167121f, -0.03186548f, -0.02502956f, -0.15294163f, 0.00829034f, -0.08789649f, 
    -0.02116000f, 0.09078190f, 0.26352742f, 0.11003102f, -0.04669566f, 0.05653225f, 0.05309061f, -0.05387115f, 
    0.15233600f, 0.13117899f, -0.10915442f, 0.24176532f, -0.08042429f, 0.03805327f, -0.21033610f, -0.21097554f, 
    -0.00938730f, 0.22113863f, -0.08827060f, 0.16967402f, 0.20579885f, 0.17116818f, 0.06085867f, 0.14707659f, 
    -0.12712017f, 0.00690311f, 0.14640236f, -0.00963016f, 0.10152982f, 0.10027459f, -0.03036383f, 0.04198679f, 
    -0.16893540f, -0.20984642f, 0.13945758f, 0.05202403f, -0.06358860f, -0.12089919f, 0.04379431f, 0.17970131f, 
    0.01750310f, 0.03227121f, 0.12075207f, -0.01756815f, -0.07815187f, 0.03739073f, -0.26328513f, 0.27748948f, 
    0.00212625f, -0.03302980f, 0.00318615f, 0.10419378f, 0.08833110f, -0.00097621f, -0.10302135f, 0.08122274f, 
    -0.05519936f, 0.15708753f, 0.16510616f, 0.05067878f, 0.10128001f, 0.05649703f, -0.11160606f, -0.04566184f, 
    0.00956331f, 0.02807332f, -0.05770266f, 0.01492994f, -0.08419234f, 0.14713366f, -0.34971732f, 0.02047695f, 
    -0.18251787f, -0.09056251f, 0.07025780f, -0.17089419f, -0.02109093f, -0.18417898f, -0.15024954f, -0.07247231f, 
    -0.13416038f, -0.25289369f, -0.18488172f, 0.00936550f, -0.02527439f, 0.07311027f, 0.15564288f, 0.11716066f, 
    0.03847444f, -0.01136377f, -0.15125041f, -0.14313297f, 0.07174898f, -0.34140870f, 0.00879512f, -0.05557571f, 
    0.11149002f, 0.02527257f, 0.01012279f, -0.00845995f, 0.02527748f, -0.05524702f, 0.01031911f, 0.07705655f, 
    -0.13070706f, -0.12814896f, -0.00766993f, 0.35696149f, -0.00647276f, 0.07401832f, -0.00498753f, -0.13116141f, 
    -0.07150847f, 0.08265115f, -0.12639359f, 0.04020556f, -0.16897631f, -0.28863937f, -0.01695128f, 0.35183439f, 
    0.00847465f, -0.02016341f, 0.05941090f, -0.01530906f, 0.10212332f, 0.11942600f, 0.04684226f, 0.02048510f, 
    -0.05867768f, 0.05490526f, -0.08761756f, -0.25983268f, -0.02760761f, 0.09123753f, 0.05331169f, -0.04308641f, 
    0.00635709f, 0.21727899f, 0.04430176f, -0.01407060f, 0.09464221f, 0.12040718f, -0.06584213f, 0.28163001f, 
    0.07543495f, 0.02055403f, 0.14348766f, 0.08515803f, 0.05164806f, 0.08707545f, 0.04476149f, 0.01694683f, 
    -0.08416259f, 0.10923463f, 0.03383771f, 0.14367402f, 0.03079028f, 0.09675262f, 0.03576519f, -0.01854250f, 
    0.09704727f, 0.11096209f, -0.02117250f, 0.17515455f, -0.30667764f, -0.09586178f, 0.15912919f, 0.03758962f, 
    -0.01181197f, -0.04968223f, 0.15423512f, -0.04088072f, -0.03713302f, -0.09217638f, 0.01702235f, -0.11644781f, 
    0.20305143f, -0.03055760f, 0.14923456f, -0.08920515f, 0.07160309f, 0.11055305f, -0.00762215f, 0.07938034f, 
    -0.11783712f, 0.01961850f, -0.02848128f, 0.11040984f, 0.01357687f, 0.00679095f, -0.05656025f, -0.05137284f, 
    -0.06908077f, -0.06487864f, -0.09440561f, 0.01318642f, 0.00075459f, -0.06530185f, -0.11600985f, 0.04840861f, 
    -0.35562497f, -0.05870379f, 0.09160712f, -0.05095797f, 0.10228068f, 0.03147277f, 0.16933416f, 0.16780418f, 
    0.13169426f, -0.18731694f, -0.00641672f, -0.00753810f, 0.07511938f, 0.02306785f, 0.04848821f, 0.00409349f, 
    0.19877926f, 0.05385040f, 0.02643931f, 0.12147085f, -0.02845534f, -0.00821749f, 0.13816030f, -0.01202186f, 
    0.12613186f, 0.19577877f, -0.03705167f, -0.08848844f, 0.11183507f, 0.12159862f, 0.01777484f, -0.09191515f, 
    -0.10814342f, -0.03035523f, -0.05733828f, 0.00034945f, -0.00146952f, 0.12056615f, -0.07682059f, -0.21810521f, 
    0.12485639f, 0.00666029f, -0.07895560f, -0.03799708f, 0.01223636f, 0.04780960f, 0.00657769f, 0.16282320f, 
    0.14460440f, -0.13803063f, -0.05502170f, 0.08837407f, -0.04694955f, -0.10624306f, -0.02207217f, 0.03536277f, 
    0.14231487f, 0.03525572f, 0.03277905f, 0.32618794f, 0.09994107f, -0.01550312f, 0.20669074f, 0.09253056f, 
    0.06159538f, -0.10818578f, -0.12845133f, 0.04168673f, -0.00153883f, 0.01853902f, -0.07872517f, -0.05473825f, 
    0.17712168f, -0.01882326f, 0.07648727f, 0.10926431f, -0.02548389f, -0.09792821f, 0.03868992f, 0.03191238f, 
    -0.11691043f, -0.10566603f, 0.00949525f, 0.04563694f, -0.25801307f, 0.19311407f, -0.13287787f, 0.26919699f, 
    -0.09338482f, -0.04478646f, -0.04061462f, 0.01999624f, 0.02671609f, 0.03666603f, -0.09654454f, 0.10637435f, 
    0.04647972f, -0.03304543f, 0.17913464f, 0.26938954f, -0.08628133f, -0.06866892f, 0.09921673f, 0.13771372f, 
    0.19356945f, 0.01678391f, 0.09525266f, 0.02500772f, 0.10220314f, 0.24420050f, 0.13497590f, -0.29433101f, 
    0.01437867f, -0.10233653f, -0.01760922f, 0.02761940f, 0.06783649f, -0.10959966f, -0.01884226f, -0.00980100f, 
    0.13445768f, -0.01873936f, 0.07596606f, -0.08571103f, -0.04916781f, -0.17086102f, 0.05063471f, 0.16745472f, 
    0.09646296f, 0.05229966f, 0.02640995f, 0.05563147f, -0.07333554f, 0.08205990f, 0.08369875f, -0.26804712f, 
    -0.03176774f, -0.09812599f, -0.01063911f, -0.08477057f, -0.01069988f, -0.03375386f, 0.06100189f, 0.08750141f, 
    -0.09358834f, 0.01005910f, -0.06695089f, 0.00277772f, 0.00239582f, 0.07889411f, -0.03572275f, 0.03732255f, 
    0.11969740f, 0.09074410f, 0.03623502f, 0.08071922f, 0.15260200f, 0.12832811f, 0.02843047f, -0.10168891f, 
    0.00592914f, -0.00841180f, 0.10209638f, 0.05699753f, -0.02042977f, -0.10889831f, -0.05699217f, -0.13399373f, 
    -0.33510241f, 0.14916416f, -0.04586520f, 0.11069388f, -0.08271824f, 0.04110547f, 0.00792770f, 0.04524768f, 
    0.02185494f, 0.07308023f, -0.02212360f, 0.10935640f, 0.08215324f, 0.10015982f, 0.04668975f, 0.29828709f, 
    -0.04920185f, -0.03054492f, -0.14509836f, -0.05435824f, 0.05251672f, -0.04291725f, 0.01631343f, -0.05233759f, 
    -0.09016571f, 0.21437910f, 0.09134937f, -0.29750997f, 0.01517880f, 0.05127512f, 0.18912150f, 0.00890666f, 
    -0.04173939f, 0.02601919f, -0.06759674f, 0.02916956f, -0.22269952f, -0.02465296f, -0.03117973f, -0.04490257f, 
    0.06407353f, -0.02156214f, -0.14096482f, -0.05486427f, -0.01917012f, -0.03310233f, -0.12981635f, -0.03995390f, 
    0.18671878f, 0.16984738f, 0.03327208f, 0.15006670f, 0.06667958f, 0.15975812f, 0.23801100f, 0.05483344f, 
    0.06215109f, 0.02587663f, 0.02940439f, -0.01626811f, 0.07193530f, 0.31085053f, 0.22397736f, 0.03093637f, 
    0.12353832f, 0.12484047f, -0.05684938f, -0.00365889f, 0.03864897f, -0.09871126f, 0.04170947f, -0.05441711f, 
    0.06275684f, -0.04038142f, 0.01590626f, -0.20978107f, -0.05428483f, -0.01423451f, 0.09423820f, 0.04932475f, 
    0.08290126f, 0.08193543f, -0.13460167f, -0.08697942f, -0.27961254f, -0.05873673f, 0.01893041f, 0.07955886f, 
    0.04198029f, -0.09523790f, -0.14716251f, -0.04170815f, 0.08798689f, 0.09480344f, 0.05538377f, 0.08766841f, 
    0.05534354f, -0.07456093f, -0.22644985f, 0.10004068f, 0.01132221f, -0.08512578f, 0.08355140f, 0.01634546f, 
    0.09501455f, 0.01787319f, 0.09722386f, 0.09183877f, 0.04410897f, 0.05318201f, 0.04141875f, 0.12471288f, 
    -0.24905777f, 0.03813017f, 0.09726495f, 0.00753680f, 0.11331429f, 0.04991308f, -0.01121342f, -0.01688691f, 
    0.10607348f, 0.03596709f, -0.04252403f, -0.40441778f, -0.02483259f, 0.00874886f, 0.02445578f, -0.01303360f, 
    -0.16597645f, 0.14616919f, -0.04117246f, 0.01888235f, 0.32590756f, 0.33207303f, 0.01032026f, 0.04762016f, 
    0.13553335f, 0.06949550f, -0.19810262f, 0.07460889f, -0.02639088f, -0.05414015f, -0.10438827f, 0.18212847f, 
    0.04472825f, 0.01005777f, -0.07456880f, 0.13818568f, -0.06568056f, 0.15110883f, -0.15824093f, -0.13639933f, 
    -0.08482745f, -0.15326747f, 0.03663175f, 0.10832562f, 0.07116748f, 0.11653242f, 0.14174582f, 0.08064719f, 
    0.09954683f, -0.04257181f, 0.01341146f, 0.05538486f, -0.05747567f, 0.14015271f, -0.10339930f, -0.05241469f, 
    -0.21120594f, -0.13579565f, -0.14535989f, 0.07546908f, 0.06345008f, -0.03689225f, -0.01530682f, 0.13166960f, 
    -0.09704944f, 0.06977163f, -0.06117186f, -0.02457457f, 0.14625159f, 0.18596318f, 0.39759901f, 0.12408945f, 
    -0.03449038f, -0.07290664f, 0.04842062f, 0.03838996f, -0.02875754f, -0.06028419f, 0.01180621f, 0.02794474f, 
    0.15766850f, 0.11331558f, 0.19889109f, 0.06156123f, 0.02557989f, 0.06051473f, 0.10757907f, -0.02523819f, 
    -0.05361609f, -0.01791893f, 0.10491879f, -0.04170761f, 0.10471670f, -0.12782912f, 0.29203326f, -0.00288068f, 
    0.15315776f, -0.00124723f, -0.05915568f, -0.13810286f, -0.15566823f, 0.01965463f, -0.06571652f, -0.29443032f, 
    -0.05187766f, -0.22292793f, -0.05964479f, 0.47518504f, 0.05259797f, 0.14819984f, 0.03427018f, 0.00816746f, 
    0.15335770f, 0.07610501f, -0.20429575f, -0.01222580f, 0.09165410f, 0.02904453f, -0.17897876f, 0.22069891f, 
    -0.10675710f, 0.02150702f, 0.17893356f, 0.24405070f, 0.15292859f, 0.15640199f, 0.03482071f, 0.29910997f, 
    -0.24023895f, -0.12765113f, 0.11701849f, 0.17885160f, -0.12841965f, -0.14600055f, -0.08324946f, -0.02035566f, 
    -0.18199463f, -0.09961472f, -0.16046780f, -0.15099995f, -0.30098441f, -0.40088737f, 0.14554694f, 0.26410118f, 
    0.15994774f, 0.13058256f, 0.10677574f, 0.04791534f, -0.00843084f, -0.16830461f, -0.10996877f, -0.14255612f, 
    0.30966607f, -0.06305766f, -0.13101020f, -0.12724659f, -0.00231186f, 0.04291823f, -0.03973999f, 0.27467871f, 
    0.23208742f, 0.10156738f, 0.12720364f, 0.04891793f, 0.12050711f, -0.54686475f, -0.17892410f, -0.02311766f, 
    -0.12604932f, 0.17072578f, -0.02318540f, 0.03726088f, 0.05593621f, -0.09415340f, -0.06372089f, 0.03929384f, 
    0.00168354f, -0.19983141f, -0.03350227f, -0.12080389f, -0.01404063f, 0.01065201f, 0.01565035f, 0.04827382f, 
    -0.12668382f, 0.10756971f, 0.05623414f, -0.04240720f, -0.12031341f, -0.09816306f, 0.15182397f, 0.12606429f, 
    0.23297727f, -0.07568592f, 0.01452942f, 0.01386494f, -0.03959138f, -0.07546268f, -0.05115703f, -0.08906859f, 
    -0.17015421f, -0.17816070f, 0.13160211f, -0.16679190f, 0.13526213f, -0.11461908f, -0.05759474f, 0.06208225f, 
    0.12422249f, 0.22481921f, 0.12094141f, 0.21217155f, -0.24706499f, -0.19444188f, -0.13578342f, 0.20818584f, 
    -0.04913429f, -0.00482744f, 0.16608003f, -0.14015442f, -0.02262385f, 0.06078862f, 0.18893237f, 0.12811634f, 
    0.03356340f, 0.17298299f, 0.08641654f, 0.20424059f, 0.06454954f, 0.04844526f, -0.02358172f, -0.12157587f, 
    -0.01073109f, -0.05438800f, -0.14374456f, -0.06012381f, -0.15834576f, -0.17374490f, 0.07895464f, 0.30570409f, 
    0.18796618f, 0.19584258f, -0.02579314f, 0.02324622f, 0.09048814f, 0.00870185f, 0.18381707f, 0.13315883f, 
    0.03866976f, -0.05435869f, -0.05088133f, -0.02527170f, -0.05851930f, 0.11735197f, 0.01932676f, 0.03006439f, 
    -0.09148663f, -0.10096471f, 0.06015086f, 0.05668109f, 0.05488782f, 0.09451353f, -0.08784860f, 0.13121444f, 
    0.00244345f, -0.11237063f, 0.02752045f, 0.00983037f, 0.12036945f, -0.21898803f, -0.04098348f, 0.01324621f, 
    0.27243602f, 0.13908631f, -0.39228737f, 0.00312324f, 0.00529076f, 0.10170670f, 0.06833767f, -0.10300584f, 
    0.08678874f, -0.16004822f, 0.03005040f, -0.02364278f, -0.08961459f, 0.20922257f, -0.17880052f, 0.19528563f, 
    0.22513092f, -0.02593323f, -0.00310898f, 0.11688235f, -0.09682363f, -0.06906091f, -0.12254264f, 0.02164449f, 
    0.09489481f, 0.05655418f, 0.12743989f, 0.16795850f, -0.12766539f, 0.10963206f, 0.14621307f, -0.01398493f, 
    0.07334968f, -0.00149298f, -0.12941441f, 0.09312189f, -0.04269724f, 0.00179132f, -0.17546675f, -0.07317527f, 
    0.01805120f, -0.09622984f, 0.05525764f, 0.06660715f, 0.08027378f, -0.03325000f, 0.05928558f, 0.11029091f, 
    -0.09333969f, 0.16003676f, -0.03292755f, -0.09251371f, -0.07513427f, -0.07307030f, 0.11262831f, 0.07473139f, 
    -0.05320379f, -0.05064931f, 0.07114395f, 0.02819496f, -0.15744767f, 0.08194943f, 0.11335282f, 0.06091947f, 
    0.11931448f, -0.02716047f, 0.23506534f, 0.02437238f, 0.00470099f, -0.02752420f, 0.08958874f, -0.18101926f, 
    -0.05033782f, -0.06393853f, -0.03537995f, 0.03332341f, 0.04275213f, -0.03871112f, -0.01142099f, -0.04004100f, 
    0.18223990f, -0.08640517f, 0.10287046f, -0.04791447f, -0.10809694f, 0.07978573f, -0.08117238f, 0.10177449f, 
    0.16239497f, 0.17037940f, 0.06913491f, 0.01298493f, -0.06668036f, 0.01096282f, -0.04162731f, 0.09325989f, 
    -0.11080121f, -0.18525441f, -0.14785656f, 0.24077560f, 0.08592367f, -0.02185834f, 0.13213533f, 0.13832615f, 
    -0.04883892f, -0.09468029f, -0.07312425f, -0.01877060f, 0.03329048f, -0.20329672f, 0.07163081f, 0.11298253f, 
    0.00732742f, -0.05624711f, -0.00630967f, -0.11943563f, 0.03833439f, -0.02005505f, -0.10700139f, -0.06353381f, 
    0.21165851f, -0.44449186f, 0.21090548f, 0.48973435f, -0.08882724f, -0.08584475f, -0.09887125f, -0.05156741f, 
    0.07433832f, 0.05487561f, -0.10010657f, 0.07559956f, -0.04011301f, 0.17043328f, 0.07972507f, 0.05827649f, 
    0.06803975f, -0.00656541f, 0.03207801f, -0.10350091f, 0.02091356f, -0.06327415f, 0.00658027f, 0.12910692f, 
    -0.00675801f, -0.03419422f, -0.07388345f, -0.08519485f, 0.08036491f, 0.11411025f, -0.28528452f, 0.07433148f, 
    -0.15934850f, 0.08549151f, -0.18516058f, -0.06788957f, 0.03950979f, 0.15239824f, 0.03497650f, 0.08196059f, 
    0.08693317f, -0.12861378f, 0.03444253f, 0.05374888f, 0.06394939f, -0.06993290f, 0.02358164f, -0.02838292f, 
    -0.12897386f, 0.14594203f, 0.04001932f, 0.01896114f, 0.03368087f, 0.10169648f, 0.06880395f, 0.05305263f, 
    0.09106856f, 0.11372696f, -0.03350998f, 0.17267852f, -0.29153278f, -0.06559464f, 0.21858113f, 0.04194957f, 
    -0.02583535f, 0.03210725f, 0.05925864f, 0.11272460f, -0.04561081f, -0.07396116f, 0.03846510f, -0.11235813f, 
    -0.09636496f, -0.02232337f, 0.18081295f, 0.09253116f, 0.07362092f, 0.02436481f, -0.03442615f, -0.01690183f, 
    -0.05905055f, 0.00239008f, -0.05753861f, 0.04519248f, -0.06047579f, 0.07801162f, -0.12398428f, -0.13588741f, 
    -0.11005953f, -0.13777547f, 0.00342737f, -0.11971207f, 0.02358919f, -0.06794038f, 0.04741830f, 0.04887286f, 
    -0.12204535f, 0.17496803f, 0.15045722f, -0.29170084f, 0.06033025f, 0.01933686f, 0.11265694f, 0.27666646f, 
    0.06206204f, -0.17165120f, 0.04870255f, -0.02682515f, -0.07546343f, 0.05951535f, 0.10855510f, -0.10996229f, 
    0.11869445f, 0.12333982f, -0.12937467f, 0.10633209f, -0.00832675f, -0.01973405f, 0.14444667f, -0.05242472f, 
    0.13641696f, 0.12177800f, -0.07329424f, -0.05863797f, 0.17712933f, 0.19373290f, 0.07076742f, -0.04351605f, 
    -0.03720375f, -0.03765166f, 0.00081784f, 0.03374678f, 0.18580101f, 0.06592253f, -0.04037812f, -0.20201960f, 
    0.14722018f, 0.03075105f, -0.15265454f, -0.01045272f, 0.04894070f, -0.01273340f, -0.08993451f, 0.11970886f, 
    0.01115311f, -0.18008400f, -0.02860255f, 0.03907201f, -0.13028349f, -0.02534634f, -0.06417651f, 0.06600600f, 
    0.07704041f, -0.00252345f, -0.01374855f, 0.26455894f, -0.09042230f, -0.01119594f, 0.02525176f, 0.03599938f, 
    -0.02442297f, -0.05985808f, -0.07320758f, 0.03901098f, -0.06964032f, 0.04424483f, -0.07473096f, 0.06584997f, 
    0.02664511f, -0.00546206f, -0.00577453f, 0.03816748f, 0.00206646f, -0.05106609f, 0.06784876f, 0.01486696f, 
    -0.05162317f, -0.00610839f, -0.03871346f, 0.08684425f, -0.06300551f, 0.20514771f, -0.02587624f, 0.06321335f, 
    -0.14316611f, -0.03769587f, 0.03545346f, 0.13488513f, 0.04454167f, -0.00845506f, 0.02145247f, 0.06241898f, 
    0.05822791f, 0.13469426f, 0.28825480f, 0.10194565f, -0.06864049f, -0.00233754f, 0.08536598f, 0.06829351f, 
    0.17108822f, 0.02529602f, 0.09444544f, 0.06616014f, 0.22662643f, 0.09203712f, -0.00076619f, -0.16453351f, 
    0.01819306f, 0.09366897f, -0.06738751f, 0.21772210f, 0.09449492f, -0.03607313f, -0.19668984f, -0.09261604f, 
    0.02733106f, 0.07767480f, -0.06416316f, -0.09593685f, -0.11479366f, -0.15237598f, 0.04196469f, -0.02441248f, 
    0.15251128f, -0.05159708f, 0.02741041f, -0.01645397f, 0.04382022f, -0.06763619f, 0.09096155f, -0.29008478f, 
    -0.02965021f, -0.06157315f, 0.07813672f, -0.00852477f, -0.04033027f, 0.02877189f, 0.06673554f, 0.10877904f, 
    0.24196066f, -0.00814050f, 0.10928750f, 0.00244475f, 0.07022536f, -0.04556337f, -0.01033011f, -0.06329992f, 
    0.17912747f, -0.11181209f, 0.05003144f, 0.03182186f, -0.04834784f, -0.20195363f, -0.19220918f, -0.12331399f, 
    -0.04855274f, 0.05218824f, -0.10022428f, 0.04017325f, 0.17815687f, -0.08048838f, -0.06239040f, -0.05252903f, 
    -0.03917156f, 0.28710219f, -0.10168246f, 0.02702445f, 0.07381680f, -0.03617437f, -0.05943903f, -0.09207287f, 
    0.00435937f, 0.04515935f, 0.01652606f, 0.04249937f, -0.11666165f, 0.20800096f, -0.15232751f, 0.39387906f, 
    0.00585126f, -0.21824229f, -0.08877026f, -0.10569378f, -0.07591978f, -0.00428302f, 0.06239202f, 0.04454446f, 
    0.09551789f, -0.10322973f, 0.12426481f, -0.31410900f, -0.05719964f, -0.03716569f, 0.10033333f, 0.15948248f, 
    0.11720722f, -0.06315319f, 0.10841800f, -0.02397481f, -0.03971657f, -0.24964698f, 0.01908770f, -0.09505741f, 
    0.09598760f, 0.02536784f, -0.08252574f, 0.07259550f, -0.18144809f, -0.21188764f, 0.05315086f, -0.28614342f, 
    0.09216220f, 0.31241456f, -0.14215778f, -0.19474246f, 0.08857920f, -0.05563995f, 0.10128554f, 0.06488243f, 
    0.07083033f, 0.03859874f, 0.08492831f, 0.12741144f, 0.12954411f, 0.29713479f, -0.03597792f, 0.10225301f, 
    0.05047411f, -0.03342441f, 0.11060067f, 0.01938456f, 0.04149618f, 0.05240598f, 0.00012647f, 0.03737294f, 
    -0.04843304f, 0.23457003f, 0.07689752f, -0.00369722f, -0.01744336f, -0.04340191f, -0.06351589f, -0.00885199f, 
    0.06489663f, 0.04479610f, 0.02275488f, 0.16424948f, -0.13281885f, 0.12797347f, -0.01479777f, 0.05267891f, 
    0.10714833f, -0.04826248f, -0.09887643f, -0.11535584f, -0.04302200f, -0.05771058f, 0.14822252f, -0.02717314f, 
    0.11410157f, 0.11067190f, -0.03457866f, 0.16735476f, -0.09104355f, -0.08045539f, -0.02468965f, -0.03185076f, 
    0.00242080f, -0.04048683f, 0.07345747f, 0.11466157f, 0.12694697f, 0.00895604f, -0.00227886f, -0.12473197f, 
    -0.06860017f, -0.09517534f, 0.05226653f, 0.07455623f, 0.13440996f, 0.04083397f, 0.02015178f, 0.18489036f, 
    0.35094431f, 0.03142070f, 0.23912176f, -0.08763327f, -0.05101107f, -0.11338352f, -0.04665266f, -0.03491782f, 
    0.14770547f, -0.01925798f, -0.05755290f, 0.15460710f, 0.00709613f, 0.19691926f, 0.11728267f, -0.06028066f, 
    0.14734867f, -0.15029365f, -0.02399664f, -0.00752892f, 0.18622217f, 0.03892807f, 0.01464004f, -0.03295832f, 
    0.11947729f, -0.04116803f, -0.00325794f, -0.10099711f, -0.00640127f, 0.10304143f, 0.02796087f, 0.11863016f, 
    0.06330568f, -0.20314339f, 0.08399440f, -0.08566800f, 0.06710266f, 0.20445426f, 0.05666438f, -0.04462985f, 
    0.09652878f, -0.18776585f, 0.08086935f, 0.09469205f, -0.02379239f, -0.01457113f, -0.08734417f, -0.02742316f, 
    0.16361023f, -0.29698747f, -0.02898528f, 0.07587758f, -0.04510927f, 0.11006880f, -0.09611769f, 0.02881030f, 
    0.19382423f, -0.04601343f, 0.21224321f, 0.31014359f, -0.41615769f, -0.41932625f, -0.24248436f, -0.07630777f, 
    0.03671971f, 0.07639692f, -0.09712749f, 0.04256298f, 0.20257324f, 0.08682117f, 0.06254350f, 0.05714451f, 
    0.18115394f, -0.01409078f, -0.24269323f, -0.27709958f, 0.03888043f, -0.06401813f, -0.05564422f, 0.00067726f, 
    0.10385012f, -0.00502669f, -0.04336962f, -0.13906315f, -0.22014813f, 0.27630913f, -0.36515337f, -0.06372403f, 
    0.01706946f, -0.19138764f, -0.06577190f, 0.04344398f, 0.17528237f, 0.04228835f, 0.01011867f, 0.16383605f, 
    0.23123270f, -0.14409746f, 0.35777399f, 0.10800414f, -0.00878481f, 0.11401331f, 0.03810595f, 0.07652174f, 
    0.10416164f, -0.08261961f, 0.06741828f, -0.00590875f, -0.06558111f, -0.29987040f, -0.05106871f, 0.00478483f, 
    0.03672368f, 0.01378428f, -0.09658965f, 0.09029198f, 0.02401167f, -0.08903830f, 0.01308114f, -0.30301958f, 
    0.11190876f, 0.36959586f, 0.09159683f, -0.07276945f, 0.12418824f, 0.12547594f, 0.05932978f, -0.00926100f, 
    0.06118607f, -0.05301566f, 0.00480933f, 0.16661410f, 0.18448846f, 0.18116690f, -0.01573097f, -0.08037002f, 
    0.07011139f, -0.09408224f, 0.08478179f, 0.08997728f, -0.01969460f, 0.09925216f, 0.11784561f, 0.08049812f, 
    -0.36402833f, -0.15671962f, -0.21368586f, 0.02255007f, -0.14567833f, -0.20189895f, -0.07256389f, -0.05416451f, 
    0.17075944f, 0.02869171f, 0.13134623f, 0.03154582f, -0.26617360f, -0.19919723f, -0.10739779f, -0.11484813f, 
    0.06288695f, -0.05198360f, -0.08232518f, -0.15431720f, -0.05731795f, 0.14224291f, 0.12596223f, -0.12593065f, 
    -0.21217431f, -0.02787191f, -0.32879722f, -0.12182201f, -0.06810448f, -0.09434537f, -0.04057291f, 0.02864998f, 
    0.00445882f, -0.00301456f, -0.02421124f, -0.03164097f, 0.02099964f, -0.14075825f, 0.12318165f, -0.15442926f, 
    -0.08383628f, 0.04456552f, 0.07051751f, -0.04165823f, 0.21145988f, -0.01060139f, 0.05855046f, 0.18548861f, 
    0.10510595f, -0.15437432f, 0.28329974f, -0.09010015f, -0.08068835f, -0.20366868f, -0.12546843f, 0.07289586f, 
    -0.01231864f, 0.03976282f, 0.07301240f, 0.12793636f, 0.06071573f, 0.28197187f, 0.29079026f, -0.01258951f, 
    0.14336210f, 0.17577630f, 0.08462182f, 0.11163203f, -0.00544271f, -0.17921975f, -0.04276903f, -0.04154104f, 
    0.15316387f, -0.19944496f, -0.00002843f, -0.30466416f, 0.02821126f, 0.15570977f, -0.02496438f, 0.05689579f, 
    0.24406931f, -0.02267769f, 0.09033346f, 0.05227563f, 0.20032221f, 0.24276337f, 0.05860894f, -0.16913058f, 
    0.06334152f, -0.03842783f, 0.20728752f, 0.07153619f, -0.20153530f, 0.00138184f, -0.14380115f, 0.10313494f, 
    -0.11151389f, 0.18810257f, -0.13713798f, 0.01486423f, -0.07622838f, 0.13985792f, -0.01444138f, -0.10919454f, 
    0.20318796f, 0.24129604f, 0.26870626f, 0.22744155f, -0.19314811f, -0.01105061f, 0.03611339f, -0.20470737f, 
    0.01854444f, -0.13090584f, 0.05099873f, 0.13760641f, -0.01861827f, 0.01373178f, -0.05939993f, -0.04637032f, 
    0.54789543f, 0.02197922f, -0.10977499f, -0.08543700f, -0.20598191f, -0.03015261f, -0.00597206f, 0.03647363f, 
    -0.01378213f, 0.01202578f, -0.01433342f, 0.00303416f, 0.23065713f, -0.41632628f, 0.10870187f, -0.18675545f, 
    -0.10205707f, -0.10564160f, 0.02449416f, -0.11513325f, 0.17388077f, 0.04603488f, -0.14495780f, 0.10875230f, 
    -0.43888485f, 0.01399909f, 0.13159566f, 0.19484961f, 0.00368853f, 0.14701959f, 0.05335221f, 0.05364882f, 
    -0.00367025f, -0.07089087f, -0.14749101f, 0.05918872f, 0.08809794f, 0.01857832f, -0.05003848f, 0.04979586f, 
    0.06455127f, -0.05323146f, 0.02946718f, 0.17850399f, -0.02924451f, -0.03741008f, -0.04027498f, -0.19514549f, 
    -0.05056207f, 0.03064811f, 0.19299936f, 0.12841141f, -0.03566412f, 0.14969106f, 0.14742355f, 0.15093003f, 
    -0.06377341f, 0.00183334f, 0.03052965f, 0.09972186f, -0.15864135f, -0.12097410f, 0.25501674f, 0.11062179f, 
    0.12229576f, -0.01070545f, 0.24449112f, 0.08215408f, -0.07365574f, 0.02431325f, 0.10213306f, 0.14524178f, 
    0.04585190f, -0.08053562f, 0.14733511f, 0.19049244f, -0.09462503f, -0.17438029f, -0.12770064f, -0.13362435f, 
    0.15743257f, -0.16657101f, -0.00375932f, 0.01558534f, 0.15501247f, -0.13888532f, 0.07784131f, -0.10212406f, 
    -0.08203780f, 0.06156826f, -0.02746054f, -0.13658109f, -0.13534899f, 0.13731174f, -0.06248865f, -0.13121213f, 
    0.05090556f, 0.04907457f, 0.15748012f, 0.19675092f, -0.19068429f, -0.05678309f, 0.07116397f, 0.04969367f, 
    0.10652103f, 0.03314525f, -0.15188722f, -0.04959567f, -0.20908703f, 0.05073016f, -0.10445486f, 0.23259741f, 
    0.07077584f, 0.06453416f, 0.08749318f, -0.13979322f, -0.14934126f, -0.03677243f, 0.02654239f, 0.12538639f, 
    -0.31970468f, -0.20167114f, 0.47767219f, 0.23612489f, -0.07914115f, -0.00124434f, -0.11279129f, -0.15218714f, 
    0.12114646f, -0.09977316f, -0.00235184f, -0.04477644f, -0.09079362f, -0.06480526f, 0.08313102f, 0.16294169f, 
    0.03065260f, 0.07013247f, -0.04294902f, 0.12896515f, 0.17451072f, 0.00086365f, -0.05919372f, -0.12741114f, 
    0.34678909f, 0.00598151f, 0.01081572f, 0.22921568f, -0.00706457f, 0.09187460f, -0.07194207f, -0.05766452f, 
    0.01089907f, 0.08358444f, 0.03362594f, 0.21815789f, -0.03886974f, 0.07714208f, 0.00713401f, 0.16014925f, 
    -0.05513942f, -0.08401836f, 0.01016564f, -0.02570108f, -0.07141855f, -0.05885202f, -0.04672794f, -0.05478433f, 
    0.02884313f, -0.03192685f, -0.05849115f, 0.00088708f, -0.00809247f, -0.04447621f, -0.00892252f, 0.03309020f, 
    -0.01711561f, 0.00261826f, -0.06908785f, -0.00208256f, -0.05547174f, 0.01139295f, -0.07685992f, -0.04999380f, 
    -0.01003665f, 0.05781770f, 0.05882172f, -0.03864528f, 0.01790201f, -0.00125294f, 0.00283343f, -0.06713745f, 
    0.00330722f, 0.02250607f, -0.06361748f, 0.03500598f, 0.00511158f, 0.04394663f, -0.02975539f, 0.02156088f, 
    0.04624167f, 0.03033173f, 0.03398104f, -0.07850991f, -0.04351916f, 0.02366703f, 0.01793641f, -0.06682106f, 
    -0.03898308f, 0.05312055f, -0.06304195f, -0.02667532f, -0.02596413f, -0.06493173f, 0.02251607f, -0.03648506f, 
    0.04037641f, 0.04412769f, -0.03556506f, -0.07387898f, 0.02762840f, 0.05297608f, 0.01779003f, -0.05374976f, 
    0.04914407f, 0.05516857f, -0.07026810f, -0.01339140f, -0.05871668f, -0.01051861f, -0.02748371f, -0.03787963f, 
    -0.00773549f, 0.01875886f, -0.00738650f, -0.04817303f, 0.04001366f, -0.03968815f, 0.01179537f, 0.05132770f, 
    0.03327538f, -0.06468740f, 0.01676871f, -0.01099365f, 0.05341318f, 0.03832895f, -0.04785018f, -0.00814309f, 
    -0.06801505f, -0.03297726f, -0.06723159f, -0.07340352f, 0.04830011f, -0.01796313f, -0.02429333f, -0.06227965f, 
    0.02658542f, 0.00826155f, -0.01970061f, 0.03937504f, 0.01840315f, 0.06195854f, -0.02623574f, -0.05001797f, 
    -0.03977303f, -0.03277963f, -0.05604738f, 0.06800848f, 0.03439965f, 0.06176229f, 0.03342178f, 0.00417635f, 
    -0.04094749f, -0.07485758f, -0.07334161f, 0.05540221f, -0.06847747f, -0.05893362f, -0.06643688f, 0.01726686f, 
    -0.05491069f, -0.04431432f, -0.00863916f, -0.02544362f, 0.02570254f, -0.06006047f, -0.07640707f, 0.02770190f, 
    -0.03575192f, -0.03421401f, -0.04110068f, 0.01547687f, 0.03361701f, -0.03409272f, -0.00557700f, 0.03671209f, 
    0.01857404f, -0.01328636f, -0.00199868f, -0.03773872f, 0.03821517f, -0.00106806f, -0.04577628f, -0.04189348f, 
    -0.06877501f, 0.05918714f, -0.05657227f, 0.00387845f, -0.06917463f, -0.05083608f, 0.02598633f, -0.01190968f, 
    0.00909894f, 0.03092942f, -0.05980481f, -0.03314070f, 0.02404573f, -0.02578431f, 0.04811534f, 0.02793868f, 
    -0.02927668f, -0.03531733f, -0.01732729f, 0.02126865f, -0.07177860f, 0.04153818f, -0.02478220f, -0.03571863f, 
    -0.00632330f, -0.07136690f, 0.05229022f, -0.01412892f, -0.03129860f, 0.01683952f, -0.05578398f, -0.06842010f, 
    0.01156200f, -0.05542691f, 0.06403717f, 0.06120335f, -0.04315904f, 0.01669909f, -0.06587607f, -0.02425192f, 
    0.02630394f, 0.02412629f, 0.00874755f, -0.01876436f, -0.06903967f, -0.01915002f, 0.04181753f, -0.06608971f, 
    0.01948496f, -0.07826061f, 0.03179992f, 0.06183365f, 0.01018919f, -0.06645232f, 0.02496340f, 0.01818122f, 
    0.07490483f, 0.19099395f, 0.09675716f, 0.17375527f, 0.10402998f, 0.09295459f, 0.04716172f, 0.03037077f, 
    -0.01784604f, -0.07813181f, -0.19975832f, -0.09650299f, -0.11742534f, -0.20635079f, -0.25242466f, -0.26055977f, 
    -0.05167706f, -0.04779049f, -0.09554657f, 0.03663849f, -0.07267070f, 0.06295206f, 0.04085129f, -0.08376556f, 
    0.56255960f, 0.03512942f, 0.05559775f, -0.10691748f, -0.01458535f, -0.07914601f, -0.06236642f, 0.13411283f, 
    -0.04817447f, 0.01066561f, -0.01140997f, 0.02999337f, 0.20389152f, -0.05500867f, -0.09117237f, 0.25319114f, 
    -0.15927269f, 0.01626750f, 0.04521435f, -0.11201641f, -0.02872294f, 0.02716015f, 0.01922234f, 0.02151440f, 
    -0.49292740f, -0.29940537f, 0.01201088f, -0.05063617f, 0.21805492f, 0.18592332f, 0.03413095f, 0.06164848f, 
    0.17103575f, -0.08521717f, 0.07583661f, -0.03116278f, 0.03734906f, -0.18327460f, -0.00362947f, 0.05320786f, 
    0.04033152f, 0.13996324f, 0.11098313f, 0.22898890f, -0.01860366f, 0.09473621f, 0.02995529f, 0.05411443f, 
    -0.02708976f, -0.13607837f, -0.19889228f, -0.12652119f, -0.01269874f, -0.07714318f, -0.17723517f, -0.04920676f, 
    -0.01178385f, 0.04384639f, -0.06377897f, -0.06102078f, -0.02821088f, -0.16354977f, 0.01886637f, -0.14690544f, 
    0.09060059f, 0.04973381f, -0.09438939f, 0.12646164f, -0.05162987f, -0.01633612f, 0.05713457f, 0.05672180f, 
    0.20659979f, 0.01857912f, -0.00686561f, 0.07840374f, 0.04408993f, -0.03816430f, -0.06623231f, 0.01470615f, 
    0.09394274f, -0.03461676f, 0.18032473f, -0.09487861f, 0.38984111f, -0.03386480f, 0.18295246f, 0.09225918f, 
    -0.08640882f, -0.06410731f, -0.10086153f, 0.04273450f, 0.00621496f, -0.02271446f, 0.10372012f, -0.06478874f, 
    0.26872003f, 0.32864118f, 0.27750558f, 0.17672743f, -0.01849992f, -0.07859810f, -0.02719608f, 0.01123885f, 
    -0.00579724f, 0.08705964f, 0.04387935f, -0.04210345f, -0.18367828f, 0.08335522f, -0.06373502f, -0.02310473f, 
    -0.13046862f, 0.15719718f, -0.00806048f, 0.04819890f, -0.02877671f, -0.14582103f, 0.05286863f, -0.18691300f, 
    0.14244801f, 0.27212179f, 0.22052537f, -0.11628908f, 0.08776932f, 0.03754441f, 0.07609811f, -0.08064894f, 
    0.03882514f, 0.03710797f, 0.14824200f, -0.01013513f, -0.26704293f, -0.24118511f, -0.13785946f, 0.09510001f, 
    -0.11204313f, -0.18229452f, 0.03835810f, -0.12165547f, 0.04099725f, -0.04804445f, 0.09099079f, -0.08603571f, 
    0.06410061f, 0.13919123f, 0.04399907f, 0.08527564f, 0.07612739f, 0.07348061f, 0.06705309f, 0.08524724f, 
    -0.03867305f, 0.02433112f, 0.06598957f, -0.10570206f, -0.16412379f, -0.20389748f, 0.01589408f, 0.33630034f, 
    -0.12807232f, -0.05555744f, -0.12225827f, 0.03066831f, 0.13578729f, -0.02578317f, 0.12023728f, 0.18914019f, 
    0.04580757f, 0.12808684f, 0.03793032f, 0.11712565f, 0.05041841f, 0.04195299f, 0.00133445f, -0.03087071f, 
    -0.01049203f, 0.07856283f, -0.01628258f, 0.10001598f, -0.10271272f, -0.13915424f, -0.03796949f, -0.11471112f, 
    -0.08216371f, -0.08256955f, 0.01981472f, 0.05578096f, 0.06691680f, -0.15925203f, -0.00548059f, -0.09912416f, 
    0.30520025f, 0.38042834f, 0.24842176f, 0.20380172f, -0.03024769f, -0.12206301f, 0.07205354f, 0.00390712f, 
    -0.08145509f, -0.04461256f, 0.05012473f, 0.04084095f, 0.38189253f, 0.07069309f, -0.04597217f, 0.11542819f, 
    -0.18703787f, -0.17180200f, 0.04229624f, -0.06662922f, 0.02257359f, -0.09492084f, 0.01044351f, -0.05708788f, 
    -0.29660746f, 0.14061587f, -0.09138343f, -0.59110463f, -0.00950859f, 0.29342097f, 0.08637708f, 0.21586931f, 
    0.09062289f, -0.15190829f, -0.11586677f, -0.01912208f, -0.14611356f, 0.03415067f, -0.02595314f, -0.09363483f, 
    -0.03370228f, -0.01238921f, -0.14500365f, -0.04106827f, -0.26998657f, -0.17558603f, 0.02331762f, -0.20008913f, 
    -0.33092967f, -0.56223416f, -0.58134300f, -0.17329615f, 0.07075764f, 0.00746804f, -0.04333460f, 0.04963166f, 
    -0.08571847f, -0.08155004f, 0.01202435f, 0.05376637f, 0.04068204f, 0.08811897f, -0.10885368f, -0.11680180f, 
    0.12365885f, 0.08271433f, -0.09863622f, 0.09951888f, -0.04551597f, -0.05088374f, -0.08216581f, 0.10746994f, 
    0.14123447f, 0.06666481f, 0.09395707f, 0.11043540f, -0.07328679f, 0.03779698f, -0.05726954f, -0.04819068f, 
    0.17540725f, 0.03003572f, 0.10116299f, 0.11501271f, 0.00271420f, 0.04536710f, -0.01736261f, 0.11152528f, 
    -0.07276565f, -0.10174100f, 0.01999195f, 0.07911664f, 0.08543091f, 0.00540888f, 0.02087096f, 0.00234647f, 
    0.24340361f, 0.16063619f, 0.16823906f, 0.23968619f, -0.01594832f, -0.06061896f, -0.02486746f, -0.06346087f, 
    0.06583778f, -0.03933767f, 0.03210309f, 0.01606435f, -0.02538951f, 0.05471277f, 0.05357862f, 0.01254257f, 
    0.02531910f, 0.17049888f, -0.07523458f, 0.07009786f, 0.03517222f, -0.05287131f, -0.01534537f, 0.03922282f, 
    -0.06382434f, 0.13139586f, 0.25180581f, 0.05977745f, -0.05026132f, 0.07628412f, 0.04738404f, 0.01398160f, 
    0.00555601f, 0.08358586f, 0.08206459f, -0.05316854f, -0.30216673f, -0.23023757f, -0.46307260f, -0.27668336f, 
    0.22439793f, -0.04401715f, -0.23802504f, -0.17485236f, 0.00991846f, 0.04281311f, 0.10768482f, 0.07598248f, 
    0.16429141f, 0.02867445f, 0.05083512f, -0.00289881f, 0.11411971f, -0.04053085f, -0.06274173f, -0.04623608f, 
    0.13711780f, 0.15313670f, 0.03179137f, -0.12047802f, 0.09507180f, 0.17710815f, 0.13416107f, -0.17664807f, 
    0.09736841f, -0.18231457f, 0.16828667f, 0.26002759f, -0.00698040f, -0.00487538f, 0.11991578f, -0.00781546f, 
    -0.15497489f, -0.18828404f, -0.07310168f, 0.28224364f, -0.08079432f, 0.07357582f, -0.03250898f, -0.24282505f, 
    0.03740555f, 0.07339332f, -0.06991897f, -0.01320455f, 0.01101950f, 0.12717842f, 0.30106437f, 0.24658747f, 
    -0.15785073f, -0.07634866f, 0.01469620f, -0.02143085f, 0.02218430f, -0.08102801f, -0.00897438f, -0.16119014f, 
    0.15533179f, -0.10411414f, 0.04097771f, 0.11118358f, -0.12251110f, 0.10858691f, 0.04906861f, -0.00015779f, 
    -0.00362053f, -0.01270710f, -0.07797860f, -0.10118291f, 0.26817667f, -0.03094522f, -0.18642798f, -0.03400186f, 
    0.08445608f, -0.01976863f, 0.14747469f, 0.07023098f, -0.00632132f, -0.09145799f, -0.25825655f, -0.05914981f, 
    0.01219011f, 0.21879204f, -0.11768527f, 0.08385224f, 0.04979043f, 0.02284254f, -0.07882909f, 0.08843350f, 
    0.12654410f, 0.10767744f, 0.02310769f, 0.00745612f, 0.17397325f, 0.15612769f, -0.07828670f, -0.05649463f, 
    -0.03249032f, 0.07560351f, -0.11842089f, 0.04238265f, 0.16944252f, 0.13370392f, 0.15803257f, 0.21079665f, 
    0.01614867f, 0.26127627f, 0.14157680f, 0.02237808f, 0.04407702f, 0.11993065f, 0.09263076f, -0.06291104f, 
    -0.04984149f, 0.01713804f, -0.14498293f, -0.03066246f, 0.01508160f, 0.25667676f, -0.06261447f, 0.02588335f, 
    0.12018242f, 0.17613292f, 0.05625203f, 0.01451484f, 0.03219595f, -0.04967062f, -0.06231872f, -0.00792689f, 
    0.01187700f, -0.16824213f, -0.05191213f, 0.05801446f, -0.04552041f, -0.08897359f, -0.12020978f, 0.03566035f, 
    0.21125276f, 0.10388751f, 0.14834812f, 0.17555180f, -0.07816046f, -0.06474780f, -0.33111188f, 0.11905781f, 
    0.04596850f, 0.08247771f, 0.08861290f, -0.16904265f, 0.03341461f, 0.03751312f, -0.05865716f, -0.02012226f, 
    -0.11902522f, -0.21752813f, -0.03318878f, 0.05643602f, 0.12162326f, 0.09017377f, 0.15693785f, -0.06024938f, 
    0.04699324f, -0.00048635f, -0.14858060f, -0.08920183f, -0.03825007f, 0.07886695f, 0.00232355f, 0.01271548f, 
    0.15688884f, -0.05684077f, -0.03695538f, -0.09799833f, 0.15766668f, -0.11282282f, -0.25917548f, 0.05411595f, 
    0.01263642f, -0.15127794f, 0.28778103f, 0.39483425f, 0.08186996f, -0.13030741f, 0.04179849f, 0.01907486f, 
    0.02406585f, 0.01996950f, -0.12360109f, 0.04149174f, -0.14532746f, 0.24580057f, 0.16941440f, -0.04923850f, 
    0.14939699f, 0.03751693f, -0.09311897f, 0.02671897f, 0.03437782f, 0.02183649f, 0.06221034f, 0.26920158f, 
    0.24610698f, -0.06252556f, -0.24751672f, -0.41900256f, 0.09895210f, 0.14897922f, -0.10489953f, -0.09390698f, 
    0.20522037f, 0.01320735f, -0.09419268f, -0.07540275f, 0.07348882f, 0.26680017f, 0.10401115f, -0.11132064f, 
    0.10230314f, -0.03090539f, 0.07229330f, 0.04806713f, 0.04830748f, 0.14345506f, 0.08342230f, 0.06772353f, 
    0.20355481f, -0.04092368f, 0.04834386f, 0.06106890f, 0.05514134f, 0.07173997f, -0.01050750f, -0.05591753f, 
    0.09560989f, -0.10949513f, 0.09940368f, 0.02731833f, -0.42841291f, -0.12682150f, -0.35988384f, -0.03752157f, 
    0.05095128f, -0.04187508f, -0.09869968f, 0.00384717f, 0.09600316f, 0.03363809f, -0.15068957f, -0.02601977f, 
    0.50520205f, 0.04497923f, -0.18564034f, 0.03156007f, -0.06118036f, 0.03601808f, -0.05847045f, 0.02124838f, 
    0.03985586f, -0.15189281f, -0.11211060f, 0.01795494f, -0.12999588f, 0.11482172f, -0.25950381f, 0.09712174f, 
    0.07130978f, -0.03406219f, -0.07994307f, -0.12508604f, -0.01734043f, -0.04494848f, -0.11120648f, 0.16020684f, 
    0.15812965f, 0.04631071f, 0.34811208f, -0.03014678f, 0.03716831f, -0.01533768f, 0.14953026f, 0.01842511f, 
    0.15436761f, -0.10636111f, -0.00178068f, 0.04886952f, -0.17669243f, -0.05847682f, -0.10477921f, -0.01676429f, 
    0.05800569f, -0.01511206f, 0.14428616f, 0.07340584f, 0.01627320f, -0.05451949f, -0.00980876f, -0.05467081f, 
    0.14714296f, 0.29933003f, -0.14446726f, -0.23830257f, -0.00240496f, 0.11567813f, 0.02288321f, 0.15680557f, 
    -0.04269761f, 0.00582618f, 0.00654570f, 0.00790104f, 0.09162681f, 0.25995260f, 0.11078302f, -0.11509887f, 
    0.10763106f, -0.03106865f, 0.21222141f, 0.04040027f, 0.04851688f, 0.00999734f, 0.06111220f, -0.02928002f, 
    -0.16296114f, 0.10107604f, -0.24196976f, 0.21228425f, -0.08983259f, -0.03570545f, -0.13993287f, -0.09893908f, 
    0.05764651f, 0.00826333f, 0.20139706f, 0.01590073f, 0.14490405f, 0.09547582f, 0.15491529f, 0.06970149f, 
    0.10548531f, 0.15348643f, 0.08169118f, -0.03069608f, -0.05683616f, 0.05873596f, 0.18086946f, -0.08870944f, 
    0.08612699f, -0.01920913f, 0.00256159f, 0.22564632f, 0.01174190f, -0.00723529f, 0.05789772f, 0.01042320f, 
    -0.09915499f, 0.04090466f, -0.06414707f, -0.07923601f, -0.20533937f, -0.17041606f, 0.01661819f, 0.13403057f, 
    -0.09598058f, 0.12511410f, -0.02867857f, -0.11255679f, 0.02019913f, -0.17196386f, 0.03471068f, 0.10895608f, 
    -0.08590993f, -0.13407561f, 0.20465221f, 0.30512971f, -0.07787644f, -0.07620283f, -0.13278867f, -0.04575088f, 
    0.03390185f, -0.04509684f, -0.03196841f, 0.00463463f, -0.08282734f, 0.28994635f, 0.11176994f, -0.21931788f, 
    0.07952304f, 0.02610225f, 0.11181362f, 0.03476286f, -0.00119593f, -0.04572587f, 0.00439429f, -0.06795883f, 
    0.07009198f, -0.12087207f, 0.07310336f, 0.02918097f, 0.00650946f, 0.16314285f, -0.07137023f, 0.03891869f, 
    -0.08711613f, 0.09814628f, -0.08528873f, -0.00668102f, 0.18235590f, 0.26740590f, 0.12285742f, -0.05929535f, 
    -0.13199550f, -0.09134525f, 0.11153938f, 0.07517476f, -0.01131417f, -0.03189114f, 0.03779712f, 0.03127979f, 
    0.10272347f, -0.07806790f, 0.01778220f, -0.15547647f, 0.04685502f, 0.01947124f, 0.05166183f, 0.07365450f, 
    0.16029045f, -0.09711713f, 0.00475525f, 0.07256886f, 0.17155002f, -0.21596633f, -0.28281739f, -0.00082131f, 
    0.10111452f, 0.05853177f, 0.08480948f, 0.06605274f, 0.12563562f, 0.28521842f, -0.07277502f, 0.04611934f, 
    -0.08186232f, 0.11349629f, 0.10642904f, -0.05200106f, 0.01243005f, 0.04241062f, 0.09309470f, 0.08360521f, 
    0.07583236f, -0.02818325f, 0.11146013f, -0.07240845f, -0.23318601f, 0.20254290f, 0.15824269f, 0.39660403f, 
    0.16054353f, 0.04746272f, -0.17743176f, 0.11993982f, 0.07252426f, -0.00429979f, 0.00476109f, -0.03885861f, 
    0.52996504f, -0.15472290f, 0.15757830f, 0.04516875f, 0.07451337f, -0.11178473f, 0.00577013f, -0.09346722f, 
    -0.12048271f, -0.03046337f, -0.03956098f, 0.07223686f, -0.27664340f, -0.23968063f, -0.12540384f, 0.15687910f, 
    0.06411755f, 0.01327343f, 0.13175425f, 0.06445932f, 0.10143982f, -0.00246950f, 0.04681902f, -0.29586032f, 
    -0.06068399f, 0.05842378f, -0.29171461f, -0.07311259f, -0.02177299f, -0.13267511f, -0.20815255f, -0.12719226f, 
    -0.04296477f, -0.12454681f, 0.10011323f, 0.11297822f, 0.14064921f, 0.09365016f, 0.18735982f, 0.10088935f, 
    -0.08317284f, 0.00012781f, 0.00054316f, -0.00541568f, 0.00741199f, 0.07843938f, 0.13009463f, -0.07678925f, 
    -0.00735493f, 0.15406561f, 0.08115449f, -0.16981833f, -0.01408149f, 0.02855714f, -0.04929573f, 0.04300436f, 
    0.07492925f, -0.11339607f, 0.06115726f, -0.00917937f, -0.14747575f, 0.02313670f, 0.18942751f, 0.04638835f, 
    0.04305650f, 0.16758583f, 0.05090312f, -0.00501818f, -0.06132173f, -0.00882543f, 0.01240418f, -0.11633976f, 
    0.05389337f, 0.09088197f, -0.06447234f, 0.02711252f, 0.02373056f, 0.01448008f, 0.04926295f, 0.01165903f, 
    0.01123339f, -0.01528517f, -0.06591891f, 0.01753637f, 0.16628146f, -0.04993956f, 0.06371707f, -0.07407055f, 
    -0.03810756f, -0.17430338f, 0.11367987f, -0.08387189f, 0.02424322f, 0.09153602f, -0.00599443f, 0.04656758f, 
    0.49840263f, -0.00556775f, -0.08566720f, -0.41109225f, 0.09897060f, -0.16875134f, 0.06082229f, -0.00183272f, 
    0.04210452f, 0.12759233f, -0.02124673f, 0.04334543f, -0.11302800f, 0.09495879f, -0.01499799f, -0.28820521f, 
    0.05779841f, 0.01249905f, 0.08925717f, -0.08843403f, -0.15485765f, -0.07311750f, 0.06915245f, 0.14666544f, 
    -0.13163655f, -0.03539999f, 0.04961152f, 0.15291682f, 0.02563446f, 0.17064135f, -0.10797461f, 0.11956287f, 
    0.14629872f, -0.03937261f, 0.08557924f, 0.15272653f, -0.05082697f, 0.15923528f, 0.11655505f, 0.08953060f, 
    0.19235824f, -0.01670285f, -0.00838234f, -0.19288491f, 0.01434659f, 0.04864495f, -0.06204164f, -0.07006592f, 
    -0.07251523f, -0.04963051f, -0.01080910f, -0.04965184f, -0.02591150f, -0.06167296f, 0.05273468f, 0.02345965f, 
    -0.04399471f, -0.02910352f, -0.02389088f, 0.00470495f, 0.03174669f, 0.00033326f, -0.00870907f, 0.00750675f, 
    0.05875775f, 0.02518631f, 0.05622978f, 0.02381220f, -0.03726041f, -0.05201666f, -0.06249992f, -0.07307620f, 
    -0.02686747f, 0.02343565f, -0.00541968f, 0.00373839f, 0.05178624f, -0.06296158f, -0.06771915f, -0.07030249f, 
    -0.01351716f, -0.00972674f, -0.04222705f, -0.03671140f, 0.02196219f, -0.06660248f, 0.01734085f, 0.01215165f, 
    -0.07773844f, -0.05703881f, -0.03136464f, -0.03741091f, -0.01207836f, -0.03020589f, -0.01680277f, 0.04660393f, 
    -0.03968303f, -0.00543523f, -0.06330336f, -0.03867373f, 0.04695560f, 0.05937164f, 0.05329492f, 0.05111346f, 
    -0.07796536f, -0.00718782f, -0.04196912f, -0.01750914f, -0.06261569f, -0.00147712f, -0.02810216f, 0.06034599f, 
    0.03988098f, 0.01795462f, -0.03780292f, 0.05584402f, 0.02720579f, 0.02142915f, -0.00798517f, 0.03089454f, 
    0.05039205f, -0.06419474f, -0.04132866f, 0.04713232f, -0.01808323f, -0.03901798f, -0.04681232f, 0.00496603f, 
    0.02492443f, -0.07593591f, -0.04784766f, 0.01076451f, 0.02189442f, -0.04863483f, -0.04055441f, 0.05580005f, 
    0.00154841f, 0.01543238f, -0.03248476f, -0.03669230f, -0.05360087f, -0.01181012f, 0.03254092f, 0.01008838f, 
    -0.00220077f, -0.03674762f, -0.06786316f, -0.04663094f, -0.04819358f, -0.03221213f, -0.04866842f, 0.04877520f, 
    -0.06371500f, 0.01585082f, 0.02314867f, -0.01734914f, 0.02779804f, -0.06041862f, 0.00411669f, 0.03546130f, 
    0.04143401f, -0.02733427f, 0.02927237f, -0.02454994f, -0.00314926f, -0.06136584f, -0.08086485f, 0.05712792f, 
    0.00692050f, -0.06140634f, 0.03415003f, -0.04309560f, -0.07654193f, -0.07413414f, 0.02500060f, -0.00200518f, 
    -0.09462637f, -0.05314380f, -0.02407842f, 0.02964479f, -0.05231581f, -0.07460292f, -0.03382513f, -0.07179707f, 
    -0.03997874f, -0.04916363f, -0.02103342f, 0.00174077f, -0.04746363f, -0.07040965f, -0.04251563f, -0.01106004f, 
    -0.05831080f, 0.01315945f, 0.04382973f, 0.02441051f, 0.06275599f, -0.04864817f, -0.03732898f, 0.02527002f, 
    -0.03164282f, 0.02731470f, 0.00365783f, 0.02002190f, -0.04065675f, 0.02150463f, -0.00227418f, 0.02256246f, 
    0.00490788f, -0.01699444f, 0.05602780f, -0.03795361f, 0.00962783f, 0.05175806f, 0.00291080f, 0.01485584f, 
    0.05150477f, -0.05662888f, -0.03799036f, -0.08372080f, 0.04772595f, -0.06321844f, 0.06026320f, 0.05667762f, 
    -0.05054736f, -0.04846070f, -0.01493697f, -0.01789242f, -0.04473802f, 0.04921252f, 0.03022251f, -0.01533931f, 
    -0.01735829f, -0.05725685f, 0.01454775f, 0.00113020f, 0.05970590f, 0.01903261f, -0.04718958f, -0.02205250f, 
    0.00730528f, -0.04773200f, 0.02387924f, -0.05562601f, -0.04445320f, -0.07434715f, 0.01748660f, 0.03026996f, 
    -0.01543681f, 0.04427834f, -0.04888178f, -0.00947345f, -0.06490244f, -0.04097069f, 0.04818957f, -0.03297630f, 
    -0.01192908f, -0.06905641f, 0.03594161f, -0.03440796f, -0.05422946f, -0.01485920f, -0.05301290f, -0.00497020f, 
    -0.07133090f, -0.06994447f, -0.00477083f, 0.05301804f, 0.05612754f, -0.00561621f, -0.04520581f, -0.06948737f, 
    -0.03597261f, -0.03117874f, -0.02448558f, 0.02225323f, -0.04984432f, 0.04750706f, -0.03804583f, -0.04671987f, 
    -0.02330542f, -0.00073915f, -0.05083419f, -0.03426906f, 0.05495534f, 0.05374093f, 0.04019475f, -0.05191117f, 
    -0.06502040f, 0.05390204f, -0.01058503f, 0.03375987f, 0.00186059f, -0.03226008f, -0.07765763f, -0.00224911f, 
    -0.07813007f, 0.02572699f, -0.05924512f, -0.04146467f, -0.00948689f, 0.03874657f, 0.03213735f, 0.03286052f, 
    -0.01750016f, -0.03356705f, 0.02803698f, 0.00829424f, -0.05928189f, -0.00451788f, 0.05722067f, -0.02207741f, 
    0.06150224f, 0.03679033f, -0.04364527f, -0.04619019f, -0.04675541f, -0.04718585f, -0.05589745f, 0.05403069f, 
    -0.05183212f, -0.03068677f, -0.05843438f, 0.02882769f, 0.03657480f, -0.07750651f, -0.01434462f, -0.04582880f, 
    0.01121532f, -0.02256522f, 0.04516959f, -0.06631161f, -0.02863484f, 0.00126599f, -0.06975539f, 0.00834983f, 
    0.03340086f, 0.00077245f, 0.03250027f, -0.01180358f, 0.06005915f, -0.05644333f, 0.06352136f, 0.05048753f, 
    0.05295511f, -0.01454562f, -0.05828940f, 0.05632393f, 0.04653709f, -0.05274986f, 0.01636329f, -0.07593762f, 
    -0.05776503f, 0.02172941f, -0.03101365f, 0.03173440f, 0.04819362f, -0.03821406f, -0.06709834f, 0.02219245f, 
    0.03545129f, -0.02029521f, 0.02984311f, 0.00515200f, -0.03593389f, -0.03349596f, 0.00291432f, 0.04113420f, 
    -0.03458516f, 0.04151581f, -0.06301200f, -0.01724163f, 0.03741681f, -0.04707211f, 0.00519643f, 0.03337219f, 
    0.01196225f, -0.00456557f, -0.05771039f, 0.04195063f, -0.07051101f, -0.06398716f, 0.00260513f, -0.04057920f, 
    0.01439411f, 0.00286365f, -0.05466976f, -0.01127177f, 0.02921868f, 0.05195868f, -0.02091139f, 0.06519892f, 
    -0.05030471f, -0.01611201f, 0.02844614f, 0.05785595f, 0.01653803f, 0.06371822f, -0.00249382f, -0.06338234f, 
    -0.05007959f, 0.02704894f, 0.01606597f, -0.05820127f, -0.03902357f, -0.00375326f, 0.02855890f, 0.05406073f, 
    -0.03167642f, 0.02797179f, -0.00516771f, -0.00965523f, -0.05821676f, 0.02497776f, 0.06484715f, -0.04460366f, 
    -0.00443430f, -0.04216814f, -0.03347653f, -0.03168721f, -0.03508925f, 0.00087862f, 0.05657816f, 0.02715849f, 
    0.00157250f, 0.06544264f, -0.06537367f, -0.06332053f, -0.00702677f, 0.05432674f, -0.06405356f, 0.01583085f, 
    0.00965239f, 0.02722194f, 0.01675750f, 0.14357308f, 0.00696937f, -0.04240208f, -0.03670328f, 0.02014082f, 
    0.03504115f, -0.02288999f, -0.13544111f, 0.05346388f, -0.30050245f, -0.12268789f, -0.03857258f, -0.15673515f, 
    -0.04334034f, -0.13612355f, -0.03302635f, -0.14331962f, -0.02534216f, 0.04179349f, 0.08841466f, -0.00639719f, 
    0.55685294f, 0.12306137f, 0.11948742f, -0.11672122f, 0.01499982f, 0.08181908f, 0.04817427f, 0.03912232f, 
    -0.12796876f, -0.03468409f, 0.03198136f, -0.00982230f, 0.29317167f, -0.16431575f, -0.08822248f, -0.02468733f, 
    0.08679156f, -0.02202570f, 0.03420367f, -0.05054107f, -0.05854325f, -0.01786642f, -0.13206902f, -0.01081252f, 
    -0.60529339f, -0.00124069f, -0.10255145f, -0.06994057f, 0.09835521f, 0.15559377f, 0.00411094f, 0.00382993f, 
    0.24959829f, -0.09694982f, 0.04400471f, -0.06293411f, 0.25037059f, -0.08929110f, 0.06008646f, 0.17529672f, 
    0.04348166f, -0.04104679f, 0.13605392f, 0.16437528f, -0.02164257f, 0.12202653f, 0.13341480f, 0.06666821f, 
    -0.14967002f, -0.31839710f, -0.29721719f, -0.32406008f, 0.14826627f, -0.25777727f, -0.27155301f, -0.04153360f, 
    -0.00541215f, 0.02445218f, -0.08576423f, -0.05881635f, 0.06473334f, 0.07931454f, -0.02637144f, -0.13853915f, 
    0.12350474f, 0.00033609f, 0.01799226f, 0.00976067f, -0.05385891f, -0.08374745f, -0.06939029f, -0.09840637f, 
    0.19505674f, 0.06003045f, 0.08378229f, 0.12579943f, 0.05860280f, -0.05908126f, -0.13441528f, 0.05722740f, 
    0.02969691f, 0.03327930f, 0.31186965f, -0.02292930f, 0.45575854f, -0.05060419f, -0.01951598f, 0.12952863f, 
    0.01001047f, 0.09332991f, 0.15119624f, -0.00849404f, 0.04443933f, 0.07889364f, -0.01790913f, -0.02873801f, 
    0.27560058f, 0.21475089f, 0.11128569f, 0.09001868f, -0.02839158f, 0.00265467f, -0.06319306f, -0.09311195f, 
    -0.06220242f, 0.01895584f, -0.09231138f, 0.01501707f, -0.16418549f, -0.06250302f, -0.03431609f, 0.05258159f, 
    -0.02403144f, 0.05105633f, -0.07638557f, 0.04420414f, -0.12038931f, -0.09174305f, -0.03023867f, -0.03239700f, 
    -0.00511697f, 0.18608585f, 0.33246458f, 0.01360321f, -0.01995879f, 0.09448852f, 0.04369606f, -0.03261524f, 
    -0.02183017f, 0.20257643f, 0.11419991f, 0.04888508f, -0.37984413f, -0.29694134f, -0.29941070f, -0.13719952f, 
    -0.12768245f, -0.01135886f, 0.04299059f, -0.09837372f, 0.02487235f, -0.01410126f, 0.30877388f, -0.00602992f, 
    0.08576343f, 0.07929674f, 0.04843132f, 0.18239875f, 0.02437320f, -0.13387355f, 0.08030408f, 0.07992596f, 
    0.09616549f, 0.05341503f, -0.07725795f, -0.13985007f, 0.16965853f, -0.14019552f, 0.06099764f, 0.14703199f, 
    -0.13550271f, -0.04914131f, 0.11607288f, 0.03387265f, 0.13837256f, 0.06100640f, 0.14525793f, 0.01919753f, 
    0.06061967f, -0.01455324f, 0.20822631f, -0.03085993f, 0.09807136f, -0.15978582f, 0.01794132f, 0.12527089f, 
    -0.02784800f, 0.12905154f, -0.06148884f, 0.09719874f, 0.00192980f, -0.18367045f, 0.10053749f, 0.04971786f, 
    0.05700460f, 0.12074132f, 0.06939062f, 0.06371786f, -0.00036734f, 0.07176064f, -0.00991252f, -0.05486193f, 
    0.07357012f, 0.06178310f, 0.44376853f, 0.06107312f, -0.13147801f, -0.05534183f, -0.23600303f, 0.08022565f, 
    -0.19390513f, -0.04915372f, 0.01922921f, 0.04087614f, 0.06369197f, 0.09885006f, 0.36862907f, 0.10484618f, 
    -0.09235045f, -0.11983328f, -0.08690313f, -0.00607177f, -0.04402668f, -0.01730258f, 0.05655827f, -0.18163362f, 
    0.07401905f, -0.11689264f, -0.14352651f, 0.14562117f, 0.12946947f, -0.06191972f, 0.04195907f, -0.03996949f, 
    0.00972764f, -0.08159982f, 0.00167013f, -0.04447179f, -0.12995881f, -0.19575489f, 0.20944391f, 0.13058047f, 
    -0.03431597f, 0.08195123f, 0.01826224f, -0.07199731f, 0.13108006f, 0.17382497f, 0.11877488f, 0.05818377f, 
    -0.09043461f, -0.24007140f, 0.04268019f, 0.19596657f, 0.11850308f, -0.04111750f, -0.12132660f, -0.00698114f, 
    -0.13224295f, -0.13183883f, -0.19220071f, -0.06655892f, 0.40259078f, 0.06156864f, -0.05919633f, 0.03606261f, 
    0.00569102f, 0.12219939f, -0.03203944f, 0.08141777f, 0.03222080f, -0.03319051f, -0.19472255f, 0.05334140f, 
    0.00607531f, 0.10848548f, -0.04764779f, -0.03454819f, 0.04124935f, 0.10598435f, -0.01634703f, 0.08509929f, 
    -0.13765030f, 0.20702419f, 0.09198055f, 0.11201400f, 0.03332270f, 0.14474051f, 0.19472267f, -0.02357792f, 
    -0.13867281f, -0.08271421f, -0.06073763f, 0.00979460f, 0.03633938f, -0.03146137f, -0.00022865f, 0.09165036f, 
    0.23150036f, 0.25066912f, 0.28902978f, -0.03113383f, -0.16467814f, -0.10559738f, -0.09739440f, -0.01349461f, 
    0.00030239f, 0.11860223f, 0.15997668f, -0.13745528f, -0.00069959f, 0.16804317f, -0.17800193f, -0.10485533f, 
    0.15424560f, 0.10221404f, -0.02310935f, 0.09136683f, -0.07017647f, 0.01777599f, -0.00143534f, 0.11513721f, 
    -0.23179388f, 0.40574053f, -0.40631637f, -0.39805862f, 0.20344934f, 0.06349924f, 0.19902463f, -0.15660745f, 
    0.04060162f, 0.06281631f, 0.03954853f, -0.01731692f, -0.05315905f, -0.17713174f, -0.09059037f, 0.05042121f, 
    -0.03030973f, 0.00454443f, 0.10878672f, 0.06735274f, -0.00317940f, 0.01700614f, 0.07660580f, 0.01262986f, 
    -0.23470972f, 0.03429767f, 0.11346899f, 0.15706046f, 0.03218048f, -0.09494978f, 0.28669184f, 0.03540312f, 
    -0.00929380f, 0.14290880f, 0.23556131f, 0.08537403f, -0.11630992f, -0.26759553f, 0.01315587f, 0.14142725f, 
    0.02432078f, 0.09761376f, 0.00548959f, -0.01230200f, -0.02286011f, -0.01721294f, 0.13533540f, 0.00906297f, 
    -0.10238350f, 0.03994513f, -0.15430655f, -0.08452471f, -0.06961310f, 0.01575112f, -0.09231253f, 0.01817937f, 
    0.06789357f, -0.01850753f, 0.09465291f, 0.01293144f, 0.08998356f, 0.24506482f, 0.02901111f, -0.07585505f, 
    -0.00000993f, -0.02787632f, -0.05229136f, 0.13919023f, -0.00546379f, -0.00529318f, 0.04870249f, -0.10065127f, 
    -0.31800097f, -0.03517705f, -0.38543305f, 0.08108711f, -0.01188320f, -0.00974536f, 0.03344982f, 0.01221530f, 
    0.01898393f, -0.02402510f, 0.03348720f, 0.06929045f, 0.09670812f, -0.07590286f, -0.13552424f, 0.12955061f, 
    -0.03521603f, -0.00746992f, -0.08331055f, -0.06088610f, 0.03539321f, 0.02107969f, -0.02467815f, 0.10167924f, 
    -0.27253339f, 0.17024849f, 0.12439038f, -0.16278245f, -0.06161878f, 0.21880701f, 0.18393861f, 0.11431950f, 
    0.09855603f, -0.08557113f, 0.01457786f, -0.08156676f, 0.00158962f, 0.02068624f, -0.00855219f, -0.13176809f, 
    0.08912002f, 0.04348032f, -0.06750655f, 0.01667377f, -0.09484585f, -0.02731417f, 0.00353750f, 0.04943921f, 
    0.28320283f, 0.32250655f, 0.16905922f, 0.10106685f, 0.10891720f, 0.10234793f, 0.24833719f, 0.14616159f, 
    0.05309818f, -0.03899666f, 0.02728330f, -0.04409529f, 0.00738475f, 0.26812941f, 0.17046735f, 0.02234743f, 
    0.00049979f, 0.03855043f, 0.10685567f, 0.09419608f, -0.09039600f, -0.01747392f, -0.00190172f, -0.03535241f, 
    -0.04951262f, -0.02281734f, -0.09033149f, -0.10077818f, 0.04578742f, 0.04866241f, 0.10326610f, 0.09937819f, 
    0.04877110f, 0.05712459f, 0.11099223f, 0.04145053f, -0.08047047f, -0.19013083f, -0.24923702f, 0.01096113f, 
    0.03733348f, -0.00732133f, -0.14876036f, 0.01864653f, 0.05290391f, 0.06157204f, 0.04537087f, 0.04124261f, 
    -0.07060449f, -0.07134065f, -0.22096279f, 0.06054943f, -0.10836436f, -0.03337628f, 0.03844227f, 0.03443842f, 
    0.09391413f, -0.00288824f, -0.01996701f, 0.09108745f, 0.04896281f, 0.02390621f, -0.02608674f, 0.01878716f, 
    -0.26616094f, 0.19664371f, 0.01501547f, 0.06221613f, 0.10902779f, 0.04488209f, -0.07643323f, -0.06604370f, 
    -0.15036376f, -0.08577394f, 0.25074717f, -0.18521497f, -0.02265328f, 0.07206237f, -0.01085415f, -0.06968345f, 
    -0.07302056f, 0.10532868f, -0.02440433f, 0.16652524f, 0.29048598f, 0.24317549f, 0.15836208f, 0.07066149f, 
    -0.05633681f, -0.00623433f, -0.15086645f, 0.11754011f, 0.05908640f, -0.08631232f, -0.01458242f, 0.08156700f, 
    0.07476249f, 0.08172784f, -0.02431250f, -0.06763282f, -0.07940897f, 0.07595430f, -0.04529221f, -0.09803079f, 
    -0.07172848f, -0.13476482f, -0.05944008f, -0.06229982f, 0.08948601f, 0.25143078f, -0.03645721f, 0.16063958f, 
    -0.03254464f, -0.06916836f, 0.08322962f, 0.11151047f, 0.04348122f, 0.03658980f, -0.01362863f, 0.02267525f, 
    0.05371606f, -0.15206288f, 0.11794344f, 0.03844346f, 0.10042715f, -0.10342345f, 0.05302516f, -0.03559918f, 
    0.05660849f, -0.16621940f, 0.05159269f, -0.03167891f, 0.30832055f, -0.15196405f, -0.19745804f, -0.02352551f, 
    -0.04450883f, -0.06224334f, 0.05420259f, -0.00164498f, 0.18972263f, 0.09362073f, 0.05750323f, -0.06091146f, 
    0.29344618f, 0.12363587f, -0.29074758f, -0.23707856f, -0.05169571f, 0.00316599f, 0.04639823f, 0.04505049f, 
    0.04633494f, 0.00336870f, 0.02543459f, -0.09643815f, 0.04670113f, 0.10850400f, 0.04701354f, 0.22592869f, 
    0.26274583f, 0.07388487f, 0.03154729f, 0.09648526f, 0.07058349f, 0.05969704f, -0.02399904f, 0.02498945f, 
    -0.02713452f, -0.25938693f, -0.08684517f, 0.41500041f, -0.03264453f, 0.05251193f, -0.13571066f, -0.10445171f, 
    -0.04654251f, 0.12390767f, 0.01707554f, 0.07809933f, 0.15036745f, -0.19220582f, -0.10903399f, -0.01816549f, 
    -0.02278049f, 0.03260889f, -0.02472360f, 0.00660686f, -0.07719174f, -0.09734230f, -0.05551390f, -0.04930256f, 
    -0.13069038f, 0.16215269f, 0.16300067f, 0.08658241f, -0.01156634f, -0.06245938f, -0.07681199f, 0.03540359f, 
    -0.00261622f, 0.00307821f, 0.08593669f, -0.00491783f, -0.19937216f, 0.06047901f, 0.19640201f, 0.27798557f, 
    -0.00366468f, -0.06352826f, 0.02372271f, -0.05171188f, -0.00224631f, 0.01894408f, 0.01855109f, -0.03024103f, 
    0.24334012f, 0.17714630f, -0.01707576f, 0.02127695f, 0.07495241f, -0.02981383f, -0.00461251f, -0.02648373f, 
    0.00976043f, -0.14822401f, -0.02984636f, -0.05475022f, 0.09304839f, 0.02865971f, 0.15264656f, 0.01870243f, 
    0.01426794f, 0.12278926f, 0.01731434f, -0.02424817f, 0.13904539f, -0.05752655f, 0.09515582f, -0.06943469f, 
    0.07820365f, 0.19502874f, 0.13255246f, 0.10299819f, -0.01130844f, -0.07575408f, -0.06588547f, 0.06840898f, 
    0.01914080f, 0.04240023f, 0.05242965f, -0.03240923f, 0.09682438f, -0.11992770f, 0.10542832f, -0.11008679f, 
    0.17165342f, -0.00901469f, -0.03053692f, -0.00590353f, 0.06375594f, -0.05128971f, -0.10385108f, -0.11794683f, 
    0.19011113f, -0.33556962f, 0.01283988f, -0.20360604f, 0.00897320f, -0.09937124f, -0.07334571f, 0.00001324f, 
    -0.06728797f, 0.03122077f, -0.08960545f, 0.03742290f, -0.03927561f, -0.02161749f, 0.17222583f, 0.26078504f, 
    -0.07433617f, -0.10998911f, -0.06683437f, -0.07130802f, -0.01449347f, -0.05241302f, 0.15374330f, 0.18697512f, 
    -0.07484750f, -0.01256681f, 0.13237922f, -0.08160628f, 0.02672770f, -0.02596180f, -0.12339136f, 0.10248604f, 
    0.13042016f, -0.00653725f, -0.10162415f, -0.06598403f, -0.06398112f, 0.17551896f, 0.02781114f, 0.27528271f, 
    0.02970529f, -0.06491600f, -0.03897131f, -0.06584062f, -0.06873466f, 0.00012502f, 0.04637036f, -0.08057462f, 
    0.11721040f, 0.12045750f, -0.00080675f, 0.04048641f, 0.00756642f, 0.00138865f, -0.08653683f, -0.02031320f, 
    0.06900419f, 0.03116156f, -0.05229733f, 0.14706877f, -0.07403143f, 0.11023660f, 0.15450381f, 0.16478097f, 
    0.06403419f, 0.01854904f, -0.14696963f, 0.02028104f, 0.00170848f, 0.07172940f, -0.00617396f, 0.10848574f, 
    0.10198942f, 0.00249264f, 0.18604052f, 0.13073389f, -0.02925190f, 0.13526136f, -0.06700098f, -0.03813959f, 
    0.02987068f, -0.02567850f, -0.05416281f, 0.04218772f, -0.08547614f, -0.27602401f, 0.14830323f, -0.13399547f, 
    -0.12467317f, -0.13673835f, 0.02757912f, -0.14180887f, 0.11261837f, 0.05635807f, 0.05435291f, 0.06566360f, 
    0.15726668f, 0.18294731f, -0.09309380f, -0.07043453f, 0.07732397f, -0.04341615f, 0.14480653f, 0.03738403f, 
    -0.01032809f, -0.06145914f, -0.08171531f, -0.04920294f, -0.06396843f, 0.13642381f, 0.10822433f, 0.11505210f, 
    -0.04173677f, 0.04724571f, 0.14073411f, 0.07370242f, 0.06037791f, 0.08854634f, 0.00464575f, 0.01668420f, 
    -0.01274757f, -0.25602528f, -0.11337692f, 0.11450296f, -0.05652025f, -0.16326603f, -0.10393073f, -0.09482209f, 
    0.03700452f, 0.05074454f, 0.13885687f, 0.09985408f, 0.24633564f, -0.08317789f, -0.18704690f, -0.16809848f, 
    -0.02638094f, 0.08540242f, 0.16980970f, 0.07682177f, 0.01864517f, 0.03999478f, -0.09911890f, 0.11909229f, 
    -0.17997080f, 0.21515283f, 0.04085764f, 0.04893802f, -0.03265130f, 0.01909367f, 0.01021181f, -0.09320539f, 
    -0.16834871f, 0.18372694f, 0.04432930f, 0.10706814f, -0.07726855f, 0.00365613f, -0.25860110f, -0.08762238f, 
    -0.13645250f, -0.03990327f, 0.11985909f, 0.00945854f, -0.18713383f, 0.00930555f, -0.07055098f, 0.02794038f, 
    0.02178074f, -0.08850295f, -0.00515608f, 0.11963931f, -0.04095020f, 0.03942789f, -0.03614463f, -0.07948282f, 
    -0.02993493f, 0.04130614f, -0.06528720f, -0.00078045f, -0.03157615f, -0.07468910f, 0.00307059f, 0.03530958f, 
    0.15218039f, 0.09811705f, -0.04316555f, -0.07883918f, -0.01404991f, 0.13671371f, 0.04491420f, 0.18613665f, 
    -0.32849815f, 0.04624807f, 0.04925251f, 0.10169692f, 0.07187069f, -0.00339383f, -0.01502325f, -0.09143958f, 
    -0.00615028f, -0.03175462f, 0.07127262f, 0.08072563f, -0.16585957f, -0.16923016f, -0.19200048f, -0.02695026f, 
    0.06873401f, 0.13591647f, 0.10229043f, -0.08900253f, 0.01158555f, 0.08241706f, 0.06927884f, -0.01336146f, 
    -0.05172409f, 0.08589739f, 0.02957177f, 0.38612685f, 0.01298687f, 0.14307895f, 0.05154265f, -0.13481371f, 
    -0.02017912f, -0.04266714f, 0.10011864f, 0.19994898f, 0.15469994f, -0.20724274f, -0.05359536f, 0.03322513f, 
    -0.00083418f, 0.16313663f, 0.09587137f, -0.01134564f, 0.01900735f, 0.06952740f, -0.05498462f, 0.02556429f, 
    -0.17711745f, 0.24093495f, -0.14089590f, 0.10244451f, 0.00428903f, 0.03484330f, -0.01415236f, 0.02635064f, 
    0.30080929f, 0.15978801f, 0.22839171f, 0.16968545f, -0.13767520f, -0.09154735f, 0.12178878f, -0.15666428f, 
    0.00931557f, 0.03379226f, 0.22612779f, 0.06617478f, 0.01117830f, 0.21247683f, 0.06784812f, -0.03938572f, 
    -0.13775459f, 0.11880872f, 0.28563434f, -0.11312225f, -0.03689947f, 0.02084616f, -0.01569998f, 0.04539474f, 
    -0.14259176f, 0.15388325f, -0.10936692f, 0.08144713f, 0.10503954f, -0.28365576f, 0.30200830f, -0.22460319f, 
    -0.19364405f, -0.00164618f, -0.06265730f, 0.08561418f, 0.12648392f, 0.16158819f, 0.04127992f, 0.09425899f, 
    -0.15612048f, -0.00357753f, 0.02642375f, 0.07676648f, 0.12006899f, 0.08480961f, 0.10642200f, 0.07189311f, 
    -0.07699172f, -0.13125336f, 0.14407937f, -0.00494370f, 0.06009682f, 0.25587648f, 0.30204040f, 0.04503212f, 
    0.08621279f, 0.03107507f, -0.03201088f, 0.03011173f, 0.00057131f, -0.04704887f, -0.00649294f, -0.20046040f, 
    -0.00624779f, -0.11190417f, 0.13034447f, 0.09812422f, 0.14858541f, 0.20975001f, 0.25417948f, 0.09322064f, 
    0.02468183f, 0.01644440f, 0.04341857f, 0.05605581f, 0.10687045f, -0.10663617f, 0.00487250f, 0.00000369f, 
    0.07226402f, -0.01433479f, -0.00979854f, 0.08364276f, 0.07945587f, 0.17075229f, 0.06572710f, 0.21341307f, 
    0.19515881f, -0.09849872f, 0.10137121f, -0.06812733f, -0.18830454f, -0.19498548f, -0.08188996f, -0.14581227f, 
    -0.03400094f, -0.07932117f, -0.16578224f, 0.07170437f, -0.11954598f, -0.22730620f, 0.18890025f, -0.38497594f, 
    -0.07205198f, -0.33174360f, -0.06768579f, 0.01214138f, -0.25754398f, -0.05186082f, -0.18861263f, -0.18629938f, 
    0.22571784f, 0.21723075f, 0.22618628f, -0.14586948f, -0.05370850f, -0.08875833f, -0.21369290f, -0.08486152f, 
    0.05220107f, -0.10698474f, -0.06443409f, -0.05814964f, 0.00875589f, 0.23440173f, -0.33966404f, 0.24423355f, 
    0.00854827f, -0.01064544f, -0.02920777f, 0.09328153f, -0.03649772f, 0.14022179f, 0.18576962f, 0.07825701f, 
    0.10098030f, 0.05937765f, -0.11237765f, -0.21683215f, -0.04845909f, -0.02819237f, 0.15600397f, -0.05621263f, 
    0.12783393f, -0.13997658f, 0.10766131f, 0.01984127f, 0.00794945f, -0.17201881f, -0.01057036f, -0.05136911f, 
    0.01507682f, 0.08765306f, 0.04042808f, 0.21735941f, 0.01175291f, -0.09587497f, -0.15734436f, -0.13575163f, 
    0.03847603f, 0.04170041f, -0.01032200f, 0.22351901f, 0.00731090f, -0.02710087f, 0.09940934f, 0.12654994f, 
    0.10585382f, -0.09289726f, 0.33541691f, 0.37858239f, -0.07647227f, -0.15329166f, 0.04956824f, -0.09013657f, 
    -0.02966735f, -0.01662349f, -0.03056123f, -0.05325219f, -0.16234082f, -0.05471539f, -0.05288765f, -0.04930674f, 
    -0.03015528f, 0.05755203f, -0.02903010f, -0.04904862f, -0.00414393f, 0.03985529f, 0.07795730f, 0.00590216f, 
    0.00891043f, 0.11529115f, -0.01079427f, 0.02888273f, -0.06088658f, -0.17083886f, 0.23795529f, -0.10713484f, 
    0.05325347f, 0.03084926f, 0.10471835f, 0.13965230f, -0.06368436f, 0.06727464f, 0.03744755f, 0.00178344f, 
    0.00055474f, -0.07396786f, 0.31475136f, -0.00740760f, 0.01872987f, 0.01993947f, -0.11192713f, 0.00991366f, 
    -0.09544859f, 0.11677779f, 0.03191479f, 0.06572108f, 0.03365888f, -0.05261284f, 0.03284030f, 0.14248139f, 
    -0.17631142f, -0.14367636f, -0.09412338f, -0.10864115f, -0.03983654f, 0.06220612f, 0.10567526f, -0.02951858f, 
    -0.12233346f, 0.12237199f, 0.11152299f, -0.26360336f, 0.22245458f, 0.03550293f, 0.17660296f, 0.11234693f, 
    0.11068445f, -0.05788184f, 0.03167466f, -0.11254625f, -0.16586046f, -0.14845043f, 0.13670877f, 0.00131512f, 
    0.09700994f, 0.06264055f, -0.10628630f, 0.17634632f, -0.04475826f, 0.03560877f, 0.00889634f, -0.15721130f, 
    0.23199990f, -0.02863050f, -0.03709913f, 0.14028218f, 0.21913913f, 0.08075029f, -0.06921585f, -0.09839883f, 
    -0.03002519f, 0.01876268f, -0.09033109f, -0.04839590f, 0.30474609f, 0.08264440f, 0.10231306f, -0.17101745f, 
    -0.00785173f, 0.02471411f, -0.13449521f, 0.07788096f, 0.01043867f, 0.01188868f, -0.09258838f, 0.13255265f, 
    -0.08055395f, -0.06387097f, 0.01762399f, -0.02559065f, -0.10368925f, 0.07124970f, -0.03292165f, 0.03391900f, 
    -0.03540665f, 0.17346193f, -0.03700825f, 0.13257669f, -0.01981262f, -0.07880654f, 0.11373648f, 0.00715262f, 
    -0.06159519f, -0.14869393f, -0.04743580f, 0.00772494f, -0.06618942f, 0.05227443f, 0.10001591f, -0.07304929f, 
    0.10910692f, 0.17163990f, 0.02544827f, -0.00715948f, -0.04088655f, -0.09787539f, -0.08701479f, -0.09009525f, 
    -0.00073262f, -0.05411229f, 0.05827367f, 0.03643781f, 0.02884455f, 0.26772937f, -0.06391496f, -0.01600460f, 
    -0.01753666f, 0.01223287f, -0.02655257f, 0.12198506f, -0.04285752f, -0.01144847f, 0.13630061f, 0.05992953f, 
    -0.25159016f, 0.39660591f, -0.04590570f, -0.36658880f, 0.05376080f, 0.09154206f, 0.08238693f, -0.03330870f, 
    0.09541006f, -0.02885500f, 0.11253713f, 0.05601542f, 0.09848846f, 0.02380685f, -0.01043713f, -0.02926115f, 
    0.05858192f, 0.03391247f, 0.01833496f, -0.01682482f, 0.00470888f, 0.07949902f, 0.00906224f, -0.06496490f, 
    -0.16120672f, 0.08066488f, -0.08161101f, 0.25649390f, -0.03481429f, -0.12252638f, 0.17435949f, 0.04664409f, 
    0.05159735f, -0.11338468f, 0.17151658f, 0.02680378f, 0.03599950f, -0.02629164f, 0.17370015f, 0.04811524f, 
    0.08919056f, 0.03057045f, -0.06917924f, 0.00923602f, 0.08138918f, 0.02606384f, 0.06603600f, 0.04121257f, 
    -0.11229743f, -0.07588720f, 0.02282191f, 0.13930826f, 0.00023660f, -0.06297685f, -0.02556684f, 0.07091524f, 
    -0.12261012f, -0.07681689f, -0.19726898f, -0.14851604f, 0.21880239f, 0.05963969f, 0.06037538f, 0.20745833f, 
    -0.02860697f, 0.01157252f, -0.08528139f, -0.14161576f, 0.00454031f, -0.02701240f, 0.08551092f, 0.20578967f, 
    0.01400775f, 0.00719307f, 0.02107918f, 0.04366944f, 0.05012621f, 0.02993180f, 0.06028581f, -0.06588966f, 
    0.12283527f, -0.04639861f, 0.04755317f, 0.01449586f, 0.01966654f, 0.02020528f, -0.05618332f, -0.11818555f, 
    0.11431231f, 0.19025034f, 0.22340587f, 0.12781073f, -0.06232405f, 0.04262187f, -0.02564087f, 0.03325894f, 
    0.11123811f, -0.02338182f, -0.20205662f, 0.28307152f, -0.18212597f, 0.01456816f, -0.22731782f, -0.06420303f, 
    -0.03664372f, 0.10807463f, 0.00235448f, 0.05280238f, 0.30668354f, 0.16330785f, -0.03702942f, -0.08673885f, 
    -0.18095909f, -0.05020126f, -0.07683948f, -0.14802554f, 0.10222416f, 0.08523903f, 0.14389396f, 0.27746895f, 
    -0.19890004f, -0.02033947f, 0.09349870f, 0.02478484f, -0.01149389f, -0.08257055f, -0.12853996f, 0.06069431f, 
    -0.02953286f, 0.02793678f, -0.08750544f, -0.11171386f, -0.16931812f, 0.04967517f, -0.17104188f, 0.11542473f, 
    0.15501270f, 0.07404726f, 0.05337158f, 0.07911337f, 0.01352891f, -0.03138920f, -0.08044187f, -0.02624634f, 
    0.17479591f, -0.06464695f, -0.06091900f, 0.09364247f, 0.16528326f, 0.01888271f, 0.03357400f, 0.07992293f, 
    0.09340481f, 0.10387890f, -0.02668284f, -0.08180418f, 0.13100637f, 0.01175899f, -0.14229752f, 0.03111249f, 
    0.01187653f, 0.06294104f, 0.15144096f, -0.00615072f, 0.20900206f, -0.01668276f, 0.04395081f, 0.18176098f, 
    -0.09635856f, -0.22885458f, -0.02506445f, -0.11756454f, 0.18783468f, 0.04377377f, 0.11746786f, -0.02617060f, 
    0.00123908f, -0.01411758f, -0.02077975f, -0.05386612f, 0.01101777f, -0.18268502f, 0.05770108f, -0.02325869f, 
    0.15796876f, -0.02839840f, 0.10730448f, 0.07339508f, -0.08326222f, -0.06415446f, -0.12125932f, 0.03152239f, 
    0.06556908f, -0.04393851f, -0.09534005f, 0.42995426f, 0.09236131f, 0.04040011f, 0.06118608f, 0.12238248f, 
    -0.02869015f, 0.14712331f, -0.09987883f, -0.00444169f, -0.07297455f, 0.00258970f, 0.01929222f, 0.13077106f, 
    -0.08022731f, -0.03573252f, 0.08040749f, -0.09401686f, -0.07765085f, -0.03587982f, -0.05842615f, 0.09092485f, 
    0.14013900f, 0.02949297f, -0.05717215f, -0.29331675f, 0.13104704f, -0.00198410f, -0.05520198f, 0.05161044f, 
    0.03147242f, 0.26876789f, -0.04046104f, -0.14508413f, -0.02170405f, 0.01752852f, -0.09026845f, -0.07082084f, 
    0.06390787f, 0.09047800f, -0.01282216f, 0.08387016f, 0.05865307f, 0.01387568f, 0.11899370f, 0.01855466f, 
    -0.10118687f, 0.12164712f, 0.07710515f, 0.06862103f, 0.06972975f, -0.05286236f, 0.07342033f, 0.10389842f, 
    0.11089378f, 0.10233023f, -0.14688303f, 0.04684373f, -0.14901744f, 0.02478675f, 0.22748780f, 0.13573807f, 
    -0.02720263f, 0.12640154f, 0.09702393f, 0.00401506f, -0.19845450f, -0.00866274f, 0.08566147f, 0.02609266f, 
    -0.10961747f, 0.04698497f, 0.26754594f, -0.05687936f, 0.04572195f, 0.07268250f, -0.08518963f, 0.09696124f, 
    -0.09056042f, 0.08765113f, 0.00724197f, 0.01715006f, -0.07118540f, -0.06902520f, 0.15329394f, -0.19632713f, 
    -0.05842240f, -0.02971592f, 0.05974169f, -0.01744857f, -0.04613725f, -0.00995047f, -0.00619210f, -0.03902666f, 
    -0.08453821f, 0.00764878f, -0.10040899f, 0.03051344f, 0.07542261f, -0.06331425f, -0.00404580f, 0.07720099f, 
    0.05486370f, 0.02585137f, 0.06661882f, -0.01180268f, 0.17281573f, 0.15706642f, 0.19871865f, -0.06621568f, 
    0.01768487f, 0.10679927f, -0.02430000f, -0.01744282f, 0.09512133f, 0.11956139f, 0.23157398f, 0.33961803f, 
    -0.01517056f, -0.00292322f, 0.07593647f, -0.01233793f, 0.03372464f, -0.03342840f, 0.01032922f, 0.04225020f, 
    -0.09639428f, 0.03239096f, -0.16177054f, -0.16686563f, 0.13175221f, -0.12239897f, -0.25824031f, -0.12114822f, 
    -0.08459052f, 0.08044215f, -0.08628012f, -0.01017311f, 0.08383054f, 0.07732341f, 0.00805458f, 0.10589682f, 
    0.13144937f, -0.19206625f, -0.03341483f, 0.03196125f, -0.04144497f, -0.04027927f, -0.00201830f, 0.02416503f, 
    -0.06412992f, 0.08840969f, 0.05161037f, 0.12685558f, 0.11776022f, 0.01177982f, 0.06868393f, -0.13158338f, 
    0.02616586f, -0.18464500f, -0.00574089f, 0.13788596f, -0.05320043f, -0.05658840f, -0.06444233f, 0.04018728f, 
    0.09832117f, -0.00810755f, 0.18931811f, -0.21210395f, -0.02237894f, -0.00184121f, 0.02390067f, -0.00395164f, 
    -0.10906221f, 0.03055253f, 0.03221725f, -0.07933575f, -0.13875830f, 0.18812257f, -0.12364196f, 0.19508885f, 
    0.11640676f, -0.02631138f, -0.10069177f, 0.20696336f, -0.13274492f, 0.01868195f, -0.04216259f, 0.02029215f, 
    0.07831934f, 0.08360594f, -0.26817304f, 0.11295932f, -0.05996042f, 0.10285709f, 0.13564141f, 0.02030062f, 
    0.15115368f, 0.05792855f, 0.19034716f, 0.05048088f, 0.07754510f, -0.03293536f, -0.11353021f, -0.17616452f, 
    -0.15141581f, -0.02871089f, 0.03673875f, 0.12414017f, -0.02894450f, -0.04889134f, -0.07957993f, -0.04618884f, 
    -0.06668641f, 0.03195364f, 0.01874504f, -0.01911698f, -0.04344872f, -0.22286546f, 0.22950898f, 0.21552597f, 
    -0.04003777f, 0.00999276f, 0.11540472f, 0.01888739f, -0.11964053f, -0.16510896f, -0.08700095f, -0.30576992f, 
    -0.08718950f, 0.08742132f, -0.11427373f, 0.07486859f, 0.05674619f, -0.06557098f, 0.09109956f, 0.13932341f, 
    0.34148321f, -0.09113725f, 0.11011001f, -0.12140284f, 0.04591608f, 0.09830446f, -0.07776156f, -0.14049596f, 
    0.09319981f, 0.01664869f, 0.15578178f, 0.06021843f, -0.24052683f, -0.22858940f, -0.43974748f, -0.08332317f, 
    0.15331417f, 0.03019948f, -0.16227913f, 0.01084941f, 0.08386634f, 0.04980734f, -0.06439708f, 0.02454164f, 
    0.46433926f, 0.07351838f, -0.16056906f, 0.10901799f, 0.04298494f, -0.02394215f, 0.01971437f, -0.05497249f, 
    0.10138801f, -0.06434938f, -0.10780194f, -0.01524409f, -0.13875663f, 0.13202541f, -0.18374176f, 0.11774946f, 
    0.02384279f, -0.12249149f, 0.05294204f, 0.02561047f, 0.05884385f, 0.04768382f, 0.01604482f, 0.12082729f, 
    0.32897973f, -0.02553025f, 0.27610373f, 0.09671999f, -0.05697732f, -0.00106605f, 0.10156220f, -0.01920173f, 
    0.06357119f, -0.01644235f, 0.02237068f, 0.05970298f, -0.19181353f, -0.15744688f, -0.02474922f, 0.08321008f, 
    -0.03280694f, -0.08504960f, 0.12458330f, 0.02725892f, 0.01184553f, -0.11767584f, -0.00581133f, -0.17210805f, 
    0.08445597f, 0.18590811f, 0.03681802f, -0.13520931f, -0.04393395f, 0.10628321f, 0.15294555f, 0.15126617f, 
    0.03893010f, -0.03134328f, 0.05405548f, 0.12953570f, 0.12926796f, 0.16623834f, 0.00387659f, 0.05752386f, 
    0.05822988f, -0.08284001f, 0.08975523f, 0.11264388f, -0.03357625f, -0.01833603f, -0.02507687f, -0.06324212f, 
    -0.22325189f, 0.26184675f, -0.11788935f, 0.25267267f, -0.01204316f, 0.00063908f, -0.06488941f, -0.18175274f, 
    0.06489853f, -0.04602790f, 0.11303601f, 0.04554663f, -0.02345190f, 0.06657567f, 0.07236742f, -0.01389838f, 
    0.09956763f, 0.11363875f, 0.01871257f, 0.00226198f, -0.17976877f, 0.06886987f, 0.09025458f, -0.05073573f, 
    -0.01939907f, 0.10938649f, -0.06705415f, 0.17745250f, -0.00176515f, -0.04802977f, 0.11645205f, -0.00658700f, 
    0.00268364f, 0.02920615f, -0.05622438f, -0.06188114f, 0.02458369f, -0.13536686f, 0.18800154f, -0.18584573f, 
    -0.04991520f, 0.07167996f, -0.03362606f, -0.24078016f, 0.00230317f, -0.06666046f, 0.05016790f, 0.03396035f, 
    -0.16503946f, -0.09773456f, 0.18785201f, 0.26561195f, -0.16244856f, -0.12201406f, -0.24228740f, 0.01202117f, 
    0.06068109f, -0.07698866f, -0.02899671f, -0.01835317f, -0.15409867f, 0.05973617f, 0.18585761f, -0.03396901f, 
    0.16596100f, 0.11929250f, 0.06620333f, 0.00370779f, 0.06861199f, 0.05725493f, -0.02890875f, 0.01795438f, 
    0.14857173f, -0.06805838f, -0.00184125f, -0.16273868f, -0.04089323f, 0.17431062f, -0.13334005f, -0.13613841f, 
    -0.00276311f, 0.05307916f, -0.08371011f, -0.02195302f, 0.18772371f, 0.18875089f, -0.01205051f, 0.08896754f, 
    0.00015214f, -0.08458855f, 0.08518957f, 0.11998055f, -0.14623095f, -0.03271394f, -0.01402480f, -0.09056715f, 
    0.20863824f, 0.00163283f, 0.10034191f, -0.05294153f, 0.04115597f, 0.03077183f, -0.06131623f, -0.14359820f, 
    0.16274992f, 0.05598780f, 0.06111251f, 0.07963144f, -0.09196182f, -0.34316364f, -0.10405707f, -0.10139532f, 
    0.09651476f, 0.08477417f, -0.02822012f, 0.01704708f, 0.11484388f, 0.19290130f, 0.12163754f, 0.01509174f, 
    -0.05613183f, 0.03244973f, 0.27080789f, 0.14506879f, -0.05836092f, -0.07759321f, -0.00964610f, -0.04948676f, 
    -0.01713980f, 0.05839011f, -0.10829525f, -0.01976771f, -0.24499120f, 0.08098172f, -0.04948070f, -0.12301335f, 
    -0.23842932f, -0.07885634f, 0.05808478f, 0.08366721f, -0.07136501f, 0.08760127f, 0.16909373f, -0.02282005f, 
    0.32603401f, -0.07595963f, 0.12134968f, 0.03204778f, 0.13040052f, 0.02853866f, -0.07330769f, 0.17949013f, 
    -0.05486627f, -0.02907243f, 0.13293646f, -0.02129851f, -0.07723355f, 0.00691791f, 0.23544608f, 0.10742147f, 
    -0.00623007f, 0.00167220f, -0.05772775f, 0.03849105f, 0.06844350f, -0.02605627f, 0.08512117f, -0.13751243f, 
    0.04690930f, -0.01284644f, -0.02187075f, -0.10687615f, 0.04184940f, 0.13476901f, 0.16393243f, 0.05723134f, 
    0.08904456f, 0.04825860f, 0.01268793f, 0.12513807f, 0.17170107f, 0.01784087f, -0.10307392f, 0.00894371f, 
    0.03144895f, -0.05272777f, 0.00239380f, 0.11646299f, 0.01450808f, 0.11483103f, -0.03003990f, 0.10891517f, 
    -0.08744691f, 0.17913733f, 0.12302397f, 0.19556877f, -0.14186570f, -0.10995261f, -0.03953163f, -0.23664735f, 
    -0.10427064f, -0.03573964f, -0.06509630f, 0.01966407f, -0.31514058f, 0.03591820f, 0.16202159f, -0.26278824f, 
    -0.07198143f, -0.23879278f, -0.04426612f, 0.03054202f, -0.14355202f, -0.04313433f, 0.00240458f, -0.10482248f, 
    0.03060746f, 0.14555217f, 0.01632765f, -0.11281496f, 0.00883310f, -0.04038824f, -0.05173313f, -0.06046604f, 
    -0.02313193f, -0.08289518f, 0.03573332f, -0.02292156f, 0.10736333f, 0.06278256f, -0.00022839f, -0.26805246f, 
    -0.00493759f, 0.01717645f, 0.01375474f, 0.05484323f, 0.09698833f, 0.05039584f, 0.09127487f, 0.22605774f, 
    0.21567330f, 0.23220567f, -0.08992039f, -0.08468954f, 0.01353323f, -0.12119640f, -0.05874171f, -0.08849254f, 
    0.11990295f, -0.08592276f, 0.09138071f, 0.09451848f, -0.11694680f, 0.04526427f, 0.10976809f, -0.07279008f, 
    0.13942660f, 0.12889688f, 0.00667870f, 0.14452693f, 0.05885539f, 0.06677937f, -0.18567981f, -0.06862082f, 
    0.03874356f, -0.08305794f, -0.00568071f, -0.22781529f, -0.06403066f, 0.16194583f, 0.09219575f, 0.05387763f, 
    0.20550184f, 0.03320925f, 0.19876266f, 0.10553367f, 0.08903160f, -0.04869099f, 0.12219078f, -0.19128320f, 
    0.02618954f, -0.01408244f, 0.05002345f, 0.13056946f, -0.12480592f, 0.02720452f, -0.09219451f, -0.01720196f, 
    -0.10639320f, 0.09547915f, -0.06115589f, -0.01496546f, 0.05748179f, 0.11913090f, -0.09365884f, 0.24915586f, 
    0.16131386f, 0.17488709f, 0.20635028f, 0.13928981f, -0.11447217f, 0.30246362f, 0.25214964f, -0.18832435f, 
    -0.05066519f, 0.04522863f, 0.01963102f, 0.12608013f, -0.07358760f, 0.18473116f, -0.04360597f, 0.00645600f, 
    -0.10426740f, 0.17224249f, -0.08320267f, -0.07229853f, -0.04234498f, -0.03461366f, 0.11293311f, -0.10588590f, 
    -0.09845376f, 0.07035533f, -0.05914884f, 0.14554341f, -0.09473658f, -0.37301350f, 0.24856447f, -0.03667923f, 
    -0.18186033f, -0.03732173f, -0.04648631f, -0.13364060f, 0.07230855f, 0.00886934f, -0.04259720f, -0.05103614f, 
    -0.22247112f, 0.05150453f, -0.09748846f, -0.08371667f, -0.03815491f, 0.08607539f, 0.10527302f, -0.01660986f, 
    -0.06731135f, -0.05411536f, -0.11654603f, -0.05422886f, 0.24543990f, 0.06028328f, -0.07413717f, 0.17724654f, 
    -0.12479161f, -0.07214598f, 0.18011405f, 0.15390602f, -0.03866992f, 0.03296763f, 0.09608214f, 0.07103953f, 
    0.04924837f, -0.24917251f, -0.06968318f, -0.03303600f, -0.03636301f, -0.12161488f, 0.11491196f, -0.02503160f, 
    0.02997134f, -0.01953273f, 0.02339335f, 0.09454290f, -0.17019500f, -0.28752390f, 0.03479206f, 0.04539148f, 
    0.05233708f, -0.01962652f, 0.12364861f, -0.12784879f, -0.02631703f, 0.09962203f, 0.07697399f, 0.09334511f, 
    0.09984713f, 0.01829719f, 0.16542833f, -0.15382156f, -0.00807782f, -0.08733565f, -0.12201828f, -0.14994600f, 
    0.03782494f, 0.04151829f, 0.03213475f, 0.19101924f, 0.14809152f, -0.23159547f, -0.34621161f, -0.00592949f, 
    -0.08746713f, 0.12674990f, 0.07688639f, 0.01394759f, -0.14768040f, -0.02899303f, -0.22236213f, -0.12539242f, 
    0.05407003f, -0.14730702f, -0.12013353f, 0.02128058f, 0.03127438f, 0.10012049f, 0.01720356f, 0.04895139f, 
    -0.03809736f, 0.10940389f, -0.03202397f, 0.01458430f, -0.00854244f, 0.01272655f, 0.03707882f, 0.28821078f, 
    0.16178560f, -0.04102925f, -0.06221839f, -0.01057216f, -0.10422640f, 0.05876698f, 0.21922319f, 0.07442076f, 
    -0.04763659f, -0.02856233f, 0.23255739f, -0.06844530f, -0.02440546f, -0.00807648f, 0.00820817f, -0.01699199f, 
    0.11117680f, 0.19967912f, 0.20099629f, -0.02022856f, 0.00619675f, -0.16140048f, -0.31401023f, -0.13037544f, 
    -0.15241969f, 0.22370337f, -0.02532584f, 0.01571174f, 0.01666593f, 0.06810246f, 0.23224910f, -0.08473030f, 
    0.11676200f, 0.19888060f, 0.01746114f, 0.41628745f, 0.12025435f, 0.00335078f, 0.07463553f, 0.00571765f, 
    0.12768444f, -0.06583128f, 0.03053950f, 0.15022475f, -0.03636777f, -0.26215172f, -0.13384502f, 0.02795929f, 
    0.10167876f, 0.19276702f, 0.14180779f, -0.14060418f, 0.06933054f, 0.05807014f, -0.14571019f, -0.00863903f, 
    0.06500829f, 0.20586860f, 0.07840651f, 0.10682260f, -0.02162176f, -0.03427511f, -0.01760798f, -0.05683415f, 
    0.03854356f, -0.05193854f, -0.04873492f, -0.06211307f, -0.11743837f, -0.02974240f, -0.21466765f, -0.10260398f, 
    -0.24584164f, -0.20551699f, -0.06075699f, -0.00549067f, 0.01454952f, -0.32290363f, -0.02496854f, -0.09090119f, 
    0.29922360f, 0.38201377f, 0.17623474f, 0.20578274f, -0.04555283f, -0.07588812f, -0.03651946f, -0.01510453f, 
    0.01746458f, -0.04127816f, -0.00686474f, 0.03068902f, 0.33104208f, -0.00194403f, -0.10689983f, 0.03934658f, 
    -0.01198171f, -0.06035883f, 0.00935051f, 0.03731889f, -0.10175247f, 0.00362262f, -0.09189733f, -0.04876911f, 
    -0.06894063f, 0.38279307f, -0.33034435f, -0.53066134f, 0.00403302f, 0.07115837f, 0.07524280f, 0.00626231f, 
    0.05137090f, -0.00126392f, 0.04179121f, -0.03324557f, -0.15861833f, 0.12591553f, -0.02145912f, -0.07510748f, 
    -0.05882718f, 0.06798746f, -0.16835895f, -0.01975478f, -0.14385352f, -0.11324116f, -0.06154092f, -0.06544308f, 
    -0.14838929f, -0.52187246f, -0.46570706f, -0.08548679f, 0.06525131f, 0.14991388f, 0.09915210f, 0.21521893f, 
    -0.04811629f, -0.06861880f, 0.03565512f, 0.05920604f, -0.25272411f, -0.01548766f, -0.18112470f, -0.14082241f, 
    0.09698985f, 0.12948823f, -0.02396764f, 0.15289645f, -0.05990887f, -0.08584883f, -0.09131409f, 0.04291575f, 
    0.12620375f, 0.09099412f, 0.13833800f, 0.20063801f, -0.11775442f, -0.03572311f, 0.00153389f, -0.07368795f, 
    0.19075802f, -0.08499364f, 0.06486895f, 0.18445595f, 0.00860771f, 0.19570743f, 0.01525204f, 0.20585130f, 
    0.00572119f, -0.06247379f, -0.00338137f, 0.03895628f, 0.05255004f, -0.07156767f, 0.07847108f, 0.04981717f, 
    0.27793631f, 0.22720674f, 0.09119636f, 0.27266464f, -0.05425363f, -0.00391687f, 0.06956621f, -0.02237360f, 
    0.00549410f, -0.03465225f, -0.04410445f, 0.06356014f, -0.01379982f, 0.08747268f, 0.03916651f, -0.06519317f, 
    -0.03954464f, 0.01905839f, -0.10560293f, -0.08027397f, -0.00196433f, -0.10565516f, -0.10668246f, 0.08945337f, 
    0.18553048f, -0.01857821f, 0.16707364f, 0.25150162f, -0.14775522f, 0.12198082f, 0.00650877f, -0.08240406f, 
    0.10473714f, -0.00864476f, 0.03166222f, -0.04798061f, -0.03651366f, -0.18386377f, -0.32342505f, -0.23474732f, 
    0.23440041f, -0.03200901f, -0.09384613f, -0.07772916f, 0.11160848f, 0.08632722f, -0.08694328f, -0.04013791f, 
    0.05370520f, 0.08607038f, 0.00068257f, -0.01156431f, 0.02487077f, -0.00842487f, -0.03283466f, -0.02868678f, 
    0.08848007f, -0.01920915f, -0.06430667f, -0.09623004f, 0.12399769f, 0.12073752f, 0.16992958f, -0.24177875f, 
    0.12049276f, -0.11984938f, 0.17290719f, 0.11499920f, 0.04479045f, 0.12290752f, -0.01806367f, -0.18086161f, 
    -0.00401979f, 0.02645557f, 0.00384325f, -0.04626711f, 0.08164291f, -0.13096717f, -0.06507052f, -0.28337196f, 
    -0.06673898f, -0.01690724f, -0.27908677f, -0.26723960f, 0.18891230f, 0.15782931f, -0.03107849f, 0.16666338f, 
    -0.00721590f, -0.01989652f, -0.10909064f, -0.06825742f, -0.03864057f, -0.15211113f, -0.03100848f, 0.00317076f, 
    0.03715990f, -0.14059322f, 0.09553692f, 0.31403923f, -0.16787513f, -0.08523293f, -0.19620734f, -0.01037667f, 
    0.00928552f, -0.19047819f, -0.11034862f, -0.05642248f, 0.11322448f, 0.04446626f, -0.05704161f, 0.07560084f, 
    0.01935541f, -0.03088441f, 0.02039525f, 0.17902766f, -0.01873214f, 0.00293944f, 0.04914925f, -0.18101193f, 
    0.26970276f, 0.37923583f, 0.07199962f, -0.09247743f, -0.04140712f, -0.01738928f, 0.04702250f, -0.12190527f, 
    -0.00577539f, 0.05982227f, 0.03937211f, 0.11688441f, -0.08586633f, 0.21539611f, 0.13230845f, -0.04840329f, 
    -0.02725431f, 0.02791180f, 0.00451888f, -0.13770637f, 0.10544222f, 0.03155671f, 0.12555809f, 0.36742565f, 
    0.17705357f, 0.19330066f, 0.12382530f, 0.06311788f, 0.05493338f, 0.16681170f, -0.05362771f, 0.17849790f, 
    0.00891415f, -0.06634139f, -0.09300596f, -0.17229153f, 0.19204342f, 0.35432577f, 0.01627530f, 0.09178909f, 
    0.07451905f, 0.23111720f, 0.14347436f, 0.09651303f, -0.02620986f, -0.07551388f, -0.09254252f, -0.13116057f, 
    -0.30312952f, -0.08030808f, -0.14860912f, 0.08648665f, 0.09103852f, 0.06234023f, -0.04502479f, -0.07419473f, 
    -0.04280401f, 0.20391025f, 0.15358029f, 0.11657828f, -0.04100027f, 0.25469869f, -0.28157330f, 0.15651841f, 
    -0.08845650f, -0.02223277f, 0.03034841f, -0.07537279f, 0.11634914f, 0.06488253f, 0.19874652f, 0.22769541f, 
    -0.16707179f, -0.28674266f, 0.17325766f, 0.18198152f, -0.09404671f, 0.01829359f, -0.15730482f, -0.11085026f, 
    -0.03143172f, 0.09923054f, 0.04312422f, -0.07559925f, -0.03770538f, 0.07174068f, 0.08867414f, -0.19822688f, 
    0.04806176f, 0.08492979f, -0.13804412f, 0.03046360f, 0.10553761f, -0.00889262f, -0.16800083f, -0.04095051f, 
    -0.40643588f, -0.06018946f, -0.21427876f, 0.26604015f, 0.08328797f, 0.06678178f, -0.05228235f, -0.02497348f, 
    -0.07276017f, 0.05018909f, -0.05280431f, 0.08112497f, 0.20193836f, 0.10212194f, -0.01002439f, 0.09363909f, 
    0.11940522f, 0.02588307f, 0.09094323f, 0.03967929f, -0.00157624f, 0.07687224f, 0.00549807f, 0.18516439f, 
    -0.17053568f, -0.08903760f, -0.20302013f, -0.31915423f, -0.09602870f, -0.00678128f, -0.04990496f, -0.26961851f, 
    -0.17778544f, 0.08603135f, -0.02015832f, -0.21989721f, 0.18401207f, 0.25991952f, 0.14221735f, 0.03624635f, 
    0.10138738f, 0.13834471f, 0.01385539f, 0.26686090f, 0.13506129f, 0.10807324f, 0.17545742f, 0.14994417f, 
    -0.04807967f, 0.07508326f, 0.05854353f, 0.14846697f, -0.02699233f, 0.02536557f, 0.00984531f, 0.08523715f, 
    0.12020636f, -0.01845399f, -0.02137176f, -0.03961283f, -0.05211388f, -0.00426020f, 0.30662942f, 0.18299277f, 
    -0.16088086f, -0.07855877f, -0.03321924f, -0.03879078f, -0.14808579f, -0.04869305f, 0.08151315f, 0.02810147f, 
    0.31072313f, -0.07619598f, 0.16539055f, -0.00811514f, -0.00301355f, 0.03256958f, -0.00579482f, 0.04091175f, 
    0.01792575f, -0.05030041f, 0.06020236f, 0.02787263f, -0.04129589f, -0.08065339f, 0.06245494f, -0.14573815f, 
    0.01461166f, -0.06397657f, -0.04425160f, 0.02208574f, -0.10579580f, -0.04670189f, 0.03215513f, -0.02150991f, 
    0.01317623f, -0.37074935f, -0.12774293f, 0.35966671f, -0.00848118f, 0.14700392f, -0.06901619f, 0.05442741f, 
    -0.02666911f, 0.09268251f, 0.05315306f, -0.02073244f, 0.19718429f, 0.06685900f, 0.01383267f, 0.03090815f, 
    0.02799840f, 0.11193837f, 0.06856397f, 0.08018921f, 0.13092221f, 0.22703341f, 0.19022596f, 0.14985466f, 
    -0.37970796f, -0.30678269f, -0.07128813f, -0.02571647f, -0.11770981f, -0.06902939f, -0.12174143f, 0.03033894f, 
    -0.12152116f, -0.09036279f, -0.13659194f, -0.14819957f, -0.11618559f, -0.32524669f, -0.22178930f, -0.05192231f, 
    0.10826129f, 0.04213070f, -0.24082178f, -0.12408094f, -0.15689516f, -0.17850780f, -0.06518358f, -0.01287891f, 
    0.28605556f, -0.01715612f, 0.09002189f, 0.11069611f, -0.03876226f, 0.04926450f, -0.03073107f, 0.08591974f, 
    0.22804356f, -0.00898615f, 0.05592212f, 0.03980324f, 0.08734151f, -0.12777777f, 0.23039268f, -0.08815771f, 
    0.10926890f, -0.08190670f, 0.05036026f, 0.11956619f, -0.03082308f, -0.04170705f, -0.01168625f, 0.07876412f, 
    0.12320679f, 0.09991480f, 0.18834059f, -0.13645066f, 0.04662039f, -0.08623668f, -0.06166230f, 0.05639797f, 
    -0.07048223f, -0.06513064f, 0.01269833f, 0.03864459f, -0.05203399f, -0.00781400f, 0.02384540f, 0.12249827f, 
    0.05236290f, -0.03630115f, -0.11944164f, 0.03724427f, -0.04085024f, -0.14695762f, -0.08245307f, -0.09306889f, 
    0.38117856f, 0.04930166f, -0.05295876f, 0.01323943f, 0.09775705f, 0.06914256f, 0.08117374f, 0.14248669f, 
    0.06869274f, 0.16886167f, 0.11116993f, 0.06162657f, -0.25253311f, -0.23666608f, -0.15690219f, 0.03237665f, 
    0.01719833f, 0.05930587f, 0.11607753f, -0.03896898f, -0.01918262f, -0.01465709f, -0.02000378f, 0.00523622f, 
    0.12310089f, 0.04477698f, 0.06842966f, -0.12284888f, -0.01929794f, -0.07175952f, 0.04399036f, -0.02167656f, 
    0.18935807f, -0.06782144f, -0.07939320f, -0.08927207f, -0.35514599f, -0.34419748f, -0.03416934f, 0.01575121f, 
    0.10843596f, 0.00981771f, 0.07692569f, -0.13359135f, 0.12226862f, -0.03046426f, 0.04650741f, 0.03947458f, 
    0.05512061f, 0.02499674f, -0.00668504f, 0.02033398f, -0.01508483f, -0.01841531f, -0.02166368f, -0.00085387f, 
    -0.02064950f, 0.03750773f, 0.00901318f, -0.05616498f, -0.02714619f, -0.05941267f, -0.02614964f, -0.01004654f, 
    -0.05330717f, -0.01814593f, -0.02424805f, -0.02137313f, -0.01508024f, -0.00059474f, 0.06364998f, 0.06475284f, 
    0.03256489f, -0.02470787f, -0.02456844f, -0.07225690f, -0.03847224f, 0.02533247f, 0.02540305f, 0.00270153f, 
    0.03069092f, -0.06198362f, 0.02017790f, -0.04211587f, -0.05352428f, -0.05440376f, 0.04611130f, 0.03760670f, 
    -0.05836253f, -0.00264186f, -0.03632045f, -0.03803361f, -0.04519099f, -0.04473218f, 0.05168212f, 0.05163472f, 
    -0.02471540f, -0.04186242f, 0.05079662f, -0.03005806f, -0.00656446f, -0.00902925f, 0.02472223f, -0.07236909f, 
    0.02226595f, -0.00014019f, -0.01318568f, -0.05706225f, -0.04092013f, -0.06314513f, -0.06954357f, 0.03333264f, 
    -0.03938468f, -0.02267064f, -0.00803061f, -0.06467491f, 0.02873874f, 0.00757010f, 0.03066109f, -0.03367927f, 
    -0.03215117f, -0.00890755f, 0.01260757f, -0.07683836f, -0.00230594f, -0.05211535f, -0.04318258f, -0.00299110f, 
    -0.07394143f, -0.01791289f, -0.00853891f, 0.01013491f, 0.03916547f, -0.03692492f, 0.00634043f, -0.04167404f, 
    0.06363968f, -0.04979793f, -0.03191213f, -0.06668109f, 0.02413330f, -0.04005885f, 0.03182678f, -0.05481519f, 
    -0.06841260f, -0.03532732f, 0.04862474f, -0.05022509f, 0.02605786f, 0.01729539f, -0.01725888f, -0.03345752f, 
    0.06127940f, -0.04224664f, -0.00920688f, 0.01572690f, -0.01990083f, -0.07642625f, -0.06886752f, 0.05491760f, 
    0.04664462f, -0.01106468f, 0.05797897f, -0.07578817f, -0.06108269f, -0.06602130f, 0.05554604f, -0.02659616f, 
    0.03247982f, -0.06008383f, -0.05912430f, -0.06302980f, -0.06865350f, -0.00046418f, 0.00029747f, 0.02392456f, 
    0.06001463f, -0.00312967f, -0.01313255f, 0.00018029f, 0.05841247f, -0.07482657f, -0.02850319f, 0.04975495f, 
    -0.03184733f, 0.06845764f, -0.02078141f, -0.02740212f, 0.01748591f, -0.03822746f, 0.05223364f, 0.02461760f, 
    0.04214947f, 0.05754810f, 0.04140123f, -0.02684008f, 0.04010593f, 0.02979441f, -0.06087020f, 0.01913552f, 
    0.04157188f, 0.00010053f, 0.04283185f, -0.03396736f, -0.02327766f, 0.01428315f, 0.07502637f, -0.06853396f, 
    -0.07281656f, -0.01412469f, -0.05984940f, -0.05793418f, 0.06896734f, -0.03143185f, -0.06907253f, -0.00093124f, 
    -0.03031267f, -0.06565247f, -0.03367440f, 0.01701885f, 0.05698370f, 0.02677127f, -0.02143330f, -0.07379024f, 
    0.05872326f, 0.03410326f, 0.05393580f, -0.04415391f, -0.04214076f, 0.01422583f, 0.02923587f, 0.04064015f, 
    -0.03904936f, 0.05416939f, 0.02420386f, -0.01229224f, -0.06016258f, 0.04059244f, -0.02632518f, -0.04932512f, 
    0.14901331f, -0.11296741f, -0.13583791f, -0.32079065f, -0.14534748f, -0.20514289f, -0.23855986f, -0.01845699f, 
    -0.21356532f, 0.04392552f, -0.32670072f, -0.35672608f, 0.29101977f, 0.06522483f, -0.16952446f, -0.01644003f, 
    0.07690537f, 0.15777119f, 0.01882024f, -0.09795877f, 0.00847652f, -0.04516757f, -0.01576030f, 0.01885557f, 
    0.00634003f, 0.16500728f, -0.02306493f, 0.14532270f, -0.01880345f, -0.07373963f, -0.01539959f, -0.05513113f, 
    -0.20494588f, -0.00391034f, 0.16163613f, -0.12247543f, -0.15119186f, 0.26250276f, -0.05143334f, 0.30364570f, 
    0.03855105f, 0.08312262f, -0.02135718f, 0.02872097f, -0.23360647f, -0.01937950f, 0.06783494f, -0.43199819f, 
    0.28166935f, 0.15026879f, 0.29768744f, -0.15055394f, 0.00185070f, 0.06332062f, 0.05779717f, -0.00426682f, 
    0.01960072f, -0.08647187f, 0.00048259f, 0.15566234f, -0.08395536f, 0.16703933f, 0.05085006f, -0.07041893f, 
    -0.22030264f, -0.16734064f, 0.13690345f, 0.18106753f, -0.03198672f, -0.00657749f, 0.13784364f, 0.36022726f, 
    0.17018825f, 0.04865685f, -0.09710876f, 0.09797711f, 0.04303866f, -0.01154615f, 0.05969112f, 0.32177445f, 
    0.10272004f, -0.01719129f, 0.04071296f, -0.26347926f, -0.16427799f, -0.05827191f, 0.36063015f, 0.04906274f, 
    0.04959567f, 0.00980486f, -0.05979415f, 0.00438493f, -0.05495762f, 0.02423901f, 0.16792175f, -0.21480049f, 
    -0.04924235f, 0.16290335f, 0.02036758f, -0.04691774f, -0.08465011f, 0.10960829f, -0.04368744f, -0.41647637f, 
    -0.14900738f, -0.05065925f, 0.19278724f, 0.09253422f, 0.01314133f, 0.02537711f, 0.23311232f, 0.09178598f, 
    0.12029166f, 0.13305651f, -0.09418570f, 0.08773246f, -0.09872966f, 0.08853352f, 0.07335808f, 0.08049875f, 
    0.00162233f, 0.05671944f, 0.13370973f, 0.04878738f, -0.04036520f, -0.13552718f, -0.18863864f, -0.15546422f, 
    -0.21259683f, -0.05681941f, -0.00669895f, 0.02102430f, 0.11105458f, -0.10130192f, 0.26280087f, 0.09511475f, 
    -0.09026051f, 0.07227873f, -0.15937531f, -0.11340082f, -0.14809987f, -0.22578247f, 0.09044533f, -0.26518410f, 
    -0.13788050f, 0.39127392f, -0.13006423f, -0.25558501f, -0.23826568f, 0.04283039f, -0.25366455f, -0.16445535f, 
    -0.23801401f, -0.06008441f, 0.12260269f, 0.07244913f, 0.24202856f, 0.12573251f, -0.09059903f, 0.17237656f, 
    0.13826047f, 0.03425106f, 0.19065443f, 0.04843302f, -0.02327841f, 0.13806529f, 0.14683066f, 0.15207636f, 
    -0.34389117f, -0.08062340f, -0.02774249f, 0.06989494f, -0.06738492f, -0.01744498f, -0.04547447f, -0.16501291f, 
    -0.15590626f, 0.05606127f, -0.14227913f, -0.24556495f, 0.06009246f, 0.09236593f, -0.03887039f, 0.36779550f, 
    -0.13498622f, 0.06138508f, 0.11241348f, 0.13726605f, 0.34526312f, 0.07361206f, 0.10467317f, 0.09235767f, 
    0.19555967f, -0.14840502f, -0.00410027f, 0.11082114f, 0.08700827f, 0.03525797f, 0.00891137f, -0.03024235f, 
    0.04642044f, 0.02831598f, 0.11062779f, 0.05545720f, -0.05487393f, 0.15364712f, -0.21342672f, 0.06471771f, 
    -0.11621091f, -0.15181367f, 0.00347483f, 0.07145943f, 0.09873454f, -0.08373265f, 0.03349992f, 0.05171851f, 
    0.45106000f, 0.28562769f, -0.38452935f, 0.11087567f, -0.04457846f, 0.02090786f, 0.14567852f, -0.00390981f, 
    -0.04607170f, 0.01514374f, -0.03426424f, -0.00680205f, -0.12333797f, 0.03913115f, -0.12396561f, -0.01784365f, 
    0.08879039f, -0.23350325f, 0.06148174f, -0.07334143f, -0.05270140f, -0.05547693f, -0.14770722f, 0.01113555f, 
    0.00523729f, -0.04608071f, -0.04349739f, 0.37405312f, -0.10887230f, 0.07371106f, 0.06198731f, -0.02484996f, 
    0.06379605f, 0.00602420f, 0.05406311f, -0.07490888f, 0.19887713f, 0.11591661f, -0.15654312f, -0.12118990f, 
    0.08048777f, -0.04822990f, 0.02887443f, 0.00599539f, -0.08584626f, -0.03144625f, 0.07242375f, -0.01149747f, 
    -0.13685124f, 0.16081089f, 0.08818279f, -0.12906148f, -0.14233449f, 0.04476523f, 0.13500309f, -0.03219653f, 
    0.00922652f, 0.00892916f, -0.02949058f, 0.07173847f, -0.22689299f, 0.02503901f, -0.05429625f, 0.22088477f, 
    0.13533106f, 0.05963742f, 0.24748062f, -0.01711840f, 0.05116493f, -0.06621461f, 0.01438721f, -0.00682778f, 
    -0.22372550f, 0.14770076f, 0.12081026f, 0.10687531f, -0.00712984f, -0.08029310f, -0.04847249f, -0.11021580f, 
    0.24841417f, 0.05549676f, -0.02011435f, 0.00747502f, -0.22839247f, 0.25287697f, -0.24654934f, 0.06911612f, 
    0.09152354f, 0.06594132f, -0.08430375f, -0.23728159f, -0.02758492f, 0.01343009f, 0.02035790f, -0.02100846f, 
    0.12816423f, -0.17581283f, -0.07072655f, 0.06790852f, -0.08229364f, 0.01049454f, 0.12140647f, 0.01479117f, 
    0.04377656f, 0.08724274f, -0.04708398f, -0.10813026f, -0.02432973f, -0.27350876f, 0.11480061f, 0.09315272f, 
    0.01106182f, -0.06374675f, 0.01863272f, -0.07326133f, 0.13766427f, -0.09478880f, -0.13916531f, 0.11976118f, 
    -0.22413190f, -0.71213323f, 0.23049738f, 0.62705904f, -0.09920695f, -0.04735693f, -0.24755146f, -0.02821945f, 
    0.07766573f, 0.14496490f, -0.19720748f, 0.03196102f, -0.24016085f, -0.03351872f, 0.18530446f, -0.01151587f, 
    0.05093068f, 0.03915520f, -0.06531598f, 0.02665743f, 0.08955525f, 0.09529137f, 0.14769094f, 0.14873992f, 
    0.15822214f, -0.09354062f, -0.03208847f, -0.34777066f, 0.10474325f, 0.03357529f, -0.07082453f, -0.07765266f, 
    0.02570431f, 0.09441730f, -0.06332745f, 0.03294641f, -0.06401222f, 0.27437964f, 0.04344938f, 0.08749403f, 
    0.02290340f, -0.04283584f, 0.07892013f, -0.05016182f, 0.00528038f, -0.02854141f, 0.02435345f, 0.01504816f, 
    0.05951459f, -0.03762849f, 0.17907922f, -0.17714101f, 0.04221857f, -0.13617490f, -0.01473720f, -0.19145790f, 
    0.01059406f, 0.07958333f, -0.10839935f, -0.12099157f, 0.22549127f, -0.30469745f, -0.15651505f, -0.03925759f, 
    0.09121177f, 0.04758390f, 0.06219597f, 0.05026938f, 0.01332939f, 0.13685942f, 0.08076527f, -0.05252375f, 
    0.14107265f, 0.00962197f, 0.28363091f, 0.24131240f, -0.10309422f, -0.19965041f, -0.20640934f, 0.07269364f, 
    -0.00540256f, -0.03816826f, -0.06274290f, -0.15632550f, 0.07871649f, 0.22085205f, -0.06321831f, 0.17342794f, 
    -0.02246863f, -0.10476190f, -0.12498425f, 0.16756654f, -0.00383680f, 0.01373985f, 0.05757584f, -0.06844936f, 
    0.28414595f, 0.06590454f, 0.20739885f, -0.06380060f, 0.32901168f, 0.01263476f, -0.01880364f, -0.04089900f, 
    0.03146939f, 0.13637012f, 0.07191955f, 0.00220399f, -0.19318862f, -0.14663891f, 0.24571474f, -0.06250067f, 
    0.01008121f, 0.10329582f, -0.11039642f, -0.00031497f, 0.03293528f, -0.04082179f, 0.02481124f, -0.05019218f, 
    0.23254706f, 0.09148870f, 0.04147875f, 0.09022513f, 0.19378942f, 0.15932648f, 0.05105587f, 0.20563190f, 
    0.13327575f, 0.09402099f, -0.04561564f, -0.07541914f, 0.27332935f, 0.16539986f, 0.10812364f, -0.00502707f, 
    0.08191139f, 0.06976458f, -0.06375013f, 0.26791602f, -0.00439920f, -0.01627361f, 0.00584695f, 0.04320237f, 
    -0.03963982f, 0.14400697f, -0.00239195f, 0.11925934f, -0.08383352f, -0.01813387f, -0.03050113f, -0.14245559f, 
    -0.14266656f, -0.06142703f, 0.01602858f, -0.09029243f, -0.16715112f, 0.17119710f, 0.30094635f, -0.07098652f, 
    -0.14634353f, -0.18883131f, -0.13340917f, 0.05487870f, 0.06897984f, 0.01087585f, 0.25037351f, 0.09113108f, 
    0.05129126f, 0.21875764f, 0.20278829f, 0.05257467f, -0.17111686f, -0.23873408f, -0.18338479f, -0.11827873f, 
    0.00509831f, -0.04527039f, 0.14985038f, -0.00481928f, 0.08109166f, -0.03772748f, -0.00417464f, -0.42512849f, 
    -0.05115816f, 0.09761915f, 0.12322775f, 0.09613273f, 0.23749970f, -0.01014372f, 0.19625217f, 0.06626884f, 
    0.03481814f, 0.44214159f, -0.20742624f, -0.20111412f, 0.01954485f, 0.16783252f, -0.07971135f, -0.06411173f, 
    -0.00245652f, -0.08350284f, 0.00987832f, -0.02731013f, 0.09943940f, 0.14112400f, 0.20164908f, 0.02442143f, 
    0.16025893f, 0.07780123f, 0.11589302f, 0.05194429f, -0.01211231f, -0.06644132f, -0.07825622f, 0.03481277f, 
    -0.13611484f, -0.06611281f, -0.07600245f, -0.24535759f, -0.12553157f, 0.13940710f, 0.07650837f, -0.01410662f, 
    0.03451001f, 0.14903726f, 0.12002409f, 0.00561237f, 0.01143092f, -0.00234551f, 0.11267007f, 0.00571205f, 
    0.07675746f, -0.01426696f, 0.03815655f, 0.19511580f, 0.04252161f, -0.07793808f, 0.10585806f, 0.01977146f, 
    -0.17286099f, -0.35077819f, 0.01894597f, -0.28589621f, -0.08610258f, 0.00575928f, -0.12148387f, 0.00873166f, 
    -0.11855232f, 0.05790182f, 0.11913265f, -0.01160821f, 0.32800043f, -0.15868576f, 0.11491406f, 0.06558267f, 
    0.08660039f, 0.10435373f, 0.04219240f, 0.18124592f, 0.06892084f, 0.04970104f, -0.00695177f, 0.01841480f, 
    -0.21470158f, 0.13736185f, 0.31521013f, 0.19058882f, -0.02142142f, 0.03780165f, 0.02538368f, 0.02405700f, 
    0.06414336f, 0.04088984f, 0.08757820f, -0.04845063f, 0.16987105f, 0.13587545f, 0.19981483f, 0.17867638f, 
    0.03913605f, 0.03198356f, 0.02184632f, 0.07628762f, 0.09165134f, -0.07954723f, 0.08715360f, -0.15754578f, 
    0.21998557f, -0.12210230f, -0.05508419f, 0.23944174f, 0.07273526f, 0.09185361f, -0.10407866f, -0.01804576f, 
    -0.11298668f, 0.14921750f, -0.07652375f, 0.03790744f, -0.02944494f, -0.04083843f, 0.03110339f, 0.20369980f, 
    -0.11945897f, 0.11340889f, -0.08511669f, 0.08118227f, 0.00592546f, 0.11910584f, -0.10080139f, -0.06724924f, 
    -0.04741347f, -0.14577016f, 0.09764605f, 0.22595614f, 0.05467623f, 0.01645155f, 0.01514980f, -0.15394393f, 
    0.04591165f, -0.06675626f, 0.09690263f, 0.09455155f, 0.01948685f, -0.19212651f, 0.10322445f, 0.19179140f, 
    0.13036326f, 0.09916238f, 0.02156345f, 0.13916779f, -0.05240541f, -0.12719344f, -0.11033333f, 0.07131910f, 
    0.19609089f, 0.02275245f, -0.04129694f, -0.17139401f, -0.04339440f, -0.08730380f, 0.02848548f, 0.04411015f, 
    -0.00400551f, 0.01184353f, -0.06992379f, -0.05186439f, -0.31645188f, -0.24938576f, -0.17293565f, -0.01383398f, 
    -0.15942758f, -0.10925464f, -0.05556056f, -0.03715784f, 0.05038223f, -0.01180060f, -0.08212997f, -0.07598890f, 
    -0.20708826f, 0.01383159f, -0.22745104f, -0.01987238f, 0.00787918f, -0.08435567f, -0.07076275f, 0.01640162f, 
    0.03164458f, 0.00742097f, -0.07274070f, -0.04326027f, 0.26424307f, -0.09882634f, 0.10677389f, -0.33189353f, 
    0.16431004f, -0.03823195f, 0.03178621f, -0.04717034f, 0.04713338f, 0.08936220f, -0.04659475f, 0.07975487f, 
    0.21379764f, 0.09783070f, 0.15155464f, -0.55091727f, -0.05089444f, -0.07163565f, 0.06015151f, -0.00660124f, 
    -0.01591733f, 0.05276775f, -0.03279196f, 0.00166384f, -0.19920862f, -0.07230581f, -0.07934123f, 0.17248969f, 
    0.11134199f, 0.12839337f, 0.05270910f, 0.03110269f, -0.06348804f, -0.00441414f, 0.04267220f, 0.08532639f, 
    -0.15174143f, 0.00496566f, -0.06303013f, 0.08003991f, 0.06046361f, 0.05878419f, -0.10892624f, -0.12527558f, 
    0.28910989f, 0.07912727f, 0.00451669f, 0.06767724f, -0.03797608f, 0.00907991f, 0.13959968f, 0.26952773f, 
    0.32589662f, 0.22488238f, 0.11821707f, -0.02324880f, 0.00428513f, -0.09110314f, 0.08449580f, 0.05434127f, 
    -0.07495388f, -0.10363790f, -0.01897127f, 0.00459363f, 0.01806100f, 0.03807070f, 0.01361178f, -0.09167606f, 
    0.03136693f, -0.05663444f, -0.06654035f, 0.03806337f, 0.03208410f, -0.01805207f, 0.00872359f, -0.05569621f, 
    0.00675400f, -0.06006979f, -0.04102099f, -0.01042369f, 0.01859859f, -0.05511739f, -0.00173511f, 0.03574155f, 
    -0.03696378f, -0.02800746f, -0.06607593f, -0.01761129f, -0.00131867f, 0.01320727f, 0.00233084f, -0.06041256f, 
    0.00417554f, -0.06323252f, -0.06103483f, -0.01127951f, 0.02176643f, -0.09199581f, -0.09023462f, -0.05897836f, 
    0.01051425f, -0.01752320f, -0.02954039f, -0.02803213f, 0.02609994f, -0.03914727f, -0.05112280f, -0.00184411f, 
    0.02848832f, 0.00623394f, -0.08706575f, 0.05123483f, -0.04459942f, 0.00975739f, 0.00844524f, -0.07905354f, 
    -0.06199865f, 0.03318499f, -0.01964284f, -0.08978865f, 0.02497217f, 0.01842610f, -0.05716325f, -0.10205253f, 
    -0.00599327f, 0.00309364f, 0.03723980f, -0.09058546f, 0.04896336f, -0.08062799f, -0.02333379f, -0.01627149f, 
    -0.05697617f, 0.01401303f, -0.03314520f, 0.04026787f, -0.05789781f, -0.01515371f, -0.02011928f, 0.02245367f, 
    0.00645769f, -0.04624025f, -0.00784222f, 0.00836849f, -0.05796487f, -0.05738482f, -0.06463035f, -0.08275343f, 
    -0.05145707f, 0.02517346f, -0.07088572f, -0.01475420f, -0.02282070f, -0.07445940f, -0.01767814f, 0.02550491f, 
    -0.05222783f, -0.04456773f, 0.04219041f, -0.02249756f, 0.02646849f, 0.02740891f, -0.03224742f, -0.02772677f, 
    0.02588071f, -0.06747424f, 0.00708213f, 0.01262719f, 0.00949555f, -0.02943266f, -0.00381249f, 0.03585900f, 
    0.01420182f, -0.07753085f, 0.02811518f, -0.08183583f, 0.00196835f, -0.06127562f, -0.02053524f, 0.00858204f, 
    -0.04727021f, -0.00751229f, -0.06616162f, 0.00469111f, -0.04410579f, -0.02759219f, -0.02186698f, -0.07980228f, 
    0.01962219f, -0.01554367f, -0.09080849f, -0.08607502f, -0.04502377f, -0.03021447f, -0.07979213f, -0.07965136f, 
    0.01305542f, -0.03702148f, 0.02716384f, -0.01538226f, 0.01620100f, -0.03689234f, 0.01789178f, 0.02667607f, 
    -0.04217093f, -0.08347746f, -0.08014805f, -0.04929670f, -0.01587451f, -0.03111465f, -0.03128702f, -0.03312109f, 
    -0.05941791f, 0.01910878f, 0.00821759f, -0.05496541f, 0.01866544f, 0.03277346f, -0.08178250f, 0.03101128f, 
    -0.05008504f, 0.05734955f, 0.00579015f, 0.04512771f, -0.05047975f, 0.00311608f, -0.03237062f, -0.05466425f, 
    -0.01773933f, -0.04098682f, -0.07520126f, -0.03737260f, -0.07140684f, -0.00878643f, -0.04906658f, -0.08453152f, 
    0.02053239f, -0.02280569f, -0.01217373f, 0.03489603f, 0.00513536f, -0.04742187f, 0.01469850f, 0.02298140f, 
    -0.03148344f, -0.00788920f, 0.02812783f, 0.01083775f, -0.05857743f, 0.03622350f, -0.01349056f, -0.09006994f, 
    0.03460968f, 0.07647560f, 0.11283034f, -0.06086524f, 0.06353405f, 0.10340421f, 0.01772296f, 0.06789371f, 
    0.15299883f, 0.04397851f, 0.09114413f, 0.10320064f, 0.15737571f, 0.30107403f, 0.02433962f, -0.04681820f, 
    -0.10376687f, 0.01621194f, 0.09024257f, 0.11190528f, -0.02351899f, 0.04855971f, 0.16203824f, -0.01625361f, 
    -0.32971019f, 0.33865759f, -0.14643829f, 0.00863614f, 0.02009091f, -0.09154477f, 0.04430216f, -0.07744770f, 
    -0.00749156f, -0.02310478f, -0.06178874f, 0.04375270f, -0.19715048f, -0.10607393f, -0.01239634f, 0.13205938f, 
    -0.22170706f, 0.11488234f, 0.02358032f, -0.14983059f, -0.01539614f, 0.01644143f, 0.03269985f, 0.05722982f, 
    0.04291534f, 0.11625672f, -0.15721621f, -0.11784802f, 0.17498110f, 0.09061179f, -0.00854896f, 0.09753209f, 
    -0.01185115f, -0.01273506f, 0.20765190f, -0.09914470f, 0.10160901f, 0.02002864f, -0.04232579f, -0.15602890f, 
    0.09534736f, -0.00404212f, -0.01139193f, -0.02620570f, -0.00031687f, -0.00386167f, 0.16257402f, 0.01406874f, 
    -0.10405976f, -0.13229614f, 0.04459583f, -0.08252884f, -0.02206976f, 0.01019037f, 0.20407893f, 0.12006676f, 
    0.05425268f, 0.02731566f, -0.09150786f, -0.01033537f, -0.07119618f, 0.01408128f, -0.08608040f, 0.17213821f, 
    0.00293909f, -0.18445568f, -0.00161706f, -0.14031836f, 0.03891089f, 0.05983779f, 0.08902272f, 0.06803773f, 
    0.08496857f, 0.08052932f, 0.36558565f, -0.04392563f, -0.05605537f, -0.00705658f, 0.02325517f, -0.03511630f, 
    0.08391361f, 0.20623377f, -0.02530645f, 0.16223855f, -0.10124673f, 0.14372224f, -0.07338122f, -0.03680744f, 
    0.12743017f, 0.07384685f, 0.02674892f, 0.05783098f, -0.04533365f, -0.09689125f, -0.00937667f, -0.03159191f, 
    0.03503491f, 0.02482004f, 0.13115799f, -0.07706290f, -0.10120936f, -0.03905268f, -0.02268167f, -0.03686607f, 
    -0.03706811f, -0.07471918f, -0.03893033f, 0.07550099f, 0.15028933f, 0.03361079f, -0.05698684f, 0.11182390f, 
    0.02375005f, -0.02494066f, 0.00491272f, 0.08178245f, 0.01539290f, 0.07728448f, 0.12168367f, 0.11344348f, 
    0.66734350f, -0.03011169f, -0.13129506f, 0.27021968f, 0.04886095f, 0.12196612f, -0.08712985f, -0.06303960f, 
    0.07410634f, 0.04552513f, 0.14853686f, 0.13658036f, 0.21609153f, -0.12801228f, -0.12451781f, 0.00688613f, 
    -0.09624556f, 0.01043110f, -0.11503971f, 0.14074686f, 0.01306552f, -0.11239737f, -0.13445981f, -0.01976474f, 
    0.00637245f, 0.09243981f, 0.13578527f, 0.05456139f, -0.04957675f, 0.08132891f, 0.23872994f, 0.26238367f, 
    0.15789790f, -0.04367004f, 0.08707966f, 0.19435228f, -0.10451310f, 0.02940693f, -0.07893643f, -0.07890438f, 
    0.06189387f, -0.06047186f, 0.11648925f, 0.04823520f, 0.07376380f, -0.00717535f, -0.14423452f, 0.00501009f, 
    -0.19373034f, 0.16043338f, -0.04428960f, -0.12296644f, -0.01549828f, -0.17888266f, 0.05091983f, -0.26088604f, 
    -0.17855954f, -0.10108363f, -0.16029701f, -0.15487285f, 0.23403205f, 0.29427770f, 0.18560925f, 0.09073452f, 
    -0.07015663f, 0.04073794f, 0.13170791f, 0.10401767f, -0.03168826f, -0.14208686f, 0.01031354f, -0.04662564f, 
    -0.66912091f, -0.11699613f, 0.08744011f, -0.21247272f, 0.09880746f, -0.01704063f, -0.23109637f, 0.02881350f, 
    -0.00324354f, 0.02705133f, 0.02112368f, 0.07453530f, -0.02629629f, 0.02463395f, -0.17761335f, -0.13713552f, 
    0.19295305f, 0.13615426f, -0.09297729f, -0.04227491f, -0.01027014f, -0.04408009f, -0.00398542f, -0.12381184f, 
    -0.20503803f, 0.25713718f, -0.08628844f, -0.10559402f, -0.06240888f, -0.18441327f, 0.22496009f, 0.08413345f, 
    0.03642692f, 0.05922337f, -0.03118745f, 0.06936422f, 0.17104690f, 0.01301734f, 0.21068950f, -0.26344812f, 
    0.14665787f, -0.01484548f, -0.12609211f, -0.09122737f, 0.09378429f, 0.00010467f, 0.15040748f, 0.19942348f, 
    0.20178911f, 0.18582465f, 0.19637309f, 0.14027956f, 0.10062654f, 0.24163732f, 0.24548171f, 0.10495480f, 
    -0.01398510f, 0.01474742f, -0.02033046f, -0.06960829f, 0.14094768f, 0.16965283f, -0.08168837f, 0.00055963f, 
    -0.09566392f, -0.02307978f, -0.06343706f, 0.09586297f, 0.16704023f, 0.05064653f, -0.01407518f, 0.01191594f, 
    -0.33769283f, -0.59297520f, -0.36290267f, -0.10503072f, -0.03974815f, -0.07659053f, 0.00316312f, 0.07236830f, 
    -0.15614602f, 0.15656309f, -0.09037503f, -0.00542597f, -0.13846724f, -0.06941837f, -0.21804880f, -0.18337831f, 
    0.16595550f, -0.04549795f, -0.29553437f, -0.00613836f, -0.13279009f, -0.03271722f, -0.01139918f, 0.16760857f, 
    -0.29872790f, -0.23220359f, 0.01084375f, -0.75610107f, -0.00325106f, -0.03108095f, -0.11138190f, -0.17250706f, 
    -0.09843097f, -0.11085127f, 0.11313625f, -0.01123037f, 0.03705314f, 0.15924990f, -0.31197724f, 0.11852200f, 
    -0.18840727f, -0.03915014f, 0.09084136f, 0.07402486f, 0.04170094f, 0.04929110f, -0.13435110f, -0.05752103f, 
    -0.08781712f, -0.12539072f, -0.49936190f, 0.13512774f, -0.02769575f, -0.08174899f, 0.00319532f, 0.05908226f, 
    0.11503867f, 0.08804618f, -0.06085872f, -0.02758720f, 0.36577797f, 0.18781406f, 0.18190663f, 0.11694563f, 
    -0.00245051f, -0.08286858f, -0.00801883f, 0.21616252f, 0.00144868f, 0.01339567f, 0.01404168f, 0.34736615f, 
    -0.13048041f, 0.04964153f, 0.00145948f, -0.32295787f, -0.07327438f, -0.07751296f, 0.05748790f, 0.11492959f, 
    -0.13027564f, -0.03794741f, 0.10998687f, 0.02255735f, -0.01568725f, 0.02855665f, -0.05345206f, -0.12763315f, 
    0.05366072f, 0.00385345f, -0.06624670f, 0.25163251f, 0.03261431f, 0.01403815f, -0.01194351f, 0.09605259f, 
    -0.02409641f, -0.02096586f, -0.11162718f, 0.01852246f, -0.00635932f, 0.07376128f, -0.10344644f, -0.05335174f, 
    0.10508098f, 0.01101348f, 0.25242943f, -0.01800654f, 0.19500548f, 0.24476497f, -0.02786116f, -0.09543952f, 
    -0.15920843f, -0.14548199f, -0.10889649f, 0.02258704f, -0.00085115f, 0.06613390f, 0.05458781f, 0.00242411f, 
    0.01139307f, 0.22334392f, -0.53305292f, -0.03748778f, -0.07268006f, -0.03362121f, 0.15394071f, -0.05899016f, 
    0.11517609f, 0.02204685f, 0.00215163f, 0.03847669f, 0.07134810f, -0.23002441f, -0.17882830f, 0.02525466f, 
    0.04850287f, 0.14725162f, 0.05138325f, -0.05463247f, 0.14010467f, -0.07412773f, -0.02263295f, 0.07830610f, 
    -0.24277343f, 0.03952441f, 0.03457486f, -0.08714414f, -0.08701412f, 0.15795611f, 0.06404843f, 0.03632692f, 
    -0.01710254f, 0.14484484f, 0.08708649f, -0.00613785f, 0.04586062f, 0.01947035f, -0.16731136f, -0.04917577f, 
    -0.04110044f, -0.09242533f, 0.05160037f, 0.02051155f, -0.13204485f, -0.11613510f, -0.05531478f, -0.10937733f, 
    0.04383001f, 0.03833748f, 0.22197305f, 0.12863488f, -0.06507567f, 0.05395193f, 0.23455752f, 0.13606513f, 
    0.05593174f, 0.04342429f, 0.01374943f, 0.06202924f, -0.42136872f, 0.03864989f, 0.08038921f, 0.04539891f, 
    -0.03590266f, -0.05027670f, 0.08833364f, 0.13151093f, -0.04861467f, -0.02135558f, 0.05651867f, 0.04506960f, 
    0.20669442f, 0.11644530f, 0.27324846f, 0.00124039f, 0.04825561f, 0.01841561f, -0.05068033f, -0.04046779f, 
    0.12648137f, -0.20724076f, -0.14618291f, -0.06282979f, -0.01314670f, -0.05443317f, -0.17411645f, 0.11003684f, 
    0.15528038f, 0.15460348f, 0.02487013f, -0.16032735f, 0.01337897f, 0.07603964f, 0.04492056f, 0.00028049f, 
    0.03090753f, 0.03916134f, -0.08596172f, 0.15754360f, -0.08088345f, -0.06247694f, -0.02722029f, -0.04685784f, 
    0.11018891f, 0.00590787f, 0.00605656f, 0.09176319f, 0.08303051f, -0.05075779f, 0.17631748f, 0.02920169f, 
    0.04929318f, 0.05266553f, 0.10880589f, -0.03479347f, 0.11752880f, -0.00350913f, -0.00550158f, 0.07542825f, 
    0.20906682f, -0.37257800f, 0.31107545f, 0.02428237f, -0.00183913f, 0.05154097f, -0.10585429f, -0.01946741f, 
    -0.03405474f, -0.01181820f, -0.06318628f, -0.03932280f, -0.01316405f, 0.01293855f, 0.18961814f, 0.12696418f, 
    0.10184579f, 0.07036945f, -0.06984213f, 0.10740975f, -0.01122314f, -0.07619947f, 0.05554553f, -0.05863106f, 
    0.23052078f, 0.04514208f, -0.01540535f, 0.15459912f, -0.04817234f, 0.16304322f, -0.05966665f, -0.11490128f, 
    0.02099585f, -0.03382811f, -0.05832722f, 0.07349865f, -0.11122937f, 0.04949949f, -0.13041204f, 0.13930795f, 
    0.13921763f, 0.00727292f, 0.15086807f, 0.01406500f, -0.09918654f, -0.05600546f, -0.22847271f, -0.11463507f, 
    -0.15151684f, 0.01985713f, -0.07341351f, -0.01093125f, -0.02662749f, 0.01803360f, -0.04974330f, -0.02218593f, 
    -0.01049678f, 0.24060386f, 0.02242786f, 0.11137161f, -0.16843496f, -0.04289921f, 0.38765383f, 0.07613743f, 
    0.02023035f, 0.11289218f, 0.12477034f, 0.02646768f, -0.01392173f, -0.08485488f, -0.00648820f, 0.03298930f, 
    -0.40876940f, -0.16889083f, 0.36930725f, 0.22172317f, 0.11862067f, 0.07558253f, 0.08516444f, 0.02448641f, 
    -0.09833385f, 0.04505320f, -0.00457947f, 0.04387391f, 0.03923300f, -0.05811572f, 0.10007016f, -0.23048586f, 
    -0.10260201f, 0.00592519f, 0.09747116f, 0.03425656f, 0.04647949f, 0.06576745f, 0.07057379f, 0.05809066f, 
    0.15352769f, 0.17879292f, -0.06441282f, -0.17650272f, -0.05096175f, -0.05241309f, 0.04361371f, 0.06641890f, 
    0.02344793f, 0.06351210f, -0.08365825f, 0.09251080f, -0.00928147f, 0.04236967f, 0.15488786f, 0.15836020f, 
    -0.02421630f, -0.02479150f, -0.01418880f, -0.04703457f, 0.11898196f, 0.07294982f, 0.12190719f, 0.03062180f, 
    0.05686044f, -0.20207846f, -0.08066915f, 0.09840521f, 0.17276107f, 0.10006882f, 0.15861616f, -0.11707519f, 
    0.04274066f, 0.06915677f, 0.00167316f, 0.02394420f, 0.15396425f, -0.19616731f, -0.20472869f, -0.22285132f, 
    0.12961909f, 0.18031256f, -0.10980820f, 0.08717924f, 0.14892513f, 0.02907301f, -0.06746988f, 0.09679783f, 
    -0.03328096f, -0.18962745f, -0.04594624f, 0.13938119f, 0.01368774f, -0.00756853f, 0.06266627f, 0.06339183f, 
    -0.05629564f, 0.02016323f, -0.14259900f, 0.02103771f, -0.19346304f, -0.18860601f, -0.16631663f, -0.10403237f, 
    -0.18120156f, -0.14898658f, -0.12893113f, -0.01396969f, -0.14094365f, -0.07462509f, -0.10666834f, -0.03505240f, 
    -0.18971771f, -0.18800981f, -0.17028210f, -0.12363341f, 0.11304985f, 0.02656024f, 0.02695671f, -0.05643700f, 
    -0.00943255f, -0.00309835f, 0.08667910f, 0.04990094f, 0.07852529f, 0.01104621f, -0.08282235f, -0.03526875f, 
    0.02301637f, 0.02244854f, 0.06917290f, 0.05471725f, -0.00732263f, 0.24010363f, 0.14161016f, 0.21776070f, 
    -0.24668702f, 0.18987562f, -0.04711105f, 0.09532932f, -0.05676132f, -0.01444039f, 0.05520002f, 0.11602229f, 
    0.06290228f, -0.00944209f, 0.02021487f, -0.05992707f, 0.09308991f, 0.03274855f, -0.09844017f, -0.15809645f, 
    0.13510747f, 0.15095183f, 0.10455792f, 0.05333077f, -0.01767753f, 0.01139942f, -0.10140106f, -0.04469586f, 
    -0.02133337f, -0.00145375f, -0.05165914f, -0.00415206f, 0.03239877f, -0.15520951f, 0.11727972f, -0.15967551f, 
    0.23073179f, 0.07947288f, 0.09677504f, 0.01849746f, 0.07264797f, -0.20207110f, 0.06261232f, -0.19283754f, 
    0.05748894f, 0.18473616f, 0.10116220f, 0.12545127f, -0.02242878f, -0.01933820f, 0.06493114f, 0.13906041f, 
    0.07998309f, -0.28690553f, 0.08917081f, -0.08462477f, -0.03859935f, 0.17984383f, -0.17547695f, -0.13952810f, 
    0.01345545f, 0.02617295f, 0.15138850f, 0.05228255f, 0.02991006f, -0.40479091f, -0.12298730f, -0.11172211f, 
    0.06855496f, -0.12757608f, -0.05977015f, 0.05612260f, 0.03656079f, 0.02944235f, -0.00851317f, -0.09517626f, 
    0.29793191f, -0.00292679f, 0.03791571f, 0.06975834f, -0.02233828f, -0.18833055f, -0.05191637f, -0.00071231f, 
    0.11431178f, -0.02748057f, -0.07488897f, -0.16823632f, 0.20142350f, 0.06455850f, -0.13006473f, 0.06702156f, 
    -0.01617067f, -0.10123318f, -0.06561025f, 0.29793721f, -0.02840952f, 0.08437596f, -0.00310706f, 0.21842514f, 
    0.27910894f, -0.25315908f, 0.29995778f, 0.27374777f, 0.07055986f, 0.04286199f, -0.12389190f, 0.08671070f, 
    0.18021214f, 0.07251201f, -0.01698580f, 0.13672154f, -0.13526532f, -0.12466767f, 0.11549126f, 0.17813592f, 
    -0.01801983f, 0.12735134f, 0.07307998f, 0.12775163f, 0.14059336f, -0.00720947f, 0.00934408f, -0.18908298f, 
    -0.07379118f, 0.11254915f, 0.16826680f, 0.07913724f, 0.01102044f, 0.07970752f, -0.01158196f, 0.06468862f, 
    0.05704434f, -0.01543979f, 0.01709802f, 0.13253509f, -0.08081161f, -0.11146490f, 0.18249527f, 0.23598783f, 
    0.03930317f, 0.11679325f, 0.06146305f, 0.13491666f, 0.02210629f, -0.14346713f, 0.04307837f, 0.09072790f, 
    0.08405795f, -0.06001858f, -0.02812352f, 0.16400988f, -0.05995016f, -0.10609724f, -0.13963293f, -0.26940873f, 
    0.06286993f, -0.11108555f, 0.11416847f, 0.04832865f, -0.38609928f, -0.26944146f, 0.23985322f, -0.23446767f, 
    -0.30569974f, -0.04010394f, -0.08916772f, 0.12270302f, -0.00338923f, -0.03186988f, 0.10504241f, -0.04686975f, 
    -0.02355597f, 0.18452345f, 0.04089151f, -0.03344542f, -0.12762977f, -0.30383062f, -0.06603763f, -0.03719448f, 
    0.03396779f, -0.08801176f, 0.06929057f, 0.06086402f, -0.02931117f, -0.25518352f, 0.20515126f, -0.37137285f, 
    0.00164929f, 0.04805508f, 0.18092531f, -0.08105367f, 0.17916577f, -0.09737997f, 0.04439443f, 0.05212530f, 
    0.10097421f, 0.16571240f, 0.17197372f, -0.25657931f, -0.07605335f, -0.12125230f, -0.30134049f, 0.07714055f, 
    0.08876733f, -0.06733784f, -0.03709728f, -0.17034051f, -0.19933636f, -0.00916349f, 0.25971487f, 0.06289607f, 
    0.18183142f, 0.21427128f, 0.07743920f, 0.10253248f, 0.08460630f, 0.00255543f, -0.12397581f, -0.11830917f, 
    0.10058855f, -0.02929759f, -0.02439487f, -0.36414272f, 0.04240919f, 0.22653326f, -0.02997015f, -0.13250513f, 
    0.13995481f, 0.05030315f, 0.13541207f, -0.03157942f, -0.15421417f, -0.08315902f, 0.04568573f, 0.05124488f, 
    0.12007596f, -0.03014664f, 0.08289643f, 0.09271479f, -0.12442524f, -0.08305619f, 0.05774147f, 0.11972757f, 
    0.14858471f, -0.11159043f, 0.03313117f, 0.02625095f, 0.03965209f, 0.01055958f, 0.01465965f, 0.04209642f, 
    0.15646991f, -0.15759775f, 0.02735163f, 0.15201794f, -0.43307909f, -0.30305049f, -0.33783427f, 0.05019308f, 
    0.00662114f, 0.05538156f, -0.10681400f, -0.01907753f, 0.23586386f, 0.11155450f, -0.10368647f, -0.06529727f, 
    0.45425251f, -0.00590325f, -0.18095154f, -0.14480683f, 0.03691690f, 0.08646922f, -0.02770296f, 0.09074855f, 
    0.02553016f, 0.01106653f, 0.07138361f, -0.05596744f, -0.11676311f, 0.21633612f, -0.09535022f, 0.36051974f, 
    0.22358705f, -0.16713652f, -0.12094983f, 0.01060060f, -0.02350980f, 0.02432027f, -0.03756137f, 0.09290111f, 
    0.15242942f, -0.23517609f, 0.26834926f, 0.15369499f, -0.05372416f, -0.12833099f, 0.12521464f, 0.00364203f, 
    0.07824347f, -0.13871862f, -0.00338683f, 0.02040881f, -0.01072156f, -0.18092515f, -0.06555364f, 0.03910841f, 
    0.15043031f, 0.06338721f, 0.07094346f, 0.11443165f, -0.00281203f, -0.01566513f, 0.11343970f, -0.02652600f, 
    -0.01476560f, 0.31426454f, -0.01871893f, -0.07416984f, -0.01336035f, 0.02476166f, 0.01014486f, -0.02285611f, 
    0.05514781f, -0.06281823f, 0.08270027f, 0.06379503f, 0.17725736f, 0.26054350f, 0.08196423f, 0.00864719f, 
    -0.03733858f, 0.02663525f, 0.08582514f, 0.07846123f, -0.01312682f, 0.01070543f, 0.04756336f, -0.01863489f, 
    -0.19983488f, 0.19242691f, -0.29233375f, -0.04521042f, 0.05668380f, -0.02531811f, -0.09043027f, -0.01697229f, 
    0.13134816f, 0.03336535f, 0.19354634f, 0.13595906f, 0.02238395f, 0.12450241f, 0.24584165f, 0.10808167f, 
    0.14610517f, 0.08517357f, -0.08441809f, -0.10316242f, -0.07303128f, 0.11252906f, 0.03024868f, -0.02274445f, 
    0.13604674f, 0.22747152f, -0.07818449f, 0.16515832f, 0.03441551f, -0.06090528f, -0.06511720f, 0.05987778f, 
    -0.01563468f, 0.06322783f, -0.09412625f, -0.06275802f, -0.05352111f, -0.09388314f, 0.06622185f, -0.04897430f, 
    -0.01207843f, -0.12808868f, -0.00051706f, -0.09938524f, 0.20274188f, -0.14964242f, -0.08384774f, -0.06390434f, 
    0.00642164f, -0.26969236f, 0.16655678f, -0.00151354f, -0.06505783f, -0.24495669f, -0.05062976f, 0.08749945f, 
    0.01164355f, 0.04506069f, -0.04715928f, 0.14255522f, -0.08459330f, 0.25853074f, 0.12747501f, -0.04224287f, 
    0.05292373f, -0.13516301f, -0.01226216f, -0.07960907f, 0.16738090f, 0.08857954f, 0.36652470f, 0.05000865f, 
    0.09381282f, -0.13536593f, 0.01496669f, -0.12031477f, 0.11931499f, 0.04413288f, -0.25018257f, 0.06616579f, 
    0.02136584f, -0.15916669f, -0.06492937f, 0.01801172f, 0.06280222f, 0.28564575f, 0.20375517f, -0.02961991f, 
    0.03133666f, -0.05571653f, -0.07286864f, -0.04515909f, -0.03475595f, -0.08159330f, 0.08361280f, -0.06822933f, 
    -0.14894375f, 0.05711601f, -0.06721554f, -0.20002072f, -0.07263706f, -0.05693199f, 0.05525616f, 0.00277584f, 
    0.07240277f, 0.06524023f, 0.08985678f, 0.00313949f, 0.07635348f, 0.08982383f, 0.12088702f, 0.11404751f, 
    -0.00383067f, 0.06988543f, 0.23870191f, -0.00387576f, 0.02891728f, 0.10302848f, 0.10679209f, 0.00204978f, 
    -0.13577425f, 0.13491905f, 0.47645825f, 0.03176343f, -0.04485064f, 0.03727753f, -0.03150430f, 0.09890947f, 
    -0.19457489f, 0.01622052f, 0.13328774f, 0.04140331f, 0.04568168f, 0.03212216f, 0.45188424f, 0.12300660f, 
    0.00139907f, -0.09209318f, -0.12597483f, 0.06293369f, 0.00279955f, 0.00206025f, 0.10090346f, -0.14155287f, 
    -0.02829613f, 0.01564319f, -0.19978213f, 0.15214019f, 0.22154197f, 0.12771519f, 0.10331819f, -0.05086233f, 
    -0.15216218f, -0.00337563f, -0.00310584f, -0.00963202f, -0.02199231f, 0.20113142f, 0.05354376f, 0.26244894f, 
    0.15259773f, 0.08222773f, 0.04449631f, -0.00086408f, 0.06905740f, 0.11901542f, 0.00210322f, -0.04151753f, 
    -0.13493752f, -0.32340044f, 0.04839820f, 0.29763776f, 0.12678342f, 0.07221817f, 0.02077165f, -0.08411295f, 
    0.03917747f, 0.06726813f, 0.07967289f, 0.01167930f, 0.24383707f, -0.08886670f, 0.08189248f, -0.00310940f, 
    0.04648866f, 0.06874429f, 0.02229505f, -0.00816126f, -0.00839708f, 0.06274531f, 0.00647768f, 0.06537662f, 
    -0.06324975f, -0.05535467f, -0.04222916f, -0.26160389f, -0.21912979f, -0.07294721f, 0.03762464f, 0.02559229f, 
    -0.04530853f, 0.14554830f, -0.12083091f, 0.19731700f, -0.22165984f, -0.00874284f, 0.04412998f, -0.11507434f, 
    -0.04762822f, -0.18513988f, -0.10505151f, 0.00550644f, -0.12111685f, -0.08763992f, -0.20511426f, -0.14001305f, 
    0.00795925f, 0.10524815f, 0.15654387f, -0.01481556f, -0.19926621f, -0.15348491f, -0.03857572f, -0.00352168f, 
    -0.06861211f, -0.07197960f, -0.03931269f, -0.02822588f, -0.08699913f, 0.11174710f, -0.32153609f, 0.25536069f, 
    0.00761758f, -0.00667253f, -0.00666541f, -0.03002031f, -0.01023901f, 0.11001898f, 0.11617872f, 0.01955685f, 
    -0.10833811f, 0.12561221f, -0.22370452f, -0.30876097f, -0.00729950f, 0.03204739f, 0.11437857f, -0.09143044f, 
    0.04087475f, 0.02922633f, 0.30342811f, 0.06606691f, 0.06016304f, -0.27501270f, -0.28841779f, -0.01441227f, 
    -0.04436085f, -0.00375811f, 0.02334039f, -0.01542203f, 0.03004740f, 0.06231491f, 0.11998118f, 0.03416854f, 
    -0.33260024f, -0.03244644f, -0.02773165f, 0.40712389f, -0.01990841f, -0.08686171f, -0.01771666f, 0.18038943f, 
    -0.00852593f, -0.04034518f, 0.22656971f, 0.24301326f, -0.15286709f, -0.13292956f, 0.17213327f, 0.28512722f, 
    0.17436615f, 0.08066202f, -0.03043402f, -0.00756974f, 0.05131876f, 0.01544300f, 0.06309649f, 0.09568755f, 
    -0.00516277f, 0.12495968f, 0.09212782f, -0.02660933f, -0.06379568f, -0.35950968f, 0.09260190f, -0.10199142f, 
    -0.10697498f, -0.15986665f, -0.23310916f, -0.21163572f, 0.26491097f, 0.17315748f, 0.01492539f, 0.22141214f, 
    -0.17995009f, -0.07986493f, -0.08354988f, 0.02325837f, -0.11525912f, -0.15926512f, -0.03192810f, 0.01978807f, 
    0.22389126f, 0.14526485f, 0.26234904f, 0.13307635f, -0.10754318f, 0.07412245f, -0.15461157f, 0.00299263f, 
    -0.10569540f, -0.04980595f, 0.02199943f, 0.04747903f, 0.20448931f, 0.10334637f, 0.33973202f, -0.10971011f, 
    0.14918590f, 0.02579890f, -0.07980271f, 0.09879062f, -0.21314555f, 0.01967913f, -0.12068370f, -0.14073940f, 
    0.04166864f, -0.00321743f, -0.22324097f, 0.40797320f, -0.05748481f, -0.03220992f, 0.03325620f, -0.03282288f, 
    0.02781507f, 0.05612915f, 0.17360967f, -0.01022342f, 0.13981305f, 0.23890516f, 0.15218633f, -0.09306139f, 
    0.02194604f, 0.11455474f, 0.03071033f, -0.22504477f, 0.24332432f, 0.27686092f, 0.14379317f, 0.25628033f, 
    -0.20962326f, -0.23552756f, 0.18501408f, 0.11092018f, -0.04197745f, 0.00039582f, 0.02849035f, 0.10057592f, 
    0.00513896f, -0.03863585f, -0.07681724f, -0.13460569f, -0.02462275f, 0.04517415f, -0.02473262f, 0.09666298f, 
    -0.05149946f, 0.05156701f, -0.05643607f, -0.02704229f, -0.06403896f, -0.07768304f, -0.09380209f, -0.18044217f, 
    -0.14047338f, 0.11591022f, -0.11647418f, -0.00745675f, 0.11910867f, 0.08764070f, -0.01744609f, 0.08346069f, 
    0.20361033f, 0.15129746f, 0.15026268f, -0.01213556f, 0.15829012f, 0.12265406f, 0.06406550f, -0.02573990f, 
    -0.02790809f, -0.00867774f, 0.00703399f, 0.15933529f, 0.01492365f, -0.25155407f, 0.00034514f, 0.06450697f, 
    -0.00001810f, -0.10655596f, 0.25020182f, -0.18902855f, -0.14384691f, 0.04975757f, -0.10395652f, -0.00600934f, 
    -0.07095657f, -0.01581905f, 0.05790809f, -0.17910998f, 0.00074672f, -0.07539175f, -0.06348681f, -0.00393080f, 
    0.00538539f, -0.06336045f, -0.03154240f, 0.11996651f, -0.02356319f, -0.10419626f, -0.00269336f, -0.17346908f, 
    -0.10729834f, -0.10532216f, -0.42985925f, 0.22900037f, 0.04088518f, 0.23943722f, -0.02153084f, 0.02965262f, 
    0.00211553f, 0.17534089f, 0.08724120f, 0.01300698f, -0.09668586f, -0.29590389f, 0.08138563f, 0.20522551f, 
    0.06334048f, -0.09630314f, 0.20619392f, 0.05303768f, -0.09147743f, 0.12742950f, 0.00161249f, 0.11726848f, 
    -0.03478934f, 0.07329042f, 0.16058722f, -0.24554224f, -0.07056720f, -0.05174836f, -0.02416003f, 0.09831651f, 
    -0.06051954f, -0.06393366f, -0.13202994f, 0.01806220f, -0.07632383f, 0.04835635f, -0.02139206f, 0.18851934f, 
    0.00900070f, 0.12478639f, 0.01999762f, 0.20908888f, 0.13169342f, 0.11901542f, 0.10386332f, 0.01363269f, 
    -0.02117135f, -0.04945151f, -0.10371716f, -0.23886473f, -0.11570729f, -0.06607082f, -0.06347315f, -0.09898093f, 
    -0.22630243f, 0.14593954f, -0.03750171f, -0.29014412f, 0.22656338f, 0.04582140f, 0.28344977f, 0.29751804f, 
    -0.14255537f, -0.15091369f, 0.03201272f, 0.00221354f, 0.18803021f, -0.08033567f, 0.04612564f, -0.06483644f, 
    -0.27991500f, 0.01123929f, 0.44525194f, 0.36733896f, -0.00416185f, 0.07066315f, 0.03601562f, -0.04016897f, 
    -0.12591045f, -0.22483955f, 0.08856911f, -0.16607231f, -0.16388159f, 0.17620924f, 0.11153589f, -0.00665898f, 
    0.22192189f, -0.00190538f, 0.01598149f, 0.25739303f, -0.32367906f, -0.02634853f, -0.00388432f, -0.35897106f, 
    0.50080484f, -0.00947466f, 0.02225261f, -0.00225220f, -0.06693292f, 0.11596156f, -0.03088372f, -0.11447643f, 
    0.10958322f, 0.22308820f, -0.01452549f, 0.16238853f, -0.06479433f, 0.35445243f, -0.02553084f, 0.04222428f, 
    0.04768743f, 0.08255278f, 0.01608664f, 0.06516799f, 0.14320031f, 0.11582865f, 0.12936091f, 0.15519805f, 
    -0.21037778f, -0.10774044f, -0.04892138f, 0.22533606f, -0.01480470f, -0.01123004f, -0.08910779f, 0.11007093f, 
    -0.02733191f, -0.09861559f, -0.11997704f, -0.10457588f, 0.01238514f, -0.03191363f, 0.31801912f, 0.14853914f, 
    0.14018479f, 0.30698603f, 0.06606609f, 0.04418112f, 0.03842059f, -0.13701296f, -0.08357058f, -0.10519676f, 
    0.29897237f, 0.02227655f, -0.10667531f, -0.01818265f, -0.06833569f, -0.25131342f, 0.05453265f, 0.07827019f, 
    0.06759138f, -0.08581323f, 0.13951856f, 0.02900538f, -0.74904752f, -0.09539276f, 0.30982262f, 0.17044163f, 
    -0.05224550f, 0.09639092f, -0.07895940f, -0.04555366f, 0.04891625f, -0.05696506f, -0.03192405f, -0.02668782f, 
    -0.19226381f, -0.01248670f, 0.13016561f, 0.21390815f, -0.05957390f, -0.23241851f, 0.14712226f, 0.08820803f, 
    -0.20725311f, -0.14375463f, 0.02595814f, -0.01503960f, -0.12319218f, -0.13819215f, 0.14698441f, -0.08259367f, 
    0.12019964f, -0.06825503f, -0.09009074f, 0.01136520f, -0.13217425f, -0.05161423f, -0.13921620f, -0.07721304f, 
    0.10182606f, 0.30425739f, 0.04806152f, -0.13007183f, -0.07768577f, -0.08321089f, -0.32286438f, -0.09228765f, 
    0.07651787f, 0.09521058f, 0.13666597f, -0.09642870f, -0.01402104f, 0.05981835f, -0.03209405f, 0.03550870f, 
    0.28319418f, 0.02685190f, -0.01925910f, 0.02876489f, 0.05310065f, 0.14649716f, -0.02076550f, 0.15092777f, 
    -0.31158203f, -0.06916833f, 0.02260298f, 0.08471940f, 0.00427881f, 0.02714551f, -0.24463652f, -0.17284514f, 
    -0.23125036f, -0.04586023f, -0.11371379f, -0.05829208f, -0.07103685f, 0.06723966f, 0.06329934f, 0.27942076f, 
    0.19585226f, 0.11252522f, 0.03485466f, 0.13636582f, 0.33289018f, 0.08692186f, 0.17340647f, 0.09207678f, 
    0.04335073f, -0.15121169f, 0.04710727f, 0.08931874f, 0.00367121f, 0.01646029f, -0.09297124f, -0.14125921f, 
    0.01403696f, -0.21241771f, 0.07509635f, -0.05945220f, -0.04348983f, -0.17146270f, -0.28108007f, -0.17237800f, 
    -0.02116744f, -0.05304058f, -0.03643898f, -0.11560909f, -0.01417589f, 0.12183522f, -0.04296942f, -0.13742518f, 
    0.37034193f, 0.06350937f, -0.19275661f, -0.09918435f, -0.07079431f, 0.05132117f, -0.12110601f, 0.05706057f, 
    0.05539896f, 0.00959127f, 0.08392033f, -0.04901014f, 0.14399740f, 0.21151304f, -0.16783284f, 0.20452709f, 
    0.10163816f, -0.07770109f, -0.08246239f, 0.04547768f, -0.01174035f, 0.03277300f, -0.02224820f, 0.06268577f, 
    -0.10128895f, -0.09144568f, 0.19296701f, 0.08609781f, -0.04252620f, -0.02082328f, 0.13561364f, 0.11503068f, 
    0.22385283f, 0.05662516f, 0.00955055f, 0.03645221f, -0.04372248f, -0.14760871f, -0.03939855f, -0.04736840f, 
    0.08993863f, -0.01517018f, -0.02640827f, 0.00551759f, 0.03248552f, -0.07760384f, 0.09281211f, 0.03214306f, 
    0.12749374f, 0.40343538f, 0.07919302f, -0.13411742f, 0.03269387f, 0.10940841f, 0.09391021f, 0.18593709f, 
    0.01783816f, 0.06599711f, -0.08994304f, 0.07661073f, -0.07499243f, 0.20831615f, 0.17303792f, -0.02948743f, 
    0.11178281f, -0.12653144f, 0.07915209f, -0.00707628f, -0.05986609f, -0.00802212f, 0.01729476f, -0.00688494f, 
    -0.04789354f, 0.07308068f, -0.08739305f, -0.03387358f, 0.05212947f, 0.00773141f, 0.04513825f, -0.00883132f, 
    0.17147672f, -0.04499216f, 0.06757402f, -0.06431320f, 0.12175512f, -0.04273500f, 0.28164905f, -0.03706467f, 
    0.17312439f, 0.03868391f, -0.14027528f, -0.10385744f, 0.01803716f, 0.03354394f, 0.14204597f, 0.06955599f, 
    0.14897169f, 0.10540266f, 0.07503854f, 0.11232261f, -0.05824033f, -0.01304086f, -0.11561298f, 0.06004728f, 
    0.05959670f, -0.01124236f, -0.07617600f, 0.04226971f, -0.11092668f, 0.08667757f, 0.00285965f, -0.08435125f, 
    -0.16503233f, 0.05048136f, 0.01153977f, -0.02168181f, 0.06409292f, -0.16531187f, -0.09705311f, -0.14535767f, 
    0.27836263f, -0.09952615f, 0.11823664f, -0.02663728f, 0.04226316f, -0.12002773f, -0.08094098f, 0.00749128f, 
    0.05130465f, 0.07275611f, -0.08946827f, -0.01293656f, 0.08367884f, 0.34073460f, 0.15667285f, 0.00648117f, 
    0.00354628f, -0.08006062f, 0.00257631f, 0.06245320f, 0.09329041f, -0.00301345f, 0.13986765f, 0.03445745f, 
    0.13412304f, -0.12834102f, -0.04707368f, -0.23849198f, -0.04949574f, 0.03075669f, -0.14552835f, 0.01310902f, 
    -0.01340966f, -0.14509647f, -0.05696081f, 0.00624249f, -0.01873981f, 0.19250646f, 0.07213940f, 0.00026318f, 
    -0.08670848f, -0.16081189f, -0.05152362f, -0.01903204f, 0.07016273f, -0.04143489f, -0.03035964f, -0.07115609f, 
    -0.00750562f, 0.05281135f, -0.03419238f, -0.02309064f, 0.06091947f, -0.04616385f, -0.00342391f, -0.05457664f, 
    -0.04429985f, -0.08030293f, -0.02263907f, -0.01320818f, 0.05217310f, 0.00425201f, 0.03419494f, 0.05774073f, 
    0.02461668f, 0.00574236f, -0.03385612f, 0.04997675f, -0.01927209f, 0.04270061f, 0.04565534f, -0.03789140f, 
    -0.01190484f, 0.05566153f, 0.00696174f, -0.03770810f, 0.02283974f, -0.07454380f, -0.05309836f, -0.00785782f, 
    0.02842268f, 0.02837379f, -0.01935876f, -0.03407042f, -0.02615584f, -0.04373218f, 0.06354901f, 0.01852446f, 
    0.02617942f, 0.01082921f, -0.05751192f, -0.06642748f, 0.02888211f, -0.07878669f, 0.00480270f, -0.04272655f, 
    -0.00039469f, 0.02642436f, -0.01470925f, -0.02662754f, -0.00394245f, -0.01270937f, 0.01927231f, 0.03631860f, 
    -0.02551418f, -0.04364787f, -0.01344360f, -0.06557098f, 0.03618457f, 0.02567838f, 0.03630387f, -0.03370438f, 
    0.04497419f, -0.02790199f, -0.03528671f, -0.04962231f, 0.00265424f, -0.05798369f, 0.05214962f, -0.06681231f, 
    -0.06847387f, -0.02729321f, 0.02403112f, -0.02987714f, 0.02851478f, -0.06150199f, -0.05658130f, -0.07315862f, 
    0.03724891f, 0.03220793f, -0.01806624f, -0.01326859f, -0.01841427f, -0.06189745f, -0.04176782f, 0.01899842f, 
    0.02571896f, -0.01575694f, -0.01478916f, 0.02122650f, 0.03657674f, -0.03230017f, -0.03390768f, -0.04566417f, 
    0.04323005f, -0.06968118f, -0.03739943f, -0.01469212f, -0.01094878f, -0.04758435f, -0.04783076f, 0.05661248f, 
    0.01437183f, -0.04411916f, -0.05993005f, -0.03142743f, -0.05454146f, 0.02623374f, -0.01257741f, 0.02095228f, 
    -0.07203712f, -0.05089851f, 0.03064345f, 0.00789966f, -0.06379696f, 0.05921533f, 0.04060309f, 0.01053174f, 
    -0.02559418f, 0.00700610f, 0.01705728f, -0.01758297f, 0.00294347f, 0.01533698f, -0.02796840f, -0.07859401f, 
    -0.03073058f, 0.02261513f, -0.01961284f, -0.02382093f, -0.04903535f, -0.02209344f, 0.03075612f, 0.04012981f, 
    -0.03837712f, -0.07423954f, -0.07702950f, -0.03466016f, -0.06629936f, 0.00583284f, -0.02497089f, 0.05827021f, 
    -0.01120639f, -0.04274574f, -0.04570814f, 0.05038205f, -0.05194413f, 0.03390091f, 0.05009423f, 0.06345638f, 
    0.04397994f, 0.00860488f, -0.03661051f, -0.03076915f, -0.04556005f, 0.02718344f, 0.04273408f, 0.02279606f, 
    -0.06995677f, 0.03340145f, 0.02548239f, 0.06117425f, 0.05524392f, -0.02602650f, -0.06926097f, 0.04328518f, 
    -0.04411301f, -0.01389954f, -0.01021380f, -0.07771788f, -0.01422897f, -0.04033309f, -0.03161998f, -0.06647275f, 
    -0.06603580f, 0.03545516f, -0.00443624f, 0.00461770f, -0.03008028f, 0.01123240f, -0.07071036f, -0.04156351f, 
    0.01821288f, 0.00558312f, -0.06847230f, -0.03418952f, 0.01563978f, -0.00105116f, -0.07877801f, -0.03355525f, 
    -0.05068967f, -0.09289189f, -0.11858935f, -0.00981379f, -0.00219582f, 0.03944106f, 0.04002935f, -0.03507051f, 
    -0.04075169f, 0.04729067f, 0.05226481f, 0.00570803f, 0.10069693f, 0.25733489f, 0.03441757f, 0.05044273f, 
    -0.07934623f, -0.00242608f, 0.00368926f, 0.12913644f, 0.07934198f, -0.07039952f, -0.01163745f, 0.09719618f, 
    -0.13150492f, -0.14652511f, -0.38218468f, 0.10464735f, -0.03552789f, -0.06664523f, 0.07675240f, -0.09176628f, 
    0.07491542f, -0.08630475f, 0.05100077f, -0.06331077f, -0.01282143f, -0.02411724f, -0.20573489f, 0.04882757f, 
    0.14381102f, 0.07830273f, 0.03410953f, 0.05499048f, 0.15227301f, -0.06755377f, -0.16578044f, 0.02843734f, 
    0.07312607f, 0.29248405f, 0.28583357f, -0.01200795f, -0.18698095f, 0.16886294f, 0.10345913f, 0.16370995f, 
    0.03193264f, -0.01569588f, 0.01134062f, 0.02782261f, 0.00180281f, 0.20511796f, -0.02566680f, -0.03330643f, 
    0.02180155f, 0.01323295f, -0.11542826f, -0.06028569f, -0.05270571f, -0.06556141f, -0.02643456f, 0.03528312f, 
    0.10056314f, 0.25953889f, 0.12379765f, -0.07987053f, 0.00667346f, 0.12742230f, 0.16436936f, 0.07542039f, 
    -0.03543593f, -0.07996522f, 0.01408361f, -0.00176267f, 0.02790190f, 0.38823256f, 0.25394297f, 0.10135905f, 
    0.16645642f, 0.13992301f, 0.22326379f, 0.09157904f, -0.00515827f, -0.02850365f, -0.03341178f, -0.01298314f, 
    -0.05710024f, -0.18130513f, -0.15840662f, -0.06788494f, 0.05395389f, -0.10288274f, 0.04323900f, -0.00744622f, 
    0.08273327f, -0.03906902f, 0.10452572f, 0.02635410f, -0.18331073f, -0.04120786f, -0.28649935f, 0.00893068f, 
    0.01678589f, 0.12305591f, 0.00004997f, -0.09355143f, 0.01781640f, 0.02135652f, -0.03953941f, 0.09062811f, 
    -0.37473187f, -0.40695390f, -0.23242109f, 0.13255650f, 0.01133731f, -0.03318492f, -0.01502604f, 0.03725388f, 
    0.08707723f, 0.02444306f, -0.08893211f, 0.10821279f, 0.09471436f, -0.03227412f, 0.16571392f, 0.04129757f, 
    -0.08716211f, 0.14284380f, 0.08719123f, -0.03399342f, 0.02706665f, 0.00203284f, -0.00317263f, 0.07734719f, 
    -0.01522065f, -0.23724824f, 0.14589380f, 0.11830693f, -0.15542802f, 0.09586342f, -0.01925286f, -0.03668751f, 
    -0.06389289f, 0.05748915f, -0.07232163f, 0.12007961f, 0.18502955f, 0.29661813f, 0.22524343f, 0.07799493f, 
    0.01280973f, -0.00402323f, -0.07555950f, 0.06752813f, 0.01422706f, -0.01025653f, 0.00577264f, 0.04099248f, 
    0.17356212f, -0.12089439f, -0.11333371f, -0.15815994f, 0.00679093f, 0.16249786f, -0.08755495f, -0.05798305f, 
    -0.06003556f, 0.06769184f, 0.04460773f, 0.02170902f, 0.13375328f, 0.29070914f, 0.10521278f, 0.05563068f, 
    0.03956838f, -0.01634532f, 0.11676916f, 0.06470840f, 0.05037654f, -0.02989164f, -0.09947828f, -0.05224052f, 
    -0.09369298f, 0.14976384f, -0.13196000f, 0.09778725f, 0.01978068f, -0.07437323f, 0.05926502f, -0.02037912f, 
    0.06938115f, 0.12506944f, -0.02271666f, 0.03051300f, 0.17023809f, 0.36418352f, 0.14019421f, 0.15323512f, 
    -0.03476841f, -0.09906692f, -0.00906393f, 0.04104646f, -0.06790173f, -0.11695638f, 0.10771798f, 0.02484837f, 
    0.22361338f, 0.14826378f, -0.01522513f, 0.06121040f, -0.10629710f, 0.06655708f, -0.00873915f, 0.06147700f, 
    0.00019107f, 0.04644481f, -0.06347569f, -0.00470069f, 0.01644260f, -0.29848310f, 0.24526417f, -0.32381094f, 
    0.10458445f, 0.11083677f, 0.10438754f, 0.01637957f, 0.01056765f, -0.06677095f, -0.06364459f, -0.01992581f, 
    -0.21156812f, -0.00050165f, -0.23113622f, 0.45166388f, -0.03739590f, 0.12581329f, 0.02978958f, 0.06096688f, 
    0.03379782f, 0.08976639f, 0.11667549f, 0.10360285f, 0.37028688f, 0.36038980f, 0.01878496f, -0.04011476f, 
    -0.00484980f, 0.03973698f, 0.11945060f, 0.01988897f, 0.18244585f, 0.05011057f, 0.08960731f, 0.31105065f, 
    -0.20392653f, -0.16853321f, 0.24933657f, -0.01164463f, -0.09622966f, -0.04266087f, 0.17186618f, 0.09705059f, 
    -0.07368311f, 0.06567258f, 0.04508261f, 0.00798483f, -0.25391999f, -0.17795590f, -0.11572928f, 0.18549845f, 
    0.05237074f, 0.07857079f, 0.04618624f, 0.02318386f, -0.00890337f, -0.03218075f, -0.03681331f, -0.00165825f, 
    0.06111476f, -0.07451256f, 0.10184262f, -0.04168091f, -0.05400262f, 0.01011058f, -0.04679074f, -0.10997404f, 
    0.12081937f, 0.05375199f, 0.01384355f, 0.18286595f, 0.03851950f, 0.02314062f, -0.11639334f, -0.07457216f, 
    0.03354707f, 0.02173222f, 0.04198702f, 0.05203283f, -0.00684832f, -0.15399790f, -0.17318037f, -0.11605102f, 
    -0.02287806f, -0.25364786f, 0.24001801f, -0.14810227f, 0.00274189f, 0.02807952f, -0.04075993f, 0.06473404f, 
    -0.01688206f, -0.02794916f, -0.04183938f, -0.14411628f, -0.06381620f, -0.11160235f, 0.03038754f, 0.35564494f, 
    0.22465774f, 0.05718750f, 0.03756572f, -0.01845961f, -0.04974111f, -0.04021866f, 0.05324774f, 0.05974357f, 
    -0.21309544f, -0.41669592f, -0.06409662f, 0.55803293f, 0.05396343f, 0.06476520f, -0.01878020f, -0.05926367f, 
    0.12857383f, 0.02748572f, 0.12460909f, -0.02765995f, -0.21350017f, -0.36790201f, -0.04251095f, 0.11617559f, 
    -0.16649629f, -0.01079902f, -0.04397794f, -0.00697190f, 0.01479591f, 0.02169466f, 0.04403687f, -0.05137026f, 
    0.08670305f, 0.20846266f, 0.10916665f, 0.05365553f, 0.03609249f, -0.11594430f, 0.07722293f, 0.18549889f, 
    -0.05240135f, 0.11639215f, -0.02228977f, 0.15117051f, -0.12378624f, -0.04982706f, -0.14691877f, 0.05220415f, 
    -0.08318393f, 0.03422139f, -0.04011905f, 0.04696548f, 0.01045865f, 0.00631719f, 0.05416884f, 0.13965876f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.12704659f, -0.14179476f, 0.00702134f, 0.15093096f, -0.11738730f, -0.01139077f, 0.04111505f, 0.15664935f, 
    -0.05739905f, 0.13147999f, 0.10943134f, 0.22185171f, -0.01467047f, -0.05158038f, -0.01704202f, 0.04356261f, 
    0.14607100f, 0.10555734f, 0.00023923f, 0.02199358f, 0.08722282f, 0.00516517f, 0.20881347f, 0.19221638f, 
    -0.06780244f, -0.00562745f, -0.01189215f, 0.02149102f, 0.28208059f, 0.14750488f, -0.02094968f, 0.10517050f, 
    0.00347881f, 0.07492470f, -0.04923385f, -0.03039227f, -0.06232912f, -0.01414997f, 0.05598252f, -0.01385237f, 
    0.08796712f, 0.07656701f, 0.12928824f, -0.05597324f, 0.07629436f, 0.15366742f, 0.18173583f, 0.04589550f, 
    0.03521051f, 0.01625687f, 0.04360657f, 0.10988639f, 0.04332846f, 0.05034761f, 0.10206651f, -0.00537224f, 
    0.06031929f, 0.04170958f, 0.01963644f, 0.12654415f, 0.04813482f, 0.01285827f, 0.01442680f, -0.12114573f, 
    -0.04792876f, -0.06763755f, 0.01411050f, 0.07525852f, 0.02264844f, 0.04620005f, 0.05519489f, -0.02057949f, 
    0.00881149f, 0.02392899f, 0.01701721f, -0.00044824f, 0.06448627f, 0.13030909f, 0.20618467f, -0.06076476f, 
    0.05006224f, 0.03178764f, 0.07475630f, 0.08072916f, 0.09423906f, 0.11790838f, -0.00363634f, 0.00178621f, 
    0.12348678f, 0.19730015f, 0.07225230f, 0.04169074f, 0.05492502f, -0.04145017f, 0.12650356f, 0.01095393f, 
    -0.04342578f, -0.05240098f, 0.16045634f, 0.18658023f, 0.07412686f, 0.01399292f, 0.17705348f, 0.00793633f, 
    0.03817606f, 0.15054807f, 0.04851392f, 0.04846393f, 0.15848543f, -0.01067794f, -0.16185711f, 0.17773309f, 
    -0.05911190f, -0.00058499f, -0.02453275f, 0.09478600f, -0.07856127f, 0.02149219f, 0.12580401f, 0.07319291f, 
    -0.01022044f, 0.13021803f, 0.06590367f, 0.05025269f, -0.08872619f, 0.03953736f, 0.01230238f, 0.21549658f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.10397132f, 0.30258271f, -0.09120310f, -0.40992016f, 0.42438543f, 0.06700995f, -0.06096642f, -0.37575582f, 
    0.00202061f, -0.05586991f, 0.13577151f, -0.20638943f, -0.43602464f, -0.01781009f, 0.04846677f, 0.05690533f, 
    -0.27481842f, 0.23736979f, 0.10361996f, -0.03088645f, 0.05840582f, -0.60944819f, -0.33525556f, -0.39161241f, 
    -0.03943222f, 0.00870533f, -0.02284853f, 0.20602766f, -0.20103447f, 0.22631291f, 0.07211023f, -0.36090219f, 
    0.03344693f, -0.28467521f, -0.05472644f, -0.05375159f, 0.01675391f, -0.05855268f, -0.02068591f, -0.03010768f, 
    0.10229640f, -0.03465123f, 0.12181896f, 0.07995392f, -0.08777586f, -0.16450837f, -0.23679990f, 0.05305289f, 
    0.10168528f, -0.01852078f, -0.31002438f, -0.31043106f, -0.34004501f, 0.07484986f, -0.07839186f, 0.04333158f, 
    -0.14960296f, 0.06782511f, 0.07334156f, -0.31903881f, -0.07045177f, 0.00300000f, -0.00229252f, 0.22834031f, 
    -0.29660672f, 0.02634978f, -0.03886803f, -0.03812870f, 0.22173727f, 0.05421402f, 0.12922090f, -0.13926780f, 
    -0.32738361f, -0.32696098f, -0.21320783f, 0.03337200f, 0.05741955f, -0.45741993f, 0.11434928f, 0.18196242f, 
    -0.33457199f, 0.02678663f, 0.16616566f, 0.02807066f, 0.05079646f, -0.32121706f, 0.07190865f, -0.14264083f, 
    -0.07194638f, 0.09011564f, 0.19619790f, 0.07537248f, 0.00697063f, 0.06149531f, -0.13181117f, -0.31261972f, 
    0.12491073f, -0.23240069f, -0.09850176f, -0.27014425f, 0.08562676f, -0.02645248f, 0.04464048f, -0.02357733f, 
    -0.05750916f, -0.09898595f, -0.04283971f, 0.12966006f, -0.12039254f, -0.06123323f, 0.28544313f, -0.40940565f, 
    0.04962355f, -0.14700440f, 0.02427898f, -0.03880138f, 0.14893343f, -0.09229100f, 0.08800694f, -0.20671049f, 
    0.01355053f, -0.35416934f, -0.51255924f, 0.11756486f, 0.11235216f, -0.02792743f, 0.11979876f, -0.31576779f, 
    0.03802381f, -0.27245271f, -0.05087855f, 0.04025019f, -0.52005500f, 0.09248675f, -0.07929789f, -0.01100807f, 
    -0.06809557f, 0.16918528f, 0.14219691f, 0.01396341f, -0.30564800f, 0.02185736f, 0.01093326f, 0.00624817f, 
    -0.10770339f, -0.05458068f, 0.26283255f, -0.01723967f, 0.03509970f, -0.23440564f, -0.11892204f, 0.11226746f, 
    -0.02976738f, 0.03587795f, 0.06016381f, 0.09612006f, 0.08399099f, 0.19385412f, -0.06874325f, -0.12506355f, 
    -0.06721684f, -0.53878301f, -0.02796302f, 0.07024196f, 0.01024071f, -0.05400136f, 0.03351842f, -0.06254561f, 
    0.17564774f, -0.10003631f, 0.14289564f, -0.08858181f, 0.20050505f, -0.22070180f, 0.33842349f, 0.00499441f, 
    -0.11456537f, 0.06893665f, -0.38707966f, -0.02996597f, -0.25452718f, 0.03937763f, 0.01363126f, -0.05208950f, 
    -0.12252215f, 0.15565474f, 0.01478585f, 0.19802342f, 0.20601611f, 0.02471652f, 0.08311641f, -0.05870428f, 
    0.01667674f, -0.04399458f, -0.00459398f, 0.06616095f, -0.58373833f, 0.03553090f, 0.00067023f, 0.20672008f, 
    0.36991915f, -0.14212444f, 0.05865628f, -0.05498142f, -0.56261361f, -0.20227931f, 0.16586448f, 0.04368718f, 
    -0.50581938f, -0.21152626f, 0.17413642f, 0.07866022f, 0.04698534f, 0.09695900f, 0.06310550f, 0.12660828f, 
    0.23537353f, 0.10677325f, -0.04442964f, -0.15699475f, 0.06180079f, -0.02639090f, 0.29762992f, 0.03731921f, 
    0.06233449f, -0.05542256f, -0.08686840f, 0.18795565f, 0.06736612f, -0.05611008f, 0.05824483f, -0.12177334f, 
    0.04633833f, -0.07555463f, 0.40288863f, -0.03551460f, 0.15945894f, -0.08123966f, -0.82791573f, -0.03590755f, 
    0.04808363f, -0.16298206f, -0.04374422f, 0.00866189f, 0.56125337f, -0.03844001f, 0.04784796f, -0.08819991f, 
    -0.04160044f, -0.04068938f, 0.07669710f, -0.48033750f, 0.05330697f, 0.01219832f, 0.02285855f, -0.01867464f, 
    0.08634045f, -0.47891718f, 0.04874155f, 0.09796064f, -1.04270315f, -0.01598800f, 0.00000711f, 0.10322306f, 
    0.02059503f, -0.10315047f, -0.47939721f, 0.05632786f, -0.12028392f, 0.00211264f, 0.06374434f, -0.06285360f, 
    -0.00167219f, -0.43632108f, -0.05522517f, 0.04870257f, 0.14038546f, 0.18437697f, 0.07340942f, -0.10682567f, 
    -0.02651387f, -0.07149688f, -0.08044930f, 0.01551274f, 0.12759203f, 0.12698127f, 0.07612573f, 0.29766381f, 
    0.05892805f, 0.18697917f, -0.01916289f, 0.04181875f, 0.02566106f, -0.01097455f, 0.03678571f, 0.01941447f, 
    0.16354515f, 0.17965470f, 0.17763965f, -0.14805189f, -0.06386098f, -0.10412345f, -0.07141030f, 0.06143619f, 
    0.12990853f, 0.05179735f, 0.37786210f, -0.28749681f, 0.10354329f, -0.07198520f, 0.00391608f, -0.03428224f, 
    -0.00732580f, -0.47011143f, -0.06238213f, 0.11389726f, 0.07874742f, 0.02635518f, 0.05109480f, -0.11266594f, 
    -0.31747994f, 0.08358749f, 0.00054913f, 0.03320302f, -0.36545086f, 0.00802979f, -0.01746543f, 0.03120726f, 
    -0.49403408f, 0.05032132f, -0.28255460f, -0.07880119f, 0.37496135f, -0.02718460f, 0.07931692f, -0.02825618f, 
    0.24277171f, -0.03135867f, 0.01129975f, -0.23687491f, -0.41096285f, -0.00545443f, 0.03183667f, -0.33633626f, 
    -0.43688342f, 0.15141784f, -0.23818265f, -0.02493060f, -0.04661623f, -0.03816381f, -0.40417939f, -0.01261359f, 
    -0.13819033f, -0.05102398f, 0.02154981f, 0.11873028f, -0.18912558f, 0.12419285f, 0.16143215f, -0.38534400f, 
    0.03182646f, -0.11924139f, -0.14779247f, -0.00603424f, 0.19925141f, 0.01464941f, -0.17514478f, 0.02610222f, 
    -0.08627903f, 0.02294016f, -0.00548243f, -0.04441689f, -0.11640928f, -0.11636073f, 0.12131467f, 0.19407350f, 
    -0.11999834f, 0.08028837f, 0.30211774f, 0.50517094f, -0.06885310f, 0.04102536f, -0.05891610f, 0.10059226f, 
    -0.35170853f, 0.00760597f, -0.08386901f, -0.16644877f, -0.20198995f, 0.07116707f, -0.02318409f, 0.17333110f, 
    -0.07204392f, -0.36786014f, -0.14384630f, -0.41700602f, 0.01213218f, -0.06871566f, -0.04522671f, -0.00865266f, 
    -0.05729124f, -0.02501715f, 0.10083450f, -0.00114307f, 0.21937811f, 0.16634750f, -0.26999643f, -0.34654227f, 
    -0.03804132f, 0.05208142f, -0.07298740f, -0.06362481f, -0.43605205f, -0.24598026f, -0.05005134f, 0.25341699f, 
    0.06884930f, 0.15211993f, -0.01982405f, -0.01731857f, 0.00127506f, -0.08201484f, 0.01068760f, 0.06709231f, 
    -0.23548630f, 0.09058674f, -0.10150775f, 0.08339617f, 0.24482121f, -0.17240702f, -0.22511835f, 0.08600081f, 
    -0.21163195f, 0.00764814f, 0.00305949f, 0.09115429f, 0.25628588f, -0.03106671f, -0.02416816f, 0.07808743f, 
    0.06301351f, 0.02661990f, -0.06318572f, 0.03529882f, 0.23334011f, -0.25198367f, -0.21606213f, 0.13976903f, 
    0.25496814f, -0.01809471f, -0.05046127f, 0.24224174f, 0.16929112f, 0.16308264f, 0.04621746f, 0.24205919f, 
    0.03170760f, 0.13775760f, -0.01886174f, 0.05862011f, -0.01042100f, 0.08525553f, -0.31896496f, 0.01882442f, 
    0.05824522f, -0.40245986f, -0.10292581f, -0.21070202f, -0.09852723f, -0.16564138f, -0.05985822f, -0.22396030f, 
    -0.01936258f, 0.04783345f, -0.29427782f, -0.21689659f, 0.00472662f, -0.03501721f, -0.10414129f, 0.41226181f, 
    -0.02682078f, -0.10282606f, 0.20634103f, -0.12260699f, 0.19781320f, -0.01395214f, -0.07248653f, -0.11802126f, 
    -0.03426742f, -0.07894405f, 0.09027028f, 0.10142227f, -0.50954950f, -0.03827238f, 0.05979234f, -0.61824691f, 
    0.16294767f, 0.27771783f, 0.00806412f, -0.27941489f, 0.01630081f, -0.16851147f, 0.19035304f, 0.05796585f, 
    -0.24557237f, 0.07542012f, 0.10437489f, 0.15840501f, -0.23423000f, 0.04634074f, -0.10049558f, -0.17289649f, 
    0.01432652f, -0.02440287f, 0.00223244f, 0.02359081f, 0.09023806f, 0.01591605f, -0.06616433f, -0.04971289f, 
    -0.04383745f, -0.12240884f, -0.36459792f, -0.04271533f, 0.33683553f, 0.04071843f, -0.03203455f, -0.06019818f, 
    -0.01120290f, -0.25193647f, 0.12697302f, -0.01145652f, -0.05327198f, -0.10723864f, 0.12550247f, -0.01890228f, 
    0.04182329f, -0.02309996f, -0.03129407f, 0.02896006f, -0.15295658f, -0.05313841f, -0.08575861f, -0.41472799f, 
    -0.03573992f, 0.04087703f, 0.05172222f, 0.07426928f, -0.03391492f, 0.03728605f, -0.05181902f, -0.05822308f, 
    -0.38023061f, -0.00479541f, -0.14535002f, 0.15814270f, -0.40761879f, -0.36250034f, 0.04071003f, 0.02612170f, 
    -0.20632137f, 0.04880646f, -0.02419944f, -0.22248347f, -0.29089943f, 0.03181657f, 0.11937147f, 0.02973078f, 
    -0.23039359f, 0.10976885f, -0.03298098f, 0.14321285f, 0.14485691f, -0.02684674f, 0.07322893f, 0.02335695f, 
    0.26601240f, -0.03552730f, 0.07645588f, -0.29253143f, 0.08773680f, -0.02437881f, -0.09041371f, 0.15556748f, 
    -1.05856025f, 0.06436771f, 0.19795376f, -0.02360013f, 0.22811913f, 0.08923826f, -0.08360539f, 0.10225804f, 
    0.16799212f, 0.25833228f, -0.14259161f, 0.03778090f, -0.11599088f, -0.05762358f, -0.04336400f, 0.17347014f, 
    0.12125487f, 0.12749489f, -0.08923650f, 0.10829037f, -0.06385496f, -0.04775425f, -0.22090489f, -0.14076731f, 
    0.06637800f, 0.16522652f, -0.24128824f, -0.36619189f, -0.14920011f, 0.07530572f, -0.20113300f, -0.13784035f, 
    -0.48108992f, -0.18818359f, -0.08194938f, 0.05155887f, -0.12036873f, -0.00005194f, 0.11971001f, 0.20281862f, 
    -0.11531045f, 0.09446842f, -0.03527234f, -0.08517087f, 0.11647462f, 0.02881403f, -0.16001417f, -0.17482416f, 
    0.07270555f, -0.01216500f, 0.13920808f, 0.20622782f, 0.10943054f, 0.02885402f, 0.13016041f, 0.01145861f, 
    -0.13808286f, -0.00248044f, 0.03503647f, 0.15008233f, -0.07022671f, -0.05243276f, -0.02962162f, -0.02450943f, 
    -0.04275251f, 0.11590903f, -0.06085856f, 0.06703213f, -0.55725229f, 0.06429353f, 0.06798664f, -0.06913218f, 
    -0.17790045f, 0.25679281f, -0.12858640f, 0.04363371f, 0.01007007f, 0.08781788f, 0.01062826f, 0.18684080f, 
    -0.07851440f, -0.00145541f, -0.03918779f, 0.07789211f, 0.15660857f, -0.04143608f, -0.04671135f, 0.15347359f, 
    -0.08537800f, -0.17887317f, 0.00230068f, -0.10214870f, 0.05096915f, -0.07954969f, -0.06785040f, 0.02801956f, 
    0.10241542f, 0.24013597f, -0.03720043f, -0.02420554f, -0.07651936f, 0.28462613f, 0.01066394f, -0.04515913f, 
    0.10498668f, -0.01491485f, 0.19792078f, 0.02203695f, -0.08047795f, 0.09002885f, 0.14061449f, -0.04325579f, 
    0.03110412f, 0.09501614f, -0.06043813f, -0.38593736f, -0.46445394f, -0.04698548f, 0.10003909f, 0.08428456f, 
    -0.72200900f, -0.03810517f, 0.02663658f, 0.03217817f, 0.34847981f, -0.23964614f, 0.00465845f, -0.14940485f, 
    -0.09979030f, 0.04650635f, 0.05330825f, -0.04994116f, -0.25840163f, -0.17170145f, 0.07802568f, -0.00743604f, 
    -0.19582033f, 0.19658557f, 0.03252300f, 0.16245414f, 0.29612714f, 0.23816270f, -0.05509080f, -0.05171924f, 
    -0.17354468f, 0.11099744f, 0.31338677f, 0.11298013f, -0.00658799f, -0.06640367f, -0.05739303f, -0.33260649f, 
    -0.00692265f, 0.08938354f, -0.02273369f, -0.03400501f, -0.04694811f, -0.08423667f, -0.27326375f, 0.37141171f, 
    0.06408848f, -0.09343012f, -0.06018916f, -0.16801342f, -0.24410103f, -0.00678564f, -0.24987090f, 0.32009611f, 
    -0.00755252f, -0.00134520f, 0.02381371f, -0.17085585f, -0.53285903f, -0.01711830f, -0.08416381f, 0.36885595f, 
    0.27053288f, -0.27368173f, -0.59648865f, -0.04506591f, 0.16834503f, -0.05178105f, 0.06779234f, -0.13551983f, 
    0.08768766f, 0.08383048f, 0.06108356f, 0.19768819f, -0.42885971f, -0.03809285f, -0.00715410f, 0.05492832f, 
    -0.07936350f, -0.41335803f, 0.08933302f, 0.22336380f, 0.18454728f, 0.02910074f, -0.09367262f, 0.05539320f, 
    0.15729272f, -0.29689085f, -0.61403751f, 0.01055823f, -0.24359059f, -0.07271399f, 0.02732825f, 0.22154170f, 
    -0.02345183f, 0.00247800f, 0.01453888f, -0.09106480f, 0.20277303f, -0.06373142f, -0.08895028f, -0.48072699f, 
    0.06564812f, 0.30198663f, 0.07801842f, -0.08299564f, 0.07388271f, -0.01383099f, -0.00941831f, 0.03184609f, 
    -0.42756745f, -0.35732394f, 0.14461204f, -0.03745097f, -0.05740364f, 0.27039683f, -0.34266061f, -0.05176885f, 
    0.02966670f, -0.06105958f, -0.11618632f, 0.04112065f, -0.06813264f, 0.02885916f, -0.41388530f, 0.02677357f, 
    0.19898319f, -0.42815036f, 0.03536575f, -0.22229055f, -0.19024205f, 0.17815138f, 0.00541088f, -0.28233153f, 
    0.10107669f, -0.08009969f, 0.04902117f, 0.05324662f, -0.17379314f, -0.32911915f, -0.07445631f, -0.37255895f, 
    0.11257534f, 0.19871126f, -0.51151407f, 0.02296481f, 0.09168259f, 0.01975122f, 0.10368807f, -0.27667281f, 
    0.42942998f, -0.09028607f, 0.05042093f, -0.17048746f, -0.44595069f, -0.02571268f, 0.06292608f, 0.04493064f, 
    -0.15135005f, 0.09724805f, -0.23302735f, -0.08112522f, -0.00397402f, -0.05387131f, 0.22707556f, 0.05637569f, 
    -0.24459451f, -0.03524203f, 0.06634290f, -0.02388046f, -0.11254150f, 0.14415237f, 0.19642799f, -0.42903218f, 
    -0.22583631f, 0.27985570f, -0.35811839f, -0.68874478f, 0.20509407f, -0.03243997f, -0.39044255f, -0.04807910f, 
    -0.67781132f, 0.04651697f, 0.00144717f, 0.00769345f, -0.05085434f, -0.10608112f, 0.07166699f, -0.39440280f, 
    -0.06029690f, -0.01302796f, -0.04850505f, -0.24952109f, -0.16552874f, 0.03060025f, -0.51549435f, 0.15201278f, 
    -0.18733598f, 0.20855623f, -0.03547099f, -0.14528887f, -0.13337824f, -0.00329003f, 0.06004405f, -0.32936332f, 
    -0.07334080f, -0.10383884f, 0.04793958f, 0.10374770f, 0.26323581f, -0.06588086f, 0.01070755f, -0.02686531f, 
    -0.04109160f, -0.27039632f, -0.40249625f, 0.07060537f, -0.27836490f, 0.08472393f, -0.30124080f, 0.13656703f, 
    -0.03362566f, -0.08711456f, -0.00361400f, 0.09042195f, -0.00595952f, -0.27655107f, 0.04410736f, 0.16679667f, 
    -0.04252879f, 0.08380364f, -0.00269590f, -0.02271605f, 0.02539302f, -0.04476589f, -0.07094018f, -0.05521056f, 
    0.00721849f, 0.18578164f, -0.12316283f, -0.31696439f, 0.35715204f, 0.11585702f, -0.02232026f, -0.06015816f, 
    -0.06490687f, -0.04886266f, 0.27229202f, -0.01127115f, -0.05311385f, 0.03355117f, -0.19081648f, 0.07431000f, 
    0.06687861f, -0.17958696f, -0.00739311f, -0.10563002f, -0.29232803f, 0.10805308f, 0.11714200f, 0.39125153f, 
    -0.02534106f, -0.04201369f, 0.00839765f, -0.32580090f, -0.00709136f, -0.04269409f, -0.22276743f, -0.27960393f, 
    0.27139622f, 0.05770712f, -0.04407435f, -0.07301508f, 0.06047567f, -0.06538481f, -0.28931069f, 0.01619658f, 
    -0.00119985f, -0.05648945f, -0.28198734f, 0.06573843f, -0.36242354f, -0.08983932f, -0.08218409f, 0.09399784f, 
    -0.15087907f, -0.63113600f, -0.25549835f, 0.17338312f, -0.00363774f, -0.00856243f, -0.18448353f, -0.20282523f, 
    -0.01891402f, 0.16054833f, -0.39119717f, -0.02627090f, -0.06105681f, 0.05728966f, -0.01527761f, 0.05929992f, 
    0.10857642f, -0.10610221f, -0.19326922f, -0.50790131f, 0.07312311f, -0.05335150f, 0.38664120f, -0.19300129f, 
    0.23079382f, 0.22069488f, 0.07125119f, 0.18827629f, -0.11838147f, 0.12512709f, -0.45983839f, 0.48818612f, 
    -0.22669679f, -0.18217015f, 0.07504942f, 0.02035218f, 0.09128956f, -0.03297130f, -0.24480498f, -0.04697197f, 
    -0.10132879f, 0.26077905f, 0.05402219f, 0.12735485f, -0.16702966f, -0.16995141f, 0.02500252f, -0.08249323f, 
    0.04334322f, 0.24216311f, 0.01967034f, -0.09285730f, -0.15872365f, 0.00425888f, 0.06376125f, 0.04961129f, 
    0.12045195f, 0.26139989f, -0.39590362f, 0.07010213f, 0.06768534f, 0.19450621f, -0.00992007f, 0.03721078f, 
    -0.03814564f, 0.06883474f, 0.01829495f, -0.16898534f, 0.01359597f, -0.32910940f, 0.05216355f, 0.28648466f, 
    -0.04484558f, -0.27627093f, 0.07234594f, -0.02757783f, -0.06748194f, 0.07587170f, 0.03141175f, -0.02213053f, 
    0.11768270f, -0.18678159f, 0.15905778f, -0.44106176f, 0.10808335f, -0.04777599f, -0.04959133f, 0.07076357f, 
    -0.16044544f, 0.06700949f, 0.18504603f, -0.00857937f, 0.24705210f, -0.03937700f, -0.40540168f, -0.00502062f, 
    0.10495419f, 0.00493923f, 0.05723577f, -0.08070269f, -0.22792797f, -0.33362302f, -0.28695741f, -0.13941751f, 
    -0.32717752f, -0.06383485f, 0.03976680f, 0.18005945f, -0.05155950f, -0.04631339f, 0.13013491f, -0.45313427f, 
    -0.27136850f, 0.25489998f, 0.16133064f, 0.04510582f, -0.33255997f, 0.00027345f, -0.02427761f, 0.00365768f, 
    -0.35081530f, -0.16308360f, 0.01262591f, 0.19686300f, 0.18645924f, -0.32473189f, 0.01462254f, -0.11895841f, 
    0.00034778f, -0.55310035f, -0.00682250f, 0.29108152f, 0.04125103f, -0.01501824f, -0.25587818f, 0.28685489f, 
    -0.18900648f, -0.05551053f, 0.09397107f, 0.16287492f, 0.13800529f, -0.24559145f, 0.07781253f, 0.04424024f, 
    0.27295750f, -0.01437880f, -0.11412410f, -0.55009639f, -0.17153636f, -0.05651810f, -0.04741955f, -0.06240195f, 
    0.03998338f, 0.07723039f, 0.07445227f, 0.16035363f, 0.08103778f, -0.24716556f, 0.06733747f, -0.12359998f, 
    0.10099719f, 0.36183536f, -0.20881215f, 0.00068997f, -0.15399495f, -0.04845053f, -0.38678339f, -0.08084415f, 
    0.20778124f, 0.09118914f, -0.07559031f, 0.10945374f, 0.16156149f, -0.33424747f, -0.05993332f, -0.27675489f, 
    0.06530131f, -0.07521541f, 0.13751651f, 0.15135515f, 0.25119111f, 0.00490841f, 0.06185396f, 0.03911024f, 
    0.11629583f, 0.09051949f, 0.08105656f, -0.09160811f, -0.40580726f, -0.14235519f, 0.13549572f, 0.03542123f, 
    0.03198129f, 0.04400508f, -0.04628419f, 0.30210900f, -0.00718036f, 0.25206640f, 0.00722455f, 0.01336480f, 
    0.07771874f, 0.15102637f, 0.01725272f, 0.01183320f, 0.03635436f, 0.05761302f, -0.07520573f, -0.05859729f, 
    -0.05264247f, 0.19947374f, 0.08435501f, -0.11107299f, -0.46904349f, -0.14398086f, -0.32972229f, -0.02820651f, 
    0.03885836f, 0.05978148f, -0.09827056f, 0.02945871f, 0.12268266f, 0.05019506f, -0.15024869f, 0.07194639f, 
    -0.02232235f, 0.10310662f, 0.00330314f, 0.26086584f, 0.10297344f, 0.01748701f, 0.22134039f, -0.11265384f, 
    0.03237722f, 0.07641720f, 0.07060304f, -0.55042022f, -0.43024495f, -0.01327527f, -0.48587021f, 0.05391552f, 
    -0.12334888f, -0.24946232f, -0.05715027f, 0.05845769f, -0.18611102f, 0.35794252f, -0.20175482f, -0.11668982f, 
    -0.10666920f, 0.15468970f, -0.13651672f, 0.09238418f, 0.11961388f, -0.05225398f, 0.07527056f, -0.29482016f, 
    0.11484626f, 0.12026808f, 0.14430608f, -0.28355062f, -0.06832499f, 0.06460292f, -0.13871513f, -0.23934838f, 
    -0.00531230f, -0.13606063f, 0.17840052f, -0.40810502f, -0.39853081f, 0.14180611f, -0.05783151f, 0.23739649f, 
    -0.01426370f, -0.03581669f, 0.25678220f, 0.20764826f, -0.16719557f, -0.01115807f, -0.01431161f, 0.41392595f, 
    -0.22645076f, -0.24836214f, 0.00940347f, 0.08270637f, -0.16955623f, 0.03098333f, -0.03615776f, -0.23220235f, 
    -0.09473944f, -0.49883887f, 0.21995255f, -0.22680604f, -0.12247237f, -0.00495926f, 0.10645133f, 0.15924129f, 
    -0.06684167f, -0.11238420f, 0.00647513f, 0.09402682f, -0.05071275f, 0.26826391f, -0.02617602f, 0.17385656f, 
    0.08246801f, -0.11211674f, -0.29271734f, 0.15839715f, -0.06528396f, 0.02205435f, 0.05866273f, 0.02065631f, 
    -0.03208992f, 0.22375058f, -0.19525197f, -0.05828835f, -0.22667961f, 0.02029376f, 0.24981536f, 0.26531053f, 
    0.02792420f, 0.02946232f, -0.06833485f, -0.46353462f, -0.17987332f, 0.18063159f, 0.04644947f, -0.03623981f, 
    0.05481278f, -0.17921865f, -0.00778872f, 0.00427575f, -0.00129776f, -0.05232241f, 0.04086231f, 0.06304662f, 
    -0.08311293f, -0.73166114f, -0.16983277f, 0.11229537f, -0.11359821f, -0.02601251f, 0.21520193f, 0.04028499f, 
    -0.45317185f, -0.01914020f, -0.09952440f, 0.27347070f, 0.14424433f, 0.02835704f, 0.29201114f, -0.01020152f, 
    -0.09063077f, 0.17956360f, 0.01940473f, 0.13009442f, -0.25142258f, -0.20563552f, 0.18723686f, -0.47639671f, 
    -0.33450451f, 0.00266113f, -0.00260593f, -0.04718167f, -0.32314718f, 0.21071582f, 0.28065276f, 0.22903110f, 
    -0.05132443f, -0.15575126f, 0.18138106f, -0.00719150f, -0.18137513f, -0.10488612f, -0.06051651f, 0.14350569f, 
    0.06486258f, -0.16208392f, 0.04656050f, -0.34293637f, -0.26440245f, 0.34343940f, -0.02569422f, -0.15270159f, 
    -0.25677434f, -0.17348686f, -0.15741059f, -0.15284434f, 0.04789754f, -0.07860417f, -0.19933352f, -0.22718838f, 
    0.10824170f, -0.26181364f, 0.25599071f, 0.32738605f, 0.03706446f, -0.35137480f, -0.07931923f, -0.15932666f, 
    -0.10226727f, 0.46072149f, -0.46956179f, -0.33589080f, -0.22190517f, 0.01443020f, 0.19275381f, -0.13179781f, 
    -0.39980856f, 0.05986051f, -0.01196188f, 0.10098796f, -0.34971875f, 0.24738632f, 0.09668340f, -0.29362443f, 
    -0.48012018f, 0.21619423f, -0.43035331f, -0.22124653f, -0.44831628f, 0.02376935f, 0.04659575f, 0.20831387f, 
    0.23817986f, -0.33945331f, 0.03526951f, -0.20205295f, -0.06620765f, -0.04474284f, -0.08003936f, 0.38016576f, 
    -0.00307586f, 0.21590550f, 0.05765457f, 0.09312660f, -0.21798794f, -0.07018651f, -0.04040822f, 0.02799164f, 
    0.12595762f, -0.13615406f, -0.00138484f, 0.03629519f, 0.17015506f, 0.22237381f, 0.00333864f, -0.19429950f, 
    0.02309596f, -0.00770942f, -0.06868216f, -0.63939607f, 0.01674796f, -0.04109140f, -0.05695979f, 0.29569724f, 
    0.06528335f, 0.22039394f, -0.01149960f, 0.00163519f, -0.02099176f, 0.04367985f, -0.01986318f, 0.01533071f, 
    0.00759729f, 0.12247875f, -0.44898537f, 0.38793576f, -0.05422651f, -0.08970416f, -0.16944361f, -0.00934513f, 
    0.16289650f, 0.02724590f, -0.17944035f, 0.11196128f, 0.08762469f, 0.07548125f, -0.07352340f, -0.02920239f, 
    0.04587564f, -0.32456332f, 0.03418313f, 0.00507935f, -0.21113433f, -0.07084386f, -0.48401374f, -0.33615002f, 
    0.28688630f, 0.07152187f, 0.05277544f, 0.12716673f, 0.13974647f, 0.26335120f, -0.13965753f, -0.39622214f, 
    -0.37869778f, 0.09028089f, 0.17753345f, -0.00936941f, 0.00253451f, -0.23066857f, 0.10038319f, -0.28876945f, 
    -0.01038441f, -0.07496925f, -0.15005778f, -0.25447002f, -0.30584866f, 0.15171514f, 0.03144502f, 0.30130905f, 
    -0.26851165f, -0.22987717f, 0.32156283f, -0.10801324f, -0.07808504f, -0.01399543f, 0.23072895f, 0.24761778f, 
    -0.14872810f, 0.00055893f, 0.07079907f, 0.06092303f, 0.10086230f, -0.07409842f, 0.18224496f, 0.06560245f, 
    -0.10562200f, -0.14851841f, -0.27198082f, 0.15550134f, 0.07178187f, -0.05720236f, 0.22998884f, -0.05884052f, 
    0.03224714f, -0.58026952f, 0.05294367f, -0.12625585f, -0.12791066f, -0.42112947f, -0.38275224f, -0.15968855f, 
    0.13728081f, 0.07132317f, 0.19090648f, -0.37057462f, 0.12857988f, -0.07720726f, -0.19833019f, 0.11672706f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.10091488f, -0.01776882f, 0.06087954f, -0.07508994f, -0.01923457f, -0.08206862f, 0.11072378f, -0.06283459f, 
    0.08747791f, -0.01162807f, 0.07566088f, 0.03963126f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
