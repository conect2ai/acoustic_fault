#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.66204286f, 0.68137306f, -0.26301339f, -0.59467566f, -0.39829943f, -0.09210286f, -0.43062243f, -0.46784410f, 
    -0.53225040f, 0.50343716f, 0.12003706f, 0.57943290f, 0.27593231f, -0.25973558f, -0.14216669f, 0.55929971f, 
    -0.38517511f, 0.08383492f, -0.43431613f, -0.67866516f, 0.97214085f, -0.72726911f, -0.75694340f, -0.40238541f, 
    0.27568629f, 0.09847492f, 0.36149922f, 0.40797910f, 0.96213490f, 0.69887096f, -0.91518968f, 0.10473115f, 
    -0.58821285f, 0.03374630f, 0.09901467f, -0.05595014f, -0.60515362f, -0.82937032f, -0.91607964f, -0.12835345f, 
    -0.33483815f, 0.29311204f, 0.29328910f, -0.08150066f, 0.27560961f, 0.73180342f, 0.56992841f, -0.54143304f, 
    0.40696037f, -0.29233462f, -0.52763581f, -0.46097505f, 0.52779484f, 0.31201598f, -0.17505386f, 1.17958081f, 
    -1.08506000f, 0.20397916f, -0.14536959f, 0.02957482f, 0.37001538f, -0.47927824f, -0.05437596f, 0.55233413f, 
    0.48919192f, 0.57805663f, 0.16343895f, 0.31989402f, 0.48353493f, 0.35638851f, 0.37114823f, 0.02384588f, 
    0.72101504f, -0.41931185f, -0.16096270f, 0.55492371f, 0.11315049f, 0.40601781f, 0.36443344f, -1.04578149f, 
    -0.36030850f, -0.51173586f, -0.91031474f, -0.14138512f, 0.32204542f, -0.33502418f, 0.56954765f, -0.44488075f, 
    -0.28550664f, -0.54902208f, -0.19311190f, -0.12432297f, 0.69564563f, 0.44876575f, 0.40252504f, 0.39886972f, 
    -0.21667171f, 0.72249687f, -0.54434884f, 0.04445124f, -0.06541166f, 0.44830242f, -0.74289018f, -0.24094151f, 
    -0.02256808f, 0.39155823f, 0.70410538f, 0.84098047f, -1.17985880f, -0.52003199f, -0.14178534f, 0.98445565f, 
    0.61190110f, -0.87827772f, -0.11964038f, -0.17986915f, -0.24475604f, -1.39507508f, -0.17887847f, 0.05339439f, 
    -0.57004702f, -0.51690823f, -0.17851430f, 0.15197849f, -0.41090286f, -0.20116811f, 0.18572782f, 0.31084445f, 
    0.18382442f, 0.15687062f, 0.09617623f, 0.65344572f, -0.39938188f, -0.40524417f, 0.83792460f, -0.67951471f, 
    -0.00003144f, -0.58876628f, 0.77693468f, 0.55755872f, 0.60359508f, 0.39692831f, 0.46826449f, 0.20905574f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.22265896f, 0.69851261f, 0.13241994f, 0.31857410f, 0.71915191f, 0.38818017f, -0.18785146f, -0.23221305f, 
    0.32623875f, -0.05174429f, -0.02601341f, -0.22809149f, -0.03972576f, 0.07106083f, 0.56285334f, 0.09905487f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.39873835f, 0.03617343f, -0.26684895f, -0.34945849f, -0.45890808f, -0.18279243f, -0.11315806f, 0.08507676f, 
    0.02429203f, 0.32677838f, 0.38580248f, 0.26711750f, -0.03114804f, 0.02815515f, -0.03926376f, 0.14775652f, 
    0.11021043f, 0.12412954f, -0.24314710f, -0.71203458f, 0.04804497f, -0.04442251f, -0.09162349f, 0.10736088f, 
    0.18453415f, -0.05630263f, 0.03915075f, 0.56098747f, 0.30521563f, 0.30145371f, -0.00389508f, 0.03723894f, 
    -0.18207639f, -0.06589016f, 0.12636580f, 0.02401339f, 0.20270209f, -0.28903961f, -0.09685399f, 0.11631963f, 
    0.16510992f, -0.01054131f, -0.02189294f, 0.11275599f, -0.01601287f, 0.23104219f, 0.28910625f, 0.14493090f, 
    -0.07491905f, 0.00844803f, 0.08522157f, 0.17152780f, -0.00425997f, 0.04285618f, -0.18905550f, -0.60042459f, 
    -0.40312588f, -0.21545337f, -0.02359883f, -0.12358196f, 0.24173018f, -0.03770456f, -0.03970553f, 0.44013357f, 
    0.33807534f, -0.00016675f, -0.33720177f, -0.16320498f, -0.03406252f, -0.07436430f, -0.15390855f, 0.11563272f, 
    -0.22013801f, 0.01354403f, 0.02394565f, 0.10868855f, -0.19296366f, -0.01961514f, -0.10330638f, -0.10878171f, 
    0.07896470f, 0.08952241f, -0.09932365f, 0.22693436f, -0.13756080f, 0.14345188f, -0.12811366f, 0.04382136f, 
    -0.12773368f, 0.16486295f, 0.09583685f, 0.07863647f, -0.11254307f, -0.09160160f, 0.15137492f, 0.14041625f, 
    0.18095830f, 0.04440321f, 0.12920874f, 0.21698041f, -0.31656736f, -0.19645932f, -0.14303289f, -0.05948070f, 
    -0.21773481f, 0.22852090f, 0.18073517f, -0.29132733f, -0.33905330f, -0.57201725f, -0.33456045f, -0.09723724f, 
    0.17777106f, 0.03697763f, -0.09009218f, -0.10139388f, 0.13387735f, 0.40832275f, -0.15850104f, -0.12661710f, 
    -0.18472239f, -0.21500589f, -0.03683693f, 0.04575993f, 0.12900169f, 0.11131181f, 0.26589242f, 0.09835728f, 
    0.35873792f, 0.07247602f, -0.02848879f, 0.12681273f, 0.03976256f, 0.01852155f, -0.20089996f, -0.47545224f, 
    -0.17321911f, -0.16977240f, 0.08296138f, 0.13668361f, 0.21006072f, -0.00511902f, -0.11038139f, -0.15014127f, 
    -0.33334273f, -0.31939420f, -0.30577543f, -0.14845273f, 0.14546141f, 0.05703485f, -0.12017655f, -0.11644813f, 
    -0.15780520f, 0.01145345f, 0.20878509f, 0.30590495f, -0.05219742f, 0.35677600f, 0.09645968f, 0.08026458f, 
    0.33792558f, 0.28212166f, -0.22795179f, -0.04024090f, 0.10131864f, -0.00364844f, 0.24126692f, 0.07353693f, 
    0.12750193f, 0.07839011f, 0.10888024f, -0.15485777f, -0.39157087f, 0.24642049f, 0.03756317f, 0.02171328f, 
    0.06716637f, 0.17089428f, -0.09178554f, 0.00306267f, -0.27085176f, 0.18368600f, -0.09884305f, -0.09013375f, 
    0.11188105f, 0.07552270f, -0.01947826f, 0.05346105f, -0.00427814f, 0.01255766f, -0.07991360f, 0.32504183f, 
    -0.13191387f, 0.12467739f, 0.19410346f, -0.01073187f, 0.10828247f, 0.17766742f, -0.16326433f, 0.32873029f, 
    0.09290929f, 0.18999712f, 0.08150224f, 0.33122149f, 0.28790399f, -0.07930920f, -0.01310502f, 0.08077952f, 
    0.06227626f, 0.03639527f, -0.30570984f, 0.04831535f, -0.18720680f, -0.21843030f, -0.06736343f, 0.09593849f, 
    -0.06785273f, 0.16895655f, 0.04965330f, -0.12684064f, 0.08742545f, -0.13428955f, -0.09768072f, -0.26971585f, 
    0.10850002f, -0.01970596f, 0.04048047f, -0.52439648f, 0.07476472f, -0.03895957f, 0.05691723f, 0.05016480f, 
    -0.12707847f, -0.08465745f, 0.00061633f, 0.19726856f, 0.08527644f, -0.03966391f, 0.17352878f, -0.23598696f, 
    -0.14957532f, 0.04305031f, 0.04483726f, 0.29158592f, -0.21242775f, -0.22288127f, 0.09357571f, -0.00755461f, 
    0.09131160f, 0.04096353f, 0.10205757f, 0.35751006f, -0.20821492f, -0.17054340f, 0.26612383f, 0.04280757f, 
    -0.14321171f, -0.11274593f, -0.00240247f, 0.02372709f, 0.05080300f, -0.25519353f, -0.22068122f, 0.05366022f, 
    -0.02621789f, 0.07591378f, -0.01146936f, 0.09970360f, 0.13534768f, -0.06604353f, 0.01804759f, 0.31088084f, 
    0.23061623f, 0.16754140f, -0.03649275f, -0.08179863f, 0.04554980f, -0.06703749f, 0.00001171f, -0.37031010f, 
    0.07094508f, 0.09491379f, -0.08386470f, -0.09293539f, -0.10083103f, -0.04114186f, -0.10606249f, 0.02074925f, 
    0.29937980f, 0.18915167f, 0.23740868f, -0.08487972f, 0.04763306f, -0.02190269f, 0.10378478f, 0.04396773f, 
    0.18511941f, -0.28762847f, -0.26489475f, -0.11836646f, 0.03919498f, 0.03570697f, -0.02335689f, -0.01267976f, 
    -0.07696539f, -0.04324444f, 0.13773294f, 0.13396542f, -0.00504581f, -0.07405135f, -0.13850790f, 0.17863913f, 
    0.08725705f, 0.15958866f, 0.04699051f, -0.40153897f, -0.08042207f, 0.20122409f, -0.03713357f, -0.05702648f, 
    -0.19675964f, 0.17408128f, 0.02714577f, 0.10374165f, 0.12408553f, -0.27916524f, -0.41280481f, -0.00979318f, 
    0.18957776f, -0.21463491f, 0.08984222f, 0.02208487f, -0.11170805f, -0.15864107f, -0.06067176f, -0.21092021f, 
    -0.25892326f, 0.01834738f, -0.20717578f, 0.09550223f, 0.10814986f, 0.06873807f, -0.19959660f, -0.38483235f, 
    0.53233361f, 0.14745596f, 0.04902091f, 0.30056378f, -0.20752607f, -0.03977153f, -0.03371746f, 0.06852231f, 
    -0.15209949f, 0.05884337f, -0.02172051f, 0.03621739f, 0.13420048f, 0.09962219f, -0.09053850f, 0.04253653f, 
    -0.24211791f, -0.24555835f, -0.00705558f, 0.08200185f, 0.04120413f, -0.06187142f, 0.10564084f, -0.15516216f, 
    0.08872240f, 0.03701451f, 0.22990495f, -0.07876256f, -0.02405899f, 0.26976660f, -0.03768807f, 0.13785714f, 
    0.00042827f, 0.12732585f, 0.05899626f, 0.04193084f, 0.07698171f, 0.08357402f, 0.08941590f, 0.17912009f, 
    -0.07759778f, -0.24665591f, -0.02695550f, -0.15333445f, 0.09101949f, 0.10867797f, 0.34793058f, 0.33727759f, 
    0.16524585f, -0.06257591f, 0.16102132f, 0.08844189f, 0.59307301f, -0.23645793f, 0.07220755f, -0.21369840f, 
    0.17859332f, -0.14798461f, -0.00215731f, 0.08067437f, 0.17107044f, 0.39573103f, 0.18336843f, -0.37695026f, 
    -0.12190105f, 0.03153835f, -0.02651416f, -0.10642698f, -0.01284794f, 0.03549170f, -0.04003323f, -0.03108564f, 
    0.03989188f, 0.05667004f, -0.05220231f, -0.00298759f, 0.11538488f, -0.29626957f, -0.05386201f, -0.01449587f, 
    0.04513314f, 0.19936815f, 0.08455873f, 0.12511274f, -0.07247727f, 0.20520209f, -0.18295696f, -0.13527778f, 
    0.29531726f, -0.22927590f, -0.52463013f, -0.05123880f, 0.08778884f, 0.04478335f, -0.04905690f, 0.10785297f, 
    -0.11292466f, -0.02757332f, 0.07539726f, 0.08777355f, 0.15563324f, -0.17728294f, 0.27899387f, -0.16832359f, 
    -0.00605186f, -0.10941584f, -0.34823936f, -0.00276996f, 0.13471393f, 0.06906965f, 0.20431225f, 0.12558550f, 
    0.03849855f, 0.09789635f, 0.15544164f, -0.06316908f, -0.34038815f, -0.06090657f, 0.11068687f, 0.08379750f, 
    -0.01601334f, 0.21127775f, 0.35738358f, -0.00235644f, 0.00909867f, 0.29367644f, 0.06415993f, -0.04692496f, 
    -0.05337150f, -0.03125563f, -0.04662631f, 0.21975757f, -0.04553420f, 0.36575392f, -0.39506862f, -0.31099406f, 
    0.02889877f, 0.17851777f, 0.18310833f, 0.21559042f, -0.10186382f, 0.00998329f, -0.01832100f, -0.06449888f, 
    -0.42885408f, -0.09119751f, -0.03466194f, 0.20685887f, -0.05265229f, -0.14323686f, -0.04803093f, -0.04344416f, 
    0.04162605f, 0.20477261f, 0.22292440f, 0.09887349f, 0.12043047f, 0.05435051f, -0.05108616f, -0.01305265f, 
    0.13688710f, 0.09534248f, 0.02911837f, -0.06480551f, -0.15415707f, 0.07085779f, -0.00719623f, -0.12467511f, 
    -0.43579087f, -0.13997842f, 0.03178610f, 0.27751648f, -0.04585511f, 0.08875663f, 0.01060457f, -0.16898887f, 
    -0.11461668f, -0.33128670f, -0.05870806f, -0.10090555f, 0.10242494f, 0.10454762f, -0.06764567f, 0.06757901f, 
    -0.00747730f, 0.01035574f, 0.00067244f, 0.12880984f, -0.16753000f, 0.09977344f, 0.15745826f, -0.00273637f, 
    -0.00747831f, 0.17549695f, 0.25341630f, 0.23444617f, -0.44866487f, 0.04270560f, 0.27851346f, 0.09032866f, 
    0.10785279f, -0.05071892f, 0.00861093f, -0.15990083f, -0.24165638f, -0.27915603f, -0.06477441f, 0.17145072f, 
    0.14482613f, 0.04138247f, 0.19402631f, 0.09810227f, 0.04580228f, -0.08190975f, -0.05595324f, 0.04546764f, 
    0.35969922f, -0.15226603f, 0.06523484f, 0.05710421f, -0.01139953f, -0.19940220f, 0.09824012f, -0.03054655f, 
    0.20234725f, 0.01690984f, 0.20581818f, 0.07958864f, 0.09496600f, 0.09669099f, 0.11411540f, 0.01590868f, 
    -0.09217857f, 0.29629391f, -0.28069752f, 0.05722692f, -0.13742027f, -0.05997416f, 0.09406506f, 0.08187258f, 
    0.01036988f, 0.25126657f, 0.28631786f, -0.18846801f, 0.10324351f, -0.06390309f, -0.03955190f, 0.06410357f, 
    0.17578574f, 0.23358777f, -0.70879096f, -0.51103210f, -0.07240438f, -0.13127506f, -0.05816330f, -0.23935744f, 
    -0.18679112f, -0.06364443f, 0.07938559f, -0.53626907f, 0.45255020f, -0.15194885f, -0.12560226f, -0.20041053f, 
    -0.00856463f, 0.02012282f, 0.09900960f, 0.00046532f, 0.45303538f, 0.25576666f, -0.24049319f, -0.16347682f, 
    0.21760722f, -0.17223884f, -0.00023555f, 0.24516399f, -0.01139329f, 0.58490121f, 0.13680321f, -0.27794847f, 
    -0.11727343f, -0.17567828f, 0.18833399f, 0.11711428f, 0.04192793f, 0.16302039f, -0.60670131f, 0.05486377f, 
    -0.48771194f, -0.00519693f, 0.09618718f, 0.04881733f, -0.05200411f, 0.13745154f, -0.03139147f, 0.06912943f, 
    -0.02720089f, 0.26136443f, -0.00094689f, -0.23606271f, -0.04943007f, -0.02007889f, -0.10591365f, -0.01034371f, 
    0.32273430f, 0.19710526f, 0.21680665f, -0.01980046f, 0.14896205f, -0.07444710f, -0.00914515f, 0.10626487f, 
    0.13677518f, -0.27861452f, 0.07527993f, -0.07955587f, 0.06450470f, -0.18246448f, -0.17159106f, 0.05716562f, 
    0.02591414f, -0.10789932f, 0.12930970f, 0.01888551f, 0.25665048f, -0.43526453f, 0.03193318f, -0.11294371f, 
    -0.20057714f, -0.00106020f, -0.01806695f, -0.52085507f, -0.22042270f, 0.14310837f, 0.19621977f, -0.19549280f, 
    -0.15983875f, 0.03828372f, 0.02863781f, -0.04872878f, -0.22737299f, 0.73485202f, -0.17336194f, -0.07178847f, 
    0.03631366f, 0.09683440f, 0.10782632f, -0.01577805f, -0.16730562f, -0.00510931f, -0.29257837f, 0.00013212f, 
    -0.01790751f, -0.13038687f, 0.07295197f, -0.09985057f, 0.00325540f, -0.09424855f, 0.05762482f, -0.09318306f, 
    0.12777364f, 0.03805501f, 0.01362598f, -0.00272968f, -0.01980807f, 0.22849075f, -0.14775455f, 0.08171540f, 
    0.21917427f, -0.17514320f, -0.48829123f, -0.00307581f, 0.03125794f, -0.08093072f, 0.05509802f, 0.06515947f, 
    -0.03520700f, -0.74891996f, 0.17573614f, -0.12408573f, 0.06219496f, -0.13260670f, 0.02411801f, 0.03060072f, 
    -0.22422217f, -0.18888976f, -0.07854518f, 0.14677355f, -0.04507697f, 0.08108117f, 0.05284773f, 0.09790479f, 
    0.22626236f, 0.10818571f, 0.14546640f, -0.10905511f, 0.07940283f, 0.12201761f, 0.05817249f, -0.01777748f, 
    0.16758190f, 0.12686929f, 0.42996138f, -0.31098700f, -0.45538697f, 0.14727555f, -0.14183176f, 0.01211126f, 
    -0.03177636f, -0.19815300f, -0.06220928f, 0.22537772f, -0.28696218f, -0.24423760f, 0.32763070f, 0.01495560f, 
    0.02553846f, 0.04788040f, -0.09423681f, 0.13385928f, 0.05328089f, -0.01962893f, 0.07784835f, 0.44155332f, 
    0.14719109f, 0.18147059f, 0.11197582f, 0.06784106f, 0.11496776f, 0.25072071f, 0.56059700f, 0.15773988f, 
    0.19197266f, 0.29241478f, -0.04455214f, 0.13152365f, 0.04094324f, 0.22337720f, 0.29397282f, -0.17316940f, 
    -0.09616373f, -0.14906560f, -0.19887458f, -0.04351168f, -0.31647629f, 0.12446441f, 0.13914084f, -0.06551944f, 
    -0.12710701f, -0.03041686f, 0.16545415f, -0.26418269f, 0.00135168f, -0.24316879f, 0.06530893f, 0.09506571f, 
    -0.13412002f, -0.10874099f, -0.29467234f, 0.05429748f, -0.15049501f, -0.04166783f, 0.18610650f, 0.05331309f, 
    0.08471394f, 0.17183913f, -0.02763807f, 0.00633642f, 0.04063396f, 0.05460133f, -0.00481266f, 0.23551811f, 
    0.15376890f, -0.25120947f, 0.00076845f, -0.03967643f, -0.28067064f, -0.35884511f, -0.10268649f, -0.06002657f, 
    -0.43621022f, 0.15729548f, 0.18836005f, 0.16547959f, -0.33473697f, -0.05481903f, 0.28870231f, -0.03897581f, 
    0.18574923f, -0.21641189f, 0.05072888f, 0.19525708f, 0.07054681f, -0.08479477f, 0.14658181f, -0.01724385f, 
    0.16696844f, 0.01981442f, -0.01107233f, 0.04675040f, 0.02657441f, 0.34161559f, -0.07054523f, 0.06551543f, 
    -0.16003464f, -0.06902261f, 0.01333665f, 0.07293017f, 0.15554488f, 0.11721743f, 0.15055044f, -0.11818582f, 
    -0.12301721f, 0.02011599f, 0.14182082f, 0.21104616f, 0.08234624f, -0.15903930f, -0.03746468f, 0.34956867f, 
    -0.30003855f, -0.04816280f, 0.51856792f, 0.24356411f, -0.09958031f, -0.14054774f, -0.02285199f, 0.05163441f, 
    -0.04446900f, -0.17501327f, -0.33549142f, 0.05903226f, 0.00555767f, 0.22915119f, 0.03923207f, -0.01662883f, 
    0.12727240f, 0.06356909f, -0.01446327f, 0.27615803f, 0.34759751f, -0.05257554f, 0.09645479f, -0.23629557f, 
    0.16890550f, 0.03993741f, -0.12891147f, -0.73536658f, -0.13858721f, 0.17506908f, -0.10674433f, 0.11999281f, 
    0.05758157f, -0.03916738f, -0.06066648f, 0.15045433f, -0.00145996f, -0.06290694f, 0.30985326f, 0.06569250f, 
    0.08004926f, 0.00364095f, 0.19177434f, 0.01034895f, 0.00872648f, -0.23996586f, -0.05884627f, 0.24538766f, 
    -0.00581304f, 0.14138815f, 0.09088087f, -0.08803561f, 0.15438545f, -0.02790371f, -0.22000599f, 0.02932785f, 
    0.64225119f, 0.16649704f, 0.24744217f, -0.15905125f, -0.12962225f, 0.06274448f, 0.25134173f, -0.02794456f, 
    -0.42416275f, -0.07862335f, -0.01673331f, 0.03849746f, -0.04199837f, -0.13838612f, 0.00107399f, 0.17200126f, 
    0.01070697f, 0.08552955f, 0.08990618f, -0.03319345f, 0.02595645f, -0.06711658f, -0.00402121f, 0.06587566f, 
    0.32199353f, 0.07778124f, -0.04011850f, -0.14555794f, -0.14726257f, 0.07305589f, -0.09598960f, 0.27278802f, 
    -0.04326888f, -0.20954937f, 0.00764625f, 0.20144078f, -0.02822487f, 0.00961030f, 0.13061097f, -0.17978568f, 
    -0.02040644f, 0.30457020f, 0.31516364f, -0.26309189f, 0.21205015f, -0.18704677f, -0.10870172f, 0.03163662f, 
    -0.07380956f, -0.10667031f, -0.08222273f, -0.12810132f, 0.43905690f, 0.17788555f, 0.10753272f, 0.04774500f, 
    -0.25824416f, -0.08750826f, -0.07521891f, 0.02578597f, 0.02937376f, 0.33335808f, 0.15826310f, 0.00282828f, 
    -0.03174979f, 0.11387175f, -0.17420439f, 0.00152642f, -0.06847005f, 0.13862570f, 0.08136968f, 0.11940986f, 
    -0.46306831f, 0.31170279f, -0.06263206f, -0.02553963f, 0.17054357f, 0.19213231f, 0.06841531f, -0.15686491f, 
    -0.04829312f, 0.02662651f, 0.18178760f, 0.12569869f, -0.04026194f, -0.04599437f, -0.11525941f, 0.09322081f, 
    -0.11341411f, -0.38112321f, 0.14788082f, -0.03990142f, -0.07062148f, -0.08204813f, 0.15780483f, 0.05174706f, 
    0.10382511f, -0.20784320f, -0.33644056f, 0.05034520f, 0.11163489f, 0.20541818f, 0.08923141f, 0.03683261f, 
    0.07855926f, -0.05399657f, 0.12086631f, -0.29713002f, -0.07032567f, -0.21931399f, -0.02803251f, -0.16008987f, 
    0.02045038f, 0.07108410f, -0.16049972f, 0.02383809f, -0.63281274f, 0.13572434f, 0.18333691f, 0.05160498f, 
    0.08537330f, -0.21200724f, 0.01808592f, -0.06911170f, -0.16365737f, 0.57865292f, 0.64844370f, 0.19455773f, 
    -0.07871570f, -0.14889695f, 0.03923020f, -0.12920050f, 0.12508166f, 0.06176086f, -0.12604105f, -0.35157916f, 
    -0.06772581f, -0.03794109f, -0.03544053f, 0.18079989f, 0.08969864f, -0.03715229f, 0.01472007f, -0.82552481f, 
    -0.34945825f, 0.00181849f, 0.00057686f, -0.14544100f, 0.06475722f, -0.02874416f, 0.14064458f, 0.00813692f, 
    -0.03984277f, -0.00874339f, 0.07768182f, -0.05863914f, -0.17243558f, 0.18823893f, -0.11952060f, 0.07246225f, 
    -0.13876347f, 0.13525608f, -0.08694964f, 0.07035206f, -0.16080554f, 0.17200968f, 0.08083072f, 0.19413175f, 
    0.17218359f, 0.05861447f, -0.04698521f, 0.30706796f, -0.06120608f, 0.04148337f, -0.00643187f, 0.04244804f, 
    -0.01800453f, -0.01476937f, 0.20317040f, 0.13735285f, 0.04852465f, -0.22787300f, -0.20219392f, -0.14370808f, 
    0.02724285f, 0.07865802f, -0.01400715f, 0.03720877f, -0.33131051f, -0.32236597f, -0.15987112f, -0.09001482f, 
    0.11989360f, 0.04824861f, 0.09285796f, -0.05386899f, -0.58588493f, -0.16671982f, 0.42349032f, -0.13789649f, 
    -0.03569110f, -0.13548827f, -0.04624442f, 0.05671534f, -0.06440935f, -0.01387710f, -0.01354395f, 0.25047579f, 
    0.04224149f, -0.05041686f, -0.17452066f, -0.04706140f, 0.06559296f, 0.12534809f, 0.03501909f, -0.01046651f, 
    -0.03106241f, -0.14280047f, -0.15011844f, 0.07693549f, -0.00254848f, 0.06985004f, 0.32790217f, 0.03474908f, 
    0.27676272f, 0.47286540f, -0.43389583f, -0.15324758f, 0.05655767f, 0.12179182f, 0.03983236f, 0.08922563f, 
    0.49169615f, 0.18826777f, 0.36608005f, 0.34409496f, 0.05848594f, -0.09032711f, 0.02753306f, 0.11822604f, 
    -0.01215538f, 0.32970202f, 0.04893627f, 0.08497686f, -0.07104048f, 0.06697404f, 0.13256438f, -0.14200160f, 
    0.01838528f, -0.02681207f, 0.06776655f, -0.02104152f, -0.06090143f, 0.20681645f, 0.02876140f, 0.09625214f, 
    -0.10578136f, -0.15133756f, -0.00614020f, 0.33316401f, 0.41654184f, -0.08379612f, -0.09432434f, 0.02327543f, 
    0.06753884f, 0.01387426f, 0.04308363f, 0.08569881f, 0.18435591f, -0.06910690f, 0.13834308f, -0.00171970f, 
    -0.01616327f, -0.01837380f, 0.08883104f, -0.08401886f, -0.10614785f, 0.07593916f, 0.19038619f, -0.03806466f, 
    0.13954830f, 0.11691169f, 0.13482949f, -0.01941580f, -0.24573834f, -0.02507306f, 0.29660589f, 0.10671122f, 
    0.28163114f, 0.13841307f, 0.01539971f, -0.02200229f, 0.19524859f, -0.16081204f, 0.19447351f, 0.18482937f, 
    -0.05620635f, 0.07321333f, 0.19029847f, 0.16719131f, 0.08737484f, 0.10584148f, -0.22274303f, -0.04283654f, 
    -0.12293842f, -0.21271352f, 0.00194385f, -0.04098396f, -0.03608026f, 0.13729775f, 0.07046247f, 0.05421583f, 
    0.08965945f, -0.08082198f, -0.00935037f, 0.03805672f, 0.02007068f, -0.01751865f, 0.24641897f, -0.03924890f, 
    0.18279953f, 0.44252124f, 0.08508755f, 0.25133663f, -0.24786043f, 0.07870308f, 0.06456209f, 0.03040784f, 
    0.00054344f, -0.02603045f, -0.23595288f, -0.16224495f, 0.17436969f, 0.02022640f, -0.10729255f, 0.08564743f, 
    0.06723261f, -0.01256525f, -0.38238344f, -0.61062723f, -0.29525974f, 0.14550696f, -0.09065175f, 0.01840094f, 
    -0.04168994f, 0.09143043f, 0.01030865f, 0.09009139f, 0.48601609f, -0.03990165f, 0.03581839f, 0.16255233f, 
    0.18784557f, -0.08960181f, 0.22548556f, 0.06103330f, -0.11047740f, 0.21352233f, -0.29391572f, -0.07406840f, 
    -0.02685795f, 0.08434786f, -0.06885111f, -0.16927432f, 0.05376195f, -0.03221587f, -0.25501320f, 0.02217587f, 
    -0.02378550f, 0.09036731f, 0.03656868f, 0.08700321f, 0.07804920f, -0.12893872f, -0.11145047f, -0.17772093f, 
    0.03008703f, 0.01682782f, -0.06687739f, -0.15533961f, 0.13563234f, 0.14790642f, 0.15311514f, -0.09991755f, 
    0.06535890f, 0.11533672f, 0.24005195f, 0.08195980f, 0.15289201f, 0.04938346f, -0.20019919f, 0.05398342f, 
    -0.16976687f, 0.11747434f, -0.69353676f, 0.51035273f, 0.12765309f, -0.09918566f, 0.12161639f, 0.38778731f, 
    -0.03698277f, -0.12340363f, -0.10481175f, -0.03871727f, 0.24274939f, -0.30469128f, 0.13488729f, 0.15359446f, 
    -0.09943921f, -0.04141032f, -0.02629801f, 0.15646687f, -0.07304431f, -0.22297479f, -0.05753893f, 0.10238494f, 
    0.11206709f, -0.19493641f, -0.01042545f, -0.16365969f, -0.16673067f, 0.33336911f, 0.12419884f, 0.31187820f, 
    0.02851056f, 0.29728469f, -0.03280615f, 0.14584248f, 0.10340136f, 0.09474827f, -0.07635630f, 0.81726944f, 
    0.19670525f, -0.03771150f, 0.06795718f, 0.31335750f, 0.01031827f, 0.26853305f, -0.08168406f, -0.01681615f, 
    0.20897022f, 0.10906938f, 0.10377219f, 0.02087691f, 0.05254740f, -0.08541016f, 0.00647185f, 0.00419413f, 
    0.05995129f, -0.22729112f, 0.33608368f, 0.14801387f, -0.37750781f, -0.03695904f, -0.13757730f, 0.19016880f, 
    0.03668441f, -0.04784112f, -0.01318139f, -0.03345332f, 0.15107866f, -0.02072836f, -0.08315099f, 0.04718156f, 
    0.23922990f, -0.15363243f, -0.01553138f, 0.38732648f, -0.15593526f, 0.11556890f, 0.13205747f, -0.04815168f, 
    -0.14659779f, 0.09055658f, -0.18043989f, -0.10502435f, 0.18891656f, -0.01215445f, -0.03554626f, 0.06035475f, 
    0.12474344f, -0.05088934f, -0.03377879f, 0.17796536f, -0.13698670f, -0.21259956f, -0.21341877f, -0.02910501f, 
    0.00647055f, 0.00538434f, 0.07997286f, 0.04458817f, -0.07538491f, -0.24050736f, -0.10767236f, -0.01222430f, 
    -0.02099185f, -0.04490523f, 0.05511209f, 0.04877435f, -0.01366690f, 0.08165084f, -0.02162700f, 0.18855558f, 
    -0.04232787f, -0.16010553f, -0.02378449f, -0.08247550f, -0.09518033f, 0.05730572f, -0.05622331f, 0.18716280f, 
    -0.09802888f, 0.12238036f, -0.11434185f, -0.14105015f, -0.11342086f, -0.18854930f, -0.16628295f, -0.04565835f, 
    0.24937266f, -0.28732589f, 0.11393918f, 0.02191565f, 0.12555240f, -0.15299717f, 0.02212017f, 0.09545581f, 
    0.09285779f, -0.33913094f, 0.15869310f, 0.00592424f, 0.11447013f, -0.13194038f, -0.06722445f, -0.02066120f, 
    -0.30490389f, 0.02549127f, -0.20743071f, -0.52641690f, 0.53276247f, -0.06010168f, 0.12355802f, -0.14145395f, 
    0.16266510f, -0.14232393f, -0.09036881f, -0.00528072f, -0.47109073f, -0.00484633f, 0.14358629f, -0.01935961f, 
    -0.04119063f, 0.01941367f, 0.22233917f, -0.10790258f, -0.35704345f, 0.30261275f, -0.18336146f, 0.19245452f, 
    0.03480389f, 0.04681612f, 0.06180790f, 0.01005312f, 0.00624303f, 0.23739754f, 0.23592167f, -0.13884437f, 
    -0.34630591f, 0.11664857f, 0.14274739f, 0.09330034f, 0.00428789f, 0.04188734f, 0.57077348f, -0.00217537f, 
    -0.53977573f, 0.11048208f, 0.25586119f, 0.03109466f, 0.00944349f, 0.06807533f, -0.07271676f, 0.03688555f, 
    0.05881030f, -0.02789829f, -0.01353476f, -0.01735505f, -0.07783543f, 0.14235114f, 0.12565787f, 0.10503442f, 
    -0.06874555f, 0.08142422f, -0.28066412f, 0.01250795f, 0.20300062f, -0.16754536f, 0.20007154f, 0.12859629f, 
    0.08854293f, 0.39249337f, -0.11829634f, -0.08670013f, 0.05369372f, -0.07971462f, 0.24516021f, -0.13643590f, 
    0.07880815f, 0.10964614f, 0.16158776f, 0.17333813f, -0.06116104f, -0.06754848f, -0.05792147f, -0.31256515f, 
    0.05929567f, 0.03479973f, -0.08407885f, 0.19270727f, -0.15155783f, 0.19378863f, -0.04011407f, -0.18047477f, 
    -0.09006497f, -0.04329959f, 0.11381677f, -0.08828770f, -1.03631949f, -0.16332866f, -0.59139985f, 0.11196579f, 
    -0.09288869f, 0.30200422f, 0.08805673f, 0.02460646f, -0.06956030f, 0.06705631f, 0.18686390f, 0.46214953f, 
    -0.17616132f, -0.06471875f, 0.10621178f, 0.01740807f, -0.11858749f, -0.02401511f, 0.15073435f, -0.06903763f, 
    0.29676345f, -0.08674634f, 0.05753228f, 0.01654257f, -0.08666015f, 0.26071584f, -0.00865906f, 0.08611364f, 
    -0.14788252f, -0.18615025f, -0.19504856f, -0.23222195f, 0.10036042f, -0.02015169f, -0.10910067f, 0.06705619f, 
    0.05129677f, -0.29263330f, 0.23616675f, 0.19065747f, -0.17390490f, 0.14140882f, -0.23934694f, -0.03697937f, 
    0.00007059f, -0.22590984f, 0.13224265f, -0.04445594f, -0.02128710f, -0.06151382f, -0.09544557f, 0.25960568f, 
    0.14139669f, 0.07615338f, 0.42828295f, -0.30626532f, -0.20150796f, 0.01081873f, -0.03124773f, -0.18752401f, 
    0.10162173f, 0.09823863f, -0.10302077f, -0.21625876f, 0.03864374f, -0.00879083f, 0.00280509f, -0.09970987f, 
    0.02878033f, 0.19121931f, -0.07106151f, 0.23178636f, -0.07303607f, -0.26888227f, 0.21476434f, 0.28870428f, 
    0.13815993f, 0.15238969f, -0.06381986f, 0.19771798f, 0.08660040f, -0.26596573f, 0.12859167f, 0.31417841f, 
    0.11197219f, -0.21446083f, 0.27672747f, 0.06645786f, -0.03868617f, -0.29181963f, 0.03162708f, -0.14048056f, 
    -0.53428829f, -0.29672885f, 0.07773662f, -0.19106194f, 0.35753471f, 0.01049324f, 0.13095993f, -0.01293572f, 
    0.10083468f, -0.26749295f, 0.04454494f, -0.04872744f, -0.10929042f, 0.05564309f, -0.06633707f, -0.03451036f, 
    -0.32049891f, 0.47052890f, -0.21125233f, 0.16826726f, 0.26293546f, 0.13540402f, 0.16473761f, 0.23365827f, 
    0.03741295f, 0.10651705f, -0.01612327f, 0.05704079f, 0.18112378f, 0.11535570f, 0.12456293f, 0.12427911f, 
    0.27094766f, -0.10958887f, 0.08479773f, -0.03480038f, -0.42099297f, 0.11105688f, -0.01916998f, 0.04280528f, 
    0.13694203f, -0.22502010f, -0.07197282f, 0.11712508f, -0.06031987f, -0.15320565f, -0.09497771f, 0.02400355f, 
    0.19539416f, -0.05847654f, -0.08588871f, -0.08855429f, -0.00890691f, 0.13131122f, -0.46526560f, 0.03365393f, 
    0.28864786f, 0.19840345f, -0.07729171f, -0.05293097f, 0.26305982f, 0.37255728f, 0.16191782f, 0.19769442f, 
    0.21838543f, 0.12301268f, -0.00983203f, -0.07559209f, 0.01265578f, 0.14370632f, 0.11716246f, -0.03353559f, 
    -0.24421607f, 0.13169391f, 0.10662293f, -0.00801373f, 0.00069442f, -0.04020431f, 0.27216667f, 0.06940896f, 
    -0.17262098f, -0.41883925f, 0.09712628f, 0.14889367f, 0.10720427f, 0.09801317f, -0.14325804f, -0.03489387f, 
    -0.02197370f, -0.54500085f, -0.19217765f, 0.07547119f, 0.06262361f, 0.22166558f, -0.15517047f, -0.05616210f, 
    -0.28013748f, 0.25070161f, 0.06781711f, -0.03820679f, -0.12207755f, 0.11135522f, 0.15127042f, 0.00854279f, 
    -0.03525756f, 0.11818938f, 0.19921400f, 0.02712524f, -0.26512787f, -0.04932695f, -0.08958942f, 0.23915449f, 
    0.13680023f, 0.18763976f, 0.18919763f, -0.38302162f, -0.11746965f, -0.35441148f, -0.00509722f, 0.03927170f, 
    0.12921572f, 0.05170755f, 0.12015290f, 0.05805152f, 0.00673882f, 0.05821659f, 0.22457930f, 0.16145316f, 
    -0.08814603f, -0.07562400f, -0.02141120f, 0.18727900f, -0.00882394f, 0.17205119f, -0.01635154f, -0.23889044f, 
    0.11899383f, 0.21362942f, 0.20148355f, 0.26901764f, -0.24619266f, -0.25555763f, 0.03683895f, 0.31397253f, 
    -0.17778984f, -0.03262855f, -0.35707498f, 0.13420245f, 0.15938908f, 0.10517714f, 0.27665281f, -0.26489645f, 
    -0.17623585f, -0.03784667f, 0.06153112f, -0.10629442f, -0.05466222f, -0.10255608f, 0.09497123f, 0.15081742f, 
    0.33098331f, -0.18035248f, -0.16016842f, -0.16205512f, 0.15019327f, -0.04501428f, -0.08836629f, -0.06116205f, 
    -0.30776420f, 0.20545788f, -0.02065251f, -0.33794403f, -0.06055974f, -0.24492210f, 0.03718664f, -0.20591825f, 
    -0.19899206f, -0.02747780f, -0.20018342f, -0.18393077f, -0.18394342f, -0.02277874f, -0.08232838f, 0.12507306f, 
    0.09714729f, -0.04821268f, 0.10245566f, 0.03119257f, -0.04862355f, -0.07140281f, -0.04939036f, -0.05720296f, 
    -0.05165354f, 0.16366479f, 0.16471389f, 0.05376603f, -0.28583562f, 0.02097655f, 0.06147729f, -0.00252665f, 
    -0.17643633f, -0.11895977f, 0.05669795f, -0.08087996f, -0.11252447f, -0.04675162f, -0.08160129f, 0.22843641f, 
    0.10720643f, -0.16472666f, 0.05883215f, 0.08082955f, 0.07739218f, -0.03880310f, 0.33787054f, -0.29837859f, 
    0.10225784f, -0.06432679f, -0.07503068f, 0.17243671f, 0.01572722f, 0.20064539f, 0.05277411f, -0.10465933f, 
    0.04961754f, -0.35228637f, 0.33481535f, 0.01610547f, 0.05119953f, 0.07639576f, 0.06664972f, -0.05606290f, 
    -0.17407358f, -0.19582024f, 0.14949730f, 0.08233309f, -0.00778860f, 0.09193399f, -0.06460816f, 0.06573369f, 
    0.12340076f, 0.04957512f, -0.11349348f, -0.04280611f, 0.04458586f, -0.02154922f, -0.07715631f, -0.08337677f, 
    -0.18282738f, -0.19395323f, 0.37254080f, 0.54780233f, 0.14129961f, 0.15922494f, -0.23412913f, 0.09097128f, 
    0.03475411f, -0.08707843f, 0.21036366f, -0.17486149f, 0.20346630f, 0.06456003f, 0.16339301f, 0.06317759f, 
    0.06502036f, 0.02363028f, 0.24755968f, -0.10714880f, 0.04635470f, -0.58066797f, 0.00007145f, 0.10012505f, 
    -0.24693915f, 0.04380011f, -0.05535585f, -0.02915740f, 0.02474163f, -0.16965717f, 0.19460142f, 0.00577580f, 
    0.06193720f, 0.06321035f, 0.21367086f, 0.12046733f, -0.13000582f, -0.14515358f, -0.09506983f, 0.08547683f, 
    -0.58074671f, 0.14523166f, -0.13793261f, 0.44717085f, 0.03014768f, -0.27844259f, -0.40991309f, -0.04894785f, 
    0.03225086f, 0.24034043f, 0.00308831f, 0.06011078f, -0.00479905f, 0.13586257f, 0.04388860f, 0.11330202f, 
    0.27515370f, 0.09493561f, 0.15905100f, 0.02351288f, 0.07537533f, -0.13931954f, -0.01990007f, 0.00511041f, 
    -0.14055088f, 0.16977862f, 0.03568984f, -0.06337802f, -0.19290067f, 0.04398513f, -0.10244022f, -0.00119829f, 
    -0.05660645f, -0.09578074f, 0.05032623f, 0.25357983f, 0.38466913f, -0.16875771f, -0.34358081f, -0.21518125f, 
    -0.21586660f, -0.14858499f, -0.17660156f, 0.05054703f, 0.26816687f, 0.30679306f, 0.10977121f, 0.03638430f, 
    0.13577452f, 0.15477996f, 0.34297034f, 0.12903771f, 0.42389700f, -0.23374656f, 0.10986713f, -0.32678837f, 
    0.13003498f, -0.45119885f, -0.06890228f, -0.31597450f, -0.09572612f, 0.47144693f, 0.38789088f, -0.23868595f, 
    0.07093951f, -0.04873997f, -0.15891513f, 0.10929646f, -0.09895003f, -0.14778847f, -0.02607483f, 0.06480147f, 
    -0.03938162f, 0.03231250f, -0.16303429f, -0.18476227f, -0.07127415f, -0.02895732f, 0.09056894f, 0.35233527f, 
    0.12323355f, 0.27566186f, -0.13601717f, -0.15085480f, -0.32569525f, -0.01444228f, 0.19698200f, 0.01453099f, 
    -0.41145039f, 0.21175860f, -0.24437065f, -0.21792284f, 0.05591676f, -0.12967914f, -0.00503714f, 0.08382903f, 
    0.33177188f, 0.22747323f, 0.02920733f, 0.03102417f, -0.15050127f, 0.20791395f, 0.00054180f, 0.12923458f, 
    0.14905488f, -0.01778013f, -0.12414092f, -0.12250783f, 0.07967372f, -0.03797033f, -0.09649735f, -0.13799500f, 
    0.01066896f, -0.04379430f, -0.05073059f, 0.25212109f, -0.10770132f, -0.07170811f, 0.00187998f, 0.03911552f, 
    0.10146786f, -0.01533974f, 0.12002543f, 0.17111069f, -0.32031462f, -0.09232650f, -0.36494553f, 0.11142183f, 
    0.29014271f, 0.04391283f, 0.11857881f, -0.05134626f, -0.04822186f, -0.16427502f, 0.33742133f, -0.01975673f, 
    -0.01827824f, -0.07316269f, 0.21759698f, 0.10061219f, 0.00360748f, 0.20752466f, -0.02285574f, 0.16088885f, 
    -0.13700688f, 0.28225818f, 0.57453221f, 0.10968013f, 0.17051218f, 0.43618768f, -0.25534362f, 0.14464135f, 
    0.12620243f, -0.11108549f, -0.39847687f, -0.50912601f, -0.22474706f, 0.02719533f, -0.04142403f, -0.01010495f, 
    -0.13252839f, 0.33445579f, 0.01549887f, 0.14988683f, -0.00052379f, -0.15430772f, 0.07829561f, 0.18521619f, 
    0.02412890f, 0.15160885f, -0.90951025f, -0.72038019f, -0.06058310f, -0.12918581f, 0.18055594f, 0.12666075f, 
    -0.25400436f, -0.29667789f, 0.14379367f, 0.28827614f, 0.10401681f, 0.05835036f, -0.42595363f, -0.27804652f, 
    -0.01119807f, 0.03513390f, 0.01219015f, -0.14948075f, -0.39503157f, 0.00227725f, -0.24181247f, -0.27002975f, 
    -0.08844025f, 0.02602105f, 0.03739184f, 0.02233161f, 0.30109522f, -0.87893564f, -0.38564014f, 0.04129960f, 
    0.03582503f, 0.05447527f, 0.00289788f, -0.05272641f, 0.08354781f, -0.05856880f, -0.41180634f, -0.22027883f, 
    -0.13226596f, -0.14231640f, 0.05892643f, 0.13742824f, -0.04903674f, 0.09792174f, 0.13441223f, 0.15183543f, 
    0.28900421f, 0.06246825f, 0.09393315f, 0.18999781f, 0.04845284f, 0.00077000f, -0.07646745f, -0.15810740f, 
    -0.11203218f, -0.03941997f, 0.08323089f, 0.07178232f, -0.01288546f, 0.00362065f, 0.07754704f, -0.09985992f, 
    -0.02433502f, 0.08451094f, -0.04295655f, 0.06404498f, -0.00376119f, -0.04519894f, -0.10712737f, -0.18483630f, 
    -0.13790925f, -0.38248730f, -0.34035730f, -0.19425039f, 0.12394485f, 0.05707033f, 0.05592899f, -0.11829475f, 
    0.00185267f, 0.06238620f, -0.03305162f, 0.43980211f, 0.30303815f, 0.08276530f, 0.29632750f, -0.06313554f, 
    -0.02896155f, 0.19520117f, 0.05732948f, -0.56814277f, -0.65745807f, -0.32994688f, 0.18270548f, 0.04878482f, 
    0.05628766f, -0.01762243f, 0.09609652f, 0.00134097f, 0.44057608f, 0.23983750f, 0.37445948f, -0.10067160f, 
    0.02763774f, 0.14346652f, 0.04078657f, 0.12035794f, -0.00066432f, -0.32652819f, -0.50967544f, -0.51829278f, 
    0.04206308f, 0.09312697f, 0.12058379f, 0.11009179f, 0.24340647f, 0.05901910f, -0.15829423f, 0.05924363f, 
    0.05256515f, 0.02156551f, -0.15953995f, 0.21580601f, -0.22625118f, 0.19772232f, -0.03375265f, -0.04434872f, 
    -0.01162412f, 0.01252254f, 0.08859466f, -0.02955532f, 0.12930493f, -0.13067618f, -0.00966022f, 0.09787292f, 
    -0.00847377f, -0.29302871f, -0.15563144f, 0.13646264f, 0.09015342f, -0.06369708f, 0.02380240f, 0.00692004f, 
    -0.09735910f, 0.30309540f, 0.27883092f, 0.38776547f, -0.00881190f, -0.00886658f, 0.12645909f, 0.16756259f, 
    -0.17356220f, 0.05003190f, -0.08956473f, -0.20066646f, -0.03874999f, 0.13356513f, -0.10153585f, -0.00755838f, 
    -0.07310729f, -0.16997427f, -0.04228877f, -0.14557666f, -0.11660998f, 0.02782718f, -0.05182926f, 0.04354103f, 
    -0.12463085f, 0.01945168f, 0.08795932f, 0.20556067f, 0.42241204f, 0.51533324f, 0.27272350f, 0.01611451f, 
    -0.18584262f, 0.23667815f, -0.06659273f, 0.13495407f, -0.02682957f, 0.38140419f, 0.36894462f, 0.48396477f, 
    0.05165690f, 0.03200653f, 0.05843094f, 0.01740251f, 0.18571723f, 0.10250606f, -0.02838745f, -0.04151871f, 
    -0.00218712f, 0.28052005f, 0.16050802f, -0.40880570f, 0.26622868f, 0.05009588f, 0.06408304f, 0.11527213f, 
    0.00931118f, 0.12704009f, -0.02259447f, -0.20072463f, -0.02527285f, 0.01528315f, 0.03000914f, 0.13219245f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.39853755f, 0.23220915f, -0.26957178f, 0.14368941f, 0.23656374f, 0.43250528f, -0.05373936f, 0.23836403f, 
    0.00277237f, -0.10932684f, 0.09281251f, 0.02916840f, 0.24183713f, -0.21723621f, 0.38715735f, 0.11330351f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.15272923f, -0.02400229f, 0.39983150f, -0.27143878f, 0.14778218f, -0.46761632f, 0.17919292f, 0.06522314f, 
    -0.06093902f, -0.18058890f, 0.44126818f, 0.17074025f, 0.01949361f, 0.10098058f, 0.23512389f, 0.29497713f, 
    0.37558484f, 0.08611574f, 0.43543142f, 0.08090905f, 0.44526017f, -0.05325121f, -0.29130280f, 0.16507752f, 
    0.12994844f, -0.02132573f, -0.20818901f, -0.23036349f, -0.23408949f, -0.37167767f, -0.15436307f, 0.23008800f, 
    -0.18400931f, 0.15936267f, -0.11436814f, -0.10318556f, 0.06855225f, -0.24536407f, -0.01115997f, -0.18371859f, 
    -0.16379744f, -0.21650453f, 0.09457947f, -0.23362173f, -0.19937110f, 0.16462240f, -0.11472294f, 0.02495395f, 
    0.10327413f, 0.21064849f, -0.22047144f, 0.23183455f, 0.28522503f, 0.02030435f, -0.21244583f, 0.12064156f, 
    -0.43149486f, -0.15955265f, -0.61526310f, -0.05145555f, 0.31378680f, 0.28379416f, 0.39865676f, 0.16174668f, 
    -0.17012566f, 0.06554169f, -0.28415278f, 0.08979050f, -0.01646447f, -0.05549147f, 0.41341242f, 0.11534324f, 
    0.14079398f, 0.03456053f, 0.46857002f, 0.23002456f, 0.44213659f, 0.20537619f, -0.42354429f, -0.35378081f, 
    -0.47193268f, -0.08613756f, -0.38899326f, -0.06441304f, 0.67360497f, 0.44419816f, 0.04514730f, 0.21169063f, 
    -0.33624151f, -0.68503821f, 0.06940422f, 0.30478406f, 0.28130937f, -0.48429316f, -0.60030448f, 0.20306309f, 
    0.09247217f, 0.48646438f, -0.20335278f, 0.18191467f, -0.05000129f, -0.07440838f, 0.14701639f, -0.58960438f, 
    -0.27553990f, -0.68665594f, -0.54845685f, 0.47292456f, 0.47750914f, -0.35157329f, 0.35629359f, 0.05635570f, 
    0.08847678f, -0.18800284f, 0.22385538f, -0.02541088f, -0.24275383f, -0.24219613f, -0.10716125f, -0.24277505f, 
    0.02382951f, -0.12137678f, -0.21730688f, -0.23242657f, -0.15862402f, 0.10738239f, 0.18994686f, -0.18057346f, 
    -0.05248709f, 0.42084515f, 0.32135761f, -0.29574275f, 0.10021184f, 0.18357785f, 0.41576174f, -0.73673713f, 
    -0.17373611f, 0.27326852f, -0.31133074f, -0.01775248f, 0.04617574f, -0.43965110f, -0.18354869f, 0.09453693f, 
    -0.77324176f, -0.19143943f, -0.54181653f, 0.31850776f, -0.78117579f, 0.13546599f, -0.06953177f, 0.15868622f, 
    0.25958577f, -0.23856293f, 0.27502254f, 0.15045735f, 0.43549076f, -0.43517634f, -0.59202939f, 0.21758422f, 
    0.14957595f, 0.29487583f, 0.35969841f, -0.14923161f, -0.18541786f, 0.22900173f, -0.00121374f, -0.05422068f, 
    -0.23693283f, -0.40067342f, 0.37357160f, -0.19110546f, 0.44216859f, -0.37611121f, 0.25243685f, 0.16545574f, 
    0.64754552f, 0.12596604f, -0.34351474f, 0.04598770f, -0.38720223f, -0.26063874f, -0.19048400f, 0.02725847f, 
    -0.09247621f, 0.03210953f, 0.44078335f, -0.03601718f, 0.35304788f, -0.10693739f, 0.26174769f, 0.36927250f, 
    -0.35440823f, -0.24234436f, 0.20526209f, 0.03617287f, 0.41297850f, -0.08208218f, 0.14714086f, 0.64795625f, 
    0.30200776f, 0.26839533f, 0.52641857f, -0.28602070f, -0.16500278f, -0.16083492f, 0.25340939f, 0.26860881f, 
    0.32200488f, 0.15123577f, 0.04797696f, 0.20582835f, -0.46337420f, 0.04652220f, 0.16750078f, 0.38569507f, 
    0.03021427f, -0.23755333f, -0.23446614f, 0.09468981f, -0.38490698f, -0.27442423f, 0.01992116f, -0.01009355f, 
    0.60619992f, 0.14918980f, 0.33986658f, -0.24048337f, 0.38627756f, -0.08637047f, 0.14628808f, -0.20671590f, 
    0.09151199f, 0.16700511f, 0.34205922f, -0.22157322f, -0.25792512f, -0.16455680f, -0.21809413f, -0.14281264f, 
    0.55318224f, -0.43019214f, -0.35979962f, -0.31826088f, 0.32267079f, 0.27653733f, 0.37755665f, 0.33713633f, 
    0.36240652f, -0.36692271f, -0.12415791f, 0.12220154f, -0.16583186f, -0.42717335f, -0.56435561f, -0.03016388f, 
    0.18190821f, 0.26311553f, -0.22053224f, 0.06234252f, -0.16309163f, 0.01630181f, -0.04767948f, 0.21098711f, 
    0.04664951f, 0.37925065f, 0.19603993f, -0.16623783f, 0.17190604f, -0.38912818f, 0.45531991f, 0.22778298f, 
    -0.13147305f, 0.11291848f, -0.09989758f, -0.11801367f, -0.19912511f, -0.23603196f, 0.11415709f, -0.08955941f, 
    0.14487568f, 0.05298483f, -0.10345605f, -0.23433155f, 0.17027186f, -0.17976387f, -0.06496321f, -0.06817771f, 
    -0.47073385f, 0.33978868f, 0.14755310f, -0.03598213f, -0.16225792f, -0.30041221f, -0.09557589f, -0.34323019f, 
    -0.14090160f, -0.29896379f, -0.41689569f, 0.39020270f, 0.06580428f, -0.31086522f, -0.74882799f, 0.44897354f, 
    0.07159183f, -0.26729059f, 0.00385950f, -0.21732765f, -0.11208953f, 0.19246460f, -0.15311846f, 0.15896858f, 
    -0.04901724f, 0.17672645f, -0.25899577f, 0.06828257f, -0.04486704f, -0.20768897f, 0.04918828f, -0.27096117f, 
    -0.06152361f, -0.42427748f, 0.01223705f, 0.09387220f, 0.29496184f, -0.36240160f, -0.00036896f, 0.23348631f, 
    0.42974627f, -0.02502473f, 0.05065249f, 0.06570288f, -0.02709131f, 0.13507725f, -0.15746588f, 0.29965895f, 
    -0.05248277f, -0.24741349f, -0.17338054f, -0.12409114f, 0.37699255f, -0.34259254f, -0.01471209f, -0.26024124f, 
    0.03089513f, 0.27181652f, -0.26630822f, 0.25118008f, -0.23716462f, 0.09437590f, 0.53767884f, 0.03520172f, 
    -0.01816209f, 0.11839689f, 0.17055145f, -0.22002649f, 0.21526831f, 0.13037372f, 0.11755219f, -0.12382248f, 
    -0.23235254f, -0.12497687f, 0.03544678f, -0.14308801f, -0.02736845f, -0.15008481f, -0.10195286f, -0.15609489f, 
    -0.26081887f, -0.03855867f, -0.00808923f, 0.04489880f, -0.11402476f, -0.20101310f, 0.00429522f, -0.04164443f, 
    -0.14480746f, -0.00316727f, -0.01923499f, 0.07501388f, -0.30345607f, 0.03174483f, -0.25817531f, -0.02956414f, 
    -0.11001056f, 0.00757537f, -0.22039399f, -0.02112801f, -0.25734317f, -0.23768070f, -0.12201953f, -0.04949849f, 
    0.02651556f, 0.08461890f, -0.24918847f, 0.11354523f, 0.10763389f, -0.15233521f, -0.02831003f, -0.06290442f, 
    0.15443604f, -0.02744948f, 0.02036652f, 0.52967596f, 0.49368069f, 0.19893679f, 0.15298845f, -0.56014109f, 
    0.13359371f, -0.21795818f, 0.05475838f, -0.32500118f, 0.23993677f, -0.60813856f, -0.54904568f, 0.11835955f, 
    -0.01844195f, 0.13448265f, -0.29655126f, 0.16466171f, 0.03132857f, 0.32745588f, -0.07319960f, 0.47179517f, 
    0.35896865f, -0.15347983f, -0.03906887f, 0.33057746f, 0.28793845f, -0.46315169f, 0.05039889f, -0.33685350f, 
    -0.19302438f, -0.07525148f, -0.31167179f, 0.08889054f, -0.16837874f, 0.26403219f, 0.40686986f, 0.40607670f, 
    0.24659739f, 0.36591291f, -0.00665942f, 0.03693322f, 0.21512900f, -0.10875147f, -0.44904968f, 0.07264929f, 
    -0.29299214f, 0.20559324f, -0.00010266f, -0.09390204f, -0.44407037f, -0.21874088f, 0.27754274f, -0.60464430f, 
    -0.15146926f, -0.06376836f, -0.77203834f, 0.20207347f, 0.18525003f, -0.07904617f, 0.21376877f, 0.51486176f, 
    0.45009065f, 0.18664032f, -0.49308100f, -0.17572026f, -0.59584254f, 0.39730239f, -0.18479086f, -0.11380430f, 
    0.13366164f, -0.15933217f, 0.59352493f, 0.06070131f, 0.17190005f, -0.32716665f, -0.00582318f, 0.10614704f, 
    -0.11293189f, -0.14394158f, -0.23960151f, 0.36088547f, 0.42145517f, 0.22286887f, 0.12083472f, -0.15125917f, 
    -0.34056586f, -0.32075539f, 0.59109735f, -0.42211297f, 0.07058191f, -0.08947071f, 0.55906671f, 0.42095447f, 
    -0.38640830f, -0.18160555f, 0.37648058f, -0.41270185f, 1.00571251f, 0.05617838f, 0.56408066f, 0.09706552f, 
    -0.21807094f, 0.13133895f, -0.16076411f, -0.00552040f, -0.37513664f, -0.22894512f, 0.48103952f, 0.37090850f, 
    -0.26251745f, 0.04032771f, -0.30134958f, -0.07230373f, 0.26864907f, 0.05187351f, -0.09351706f, 0.25540045f, 
    0.22057088f, 0.10548531f, 0.74087113f, 0.39436710f, 0.29556662f, 0.10801838f, -0.07377848f, -0.26442692f, 
    0.09858775f, 0.12027845f, 0.02151625f, -0.15491490f, 0.23170653f, -0.04558562f, -0.22399993f, -0.17579836f, 
    -0.21718450f, 0.08121073f, -0.02964705f, -0.22447461f, -0.07183654f, -0.22201543f, -0.07834177f, -0.02822222f, 
    0.01767436f, 0.29272673f, -0.08488127f, -0.13955361f, 0.59146529f, 0.03427925f, 0.08553720f, 0.59681088f, 
    0.12849537f, -0.34716752f, -0.21324405f, 0.16170539f, -0.13961406f, -1.00247526f, 0.42367697f, -0.42691857f, 
    -0.14580666f, -0.41825557f, -0.09837135f, 0.17184669f, -0.88791978f, 0.12250598f, 0.13109124f, -0.02476859f, 
    0.02415173f, -0.14656551f, -0.31901994f, -0.01387713f, 0.14228739f, 0.22839402f, -0.63462472f, 0.36248296f, 
    0.10320161f, -0.00107196f, -0.15475497f, -0.47783607f, 0.15145841f, -0.03840940f, 0.00501279f, 0.06350107f, 
    0.03096137f, -0.20360117f, 0.50394952f, 0.50010598f, 0.21273573f, -0.01633005f, 0.06340121f, 0.00794839f, 
    0.07856628f, 0.02562933f, 0.01846341f, -0.07717814f, -0.27035141f, -0.14270420f, -0.11270133f, -0.02791298f, 
    0.08098245f, -0.23348603f, 0.03524728f, -0.10915504f, -0.21696505f, 0.12651743f, -0.30419412f, -0.20870437f, 
    0.24282998f, -0.13289176f, -0.33808321f, -0.00270479f, 0.16391103f, -0.34437272f, -0.54829192f, -0.27612180f, 
    0.08923525f, 0.24573234f, 0.29893866f, -0.00691085f, -0.15342051f, 0.12036777f, 0.01235867f, -0.60137838f, 
    0.54778814f, 0.21573798f, -0.43152788f, 0.13338593f, -0.65053415f, 0.50214142f, 0.18119392f, -0.78998834f, 
    -0.09874129f, -0.13683243f, -0.29117331f, -0.05141337f, 0.19064076f, -0.16663156f, -0.22999424f, 0.09289281f, 
    0.57355911f, 0.26082113f, -0.21276033f, -0.20650510f, -0.00382227f, 0.07112329f, -0.16094899f, -0.29178414f, 
    0.38926128f, 0.19561143f, 0.01963496f, 0.17925501f, -0.28884530f, -0.17962442f, 0.10004157f, -0.37355170f, 
    0.00491782f, 0.09797599f, -0.42310563f, 0.30133903f, 0.00067074f, 0.22566167f, -0.02639583f, -0.13290490f, 
    0.24945536f, -0.12511095f, 0.26973596f, -0.06221968f, 0.28219667f, -0.15295075f, 0.14769679f, -0.05793225f, 
    0.07016206f, -0.23121005f, 0.05113581f, -0.28345355f, -0.04483673f, 0.27395278f, 0.45689219f, 0.04438058f, 
    0.23422877f, 0.10689399f, 0.39301646f, -0.01660330f, 0.23188983f, 0.14614061f, -0.64218146f, 0.03777712f, 
    -0.20872509f, 0.31079483f, 0.02594465f, -0.07308067f, 0.10454286f, -0.40965626f, -0.12643434f, -0.06307823f, 
    -0.09956865f, 0.12458759f, 0.39274752f, 0.15342474f, 0.35241830f, -0.07061957f, 0.44667211f, 0.18806513f, 
    0.61104959f, -0.65283960f, -0.30623084f, -0.48515496f, -0.38592792f, -0.23765118f, 0.23845081f, 0.22070599f, 
    0.33394882f, -0.22440970f, 0.34485516f, 0.33570418f, 0.32357991f, 0.11363099f, -0.69862539f, 0.16291878f, 
    -0.71270859f, -0.06450200f, 0.34141979f, 0.08027954f, -0.14515609f, -0.30307776f, -0.01815401f, 0.25629333f, 
    0.16951378f, 0.02806919f, -0.25354758f, -0.22780228f, -0.14611660f, 0.13176267f, -0.23218329f, 0.44918063f, 
    -0.05279725f, 0.15405917f, 0.16561629f, -0.25497290f, 0.08122140f, -0.14341512f, 0.03867711f, -0.01072072f, 
    -0.07288738f, -0.23315413f, -0.06621697f, 0.08554740f, 0.10331641f, -0.01029368f, -0.12237164f, -0.21319391f, 
    0.12710211f, 0.10301694f, 0.05875684f, 0.11636546f, 0.24627392f, 0.23268937f, 0.22684370f, -0.13476878f, 
    -0.40388203f, -0.05673179f, -0.44176418f, -0.26548380f, -0.27970213f, 0.19420008f, 0.00493394f, 0.42078382f, 
    0.32418659f, 0.23028664f, -0.29991165f, 0.21403490f, -0.00613142f, 0.05131420f, -0.33379969f, 0.06627311f, 
    0.11084411f, -0.26294357f, -0.90506023f, 0.22166047f, 0.15306412f, -0.45534176f, 0.13321590f, 0.24267170f, 
    0.50052810f, -0.02915299f, 0.46982786f, -0.68333054f, -0.41919410f, -0.09389204f, 0.40065238f, -0.44942167f, 
    -0.04400988f, 0.31529233f, 0.42129418f, 0.17847446f, -0.34356129f, -0.21484071f, -0.07598505f, 0.15870489f, 
    0.33537433f, 0.24807097f, 0.41437361f, -0.32763526f, -0.66884279f, 0.58746058f, 0.32563859f, -0.17366351f, 
    -0.12098543f, -0.13641386f, -0.94544184f, 0.16906020f, -0.32795420f, -0.10866676f, 0.22033551f, 0.00922040f, 
    -0.06124935f, 0.41168606f, 0.23763014f, 0.06352953f, -0.10202532f, -0.07552421f, 0.12913391f, -0.61928511f, 
    -0.36193985f, 0.20237504f, -0.11915927f, -0.28642121f, 0.11556071f, 0.15730165f, 0.31568015f, 0.48154160f, 
    0.34873813f, 0.12314937f, -0.17993996f, 0.04424598f, -0.32904983f, -0.25325066f, -0.20853040f, -0.39772257f, 
    -0.23978744f, -0.38856873f, -0.13705258f, 0.23953988f, 0.24758705f, -0.18378542f, 0.72527397f, 0.46104062f, 
    -0.26604322f, -0.24722503f, 0.10364737f, -0.00544558f, 0.28751224f, 0.35356316f, 0.21729924f, 0.51145065f, 
    -0.01251173f, -0.06175732f, 0.12967536f, 0.26144052f, 0.04817414f, 0.21969262f, 0.11370102f, 0.04483785f, 
    -0.20370744f, 0.07387821f, -0.34958166f, -0.06945295f, 0.40389937f, 0.39325148f, 0.32150382f, -0.39759728f, 
    -0.30491430f, -0.30953494f, -0.25383323f, -0.00443298f, 0.50233585f, 0.19879897f, -0.20271067f, 0.36315688f, 
    0.02959752f, -0.05821803f, 0.40768474f, -0.32873324f, 0.15171376f, -0.26070592f, 0.28396294f, -0.83626115f, 
    -0.26171106f, -0.53184795f, -0.29648808f, 0.44444400f, -0.07361612f, 0.39675966f, 0.14943908f, 0.11616079f, 
    0.09117816f, 0.21858238f, 0.04766849f, 0.27527300f, -0.07292252f, 0.19003552f, -0.37366408f, 0.17057414f, 
    0.18634477f, -0.31742716f, -0.32664758f, 0.10910336f, 0.03726450f, -0.24531794f, -0.11351901f, -0.13836390f, 
    -0.22378325f, -0.24235460f, -0.13498729f, 0.02779996f, -0.02173659f, -0.14526632f, 0.04228681f, -0.12356779f, 
    -0.04875025f, -0.10052606f, -0.12786618f, -0.16983578f, 0.20814213f, -0.03867319f, 0.01745787f, -0.10695750f, 
    -0.36076078f, 0.01534171f, -0.12600532f, -0.01311779f, 0.41769257f, -0.29880619f, 0.40465263f, -0.62079746f, 
    0.05751237f, 0.36733490f, 0.08484737f, -0.13642301f, -0.05715592f, -0.05678493f, -0.10729954f, 0.38221678f, 
    0.02049961f, -0.03340756f, -0.06095420f, 0.08780833f, 0.32052901f, -0.06044831f, -0.51559758f, -0.09224170f, 
    -0.05327384f, 0.24662359f, 0.15318488f, -0.34675482f, -0.25461766f, 0.11536288f, 0.01384643f, -0.55272222f, 
    -0.16795222f, 0.02019302f, -0.33584213f, -0.05329489f, -0.32126477f, 0.45496723f, -0.05227004f, -0.17739551f, 
    -0.23580353f, -0.70680898f, 0.51650375f, 0.30112118f, 0.45397174f, 0.07017311f, -0.09060263f, 0.13524409f, 
    -0.41670370f, -0.18781769f, -0.02210689f, 0.27183801f, 0.34126627f, -0.25605008f, -0.03826777f, -0.26025039f, 
    -0.30744782f, -0.36221102f, -0.12610565f, 0.42396730f, 0.40723622f, 0.26795277f, -0.50660950f, 0.25657293f, 
    -0.18890311f, -0.14038971f, 0.27712038f, -0.13549824f, 0.36757392f, -0.22534479f, 0.11078317f, -0.35861287f, 
    0.07895379f, -0.30481696f, 0.71300411f, 0.39386755f, 0.30594066f, 0.39370000f, 0.11177514f, -0.09689447f, 
    0.17251809f, -0.34577164f, -0.40433753f, -0.37500158f, 0.54737455f, -0.01476239f, 0.34516671f, 1.08182430f, 
    0.41557679f, -0.24388006f, 0.06530647f, 0.41285282f, -0.01455711f, -0.02461276f, -0.54123646f, -0.01301757f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.79950136f, 0.12397547f, -0.16063057f, -0.01003551f, 0.29135206f, 0.35166246f, 0.21464057f, 0.02295647f, 
    0.21796136f, -0.03763688f, -0.34507042f, 0.11891609f, -0.18129329f, 0.22679986f, -0.15344970f, 0.35317364f, 
    0.17145881f, -0.13039629f, -0.09474618f, -0.23997727f, 0.13615212f, 0.03213574f, -0.04795634f, -0.12046214f, 
    -0.26688737f, 0.13845547f, 0.61189055f, 0.49023247f, 0.10187889f, -0.09519652f, 0.20616488f, 0.32098296f, 
    0.19873419f, -0.15270279f, 0.42320815f, 0.17945422f, -0.03063544f, -0.25561553f, 0.13484833f, 0.39783210f, 
    -0.06505928f, 0.50503671f, 0.09652408f, -0.19770661f, 0.09719235f, -0.10155710f, -0.05949470f, 0.09350194f, 
    0.43750450f, -0.26144761f, 0.19104661f, -0.00274494f, 0.16221029f, 0.30919713f, 0.45571870f, -0.32289332f, 
    0.48557243f, -0.19736969f, -0.14856449f, 0.34481835f, 0.14501277f, 0.05174582f, -0.11784981f, 0.23079872f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.40409148f, 0.23570684f, -0.00644352f, 0.02461802f, -0.24446096f, -0.16295329f, 0.00925703f, 0.09727196f, 
    0.10996979f, -0.21553878f, 0.26700574f, 0.07039464f, 0.17387779f, -0.23251516f, -0.22918528f, -0.29654375f, 
    -0.17172509f, -0.08122745f, 0.39238146f, -0.02584284f, 0.18273923f, -0.31676796f, 0.01259266f, -0.01656792f, 
    -0.03864868f, -0.17713943f, -0.69847965f, -0.25065443f, 0.14466986f, -0.41987911f, -0.00631654f, 0.14612401f, 
    -0.10535886f, -0.13996382f, -0.24394529f, 0.00453731f, -0.07253580f, 0.01266530f, -0.62875324f, -0.21162991f, 
    -0.50719619f, -0.44842607f, -0.17366260f, 0.29470745f, 0.19971839f, 0.36222038f, 0.11948314f, 0.04656699f, 
    -0.04867445f, 0.35125870f, -0.34162802f, 0.21239513f, 0.40471607f, -0.18288620f, 0.06916863f, 0.75145477f, 
    -0.15375559f, -0.10693909f, 0.30411714f, -0.14557251f, -0.14452526f, 0.21305156f, 0.09615476f, -0.04996617f, 
    -0.11278906f, 0.02229851f, -0.04304378f, 0.24449058f, 0.00597781f, 0.36172563f, 0.76020896f, -0.00587399f, 
    0.36972389f, 0.43541619f, -0.20877327f, 0.08033975f, -0.17048351f, -0.02605763f, 0.19288780f, -0.54269224f, 
    0.02169121f, 0.00723975f, 0.40449986f, -0.15171361f, -0.10879529f, 0.14880742f, -0.04070766f, -0.08998975f, 
    0.07755942f, 0.01412635f, -0.04782734f, -0.12971286f, 0.26909119f, -0.41024777f, 0.10475510f, 0.13526046f, 
    -0.02383967f, -0.01402524f, 0.17996550f, 0.08307186f, -0.20464730f, -0.02710875f, 0.03269720f, 0.00321654f, 
    0.16641335f, 0.08965441f, -0.45175219f, 0.16142944f, -0.94151670f, 0.39674228f, -0.01357220f, 0.08368994f, 
    0.20485857f, -0.54760671f, -0.13597068f, 0.13382633f, 0.39439288f, -0.18646480f, 0.19721355f, -0.96305686f, 
    0.09985120f, -0.04010245f, 0.21003006f, -0.00418777f, -0.02241691f, 0.25413561f, -0.15777855f, -0.36731252f, 
    -0.20146361f, 0.18830696f, 0.08115922f, 0.01048349f, -0.01319255f, 0.67451721f, -0.03693442f, 0.00371284f, 
    -0.00988188f, -0.32748112f, -0.59908032f, -0.64108735f, 0.23189712f, -0.23855112f, -0.12068918f, 0.57691777f, 
    -0.28960952f, -0.08348779f, -1.39002228f, -0.11334948f, 0.11036067f, 0.31550881f, -0.11768076f, 0.00205162f, 
    0.11814424f, 0.08595332f, 0.04385348f, 0.01643901f, -0.74173993f, -0.24411312f, 0.16259512f, 0.38193792f, 
    0.04816271f, -0.02653540f, 0.20057826f, -1.43143177f, 0.00964487f, 0.10832489f, 0.00541487f, -0.27805898f, 
    -0.73906207f, 0.03090778f, 0.03382108f, -0.21233414f, -0.01563447f, -0.01508181f, 0.06060608f, 0.15024069f, 
    -0.00611869f, -0.89869785f, 0.04398039f, -0.12743166f, -0.59820634f, 0.19075429f, 0.24869908f, -0.99321151f, 
    0.02233508f, 0.04888177f, -0.79163790f, 0.36351636f, 0.12411091f, -1.08197987f, 0.07106543f, 0.42625120f, 
    0.04642663f, -0.77936548f, 0.09314597f, 0.40770677f, 0.21319440f, 0.11273107f, -0.00992106f, 0.09040476f, 
    0.17184302f, -0.12970775f, -0.36717197f, -0.64740241f, -0.47339886f, -0.02095068f, -0.14807093f, 0.42549831f, 
    -0.63258922f, -0.05139766f, -0.03924198f, -0.04337526f, -0.01593200f, -0.26493132f, -0.09474162f, -0.02135800f, 
    -0.11358362f, -0.74970865f, -0.12368401f, -0.01243967f, 0.09529915f, -0.23920403f, -0.53218472f, 0.08483379f, 
    0.07964059f, 0.02218685f, -0.35171136f, 0.16128008f, 0.10569035f, 0.05996293f, -0.42400023f, 0.12013724f, 
    -0.24116237f, -0.39555609f, 0.20928489f, -0.31031835f, 0.27622992f, -0.23643194f, -0.03377924f, -0.01532105f, 
    -0.14159121f, 0.30166522f, 0.30201808f, -0.23405597f, -0.20232144f, 0.17675929f, 0.08960299f, 0.56000394f, 
    -0.40247309f, 0.08339684f, -0.21264072f, -0.27751562f, 0.04640453f, 0.19706248f, 0.35030374f, 0.37459955f, 
    0.18429938f, 0.27954841f, 0.09069291f, 0.04560906f, -0.04264162f, 0.04305760f, -1.21042931f, 0.09385017f, 
    -0.57805920f, 0.17412677f, -0.58543116f, -0.00291326f, 0.24644426f, 0.06832818f, 0.29825261f, 0.30557549f, 
    -0.10477968f, -0.04150672f, -0.25178197f, 0.04342276f, 0.29747277f, -0.48168647f, -0.03643494f, -0.04433328f, 
    0.08374003f, -0.00092154f, -0.14296170f, 0.01961559f, -0.03715230f, -0.35231969f, 0.12670778f, 0.20054428f, 
    -0.15401468f, -0.12432890f, -0.75110006f, 0.36681467f, -0.32509461f, 0.04766892f, -0.12919328f, -0.88023275f, 
    -0.06564831f, -0.15187152f, 0.05985311f, -0.17651176f, 0.27598009f, 0.15599054f, 0.05705845f, -0.04597550f, 
    -0.02203111f, -0.13000600f, -0.17948110f, -0.27139422f, -0.27391052f, 0.10120832f, -0.15280929f, -1.10336804f, 
    -0.16391654f, 0.03203472f, 0.06654927f, -0.15396722f, -0.31291020f, -0.02329966f, -0.15851034f, 0.23063365f, 
    -0.06242951f, -0.09110913f, -0.04176984f, -0.09442574f, 0.20951954f, 0.36645553f, 0.11992963f, 0.04683116f, 
    -0.15636900f, 0.18494458f, 0.29120204f, 0.08281465f, -0.14073434f, -0.11107747f, 0.05317003f, -0.09504039f, 
    -0.21900608f, 0.01395928f, -0.26441300f, -0.06018940f, 0.00358449f, 0.04483587f, 0.01803080f, -0.15551232f, 
    -0.07295034f, 0.38663891f, 0.01628678f, -0.02786878f, -0.14087473f, 0.12904963f, 0.18730405f, -0.31317872f, 
    0.17240761f, -0.01441139f, -1.22389269f, 0.11232799f, -0.01133455f, 0.04987550f, -1.36728430f, 0.15088093f, 
    0.21780069f, 0.21113522f, 0.03714113f, -0.01602924f, -0.12040247f, -0.06526916f, -0.00803482f, -0.08505803f, 
    -0.11017950f, -0.36117211f, -0.23935571f, -0.05126210f, 0.08101977f, -0.00423647f, 0.26765072f, -0.42164278f, 
    0.05873555f, -0.07491009f, -0.03474738f, -0.52994871f, 0.38304907f, 0.20676936f, 0.25795653f, -0.05505017f, 
    -0.22749408f, 0.35394007f, 0.09914885f, -0.26940536f, -0.02565744f, -0.75497335f, 0.11516457f, 0.03859161f, 
    -0.23950513f, -0.88946486f, 0.53902537f, -0.36871624f, 0.20633882f, 0.19107373f, -0.05042388f, 0.08189601f, 
    0.04388408f, -0.11138533f, -0.39693055f, 0.01517385f, -0.18011999f, -0.97759080f, 0.06773157f, 0.03421684f, 
    -0.08223534f, 0.20436636f, 0.31888375f, 0.00092303f, -0.23014115f, 0.03278990f, -0.23735479f, -0.10444061f, 
    0.18722023f, -0.10895813f, 0.95613456f, -0.45187441f, -0.08386366f, 0.07802663f, 0.40922213f, -0.27817494f, 
    0.21936208f, 0.13283136f, -0.11007957f, -0.02243772f, -1.14666855f, -0.06687711f, -0.07082499f, -0.36716956f, 
    0.04371735f, -0.76017880f, -0.01524712f, -0.32572469f, -0.59859097f, 0.01406921f, -1.95560074f, -0.57119882f, 
    0.27746588f, -0.11608426f, -0.44915769f, 0.21576566f, -0.64959401f, -0.47501141f, 0.00592704f, 0.18455023f, 
    0.30636504f, -0.42624044f, -0.11693699f, -0.01390378f, 0.13070844f, -0.39847252f, -0.66358024f, 0.07962342f, 
    -0.25657922f, -0.82280123f, 0.01522146f, 0.17731787f, 0.07399771f, -0.10006602f, 0.01920884f, -0.67317647f, 
    0.08637547f, 0.06450821f, -0.51796728f, -0.03712606f, -0.31560081f, 0.08373053f, 0.02188787f, 0.07479268f, 
    0.00147541f, 0.45111579f, -0.20248994f, -0.13734679f, -0.95973158f, 0.14338136f, 0.35652223f, 0.37003991f, 
    0.19703260f, -0.00626082f, -0.34739122f, -0.55538863f, 0.38459200f, -0.03936930f, -0.14607994f, -0.52698964f, 
    -0.08435246f, 0.06063195f, 0.11705271f, 0.28707218f, 0.06317142f, -0.67839855f, -0.06409189f, -0.11747827f, 
    -1.43879998f, 0.61571276f, -0.21654138f, 0.10430656f, -0.00615365f, 0.09220047f, -0.32985154f, 0.25809222f, 
    -0.41871074f, 0.07427353f, -0.11551660f, -0.13400120f, -0.12681888f, -0.76685381f, 0.34717798f, -0.30022126f, 
    -0.22600551f, -0.01382750f, -0.10412595f, 0.16662525f, -0.30882445f, -0.78349805f, 0.50216025f, 0.09120817f, 
    -0.22982129f, -0.91805285f, 0.31847572f, 0.28332365f, -0.29390219f, 0.19918194f, -0.45574176f, -1.24068689f, 
    0.09944671f, -0.10014222f, -0.73100621f, -0.10311612f, -0.18016244f, 0.16730526f, -0.03689100f, -0.02140927f, 
    -0.07919910f, -0.23124823f, 0.06716622f, -0.10906985f, 0.36532173f, 0.27050984f, 0.07957570f, -0.73201334f, 
    -0.34782466f, 0.09396958f, -0.36141449f, -0.11967579f, -0.07263754f, -0.10826077f, -0.27109787f, 0.40214965f, 
    -0.15378556f, 0.07315361f, -0.38367015f, -0.16541737f, -0.42638233f, 0.16766015f, -0.00284379f, 0.21219552f, 
    0.39916724f, -0.25719422f, 0.34862250f, 0.19189216f, 0.84500897f, 0.03821139f, 0.11784025f, 0.17366278f, 
    0.17706995f, -0.04093729f, -1.23557520f, -0.00498397f, 0.34997863f, -0.47494909f, -0.54382104f, -0.69766861f, 
    -0.67097998f, -0.53454161f, -0.00279937f, -0.04175895f, 0.38531497f, -0.29527378f, -0.69015706f, -0.12430117f, 
    -0.94112653f, 0.78423941f, -0.15551277f, 0.16521659f, 0.09218855f, -0.01572531f, -0.34032160f, -0.11449549f, 
    0.15488206f, -0.03693478f, -0.50616205f, 0.02984068f, 0.05824821f, 0.43418196f, -0.07989050f, -0.15085030f, 
    0.05954113f, -0.76363659f, 0.29826596f, 0.32154471f, -0.79673535f, 0.03878593f, -0.24575099f, -1.03440535f, 
    0.33049119f, 0.08064264f, -0.27770901f, -0.15027766f, 0.21146142f, -0.08141089f, -0.57904315f, -0.19273272f, 
    -0.11088830f, 0.14402439f, 0.24413359f, 0.00925698f, 0.73212141f, -0.14049016f, -0.09914321f, -0.57075197f, 
    -0.11053985f, -0.26116380f, -0.26267615f, -0.38943902f, -0.36490256f, 0.08369663f, -0.55331999f, -1.44498193f, 
    -0.01234829f, 0.00286452f, -1.10055530f, -0.78829008f, 0.32466790f, -1.16072679f, -0.18998073f, 0.38296667f, 
    -0.68048984f, -0.37771341f, -0.13603736f, -0.11508489f, -0.02012560f, -0.35950649f, -0.58856875f, -0.00191997f, 
    0.57740712f, -0.49497697f, 0.09501370f, -0.38239416f, 0.31297672f, -0.11500222f, -0.49346274f, -0.62619537f, 
    0.23062016f, 0.07916930f, -1.04634583f, -0.11057878f, -0.49757564f, -1.18957889f, 0.01179850f, -0.15443501f, 
    -0.01184302f, 0.11335312f, -0.22773865f, 0.22816873f, 0.14853261f, -0.08157756f, 0.43833730f, 0.61535650f, 
    -0.23177308f, -0.07324758f, -0.36947516f, -0.20830402f, -0.55075365f, 0.07712048f, -0.30296242f, 0.16269293f, 
    -0.82657743f, -0.03789826f, 0.16285937f, -0.16144776f, -0.99445403f, 0.10034858f, -0.03375417f, 0.38026476f, 
    -0.18052876f, 0.15698832f, 0.29758957f, 0.42937243f, -0.63462168f, 0.12844498f, 0.21388364f, -0.63190275f, 
    -0.46332821f, -0.06007232f, 0.22425725f, -0.25128430f, -0.00771652f, -0.79618806f, -0.68227988f, -0.51951838f, 
    -0.30823362f, 0.51394147f, 0.01959086f, -0.33900204f, -0.10297455f, -0.81287110f, -0.23674342f, 0.04357143f, 
    0.53818697f, -0.33074707f, -0.32706875f, 0.12854816f, -0.32237926f, 0.09193552f, 0.41933623f, 0.55063695f, 
    0.04080608f, -0.01785770f, -1.32863319f, 0.09139910f, -0.63935077f, -0.27119845f, -0.09100234f, -0.11196819f, 
    -0.03957943f, 0.82668489f, -0.05069244f, 0.02688648f, -0.26045167f, 0.44191581f, -0.43451247f, -1.18511617f, 
    -0.24676533f, -0.00326124f, -0.14969285f, 0.08971895f, -0.13374372f, -0.14437346f, -0.39533693f, 0.47785726f, 
    0.13415185f, 0.09314928f, 0.13929963f, -0.47330040f, 0.33939475f, -0.24323249f, 0.08167066f, 0.01027132f, 
    -0.05414411f, 0.59726322f, 0.27451700f, -0.01208652f, -0.27676675f, -0.48906395f, -0.29164070f, -0.90546912f, 
    0.17677952f, 0.05609365f, -0.45352313f, -0.41264424f, -0.21654657f, -0.03814254f, -0.56041634f, -0.30370513f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.52169091f, 0.08747420f, 0.25818279f, -0.02930952f, -0.07919934f, -0.26596966f, 0.03885138f, -0.13447697f, 
    0.15276034f, 0.27866715f, 0.26972878f, -0.12076487f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
