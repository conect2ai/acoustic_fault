#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.77017438f, 0.04887816f, -0.61643308f, 0.55914533f, 0.84653807f, 0.76240826f, 0.33163163f, 0.38741982f, 
    0.71963745f, -0.17316361f, 0.53436774f, 0.08904853f, -0.62959307f, -0.01316789f, 0.19512483f, -0.15704510f, 
    -0.61214596f, -0.03943915f, -0.61112386f, -0.06544806f, 0.42285669f, 0.54811215f, -0.26420826f, 0.18513148f, 
    -0.03068145f, 1.83123171f, 0.83516121f, 1.11856127f, -0.42940441f, -0.83368802f, 0.29225561f, -0.21424283f, 
    -0.15553874f, 0.35892344f, 0.74832147f, 0.05341871f, 0.17791583f, -0.58056414f, -0.31900102f, -0.15423082f, 
    -0.20800076f, -0.09801891f, -0.38183737f, -0.27402306f, 0.16481854f, -0.45171687f, 0.06144497f, 0.29474896f, 
    -0.03363874f, 0.38204545f, 0.21093082f, 1.45958173f, 1.47193718f, 0.90257633f, 0.41604900f, -1.41875660f, 
    0.40691066f, -0.64073759f, -0.95273685f, -0.09423040f, 0.38079733f, 0.17804147f, 0.11150731f, 0.63816386f, 
    0.34578082f, 0.01026913f, 0.38280678f, 0.39290264f, 0.30905756f, 0.25211832f, 0.06574626f, 0.19055693f, 
    0.18249959f, 0.16565892f, 0.32925522f, -1.66095328f, -0.13908976f, -0.13897830f, -1.12093270f, -1.10622191f, 
    -0.11169899f, 0.56304854f, -0.01873416f, 0.28589523f, -0.17134213f, -0.37447956f, -0.51491559f, 0.35013103f, 
    0.24141659f, 0.34817293f, -0.13377135f, -0.13636427f, -0.07456987f, -0.11920656f, -0.41733533f, 0.19534433f, 
    0.14972994f, 0.19126958f, -0.22213945f, 0.14673185f, -1.29693842f, 0.06730793f, -0.74733949f, -1.17876399f, 
    -0.89890683f, 0.82938379f, -0.46035469f, -0.27740079f, 0.99344063f, 0.65561330f, -0.22567320f, 0.01480160f, 
    -0.31225640f, 0.09403258f, -0.32437792f, -0.00710833f, 0.25706008f, -0.09507971f, 0.04366509f, 0.12549044f, 
    -0.01912205f, -0.15246059f, -0.19819638f, -0.13644774f, 0.00455998f, -0.76784259f, 1.42510903f, 0.14016432f, 
    -0.73185766f, -0.86741817f, 0.58993441f, 1.01791608f, 0.54511988f, 0.80589652f, 1.15166509f, -0.47357151f, 
    0.31459534f, -0.30135116f, -0.64209718f, -0.42827037f, 0.26890060f, 0.26952490f, -0.25038150f, 0.12403107f, 
    0.08466063f, -0.12086378f, -0.21332343f, -0.15072721f, -0.33731663f, -0.02576772f, -0.93639255f, -0.10444777f, 
    -0.69388497f, -1.28409553f, 0.55705851f, -0.63817322f, -0.59254509f, -0.43176439f, -0.07607400f, -0.73362553f, 
    -0.64193779f, -0.29482785f, -0.47528943f, -0.15092491f, -0.56938767f, 0.24400671f, 0.11073630f, 0.12795956f, 
    0.00254447f, 0.26631001f, 0.03030398f, 0.01857919f, 0.68025154f, 0.37367362f, 0.36495942f, -1.40462899f, 
    -0.59634703f, 0.54135078f, 0.02773083f, 0.07243643f, 0.64074248f, 0.24298941f, -0.81908083f, 0.13095269f, 
    -1.04636014f, -0.48092276f, 0.68219781f, 0.23056702f, 0.46334657f, 0.37937805f, 0.03184806f, -0.16100229f, 
    0.14427553f, -0.40130946f, -0.44933289f, 0.27707049f, 0.18781282f, -0.18717434f, 0.33993825f, -0.06916701f, 
    -1.47393644f, -1.53883576f, 0.44720724f, 0.95330197f, -0.00682487f, 0.90867573f, 0.64455479f, 0.77600080f, 
    0.49589804f, -0.64161068f, -0.05546001f, -0.35555354f, -0.22027761f, 0.31608236f, 0.06006983f, 0.03994356f, 
    0.36364669f, -0.37495992f, -0.12706488f, -0.13054834f, -0.19347379f, -0.12075664f, -0.16065428f, -0.12734224f, 
    -0.26360822f, 0.96434706f, -0.09713840f, -0.94024897f, -1.51567638f, -0.59703261f, -0.13449022f, -0.01736031f, 
    -0.16120107f, -0.87495154f, -0.34064060f, 0.23601513f, 0.02619748f, 0.77419603f, 0.20556627f, 0.27966881f, 
    -0.16198274f, 0.39612779f, 0.18159494f, 0.28954333f, -0.39102677f, -0.50659364f, -0.37397668f, 0.14358857f, 
    -0.31811419f, 0.06826603f, 0.76075113f, -0.10332853f, -1.08917725f, -1.23336101f, -0.94936317f, 0.09700985f, 
    1.31647635f, 0.50090390f, -0.40622437f, -0.00204833f, 0.18904813f, -0.16479602f, -0.73034275f, 0.03201565f, 
    0.15290554f, 0.19460312f, 0.02282195f, 0.13186824f, 0.21309137f, 0.36550686f, 0.00358562f, -0.07221966f, 
    -0.03873270f, 0.26416147f, 0.24981730f, -0.99716973f, -0.52952331f, 0.27040413f, 0.81211245f, 0.75852442f, 
    -0.85047871f, -0.37318161f, -0.86692989f, -0.73971015f, -0.17346554f, 0.69427317f, 0.78778726f, 0.73790872f, 
    -0.13074848f, 0.01865084f, -0.15107138f, 0.54151571f, 0.66617799f, 0.13107546f, -0.25114378f, -0.26541451f, 
    -0.16186838f, -0.01606594f, 0.25297028f, -0.50295532f, 1.32768810f, 0.76109999f, -0.02425378f, 0.98220485f, 
    1.33974695f, 0.86471808f, 0.23525760f, 0.35899389f, 0.77422208f, 0.56636220f, -0.12082698f, 0.42603016f, 
    -0.14022273f, 0.48853523f, 0.30497265f, 0.34039500f, 0.03557650f, -0.20673478f, -0.26848528f, 0.28244299f, 
    0.19687277f, 0.25674865f, 0.31795403f, -0.05334854f, 0.54114825f, -0.24678177f, -1.32412541f, 0.12079496f, 
    1.11521125f, -0.53387994f, -0.81159359f, 0.68188590f, 1.32720244f, -0.94088465f, 0.27966756f, 0.45221603f, 
    0.24478804f, 0.52046543f, 0.20857704f, -0.18164615f, -0.49330842f, -0.13264747f, -0.43009841f, 0.25311098f, 
    -0.38586548f, -0.34157139f, -0.22445008f, 0.18090703f, -0.02491397f, 0.50608230f, 1.61659801f, 0.97633910f, 
    0.27761751f, 1.39695752f, 1.36154175f, 0.76326180f, 0.52686119f, 0.00926495f, -0.30839539f, -0.04352763f, 
    -0.41537321f, 0.26169854f, 0.28800687f, 0.20832781f, -0.32136947f, -0.48174223f, 0.09636113f, 0.43984824f, 
    0.06548787f, -0.14044896f, -0.18786146f, -0.08538422f, -0.21080551f, -0.16582707f, -0.07210880f, 0.03554381f, 
    1.63389766f, -0.32418197f, -0.56144905f, 0.64141405f, 0.20164227f, -1.21927285f, -1.16178656f, -0.40561807f, 
    0.24251513f, 0.33956948f, -0.20165348f, 0.34144080f, -0.10108542f, -0.33102036f, -0.29402578f, -0.44366673f, 
    0.02638034f, -0.37398502f, -0.42486143f, -0.06428860f, 0.22313145f, -0.26965380f, -0.19930910f, -0.28712586f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.51188004f, 0.28759128f, 0.13783991f, -0.10872538f, 0.08661176f, -0.16210064f, 0.27697039f, 0.39563221f, 
    0.27640364f, 0.44333148f, 0.60415012f, 0.38770613f, 0.38208675f, 0.22577745f, 0.34333512f, 0.27726069f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.11782839f, 0.07845029f, 0.06086497f, 0.07914325f, -0.11448657f, -0.09193486f, -0.18059926f, -0.09081937f, 
    -0.00858224f, -0.20458710f, 0.14411756f, 0.01942149f, 0.29232588f, -0.18492660f, -0.00469168f, -0.06226083f, 
    -0.16367571f, -0.19975874f, -0.17098811f, 0.09818212f, -0.15384896f, -0.07840600f, 0.05805735f, -0.03707004f, 
    -0.02976667f, 0.33075744f, -0.14497931f, 0.07309785f, -0.30314639f, -0.18112083f, 0.00651503f, -0.05087654f, 
    -0.04661581f, -0.06495294f, -0.06681164f, -0.06447778f, 0.78501010f, 0.07021564f, 0.04763555f, -0.33239359f, 
    -0.14892091f, 0.29218096f, -0.22881380f, 0.27038160f, 0.22183184f, -0.05093563f, -0.10936505f, 0.13657787f, 
    0.75215882f, 0.01220413f, -0.36619323f, -0.39677528f, 0.14891198f, -0.08102546f, 0.25248608f, 0.01339717f, 
    -0.09901799f, -0.02616517f, -0.04997294f, -0.04185008f, 0.71815503f, 0.24807416f, 0.16394678f, -0.11255666f, 
    0.07536625f, 0.06856386f, 0.08701251f, -0.38381481f, -0.00958806f, -0.11126301f, 0.01635170f, -0.06873530f, 
    -0.58137697f, -0.17949198f, 0.25983891f, 0.04741910f, 0.05129785f, 0.03698149f, 0.16264322f, 0.21378170f, 
    -0.10610025f, -0.04524225f, 0.10908324f, -0.30761629f, -0.64016736f, -0.09164885f, 0.19668116f, 0.12607718f, 
    0.38299415f, -0.18951473f, 0.06329240f, 0.07646784f, 0.03165944f, -0.04558376f, 0.01297312f, -0.16105883f, 
    -0.40999353f, 0.08505940f, 0.18013862f, 0.18438581f, 0.05559365f, 0.17952666f, 0.12033869f, 0.00224727f, 
    0.05463256f, -0.25366893f, -0.02027226f, -0.20749751f, -0.85117704f, 0.11751269f, 0.43410993f, -0.20927694f, 
    0.05111499f, -0.28448695f, 0.09415959f, -0.09794905f, -0.17361377f, 0.08622164f, -0.03418850f, -0.00407851f, 
    -0.65919065f, 0.02599998f, 0.12590382f, -0.81720018f, -0.14704946f, 0.06531197f, -0.11785698f, -0.10644044f, 
    -0.12149353f, -0.01974786f, 0.06544600f, 0.08213677f, -0.11322085f, -0.17444934f, -0.15351966f, 0.15589029f, 
    0.07527060f, -0.19431418f, -0.01538950f, -0.00574245f, 0.32807234f, 0.02425347f, -0.23240903f, -0.01267422f, 
    0.25558758f, -0.33624619f, -0.10632861f, 0.32335901f, 0.00353597f, -0.06052401f, -0.13268863f, 0.00934140f, 
    -0.00729135f, 0.07572263f, 0.15814702f, -0.17241342f, -0.48627073f, 0.11039659f, -0.12220035f, 0.25206408f, 
    -0.04448209f, 0.06359681f, -0.22952959f, -0.12357557f, -0.02343074f, 0.19305179f, 0.01898876f, 0.02593992f, 
    0.34545526f, -0.34361762f, 0.22537601f, 0.36727682f, -0.25573322f, 0.11259018f, 0.04163408f, 0.12287807f, 
    0.09011538f, 0.12619801f, 0.00311595f, 0.07051402f, -0.06751531f, -0.00360547f, 0.48203883f, -0.65988404f, 
    -0.28727081f, -0.13404892f, 0.07731789f, 0.01389487f, 0.10146076f, -0.00957262f, 0.10904363f, 0.01921734f, 
    0.28335986f, 0.16325526f, -0.15378994f, 0.13537708f, 0.23142727f, 0.32778177f, -0.09776597f, 0.05567368f, 
    0.14382459f, 0.17149423f, -0.13390939f, -0.01854760f, 0.33676776f, 0.07645705f, 0.10607847f, -0.00468351f, 
    -0.31922925f, -0.22039561f, 0.03038585f, -0.15140930f, -0.13221869f, -0.19973154f, 0.05548067f, -0.13305436f, 
    0.03249075f, 0.20496036f, -0.17044805f, 0.10203724f, -0.08489835f, 0.18112707f, 0.09150266f, 0.04418543f, 
    0.17055313f, 0.10183016f, 0.09987780f, -0.01938129f, -0.26633483f, -0.18101496f, -0.10387777f, 0.15807314f, 
    0.01669572f, -0.06414396f, 0.07040644f, 0.21563078f, -0.09312051f, 0.02683824f, -0.04657574f, 0.00580302f, 
    -0.59878057f, -0.23112483f, -0.04318636f, -0.36163434f, 0.16297527f, -0.05584319f, 0.06830407f, 0.24949522f, 
    0.16956922f, 0.13218738f, -0.07292776f, -0.14798252f, -0.87729412f, 0.15830918f, -0.07680401f, -0.22117834f, 
    0.10953474f, -0.09453242f, -0.04080989f, -0.13501041f, 0.21641287f, 0.14869508f, -0.03831286f, -0.01568484f, 
    -0.12328061f, -0.16057600f, 0.34447563f, -1.05491936f, 0.04281830f, -0.02111675f, 0.17292906f, -0.02907684f, 
    0.12325144f, 0.20645045f, -0.03613397f, 0.20197488f, -0.12249540f, -0.02815075f, -0.32299814f, 0.01941099f, 
    -0.33349413f, -0.06573027f, 0.11201509f, 0.16126554f, 0.05271756f, -0.10507086f, -0.02157676f, 0.01400481f, 
    0.00082122f, 0.56712276f, -0.40664333f, 0.21325377f, 0.03955457f, 0.07945288f, -0.00351381f, -0.11865719f, 
    -0.02933871f, 0.09614603f, -0.04795789f, 0.06392640f, 0.55542952f, -0.03816243f, 0.06923946f, -0.18484372f, 
    0.06258867f, -0.12579218f, 0.03185374f, 0.26117855f, -0.19659241f, -0.12066399f, 0.22470182f, -0.04846927f, 
    0.62815559f, -0.21467133f, -0.14463563f, -0.41757619f, 0.03900605f, 0.06951177f, 0.09917985f, 0.10854141f, 
    -0.10072462f, 0.07923523f, -0.16606322f, 0.05401936f, -0.19088072f, -0.32763731f, -0.19259806f, 0.06539222f, 
    0.00162114f, -0.13779280f, -0.28375676f, -0.06637868f, -0.18313144f, -0.07624011f, 0.31500024f, -0.08789660f, 
    0.67351401f, -0.13981870f, 0.35847825f, 0.29339787f, -0.33913678f, 0.10797979f, -0.12935235f, 0.08648168f, 
    0.04865381f, 0.10286522f, -0.14529060f, 0.16192840f, -0.17722002f, 0.00588495f, -0.20271821f, 0.36453861f, 
    -0.20129213f, -0.06744194f, -0.21392472f, -0.07360100f, -0.10097677f, -0.26546070f, -0.08061254f, -0.09240649f, 
    0.42049786f, 0.19640954f, 0.23086728f, 0.35256732f, -0.09620801f, -0.06237647f, -0.18149987f, 0.10360299f, 
    -0.11913862f, -0.23704913f, -0.10045406f, -0.06686191f, -0.12370423f, -0.16494514f, -0.15655799f, -0.46914312f, 
    -0.10579415f, -0.23452432f, 0.07487994f, 0.02582402f, 0.04944716f, -0.12076653f, -0.08633859f, -0.09680615f, 
    0.13218728f, -0.10588023f, 0.04917634f, 0.26883030f, -0.21519734f, -0.11220261f, -0.08773375f, -0.15461037f, 
    0.19338687f, 0.08959337f, 0.04912604f, 0.08855320f, 0.07870690f, 0.11173467f, 0.24960975f, -0.39640078f, 
    -0.07199103f, 0.09891956f, 0.02960516f, 0.12826657f, -0.09424032f, -0.00994419f, 0.13925004f, -0.06251146f, 
    0.09597629f, 0.15706095f, -0.46970412f, 0.13643418f, 0.08308377f, 0.13616009f, 0.02769822f, -0.12953496f, 
    -0.09600262f, -0.04406433f, -0.27787885f, -0.15233846f, 0.32520589f, 0.34501976f, -0.17285143f, 0.07328447f, 
    -0.10383889f, -0.06313248f, -0.20196456f, 0.02194159f, 0.12062229f, 0.05487437f, 0.16691726f, -0.00446608f, 
    0.33197251f, 0.55864936f, 0.00737668f, 0.35478169f, 0.04098797f, -0.22999479f, 0.05978324f, -0.06529241f, 
    -0.26452419f, 0.25011626f, -0.01465262f, 0.05830509f, 0.54594803f, 0.25066870f, 0.01383015f, -0.01143925f, 
    -0.15652420f, 0.08743792f, 0.16498084f, 0.17307831f, -0.16601001f, -0.02706624f, 0.08642874f, -0.02748037f, 
    -0.93759465f, -0.49248058f, -0.40219602f, -0.45139155f, -0.07674024f, -0.08707988f, -0.15568191f, -0.07095037f, 
    -0.00426947f, -0.00758116f, 0.18044427f, -0.04932379f, 0.75624436f, -0.23858240f, -0.27337921f, -0.43385565f, 
    -0.13039628f, 0.07862259f, 0.02127035f, 0.23185858f, -0.09531951f, 0.07327120f, -0.20166637f, -0.10772858f, 
    0.33377323f, -0.38618612f, -0.02720511f, -0.05668648f, -0.31482232f, -0.18565066f, -0.25696278f, -0.10494350f, 
    0.20882156f, 0.04097721f, -0.11688650f, -0.20689745f, -0.39209563f, -0.03953530f, 0.11835035f, -0.31115171f, 
    -0.12669970f, -0.47045547f, 0.11329862f, -0.06989912f, -0.18751858f, 0.07325063f, -0.22922452f, -0.23914431f, 
    0.03654741f, 0.10356048f, 0.18872321f, 0.26822194f, -0.45357144f, -0.35453805f, -0.00441028f, -0.07203082f, 
    -0.08005182f, -0.19764268f, 0.09060928f, 0.05613409f, 0.78444546f, -0.52164876f, -0.05741234f, 0.28367963f, 
    -0.22239445f, 0.08199754f, -0.22689347f, 0.01087253f, -0.06963255f, -0.08945604f, 0.00261922f, -0.08032974f, 
    0.24811247f, -0.18112537f, -0.01654000f, 0.06199462f, 0.11457261f, -0.09086055f, 0.15791832f, -0.16689663f, 
    0.00021014f, -0.07474576f, 0.24289376f, -0.09684701f, 0.82306343f, -0.08162902f, -0.10307341f, 0.02731677f, 
    -0.21789350f, 0.07290646f, 0.00097741f, 0.05269673f, -0.06263846f, 0.14822017f, -0.02198916f, -0.14303684f, 
    0.08202130f, -0.42994747f, 0.28611964f, -0.11574392f, 0.11853016f, -0.12125003f, 0.06246468f, -0.12603602f, 
    -0.05512799f, 0.06104530f, -0.15824287f, 0.10433415f, -0.16592376f, -0.30021602f, -0.06082915f, -0.51963437f, 
    0.18858875f, -0.06032766f, 0.24511091f, -0.21800195f, -0.06154193f, 0.09097804f, 0.11622871f, -0.11469505f, 
    0.21863957f, 0.36601827f, 0.03628643f, -0.02724754f, 0.11899826f, 0.03557861f, 0.22346802f, -0.32850060f, 
    -0.02594091f, -0.01530705f, 0.00621990f, -0.02906324f, -0.43968737f, -0.38804609f, -0.62258911f, -0.22999555f, 
    0.07432564f, 0.25203252f, -0.06366881f, 0.05243722f, 0.03898442f, 0.25204021f, 0.12948574f, 0.04546946f, 
    -1.06241965f, -0.25102258f, 0.10496005f, 0.39987838f, 0.05550650f, 0.07175353f, 0.03205054f, -0.02775850f, 
    -0.08084837f, -0.24172910f, 0.11587975f, -0.05205821f, -0.34333819f, 0.31137609f, 0.03834781f, -0.11237768f, 
    -0.16635634f, -0.06013374f, 0.04695228f, 0.02887177f, 0.08380040f, 0.01321386f, 0.04779596f, 0.21708368f, 
    0.03725909f, 0.22069716f, -0.00221412f, -0.33831996f, -0.24538915f, -0.19733027f, 0.05187877f, 0.01503780f, 
    -0.06512284f, -0.20557486f, 0.07020241f, 0.04116025f, -0.81614870f, 0.13261285f, 0.21958300f, -0.42666084f, 
    -0.00606607f, 0.28162938f, -0.22218893f, 0.07652393f, -0.07194111f, 0.07320447f, -0.17017253f, -0.17047538f, 
    0.13177204f, 0.13011666f, 0.25635430f, 0.17449860f, -0.17969118f, -0.25161734f, 0.03354824f, -0.09276822f, 
    0.09362603f, 0.01151939f, 0.00840124f, 0.04122881f, 0.35840473f, 0.22840491f, 0.03507552f, 0.11106258f, 
    -0.06343287f, -0.07751245f, -0.11717196f, 0.00970148f, -0.16254966f, 0.07800100f, -0.07148107f, -0.01051999f, 
    0.12665606f, -0.12492295f, 0.02735017f, 0.07997732f, -0.11004613f, -0.32162115f, 0.03416606f, 0.06520768f, 
    0.05667639f, -0.08124188f, 0.07512681f, -0.04751416f, 0.06120342f, -0.44442603f, 0.08016649f, -0.13288699f, 
    -0.05067501f, -0.03285555f, 0.18354309f, 0.12986305f, 0.19001983f, 0.08683283f, -0.15431449f, 0.05618399f, 
    -0.21749410f, -0.34913647f, -0.14821440f, 0.14580487f, -0.12034547f, -0.00813273f, 0.02164035f, 0.18440653f, 
    -0.09606628f, -0.06978349f, 0.14792880f, 0.06256294f, -0.54748404f, 0.22229472f, 0.35579178f, 0.35701132f, 
    0.17292261f, 0.09225240f, 0.19786961f, 0.13188185f, -0.17237219f, 0.13388510f, -0.44442284f, -0.14429536f, 
    -0.66806394f, -0.30120167f, -0.71999592f, -0.21501409f, 0.04337853f, 0.07032847f, -0.10896599f, -0.07968818f, 
    -0.01789532f, -0.31173861f, 0.01956564f, -0.11693085f, 0.29706436f, -0.05662348f, 0.44989640f, -0.39338964f, 
    -0.02995851f, 0.12608063f, -0.10089543f, 0.04027857f, -0.29000029f, 0.07094063f, -0.17333260f, 0.11161349f, 
    -0.23624332f, -1.20983016f, 0.16444249f, 0.23936535f, -0.05519291f, 0.12358551f, 0.00214389f, -0.14986956f, 
    0.12757845f, -0.13188303f, -0.00305716f, 0.21169882f, 0.96802378f, 0.37253255f, 0.08557998f, 0.20665781f, 
    -0.21247527f, 0.22051865f, -0.05149004f, 0.08642191f, 0.13400459f, 0.13043559f, -0.06281143f, 0.14424366f, 
    0.18397197f, 0.02394955f, -0.35091069f, -0.30824479f, 0.00430794f, 0.04490604f, 0.16930945f, -0.18125668f, 
    -0.19893917f, -0.20646830f, 0.28389767f, -0.00309817f, -0.65204895f, -0.04811885f, 0.20953910f, -0.15869004f, 
    0.00285919f, 0.14083813f, 0.01640867f, -0.01774672f, 0.05222821f, 0.08111645f, 0.17851175f, -0.00718248f, 
    -0.81461823f, -0.22054216f, 0.44343808f, 0.28451413f, -0.19837984f, 0.01331145f, 0.06212709f, 0.12011421f, 
    0.19406410f, 0.07019374f, -0.14007583f, -0.05722372f, 0.09111279f, -0.18681064f, 0.08963493f, -0.12859501f, 
    0.16675620f, -0.29776016f, 0.41193068f, -0.10661077f, -0.00329915f, -0.04539782f, -0.20624062f, -0.11361212f, 
    0.48006508f, -0.02302273f, 0.18936659f, 0.21997657f, 0.06620874f, -0.11422448f, -0.18654345f, 0.21915002f, 
    -0.02649454f, 0.07384881f, 0.11149792f, 0.26295477f, 0.10717195f, -0.28060907f, 0.24232346f, 0.27819613f, 
    -0.11020993f, 0.05283744f, -0.01961498f, -0.05815389f, 0.01242142f, 0.22185649f, 0.14029913f, 0.11215796f, 
    0.26211104f, 0.13047929f, -0.08960501f, 0.11395401f, -0.05703543f, -0.17188574f, 0.10802975f, 0.27090949f, 
    -0.01701560f, -0.13838735f, -0.01022134f, 0.09772066f, 0.00697362f, 0.37662902f, -0.06774167f, -0.55403030f, 
    -0.01848244f, 0.00323166f, -0.08678616f, -0.22759663f, -0.13021417f, 0.10058589f, -0.16420057f, 0.13277012f, 
    -0.60678190f, -0.04197324f, -0.25661337f, -0.32765016f, -0.07410724f, 0.16871721f, 0.02397715f, 0.20978358f, 
    0.09522541f, -0.07718761f, -0.04193881f, 0.04877919f, 0.10421045f, 0.12350029f, 0.14498729f, 0.10665116f, 
    0.01997322f, 0.31901222f, 0.22361614f, 0.06635408f, 0.09023237f, -0.09919408f, 0.17442429f, 0.28775594f, 
    -0.82591689f, -0.05944283f, 0.45527390f, -0.05767702f, 0.11132282f, -0.09371468f, -0.08342802f, -0.10803459f, 
    0.07096883f, 0.01251234f, 0.03186137f, -0.16532028f, -0.38537335f, -0.07420012f, 0.26865187f, 0.09826629f, 
    0.04114205f, 0.06664500f, -0.12476520f, 0.01674738f, 0.12516786f, -0.03139132f, -0.32357022f, -0.02253171f, 
    0.18558514f, -0.17781849f, -0.31377530f, 0.22241117f, -0.09275565f, -0.19620040f, 0.03390500f, 0.01610009f, 
    0.00535500f, 0.10332345f, -0.16482800f, -0.12286006f, -0.62495345f, -0.25387451f, -0.09241728f, -0.29075050f, 
    0.04085571f, -0.08755512f, 0.14596114f, 0.14310215f, -0.14745353f, -0.01822283f, -0.05555147f, 0.00238939f, 
    0.44636592f, 0.32681572f, -0.28767598f, -0.02981468f, 0.02547668f, -0.14588045f, 0.06008880f, 0.10720235f, 
    -0.12657505f, -0.07129060f, 0.02401058f, -0.02254246f, -0.19993956f, -0.08908385f, -0.05021221f, 0.24403523f, 
    -0.25751436f, 0.02044671f, 0.00189427f, -0.03624295f, -0.10103698f, 0.02670537f, -0.00690707f, 0.24304630f, 
    -0.40713760f, 0.11850488f, 0.15247485f, -0.40437299f, -0.16006504f, -0.05066547f, 0.12197442f, 0.04790297f, 
    0.09893381f, 0.06448025f, -0.45996597f, -0.12767830f, 0.15739743f, -0.06819703f, -0.21569969f, 0.20725374f, 
    0.01210553f, -0.09790097f, 0.23121949f, 0.04820008f, -0.00680619f, -0.25914556f, -0.25059688f, -0.16040508f, 
    0.29643652f, 0.04785423f, -0.07910048f, -0.04818355f, -0.08819361f, -0.10948008f, 0.08475226f, 0.02659804f, 
    -0.09519721f, -0.07698119f, 0.27161708f, 0.32531920f, -1.02853477f, -0.66002315f, -0.02227137f, 0.08876785f, 
    0.22684871f, 0.21738571f, 0.01891076f, 0.03059305f, 0.00468132f, -0.05042654f, 0.09744164f, -0.10310540f, 
    0.08993471f, -0.48727748f, -0.12323465f, 0.13812214f, 0.15267874f, 0.35301039f, 0.04818159f, -0.43181676f, 
    0.05900719f, -0.10896724f, -0.00944932f, -0.24928278f, 0.25361413f, 0.08831719f, -0.07118980f, -0.07464854f, 
    -0.00974264f, -0.15586157f, -0.30467224f, -0.06768505f, 0.01397256f, -0.07067121f, -0.07299933f, 0.02685017f, 
    0.16288786f, -0.08438521f, 0.02037314f, 0.02561198f, 0.12596712f, 0.14633778f, 0.02325566f, 0.01238401f, 
    0.15975893f, -0.07741897f, -0.14888725f, 0.16612355f, -0.46881256f, -0.12536348f, 0.16390103f, 0.21257056f, 
    0.02029537f, -0.04087175f, -0.27390617f, 0.18441266f, -0.25463125f, 0.15175043f, 0.23298363f, 0.00851187f, 
    -0.89938647f, 0.00094182f, -0.11342759f, -0.07599787f, 0.18489659f, 0.07197295f, 0.07572787f, -0.25576892f, 
    0.03301961f, 0.05025709f, -0.07383843f, 0.08865058f, -0.35970050f, 0.04396520f, 0.10296159f, 0.08302807f, 
    0.00394263f, -0.19103323f, -0.03293542f, 0.08202342f, 0.11935835f, -0.17459081f, 0.15501143f, 0.06491042f, 
    0.16372171f, -0.01410391f, -0.49884930f, 0.02231174f, 0.12859698f, -0.00049557f, 0.01866238f, 0.06691013f, 
    0.02367888f, 0.22461896f, -0.13939054f, 0.10675568f, 0.00167641f, 0.09948235f, -0.13686782f, -0.29759410f, 
    0.12981734f, -0.00742116f, 0.20579264f, -0.01813976f, -0.00619926f, 0.05794527f, 0.29283857f, 0.37724543f, 
    -0.17308968f, 0.42629936f, 0.23658377f, -0.32334316f, -0.01680097f, 0.00568942f, 0.11362972f, -0.06302139f, 
    0.12731150f, 0.04276881f, -0.05131849f, 0.22062854f, -0.21723397f, 0.02441338f, -0.06640051f, -0.17820443f, 
    -0.03682121f, 0.01835774f, -0.01591147f, 0.09624550f, 0.06328751f, -0.21946838f, 0.05750879f, -0.08330312f, 
    -0.06016160f, -0.12615061f, 0.45492208f, -0.12115730f, 0.05550408f, 0.14137888f, 0.04775367f, -0.10495743f, 
    0.06562171f, -0.08337779f, 0.07851662f, 0.19160736f, -0.36388636f, -0.02227219f, 0.18361285f, 0.44777015f, 
    -0.02098845f, 0.00301000f, 0.08903592f, 0.00166576f, -0.05127606f, -0.28439480f, -0.06762272f, -0.13947795f, 
    0.11728881f, -0.31026953f, 0.05377101f, 0.11953322f, 0.05486413f, -0.15553886f, 0.00641583f, -0.02401598f, 
    -0.09738036f, 0.00688709f, 0.17291304f, 0.14439632f, -0.58927757f, 0.51633269f, 0.07906923f, 0.61920178f, 
    -0.14660683f, 0.10634255f, -0.10986028f, 0.19633079f, 0.00710704f, 0.11124577f, -0.02055535f, -0.04001168f, 
    0.08674324f, 0.31370604f, 0.42021593f, -0.40363786f, 0.12874641f, -0.06911090f, -0.02016637f, 0.00145063f, 
    0.00915312f, -0.14213008f, -0.34511694f, -0.18412603f, 0.28552163f, 0.02100744f, -0.28607732f, -0.20517892f, 
    -0.26838043f, 0.21384157f, -0.22122978f, -0.08642422f, -0.27848420f, 0.02332685f, 0.16646883f, 0.19293599f, 
    -0.32099521f, -0.14482927f, -0.35922235f, -0.19080915f, -0.26064837f, -0.00601592f, -0.00919587f, -0.04508829f, 
    -0.18823807f, 0.32299399f, 0.10150587f, 0.29115063f, -0.04783988f, -0.22605020f, -0.15746357f, 0.36792833f, 
    -0.16212255f, -0.08488590f, 0.26904953f, 0.12794119f, 0.00653610f, -0.10593710f, 0.25231299f, -0.07671984f, 
    -0.18017483f, 0.09813973f, -0.27310705f, 0.02406917f, -0.38954675f, 0.02493075f, -0.10880039f, -0.32486030f, 
    -0.07818068f, 0.04648113f, -0.21296991f, -0.16997145f, -0.05287774f, -0.34254318f, -0.03125330f, -0.23159021f, 
    0.20015758f, 0.24085243f, 0.15602246f, -0.12154078f, -0.08359358f, 0.12286887f, -0.05728355f, -0.15991203f, 
    0.30559233f, -1.21422219f, -0.03622250f, -0.00712442f, -0.06022847f, 0.06350540f, -0.04240104f, 0.15022938f, 
    0.08929209f, 0.02683986f, -0.03530484f, 0.01894611f, 0.28031784f, -0.36980361f, -0.36385417f, 0.36204109f, 
    -0.00901945f, 0.03328666f, -0.26244804f, -0.17509200f, 0.10215146f, 0.11851839f, -0.26859736f, -0.09352196f, 
    0.15447418f, -0.10946978f, -0.31493503f, 0.21736827f, 0.18221465f, -0.07265379f, -0.20697846f, -0.02276335f, 
    0.07076176f, -0.16956137f, 0.08027684f, -0.18522134f, 0.25840408f, -0.06180291f, 0.05030187f, -0.09507197f, 
    -0.02182881f, 0.16631828f, 0.03416204f, 0.13738088f, 0.10148010f, 0.05664477f, -0.24955843f, -0.08463468f, 
    -0.44832712f, 0.20295753f, 0.43420577f, -0.24437803f, -0.18572319f, -0.08115402f, -0.06274365f, 0.14038454f, 
    -0.00170008f, -0.20139660f, 0.12850362f, -0.25982037f, 0.48721761f, -0.30880383f, 0.26714009f, 0.07202800f, 
    0.18534997f, 0.02327674f, 0.16414860f, -0.10666563f, 0.32046652f, -0.00493951f, 0.12034736f, -0.02355973f, 
    0.08683652f, 0.03264740f, 0.18586420f, -0.70832616f, -0.24631745f, 0.09933662f, -0.02091823f, 0.12306445f, 
    0.06162172f, 0.19367869f, -0.08384030f, -0.02741455f, -0.23202923f, 0.13660863f, -0.03831263f, 0.02797985f, 
    0.20709392f, 0.04570666f, 0.07067310f, 0.14209524f, -0.31850269f, 0.33612177f, 0.00117894f, 0.11194243f, 
    -0.61290520f, 0.01068702f, -0.06836503f, -0.41141424f, -0.09119724f, -0.05723001f, -0.22310695f, 0.00457495f, 
    0.13237958f, -0.06736022f, 0.03380637f, -0.08781002f, -0.55556583f, -0.26425239f, -0.41173238f, -0.24334379f, 
    -0.11663227f, -0.02909377f, -0.09674207f, 0.00111551f, -0.06472574f, -0.09819962f, -0.30970517f, -0.21671946f, 
    0.22548996f, -0.98541898f, -0.06218068f, -0.21147864f, 0.07452073f, -0.15465176f, -0.03510141f, 0.01895549f, 
    0.01091826f, 0.05634335f, 0.01928035f, -0.06435464f, 0.32728499f, 0.19265537f, 0.15174758f, 0.54708230f, 
    0.49008778f, 0.04577515f, 0.01048910f, -0.02875282f, -0.00582023f, -0.18125246f, 0.03264610f, -0.17700557f, 
    0.01333378f, 0.39989284f, 0.06803545f, 0.48219937f, 0.25124332f, 0.08717923f, 0.16949421f, 0.02372811f, 
    0.01010467f, -0.06682034f, 0.09481713f, -0.20241894f, -0.00517741f, 0.06865670f, 0.00087138f, -0.04506224f, 
    0.15148653f, -0.07650410f, 0.14661272f, -0.13855036f, 0.17040218f, -0.07245357f, 0.03639300f, 0.13575198f, 
    0.15835787f, 0.20025423f, 0.21668459f, 0.49944869f, 0.17624395f, 0.22658148f, -0.12243647f, -0.03693167f, 
    -0.21494551f, -0.13523424f, -0.02437206f, -0.18507202f, -0.00741620f, 0.01746197f, 0.29932851f, -0.10663549f, 
    0.24217455f, 0.06402210f, 0.01262956f, -0.09344281f, -0.08231092f, -0.07291108f, 0.10091815f, -0.22502075f, 
    -0.01676553f, -0.12225624f, 0.26566580f, -0.00111319f, 0.04351362f, 0.00698344f, -0.01264398f, 0.15413362f, 
    -0.10711881f, 0.02836942f, -0.03485598f, 0.03714653f, -0.19705148f, 0.17448598f, 0.05326782f, 0.14124252f, 
    -0.21077600f, -0.09626666f, -0.19543463f, -0.06064559f, -0.17800675f, -0.04001246f, -0.11762100f, -0.19009756f, 
    0.04253406f, 0.25146788f, 0.23930700f, 0.24615049f, 0.01608079f, -0.05824882f, -0.14845307f, -0.07383729f, 
    0.05967438f, -0.05555756f, -0.10961463f, -0.13872367f, 0.09162212f, -0.51972961f, 0.29508421f, -0.18619193f, 
    -0.00556544f, -0.19058603f, -0.05674896f, -0.18223594f, -0.00769893f, -0.04983389f, -0.01139784f, -0.06709627f, 
    -0.31727016f, 0.35470372f, 0.02684223f, -0.05619262f, -0.03299754f, 0.20061311f, -0.09461561f, -0.10588463f, 
    -0.16958103f, 0.11669219f, -0.01987262f, -0.20053895f, 0.66803885f, -0.19425181f, 0.07999904f, -0.25083092f, 
    -0.18037285f, 0.06951903f, -0.16938998f, -0.27526096f, 0.07584628f, -0.04765323f, -0.26443622f, 0.02593662f, 
    -0.78068978f, 0.49442288f, -0.01855597f, -0.18701558f, -0.16716601f, 0.03386923f, 0.03547770f, -0.11267810f, 
    -0.10979751f, 0.00389418f, -0.04441132f, -0.26922113f, -0.33987981f, -0.00649831f, 0.02568699f, 0.42073643f, 
    0.16193351f, -0.35399407f, -0.22422026f, 0.18619910f, -0.18923455f, 0.04337050f, 0.10228451f, 0.03064798f, 
    -0.08009739f, -0.26445368f, 0.05049250f, 0.37353411f, -0.10731246f, -0.05927754f, -0.15176588f, 0.14300877f, 
    0.04301812f, 0.01239459f, -0.30661637f, 0.15580952f, 0.36092958f, 0.15393119f, -0.28634953f, -0.09828979f, 
    0.13123068f, 0.19791140f, -0.12629825f, -0.18210153f, 0.01802345f, -0.15393394f, -0.31850284f, 0.12449628f, 
    0.12798940f, -0.12851083f, -0.34982845f, 0.11795040f, 0.24484858f, -0.00463515f, -0.08546115f, -0.01775627f, 
    0.20689175f, 0.23124687f, 0.22956088f, 0.14230637f, -0.06855707f, -0.16005011f, 0.34290230f, -0.26238537f, 
    -0.09771091f, -0.20919883f, 0.15665869f, -0.05050533f, 0.04510960f, 0.09853298f, 0.04517047f, -0.37553769f, 
    -0.28858817f, -0.20945334f, 0.36742654f, 0.02592125f, -0.14769858f, 0.14433138f, -0.14276473f, -0.25478697f, 
    0.14489205f, -0.14500120f, -0.05014948f, -0.00330289f, 0.41863176f, 0.37888077f, -0.19140887f, 0.21559146f, 
    -0.07334776f, -0.01473816f, -0.04466541f, -0.17828405f, -0.16609526f, -0.11844197f, -0.27831191f, 0.08892572f, 
    -0.36221343f, -0.00483053f, 0.02027421f, -0.74877745f, -0.03315471f, 0.21242812f, -0.04712119f, -0.16156952f, 
    0.02502186f, -0.09818930f, 0.01962870f, -0.07572270f, -0.13824071f, -0.44140717f, 0.11100478f, -0.29972550f, 
    -0.19623902f, 0.08460210f, -0.11650301f, -0.07881609f, 0.08391396f, 0.09978626f, 0.00249862f, 0.02012457f, 
    -0.15162791f, -0.27860859f, 0.32530916f, -0.01852243f, -0.16284181f, -0.35945910f, -0.08387735f, -0.15564825f, 
    0.00872006f, -0.01562763f, -0.16513379f, -0.19039090f, -0.04525175f, 0.52952766f, -0.44644451f, -0.35260102f, 
    -0.02619163f, 0.24504095f, -0.18990806f, -0.17810656f, 0.17951305f, -0.07321935f, 0.24711004f, -0.04013046f, 
    -0.01323626f, 0.45086971f, -0.25856528f, -0.08404750f, -0.26444155f, -0.00708898f, 0.03729072f, -0.07428840f, 
    0.08482520f, 0.08316264f, -0.05740456f, 0.09300649f, -0.38957217f, -0.12714359f, -0.15886754f, -0.33316520f, 
    -0.31329262f, -0.04388333f, 0.17907944f, -0.35483950f, -0.08089879f, -0.02871257f, 0.01497514f, 0.25480610f, 
    0.24857643f, -0.12039257f, 0.16780378f, 0.27558780f, 0.17168322f, 0.16754401f, -0.01164117f, -0.08026701f, 
    -0.08119903f, 0.10981121f, 0.02667759f, -0.18284138f, 0.28665507f, -0.30970865f, 0.13079402f, -0.30112049f, 
    0.19165160f, -0.06440831f, 0.06821864f, -0.05635529f, 0.06397285f, -0.26371318f, 0.23693027f, 0.24697621f, 
    0.13938333f, -0.08393460f, 0.03269878f, 0.36175269f, 0.15854989f, 0.00064569f, -0.15992956f, -0.04521901f, 
    -0.05238039f, -0.05683116f, 0.19400281f, -0.18821432f, -0.12348438f, 0.14259893f, -0.30621335f, -0.13747694f, 
    0.24398635f, -0.14151515f, -0.27387094f, 0.16659626f, 0.13497624f, 0.06163895f, 0.07511683f, -0.18052794f, 
    -0.42615107f, 0.18053898f, -0.19267315f, 0.33454320f, -0.04925913f, 0.20157807f, -0.02294082f, 0.11679356f, 
    -0.02850271f, -0.04445355f, -0.01180111f, -0.22966990f, 0.54858267f, -0.00856455f, 0.40767303f, 0.01918201f, 
    0.11641359f, -0.03100098f, -0.24947101f, 0.01481407f, 0.06448533f, 0.13644297f, 0.04346205f, 0.01238474f, 
    0.20949024f, -0.19301704f, 0.18394478f, -0.42149308f, -0.03053129f, -0.07528405f, -0.21094817f, -0.05377448f, 
    0.00585764f, -0.19740112f, -0.12596937f, -0.28672525f, -0.16784027f, -0.16004568f, 0.14349169f, 0.15884478f, 
    0.11668767f, -0.25802433f, -0.14936820f, -0.03795667f, 0.10828722f, 0.15325022f, 0.07011719f, -0.00990983f, 
    -1.09940660f, -0.41051409f, 0.16777988f, -0.33605564f, 0.08431889f, 0.05989355f, 0.05780346f, 0.34784630f, 
    0.04933669f, -0.25488701f, 0.16007571f, 0.00314264f, 0.24602340f, -0.78380847f, 0.20346631f, 0.11905426f, 
    0.13026309f, 0.09709495f, 0.14606172f, 0.04969886f, 0.11551034f, -0.03067392f, 0.11065200f, 0.21064954f, 
    0.05636061f, -0.27739245f, -0.30808553f, 0.12263717f, 0.07795090f, 0.19207935f, -0.22883236f, 0.17608318f, 
    -0.16558200f, -0.21141645f, 0.20563278f, -0.03606068f, 0.25057861f, 0.01662659f, -0.32753181f, 0.52075458f, 
    0.00394856f, -0.17544919f, 0.02886333f, -0.07663807f, 0.09605289f, -0.10390927f, -0.03975249f, 0.04704193f, 
    0.94600898f, 0.32869816f, -0.26465699f, 0.24396369f, 0.15393214f, -0.12654637f, -0.02084468f, 0.09086872f, 
    -0.03010334f, -0.06211657f, 0.10407066f, 0.01231218f, -0.27712891f, 0.11153504f, 0.14404827f, 0.08244964f, 
    -0.15108669f, 0.09517954f, -0.19480711f, 0.06704989f, 0.00100663f, 0.01300535f, -0.23995823f, -0.19559419f, 
    -0.36939469f, 0.18297085f, 0.27689755f, 0.12046123f, 0.05414271f, 0.05519254f, -0.05108974f, 0.12914175f, 
    -0.10372292f, -0.04763017f, 0.00320717f, -0.07206158f, -0.01809482f, 0.25565800f, -0.01045395f, -0.15751036f, 
    -0.01879418f, 0.09821800f, 0.09891708f, 0.13613163f, 0.00627608f, 0.05173078f, 0.02938166f, -0.32916325f, 
    -0.45611957f, 0.65617907f, -0.40748486f, -0.21957991f, 0.16828382f, 0.25388557f, 0.07316659f, -0.18929178f, 
    -0.06981867f, -0.18494390f, 0.07387702f, -0.03817257f, -0.03985057f, 0.03994371f, -0.24597214f, -0.11298764f, 
    -0.00517645f, -0.08228967f, 0.16604999f, 0.02002774f, -0.09168650f, 0.38988283f, 0.02639948f, 0.14523266f, 
    -0.90354198f, 0.54910457f, -0.76769000f, -0.15106304f, -0.02341797f, -0.09763066f, 0.01677993f, -0.03426762f, 
    0.06348020f, 0.16694951f, -0.09677515f, -0.14614899f, -0.27069589f, -0.10035883f, 0.18868719f, -0.61650336f, 
    -0.14910249f, 0.09442078f, 0.10036473f, -0.26412547f, -0.05262715f, -0.12490217f, -0.01101833f, -0.04609551f, 
    0.72092247f, -0.07383959f, 0.03172840f, 0.01199797f, 0.08335912f, -0.21513908f, -0.03287062f, 0.35680157f, 
    0.10485248f, 0.27300650f, -0.03992452f, 0.14125673f, -1.53517067f, -0.56321740f, 0.04866283f, 0.16924031f, 
    0.20892210f, 0.05955879f, 0.25700486f, -0.36368236f, 0.13689783f, -0.08045778f, -0.15878928f, 0.26825246f, 
    -1.00619471f, 0.32750389f, -0.13034418f, -0.19226366f, 0.18177173f, 0.12628055f, -0.19078580f, 0.01325081f, 
    0.06133866f, 0.36209324f, 0.13065290f, 0.08839764f, 0.23915969f, -0.17072658f, -0.17612796f, -0.30316275f, 
    -0.23213139f, -0.13676809f, 0.03699015f, -0.20934117f, -0.28707066f, 0.12009592f, -0.09203425f, -0.03634984f, 
    0.03167039f, 0.11336249f, -0.02057766f, 0.24377941f, -0.41237229f, -0.11006673f, -0.10561071f, -0.10096008f, 
    -0.00288842f, 0.03787447f, -0.22241287f, -0.02563366f, -0.34566730f, -0.07856396f, -0.30881721f, -0.14676572f, 
    -0.00128645f, -0.06014542f, -0.19705483f, -0.01778493f, -0.14284772f, -0.24670261f, -0.21824282f, -0.13123479f, 
    0.08882175f, -0.11113032f, -0.01257423f, -0.09193655f, 0.24050806f, 0.28507569f, -0.02961628f, -0.20337974f, 
    0.09911709f, 0.15761100f, -0.16278312f, 0.10452192f, 0.14294147f, 0.24139297f, -0.25501356f, 0.01499932f, 
    0.23013146f, 0.05520913f, 0.24039687f, -0.01822478f, 0.28343481f, -0.13362440f, 0.09482323f, -0.07436220f, 
    0.27598926f, 0.16400006f, 0.13270672f, 0.03832121f, -0.18742795f, -0.18682911f, -0.07837467f, 0.13586280f, 
    -0.03035307f, 0.03558642f, -0.14669654f, -0.08281738f, -0.09828518f, 0.08925896f, -0.04397396f, -0.11988825f, 
    0.07677518f, 0.02004131f, -0.10260583f, 0.08759613f, -0.15299390f, -0.04417960f, 0.26441789f, 0.08657464f, 
    0.16175690f, -0.16580772f, 0.32612407f, 0.05410693f, -0.21407391f, -0.03924203f, -0.01845516f, 0.05270179f, 
    0.13545725f, 0.09668139f, -0.06753799f, -0.03957746f, 0.69535542f, 0.44229189f, -0.13667504f, -0.06794094f, 
    -0.16741739f, 0.09270564f, 0.07027410f, 0.02472101f, -0.00689992f, 0.08050273f, 0.38620421f, 0.17764877f, 
    -0.64840639f, -0.39661446f, -0.28063810f, -0.33183655f, 0.18798347f, -0.04763169f, 0.14035645f, 0.07524768f, 
    0.18121491f, 0.16776176f, -0.02552322f, 0.31745663f, -0.03418684f, 0.24303979f, 0.05026348f, -0.00260976f, 
    0.14234477f, 0.25251099f, 0.11938881f, 0.01241287f, 0.20882033f, 0.03347491f, 0.01685696f, 0.09311792f, 
    -1.25809467f, -0.60360920f, -0.45012349f, -0.57667536f, -0.13924642f, -0.09157924f, -0.23917300f, 0.07285898f, 
    0.00726579f, -0.07721484f, 0.04624127f, -0.16535404f, -0.03279828f, -0.05605678f, -0.31034940f, 0.13817821f, 
    0.25711897f, 0.18868299f, -0.11519633f, 0.00433442f, 0.17624997f, -0.05292762f, 0.02188335f, -0.11161593f, 
    -0.16184397f, -0.26516506f, 0.21791634f, 0.00237994f, 0.16183858f, 0.14616376f, 0.06894952f, 0.04445917f, 
    -0.11973439f, 0.07331308f, 0.04302249f, 0.14531423f, 0.82198310f, 0.20133434f, -0.07673649f, -0.09376994f, 
    0.18248418f, -0.14919792f, -0.18955575f, 0.00953652f, 0.06899799f, 0.04482468f, 0.20673184f, 0.03103765f, 
    0.93913621f, -0.01518883f, -0.31719539f, 0.12460372f, -0.10777306f, -0.16988216f, -0.08159307f, 0.01768682f, 
    -0.16290194f, -0.07367910f, 0.00766308f, 0.06398801f, -0.35283652f, 0.21558732f, 0.00721966f, 0.05224510f, 
    -0.23560511f, -0.02698084f, -0.08790333f, -0.32533383f, 0.11336433f, 0.13330512f, 0.21822688f, 0.02265979f, 
    0.21067622f, -0.05306674f, -0.20016818f, 0.06750877f, -0.29056194f, 0.05956288f, -0.16667880f, -0.26919460f, 
    -0.11596061f, -0.27365056f, -0.24232538f, 0.00801835f, -1.03568828f, -0.03676409f, -0.00214338f, -0.18985137f, 
    -0.06467254f, 0.10781858f, 0.19873239f, 0.33166671f, -0.12726928f, -0.03037656f, -0.15075180f, -0.24562204f, 
    0.22727992f, 0.04457197f, -0.39080670f, 0.39367199f, 0.00428331f, -0.30895033f, -0.25760034f, -0.15073887f, 
    -0.10853488f, 0.05934945f, -0.12152521f, -0.02555590f, 0.09226986f, -0.09578617f, 0.07853825f, 0.28822303f, 
    -0.29094169f, 0.11928700f, 0.11765953f, -0.00824906f, 0.08298112f, -0.15973327f, 0.05996888f, 0.13286474f, 
    -0.29217145f, -0.03195841f, 0.37886247f, -0.41591293f, 0.09645532f, -0.13105921f, -0.22763045f, 0.00061496f, 
    -0.14710154f, -0.03600663f, 0.18510300f, 0.06561697f, 0.18060710f, -0.25791323f, -0.46623859f, 0.11271509f, 
    0.18534946f, -0.01448736f, 0.07886206f, -0.30281699f, -0.09052953f, 0.25597301f, -0.15584178f, -0.07313531f, 
    0.03041902f, -0.22633234f, -0.07699554f, 0.16720223f, 0.18897797f, 0.10342433f, 0.12192224f, -0.09597848f, 
    -0.03171864f, -0.09780591f, -0.04693606f, -0.08274280f, -0.20852108f, 0.09457612f, -0.27178499f, 0.14455847f, 
    0.09638590f, 0.10649052f, 0.04231213f, -0.12793946f, -0.07662800f, -0.24733086f, 0.00173762f, -0.08711957f, 
    -0.14059129f, -0.32505733f, -0.30077934f, -0.02833720f, 0.15014680f, 0.01228726f, -0.00486904f, 0.09131543f, 
    -0.13841614f, 0.06077892f, -0.15705757f, -0.02077833f, -0.89968675f, 0.49009615f, -0.10701678f, 0.29956272f, 
    0.16950011f, -0.15987475f, -0.10918450f, 0.08848782f, 0.12344062f, 0.23294580f, 0.13659276f, -0.14624394f, 
    -0.18919459f, -0.14118101f, -0.27828324f, -0.13106464f, 0.36272454f, -0.03307587f, 0.02300112f, -0.05458977f, 
    0.10992189f, 0.06349653f, -0.09229241f, 0.11013452f, 0.52159905f, -0.15533015f, -0.33164683f, 0.42086661f, 
    0.12406696f, 0.20117250f, -0.12892668f, 0.07715821f, 0.23696959f, 0.03227987f, 0.00714425f, 0.12951411f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.12113997f, 0.09685066f, -0.11963552f, 0.04518957f, -0.00524225f, 0.01988001f, 0.03932892f, -0.16515645f, 
    -0.03247606f, -0.05516973f, 0.23344542f, -0.05471403f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
