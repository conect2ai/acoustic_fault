#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.52530354f, 1.32583427f, 1.19338012f, -0.50421435f, 0.71891046f, 0.58014196f, -0.26521572f, 0.45510414f, 
    0.05309614f, -1.23696864f, -0.36919436f, -0.13247944f, 0.53742206f, -0.25566140f, 0.88982159f, 0.28551307f, 
    -0.28739581f, -0.94281191f, -1.09169769f, 1.35874307f, -0.55724198f, 0.20039539f, -0.45950279f, -0.84321213f, 
    -0.07547415f, 0.02320431f, -0.08152764f, 0.96553051f, 0.78579360f, 1.09533989f, -0.50053930f, 0.67338091f, 
    0.14202827f, 0.08621410f, 0.46699581f, -0.17668349f, 1.49735820f, -0.52224368f, 1.22683322f, 0.65903229f, 
    0.19467783f, 0.74049592f, 0.18616524f, 0.08484146f, -0.05950748f, -1.58243501f, 0.43298405f, 0.11533225f, 
    0.77338541f, 0.99137431f, 0.15661108f, 0.31390956f, -0.06126981f, -0.26619926f, -0.74691808f, -0.41791388f, 
    -0.16437373f, 1.08027399f, -1.15352201f, -0.36180285f, -0.41454127f, 0.35907543f, -0.01256867f, -0.26973441f, 
    -0.66057783f, 0.23119314f, 1.18188393f, 0.55469954f, 1.05576742f, 0.35626248f, -0.00148880f, 0.83515000f, 
    -1.57134199f, -1.31820309f, -1.29658794f, -0.04932735f, -0.52272958f, -0.33976954f, -0.09987061f, 0.07096220f, 
    0.01710757f, 0.87807971f, 1.05879688f, 0.57241541f, -0.37499690f, 0.68814373f, -0.43993151f, 0.28320754f, 
    0.10131168f, 0.76830643f, -0.73184115f, -1.01492035f, -0.70420921f, -0.43046319f, 1.29904068f, 1.12176764f, 
    -0.21880002f, -0.12010443f, 0.06144422f, 1.18233204f, -0.35185459f, 0.13921791f, 1.00180686f, 0.57252467f, 
    0.25531831f, -0.65999657f, -0.17112130f, -0.42616525f, 0.75179523f, -0.55281663f, 0.00784926f, -1.44782031f, 
    0.48204228f, -1.07201946f, -0.38507542f, 0.45612949f, -0.14198875f, 1.06537223f, 0.88692087f, 0.39972338f, 
    -1.01590788f, -1.39109051f, -0.23010895f, 0.49591646f, 0.36614084f, -0.13383065f, 0.49650759f, 0.28867283f, 
    1.42056286f, -0.44764891f, -0.24899751f, -1.01915908f, -0.43078902f, -0.41088223f, -0.19567621f, -0.45174062f, 
    0.27730826f, 0.64854449f, 0.61808378f, 0.65420073f, 0.28505620f, -0.61281860f, -0.54032773f, 0.10693946f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.19834793f, 0.24309216f, 0.05603021f, 0.79311341f, 0.10556938f, -0.21052775f, -0.29430354f, 0.66650403f, 
    -0.03081591f, -0.07499590f, 0.11860789f, 0.34390444f, 0.46317217f, 0.34789127f, 0.16241576f, -0.20836289f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.22555724f, -0.07282288f, -0.06983369f, -0.17848986f, -0.19636203f, -0.20069563f, 0.23552857f, 0.03846320f, 
    0.18354131f, -0.07546128f, 0.01278347f, -0.28530052f, -0.21416128f, 0.09411713f, -0.01744947f, 0.18541977f, 
    -0.09279598f, 0.00083817f, -0.68178952f, -0.62697113f, -0.06137112f, 0.29163638f, 0.04420258f, -0.18620127f, 
    -0.09239805f, 0.02297653f, -0.04887137f, 0.26136386f, 0.27672264f, 0.52489853f, 0.05598580f, -0.26141322f, 
    -0.06134104f, -0.03431764f, 0.25901076f, -0.10849631f, 0.48035693f, -0.15790194f, 0.25708407f, -0.38062003f, 
    -0.08725291f, -0.04552125f, 0.08289030f, 0.03232623f, 0.12141223f, -0.50098807f, -0.47208875f, 0.20748818f, 
    -0.10439319f, 0.03612090f, -0.31562284f, -0.20744428f, -0.15594421f, -0.02470616f, -0.74811423f, -0.39006299f, 
    -0.17688447f, 0.23312750f, 0.05109041f, -0.13109972f, -0.01507432f, -0.00976264f, 0.03050750f, -0.09580436f, 
    0.00518252f, 0.24701238f, 0.21733740f, 0.25064829f, 0.02606364f, 0.24548484f, -0.29180828f, -0.15606716f, 
    -0.27809101f, 0.13046338f, -0.35255966f, 0.10554296f, 0.09653584f, 0.00370293f, 0.04998557f, 0.25051460f, 
    -0.28351304f, 0.58591902f, 0.31823283f, 0.17050588f, -0.07347465f, -0.24219221f, -0.14887545f, -0.03558361f, 
    0.10939816f, -0.05158941f, 0.03142457f, -0.40691635f, -1.31022513f, 0.30453339f, 0.38105521f, 0.23068248f, 
    -0.12935351f, -0.23919010f, -0.18536438f, -0.02843176f, 0.03925438f, 0.17012845f, -0.02826790f, -0.18709895f, 
    -0.14591327f, 0.26706746f, 0.18518388f, 0.22120713f, 0.05983422f, -0.20779878f, -0.05923848f, -0.06289979f, 
    0.55127156f, 0.26664445f, 0.10341217f, -0.06293850f, -0.00661849f, 0.51961720f, 0.54749340f, 0.05202081f, 
    -0.06407697f, -0.31690562f, 0.28720838f, 0.17729312f, 0.19939616f, 0.15872769f, 0.16719425f, 0.03477105f, 
    0.13782381f, 0.10524548f, 0.11177719f, 0.26480627f, -0.09425855f, 0.26604283f, 0.18902597f, 0.13526876f, 
    0.01394188f, 0.17364681f, 0.16143079f, -0.05344089f, -0.11711778f, 0.25861838f, -0.16692910f, -0.05556161f, 
    -0.02036544f, -0.05276710f, -0.01838376f, -0.05689236f, 0.06399123f, -0.07393173f, -0.03557581f, -0.06968333f, 
    -0.03522204f, 0.04991153f, -0.08545632f, -0.07598004f, 0.00662588f, -0.03157752f, -0.01006522f, -0.03200962f, 
    0.06515083f, -0.01580592f, -0.03454766f, -0.05218660f, 0.00482511f, 0.03610798f, 0.07287160f, 0.00380069f, 
    -0.04867737f, 0.05706296f, -0.04981684f, -0.08731700f, -0.09076051f, -0.07021779f, 0.00144565f, -0.05894306f, 
    -0.05948849f, -0.05308912f, -0.04029244f, 0.06032908f, -0.00730377f, -0.04226527f, -0.04151152f, 0.02676954f, 
    0.04211168f, -0.04094338f, -0.09839649f, -0.06175118f, 0.03713701f, 0.06430997f, -0.08356377f, -0.02743899f, 
    0.02063932f, 0.03526247f, -0.03619564f, 0.02730454f, 0.04920605f, -0.00997064f, 0.04517635f, -0.03555743f, 
    0.00706932f, -0.04318881f, -0.03123897f, -0.07514697f, -0.08471311f, -0.06284358f, -0.00200054f, 0.02253084f, 
    0.05890223f, -0.09804501f, 0.02041318f, -0.10018785f, -0.08414958f, -0.05895694f, -0.03000394f, -0.07830183f, 
    -0.02438187f, -0.07957786f, 0.00341055f, 0.00966933f, 0.02314515f, -0.08730505f, -0.06918084f, -0.09427612f, 
    -0.07406256f, 0.06400943f, -0.09508965f, 0.04903122f, -0.09105815f, 0.02541818f, -0.01670959f, -0.03755074f, 
    -0.05476103f, 0.02078822f, -0.03769030f, 0.06444738f, 0.06108489f, -0.01402404f, -0.07979528f, -0.07584713f, 
    0.00772682f, 0.01297485f, -0.04074156f, 0.00265098f, 0.00989398f, 0.02656526f, 0.04040945f, -0.06035711f, 
    -0.01977777f, -0.00283580f, -0.08635686f, -0.00105925f, -0.07563134f, -0.05958574f, -0.06201611f, 0.02885583f, 
    -0.04488195f, -0.09615936f, 0.02445878f, -0.05353526f, -0.09701424f, -0.10062810f, -0.02802082f, 0.03013190f, 
    0.04576531f, 0.00293962f, -0.01652452f, 0.01611827f, -0.01702031f, -0.04094732f, 0.00429394f, 0.06284382f, 
    -0.05981606f, 0.06214304f, 0.06135234f, -0.00374181f, -0.06136829f, -0.05997959f, -0.00820919f, -0.00755305f, 
    -0.08348118f, 0.05415877f, 0.04939355f, -0.03421817f, -0.02413780f, -0.05195890f, -0.01685020f, 0.00137384f, 
    -0.65349281f, 0.43387502f, 0.21187174f, 0.12444205f, -0.21552837f, -0.18728101f, 0.10637657f, -0.00525639f, 
    -0.07861519f, -0.01700242f, -0.41750067f, 0.26745012f, 0.01071546f, 0.19553995f, 0.10614810f, -0.01771048f, 
    0.09618260f, 0.00991800f, -0.28147879f, -0.06334916f, -0.16120513f, 0.12021489f, -0.14170873f, -0.05891471f, 
    -0.05513609f, -0.15935178f, -0.04042422f, -0.11921101f, 0.33479244f, -0.05987666f, 0.23548570f, 0.06158881f, 
    -0.08264344f, 0.11447213f, 0.11096311f, 0.05707651f, 0.05440219f, -0.05427955f, -0.04144279f, 0.16364962f, 
    0.29149839f, -0.04019189f, -0.02252846f, 0.12269471f, -0.04177393f, -0.16261344f, -0.09821131f, 0.00680507f, 
    0.13406277f, -0.39136428f, 0.06583471f, -0.01964678f, -0.02661836f, 0.05997305f, -0.81859565f, -0.44693029f, 
    -0.23394185f, -0.06095180f, -0.04967348f, -0.02160596f, 0.11549586f, 0.06244097f, 0.05425429f, 0.05588359f, 
    -0.17078903f, 0.32791081f, -0.09893769f, 0.07281224f, -0.01956783f, 0.05970268f, -0.20241357f, 0.04538177f, 
    -0.21388620f, -0.23504421f, 0.75456619f, 0.22801988f, 0.06975170f, -0.12027955f, 0.00137587f, 0.06955875f, 
    0.14713912f, -0.18327293f, -0.05718287f, -0.36721370f, 0.11129651f, -0.18382657f, 0.02312128f, -0.17462054f, 
    -0.12012292f, 0.01551101f, -0.11233089f, -0.41332158f, 0.25761223f, -0.10376503f, 0.01205824f, 0.17429428f, 
    -0.01510862f, -0.01277187f, 0.01779537f, 0.56893510f, 0.08135330f, 0.35313478f, 0.07319655f, -0.08040858f, 
    0.01987075f, -0.06994540f, 0.14118125f, 0.23473606f, -0.23129682f, 0.43886408f, -0.27156976f, -0.13860562f, 
    0.17877875f, 0.06271912f, -0.01685508f, -0.02343385f, -0.03579134f, -0.16642503f, 0.23924796f, -0.18735301f, 
    -0.06772784f, 0.02453349f, -0.25185722f, -0.10676047f, 0.23393036f, -0.15800957f, -0.22573443f, 0.15077315f, 
    -0.55779713f, 0.23099186f, 0.01007081f, 0.01520246f, -0.03138430f, 0.12850443f, 0.12549075f, 0.08996138f, 
    -0.14038159f, -0.17746335f, 0.08248305f, -0.11682982f, -0.01196660f, 0.12219972f, -0.04841955f, 0.22616065f, 
    -0.69056839f, 0.28260925f, 0.07862228f, -0.05341636f, -0.02226528f, 0.13839498f, -0.02041515f, -0.13969494f, 
    0.10466047f, -0.23493844f, 0.38434979f, -0.36098254f, 0.15466560f, 0.01192189f, 0.11675598f, -0.02400706f, 
    0.15662305f, 0.16412731f, 0.13379812f, -0.63389361f, -0.31725219f, 0.10856416f, 0.03252428f, 0.02956962f, 
    0.19016182f, 0.10767548f, -0.35436460f, 0.06990226f, 0.27527410f, -0.36555400f, -0.27932474f, -0.22540954f, 
    -0.08937763f, -0.05130244f, 0.05249020f, -0.12154391f, 0.14581297f, -0.15141933f, -0.05646466f, -0.01109481f, 
    0.00522038f, 0.03853420f, -0.15683945f, -0.01375391f, 0.07282105f, 0.67117679f, 0.09617224f, 0.57205456f, 
    -0.18279633f, -0.07969324f, 0.03572354f, 0.03370646f, -0.20264454f, 0.08744465f, -0.58490396f, -0.28304794f, 
    -0.48387328f, 0.12860784f, 0.05851959f, 0.05178848f, -0.26523563f, -0.07374552f, 0.04718436f, -0.28445294f, 
    0.42765498f, -0.18868102f, 0.17077075f, 0.37831768f, -0.09906857f, -0.04503223f, 0.10278323f, -0.04944456f, 
    -0.07516362f, 0.55776995f, -0.05590333f, -0.27422056f, -0.04494738f, 0.10947530f, 0.16350642f, 0.02614849f, 
    -0.04265303f, 0.25657427f, 0.12217181f, -0.17048769f, -0.17970911f, -0.11165570f, 0.04225239f, -0.06993330f, 
    0.06718405f, -0.20195125f, -0.13877264f, 0.45879725f, -0.54001671f, 0.03130545f, -0.03260974f, -0.00247388f, 
    0.04782048f, 0.10751949f, 0.07175004f, 0.76129764f, 0.00790176f, 0.05117862f, -0.22895062f, 0.02526551f, 
    0.04916717f, -0.01076835f, 0.22710241f, 0.07216443f, 0.32958111f, -0.39475054f, -0.00471179f, 0.02125187f, 
    0.08728250f, 0.10505673f, 0.09094425f, 0.01022807f, -0.16111371f, 0.03480295f, -0.10433529f, 0.21761493f, 
    -0.02201799f, -0.32258880f, -0.10232069f, 0.02435584f, 0.00206239f, 0.16493511f, -0.03635827f, -0.31123099f, 
    -0.01883958f, 0.02759851f, -0.13619882f, -0.09491474f, -0.01342177f, 0.14393543f, 0.06647136f, -0.03705203f, 
    0.35903969f, 0.39700469f, -0.18298322f, -0.26508847f, -0.08288465f, 0.27800375f, 0.11556882f, -0.00547286f, 
    -0.03795738f, 0.03416598f, -0.04628459f, -0.07244778f, -0.05743838f, -0.03366786f, -0.07701235f, 0.03623434f, 
    -0.08270270f, 0.01450539f, -0.08841103f, -0.06810521f, -0.01311749f, 0.00986288f, -0.03920183f, -0.07939175f, 
    -0.03272196f, 0.06073104f, -0.03145759f, 0.02299951f, -0.05795643f, 0.05495575f, 0.04262740f, -0.02260847f, 
    -0.07321833f, 0.06065623f, -0.07405651f, -0.00972731f, -0.07291600f, 0.04143196f, -0.01540876f, 0.02507439f, 
    -0.07787443f, 0.05168228f, -0.03152500f, -0.01945384f, -0.05792248f, 0.04623037f, -0.04731622f, 0.04554143f, 
    0.07173103f, -0.07002919f, -0.02626351f, -0.04396434f, -0.05835278f, -0.03165885f, 0.03508846f, 0.04877356f, 
    0.00051546f, 0.04836855f, -0.05183614f, -0.06521479f, 0.01444371f, 0.02889180f, -0.07603717f, -0.05527297f, 
    0.05812036f, -0.01095590f, -0.08851523f, -0.06729724f, -0.02451301f, -0.00301885f, -0.07021379f, -0.08769690f, 
    0.02619792f, 0.05966739f, 0.07527240f, -0.08144876f, 0.06387741f, 0.03273985f, -0.02098335f, 0.00084565f, 
    -0.03626761f, 0.06281684f, 0.03325448f, 0.03386243f, -0.02642888f, -0.05701904f, 0.06624451f, -0.03091454f, 
    0.02677103f, -0.07619408f, -0.05154710f, 0.00279757f, 0.06073778f, -0.05989889f, 0.00018705f, 0.03330756f, 
    0.01599824f, -0.06174341f, 0.04378602f, -0.02115503f, -0.02092555f, 0.02314615f, 0.00574451f, -0.03943241f, 
    0.00640539f, 0.01157579f, -0.00949615f, 0.05491569f, 0.00427492f, -0.04272005f, -0.03005992f, 0.07162099f, 
    -0.07217839f, 0.01233141f, -0.01986391f, 0.05300379f, -0.00485759f, 0.06129598f, -0.06704081f, -0.07501156f, 
    -0.01067272f, -0.04925743f, -0.01327460f, 0.02356240f, -0.04862106f, -0.02030017f, 0.02044843f, -0.04533892f, 
    0.06351200f, -0.07058382f, 0.06304394f, -0.01880379f, -0.01495678f, 0.04022046f, -0.08487243f, -0.02189278f, 
    -0.04521926f, 0.07662014f, -0.00224929f, -0.02056934f, 0.03106717f, 0.06367525f, -0.00637910f, -0.05093208f, 
    0.04568186f, -0.08558434f, 0.07060298f, -0.06645552f, 0.00634408f, 0.01595214f, 0.01191833f, -0.03845628f, 
    0.31464505f, 0.07990423f, -0.17677854f, -0.06079663f, 0.01102507f, -0.10181762f, 0.02159672f, 0.02103336f, 
    0.08212788f, -0.50549585f, 0.18897425f, -0.29838532f, -0.13865608f, 0.24318866f, 0.02438747f, -0.23315407f, 
    0.20217599f, -0.09209126f, -0.10517120f, -0.33394304f, 0.12826662f, -0.18635778f, 0.09279817f, -0.13763757f, 
    0.04146934f, -0.21137689f, 0.13787502f, 0.79057324f, -0.01268813f, 0.18686339f, -0.07428516f, -0.04810494f, 
    0.02061143f, -0.04155007f, 0.08034318f, 0.11024087f, -0.28476754f, -0.45357439f, 0.18769936f, 0.22516571f, 
    -0.03973205f, 0.07164524f, 0.12611125f, 0.32181436f, -0.11205495f, -0.41773465f, -0.12784679f, 0.21768032f, 
    0.02420923f, 0.01131321f, 0.08764810f, -0.25435299f, 0.29925448f, 0.03797712f, -0.00625942f, -0.22078724f, 
    -0.24094893f, 0.10049297f, 0.13451274f, 0.17136553f, 0.12208559f, 0.01229219f, -0.04580684f, -0.33671343f, 
    -0.23329119f, 0.12880632f, 0.02056528f, 0.26940560f, 0.12484074f, 0.07912853f, -0.20222424f, -0.07507181f, 
    -0.00033046f, 0.36435381f, -0.19387978f, -0.34275255f, 0.13080806f, -0.09000161f, 0.01974113f, -0.02440480f, 
    0.12995197f, 0.64521807f, 0.09318826f, 0.04082893f, 0.25982732f, 0.19411132f, -0.04613706f, 0.15502298f, 
    0.00908748f, -0.07686079f, -0.62954462f, 0.34182924f, -0.28092140f, -0.03194994f, 0.02030316f, -0.08626769f, 
    -0.14892237f, 0.14409329f, 0.05285938f, -0.44116369f, -0.33277023f, 0.10949714f, 0.16412489f, 0.14289758f, 
    0.22409144f, -0.01209098f, 0.00237529f, -0.08717395f, -0.01903417f, 0.29455605f, -0.40797809f, 0.09841085f, 
    -0.28526008f, -0.21366246f, -0.20394114f, -0.03120693f, -0.14537825f, 0.96238434f, -0.06098223f, -0.23688526f, 
    0.13719983f, -0.16082594f, -0.03584635f, 0.09565008f, 0.20447327f, 0.01022068f, 0.39512363f, 0.15773992f, 
    -0.10363234f, -0.08614597f, 0.22663052f, -0.17182970f, 0.06165028f, 0.05053868f, 0.16547145f, -0.73548615f, 
    -0.08040174f, 0.28171819f, -0.09313440f, 0.17602299f, -0.00354265f, -0.23408018f, -0.04851498f, -0.06167088f, 
    -0.11844365f, 0.02394076f, -0.07061674f, 0.00014428f, -0.01270882f, 0.05985957f, -0.01927680f, -0.00761657f, 
    -0.10311700f, -0.08538667f, -0.03006528f, -0.10698280f, -0.02006895f, -0.05990077f, 0.00767858f, -0.07815864f, 
    -0.08864330f, 0.00910671f, 0.02398207f, -0.06191579f, 0.01563705f, 0.00696326f, 0.00611284f, -0.05719755f, 
    0.05739368f, -0.05186504f, -0.03696923f, -0.09639627f, 0.03169311f, -0.02655016f, -0.00463316f, 0.00575054f, 
    -0.06727805f, -0.01201984f, -0.05857683f, -0.04276457f, 0.03596932f, -0.03363106f, 0.03663257f, -0.00498866f, 
    -0.06189855f, 0.05434893f, -0.05134541f, -0.00862061f, -0.02089548f, -0.01180594f, -0.01354162f, -0.02926724f, 
    -0.09614559f, 0.02645246f, -0.05108457f, -0.00978599f, -0.08271419f, 0.01752172f, -0.04174281f, 0.01068708f, 
    -0.10376932f, -0.08560266f, -0.05517596f, -0.04657491f, 0.01148038f, -0.09640812f, 0.04781308f, 0.01903124f, 
    0.03555711f, 0.02420180f, 0.02739088f, -0.09218234f, 0.00054355f, 0.01523213f, -0.01341179f, 0.00227058f, 
    0.04508432f, -0.09543788f, 0.02208134f, -0.06734272f, 0.05461165f, -0.05925784f, -0.06619846f, -0.01996139f, 
    -0.07136898f, -0.00870276f, -0.06902353f, 0.04194026f, -0.01745391f, 0.05427510f, 0.00924813f, 0.04014525f, 
    0.02189544f, -0.06894871f, -0.06070193f, 0.03036585f, -0.04672949f, -0.08282319f, -0.07831158f, -0.09143554f, 
    -0.05481618f, -0.00529790f, -0.08592719f, -0.07496858f, -0.01404730f, -0.06584685f, -0.01054571f, -0.05713754f, 
    0.00882468f, -0.07680892f, 0.05612205f, -0.10758299f, -0.07825924f, -0.05258460f, -0.04460837f, -0.09315666f, 
    -0.09298220f, -0.08548591f, 0.06839956f, -0.09258355f, 0.05371534f, -0.03626461f, -0.08765931f, 0.02874638f, 
    -0.00051332f, 0.01799034f, 0.01508062f, 0.02863394f, -0.01489925f, -0.07402585f, -0.10950145f, 0.00690917f, 
    -0.02407150f, -0.03192199f, -0.03316930f, -0.03438726f, -0.05861483f, 0.02631449f, -0.10452863f, -0.03250786f, 
    -0.10034120f, -0.00928685f, -0.03436378f, -0.06368607f, 0.06146000f, 0.02979513f, -0.01678707f, 0.03020159f, 
    -0.24751174f, 0.30160761f, -0.20342575f, 0.11210402f, -0.18748604f, -0.02948295f, -0.06178459f, 0.01730782f, 
    0.05871481f, 0.29657793f, 0.05700672f, 0.43438551f, 0.21438409f, 0.06758303f, 0.00520041f, 0.04450366f, 
    0.04096481f, 0.13829619f, -0.13707680f, -0.20383509f, 0.00424219f, 0.12976271f, 0.25052392f, -0.16377805f, 
    0.00988761f, 0.06251439f, -0.29370588f, -0.26627821f, -0.04535959f, 0.02070140f, -0.05716106f, -0.00138080f, 
    -0.02635745f, 0.09874162f, -0.25367320f, 0.08488756f, 0.32449463f, 0.25230652f, 0.10184614f, 0.03584775f, 
    -0.03651157f, -0.26278070f, 0.12121835f, -0.00614502f, 0.12586074f, 0.23793006f, 0.14900473f, 0.25071409f, 
    0.15909456f, 0.01105508f, 0.33328465f, -0.15942244f, 0.18402219f, 0.24508430f, 0.36608338f, 0.01638336f, 
    -0.12610754f, -0.03438358f, 0.02657414f, 0.16567449f, -0.15573777f, 0.27947661f, -0.11889975f, -0.09960849f, 
    -0.05928619f, 0.11556505f, -0.00946956f, 0.18047518f, 0.06100541f, 0.34154928f, -0.05510560f, 0.10165611f, 
    0.34287876f, 0.83998960f, 0.22720578f, 0.09293407f, -0.05622603f, 0.05757817f, 0.06144801f, 0.13293563f, 
    0.00071579f, -0.30090624f, -0.34089410f, 0.05189579f, -0.06693080f, 0.06018423f, 0.03238171f, 0.04310465f, 
    -0.02382446f, 0.08031879f, 0.16006722f, 0.26510319f, 0.15466839f, 0.32764548f, -0.08517194f, -0.33057651f, 
    0.07670124f, 0.09975655f, -0.15367129f, -0.29406711f, -0.10469652f, -0.08326776f, 0.12653869f, 0.17788190f, 
    -0.13639732f, -0.01625654f, -0.20191263f, 0.07193711f, -0.53829765f, -0.43479756f, 0.13689227f, 0.10070801f, 
    -0.02501852f, -0.04554132f, -0.28680336f, -0.30547482f, -0.17463008f, 0.05757938f, -0.25100738f, -0.23531961f, 
    -0.21605913f, -0.22550140f, -0.07058865f, -0.02027151f, 0.02009785f, -0.15340905f, -0.43078616f, -0.06304052f, 
    -0.10271057f, -0.22501761f, -0.12102452f, 0.14365421f, -0.33950257f, 0.03234055f, 0.15105759f, 0.05976263f, 
    -0.07942068f, -0.03001610f, -0.03531168f, 0.00483723f, 0.05418257f, 0.17559040f, 0.09887979f, -0.07175752f, 
    -0.06306332f, -0.01251056f, 0.07238448f, -0.03377172f, -0.03585691f, -0.05000445f, -0.02783109f, 0.04481393f, 
    -0.04766382f, -0.05728100f, 0.06264540f, 0.01301910f, 0.02796292f, 0.01828222f, -0.07000937f, -0.07467903f, 
    0.04842618f, -0.04933633f, 0.06867498f, -0.02243836f, -0.03730036f, -0.03287446f, -0.02756506f, -0.04480618f, 
    0.03059341f, -0.05518674f, 0.02577553f, -0.03736782f, -0.07991779f, -0.00831910f, -0.09162471f, -0.06063339f, 
    0.04236284f, -0.09962796f, -0.00406217f, 0.03113659f, -0.03995157f, -0.07127018f, 0.03939424f, 0.00328243f, 
    -0.03557544f, 0.04176447f, 0.01146081f, -0.05187926f, 0.03382757f, 0.00915214f, 0.03848629f, -0.10191789f, 
    0.02546188f, 0.00360176f, 0.02630047f, 0.05159000f, 0.01126017f, -0.00232936f, -0.05587872f, -0.01746402f, 
    0.02814591f, -0.05184804f, 0.04178458f, -0.04302505f, -0.07826267f, -0.02962478f, 0.06835078f, 0.02750078f, 
    -0.05560170f, -0.05481234f, -0.07778098f, -0.03464279f, -0.01619603f, -0.01413773f, -0.09188063f, -0.06495643f, 
    0.01649641f, -0.05080663f, -0.06514683f, -0.06498977f, 0.02496344f, 0.00497324f, -0.06653356f, 0.04979974f, 
    -0.06889115f, -0.00579712f, 0.02907792f, -0.04079087f, -0.02917227f, -0.02876182f, -0.07381598f, 0.03155125f, 
    0.03575051f, 0.06391143f, 0.02995955f, -0.07475524f, 0.07266996f, -0.03586219f, 0.00599880f, -0.06403283f, 
    -0.02757349f, 0.04883894f, -0.00280449f, -0.02190250f, 0.02495905f, -0.03274208f, -0.04624988f, -0.04086499f, 
    -0.05179644f, 0.03731913f, -0.00851822f, -0.05595748f, 0.05234933f, -0.01368403f, -0.07358206f, 0.01767921f, 
    0.01905137f, 0.03453404f, 0.02491847f, 0.04439690f, -0.00552753f, 0.01737829f, -0.02589088f, 0.04442172f, 
    0.03764475f, 0.04671685f, 0.03213155f, 0.01084066f, -0.03558537f, 0.06160123f, -0.06125966f, -0.03151894f, 
    0.06212868f, -0.01899845f, -0.04501526f, 0.03815519f, -0.02604560f, -0.02931360f, 0.02181821f, -0.02289879f, 
    0.01659605f, 0.01770939f, -0.00743876f, 0.00835887f, 0.01930288f, 0.06041192f, 0.01314109f, 0.03872785f, 
    0.22172154f, -0.14975487f, -0.36663738f, -0.05315113f, 0.00943685f, 0.08003769f, 0.19494830f, -0.05607839f, 
    0.18480547f, -0.17574286f, -0.01601865f, 0.19200881f, 0.18320651f, -0.02356168f, -0.23782790f, 0.23818864f, 
    -0.02815939f, -0.03935383f, -0.29322618f, -0.60986060f, -0.95608646f, 0.03834266f, 0.05727841f, -0.11967151f, 
    -0.01289592f, -0.00628043f, -0.05326477f, -0.18147457f, 0.16638409f, 0.16520539f, 0.22577626f, 0.09858725f, 
    0.23572814f, 0.11811101f, 0.03106270f, -0.04573048f, -1.29329050f, -0.00001531f, -0.08913492f, 0.21231142f, 
    -0.07055748f, -0.19957820f, 0.23660511f, 0.08084658f, 0.18122211f, 0.57590622f, -0.15183905f, -0.12628700f, 
    -0.16997863f, -0.03548736f, 0.01124556f, -0.07326249f, 0.10942872f, 0.03346049f, -0.07634544f, -0.29357681f, 
    -0.02374414f, -0.27122161f, -0.27548099f, -0.02629304f, 0.22472352f, -0.07232089f, 0.15905395f, 0.64323974f, 
    0.58092016f, 0.37682405f, -0.23392850f, -0.12641597f, 0.02984808f, 0.13930225f, -0.23182240f, 0.12829521f, 
    -0.18095700f, -0.06085628f, 0.28722832f, 0.02894650f, 0.01495796f, 0.14748813f, -0.01372032f, 0.15702586f, 
    0.19567403f, -0.03362294f, 0.08020757f, 0.02249995f, 0.34620085f, -0.02391204f, 0.02992507f, -0.24330096f, 
    -0.07981225f, 0.19959837f, 0.41385409f, 0.01811464f, -0.16953970f, -0.04890108f, 0.21929690f, -0.18963087f, 
    0.00815374f, -0.01944062f, 0.05711890f, 0.03205580f, 0.07811003f, 0.19248198f, 0.02096523f, -0.27711219f, 
    -0.21361238f, -0.03419987f, -0.02972602f, 0.27688980f, -0.17449577f, 0.53960031f, -0.36232400f, 0.24897400f, 
    0.19927227f, 0.30302048f, -0.23757319f, 0.04766232f, -0.18549426f, -0.32405928f, 0.19967683f, -0.20071025f, 
    0.05024048f, -0.04443470f, 0.18538409f, 0.03191734f, 0.10218671f, -0.01153627f, -0.56923151f, 0.11700786f, 
    -0.59345007f, 0.11063609f, 0.17019151f, 0.17182702f, -0.22896999f, -0.08695415f, 0.06324217f, 0.31717622f, 
    0.23117398f, 0.24032216f, -0.07299629f, -0.30306658f, -0.21913661f, 0.11824363f, 0.27789271f, 0.17856170f, 
    -0.01633391f, 0.06866946f, -0.04823079f, -0.02107830f, -0.01098275f, -0.04689428f, -0.06108776f, -0.04320060f, 
    -0.05806672f, 0.00189543f, 0.00306335f, -0.00603315f, 0.04186459f, -0.05753972f, -0.07682501f, -0.07311965f, 
    -0.05875426f, -0.03422488f, -0.07305162f, -0.00182892f, 0.00413087f, -0.06967249f, 0.04905180f, -0.06418015f, 
    0.06541791f, -0.07833070f, -0.08054698f, 0.05201700f, -0.00157411f, -0.09816156f, 0.04832858f, -0.02837452f, 
    -0.06257167f, 0.03026238f, 0.06878624f, -0.04914469f, -0.00397256f, -0.01521218f, -0.02824040f, -0.02196665f, 
    0.04679016f, 0.05242824f, 0.06435344f, -0.08110706f, 0.01222170f, -0.05941847f, -0.00655704f, 0.05821793f, 
    0.02103749f, -0.08882449f, 0.03508569f, -0.05804161f, -0.08085764f, -0.01524445f, -0.01379536f, 0.07406333f, 
    -0.07591780f, -0.06657869f, 0.05717192f, -0.06185302f, 0.02743244f, 0.05493216f, -0.08942943f, 0.06288218f, 
    -0.04169944f, -0.05328210f, -0.07873055f, 0.04777662f, 0.00627687f, -0.07367650f, -0.07166643f, 0.03542294f, 
    -0.06615048f, -0.06427518f, 0.01428133f, 0.06092717f, 0.05875035f, -0.03026725f, -0.03440964f, -0.08183269f, 
    0.02175492f, 0.03609890f, -0.02699912f, 0.06099539f, -0.02490613f, 0.07681790f, -0.05461886f, -0.09013733f, 
    0.03942320f, 0.03650689f, 0.04837665f, 0.06153076f, -0.04570492f, 0.03664518f, 0.05963677f, 0.07331093f, 
    0.02856495f, -0.04543833f, 0.02240797f, -0.05883111f, -0.04263390f, 0.00293074f, 0.01681169f, 0.00164155f, 
    -0.02938171f, -0.01784949f, -0.02233754f, -0.00918309f, 0.00525989f, -0.08899810f, -0.00003747f, 0.03854101f, 
    -0.02934828f, -0.06824528f, -0.00837809f, 0.00454818f, -0.07695931f, 0.05539351f, 0.04207218f, 0.01293728f, 
    0.05619508f, -0.08636276f, -0.05950376f, -0.02869815f, 0.01189726f, 0.04818741f, -0.06725280f, 0.05344129f, 
    0.03202550f, 0.00696736f, 0.06868560f, 0.03540177f, -0.08602602f, -0.03150667f, -0.01445875f, -0.03430852f, 
    -0.01510344f, -0.02508764f, -0.05253160f, 0.05093730f, 0.06099640f, 0.04016113f, -0.05701855f, -0.05593419f, 
    0.01286822f, -0.08621503f, 0.06222077f, -0.03461528f, -0.07543711f, -0.02131933f, 0.00479635f, 0.01539688f, 
    -0.04195867f, -0.01398620f, 0.06263666f, -0.03212138f, -0.02562013f, 0.07174492f, -0.05772199f, 0.00975324f, 
    0.01352006f, -0.05410799f, -0.08206643f, 0.02348748f, 0.06878324f, -0.03765301f, -0.02513159f, 0.06013316f, 
    0.03550031f, -0.06185347f, 0.05807936f, -0.06209176f, 0.02436334f, -0.03909182f, -0.04346307f, -0.03084039f, 
    -0.09447902f, -0.07709275f, -0.00368719f, -0.06693915f, -0.07543813f, 0.00563281f, 0.01217455f, -0.09224176f, 
    -0.01151560f, 0.02274730f, 0.00630528f, 0.00180472f, 0.02657953f, 0.04698381f, -0.09618203f, 0.05043239f, 
    0.00203460f, 0.07198257f, -0.02481632f, 0.01355045f, -0.08473859f, -0.05354987f, 0.02669811f, 0.01988076f, 
    0.03626698f, -0.01177468f, -0.04003726f, 0.01333271f, -0.07850723f, -0.02539011f, -0.06047143f, -0.01152814f, 
    -0.08742665f, -0.03601567f, 0.06039818f, -0.01785104f, 0.01418283f, 0.03907456f, 0.05447387f, -0.01582307f, 
    0.00977483f, 0.03571852f, -0.07135995f, 0.00195869f, 0.03281145f, 0.00136889f, -0.00966887f, -0.03565824f, 
    0.02196233f, -0.06679489f, -0.00306849f, -0.01160667f, -0.06406963f, 0.02768041f, -0.02248301f, -0.08953279f, 
    0.01533408f, -0.08959407f, 0.01980731f, 0.05372828f, -0.01778493f, 0.01449936f, 0.02875526f, 0.00143302f, 
    -0.07527526f, 0.05115555f, -0.02625769f, -0.03951715f, 0.04350999f, 0.01211057f, -0.04688878f, -0.05050146f, 
    0.01750794f, -0.04541317f, -0.07547625f, 0.02753227f, 0.02917940f, 0.04735671f, -0.03624340f, 0.02844632f, 
    -0.06082738f, 0.01424917f, -0.04708698f, -0.03618012f, -0.01812395f, 0.04552042f, 0.04401036f, -0.04027816f, 
    0.02483508f, 0.05738330f, -0.09074960f, 0.05208038f, 0.00511900f, -0.07585923f, -0.01575498f, -0.07911219f, 
    -0.02707933f, -0.02809988f, -0.03597030f, -0.01353529f, -0.01024780f, 0.03441834f, -0.04545348f, 0.03616348f, 
    -0.00387306f, 0.03008101f, -0.07083097f, 0.00714843f, -0.00680445f, -0.01598946f, 0.05643974f, -0.03667922f, 
    -0.00327328f, 0.00981294f, 0.07271224f, -0.01013950f, -0.06333299f, -0.01296635f, 0.04889303f, -0.05740270f, 
    0.03404376f, 0.00907104f, 0.07304727f, -0.08159816f, -0.02234461f, -0.01094052f, 0.03168291f, -0.08473757f, 
    0.06538343f, 0.00145434f, -0.04686366f, -0.00898704f, -0.04006581f, 0.04678673f, -0.07086866f, -0.04841854f, 
    -0.00217062f, -0.01548012f, -0.00492830f, -0.04784640f, 0.03526421f, 0.00827139f, -0.05927174f, -0.01727221f, 
    -0.03350629f, 0.00983516f, 0.05573916f, -0.07289704f, -0.01864795f, 0.07549009f, 0.04695733f, -0.00953752f, 
    0.07428796f, -0.08121037f, -0.03720240f, -0.04810830f, 0.01094341f, -0.02774794f, 0.05825638f, -0.03057113f, 
    -0.03807564f, -0.04766107f, 0.03373425f, 0.00364833f, -0.05346184f, -0.03182174f, -0.06567074f, -0.02513801f, 
    -0.08621141f, -0.00082564f, -0.02360237f, -0.01373031f, 0.00056110f, -0.05903375f, -0.07574597f, -0.07232849f, 
    -0.00818187f, 0.00176324f, 0.05304412f, -0.02944348f, -0.04773036f, -0.04178604f, 0.02140734f, 0.02607729f, 
    -0.04254200f, 0.06785468f, -0.03632987f, -0.08613610f, -0.05961915f, -0.04306947f, -0.03717672f, 0.07791151f, 
    -0.04380509f, -0.07864281f, -0.01266264f, -0.00484107f, -0.03809351f, -0.01367966f, 0.03846756f, -0.08632790f, 
    0.01865498f, -0.03735855f, 0.03125240f, -0.06152183f, -0.07137186f, -0.00437638f, -0.06793126f, -0.04098174f, 
    0.05157617f, 0.01601979f, 0.00876473f, 0.07248592f, -0.08053146f, -0.00115354f, -0.02397297f, 0.00163623f, 
    -0.07964201f, 0.04699393f, 0.06321283f, 0.04226025f, 0.00282170f, -0.04827601f, -0.05724173f, 0.05363426f, 
    -0.06487887f, -0.03485344f, -0.00110683f, 0.04669960f, -0.07966843f, -0.02842122f, 0.04044978f, -0.01293024f, 
    0.00115395f, 0.06664499f, -0.03443528f, -0.04762420f, -0.05429975f, 0.03727944f, -0.02492910f, -0.00464658f, 
    -0.04035104f, -0.06814653f, -0.06473341f, -0.08321508f, -0.00181921f, 0.04979212f, 0.07325707f, -0.00791421f, 
    -0.07042485f, -0.06315360f, 0.04193627f, -0.07787179f, 0.02788027f, 0.02453858f, 0.07285222f, -0.05693163f, 
    0.31927723f, 0.25220296f, 0.02162407f, -0.14676273f, 0.13735750f, -0.11729450f, 0.15727124f, -0.00497199f, 
    -0.14022225f, -0.30951160f, 0.19550425f, -0.04589698f, -0.17418094f, 0.20640920f, 0.01726883f, -0.11349552f, 
    0.16545017f, 0.15715137f, 0.41299835f, -0.37964517f, -0.52594656f, -0.19258218f, -0.11548694f, -0.17103775f, 
    0.01859664f, -0.11796097f, 0.30256346f, 0.20888695f, -0.27301648f, 0.17245533f, 0.00428180f, 0.19644392f, 
    0.00836266f, -0.01470339f, -0.26732263f, -0.07723555f, 0.06885993f, 0.03599699f, -0.30479643f, 0.15279043f, 
    0.20407261f, 0.14743853f, -0.03023362f, 0.11013332f, -0.56409991f, 0.60111165f, 0.14096564f, 0.22773360f, 
    -0.20625263f, -0.07857288f, -0.03828491f, -0.07436001f, 0.02359216f, 0.05832032f, 0.22954758f, -0.06107903f, 
    0.19710690f, -0.19630475f, -0.27285331f, 0.13797493f, 0.07081722f, -0.08436137f, -0.12902059f, 0.11168026f, 
    -0.00856797f, 0.05947735f, -0.02148429f, -0.29094848f, -0.06564558f, -0.13166960f, -0.08140877f, 0.01991995f, 
    -0.16684151f, 0.11602297f, 0.29822290f, -0.08268673f, -0.19384913f, -0.25350964f, 0.20094973f, -0.03821841f, 
    -0.12577485f, 0.16765749f, -0.20647331f, -0.14904098f, 0.09513158f, -0.11593218f, -0.01510732f, 0.01154312f, 
    -0.06650016f, -0.08687719f, -0.20818873f, 0.34976900f, 0.56503856f, -0.10780330f, 0.12778091f, -0.02097839f, 
    -0.21119766f, 0.24184610f, 0.12239968f, -0.18060406f, 0.11155541f, 0.04700385f, -0.24194679f, 0.03921124f, 
    0.07227967f, 0.01478955f, 0.17509186f, -0.19870724f, -0.01181561f, 0.06544984f, -0.16311444f, 0.07883909f, 
    -0.00477291f, -0.07342391f, -0.31564909f, -0.07858692f, 0.15324031f, 0.16348706f, -0.02306739f, -0.12985796f, 
    0.14971508f, -0.22622597f, -0.18449107f, 0.15744418f, 0.01192164f, -0.12262879f, 0.30555448f, -0.13300021f, 
    0.20892712f, 0.22191943f, 0.08707687f, -0.00149382f, 0.14934294f, -0.17397523f, 0.15014756f, 0.10448143f, 
    -0.07692541f, 0.17045243f, 0.01166651f, 0.12899080f, 0.14457969f, -0.19370426f, 0.12565115f, -0.14676116f, 
    -0.03433735f, 0.27953333f, 0.25559548f, 0.13975061f, 0.12929350f, 0.23672083f, -0.02775086f, 0.02630791f, 
    -0.17562556f, 0.13427329f, -0.35506505f, -0.52543974f, 0.17699812f, 0.19519331f, 0.21324410f, -0.21161672f, 
    -0.14436316f, 0.35434717f, 0.24657503f, 0.22427113f, 0.17125176f, 0.03694445f, 0.09643112f, -0.32518944f, 
    0.01322017f, 0.12769118f, 0.18408523f, -0.08337256f, 0.27693701f, 0.48480040f, -0.08384118f, -0.12351696f, 
    0.07435377f, -0.02187865f, 0.17417075f, -0.04691662f, -0.39228722f, 0.09301949f, -0.18090898f, 0.04117613f, 
    0.31469095f, 0.03774533f, 0.00639656f, -0.08517005f, -0.10971849f, 0.86668116f, 0.09807422f, 0.11313427f, 
    0.01187058f, 0.09814590f, 0.13415368f, 0.18055840f, -0.18452953f, 0.01110917f, -0.30740562f, -0.57937038f, 
    -0.42456588f, 0.10652051f, -0.02795688f, 0.01790062f, -0.06920823f, -0.27818140f, 0.00651460f, -0.24624045f, 
    -0.18353418f, -0.27269238f, 0.36011192f, 0.07585412f, 0.22828662f, -0.08145444f, 0.03998834f, -0.19406439f, 
    -0.23154305f, -0.18901166f, 0.38837904f, 0.52150953f, 0.08166387f, 0.24841583f, 0.36156079f, -0.05542608f, 
    0.20941950f, -0.16659211f, 0.18598272f, 0.33386803f, 0.11044309f, 0.13112630f, 0.07565348f, -0.10433112f, 
    -0.12701824f, -0.31897336f, -0.19256510f, -0.00786373f, 0.01924280f, -0.17839012f, 0.14773977f, 0.28762129f, 
    0.04601911f, -0.10030068f, 0.24027282f, 0.04880876f, -0.15860200f, -0.12835418f, 0.17808560f, -0.03276945f, 
    -0.10355796f, 0.14064446f, -0.04944672f, -0.12240411f, 0.10653389f, 0.07149845f, -0.15490939f, -0.16298586f, 
    -0.13030541f, 0.28692377f, -0.24185689f, -0.02565694f, 0.22489512f, -0.55904096f, -0.03715424f, 0.21337004f, 
    -0.56347942f, -0.04651842f, -0.32387814f, 0.01084373f, 0.11979764f, 0.04297135f, 0.31014743f, 0.10191797f, 
    0.28935674f, -0.06970567f, 0.00344738f, -0.41968161f, 0.15772399f, 0.08393167f, -0.08601049f, 0.26153079f, 
    0.09700585f, 0.01311576f, 0.37900430f, -0.03178123f, 0.20505941f, 0.12464973f, 0.08699882f, -0.28159732f, 
    -0.54255426f, -0.32292229f, 0.10446806f, 0.02000536f, -0.00118828f, 0.27143878f, 0.25023127f, -0.20234698f, 
    -0.10989147f, 0.33849189f, 0.22299163f, 0.26751807f, 0.11755536f, -0.01475667f, 0.34283942f, -0.11678880f, 
    -0.00069419f, -0.05816480f, 1.27033651f, 0.10235539f, -0.12101104f, -0.16998282f, -0.17357123f, -0.11960621f, 
    -0.10378763f, -0.00940446f, -0.17941815f, -0.57384479f, -0.30950132f, -0.08979782f, 0.12220928f, 0.33431461f, 
    0.11444161f, 0.03856511f, -0.06492899f, -0.01653418f, -0.77908421f, -1.09463668f, -0.24762340f, -0.08462798f, 
    0.25677571f, 0.07092894f, 0.08705574f, 0.03689650f, -0.26695037f, 0.07741253f, 0.55067289f, -0.14164521f, 
    0.00985397f, -0.10823400f, -0.31233254f, 0.08557452f, 0.07167266f, 0.11543014f, -0.00869730f, -0.18767416f, 
    0.10107060f, -0.13675021f, -0.12440582f, 0.02306250f, -0.07692306f, 0.08746754f, 0.23487920f, 0.60333461f, 
    0.27591014f, -0.17148210f, 0.00354167f, -0.06056602f, 0.15104300f, 0.03639281f, 0.29434159f, 0.15774535f, 
    -0.30829585f, 0.02169372f, -0.11316428f, -0.04728742f, -0.31455523f, -0.18959960f, -0.10142678f, -0.04624592f, 
    0.09897988f, -1.37652516f, -0.47895622f, 0.00045942f, 0.07748210f, 0.07712767f, -0.00453184f, -0.33296177f, 
    0.16610026f, -0.10835458f, 0.27284727f, 0.36827463f, 0.22278343f, -0.00359558f, -0.08018466f, -0.25707033f, 
    0.13933299f, 0.21004565f, 0.00567671f, -0.20125619f, 0.22902842f, -0.42083848f, -0.05108320f, 0.25100815f, 
    -0.03162639f, 0.01969699f, -0.11884110f, 0.04087276f, -0.20790327f, 0.69388932f, 0.43478504f, 0.12424992f, 
    0.25493029f, -0.09251798f, 0.31730962f, -0.07354073f, 0.10482071f, 0.17147376f, -0.41905636f, -0.12417359f, 
    0.20691241f, 0.08896767f, -0.09115716f, 0.10095455f, 0.15429430f, -0.02704709f, -0.30464017f, 0.05035006f, 
    0.64326733f, 0.20592225f, 0.32812631f, 0.14418983f, -0.03845473f, -0.16946802f, 0.05176132f, -0.66590810f, 
    -0.12221926f, -0.12099182f, 0.10194071f, -0.06677698f, -0.08362708f, 0.06562302f, 0.02158185f, -0.17463128f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.39056003f, -0.06165404f, 0.34076187f, -0.16319019f, -0.05094067f, -0.15742253f, -0.06575502f, -0.15198976f, 
    -0.03770863f, 0.26882887f, -0.07286921f, 0.03857420f, 0.07125659f, -0.22630830f, 0.14800119f, 0.14851670f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.06956188f, -0.14845447f, -0.27005497f, 1.15602124f, -0.15499824f, -0.41488597f, 0.16830732f, -0.09495588f, 
    -0.20795658f, -0.30863020f, 0.15530653f, 0.01128466f, -0.04044515f, -0.08844259f, 0.21574867f, -0.17962009f, 
    0.46642554f, -0.12860589f, -0.66882527f, 0.47020721f, 0.22542866f, -0.24029763f, 0.03996232f, 0.27397180f, 
    0.15562773f, 0.07177310f, 0.22317332f, 0.11718228f, 0.07034412f, -0.49638775f, 0.07498771f, -0.54337430f, 
    -0.10417316f, -0.07390016f, -0.68612349f, -0.20487158f, -0.07968977f, -0.13354594f, -0.02058501f, -1.30664635f, 
    0.16772585f, 0.73242813f, -0.00240936f, -0.00627439f, 0.03160226f, 0.58068448f, 0.09799679f, -0.22766648f, 
    -0.59926093f, 0.18607485f, 0.22579557f, 0.05466791f, -0.00932828f, 0.14688189f, -0.25649339f, -0.33421052f, 
    -0.01973412f, -0.38983855f, 0.23718023f, 0.17408553f, 0.22967397f, 0.17338434f, 0.05382220f, 0.75608742f, 
    -0.18455595f, 0.10087006f, 0.35952571f, -0.36931029f, -0.02065663f, -0.28088269f, 0.14758392f, -0.17840901f, 
    0.15375590f, -0.34262139f, -0.19774994f, 0.25508088f, -0.17646207f, 0.07907024f, 0.72625679f, 0.04039592f, 
    0.55083245f, 0.04444873f, -0.24821137f, -0.04191488f, 0.16328603f, -0.06981450f, -0.21177149f, 0.43256238f, 
    0.19170454f, -0.21060836f, -0.24667618f, -0.14479250f, -0.21872544f, -0.92996663f, 0.24134822f, -0.45792487f, 
    0.51434284f, 0.01909479f, -0.28339937f, -0.27919734f, 0.15172374f, 0.41581634f, -0.02189100f, -0.39487749f, 
    -0.19883680f, -0.73039448f, -0.04163707f, -0.00540470f, 0.19911407f, -0.51234931f, 0.52829647f, -0.16397533f, 
    -0.56742930f, 0.00113501f, -0.45969060f, 0.05002540f, -0.15702443f, -0.27892283f, -0.23959343f, 0.77388149f, 
    -0.16359423f, -0.31039879f, 0.15403339f, -0.11663365f, 0.05505561f, 0.47112453f, -0.01043529f, 0.17672139f, 
    0.24183817f, 0.03966402f, 0.72330177f, 0.37531042f, 0.10707098f, -0.02899565f, 0.13755935f, 0.37921995f, 
    -0.09077510f, 0.27754140f, 0.19032255f, 0.03129457f, -0.14726567f, 0.22438304f, -0.86385912f, -0.37788209f, 
    0.30264682f, 0.00435192f, 1.13954031f, -0.44986546f, 0.23280479f, -0.28577068f, -0.00806039f, -0.19893010f, 
    -0.20521608f, -0.57712042f, -0.00939930f, 0.01810595f, -0.03192228f, -0.00535257f, 0.27796486f, -0.20223063f, 
    -0.23938888f, -0.22237696f, -0.03840361f, -0.43962404f, 0.19815099f, 0.11640085f, 0.00634504f, 0.12075171f, 
    -0.12102810f, 0.43710238f, 0.26033911f, -0.10344800f, -0.02800004f, -0.25434521f, -0.66230339f, 0.56551015f, 
    -0.25481603f, -0.15135831f, -0.74924576f, -0.14896163f, -0.13426715f, 1.06328821f, 0.13378055f, -0.03439849f, 
    -0.11925235f, -0.27877811f, -0.09508952f, 0.23578551f, -0.24744624f, 0.25305486f, -0.04133308f, 0.05929786f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.05724459f, 0.40057400f, -0.36615580f, -0.27753016f, 0.53912640f, -0.11780378f, -0.72376478f, -0.67902374f, 
    -0.84031767f, 0.14501296f, 0.79006177f, 0.09620925f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
