#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.43807727f, -0.24263383f, -0.34334758f, -0.39155948f, 0.53606170f, -0.64465356f, 0.21588999f, 0.06704906f, 
    -0.21028018f, 0.47574139f, 0.24408962f, -0.75694460f, 0.25407904f, 0.20346059f, -0.34570125f, 0.13111085f, 
    0.25270471f, -0.13641885f, 0.55354226f, 0.58197868f, 0.48728344f, 0.49607238f, -0.06827866f, 0.09780276f, 
    0.16605967f, 0.19988599f, 0.27847221f, -0.39044726f, -0.24279302f, 0.26674339f, 0.64329845f, -0.24595614f, 
    -0.63041025f, -0.15562280f, -0.01541058f, 0.08843706f, 0.21165928f, 0.48684689f, -0.40931174f, -0.19619389f, 
    -0.56964749f, 0.18747784f, -0.39780375f, -0.16543283f, -0.30861056f, 0.49461773f, -0.73969030f, -0.51827759f, 
    -0.43720737f, -0.17743118f, -0.00217995f, -0.06159146f, -0.02043537f, 0.31737861f, 0.28533271f, 0.16888297f, 
    0.48611000f, -0.51953053f, -0.35303268f, -0.77374989f, -0.00285121f, -0.07735782f, -0.20940104f, 0.68863595f, 
    -0.18235509f, 0.33814830f, 0.55159348f, -0.03940365f, 0.05353468f, -0.26071972f, 0.10826225f, -0.38958368f, 
    -0.19721231f, -0.10591491f, 0.58961254f, 0.57356185f, -0.04622930f, 0.04877781f, 0.21293606f, -0.29709285f, 
    0.27711532f, -0.37336725f, -0.70583445f, -0.57110113f, -0.03947270f, 0.14208640f, 0.16286853f, -0.28365985f, 
    0.13061070f, -0.33257425f, 0.09665869f, -0.49602148f, 0.22184741f, -0.05715873f, -0.72370374f, 0.25473720f, 
    0.08917976f, 0.20851840f, 0.07549901f, 0.63264704f, 0.64321291f, 0.37265056f, -0.48918375f, 0.04563896f, 
    -0.02928183f, 0.04861408f, 0.29895678f, 0.11583548f, -0.27643523f, 0.77825487f, 0.01570565f, 0.39104319f, 
    -0.38859403f, -0.19546859f, 0.37176138f, 0.17506906f, 0.24419220f, -0.38190633f, 0.11877822f, -0.05411905f, 
    0.57524985f, 0.62951881f, -0.09321514f, -0.04546497f, 0.25402537f, 0.29386973f, 0.25217050f, -0.64378697f, 
    -0.27046919f, 0.58056384f, 0.59804183f, 0.38283885f, -0.15682980f, -0.17875779f, -0.22176823f, -0.66747159f, 
    -0.51659507f, -0.09930366f, -0.42922989f, 0.09811600f, 0.61754024f, 0.21041954f, 0.00417069f, 0.24725480f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.16424273f, 0.01314216f, -0.00354601f, 0.02416036f, 0.04069696f, 0.11108051f, -0.17948474f, -0.07462422f, 
    -0.22575195f, -0.30506662f, 0.07307104f, 0.16005915f, -0.01628941f, -0.13787191f, -0.01636149f, 0.24943350f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.01100468f, 0.03992564f, 0.24310729f, 0.04035183f, -0.05691068f, 0.00944527f, -0.07920750f, -0.06307857f, 
    -0.05989337f, -0.01201701f, -0.24512802f, 0.15545671f, -0.10302359f, -0.21514893f, -0.00133473f, -0.16064349f, 
    0.01436194f, -0.00646490f, -0.21200246f, -0.09401090f, 0.06845489f, 0.01973832f, 0.03348784f, 0.25532871f, 
    -0.19404566f, -0.09274609f, -0.01677413f, -0.10119043f, -0.18834341f, 0.10473885f, -0.11824170f, -0.08716613f, 
    -0.06266975f, -0.04312251f, 0.07178158f, -0.12747324f, -0.01126052f, 0.10974888f, -0.01152501f, -0.07640319f, 
    0.24625818f, 0.11699305f, -0.20489182f, -0.03189030f, -0.08190677f, 0.26499173f, 0.04612131f, 0.20813151f, 
    -0.13533381f, 0.11649549f, -0.15938394f, 0.06960768f, -0.01681160f, -0.02372694f, 0.16587938f, -0.07149722f, 
    0.07718402f, 0.10690465f, 0.08147968f, 0.10193414f, -0.01110526f, -0.05081271f, -0.03121497f, -0.31885597f, 
    -0.24879137f, -0.21121331f, 0.12924524f, 0.03131595f, 0.04420876f, -0.02118233f, -0.10008262f, -0.03798991f, 
    -0.06016926f, 0.01353152f, -0.04074276f, -0.14561048f, -0.05949258f, 0.12832431f, 0.14505902f, -0.06718693f, 
    -0.22309862f, 0.14875647f, -0.18281204f, 0.09621126f, -0.25734401f, -0.06370876f, 0.10923840f, 0.08765669f, 
    0.07831370f, -0.09035723f, -0.03312972f, -0.08751721f, -0.13049741f, -0.15725571f, -0.06170869f, -0.05781320f, 
    0.13308807f, -0.11537051f, 0.20499769f, -0.03158392f, 0.07755169f, -0.01127336f, -0.05699288f, -0.02094814f, 
    0.19584949f, 0.06434944f, 0.09451906f, 0.02877092f, 0.23779719f, 0.21771286f, 0.12593859f, -0.10038608f, 
    -0.06867881f, 0.12867384f, 0.06323942f, -0.09642509f, 0.06307110f, 0.06997117f, 0.26445746f, -0.06292302f, 
    0.04219750f, 0.02678269f, -0.09815564f, 0.19435087f, 0.01280826f, 0.08271329f, 0.14158259f, 0.05446269f, 
    0.13612534f, -0.03877019f, -0.01366459f, -0.15397653f, 0.07003120f, 0.10417990f, 0.00584818f, 0.31161585f, 
    -0.12303901f, 0.05068810f, -0.14150882f, 0.02275733f, -0.11221049f, 0.03682021f, -0.00999428f, 0.12345809f, 
    0.11758604f, 0.25202069f, 0.32653087f, 0.13035914f, -0.05332778f, 0.02326942f, -0.03594462f, -0.06760371f, 
    -0.00350788f, -0.05191990f, 0.19398592f, -0.06183312f, -0.18535659f, -0.10959440f, -0.11894653f, 0.06887227f, 
    0.17109692f, 0.00612677f, -0.04150309f, 0.27503121f, 0.19898027f, 0.08339079f, -0.02244026f, 0.16461241f, 
    -0.02612552f, -0.01816250f, -0.01378489f, -0.11988509f, -0.04436709f, -0.06745524f, -0.09437703f, 0.03243134f, 
    -0.09038093f, -0.00954675f, 0.03620943f, -0.03598440f, 0.19722158f, 0.08468054f, -0.00883645f, -0.18011554f, 
    -0.02724903f, -0.06399968f, 0.10585038f, -0.01630905f, -0.10406175f, 0.26446915f, 0.06260081f, 0.35680020f, 
    -0.16640349f, 0.09676474f, -0.12133961f, 0.00592642f, 0.11526372f, 0.11579800f, 0.07062440f, -0.17075358f, 
    -0.17981179f, -0.01535080f, -0.11510620f, -0.09803256f, 0.00976516f, -0.01740001f, 0.15512589f, 0.09413690f, 
    0.10270939f, -0.02918531f, -0.14394152f, 0.09057523f, 0.19733165f, 0.06051314f, -0.16197476f, -0.08037487f, 
    -0.02577141f, -0.23555052f, -0.31949505f, 0.34861204f, 0.06041107f, 0.02416303f, -0.15812658f, 0.09670254f, 
    -0.21152073f, 0.34290719f, 0.07952324f, 0.52890408f, 0.17818290f, 0.19987151f, 0.21363118f, 0.02832073f, 
    -0.00418200f, 0.27303585f, 0.10582475f, -0.07504486f, -0.19115709f, -0.12147073f, -0.01169284f, -0.00787977f, 
    0.11296426f, -0.04721933f, 0.06672633f, -0.21575382f, 0.06536459f, 0.03873584f, -0.15420525f, 0.01616528f, 
    -0.02716041f, -0.00439813f, 0.18246524f, -0.01754657f, -0.04868041f, -0.18001495f, -0.00049729f, 0.00643355f, 
    -0.03633463f, -0.17185774f, -0.24938214f, -0.08561940f, 0.05739333f, 0.14353688f, 0.07863515f, 0.04368407f, 
    0.09075037f, -0.08186254f, 0.08251209f, 0.17048126f, 0.02121183f, -0.13007160f, 0.03831726f, 0.06225217f, 
    -0.09753083f, 0.03475901f, -0.09713747f, -0.01357116f, 0.04765318f, 0.09186062f, 0.00952827f, 0.21307531f, 
    -0.22841455f, 0.00500078f, 0.12846898f, 0.07729431f, 0.01610290f, 0.08559585f, -0.20912650f, 0.02479401f, 
    -0.00945146f, -0.00644822f, -0.02250788f, -0.03282836f, -0.02631073f, 0.00976620f, 0.02182348f, 0.01817096f, 
    0.03280681f, 0.06497524f, 0.01076814f, -0.09211133f, -0.02683504f, -0.04121388f, -0.05385610f, -0.07244077f, 
    0.00822024f, -0.07853755f, 0.04223432f, -0.02794020f, -0.04495823f, 0.03211017f, -0.01730564f, -0.01949591f, 
    0.01247896f, -0.01281992f, -0.03303704f, -0.08683325f, 0.03082380f, 0.05966257f, -0.01722667f, -0.03482204f, 
    -0.07756917f, -0.04045099f, -0.02080154f, 0.05995155f, 0.05658143f, -0.06278107f, -0.05159855f, 0.02529039f, 
    -0.07375319f, 0.06168081f, -0.09637149f, 0.01882836f, -0.02210864f, 0.04694465f, -0.01134243f, 0.05752706f, 
    -0.03617540f, 0.07571012f, 0.06666639f, 0.00613596f, 0.01398070f, -0.02958685f, -0.09271417f, -0.07823052f, 
    0.03022480f, -0.04764279f, -0.00208206f, -0.08453017f, 0.04017531f, -0.07524061f, -0.08915406f, -0.06421855f, 
    0.06606016f, -0.06584836f, 0.05948839f, 0.05921211f, 0.06955908f, -0.03988456f, -0.05178591f, 0.01639667f, 
    -0.03807852f, -0.05244588f, 0.04637154f, 0.01647259f, 0.01025865f, -0.06407887f, -0.09075312f, -0.01888377f, 
    -0.06292986f, -0.05641834f, -0.01338602f, -0.03291794f, -0.08526574f, -0.04586121f, -0.07563472f, -0.05407114f, 
    0.03842268f, -0.00541802f, 0.06078655f, -0.01584419f, 0.04344366f, -0.02533058f, 0.06030776f, 0.00384123f, 
    -0.03671525f, -0.06995083f, -0.06180622f, 0.00823621f, 0.02857148f, -0.04718123f, 0.01851932f, 0.01389104f, 
    -0.05654073f, -0.02322951f, -0.04802955f, -0.00606275f, 0.05352056f, -0.05117433f, 0.06574021f, -0.03354470f, 
    -0.05614837f, -0.06177699f, 0.00689430f, -0.05643613f, 0.03184856f, -0.06189311f, -0.03022477f, 0.01965014f, 
    0.02933585f, 0.01229732f, 0.03620140f, -0.08474226f, 0.00860934f, 0.06421849f, -0.00679113f, 0.00929045f, 
    -0.00330712f, 0.04831525f, 0.06913065f, -0.00353795f, -0.06804708f, -0.00130699f, -0.08037824f, 0.00257760f, 
    -0.05203493f, 0.05181833f, -0.07509992f, -0.04310764f, 0.03837609f, -0.08448686f, 0.05702072f, -0.08373008f, 
    0.06039612f, -0.01046414f, 0.07344831f, 0.03948684f, -0.08102606f, 0.05207289f, 0.06927954f, -0.04279244f, 
    -0.07774869f, 0.01119587f, -0.07735313f, -0.04945945f, -0.03915169f, -0.09041943f, 0.06391905f, 0.05579009f, 
    -0.08223453f, -0.06208856f, 0.04120005f, -0.04673895f, 0.01508016f, -0.05629928f, -0.03577911f, -0.04093844f, 
    0.00641274f, 0.04579102f, -0.06448381f, -0.04151299f, -0.02030136f, -0.02789635f, 0.01905986f, 0.07229453f, 
    0.05849237f, -0.03400674f, -0.04705941f, -0.06233085f, -0.01858861f, 0.04993885f, -0.03569743f, -0.05109409f, 
    0.04552034f, -0.02790216f, -0.06104758f, 0.01831526f, 0.05952717f, -0.08063388f, -0.01091158f, -0.08914151f, 
    -0.02105545f, -0.02713243f, -0.01581706f, -0.05087813f, 0.02203162f, 0.04987269f, 0.02588608f, 0.00706080f, 
    -0.06989091f, 0.02599093f, 0.01472394f, 0.02865101f, -0.04940641f, 0.04295610f, -0.02287034f, 0.04369076f, 
    -0.06887479f, -0.04010535f, -0.00094412f, -0.03329379f, 0.04861154f, 0.02745487f, -0.05811454f, -0.09253771f, 
    0.04559102f, -0.00369314f, 0.04773029f, 0.07240139f, -0.01904080f, -0.07654050f, 0.00446063f, -0.01480317f, 
    0.04904628f, -0.03287074f, 0.07138481f, 0.06834759f, -0.01556880f, -0.00917718f, -0.02424230f, -0.09233992f, 
    -0.07085188f, -0.03983128f, -0.09372091f, 0.02014787f, 0.03449379f, 0.02630161f, -0.03869956f, -0.01583033f, 
    0.03109591f, -0.00905726f, -0.08673363f, -0.07190103f, -0.08882520f, 0.07333767f, 0.02585760f, -0.08422868f, 
    -0.00400232f, -0.02606546f, -0.06054933f, 0.01225453f, -0.05186487f, 0.06315087f, 0.02118405f, 0.01890294f, 
    -0.04647302f, 0.01113313f, 0.05580291f, -0.04559590f, 0.05518645f, 0.04202839f, 0.01402961f, -0.03244511f, 
    -0.03152715f, 0.01530232f, -0.02781247f, 0.02403695f, 0.03615740f, 0.07289267f, 0.02135773f, 0.05097033f, 
    -0.05582595f, -0.00635486f, -0.05626223f, -0.05485154f, -0.03815006f, -0.07081848f, -0.05901038f, -0.08370896f, 
    -0.05085281f, 0.04557932f, -0.00898334f, 0.02502691f, -0.08703375f, -0.04972312f, 0.05605018f, -0.05607990f, 
    0.17932217f, 0.21084026f, 0.05269961f, -0.01207092f, -0.02652754f, 0.03196436f, -0.01989686f, 0.02418147f, 
    -0.00875542f, 0.14335358f, -0.14236213f, -0.04778805f, -0.09979120f, 0.04836031f, -0.06303800f, -0.01390293f, 
    -0.00316917f, -0.04096843f, -0.50250590f, -0.21549845f, -0.23921512f, -0.00673274f, 0.02413453f, 0.17500137f, 
    -0.02823422f, 0.10399354f, 0.02163816f, -0.02431695f, 0.04312123f, -0.14727584f, -0.05488729f, -0.01401831f, 
    0.13193728f, -0.01331216f, -0.00177178f, -0.04467944f, -0.12810560f, -0.29829252f, -0.11712030f, -0.06816731f, 
    -0.00696288f, 0.06959768f, 0.05548925f, -0.05365260f, -0.01096587f, 0.07809399f, 0.15031579f, -0.23542184f, 
    -0.09170073f, -0.07220352f, 0.03093596f, 0.00511773f, 0.06035574f, 0.12451226f, -0.10458677f, -0.18134616f, 
    0.28536969f, 0.06344250f, 0.03560464f, 0.16844840f, -0.16132230f, -0.11294864f, 0.01819641f, -0.32289940f, 
    -0.20778362f, 0.10336022f, 0.16966359f, 0.03261629f, 0.11454578f, -0.03118872f, -0.03851793f, 0.06421074f, 
    -0.32840532f, -0.21846659f, -0.10494639f, 0.19704486f, -0.11347485f, -0.20604719f, -0.09194659f, 0.00870664f, 
    0.02571427f, 0.28626662f, 0.31725365f, 0.08415966f, -0.00287040f, 0.16688029f, -0.03009197f, -0.02809884f, 
    0.03332120f, -0.15473905f, 0.09918118f, -0.05211542f, -0.00357647f, 0.12180768f, 0.03686176f, 0.02530578f, 
    -0.02793810f, 0.19794515f, 0.05397068f, -0.17583928f, -0.56008303f, 0.00259255f, 0.10271961f, 0.09367736f, 
    -0.02015900f, 0.03661650f, -0.03467521f, 0.08589499f, 0.33356783f, -0.18297011f, -0.15388073f, 0.04823629f, 
    0.08020825f, -0.02451061f, 0.04543046f, -0.04310593f, 0.14141475f, -0.01897958f, -0.05907419f, -0.10687886f, 
    -0.03758331f, 0.15610483f, 0.03331317f, 0.09289756f, 0.18028486f, 0.03625378f, 0.18680555f, 0.16123776f, 
    -0.12912253f, 0.14477943f, 0.07676482f, -0.06493406f, -0.03245228f, 0.11360943f, -0.00669019f, -0.03039486f, 
    0.22965920f, 0.04650237f, 0.02531042f, -0.17237875f, -0.00882062f, 0.00947875f, 0.03237557f, 0.07055853f, 
    -0.39975351f, -0.25529256f, -0.23750184f, 0.03017496f, -0.00233724f, 0.14599124f, 0.04683878f, -0.20980819f, 
    0.04916760f, -0.17549545f, 0.12104002f, -0.42167452f, -0.07972496f, -0.01374668f, -0.19944502f, -0.05124092f, 
    0.17180583f, -0.00298805f, -0.08381717f, 0.08452442f, -0.08490937f, 0.08611987f, 0.07538852f, 0.04641368f, 
    -0.01934504f, -0.02878490f, 0.14410165f, -0.26757550f, -0.23311788f, 0.02172485f, -0.07734690f, -0.13792208f, 
    -0.02796433f, 0.18020973f, -0.13757496f, 0.15537217f, -0.06928882f, 0.12942733f, -0.19631447f, 0.09231107f, 
    0.05745873f, 0.10836806f, 0.08338072f, 0.12410928f, -0.12658431f, -0.60368150f, 0.21435088f, 0.09019746f, 
    0.08872184f, -0.14837198f, -0.05575108f, 0.05802178f, -0.02453464f, -0.09909030f, 0.14267677f, -0.18734938f, 
    0.14392145f, 0.11111280f, 0.01806086f, 0.03769435f, 0.03911251f, 0.07242867f, 0.16422878f, 0.00263432f, 
    -0.03202052f, -0.15802416f, -0.07757777f, -0.02245416f, 0.10028761f, -0.01307074f, 0.11438074f, 0.00736603f, 
    0.08006002f, 0.22232768f, 0.10260393f, 0.03976083f, 0.03279568f, -0.22361973f, -0.16431916f, -0.06316547f, 
    -0.16657209f, -0.05653442f, 0.17777374f, 0.04911192f, -0.11053308f, -0.20868576f, 0.19552346f, 0.03405505f, 
    0.04772725f, -0.10828445f, 0.12676620f, -0.18087281f, -0.15121739f, 0.05054289f, 0.06897380f, 0.11999315f, 
    -0.03301798f, 0.07064094f, 0.07612278f, 0.27969837f, -0.18448660f, -0.02772368f, 0.08692237f, 0.17311934f, 
    0.08747277f, -0.02341285f, 0.02837555f, 0.02301660f, 0.08343594f, 0.12183215f, -0.16384228f, 0.00101010f, 
    -0.04280761f, -0.12481518f, 0.24793057f, -0.02211608f, 0.07235832f, 0.24913836f, 0.17899142f, -0.27987811f, 
    0.05147420f, -0.13869907f, -0.01316507f, -0.04796792f, 0.00405658f, -0.02871031f, -0.07279757f, 0.04796353f, 
    0.06924628f, -0.05814376f, 0.13452062f, -0.16944306f, -0.01431138f, 0.02256821f, 0.00095026f, -0.00260333f, 
    0.03535499f, 0.17190000f, -0.01758615f, 0.08966002f, 0.08298160f, -0.01073563f, 0.08385243f, 0.04163305f, 
    -0.03751130f, -0.04637090f, 0.04329725f, -0.05771049f, 0.06163593f, -0.06826054f, -0.05577033f, -0.07021155f, 
    -0.03650454f, 0.04591690f, 0.00512387f, -0.03320562f, 0.03192792f, -0.08262975f, -0.05656993f, -0.09657954f, 
    0.06148215f, -0.03170254f, -0.06904352f, -0.02869574f, -0.02899827f, 0.01190371f, -0.08725212f, 0.00241228f, 
    0.02853965f, -0.07550950f, -0.02172862f, -0.04382133f, -0.00719759f, -0.08277534f, -0.08941252f, 0.00538297f, 
    -0.03842582f, -0.02583656f, 0.00585323f, 0.02442124f, -0.10178524f, -0.05354507f, 0.02100153f, 0.01408279f, 
    -0.02178697f, -0.01321717f, -0.08349505f, -0.03306042f, 0.01394977f, 0.00450984f, -0.06137986f, -0.01088163f, 
    -0.07388850f, -0.10270199f, -0.01247723f, 0.00729032f, -0.04814947f, 0.03022077f, 0.00672161f, -0.10243881f, 
    -0.07511631f, -0.07608550f, -0.06261700f, -0.05832094f, 0.06159373f, 0.01536278f, 0.05406245f, 0.02397754f, 
    0.01503109f, 0.02570231f, -0.00494261f, -0.05856275f, -0.06781733f, -0.05541585f, -0.05386169f, 0.04866191f, 
    -0.07812558f, 0.05497251f, 0.03651473f, -0.03354212f, -0.01925395f, -0.03698781f, 0.04934662f, -0.07980916f, 
    -0.06301496f, -0.10608447f, 0.04462260f, -0.05654394f, -0.03404948f, 0.00085051f, 0.02011897f, 0.01991270f, 
    -0.03096827f, -0.04022329f, -0.07845324f, -0.00146691f, 0.05471505f, 0.05034883f, -0.07196124f, -0.04556125f, 
    -0.03282967f, 0.06730385f, -0.00656030f, 0.05637859f, 0.06415037f, -0.06849942f, -0.07628661f, 0.02591595f, 
    -0.02747343f, -0.09734306f, 0.02785170f, 0.00626205f, -0.02514440f, 0.01387963f, -0.02189200f, -0.09164868f, 
    -0.09167359f, -0.02146201f, -0.08077219f, -0.10411206f, -0.08679195f, 0.00621631f, -0.06946620f, -0.06064875f, 
    0.01068117f, -0.03466510f, -0.02636437f, 0.00970502f, -0.03697250f, -0.05705858f, 0.05398314f, -0.01099001f, 
    -0.09192432f, -0.09885910f, 0.00659693f, -0.05166686f, -0.03547603f, -0.01687471f, -0.06878784f, 0.03104583f, 
    -0.08615125f, 0.05487314f, 0.05904939f, -0.05113038f, 0.03570331f, -0.01988788f, 0.01584063f, -0.04390452f, 
    0.06188184f, 0.04185610f, -0.04303555f, -0.01590215f, 0.06310946f, -0.07245520f, -0.00884212f, 0.00908394f, 
    -0.01227937f, 0.06551617f, -0.07070346f, -0.07601409f, 0.01610065f, 0.04965081f, -0.04566820f, -0.03099038f, 
    -0.07250729f, -0.02527224f, -0.02913138f, -0.00893592f, 0.04361396f, -0.07708161f, -0.00949962f, -0.07549805f, 
    -0.05098450f, -0.06486778f, 0.06433665f, -0.02704124f, -0.09509499f, 0.03865883f, -0.01331817f, 0.04938842f, 
    -0.00269501f, -0.07780025f, -0.01663734f, -0.10068792f, 0.06032843f, -0.01547593f, 0.02304602f, -0.06387586f, 
    0.00228181f, 0.01656278f, 0.03415156f, 0.02803795f, -0.03042063f, -0.04371024f, -0.01335367f, 0.04478940f, 
    0.05663900f, -0.02010084f, 0.02179280f, -0.06296653f, -0.02217741f, 0.06249309f, 0.02705882f, 0.04636414f, 
    -0.05967155f, -0.00575649f, -0.03378635f, -0.04515793f, 0.00078015f, -0.07381218f, 0.06568766f, -0.07331115f, 
    0.04720788f, 0.03359290f, 0.01348344f, -0.08979537f, 0.05855218f, -0.04147921f, 0.06407100f, 0.05886803f, 
    -0.07346791f, -0.03427453f, 0.00882338f, 0.06342963f, -0.06202257f, 0.03019337f, 0.01037881f, 0.06175763f, 
    0.00512771f, -0.04645940f, 0.02662782f, -0.05840289f, 0.04100917f, 0.04273132f, 0.02763390f, -0.03518434f, 
    0.04570597f, -0.05087515f, -0.08072749f, -0.04530396f, 0.04093711f, -0.08640971f, -0.07679264f, -0.04470093f, 
    0.00671950f, 0.02947108f, -0.00729384f, 0.02885417f, 0.04514802f, 0.02366659f, -0.06166274f, -0.06467251f, 
    -0.06903356f, 0.04721994f, -0.01664253f, -0.08380891f, -0.02732407f, -0.01247592f, -0.09414220f, 0.01037789f, 
    -0.01840109f, -0.03755107f, -0.08157229f, -0.05060932f, -0.00195189f, -0.03250935f, -0.05903583f, -0.04810735f, 
    0.02008951f, -0.02120008f, -0.08228961f, -0.01512262f, 0.03830371f, 0.06002973f, -0.01110391f, 0.06747870f, 
    -0.02376373f, -0.06721162f, -0.04639090f, 0.01343984f, -0.03882765f, -0.04414650f, -0.05523737f, -0.03724664f, 
    -0.07939809f, 0.05118226f, -0.10324620f, -0.05006705f, 0.00315195f, -0.00006930f, -0.04949212f, 0.03480426f, 
    0.05547659f, -0.01933043f, -0.17441881f, 0.07536599f, 0.19883077f, 0.08481212f, -0.05864622f, 0.13474087f, 
    0.03591767f, 0.33636355f, -0.05331099f, -0.05995038f, 0.04276022f, -0.08924444f, 0.02922192f, -0.03210349f, 
    -0.14895664f, 0.11289273f, 0.33641100f, -0.03767726f, 0.12856759f, 0.18563563f, 0.08238516f, -0.13734774f, 
    0.03935064f, 0.03555923f, -0.01521767f, -0.62153161f, 0.02463136f, 0.02970259f, -0.12279945f, -0.12966974f, 
    -0.08865919f, 0.14784259f, -0.09623145f, -0.07576475f, -0.15991266f, -0.29596204f, 0.00239108f, -0.02537318f, 
    0.01173946f, -0.10837611f, -0.06353679f, -0.10286459f, -0.09009798f, 0.36770347f, -0.00774009f, -0.24681585f, 
    0.00185545f, -0.11211318f, 0.11089432f, -0.02363062f, -0.13464776f, -0.03068055f, -0.17646623f, -0.30262652f, 
    -0.14389974f, -0.07919561f, 0.01125850f, -0.08933062f, -0.00458890f, -0.02045851f, 0.11076434f, 0.14032891f, 
    0.01554497f, 0.07683511f, 0.06128372f, -0.11520715f, -0.04585405f, -0.12359899f, -0.01155485f, 0.08036692f, 
    0.25313666f, -0.12218312f, 0.02228062f, -0.00592929f, 0.27942351f, 0.10083904f, 0.07174566f, -0.10489652f, 
    -0.11806384f, 0.23805018f, 0.25668883f, 0.04552186f, 0.03121439f, -0.18799061f, 0.11383481f, -0.02218534f, 
    -0.15565877f, 0.06521144f, -0.34613213f, 0.16865432f, -0.27872443f, -0.05737713f, -0.01387840f, 0.02858141f, 
    0.04904195f, 0.05407901f, -0.01076821f, -0.00847826f, -0.08897521f, 0.00048962f, -0.04805718f, -0.03271675f, 
    -0.03237740f, 0.02715667f, -0.07463009f, 0.07025955f, -0.15177514f, -0.11949212f, -0.14788948f, 0.11116614f, 
    -0.22789587f, 0.01276569f, -0.11983429f, 0.01398095f, 0.08391804f, -0.27389020f, -0.21751395f, -0.16636848f, 
    -0.02771075f, 0.04593797f, -0.05422696f, -0.12364937f, 0.15885125f, 0.13623086f, 0.32530063f, -0.01101949f, 
    0.16475144f, -0.13971238f, 0.05680286f, -0.15493643f, 0.02831129f, 0.09792163f, -0.15000668f, -0.31794801f, 
    0.41150326f, 0.06810425f, 0.08841870f, 0.00336005f, -0.06685827f, -0.00173923f, 0.01659844f, 0.15528964f, 
    -0.54055202f, -0.00426147f, -0.03011911f, 0.18649149f, 0.02517105f, 0.05996858f, 0.06199688f, -0.22243212f, 
    -0.14165470f, 0.01034510f, 0.22150777f, -0.01109248f, -0.11894362f, -0.03510064f, 0.03535354f, 0.03059241f, 
    -0.02476467f, 0.01493324f, -0.20855227f, 0.19868878f, 0.07622720f, 0.07146568f, 0.19490282f, -0.05418981f, 
    0.05866374f, -0.06077566f, 0.02922402f, -0.20370430f, -0.21118943f, 0.14045152f, 0.07779266f, -0.18778963f, 
    -0.03166398f, 0.13698833f, 0.11810168f, -0.02938307f, -0.11255946f, -0.01378317f, 0.15045978f, -0.03898041f, 
    -0.07373271f, -0.03720113f, -0.06323584f, 0.06701043f, -0.13192715f, -0.22570881f, -0.13511479f, 0.01946913f, 
    0.11054575f, -0.03577549f, -0.04292099f, 0.05061226f, -0.00818253f, 0.18077092f, 0.05193504f, -0.00103991f, 
    -0.10618307f, 0.08735324f, 0.19228917f, -0.00838759f, 0.06490248f, 0.17472477f, 0.08482264f, -0.05361488f, 
    -0.16666244f, 0.12449840f, -0.02502877f, 0.08464577f, -0.02386840f, 0.16894150f, 0.01250210f, -0.02861470f, 
    -0.06056343f, 0.00871952f, -0.05379064f, -0.08300131f, 0.21357995f, -0.21560188f, -0.28021988f, -0.11807341f, 
    0.00548762f, 0.05285573f, 0.16027218f, 0.02997874f, 0.09179479f, 0.06593402f, 0.03042028f, 0.08049248f, 
    -0.17123748f, -0.09515166f, -0.16314887f, -0.04588064f, 0.18236488f, -0.10267353f, -0.02164729f, -0.01345959f, 
    0.09495421f, 0.22819728f, 0.28711131f, 0.07278664f, 0.22261317f, 0.02087290f, 0.05174480f, 0.07650815f, 
    0.08419450f, -0.01634839f, 0.03704121f, 0.25256535f, -0.24311680f, -0.15333952f, 0.09492663f, -0.01185736f, 
    0.18349794f, -0.03785729f, -0.21372855f, 0.05586044f, 0.04417882f, -0.05388783f, 0.01753350f, 0.00575058f, 
    0.09983387f, -0.07934392f, 0.05338868f, -0.17333822f, 0.08246063f, 0.04071077f, 0.23797691f, -0.04371585f, 
    -0.56540149f, 0.06688651f, 0.07214385f, 0.02293882f, -0.06030495f, -0.12232256f, -0.16414928f, -0.36109379f, 
    -0.39088917f, -0.22327910f, 0.13079406f, 0.06468414f, 0.09217751f, 0.01463989f, 0.02855531f, 0.13301872f, 
    -0.03352750f, -0.17627484f, -0.24933439f, 0.24316844f, -0.02483577f, 0.02458841f, 0.05720595f, -0.06631204f, 
    -0.05995730f, 0.20951058f, -0.26388362f, 0.08849582f, -0.04593923f, -0.04041126f, -0.04199630f, 0.01658739f, 
    0.04574858f, -0.16155940f, -0.38441995f, -0.13340592f, 0.06655210f, -0.00420670f, 0.07332897f, -0.04105558f, 
    -0.20345958f, -0.01513306f, 0.04026483f, -0.11613344f, -0.14717713f, 0.05082399f, -0.04217318f, 0.07541728f, 
    -0.02897617f, 0.00816317f, -0.16339192f, 0.00198870f, -0.34961572f, -0.39513546f, -0.20414294f, 0.07879757f, 
    -0.13550486f, 0.00924705f, -0.08830376f, -0.03439900f, 0.11789761f, 0.08643546f, -0.24337412f, -0.02217976f, 
    0.14701919f, 0.03591024f, 0.22747174f, 0.08905932f, -0.03861945f, -0.05057059f, -0.03913302f, 0.06802998f, 
    -0.15073054f, 0.05239834f, 0.02473184f, -0.08674684f, 0.08685774f, -0.02545761f, 0.08678433f, -0.10175107f, 
    0.31431034f, 0.03402157f, 0.09190489f, -0.01683740f, 0.05517793f, -0.01986682f, 0.03229199f, 0.00946571f, 
    0.28248373f, 0.35332486f, -0.04667392f, -0.15170810f, 0.17559220f, -0.24031161f, -0.11143728f, 0.03012264f, 
    -0.05880370f, -0.03716993f, -0.18110102f, 0.08537198f, 0.03414731f, 0.13907136f, 0.01580802f, 0.05607728f, 
    0.03126415f, 0.12968041f, -0.29930258f, 0.30279437f, -0.08719716f, 0.08310895f, -0.00159945f, -0.14907633f, 
    -0.09433111f, 0.04743380f, 0.12749399f, 0.06038233f, 0.06435034f, -0.04423779f, 0.12811860f, 0.03909352f, 
    0.09834640f, -0.04133593f, 0.05384616f, -0.19324383f, -0.06830680f, -0.09561463f, -0.29372883f, -0.00038172f, 
    -0.04878814f, 0.02876429f, 0.06555174f, -0.02717313f, 0.13596939f, 0.15264094f, -0.06018190f, 0.06646015f, 
    -0.15712865f, -0.20224185f, 0.00151617f, 0.03631178f, 0.13957450f, 0.03391851f, 0.11456356f, 0.03754743f, 
    0.21423239f, -0.06889530f, -0.01538630f, 0.05713428f, 0.00842554f, -0.09402239f, -0.02176208f, 0.36250585f, 
    0.18841401f, 0.18794873f, -0.02118155f, -0.10941622f, -0.00040433f, -0.12600400f, -0.02163018f, 0.03019737f, 
    -0.05144269f, -0.06370493f, 0.15726247f, 0.08324619f, 0.29612574f, -0.14556818f, -0.17766866f, 0.00601043f, 
    0.07428941f, -0.07402236f, -0.12702237f, -0.02803290f, 0.02680906f, -0.26920080f, 0.09204478f, 0.05271215f, 
    0.11665691f, 0.00773958f, -0.18735833f, 0.04113954f, -0.10069416f, 0.20417368f, 0.13222355f, 0.14060181f, 
    0.00925569f, -0.06769592f, 0.00141661f, 0.21409260f, 0.11326160f, -0.46148151f, 0.02777852f, -0.11054888f, 
    -0.03790811f, 0.15427025f, 0.10793331f, 0.11482751f, -0.26177999f, -0.12774505f, 0.21168761f, -0.06604657f, 
    0.10011475f, 0.07352293f, 0.12828965f, 0.15875703f, 0.11613055f, 0.20135289f, -0.49488372f, -0.01471491f, 
    0.06251627f, -0.06109247f, -0.06847715f, 0.03804231f, -0.05602688f, 0.00751981f, 0.02539858f, 0.46026853f, 
    0.16790538f, 0.25812352f, 0.03286751f, -0.09473345f, -0.06054484f, -0.05736874f, 0.11141460f, -0.02024628f, 
    0.06625318f, -0.21171732f, -0.01892731f, 0.09599411f, 0.17183778f, 0.03987925f, 0.06100385f, -0.04261501f, 
    0.08772621f, -0.13173148f, -0.21800366f, -0.05379819f, -0.09469787f, 0.14773318f, -0.04448622f, -0.10185740f, 
    0.10879226f, -0.24609372f, 0.05321453f, 0.23964073f, -0.20127589f, -0.41281733f, 0.07887868f, 0.00506137f, 
    -0.24461849f, 0.17385772f, 0.18779436f, 0.01826800f, 0.05410397f, 0.04286505f, 0.09739904f, -0.03477382f, 
    0.26525158f, 0.21805550f, 0.07619260f, 0.01858631f, 0.30475295f, -0.12468152f, 0.19993822f, 0.27709827f, 
    0.08383992f, -0.01185020f, -0.05847992f, -0.08911125f, 0.18482408f, 0.09693301f, -0.29787624f, 0.09662207f, 
    -0.06633493f, -0.03673961f, -0.14410974f, 0.04847625f, 0.29194140f, 0.25012982f, -0.10974770f, -0.43667391f, 
    0.00706619f, -0.25636661f, 0.03611931f, 0.00463012f, -0.12474892f, 0.02983237f, 0.04933208f, -0.11590602f, 
    0.19846119f, -0.27368045f, -0.12434615f, -0.17260340f, 0.01568926f, 0.03599681f, -0.06580453f, 0.20527291f, 
    0.13761939f, 0.02214204f, -0.04361508f, 0.18940243f, 0.00969994f, 0.01467315f, -0.00169176f, 0.09246615f, 
    -0.05544843f, -0.01517342f, 0.03485250f, -0.19842726f, -0.03430124f, 0.07124904f, -0.20586634f, 0.04256319f, 
    -0.02064683f, 0.08159497f, 0.10086836f, 0.03297751f, 0.18839225f, -0.05434312f, -0.12237144f, 0.05380172f, 
    -0.04015645f, -0.00099239f, 0.35083804f, 0.07741258f, 0.05130782f, 0.10779764f, 0.06107765f, 0.14873093f, 
    0.16132410f, 0.25284487f, 0.00689672f, -0.08464482f, -0.08441737f, -0.09106684f, -0.17260715f, 0.00316027f, 
    0.05048027f, 0.08816256f, -0.03488125f, 0.10987267f, 0.17670077f, 0.11072076f, -0.15347332f, 0.26519793f, 
    0.09884075f, -0.11821153f, -0.13215841f, -0.13958257f, 0.08313641f, -0.14044227f, -0.02699666f, -0.24842398f, 
    0.13774340f, -0.05530044f, -0.02397863f, 0.15543441f, -0.00411170f, -0.09985230f, 0.57260603f, 0.21989834f, 
    -0.12325050f, 0.08253907f, 0.08448648f, 0.27093577f, -0.04119394f, -0.00761188f, -0.02301191f, -0.50721687f, 
    -0.09525578f, -0.09734564f, 0.13907972f, 0.16933337f, 0.07210858f, -0.13410209f, 0.03757820f, 0.02475892f, 
    0.04925122f, -0.25588509f, -0.07514076f, -0.06104674f, 0.09590960f, 0.07909112f, 0.08080989f, -0.07266472f, 
    -0.15576388f, 0.22276996f, 0.07036506f, -0.09170893f, -0.23949078f, -0.14952861f, 0.01616987f, 0.02201884f, 
    0.12727271f, -0.04998561f, -0.10349146f, 0.10024703f, 0.00353865f, 0.08679470f, -0.00117513f, 0.21935368f, 
    0.01013974f, 0.03672621f, 0.01865908f, 0.19729635f, 0.15446614f, 0.05773748f, 0.14383362f, 0.01912484f, 
    -0.01033250f, 0.08767877f, -0.03682028f, 0.17554449f, 0.16659690f, -0.31940046f, 0.08385866f, 0.16357218f, 
    0.03185091f, -0.02688904f, 0.15108627f, -0.00441865f, -0.02712499f, -0.20945154f, -0.21338011f, -0.16132571f, 
    -0.17678779f, 0.03167633f, -0.05984928f, -0.12277661f, -0.05582808f, -0.02534419f, -0.44845131f, -0.20315288f, 
    -0.22568363f, -0.04053409f, -0.04169143f, -0.10043795f, -0.09234141f, -0.00372863f, -0.08944528f, -0.32870477f, 
    0.14922945f, -0.39353812f, 0.05185458f, 0.00286969f, 0.10240946f, -0.11943690f, 0.04284972f, 0.06580441f, 
    0.26753986f, -0.19140831f, -0.09756492f, -0.11574610f, 0.16489865f, 0.25758389f, 0.17479871f, -0.07365946f, 
    -0.35884961f, -0.17493697f, -0.07995442f, -0.18559188f, -0.10031664f, 0.15611780f, 0.06287903f, 0.09512361f, 
    -0.02644494f, -0.00466001f, 0.00408895f, 0.05342621f, -0.05293788f, -0.07585954f, -0.07624929f, -0.26767057f, 
    -0.08179460f, 0.02674777f, 0.01497354f, 0.00975243f, -0.11510482f, 0.04106128f, 0.09778699f, 0.08562752f, 
    0.08745836f, 0.03423247f, 0.03034021f, 0.13248801f, 0.24971990f, 0.19468120f, -0.01914995f, -0.11385987f, 
    -0.15199317f, -0.01198956f, -0.13872357f, -0.13290974f, -0.09675810f, -0.58664954f, -0.24146995f, 0.15397283f, 
    0.14685988f, 0.11595943f, 0.04072104f, 0.11677758f, 0.00468143f, -0.20651574f, 0.05268740f, 0.05716501f, 
    -0.11827123f, 0.06365746f, 0.15108201f, 0.26137367f, -0.09525941f, -0.01412334f, -0.08216013f, 0.15325120f, 
    0.01003678f, 0.08998252f, 0.09703724f, 0.02068288f, -0.15091179f, 0.01020531f, 0.14801225f, 0.13038027f, 
    -0.46556371f, 0.09650750f, 0.14563642f, -0.09041211f, 0.06641243f, -0.01397994f, 0.04106963f, 0.07346833f, 
    0.15648496f, 0.26574311f, 0.13847338f, -0.34924862f, 0.06319846f, -0.34421736f, -0.02971169f, 0.03339483f, 
    0.12627703f, -0.18511435f, -0.01066038f, 0.27148271f, 0.15009817f, -0.02944787f, 0.06828202f, 0.04810926f, 
    -0.14377198f, -0.02489679f, 0.05084211f, 0.32024789f, 0.08025346f, -0.06823122f, 0.03914100f, -0.01862311f, 
    -0.01608376f, -0.03442731f, -0.01808212f, 0.04526946f, 0.07848498f, -0.13575512f, -0.10440227f, -0.09327863f, 
    -0.00356146f, -0.00373211f, 0.07285090f, 0.05316895f, -0.08736064f, 0.11175136f, -0.00669010f, 0.14578643f, 
    0.07089244f, 0.05374794f, -0.04884782f, -0.14960308f, -0.16141929f, 0.13943955f, 0.09286223f, -0.09173226f, 
    -0.12917578f, -0.02373172f, -0.00578140f, -0.17122836f, 0.12918548f, -0.03089487f, -0.04852394f, 0.00391670f, 
    0.29202452f, -0.22700743f, 0.14152978f, 0.01286616f, 0.07509298f, 0.12257777f, 0.01113491f, -0.16172245f, 
    -0.20161216f, -0.17939262f, -0.02821209f, 0.07311130f, -0.01983814f, 0.13831486f, -0.13891812f, 0.00298959f, 
    -0.01258953f, 0.40199721f, 0.24573478f, -0.25063521f, 0.06364436f, -0.03644479f, 0.09008372f, -0.22013046f, 
    0.07840112f, -0.11588190f, 0.19331351f, -0.15949234f, -0.22247244f, 0.12149366f, 0.19778839f, -0.04489095f, 
    0.09409725f, -0.04913739f, -0.11796322f, -0.09499749f, -0.15092891f, -0.15437342f, -0.18708254f, -0.16738601f, 
    -0.04355850f, 0.06310562f, 0.10243616f, 0.03284172f, 0.04144584f, 0.16777426f, -0.01941536f, 0.06405179f, 
    0.06657986f, -0.01047375f, -0.04439596f, 0.10217615f, 0.01682882f, 0.25839198f, -0.11339942f, 0.17903548f, 
    0.07376152f, -0.00854570f, -0.14058135f, 0.15475506f, 0.14415565f, -0.13560490f, 0.10670970f, 0.07890540f, 
    -0.53772122f, 0.15172943f, -0.04430036f, -0.09920090f, 0.06852888f, 0.06357800f, 0.16619126f, 0.30817208f, 
    -0.32028723f, 0.07004712f, -0.09810513f, 0.12952909f, 0.07945976f, 0.07698416f, -0.21358612f, 0.04863269f, 
    -0.00441453f, -0.16738328f, -0.34531960f, 0.10548169f, 0.12563904f, 0.08980273f, -0.04693640f, 0.17198256f, 
    0.12791939f, 0.03998782f, 0.04774243f, 0.37571397f, 0.19696170f, -0.13583630f, -0.13311547f, 0.03613706f, 
    -0.02523367f, 0.13685158f, -0.15276331f, -0.24288779f, -0.30827251f, 0.08522978f, 0.17969261f, 0.07400744f, 
    0.09895134f, 0.00718595f, -0.11092629f, 0.23786311f, 0.16090681f, -0.12216792f, 0.06769967f, 0.05181362f, 
    -0.17198670f, 0.10673521f, -0.02734905f, -0.12385282f, 0.11215320f, 0.11269113f, -0.28986132f, 0.05858434f, 
    -0.06086617f, 0.07883491f, -0.24262300f, -0.13874756f, -0.20333447f, -0.12995996f, 0.07167185f, 0.10947303f, 
    0.19457582f, -0.10066867f, 0.14803769f, -0.00771380f, -0.18093199f, -0.01279975f, -0.09359558f, -0.06167892f, 
    0.28633729f, -0.14131327f, -0.03338984f, 0.11483611f, -0.24614048f, 0.21278393f, 0.10294144f, -0.21342614f, 
    0.01257055f, 0.17950758f, -0.10704695f, 0.07261337f, -0.05180658f, -0.02299187f, -0.00764954f, 0.01680456f, 
    -0.16180184f, -0.09358022f, -0.25211319f, 0.07578219f, 0.18469074f, -0.06713056f, -0.08362851f, 0.10314186f, 
    -0.04353829f, -0.19320223f, -0.14364283f, 0.16795297f, 0.05565580f, -0.14899823f, -0.11561777f, 0.02586010f, 
    0.11399562f, -0.09091758f, -0.05014972f, 0.05280131f, 0.30298883f, -0.11565814f, -0.09800676f, 0.06885759f, 
    0.06365517f, 0.09821696f, -0.12426881f, -0.23397049f, -0.21738753f, -0.23958793f, 0.00007006f, -0.09282535f, 
    -0.04007577f, 0.15078267f, -0.11434665f, 0.09920591f, 0.02046920f, 0.06217152f, 0.35232353f, -0.14650844f, 
    -0.15645820f, -0.03317634f, -0.07977392f, 0.14533524f, 0.16941476f, 0.01584115f, -0.01083387f, -0.18107979f, 
    -0.04889431f, 0.20864388f, 0.08040100f, -0.17174904f, -0.10478004f, -0.11034013f, 0.11057530f, 0.10296794f, 
    0.25476089f, -0.15918635f, -0.03015360f, -0.01040360f, -0.04564929f, 0.08675791f, 0.14738095f, 0.28555870f, 
    0.16837224f, -0.01322396f, -0.08482669f, -0.06205986f, 0.03201453f, -0.02739031f, -0.07157940f, 0.23176417f, 
    0.08289490f, -0.30476084f, -0.03873923f, -0.18823454f, 0.10105750f, -0.05812278f, -0.05635389f, 0.01678922f, 
    -0.08229043f, -0.19252665f, 0.00898517f, -0.46292976f, -0.00993723f, 0.11191978f, -0.06755114f, 0.06469204f, 
    0.00258656f, 0.10722341f, -0.04184538f, -0.08351350f, -0.13661589f, -0.02126517f, 0.11445574f, -0.00412167f, 
    0.06687023f, 0.04938003f, 0.02155919f, 0.20795608f, 0.25108990f, 0.38393131f, -0.04377687f, -0.04020462f, 
    -0.16990519f, -0.07441530f, 0.07881404f, 0.02239671f, -0.18171808f, 0.03138852f, -0.04959464f, -0.01797482f, 
    0.06041011f, -0.00728545f, -0.19342180f, 0.12062478f, -0.06416558f, -0.02672975f, -0.08050843f, 0.10766758f, 
    0.10615166f, -0.02074125f, 0.01420031f, 0.10004765f, -0.07090157f, -0.08553115f, 0.27496561f, 0.00133342f, 
    -0.30143350f, 0.18025306f, 0.00281102f, 0.09364451f, 0.03864496f, 0.00870880f, 0.03018902f, -0.08820613f, 
    0.06454033f, -0.21888465f, 0.08055889f, 0.10757741f, 0.21105854f, -0.05179648f, -0.00525757f, -0.05121432f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    -0.10779911f, -0.00699624f, -0.05985943f, -0.04123945f, 0.05134807f, 0.10922692f, 0.03151932f, 0.04196516f, 
    0.08108401f, 0.25092632f, 0.03395152f, 0.25370067f, 0.07846931f, 0.15879577f, -0.01843905f, 0.11651205f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.08828313f, -0.16968565f, 0.24630454f, -0.00570482f, -0.09724950f, 0.17484546f, -0.14567733f, 0.14674827f, 
    -0.23490393f, 0.00982626f, -0.16623564f, -0.05618163f, 0.02077007f, -0.22627115f, -0.13293125f, 0.03930302f, 
    0.17668636f, -0.02403374f, 0.07510528f, 0.23774861f, -0.31407669f, -0.21306199f, 0.10300289f, -0.14509720f, 
    0.46779734f, -0.19528092f, 0.68645757f, 0.25916713f, -0.34970769f, 0.01061925f, -0.06186892f, 0.14453116f, 
    0.48267156f, 0.01374184f, -0.12698920f, 0.03136027f, 0.38615516f, 0.05591856f, -0.20716469f, -0.24165967f, 
    -0.13000640f, -0.32329708f, -0.05966729f, 0.13718425f, -0.36385253f, -0.02490792f, 0.53395927f, 0.37096149f, 
    0.07366028f, 0.27030560f, 0.22536923f, -0.20904508f, 0.04697423f, -0.58889282f, -0.25300756f, -0.06210342f, 
    0.12346248f, 0.38124582f, -0.39877909f, -0.03744499f, -0.21865992f, 0.32773298f, 0.11311415f, 0.15563180f, 
    0.16844667f, -0.24666296f, -0.16349347f, -0.12581612f, -0.01805384f, -0.34109908f, 0.04013149f, -0.13131116f, 
    -0.60258478f, 0.29846349f, 0.20204799f, 0.50054914f, 0.04009962f, -0.20996085f, -0.06603179f, 0.16269080f, 
    -0.22738974f, 0.34800327f, 0.03809275f, -0.13420504f, 0.16335401f, 0.05121224f, 0.08151278f, -0.16604660f, 
    0.32695439f, -0.06544757f, 0.27222106f, 0.11587008f, -0.76179844f, 0.28145102f, -0.25968319f, 0.19094798f, 
    -0.21631140f, -0.07897046f, 0.02268028f, -0.02774057f, 0.06586027f, -0.24770364f, 0.19578940f, -0.02043882f, 
    -0.23285943f, 0.19006979f, -0.15856689f, -0.12429002f, 0.21242672f, -0.14974993f, -0.10080880f, -0.13440961f, 
    -0.42254224f, 0.07059933f, -0.02979514f, -0.12695031f, -0.30067775f, -0.25355420f, 0.17578194f, 0.16092277f, 
    -0.16922040f, 0.07046350f, 0.10145743f, 0.29922280f, 0.10306402f, -0.11458289f, -0.33208060f, 0.46673203f, 
    -0.23938493f, 0.00903067f, 0.17296949f, 0.09443297f, -0.09307078f, -0.31609875f, -0.17162493f, -0.14910337f, 
    -0.32710254f, 0.22800243f, -0.22645320f, 0.24064808f, 0.21667798f, -0.28593168f, 0.12501693f, 0.15900248f, 
    0.49366623f, -0.38524979f, -0.22840239f, 0.08643589f, -0.27661237f, 0.39508900f, -0.08266222f, -0.21080518f, 
    -0.44437948f, 0.23528311f, 0.50420356f, -0.27805579f, -0.02779491f, -0.11295547f, -0.16765924f, 0.58431870f, 
    0.24688067f, 0.21229492f, 0.05610800f, 0.09768783f, 0.31694677f, -0.15159857f, -0.08755754f, -0.08324178f, 
    -0.37913948f, 0.10941565f, -0.14298721f, 0.04274276f, 0.03951589f, -0.10187666f, -0.17371574f, -0.35161662f, 
    0.18034048f, 0.28617522f, -0.18110433f, 0.12878114f, 0.11645139f, -0.24703190f, 0.13056447f, -0.10423341f, 
    0.22502372f, 0.14583057f, 0.30447704f, 0.02875690f, 0.65688360f, 0.17274471f, -0.26361924f, -0.47105566f, 
    0.32558727f, 0.10297389f, -0.04150012f, -0.24700347f, -0.32048815f, 0.57000339f, -0.01448652f, -0.17377222f, 
    0.29421094f, -0.32924548f, 0.35255989f, -0.08351259f, 0.05786046f, 0.38071734f, 0.21583335f, -0.02570170f, 
    0.02107181f, 0.37886900f, -0.15023796f, 0.03952949f, -0.21249098f, 0.31033722f, -0.10117044f, 0.12755762f, 
    0.57706052f, -0.33140671f, 0.34129971f, 0.22748096f, -0.22046463f, -0.40070185f, 0.42261848f, 0.23014669f, 
    -0.05096598f, 0.06521099f, 0.20124848f, -0.02463704f, 0.37163520f, -0.14610560f, -0.14625333f, -0.01315612f, 
    -0.83715010f, 0.03063677f, -0.13172013f, 0.19100827f, 0.12696859f, -0.28708109f, -0.00473790f, -0.00895601f, 
    -0.26673183f, -0.19449849f, 0.19962628f, -0.15054166f, -0.08755228f, 0.13295837f, 0.23559424f, -0.11386537f, 
    0.53162575f, 0.19712827f, 0.46337891f, 0.16722476f, 0.00812649f, 0.14181446f, 0.06592040f, 0.14190964f, 
    0.49468943f, -0.20910183f, 0.07279605f, 0.04530812f, 0.30498904f, 0.04673854f, -0.16408911f, 0.07573961f, 
    0.31410977f, -0.31716970f, 0.19354394f, -0.15273160f, 0.28180981f, 0.05285423f, 0.50864637f, -0.28970808f, 
    -0.05522251f, -0.23850599f, -0.14257935f, -0.03309068f, 0.14134318f, -0.23303086f, -0.12744066f, -0.17447573f, 
    0.00660649f, -0.00021899f, -0.15845472f, -0.17466341f, 0.21028818f, -0.21519387f, -0.04711478f, -0.03631509f, 
    0.05466972f, 0.00961648f, 0.01566740f, 0.06553819f, -0.17531386f, 0.27619192f, -0.02026842f, 0.18422243f, 
    0.27818337f, -0.31949663f, 0.41432261f, 0.19411753f, 0.18098660f, -0.05585102f, 0.22172672f, 0.26615185f, 
    0.56592274f, -0.07735483f, -0.23820108f, 0.18261398f, -0.19753498f, 0.19959134f, -0.07424814f, 0.12330059f, 
    -0.63767922f, -0.08871299f, 0.40104815f, 0.38486412f, 0.27142191f, 0.01357992f, -0.14412314f, -0.30912134f, 
    0.44907787f, 0.10086410f, 0.18805423f, -0.19837204f, 0.25884023f, 0.09884899f, -0.03961039f, 0.04959659f, 
    0.16801777f, -0.44953141f, 0.17663951f, 0.09901374f, -0.06458624f, 0.22093213f, 0.06214753f, -0.40732306f, 
    -0.16254812f, 0.37199911f, 0.14367495f, -0.21464017f, 0.30310619f, 0.09131348f, 0.18980695f, -0.02128901f, 
    0.95621699f, 0.25364375f, 0.14132464f, -0.31618354f, 0.34671339f, 0.03963343f, -0.06401494f, 0.07757321f, 
    0.46152613f, 0.14440690f, -0.09747841f, 0.00753045f, 0.31660873f, 0.11923335f, 0.01972093f, 0.13646917f, 
    -0.08197946f, -0.05841422f, 0.03551327f, 0.01910841f, -0.02277430f, 0.10946058f, -0.20246407f, -0.37192360f, 
    -0.23353674f, -0.13304873f, 0.04865516f, 0.06364972f, -0.17639975f, -0.10189483f, -0.05156716f, 0.20636810f, 
    0.08561213f, 0.12167896f, 0.40679657f, 0.25547040f, 0.31198254f, 0.31375894f, -0.07078210f, -0.04146019f, 
    -0.35874766f, 0.40283358f, 0.14483707f, 0.01066423f, -0.17963737f, -0.19482997f, -0.21732882f, -0.04842758f, 
    0.01682194f, 0.42977849f, -0.17447162f, -0.13089919f, -0.39580792f, 0.04829797f, 0.04068746f, 0.45260903f, 
    -0.04600231f, -0.05371019f, 0.22762707f, 0.00568046f, 0.44029170f, -0.39756662f, 0.18315573f, -0.23043734f, 
    -0.68002629f, -0.05175940f, -0.07159430f, 0.18217346f, 0.27085420f, -0.01229273f, -0.04419324f, -0.35431752f, 
    -0.57160598f, 0.22990379f, 0.16245359f, 0.21357331f, -0.71787292f, 0.02205564f, 0.04997244f, 0.23426864f, 
    -0.01150452f, -0.20013411f, -0.41250503f, 0.06517982f, 0.37106010f, -0.01788116f, 0.02960271f, 0.29733163f, 
    0.11546072f, -0.13551271f, -0.03668255f, -0.01595083f, -0.18526042f, -0.16438264f, 0.23991957f, -0.16124344f, 
    -0.04650334f, -0.18303329f, -0.12316880f, -0.17867830f, -0.12872580f, -0.14951605f, 0.08056220f, -0.23684031f, 
    -0.12209069f, -0.13583067f, 0.16444001f, -0.07129040f, -0.28139997f, -0.09969634f, 0.08727206f, -0.02127445f, 
    0.39083794f, 0.16851822f, 0.31451672f, 0.18531547f, 0.16207670f, 0.10722139f, 0.39053088f, 0.34431800f, 
    0.11936951f, 0.28974161f, -0.07191616f, 0.10196120f, -0.32259294f, -0.36416152f, -0.01992241f, 0.00417650f, 
    0.44075242f, -0.31631228f, 0.22128065f, -0.07646504f, 0.50504243f, 0.08579952f, 0.58203572f, -0.40371445f, 
    0.27995160f, -0.02601546f, -0.14823517f, 0.14075775f, 0.42047697f, -0.12580946f, -0.07066980f, 0.10617846f, 
    -0.12358106f, 0.18790233f, -0.07656285f, 0.32805070f, -0.12366553f, -0.30261853f, -0.35492441f, -0.31111729f, 
    -0.12241920f, -0.23526849f, -0.20961639f, -0.18191162f, 0.12652588f, 0.14998131f, 0.16742682f, -0.09762390f, 
    0.24882360f, 0.40526903f, 0.28085402f, 0.04938541f, 0.12747666f, 0.33133104f, -0.32760078f, 0.27912721f, 
    -0.00062033f, 0.07520819f, -0.17542617f, 0.20828734f, -0.57693487f, -0.08418290f, -0.02814907f, 0.05860716f, 
    -1.00689530f, 0.11503021f, 0.35414055f, 0.39189538f, -0.13252705f, -0.26993802f, 0.17663503f, -0.09385053f, 
    -0.12536366f, -0.22158182f, -0.20182869f, 0.16649199f, 0.19121727f, 0.26727515f, 0.09730238f, 0.11015558f, 
    0.75290734f, 0.28835461f, 0.20287111f, -0.19152248f, -0.04134610f, 0.32559854f, -0.57252085f, 0.27599704f, 
    0.40700898f, -0.33768621f, -0.17702131f, -0.07134489f, 0.25468087f, 0.02062142f, 0.05923719f, -0.00314226f, 
    -0.39076129f, -0.41307029f, 0.13131762f, 0.30244565f, 0.55391902f, -0.17262831f, 0.20967937f, -0.02040078f, 
    -0.20247620f, -0.25647807f, 0.01181857f, 0.21721074f, 0.05569804f, 0.16810131f, -0.21576208f, -0.07223313f, 
    0.32705584f, 0.19974549f, 0.49885178f, 0.17414907f, 0.22898321f, 0.25707951f, -0.07763036f, -0.18731129f, 
    -0.15778452f, -0.32754022f, -0.03301155f, 0.01027863f, 0.18510319f, 0.24132527f, -0.11464174f, -0.13526760f, 
    0.01231883f, -0.23335941f, 0.52901697f, 0.12927958f, 0.40033099f, 0.14714229f, -0.00321205f, -0.25911203f, 
    -0.09073184f, 0.40794376f, -0.17843822f, 0.15731518f, -0.37070900f, -0.57931501f, 0.25362238f, -0.16088881f, 
    0.04010591f, 0.02560414f, -0.23597856f, 0.19629513f, 0.41263407f, -0.07155514f, 0.03596631f, 0.28896099f, 
    -0.27139190f, 0.34576029f, -0.14488162f, -0.21517944f, 0.23048793f, -0.47250909f, -0.15823947f, -0.17523883f, 
    -0.00972338f, 0.37438062f, -0.30269244f, 0.16319962f, 0.08508688f, -0.23141077f, -0.20171127f, -0.01301058f, 
    -0.03529492f, -0.25239730f, -0.05889925f, 0.09894946f, -0.82164282f, 0.53099716f, 0.13214195f, 0.11447179f, 
    -1.30331600f, 0.25283846f, -0.35277033f, 0.20968646f, 0.29240578f, 0.05268056f, -0.19581963f, -0.03913061f, 
    -0.04340563f, 0.23425457f, -0.04500273f, -0.12304822f, 0.05463753f, 0.50608379f, 0.00484952f, -0.15442994f, 
    0.11731100f, -0.36242759f, -0.02698341f, 0.34053177f, -0.49144572f, 0.19892904f, -0.32643723f, -0.44017908f, 
    -0.17116351f, 0.21128631f, 0.12781708f, -0.03896599f, 0.04097307f, -0.49679667f, -0.10125877f, 0.04818466f, 
    0.43444976f, -0.39123815f, 0.19257548f, 0.18243948f, 0.50451064f, -0.27467847f, -0.41610047f, 0.26642632f, 
    0.07076890f, -0.13832948f, 0.08027631f, 0.01271600f, -0.03294622f, 0.39212272f, -0.14203021f, -0.13333514f, 
    -1.23651731f, 0.29079917f, -0.13870318f, 0.01231841f, -0.09366189f, 0.49302948f, -0.65945911f, 0.21060336f, 
    -0.17769359f, -0.16600177f, -0.03552083f, -0.21660571f, 0.18630315f, 0.33222032f, 0.19434533f, 0.05098531f, 
    0.52049762f, 0.37277433f, -0.25355420f, -0.07558759f, 0.04792375f, 0.27958134f, -0.53942204f, 0.24708718f, 
    -0.18202278f, 0.27870834f, -0.05261793f, -0.16951321f, 0.23605762f, -0.02148336f, 0.08063851f, -0.10618987f, 
    -0.30716980f, 0.27228507f, 0.02064353f, -0.03254357f, -0.56338710f, 0.06760306f, -0.31628463f, 0.12361850f, 
    -0.14800063f, 0.04732168f, -0.08824313f, 0.18729566f, -0.32443538f, 0.03277467f, -0.10740389f, -0.14001186f, 
    -0.53234416f, 0.01528764f, -0.27448332f, 0.28862306f, -0.31466338f, 0.29416910f, 0.12026414f, 0.31125313f, 
    0.25646177f, 0.14444023f, 0.00638922f, -0.05170772f, 0.35555920f, -0.27474222f, 0.14198984f, 0.05348202f, 
    -0.46675414f, -0.09968166f, 0.08458731f, 0.29566228f, 0.41752213f, -0.18866400f, -0.27546975f, -0.25611010f, 
    -0.12231573f, 0.27825508f, 0.19095573f, -0.23953293f, -0.38887170f, 0.39113727f, -0.06020295f, 0.07996152f, 
    0.59208179f, 0.03202060f, -0.05701975f, 0.10083024f, -0.17871116f, 0.24616873f, 0.35487187f, 0.13398074f, 
    0.17306042f, 0.50907725f, 0.07846230f, -0.25194135f, -0.33983541f, -0.33311310f, 0.05156567f, 0.07036076f, 
    0.03072283f, 0.14576188f, 0.25210172f, 0.15387376f, -0.58458847f, -0.10268065f, -0.21648476f, 0.23902552f, 
    0.31681323f, 0.10726170f, 0.11188878f, -0.04451709f, 0.26762447f, 0.16870145f, -0.21668448f, 0.21057481f, 
    1.19924045f, -0.39433011f, -0.22058436f, -0.02974451f, 0.24197040f, 0.23061801f, 0.14037275f, -0.29820657f, 
    0.13979980f, -0.20432740f, 0.04301199f, -0.22092533f, -0.45190209f, 0.38858271f, -0.22678950f, 0.21893400f, 
    -1.30986655f, 0.41557229f, -0.86687523f, 0.26473439f, 0.24667169f, 0.18792702f, -0.22944325f, -0.22763792f, 
    0.33245519f, 0.14423874f, 0.14084548f, 0.04704823f, -0.14356616f, 0.22849183f, 0.19465056f, 0.24158272f, 
    -0.74940121f, -0.06032126f, -0.46772367f, 0.00893801f, -0.09910880f, 0.02105614f, 0.41802132f, 0.18356855f, 
    -0.39713886f, -0.10342546f, 0.06615052f, -0.22923537f, -0.21429065f, -0.18063554f, -0.12819758f, -0.02600388f, 
    0.43179125f, 0.25915483f, -0.17001414f, 0.33047286f, -0.14826921f, 0.17668089f, 0.34311295f, 0.25748023f, 
    -0.20800298f, 0.46233705f, -0.05657759f, -0.24500346f, -0.18495895f, 0.74668735f, -0.03532377f, -0.21475977f, 
    0.42029327f, 0.26395702f, -0.25728330f, -0.07620955f, -0.31004226f, 0.07385302f, 0.17326155f, -0.24190448f, 
    -0.21123160f, -0.19702837f, 0.22744602f, -0.04688487f, -0.10661186f, -0.21784994f, -0.18278688f, -0.04817145f, 
    -0.04127479f, 0.09488514f, 0.04705963f, -0.02477749f, -0.06324161f, 0.05748115f, -0.11293332f, -0.26026073f, 
    -0.11728140f, -0.25458682f, 0.09361119f, -0.14772598f, -0.03113802f, 0.01765460f, -0.01866212f, -0.17595638f, 
    -0.08805283f, -0.25954768f, 0.04902343f, -0.11905354f, 0.07753224f, 0.11447760f, 0.16515169f, -0.22365014f, 
    -0.22718218f, -0.10431527f, 0.07558042f, -0.00660208f, -0.58007914f, 0.45669144f, -0.09549136f, 0.04358199f, 
    -1.02919126f, 0.00032994f, -0.29085711f, 0.39860502f, -0.13776486f, -0.18488947f, 0.59754205f, -0.19812939f, 
    -0.33338398f, 0.06637089f, 0.22475882f, -0.24995252f, -0.22474164f, -0.00209171f, -0.07343901f, 0.13569827f, 
    -0.42044222f, -0.08959611f, -0.21948674f, 0.27538350f, -0.27226278f, 0.09625936f, -0.01618131f, 0.46626341f, 
    0.06090351f, 0.25969040f, -0.06488261f, 0.19392939f, 0.41683564f, -0.16530471f, 0.15996389f, -0.15877731f, 
    0.05416005f, -0.03166361f, -0.17301057f, -0.14556624f, 0.18546271f, 0.15908656f, -0.09700108f, -0.01388789f, 
    -0.35247448f, 0.02894868f, -0.14590433f, -0.10594436f, -0.18214552f, -0.52091300f, -0.20272961f, -0.23199299f, 
    0.83008391f, 0.07668537f, 0.37484771f, 0.06362691f, 0.61749929f, 0.18450592f, -0.08919371f, -0.04550591f, 
    -0.00776665f, -0.28594446f, 0.13639373f, 0.19010830f, -0.08715746f, -0.05390455f, 0.11920944f, -0.03065720f, 
    -0.01747898f, -0.12947476f, -0.27323171f, -0.03669217f, 0.18250866f, -0.10187466f, 0.15456939f, -0.12231578f, 
    0.27283493f, 0.43475828f, -0.00326021f, -0.16614509f, 0.32030958f, -0.25621620f, 0.08351400f, -0.16112176f, 
    0.09190073f, 0.23268379f, 0.02095102f, -0.14499377f, -0.29431999f, -0.29525849f, 0.16349985f, 0.16105032f, 
    0.23497979f, 0.23460896f, 0.21695931f, 0.00392648f, 0.22142547f, -0.26969296f, -0.11889704f, -0.02512927f, 
    -0.43930075f, -0.13114452f, -0.40016028f, -0.01629185f, 0.23364204f, 0.20287712f, 0.05389976f, 0.25031704f, 
    -0.14758965f, -0.14666142f, -0.18872502f, 0.21362329f, -0.05690313f, -0.05900189f, 0.11072472f, -0.14939582f, 
    -0.07218250f, -0.17885357f, 0.11908776f, -0.02422930f, -0.23957089f, 0.11217414f, -0.10897487f, -0.06322565f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.17743251f, 0.00882923f, -0.36766377f, -0.13321277f, 0.41772312f, -0.06296457f, -0.18090105f, 0.22267076f, 
    0.35907331f, -0.25291210f, 0.33937964f, 0.24116851f, -0.42124465f, -0.46137744f, 0.41487962f, 0.14575686f, 
    0.00354030f, -0.26557735f, 0.50896549f, 0.22081597f, 0.09005225f, -0.17283820f, 0.07573860f, 0.52030379f, 
    0.42301932f, 0.45156711f, -0.24699277f, 0.12713563f, 0.53253168f, -0.03075585f, -0.16233835f, -0.02218898f, 
    -0.22846451f, -0.01499189f, 0.21650651f, -0.07013398f, 0.40263754f, -0.05453271f, 0.39109123f, -0.22170505f, 
    0.20406628f, 0.00816814f, -0.02342102f, 0.46854022f, 0.47264177f, 0.52492380f, -0.11337186f, -0.14674537f, 
    -0.27054557f, -0.03142575f, 0.00303089f, 0.42975128f, 0.55147159f, 0.14830573f, 0.19673157f, 0.03342209f, 
    -0.08522717f, 0.65118992f, 0.34116015f, 0.42059186f, -0.16203439f, -0.18935905f, 0.01517385f, 0.03589043f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.02252513f, 0.23254669f, -0.01233484f, 0.05327004f, 0.14847541f, 0.20583220f, -0.06160900f, 0.35358235f, 
    0.33504978f, -0.46241876f, -0.08558755f, -0.17858019f, 0.11411846f, 0.30544803f, -0.03970079f, 0.10560222f, 
    -0.55484241f, -0.02793823f, 0.15937017f, -0.01755086f, -0.13193612f, -0.04793425f, -0.16369608f, 0.14183515f, 
    0.65648711f, -0.23739204f, 0.34680414f, -0.08064792f, 0.16982092f, 0.00723536f, -0.22137649f, -0.13307483f, 
    0.50076675f, -0.27487162f, -0.32129392f, -0.14964849f, -0.36617070f, 0.35265201f, 0.04069912f, 0.48340484f, 
    0.09950441f, 0.03335689f, -0.21972224f, -0.05856089f, 0.30793238f, 0.44453219f, -0.24761935f, 0.17431748f, 
    0.55483514f, -0.17898160f, -0.11862993f, 0.49244171f, 0.15052150f, 0.14389461f, -0.05497962f, -0.14432232f, 
    0.14794068f, 0.64364189f, -0.15852471f, 0.01187993f, -0.06853488f, -0.01746119f, 0.09057672f, -0.04896584f, 
    0.11789969f, -0.01995146f, -0.02637877f, 0.08819068f, -0.14932302f, -0.01567226f, -0.05364728f, -0.12915793f, 
    0.01761061f, -0.00307773f, -0.03605814f, -0.05588074f, -0.00159803f, -0.08737309f, -0.05735107f, -0.15311486f, 
    0.00763875f, 0.08450788f, -0.02147715f, 0.09064715f, -0.10063044f, 0.00031540f, -0.12042166f, -0.12128888f, 
    0.09727059f, 0.01727160f, 0.09912519f, -0.11019084f, -0.04187793f, 0.03693919f, -0.01858150f, -0.00233764f, 
    -0.01804878f, -0.07721669f, 0.01771121f, -0.02339840f, 0.01008994f, 0.05102194f, -0.05895073f, 0.11016060f, 
    -0.02873046f, -0.13101055f, 0.02525832f, 0.06215928f, -0.04142984f, -0.11898906f, -0.07696883f, -0.06172999f, 
    -0.11823313f, -0.00480811f, -0.12388873f, 0.07482246f, -0.12529334f, -0.01333641f, 0.00407645f, -0.05206668f, 
    0.09543769f, -0.11255339f, 0.09232422f, -0.05768036f, 0.06324486f, -0.02410890f, 0.01957256f, 0.12353010f, 
    0.06864375f, -0.10910413f, -0.10263932f, -0.00298589f, 0.09578015f, -0.00483125f, 0.00260760f, 0.00036021f, 
    -0.12060148f, 0.07795453f, -0.09967831f, 0.05517119f, -0.10743391f, -0.13757466f, 0.09801514f, 0.02325017f, 
    -0.02201397f, -0.01658611f, 0.08691445f, 0.09304076f, 0.07956967f, 0.04193494f, -0.01098619f, -0.04724628f, 
    -0.04806587f, 0.05674206f, 0.02234302f, 0.12216760f, -0.06680886f, -0.06012942f, -0.03725659f, 0.03993721f, 
    -0.07534456f, -0.14514865f, -0.11854103f, -0.06349762f, -0.01679654f, 0.04233505f, -0.01869530f, -0.00558506f, 
    -0.04466880f, -0.09271204f, 0.03774193f, -0.12996136f, -0.11360977f, -0.03333089f, -0.10936988f, -0.13348120f, 
    -0.08727929f, 0.04784823f, -0.10940855f, 0.03476152f, -0.03804275f, -0.01441271f, 0.08271001f, 0.02896734f, 
    -0.07831687f, -0.09430192f, -0.01038045f, 0.07523047f, 0.11147045f, -0.10618971f, 0.06557869f, -0.05526543f, 
    0.00114554f, 0.06496860f, -0.04570191f, 0.10579848f, -0.15234278f, 0.03488277f, 0.01809385f, -0.08491126f, 
    -0.23115423f, 0.03133238f, 0.01326570f, 0.18299960f, 0.46250096f, -0.12027345f, -0.27676117f, 0.00777942f, 
    0.43973747f, -0.02748401f, 0.05017322f, 0.04048081f, 0.34989604f, -0.01520642f, 0.22997309f, 0.13270615f, 
    -0.11800029f, -0.03951407f, 0.40852106f, -0.02696872f, 0.03717821f, 0.51830792f, -0.06581725f, 0.12721610f, 
    -0.32750529f, 0.52446753f, -0.01465867f, 0.14362928f, 0.32827926f, 0.04693006f, -0.04507927f, -0.18810071f, 
    -0.08082319f, -0.25327682f, 0.65018499f, 0.38344312f, 0.00959833f, 0.04846551f, -0.16255632f, 0.18844588f, 
    -0.20836940f, 0.16337802f, 0.04045519f, 0.00373406f, 0.11616299f, 0.24210477f, -0.05692935f, 0.01491819f, 
    -0.55318284f, -0.00375948f, 0.11968733f, 0.33713645f, -0.10084830f, -0.11269347f, -0.00173466f, -0.12887971f, 
    0.12037133f, -0.02980568f, 0.02521869f, -0.08362780f, -0.10941496f, 0.08063512f, 0.07998982f, -0.10839793f, 
    -0.04873035f, 0.02447589f, -0.05646630f, -0.07222340f, -0.05456899f, -0.10636912f, 0.02283943f, -0.11702352f, 
    -0.05978264f, 0.12162361f, -0.01473526f, -0.04718632f, -0.10211153f, 0.01187584f, -0.06426859f, -0.04360775f, 
    0.08614852f, -0.06425940f, 0.03311600f, 0.06479019f, 0.07820865f, -0.12409128f, 0.05073774f, -0.13119899f, 
    0.07765637f, 0.02840446f, 0.07786721f, 0.11037133f, 0.04982811f, -0.04488598f, -0.07313213f, -0.11441745f, 
    -0.09038596f, -0.02917886f, 0.05129056f, -0.06978779f, -0.04303132f, -0.06116357f, 0.10309993f, -0.09433122f, 
    0.04980230f, -0.12399955f, -0.02076505f, -0.05829297f, -0.04870187f, 0.02280422f, 0.09004475f, 0.03410674f, 
    0.08996670f, -0.03026779f, -0.11110885f, -0.06188146f, 0.12017798f, 0.01098235f, 0.01379846f, 0.09483419f, 
    0.11477172f, -0.05521048f, -0.08031628f, -0.11395395f, 0.00673371f, -0.06072001f, 0.02536766f, -0.12130237f, 
    -0.03868764f, -0.05713883f, -0.07323466f, 0.03594813f, 0.00627720f, -0.09445804f, -0.06952056f, 0.08701003f, 
    0.00161261f, 0.07836871f, 0.00136584f, -0.10141824f, -0.02049984f, -0.09502413f, -0.07269900f, 0.10652456f, 
    -0.03542908f, 0.02810402f, 0.02728060f, -0.08730216f, -0.02051967f, -0.00360094f, -0.01306160f, -0.02990117f, 
    -0.03055947f, -0.11874054f, -0.01071334f, 0.01769526f, -0.08782029f, 0.09172397f, 0.06556604f, -0.11282805f, 
    -0.04720435f, -0.13782978f, -0.05725314f, 0.08814463f, -0.02029922f, 0.10967558f, -0.01518926f, -0.12169784f, 
    -0.10211617f, 0.09852297f, 0.06425250f, -0.12369002f, -0.06822474f, 0.11532100f, -0.04608802f, -0.05823682f, 
    -0.08466348f, -0.10454901f, 0.02448509f, -0.12456819f, -0.08560234f, -0.05130329f, 0.08443549f, -0.11141901f, 
    -0.11333999f, -0.11346219f, -0.08269665f, -0.13811176f, -0.04987124f, -0.11051707f, 0.03186837f, 0.08932283f, 
    -0.00637710f, 0.11947673f, -0.15608697f, -0.11978532f, 0.05969363f, -0.06611351f, -0.01220955f, -0.04170961f, 
    0.11298155f, 0.05823153f, -0.10546952f, -0.10439189f, 0.06772845f, 0.05889247f, 0.02544988f, -0.12594819f, 
    0.06175005f, 0.02711334f, -0.11074701f, -0.02999327f, 0.09658382f, -0.11505841f, -0.06712127f, -0.01711081f, 
    -0.06553846f, -0.11718365f, 0.07955334f, 0.07003511f, -0.01370165f, -0.07468759f, 0.09667721f, -0.11352264f, 
    0.11457141f, 0.06673468f, -0.11818746f, -0.01435257f, 0.04642725f, 0.07301660f, -0.03447085f, -0.13530500f, 
    0.05306480f, -0.11315520f, 0.05442939f, -0.04848156f, 0.07480553f, 0.08022636f, 0.04511411f, -0.02016218f, 
    0.09612199f, 0.01207954f, -0.00583414f, -0.01248125f, -0.10758571f, 0.04777797f, -0.07056854f, 0.09598018f, 
    -0.10047908f, -0.16408731f, 0.29044524f, 0.28177139f, -0.06454951f, 0.13741240f, -0.02567944f, -0.21361439f, 
    0.03514246f, 0.04969075f, 0.23074761f, 0.22387908f, -0.33788064f, 0.16798200f, 0.37326631f, -0.16461979f, 
    -0.04868493f, 0.03802870f, -0.05629272f, -0.11571087f, 0.10140622f, 0.34525245f, 0.22259888f, -0.35259297f, 
    0.19855163f, 0.25982103f, -0.05505050f, -0.03513879f, -0.32633376f, -0.00337055f, 0.44694686f, -0.14969391f, 
    0.01455090f, -0.14010774f, -0.02366255f, -0.14620744f, -0.53708994f, 0.29530659f, 0.41647074f, -0.49730614f, 
    0.05458866f, 0.07106119f, -0.18229948f, -0.30712822f, 0.13739029f, -0.31521565f, 0.39719298f, 0.05067233f, 
    0.25984886f, -0.10864095f, -0.17933948f, -0.11454653f, -0.17508847f, -0.13375182f, 0.01015043f, 0.09852324f, 
    0.16587150f, -0.39623645f, 0.18387976f, -0.28150159f, 0.01981257f, 0.50215256f, 0.29588079f, -0.04218784f, 
    -0.00326903f, -0.07006797f, -0.11160637f, 0.14821893f, -0.03981292f, 0.02630830f, 0.10053602f, 0.41587037f, 
    0.61169428f, -0.48611432f, -0.02875931f, 0.13049938f, -0.16910091f, 0.21707088f, -0.10947233f, 0.09075645f, 
    -0.30548221f, -0.04164411f, 0.10012680f, -0.22989592f, -0.38668472f, 0.21272777f, -0.16550981f, 0.13727126f, 
    0.63997900f, -0.25747573f, 0.59724373f, 0.12391123f, 0.25737813f, 0.21688126f, -0.47340840f, -0.03109062f, 
    0.11935204f, -0.06212182f, -0.12577765f, -0.12319217f, -0.17471305f, 0.46769702f, 0.25996196f, -0.07216049f, 
    -0.36310399f, 0.27057528f, -0.42330411f, 0.15636760f, 0.07927847f, 0.33550945f, -0.37237206f, 0.28954625f, 
    0.16739076f, 0.04849091f, 0.08155182f, 0.23656666f, 0.40349117f, 0.25056553f, 0.01527647f, 0.04103914f, 
    0.10378206f, 0.55596256f, 0.06360109f, 0.41516167f, -0.03769186f, 0.18485492f, 0.00277149f, 0.07216091f, 
    0.10713161f, -0.11427475f, -0.33124012f, -0.09189759f, -0.12800542f, -0.22844891f, -0.10631290f, -0.07945784f, 
    0.25861198f, -0.82560796f, -0.11675510f, 0.25718063f, 0.41822505f, 0.20756428f, -0.09473578f, 0.17749761f, 
    0.01292552f, 0.09738786f, 0.02951745f, 0.12537117f, 0.02079153f, 0.09533314f, -0.10534956f, 0.16100530f, 
    -0.31709456f, -0.11264423f, -0.59468591f, 0.03182663f, 0.17028405f, 0.41170484f, -0.14353929f, -0.14091097f, 
    0.30336633f, -0.20422104f, 0.03437883f, 0.03388019f, 0.17943430f, 0.23282999f, -0.02396387f, 0.63500655f, 
    -0.10909167f, -0.17101200f, -0.20596975f, -0.12809789f, -0.47756043f, 0.01611870f, 0.08765682f, 0.25601950f, 
    -0.28668186f, 0.06815328f, 0.74513572f, 0.15929925f, 0.15154640f, 0.54291004f, -0.02979159f, -0.00232597f, 
    0.88460433f, -0.07359508f, -0.19431184f, 0.23426874f, -0.02906626f, -0.21612628f, -0.26188731f, 0.04988478f, 
    0.04832912f, 0.41577670f, 0.06974162f, -0.19718120f, 0.20789601f, 0.13135140f, 0.09001593f, 0.14815281f, 
    0.09820692f, 0.07608264f, -0.31346935f, -0.14003299f, 0.29427329f, 0.36322206f, -0.24723789f, 0.14584604f, 
    -0.17777647f, -0.11183563f, 0.08130769f, 0.35291159f, 0.16681647f, -0.44066814f, -0.07850294f, 0.23903772f, 
    -0.16270149f, -0.60294181f, -0.74344915f, -0.03144249f, 0.22291641f, -0.10746172f, 0.00974880f, 0.05318689f, 
    0.70157635f, -0.11663508f, 0.11187517f, 0.25454107f, 0.04317535f, -0.02424947f, -0.27498767f, 0.53614450f, 
    0.17553033f, -0.15378967f, -0.07064737f, -0.24159399f, -0.06061735f, 0.11722113f, 0.03532147f, 0.21431805f, 
    0.40421319f, -0.08440379f, 0.38620991f, 0.07635287f, 0.01206159f, -0.03416808f, -0.04724891f, -0.00973383f, 
    0.48766121f, 0.08748989f, -0.62097126f, 0.03634813f, 0.02206381f, -0.29201341f, -0.25388980f, 0.02110940f, 
    -0.04827470f, -0.11337041f, -0.26054054f, 0.24734946f, 0.23962598f, -0.25621304f, -0.09422131f, 0.44735268f, 
    0.68040133f, -0.44900626f, -0.04520907f, 0.03868251f, -0.54034007f, -0.12319650f, 0.25224316f, -0.11893600f, 
    -0.55856085f, 0.07627616f, 0.08171191f, -0.01045451f, -0.51627254f, -0.01879162f, -0.15866277f, 0.14689171f, 
    0.31163865f, 0.20338939f, 0.58523649f, -0.04135168f, 0.15517335f, 0.08548948f, 0.03650976f, -0.04953638f, 
    -0.09391320f, -0.49855271f, -0.01050083f, 0.02724362f, -0.11332794f, 0.66167885f, 0.29331166f, 0.39847690f, 
    -0.62647259f, 0.28312150f, -0.30257326f, 0.06523165f, 0.06451268f, 0.27355510f, 0.11243791f, -0.09779502f, 
    0.06110809f, -0.10843160f, 0.92152071f, 0.18694025f, 0.27959380f, -0.25088868f, -0.09303763f, 0.00453947f, 
    0.24727000f, 0.43773937f, -0.04056780f, 0.19725694f, 0.05934779f, 0.04682428f, 0.10988660f, -0.03710671f, 
    0.01559648f, -0.06413742f, -0.01305605f, -0.05390963f, 0.02531993f, 0.04440689f, 0.03403875f, -0.03466274f, 
    -0.07146473f, -0.04510941f, -0.07649940f, 0.03195222f, -0.07345014f, -0.02934342f, 0.08913318f, -0.15648231f, 
    0.05947661f, -0.03803286f, -0.04959603f, -0.05389366f, -0.03996817f, -0.14426042f, -0.01323375f, -0.11782689f, 
    -0.00571919f, -0.11708132f, 0.08549585f, 0.07355221f, -0.10898466f, -0.00626571f, -0.03823416f, -0.10564330f, 
    -0.07961251f, 0.02215050f, 0.09233790f, -0.08796616f, -0.06415284f, 0.05247318f, -0.11003696f, -0.02087932f, 
    -0.07870666f, -0.13664448f, -0.05061441f, 0.05546949f, -0.15138650f, 0.09321223f, -0.03943949f, -0.00756362f, 
    -0.11053727f, -0.01207669f, 0.08784488f, -0.09371511f, -0.02515905f, -0.03763712f, -0.01470827f, -0.03937243f, 
    -0.02599843f, 0.02907131f, -0.11805727f, -0.09472467f, 0.00585958f, -0.12126175f, -0.10118675f, -0.03397222f, 
    0.02616838f, 0.01485242f, 0.26960072f, 0.11450581f, 0.28609771f, -0.04121451f, -0.00746350f, -0.16763678f, 
    0.19186944f, -0.09831778f, 0.02981497f, -0.12142028f, -0.06791808f, -0.02063754f, 0.45398811f, -0.19323482f, 
    -0.06382734f, -0.11344833f, 0.15731387f, 0.21103203f, 0.20784801f, -0.21261838f, 0.26665422f, -0.12175529f, 
    0.00513503f, 0.44122520f, 0.18608037f, 0.10118209f, -0.03800593f, -0.01139690f, 0.36564785f, -0.06460033f, 
    0.27402118f, -0.26829514f, 0.17991495f, -0.02451108f, -0.15420549f, -0.11937714f, 0.04380201f, -0.06825501f, 
    0.20547712f, 0.12635048f, -0.16586828f, -0.24614395f, 0.12125273f, 0.18073986f, 0.29994729f, 0.02288336f, 
    0.15621245f, 0.07775977f, -0.17241168f, 0.31120804f, -0.09695205f, -0.15683928f, -0.09724457f, -0.00676217f, 
    0.11494502f, 0.17533405f, 0.11022785f, -0.10622440f, -0.06916116f, 0.07797712f, 0.29642129f, -0.11197238f, 
    0.03617371f, 0.37605014f, -0.20915644f, 0.03126710f, 0.28371850f, 0.05246378f, -0.04402059f, 0.13232274f, 
    0.44500679f, 0.02004260f, 0.20293066f, 0.42339510f, -0.07651012f, 0.02021846f, 0.08147401f, -0.12678736f, 
    -0.00126750f, 0.01012657f, 0.10767062f, 0.25604793f, 0.20777035f, -0.11222729f, 0.10738903f, 0.05207881f, 
    -0.02613393f, 0.25247991f, -0.37837043f, 0.09871177f, 0.05730826f, 0.15160789f, 0.41651639f, -0.07893286f, 
    0.06616151f, -0.34309018f, 0.08317681f, 0.16081643f, -0.17995308f, 0.35147691f, 0.31019846f, 0.57116097f, 
    -0.16890402f, 0.33053091f, 0.16837244f, -0.34681192f, -0.04294413f, 0.01132876f, 0.46762234f, -0.04435487f, 
    0.37629306f, -0.01186013f, 0.80369109f, -0.36182082f, -0.04081503f, -0.02212701f, -0.02284822f, 0.00995827f, 
    -0.51736635f, 0.07804221f, 0.07512681f, 0.14916064f, 0.01390069f, 0.13546290f, -0.01060169f, -0.09115233f, 
    0.14906131f, 0.06427003f, 0.08308452f, 0.21110696f, 0.27063704f, 0.03284197f, -0.07156898f, -0.01099171f, 
    0.10902866f, -0.44750649f, -0.06048949f, 0.18929741f, 0.22381739f, -0.16593969f, -0.01922344f, 0.18472275f, 
    0.28717652f, -0.03839243f, 0.15247105f, 0.25781021f, 0.07525899f, -0.24248418f, 0.12466961f, 0.35616717f, 
    -0.04336513f, -0.00453712f, 0.64057398f, -0.10092175f, 0.08764042f, 0.16566809f, 0.07194918f, 0.13478014f, 
    0.02751883f, 0.00620035f, 0.13654082f, 0.14059523f, 0.20779453f, 0.07388732f, 0.05672918f, 0.61544710f, 
    -0.32656035f, -0.17331252f, 0.62275648f, 0.01310287f, -0.07128997f, 0.16437550f, -0.16342819f, 0.12289190f, 
    0.09739606f, -0.02307592f, 0.65497220f, 0.21741411f, 0.22318953f, -0.24434665f, -0.03758569f, -0.03220993f, 
    -0.13641675f, -0.09704208f, -0.07869064f, 0.35374135f, -0.03687180f, -0.18873060f, -0.03332059f, -0.08933895f, 
    -0.10051042f, 0.09957720f, -0.16333437f, 0.27531156f, -0.06566209f, 0.09636699f, -0.00068276f, 0.37531042f, 
    0.15596312f, -0.44149706f, 0.07653254f, -0.05217155f, -0.18354273f, 0.10795305f, 0.08169978f, 0.11472607f, 
    -0.52621454f, 0.12182289f, 0.00485763f, -0.23167580f, -0.15199333f, 0.19085598f, -0.11809717f, 0.16696902f, 
    0.55926675f, -0.12367319f, 0.84733582f, -0.08808626f, 0.03506790f, -0.23178197f, 0.00711310f, 0.00804639f, 
    -0.26590276f, -0.13515405f, -0.37331882f, 0.08758602f, -0.30504915f, 0.04424516f, 0.32157391f, 0.26459253f, 
    0.20771340f, 0.22927336f, -0.08872711f, 0.10323915f, 0.32135263f, 0.21466306f, -0.11275687f, 0.16634685f, 
    0.29145741f, -0.01869675f, 0.05279494f, -0.20155627f, 0.23323914f, 0.26465517f, 0.03070725f, -0.06539597f, 
    -0.16851147f, 0.46194509f, 0.17204534f, 0.20800617f, -0.02689862f, 0.07749832f, 0.04502548f, 0.11426610f, 
    0.13978672f, -0.07187099f, -0.00083313f, -0.16396824f, 0.03548919f, -0.20753643f, -0.11975676f, -0.33963275f, 
    -0.09557293f, 0.04234673f, 0.26366332f, 0.17374259f, -0.07385603f, 0.01738872f, 0.17176940f, 0.17112106f, 
    0.70750272f, -0.14267981f, 0.08895718f, 0.16997440f, 0.30992600f, 0.06810985f, 0.12214591f, 0.25070700f, 
    -0.44605252f, 0.19851947f, -0.14996772f, 0.06848089f, 0.01696211f, 0.47268736f, 0.14302285f, 0.17187452f, 
    -0.11312753f, 0.35164440f, 0.22552812f, 0.34107715f, 0.58186668f, -0.32993323f, 0.15165491f, 0.06497020f, 
    -0.27595374f, -0.23450938f, 0.31716952f, 0.30097213f, -0.24104820f, -0.26256278f, -0.01329109f, 0.06268060f, 
    -0.47207555f, 0.28032854f, 0.48732182f, 0.06469122f, 0.11799996f, 0.13084897f, -0.07350036f, 0.05313079f, 
    -0.27141082f, -0.35604623f, 0.06686814f, 0.22791091f, 0.04981799f, -0.11893072f, -0.07661746f, 0.04280372f, 
    0.06646568f, 0.00955171f, 0.06452154f, -0.14083864f, -0.08870725f, -0.15029116f, 0.05535217f, 0.01561419f, 
    0.06923132f, -0.06293011f, 0.11555603f, -0.11549474f, -0.01942606f, -0.10886937f, -0.11011491f, 0.09199537f, 
    -0.09237295f, 0.00872678f, -0.07225228f, -0.10029630f, -0.07244158f, 0.04374300f, -0.03685159f, -0.02172865f, 
    -0.11100107f, -0.14597379f, -0.02850655f, -0.09174396f, -0.02883422f, -0.05420130f, -0.08845210f, 0.06604571f, 
    -0.03485893f, -0.09274817f, 0.01891310f, -0.05388578f, -0.08416175f, 0.02821381f, 0.03078884f, 0.03367148f, 
    -0.11336476f, -0.07912641f, 0.05697754f, -0.08849331f, -0.13437474f, -0.02554704f, 0.10857007f, 0.03194133f, 
    -0.05832909f, -0.15344143f, -0.11086322f, -0.03019672f, -0.06652222f, 0.00001040f, 0.00894415f, 0.05726425f, 
    -0.08521731f, -0.06763703f, 0.03684694f, 0.04390077f, 0.02386604f, -0.01948114f, -0.01451278f, 0.02847767f, 
    -0.05100721f, -0.10880972f, -0.13193412f, -0.01934493f, 0.00725653f, -0.08096544f, 0.02276249f, -0.15003122f, 
    -0.13089521f, -0.11194079f, -0.03596963f, -0.06162116f, -0.03510404f, -0.04456329f, -0.07250721f, -0.13245898f, 
    -0.07307328f, -0.05706163f, 0.01638063f, 0.07772680f, -0.01903156f, 0.05589771f, -0.10564055f, 0.00946653f, 
    -0.01979852f, -0.03873308f, 0.03352071f, -0.01912771f, -0.03604173f, -0.09150674f, -0.00797095f, -0.04386358f, 
    0.06823629f, 0.05483975f, 0.04154219f, -0.02715829f, -0.08984420f, 0.00617763f, -0.07403747f, 0.02160375f, 
    0.07133887f, -0.11343540f, -0.07933215f, -0.07665514f, -0.11022376f, -0.01581367f, 0.08971163f, -0.06109092f, 
    0.02123736f, -0.13147888f, -0.12084629f, -0.04025576f, -0.01717997f, -0.07864784f, 0.00057128f, -0.12210661f, 
    0.06748775f, 0.05368000f, 0.04942831f, 0.04854517f, 0.11926816f, -0.12144570f, 0.04140798f, 0.12365992f, 
    -0.12141134f, 0.11011693f, -0.10105072f, -0.01253180f, -0.02702104f, -0.01560885f, 0.03400593f, -0.03570786f, 
    0.07883976f, 0.01235732f, -0.03256676f, -0.00014853f, -0.10503677f, 0.05375493f, -0.12141399f, 0.02666819f, 
    -0.12099349f, 0.06033546f, -0.04405835f, -0.01864125f, -0.02834541f, -0.00450510f, -0.00373469f, -0.03513457f, 
    0.11533591f, -0.11758879f, 0.02676822f, -0.04499260f, -0.07925183f, -0.01371224f, 0.00899413f, -0.05067208f, 
    0.03850798f, -0.07237692f, -0.11621280f, -0.10760464f, 0.05567324f, 0.09235373f, -0.10914655f, 0.04630019f, 
    -0.09876421f, -0.02631408f, -0.02970304f, 0.06507786f, 0.02463539f, 0.11383285f, -0.06740035f, -0.10859843f, 
    0.03875153f, -0.02943189f, 0.10626462f, -0.12106210f, -0.06303178f, -0.09490493f, -0.02179290f, 0.08565909f, 
    0.07997516f, -0.07392211f, -0.07767116f, -0.02764626f, 0.10235451f, -0.08301671f, -0.06015411f, -0.05306832f, 
    0.00256118f, -0.15699688f, -0.02537874f, -0.02495284f, 0.08040139f, 0.05377508f, 0.02779908f, 0.01187753f, 
    -0.09263933f, 0.02132437f, -0.14250796f, -0.05705705f, -0.10453977f, 0.06945701f, 0.08714046f, 0.03956477f, 
    -0.05599612f, -0.06617844f, 0.00820848f, -0.11417516f, -0.03081916f, 0.08993200f, -0.14178282f, -0.00397872f, 
    -0.10827955f, 0.07209177f, 0.00745009f, -0.06390715f, -0.12906834f, -0.15156354f, -0.02337004f, 0.02988017f, 
    -0.00490071f, 0.00170230f, -0.15569371f, -0.04582586f, -0.16080046f, 0.09343789f, -0.09120398f, -0.07848494f, 
    0.02435195f, -0.04133115f, 0.09187067f, -0.02085511f, -0.02116330f, -0.06119196f, -0.01403174f, 0.06426129f, 
    -0.07256211f, -0.14540280f, 0.09554171f, -0.08261300f, -0.07581348f, -0.06009068f, -0.04324955f, 0.06493139f, 
    -0.13725846f, -0.03617533f, -0.02118357f, 0.02958645f, 0.09673288f, -0.00489879f, -0.07293352f, -0.03105527f, 
    0.12326512f, -0.01827377f, 0.05938400f, 0.07988356f, 0.06816700f, -0.01687993f, -0.07988234f, -0.00845416f, 
    0.06114212f, -0.03762507f, -0.06402083f, -0.02126134f, 0.04461385f, -0.02883140f, -0.02196543f, -0.05971067f, 
    -0.09020564f, -0.08655134f, -0.00259244f, 0.10963403f, -0.12955990f, -0.14899212f, -0.08331324f, 0.02728059f, 
    -0.10272329f, -0.04575260f, -0.08575170f, -0.05924907f, -0.12745199f, 0.08062662f, -0.08010340f, -0.01399997f, 
    0.08136091f, 0.02622313f, -0.07129747f, -0.03373446f, -0.00936896f, -0.09223463f, 0.04301824f, 0.05040796f, 
    -0.06769346f, 0.08118126f, 0.06993665f, -0.09118631f, -0.07623663f, -0.08869620f, -0.01699127f, -0.10779580f, 
    -0.02541718f, -0.03665008f, -0.01601948f, -0.04479932f, -0.09504708f, -0.03000417f, -0.00330324f, -0.08154868f, 
    0.10968173f, -0.09959311f, -0.12170213f, 0.08630903f, -0.02986269f, -0.02312486f, -0.02197171f, -0.00833035f, 
    0.10451479f, -0.13741948f, -0.14228435f, -0.03673283f, 0.07594669f, 0.09831918f, 0.11082706f, -0.04700785f, 
    0.00807614f, -0.03705703f, 0.04998966f, -0.10316732f, -0.00823835f, -0.03854493f, -0.07781112f, 0.03183284f, 
    -0.11091906f, 0.03562279f, -0.02743342f, -0.13654202f, -0.07267892f, -0.08890091f, -0.08658459f, 0.04838884f, 
    -0.03548234f, -0.08766709f, -0.08780985f, 0.12125148f, -0.10393017f, -0.05538574f, 0.04075447f, 0.06774464f, 
    0.06900667f, 0.06338442f, -0.14327860f, -0.07252552f, 0.04846340f, -0.08091260f, -0.06610030f, 0.04336296f, 
    0.09352592f, 0.07483143f, -0.10945775f, -0.04620937f, -0.08380384f, 0.01049594f, -0.11617836f, -0.05933989f, 
    -0.04721612f, -0.12277339f, -0.09087417f, 0.02521924f, -0.11064680f, 0.06411918f, 0.00654264f, -0.08530986f, 
    0.00348747f, -0.04095326f, 0.04040173f, -0.05672917f, 0.02199998f, 0.06141746f, 0.07117845f, 0.00426637f, 
    0.00563428f, -0.03220058f, -0.03894459f, -0.09766149f, -0.11782933f, -0.05351501f, -0.08381292f, -0.02135845f, 
    -0.01647498f, 0.12439476f, 0.01620765f, -0.06615513f, 0.08273759f, -0.07350604f, -0.13362975f, 0.03035255f, 
    -0.03835182f, 0.05889466f, 0.05121991f, -0.12437509f, -0.01604665f, -0.08496491f, -0.04617381f, -0.11554386f, 
    0.00548702f, 0.01954591f, -0.03117950f, -0.02280980f, -0.15211105f, -0.05180605f, -0.01315623f, -0.09875054f, 
    -0.00747114f, 0.09334414f, -0.00936446f, -0.04879266f, 0.05281096f, -0.03904079f, 0.03175591f, -0.02812922f, 
    -0.00404420f, -0.03130952f, -0.08348841f, -0.06856859f, -0.08047497f, -0.03253818f, 0.04633836f, -0.13145514f, 
    -0.01214803f, -0.11346661f, 0.07832628f, -0.10991238f, 0.04857266f, -0.03619449f, 0.01295869f, -0.00736187f, 
    -0.03989270f, -0.06026712f, 0.04131410f, -0.05927254f, -0.01349050f, -0.15086320f, 0.08892427f, -0.08267464f, 
    0.01513523f, -0.19780011f, -0.43500829f, -0.26070139f, 0.02025427f, 0.03675267f, 0.11906803f, 0.06512263f, 
    -0.12033029f, 0.31047374f, 0.25818360f, 0.26633638f, 0.05141793f, -0.26721597f, 0.17658609f, 0.05917662f, 
    -0.32550907f, 0.09850119f, -0.09853350f, 0.22289664f, 0.02660679f, -0.02534982f, 0.25817505f, 0.08522405f, 
    -0.02516231f, 0.23029661f, -0.08696574f, -0.07167418f, -0.09341966f, -0.41866398f, 0.10377668f, 0.11265882f, 
    -0.06015510f, 0.06727336f, -0.17290612f, 0.14269902f, 0.35790196f, -0.51759046f, 0.19174227f, 0.31304383f, 
    0.42545864f, -0.56052440f, 0.46403864f, 0.24454114f, 0.30043894f, -0.12510298f, 0.14789113f, -0.11489575f, 
    -0.24564053f, -0.36412326f, 0.10871365f, -0.15157528f, -0.15958135f, 0.21086317f, -0.05726509f, 0.01517225f, 
    -0.06243727f, -0.11643627f, 0.02388703f, -0.07004473f, -0.04216383f, -0.32932696f, -0.09498802f, 0.08290550f, 
    -0.05303179f, -0.06618058f, -0.02644169f, -0.11785690f, -0.00303200f, -0.04627708f, 0.02111520f, -0.16163298f, 
    -0.15015279f, 0.07741772f, 0.02233111f, 0.07308958f, 0.08924949f, -0.05789988f, -0.17363934f, 0.03892924f, 
    -0.13479295f, -0.07267056f, -0.11701742f, -0.09068082f, -0.13544461f, 0.00751258f, -0.04643469f, -0.05313591f, 
    0.03428955f, -0.14310263f, 0.09966116f, 0.10354182f, -0.08652010f, 0.00492289f, 0.03437315f, -0.17241289f, 
    -0.10702821f, 0.02189009f, 0.01096690f, 0.04929387f, 0.01127908f, -0.13571650f, -0.05157623f, -0.04891235f, 
    0.09990392f, 0.01448205f, -0.14232138f, -0.01446077f, -0.14105494f, -0.15466277f, -0.05075854f, 0.03490707f, 
    0.06279945f, -0.10620143f, -0.07384212f, 0.02308194f, 0.08467688f, -0.02804964f, -0.09261943f, -0.07318549f, 
    -0.08766742f, 0.05262729f, -0.08632474f, 0.00570052f, 0.10219710f, 0.00135335f, -0.00681686f, 0.00726704f, 
    0.09125393f, 0.12053120f, 0.45063540f, -0.10338560f, -0.37797114f, 0.20038363f, 0.02802962f, -0.13753577f, 
    -0.38561818f, 0.25177029f, -0.01324482f, -0.13956353f, 0.50441313f, 0.35488912f, -0.18600355f, 0.07298608f, 
    0.20068361f, -0.08810864f, 0.23467842f, 0.03837185f, 0.71610272f, 0.06841611f, 0.19232459f, -0.18974662f, 
    0.00020352f, 0.00647770f, -0.44857109f, -0.05375032f, -0.09502843f, 0.28781605f, 0.00371607f, -0.11057424f, 
    0.33311087f, 0.30638903f, 0.12841888f, 0.03221642f, 0.12598786f, -0.26950338f, -0.06884285f, -0.76838976f, 
    0.88344604f, -0.08290424f, -0.03077161f, -0.00521223f, 0.06929995f, 0.13064225f, 0.08348559f, 0.25849971f, 
    0.15092339f, 0.39919075f, -1.00430977f, 0.26229233f, -0.01524378f, 0.52615297f, 0.07958231f, -0.07554808f, 
    0.10451955f, 0.01327451f, 0.06439964f, -0.16442589f, -0.09264524f, 0.01351559f, 0.12104673f, -0.07731327f, 
    0.11295024f, -0.03931970f, -0.02304010f, 0.26412141f, 0.21698305f, 0.09826890f, 0.10671915f, -0.09928104f, 
    0.09408882f, -0.39974001f, 0.33765760f, 0.18681009f, -0.29705289f, -0.40619200f, 0.20769083f, -0.04247732f, 
    0.05987107f, 0.01384516f, -0.15304327f, -0.06445539f, 0.17501883f, 0.03974775f, 0.23877202f, 0.03381706f, 
    0.08732560f, 0.28353560f, 0.44197851f, -0.00836103f, -0.16236998f, -0.08440871f, 0.39382678f, 0.15696451f, 
    -1.15000474f, 0.14462048f, -0.08174100f, -0.00869702f, -0.00433400f, -0.22390883f, 0.18956783f, 0.69308066f, 
    0.38858640f, -0.18544731f, 0.51534611f, 0.26995543f, 0.34697944f, 0.09517244f, 0.14206012f, -0.12832268f, 
    -0.10974377f, -0.06007253f, 0.66156095f, -0.05619807f, 0.03041492f, 0.17080259f, -0.04670687f, -0.03694810f, 
    -0.33886817f, 0.09206798f, 0.10148469f, 0.00469274f, 0.09353192f, -0.04626825f, 0.09395298f, -0.01927135f, 
    0.14724590f, -0.12681457f, 0.07320913f, 0.27383938f, -0.67207688f, 0.10498022f, -0.10264005f, -0.41893104f, 
    -0.45696515f, 0.20312797f, 0.20499220f, 0.20103453f, 0.48951021f, 0.15102875f, 0.04020891f, -0.47010499f, 
    0.04558464f, 0.00866310f, -0.23352468f, -0.03238656f, 0.28163898f, 0.25060609f, 0.15340024f, -0.54006606f, 
    -0.02546802f, 0.01291719f, 0.10267670f, -0.04532287f, -0.63319802f, 0.35634735f, -0.04708800f, -0.37985054f, 
    0.13160245f, -0.22881037f, -0.43547335f, -0.12716895f, -0.68925029f, 0.34636158f, -0.03745762f, -0.40427119f, 
    0.19883370f, -0.03420058f, -0.22760187f, -0.71647412f, -0.03368610f, -0.11225662f, 0.14629890f, 0.08807050f, 
    0.36974508f, 0.19964854f, 0.47736692f, -0.03798937f, -0.57304972f, 0.25648728f, -0.05627234f, 0.00282675f, 
    0.26538393f, -0.51180106f, 0.08397088f, -0.53589094f, -0.00247957f, 0.31255659f, 0.22705612f, 0.10691574f, 
    0.03225851f, 0.02300295f, 0.05698795f, 0.24876608f, -0.10255603f, 0.04283428f, -0.00654717f, 0.13936158f, 
    0.21421956f, -0.31984898f, 0.08614964f, -0.25030348f, -0.13061002f, 0.13083982f, -0.02268494f, 0.02894219f, 
    -0.50344533f, -0.07704791f, 0.10580198f, -0.09734186f, -0.23544540f, 0.28282985f, -0.07194816f, -0.21848592f, 
    0.70690483f, -0.19095300f, -0.14887492f, -0.06340261f, -0.04467098f, -0.29348835f, 0.12366911f, 0.11851379f, 
    -0.35366258f, 0.21829191f, -0.28885722f, -0.16492453f, -0.29995474f, 0.08264900f, 0.15150990f, 0.19701636f, 
    0.22887442f, -0.03770664f, -0.14929891f, 0.20249496f, 0.18982665f, 0.20605610f, -0.24590568f, 0.20350790f, 
    0.42276770f, -0.04735764f, 0.15045360f, 0.28572547f, 0.20051764f, 0.57070804f, -0.09954938f, -0.03188391f, 
    0.51581144f, 0.11668440f, 0.03550891f, -0.09270304f, -0.06915855f, 0.42504859f, 0.08693674f, 0.06649825f, 
    -0.08493946f, -0.04071874f, -0.13569790f, -0.04270227f, -0.04582035f, -0.05813882f, -0.08948667f, -0.00648584f, 
    0.03146248f, 0.01767173f, 0.00874391f, 0.00245499f, -0.12110478f, -0.07475793f, 0.04668303f, -0.07872035f, 
    0.01060602f, 0.12461728f, 0.09366858f, -0.08903763f, -0.12993379f, -0.11714995f, -0.11054797f, -0.11513510f, 
    -0.03571437f, 0.04655716f, -0.02014254f, 0.01411086f, 0.03451653f, -0.11993569f, 0.05612233f, 0.05969745f, 
    0.03567442f, -0.06500924f, -0.02969044f, -0.05601289f, -0.07230230f, -0.06881719f, -0.13435745f, -0.13503090f, 
    -0.06726658f, -0.07239866f, 0.05379640f, -0.06035521f, -0.02883762f, 0.04231820f, 0.06125979f, -0.07441959f, 
    0.02013079f, -0.04260294f, 0.02575890f, 0.06497446f, -0.08974824f, -0.00826266f, 0.01205501f, -0.00559826f, 
    -0.10374194f, -0.11708543f, -0.08638142f, -0.04639446f, 0.03512493f, -0.08095650f, 0.10151470f, -0.09997006f, 
    0.04517630f, 0.05149610f, 0.02549527f, -0.18545057f, -0.20792341f, 0.12517716f, -0.02538943f, -0.11778504f, 
    -0.06288201f, 0.26909995f, 0.04351699f, 0.26135868f, 0.00532676f, 0.29984492f, -0.00153107f, 0.18751109f, 
    0.22324130f, 0.02888205f, 0.12835793f, -0.08987480f, 0.17156629f, 0.46566215f, 0.05144073f, -0.03270080f, 
    -0.20255439f, 0.06522492f, 0.26472783f, 0.12143572f, -0.03919502f, 0.07967850f, 0.26662281f, -0.01257924f, 
    -0.33715716f, 0.48397198f, 0.08150365f, 0.16214491f, 0.21220092f, 0.03277955f, 0.26132995f, -0.43902305f, 
    0.12543380f, 0.38353908f, -0.31771812f, 0.20102808f, -0.00889947f, -0.39578888f, 0.22782247f, -0.07854825f, 
    0.01490464f, 0.23123164f, -0.72375345f, -0.47945541f, -0.12096891f, 0.01181552f, -0.10742138f, -0.07807172f, 
    -0.03373094f, -0.50698817f, 0.15031375f, 0.17509006f, 0.11490890f, 0.18874189f, -0.15481682f, -0.06569965f, 
    0.05673131f, -0.09009311f, -0.03402384f, -0.01006612f, 0.04738520f, 0.00366223f, 0.07678138f, 0.06831965f, 
    -0.05699650f, -0.14916414f, -0.09552878f, 0.03493376f, 0.07422148f, 0.05249646f, -0.03653122f, -0.08195916f, 
    0.01374081f, 0.06852630f, -0.05533435f, -0.11267581f, -0.07566726f, -0.12085727f, -0.02018239f, -0.17435887f, 
    -0.04988686f, 0.03075518f, -0.09387635f, -0.02461697f, 0.08346331f, 0.06777985f, 0.05508019f, -0.02037611f, 
    -0.07062872f, -0.15236458f, 0.02674039f, -0.07669853f, -0.18330948f, -0.02394141f, 0.00657905f, -0.01859671f, 
    0.03202164f, -0.08550586f, -0.01468482f, -0.10873790f, -0.06595031f, 0.13845812f, -0.12983048f, -0.06103287f, 
    -0.05444174f, 0.03115151f, 0.09685507f, 0.13892487f, -0.08697560f, 0.04835390f, 0.07495709f, -0.01041354f, 
    0.06456006f, -0.06899051f, 0.02910056f, -0.12856972f, -0.09243166f, 0.10000973f, -0.04949134f, -0.01934101f, 
    0.08140534f, 0.09130333f, 0.31116766f, 0.08329280f, 0.17565577f, 0.09539364f, -0.09461634f, 0.08786988f, 
    0.02879434f, -0.33079186f, -0.00419516f, -0.09887189f, 0.25704166f, 0.17013480f, -0.05358212f, 0.29427731f, 
    0.54886675f, -0.02781766f, 0.22390881f, 0.08281679f, 0.29258072f, 0.05529149f, -0.04141191f, 0.28345838f, 
    -0.22188009f, 0.03952762f, 0.50233656f, -0.04396069f, 0.30795917f, 0.29433200f, -0.27468851f, 0.16019148f, 
    0.44841015f, -0.08488329f, 0.40563750f, 0.24228615f, 0.35356361f, -0.10793040f, -0.20903036f, -0.42911866f, 
    -0.24855459f, -0.01566555f, 0.13071063f, -0.07893156f, -0.21255840f, 0.13465062f, -0.02298134f, 0.14753880f, 
    -0.31778899f, 0.19264197f, -0.42614099f, -0.00211860f, 0.30087003f, -0.13761355f, -0.00854083f, -0.00757913f, 
    -0.04425671f, 0.20335864f, 0.01307148f, 0.04312604f, -0.03063837f, -0.13894476f, -0.00247863f, 0.03613323f, 
    -0.09075226f, -0.11800562f, -0.07566320f, -0.06651387f, 0.06817779f, -0.09016382f, -0.05858724f, 0.05362753f, 
    -0.02902575f, 0.10265462f, 0.02987011f, -0.05298994f, 0.02899433f, -0.11039764f, 0.03868844f, -0.15650411f, 
    0.05213446f, 0.11300093f, -0.07840708f, 0.08642037f, -0.03157476f, -0.03438539f, 0.11713941f, -0.01418312f, 
    -0.06218597f, 0.09740777f, -0.00339664f, 0.00130732f, -0.14295739f, -0.02115889f, -0.05892163f, -0.11222535f, 
    -0.09288371f, -0.08719140f, 0.07733823f, 0.07058803f, -0.14439097f, 0.02551504f, -0.01002575f, 0.11721680f, 
    0.10016449f, 0.01890211f, -0.02558988f, 0.06330065f, -0.05678230f, -0.05738283f, -0.02455108f, 0.06127862f, 
    -0.09215162f, -0.06823112f, 0.05999929f, -0.04477441f, -0.10063866f, -0.03076304f, 0.00497890f, 0.06025201f, 
    0.06485365f, -0.03151374f, -0.02619606f, 0.03810761f, -0.10109815f, -0.13097493f, -0.07197703f, -0.00688545f, 
    0.01179924f, -0.26480806f, -0.29579186f, 0.01119151f, -0.31035554f, -0.09289268f, -0.08797218f, -0.07512269f, 
    0.09194957f, 0.24741530f, 0.25461176f, 0.44936123f, 0.10857433f, -0.01183738f, -0.13969244f, -0.00231135f, 
    0.30941212f, -0.04725223f, 0.07851882f, 0.04795291f, -0.02139466f, 0.41801953f, 0.05505763f, -0.08236438f, 
    -0.03086412f, 0.15494865f, 0.19643186f, 0.00719911f, 0.10692848f, 0.31627738f, -0.14054650f, -0.10480032f, 
    -0.38054287f, 0.45065784f, -0.02148672f, 0.06064682f, 0.31390163f, 0.21804093f, 0.20564921f, -0.58659512f, 
    -0.05756785f, 0.16685347f, -0.04440152f, 0.25066859f, -0.13229311f, -0.38138175f, 0.18464345f, -0.02310648f, 
    -0.24166070f, 0.07051852f, -0.09808908f, -0.01742601f, -0.20050627f, 0.07705322f, -0.04824848f, -0.04757782f, 
    -0.11221185f, -0.45709342f, 0.08194096f, 0.31609654f, 0.01179628f, 0.23890568f, 0.15581185f, -0.02559599f, 
    -0.07534591f, -0.00836461f, 0.11579881f, 0.09218208f, 0.33169776f, 0.01649542f, 0.09571792f, 0.11650856f, 
    0.35180253f, -0.25604689f, 0.24759181f, -0.13007833f, -0.30003080f, 0.18055162f, 0.49809176f, -0.04390407f, 
    -0.23814528f, 0.03878691f, 0.11632244f, -0.03261896f, 0.00534990f, -0.20633405f, 0.07150283f, -0.16444862f, 
    0.07743471f, 0.41536525f, 0.39072019f, -0.07193723f, 0.05964634f, -0.01420349f, 0.22808623f, -0.05219270f, 
    0.14136842f, -0.23598716f, 0.23908748f, -0.07916409f, -0.13668419f, -0.04167098f, 0.25610679f, -0.00196270f, 
    -0.15365253f, 0.24819085f, -0.47248849f, -0.20507762f, -0.02047831f, 0.03866860f, 0.32021165f, -0.12830187f, 
    0.12361578f, 0.04263321f, -0.05288002f, 0.12536646f, 0.14439927f, -0.20849997f, 0.03789005f, 0.01886304f, 
    0.25318518f, 0.25620773f, 0.11140284f, 0.00400868f, -0.10434593f, 0.18942285f, 0.06892899f, 0.08178580f, 
    -0.03224492f, -0.12766320f, -0.02674535f, 0.04822529f, -0.07930635f, -0.02560977f, -0.09852871f, -0.05952650f, 
    0.08577097f, -0.04613672f, -0.00489176f, -0.09977049f, 0.02513147f, -0.04655869f, -0.07294321f, -0.07657187f, 
    -0.12983836f, 0.00959016f, -0.07154927f, -0.11668696f, -0.01309680f, 0.09870477f, -0.10177184f, -0.10820545f, 
    0.07130020f, -0.04717153f, -0.09847105f, 0.05035454f, -0.09988521f, -0.05002047f, 0.09162224f, 0.03753871f, 
    -0.15395799f, -0.08691201f, -0.01968027f, -0.08978312f, 0.01632581f, 0.10068096f, 0.01748903f, -0.10035004f, 
    0.04142903f, 0.05289247f, -0.08181354f, -0.05005090f, 0.02517237f, -0.14079262f, -0.13653700f, 0.10671014f, 
    0.07596385f, -0.09834141f, -0.07483646f, -0.07621782f, -0.04005016f, -0.00860277f, -0.05040655f, 0.00644839f, 
    -0.12226361f, -0.02436202f, -0.12798256f, -0.03631091f, -0.03931208f, 0.06216430f, 0.10173000f, 0.12136436f, 
    0.03086382f, 0.10513593f, -0.04209628f, -0.09739915f, -0.08731402f, 0.07212219f, 0.00354548f, 0.10059804f, 
    0.09213389f, -0.12511231f, -0.12239665f, -0.06984310f, -0.08136620f, 0.02273476f, -0.08142839f, 0.01668409f, 
    0.02943791f, -0.00061475f, -0.00860123f, 0.09268492f, -0.04844042f, -0.10408805f, -0.00868094f, -0.07169501f, 
    -0.03388385f, -0.10598948f, 0.06402229f, -0.03335027f, 0.02239648f, -0.09837712f, 0.11279376f, -0.09755641f, 
    -0.04798278f, 0.01826314f, 0.07399088f, -0.03401478f, -0.10687830f, 0.08105852f, -0.00536651f, -0.13096941f, 
    -0.07954967f, -0.04785019f, 0.03911074f, -0.00453460f, -0.08664598f, -0.09106328f, 0.03498240f, 0.01116404f, 
    -0.05287690f, 0.07175085f, -0.00632130f, -0.10246567f, -0.08803734f, 0.08082970f, -0.11616967f, 0.12166768f, 
    -0.07405064f, 0.08468951f, -0.11572345f, -0.09218488f, 0.00724493f, -0.12748873f, -0.09018149f, -0.04691879f, 
    0.12196170f, -0.06022590f, 0.01658772f, -0.06396773f, -0.02179474f, -0.05341800f, 0.08572434f, -0.07919977f, 
    0.09381348f, 0.04981929f, -0.01408557f, 0.00417910f, 0.07315105f, -0.13844806f, 0.08317132f, 0.08197754f, 
    0.02416802f, -0.10614933f, -0.07742301f, 0.01511400f, 0.03666195f, -0.04267668f, -0.14004494f, 0.07033801f, 
    -0.01974566f, -0.05732803f, 0.01762375f, -0.02753909f, -0.01341844f, 0.03980183f, -0.14035124f, -0.04814974f, 
    -0.02778921f, -0.01561389f, -0.04386251f, -0.14246075f, -0.14085720f, 0.05897404f, -0.08794466f, 0.04121254f, 
    -0.00264612f, -0.03851783f, 0.06142820f, -0.07459779f, -0.09854589f, 0.07715569f, -0.11795656f, 0.00702366f, 
    0.06385055f, -0.02922816f, -0.11579326f, -0.13177921f, -0.14129917f, -0.14543171f, 0.06737417f, 0.08071949f, 
    -0.07666545f, -0.11410426f, -0.00641230f, 0.05757988f, -0.10747634f, 0.02086523f, 0.00706664f, -0.04058546f, 
    0.00824300f, 0.14566188f, 0.15895662f, 0.22900993f, -0.20811133f, 0.12739506f, 0.12339787f, -0.10992198f, 
    0.17656502f, 0.01985041f, 0.18164067f, 0.17822899f, 0.16732062f, 0.24271715f, 0.10995997f, -0.10982862f, 
    0.32872602f, -0.06931247f, 0.07073957f, -0.19481590f, 0.06879454f, 0.38160703f, -0.06623019f, -0.25464085f, 
    0.10676852f, 0.20046112f, -0.30678201f, 0.02732801f, 0.02559172f, 0.37817302f, -0.20136635f, -0.05978862f, 
    -0.19467776f, 0.02990683f, 0.01288872f, 0.02204380f, -0.16522788f, 0.19359995f, 0.14927013f, -0.41125259f, 
    -0.68758398f, 0.33975992f, -0.28548518f, -0.23294580f, -0.04688824f, -0.21986024f, 0.10864046f, 0.08619434f, 
    0.15642554f, 0.09975787f, -0.42901167f, -0.08095961f, -0.15945214f, 0.01985420f, -0.11748248f, -0.00620253f, 
    0.02006664f, -0.16237767f, 0.18972400f, 0.19129451f, 0.06608733f, 0.20943983f, 0.13788792f, -0.01274099f, 
    0.14606413f, -0.09238737f, -0.19697231f, -0.14389990f, 0.01146386f, -0.02894118f, 0.12280346f, 0.18804459f, 
    -0.03206478f, 0.64654815f, 0.21506946f, 0.47168452f, 0.03953875f, -0.11661382f, 0.08278118f, 0.18240654f, 
    0.22977638f, 0.07641831f, 0.14195029f, 0.23282419f, 0.11534294f, 0.19665578f, 0.11132171f, 0.16280708f, 
    -0.11467224f, 0.36595526f, 0.30993241f, -0.07578729f, -0.07239430f, 0.10428072f, 0.24964799f, 0.17183012f, 
    -0.13933063f, 0.41601771f, 0.23677160f, 0.24322942f, 0.53369921f, 0.15206486f, 0.12716505f, -0.24228883f, 
    0.34137031f, 0.41473934f, 0.16084690f, 0.07908668f, -0.06999342f, -0.10240344f, 0.30863443f, -0.00318188f, 
    -0.04019570f, 0.17907098f, -0.06976020f, -0.38564023f, -0.02646809f, -0.16893254f, -0.02930467f, 0.15578085f, 
    -0.43604296f, -0.17830163f, 0.13770911f, 0.30551159f, -0.08848424f, -0.20513791f, 0.10177221f, 0.11896694f, 
    0.11832199f, 0.17302062f, -0.06828945f, -0.28331354f, 0.32156911f, -0.06692096f, 0.05002619f, 0.33444926f, 
    0.17214486f, 0.03060448f, -0.07067817f, 0.13835369f, -0.04761313f, 0.24487522f, 0.15119092f, 0.21305186f, 
    0.08211157f, -0.03920073f, 0.19234094f, 0.17018422f, -0.00369177f, 0.02860205f, -0.12559959f, 0.31624624f, 
    -0.07041050f, 0.02452125f, -0.20190704f, 0.06167051f, 0.27103439f, -0.04916653f, -0.08232751f, 0.18765327f, 
    0.61922783f, -0.15048482f, 0.29117757f, 0.28598469f, 0.41290173f, -0.01985796f, -0.00784457f, -0.52806818f, 
    -0.24024047f, 0.18327801f, -0.52887654f, -0.16717847f, 0.09757781f, 0.08829764f, 0.16977035f, 0.07219934f, 
    -0.10993372f, -0.16242152f, -0.11723724f, -0.25802013f, 0.15399007f, -0.37601694f, -0.00764312f, -0.06768979f, 
    0.07480919f, 0.06250920f, -0.00888816f, 0.23594853f, 0.00389406f, -0.14406413f, -0.14369337f, 0.00685758f, 
    -0.02473363f, -0.08289646f, 0.00798561f, 0.00071498f, -0.05799758f, 0.02760049f, -0.06576425f, -0.04008314f, 
    -0.06358390f, -0.03526895f, 0.00987326f, -0.10948543f, -0.05734307f, 0.03704214f, -0.09766807f, 0.02875411f, 
    -0.01809646f, 0.00562683f, -0.10046806f, -0.10760559f, 0.06754282f, -0.12874717f, 0.01100298f, 0.05720749f, 
    0.01883634f, -0.02591647f, -0.01631898f, -0.10827370f, -0.07568237f, -0.08167055f, 0.03967502f, -0.15581796f, 
    0.06000318f, -0.13928200f, -0.07974674f, -0.12840573f, -0.02108200f, -0.00827247f, -0.08889825f, -0.13447560f, 
    0.07103954f, -0.01733148f, -0.00915890f, -0.07431784f, -0.15939710f, 0.05003934f, 0.02146531f, -0.01856989f, 
    -0.10581864f, -0.07140094f, -0.12588680f, 0.04750563f, -0.07500283f, 0.03102542f, -0.10602447f, 0.00281234f, 
    -0.05182645f, 0.07886603f, -0.14143081f, -0.03050635f, 0.06764498f, -0.11861002f, 0.02125623f, -0.02189021f, 
    -0.02853641f, 0.25669464f, -0.01092319f, 0.21352182f, 0.15855649f, 0.23810163f, 0.07366131f, 0.48755503f, 
    0.16503154f, -0.55860710f, -0.12151601f, -0.09409619f, -0.13585749f, -0.06709080f, -0.21212344f, 0.33426428f, 
    -0.35716110f, 0.08792739f, 0.06112451f, 0.07390016f, -0.31357199f, 0.04553797f, -0.14123894f, 0.23274213f, 
    0.46733180f, -0.07995936f, 0.99855703f, -0.09509328f, 0.26947677f, -0.07457997f, 0.08718478f, 0.33807039f, 
    -0.07432715f, -0.12946653f, -0.28235579f, 0.27889532f, -0.10065064f, 0.17505261f, 0.16146100f, 0.58193833f, 
    -0.32513323f, 0.16498727f, 0.08633590f, 0.37727723f, 0.18782309f, 0.21579280f, -0.12454816f, 0.15571533f, 
    0.27078021f, -0.00553399f, 0.50200087f, -0.24732055f, 0.38754311f, 0.01564372f, 0.07053176f, 0.11101402f, 
    -0.36100221f, 0.42158219f, 0.01007033f, 0.28398684f, -0.07371015f, 0.16765791f, -0.02489280f, 0.11256588f, 
    0.13380300f, 0.08665487f, -0.11842410f, 0.03723299f, 0.07458853f, 0.07752059f, -0.08181126f, 0.04470867f, 
    -0.31347153f, 0.70444882f, -0.26903009f, 0.14486496f, 0.41736606f, -0.10296775f, -0.29319066f, 0.10745502f, 
    0.46003026f, 0.05688505f, 0.20191783f, 0.06537554f, 0.13288455f, 0.15261750f, -0.01795538f, 0.11227364f, 
    -0.07639810f, -0.21046764f, -0.15231496f, 0.01507166f, -0.04281640f, 0.05933506f, -0.04021420f, 0.23186877f, 
    -0.20702945f, 0.50813383f, 0.05803483f, 0.29147673f, 0.40444171f, 0.01003529f, -0.18072505f, -0.39986619f, 
    0.27597457f, -0.08633737f, 0.61963290f, 0.21267007f, -0.07509025f, 0.11400149f, -0.07177590f, 0.12354854f, 
    -0.02541398f, 0.15600725f, -0.31123737f, -0.43548775f, 0.05033329f, 0.09596481f, 0.06648771f, 0.07022552f, 
    -0.76531726f, -0.03574812f, 0.13409007f, 0.35590816f, 0.08210949f, -0.28927803f, -0.14474809f, 0.01558688f, 
    -0.12771574f, 0.14236765f, -0.05906155f, 0.02458804f, 0.09781240f, 0.02717557f, -0.00156322f, -0.18085733f, 
    0.01255297f, 0.10451730f, 0.41439402f, 0.45145559f, 0.04306808f, -0.03564855f, 0.10631776f, -0.11235857f, 
    0.04065460f, -0.08765791f, -0.08512835f, 0.35926300f, 0.33263466f, -0.02970455f, 0.32891300f, 0.22070713f, 
    -0.12651691f, 0.37077972f, 0.20577525f, -0.10301794f, -0.11376074f, 0.21632883f, 0.36495084f, -0.15849766f, 
    -0.29133716f, -0.08394933f, 0.18119049f, 0.10283327f, 0.07723043f, 0.03562039f, 0.08478761f, -0.15846401f, 
    0.22843172f, 0.09136153f, 0.14655435f, -0.31149614f, 0.10559494f, 0.00506151f, 0.21500728f, -0.09225819f, 
    0.04953269f, 0.22614105f, 0.21084061f, 0.03099614f, 0.03693464f, 0.06258139f, 0.02023011f, -0.10636474f, 
    -0.64373696f, -0.10760093f, 0.14759642f, 0.23316251f, 0.08084872f, -0.29410467f, -0.04873492f, 0.10212044f, 
    -0.08369091f, 0.07121272f, -0.09080451f, 0.02241721f, 0.37233296f, -0.00966330f, 0.10719718f, 0.09537250f, 
    0.11452360f, 0.39820504f, 0.27677596f, 0.29160365f, -0.36137515f, -0.18552981f, 0.35929543f, 0.00412123f, 
    -0.02343167f, 0.05518754f, 0.01509741f, 0.19377945f, 0.26402301f, -0.13782156f, 0.23487963f, 0.00617600f, 
    -0.12342015f, 0.27909416f, -0.70315969f, 0.03054655f, -0.10178306f, -0.02696187f, 0.50248694f, -0.11225731f, 
    -0.11762627f, -0.21929041f, 0.16098534f, 0.07227623f, 0.35766271f, 0.02211336f, 0.15013538f, -0.70096534f, 
    0.49220923f, -0.02959643f, -0.37313578f, -0.21088582f, 0.16549270f, -0.02362695f, 0.45702016f, -0.14135347f, 
    0.03324283f, -0.00608837f, -0.21997491f, -0.12213528f, 0.01440192f, -0.19455059f, 0.06880433f, 0.11827121f, 
    0.17496030f, -0.28567940f, 0.15298128f, 0.06724150f, 0.09946472f, -0.00997410f, 0.06276571f, -0.08928493f, 
    -0.08605614f, 0.05308518f, 0.06155059f, -0.18949398f, 0.29452693f, 0.18267082f, -0.00679497f, -0.03374778f, 
    0.08819974f, 0.63891882f, 0.42121217f, 0.15411165f, -0.04376849f, 0.08015648f, 0.28476140f, -0.03514963f, 
    0.02674155f, 0.04283993f, 0.06377728f, 0.32272062f, 0.24361193f, -0.08844146f, 0.16258027f, -0.08415737f, 
    -0.20661412f, 0.36424318f, -0.94111896f, 0.07000376f, -0.14294183f, -0.14695917f, 0.38364154f, -0.08601766f, 
    0.46390027f, -0.10050272f, 0.20336053f, -0.02422049f, 0.20600121f, -0.21470581f, 0.01040002f, -0.33214086f, 
    0.81533247f, 0.20953920f, -0.23345450f, -0.31970841f, 0.11706720f, -0.06675398f, 0.50612700f, 0.03378623f, 
    0.18680416f, -0.05054973f, -0.33039391f, 0.14470837f, -0.05166585f, 0.07215428f, 0.10074084f, 0.10004276f, 
    0.23558605f, -0.02225832f, 0.09315266f, -0.08017662f, -0.08836929f, 0.06163471f, -0.06961913f, 0.12508602f, 
    0.06922972f, -0.00125546f, -0.03262453f, -0.06870487f, -0.09726226f, -0.13048571f, 0.07539222f, 0.01568641f, 
    0.06464802f, 0.11328681f, -0.00720243f, 0.11143999f, 0.06612866f, -0.00678375f, -0.13604686f, -0.10174847f, 
    -0.12827273f, 0.11688565f, -0.05915264f, -0.00979966f, -0.10270492f, 0.10596746f, 0.01020633f, -0.12583286f, 
    0.09752797f, -0.00335263f, 0.05169092f, 0.08916488f, -0.10930610f, 0.02073397f, -0.08865169f, -0.11678695f, 
    0.00155485f, 0.06184762f, -0.02181838f, -0.08122503f, 0.03360004f, 0.06248926f, 0.01769825f, -0.14312281f, 
    0.05599647f, -0.00104156f, -0.06800728f, 0.05193001f, -0.05842260f, -0.12339009f, -0.14337395f, 0.11516756f, 
    -0.06225671f, 0.01150317f, 0.05527198f, -0.02194046f, -0.05147572f, -0.02341987f, 0.10613395f, -0.07578461f, 
    0.03880331f, -0.10357004f, -0.11927127f, 0.00491774f, -0.03295800f, -0.01593916f, -0.11399638f, 0.06860428f, 
    -0.10684792f, -0.16309752f, 0.12907393f, 0.25261119f, 0.03843111f, -0.07729488f, -0.08058436f, -0.24240430f, 
    0.33994764f, -0.16260093f, 0.17180216f, -0.01325316f, 0.06354816f, -0.10391907f, 0.29851937f, -0.07872940f, 
    0.01827854f, 0.13339315f, 0.05226910f, 0.03397674f, 0.14164814f, -0.03311502f, 0.07197639f, -0.10469803f, 
    0.08909380f, 0.31060177f, 0.60613596f, -0.06661534f, -0.06039137f, 0.18963417f, -0.14353012f, -0.18886828f, 
    0.03339187f, -0.26226473f, 0.11626127f, 0.00096558f, -0.14039060f, 0.24570072f, 0.05113167f, 0.07310058f, 
    -0.19464925f, 0.00405938f, -0.06121145f, 0.00812362f, 0.13671620f, 0.20389311f, 0.04760354f, 0.10171090f, 
    -0.11927213f, 0.04253709f, 0.14811938f, 0.70692050f, 0.07949594f, -0.02343780f, -0.10658301f, -0.07956687f, 
    0.46220869f, 0.03841558f, 0.24254914f, -0.16904515f, -0.01988210f, 0.23664586f, 0.31238911f, -0.02893645f, 
    0.11062898f, 0.00462064f, 0.01022792f, 0.04818886f, -0.06229251f, 0.08560633f, 0.07669294f, -0.02777890f, 
    -0.11977713f, 0.04519228f, -0.07609580f, -0.05026877f, -0.10963848f, -0.13730955f, -0.11119614f, -0.03572892f, 
    -0.02723897f, 0.06283772f, 0.04874614f, -0.05381973f, 0.10278206f, -0.05627646f, -0.10385597f, -0.02683857f, 
    0.01459743f, -0.10950063f, -0.04128766f, 0.08509547f, -0.08098402f, -0.08233245f, -0.01607014f, -0.13848536f, 
    -0.01607086f, 0.10238104f, -0.09103651f, 0.01926761f, 0.06506576f, -0.02778403f, 0.01190827f, 0.02437963f, 
    -0.12085213f, 0.04571693f, -0.05969854f, -0.01809322f, 0.03253746f, -0.10244283f, -0.11471484f, 0.03956359f, 
    -0.11113728f, 0.10807253f, 0.11020926f, -0.05424334f, 0.00464083f, -0.03567674f, 0.11340750f, -0.04329655f, 
    -0.11227700f, 0.00863709f, -0.11521360f, 0.09499022f, 0.07885456f, -0.06473380f, -0.13276854f, 0.06400439f, 
    -0.05125333f, -0.04825348f, 0.07595643f, -0.11140193f, 0.04683280f, 0.08615609f, 0.03362450f, -0.08683126f, 
    0.06645056f, 0.04877416f, -0.04554695f, 0.00770335f, -0.06903391f, 0.00576150f, -0.11045500f, 0.03773536f, 
    -0.05812315f, -0.07981235f, 0.03877134f, -0.05419106f, -0.13022134f, -0.16077384f, -0.07913646f, 0.01613536f, 
    -0.04913091f, 0.00954324f, 0.10186516f, 0.04379049f, -0.14855404f, -0.05262481f, 0.05817999f, -0.06378106f, 
    0.06211883f, 0.00359565f, -0.01894267f, -0.06037520f, 0.00623055f, 0.04616400f, -0.15674485f, -0.12300107f, 
    -0.13685556f, -0.09878112f, 0.04763584f, 0.06604008f, 0.01491056f, 0.04378359f, 0.03700799f, 0.00039139f, 
    -0.12632221f, 0.00952403f, 0.01397379f, -0.13488288f, -0.12858614f, 0.04408965f, -0.12192524f, 0.06974718f, 
    -0.09086862f, -0.13212143f, -0.07763717f, -0.11872352f, 0.09583895f, -0.05599332f, 0.03697370f, -0.11794242f, 
    0.05152769f, -0.07164825f, 0.05407897f, 0.04236687f, 0.03333881f, -0.06948340f, -0.04683952f, -0.02783144f, 
    0.07144913f, -0.08076973f, -0.13854043f, -0.02623963f, 0.11475065f, 0.04209984f, -0.16238645f, 0.03779203f, 
    -0.14796442f, 0.09590648f, 0.04427192f, -0.06328562f, 0.02512439f, 0.00473846f, -0.12781970f, -0.03625567f, 
    -0.02712086f, -0.11910080f, 0.10854663f, -0.06454577f, -0.02478885f, -0.03732514f, -0.12656939f, 0.05179713f, 
    0.05746605f, -0.12812243f, 0.01201868f, -0.12902105f, -0.05332114f, -0.17172839f, -0.03890155f, 0.06707191f, 
    0.04321137f, -0.10406930f, -0.09150488f, -0.09593164f, -0.08374519f, 0.07023578f, -0.11212266f, -0.04094340f, 
    -0.08057532f, -0.08074115f, -0.12205567f, -0.02698472f, -0.04910989f, -0.00510911f, -0.02849011f, 0.10464206f, 
    0.06162488f, -0.06075780f, -0.01757135f, -0.05787148f, -0.06020011f, -0.10044540f, -0.16244519f, 0.11389807f, 
    -0.08771496f, 0.06281872f, 0.08547588f, -0.59684956f, 0.03389369f, -0.17495896f, -0.11294945f, 0.17738715f, 
    0.11952686f, -0.63925511f, 0.09309842f, 0.17877366f, 0.15408908f, 0.32882053f, 0.36377299f, 0.07561888f, 
    0.04097322f, 0.09586406f, 0.23080033f, 0.26841769f, 0.09528293f, -0.17184535f, -0.10708865f, 0.14738652f, 
    -0.37735111f, 0.18919544f, -0.79412794f, 0.06469493f, 0.14890134f, 0.32596818f, -0.13834855f, -0.14615653f, 
    0.79755741f, -0.16824546f, 0.38157922f, 0.18412630f, 0.47569299f, 0.00660345f, -0.11073377f, -0.45341733f, 
    0.02377975f, 0.28351089f, -0.50891387f, -0.24571030f, -0.28520280f, -0.00280572f, 0.30965272f, 0.10231816f, 
    -0.15409827f, -0.08071381f, -0.08568188f, 0.04169375f, -0.02315000f, 0.06456190f, -0.03839907f, 0.10135379f, 
    0.49308246f, 0.03906628f, -0.21191196f, 0.10918303f, -0.07971529f, -0.36912018f, -0.24066798f, 0.13372734f, 
    0.05165251f, -0.06140200f, 0.06182051f, 0.06471231f, -0.00718651f, 0.11933760f, -0.10089894f, 0.12149796f, 
    0.21070562f, -0.58299214f, 0.04965733f, 0.01243342f, -0.20427036f, -0.05534952f, 0.01893449f, 0.12669997f, 
    0.21954143f, -0.02733910f, 0.02197092f, -0.09992450f, -0.08599390f, 0.21264325f, -0.07503930f, 0.33402681f, 
    0.07283419f, 0.13672020f, 0.41044289f, -0.10278949f, 0.26498875f, 0.20887668f, -0.11672974f, 0.21935955f, 
    -0.33896729f, 0.20592754f, 0.07855386f, 0.30446962f, 0.39865038f, -0.00634574f, 0.08547465f, 0.55818295f, 
    -0.29133934f, -0.10398104f, 0.20738706f, 0.40979716f, 0.08407552f, 0.05668397f, -0.22762185f, 0.11272289f, 
    -0.21955140f, 0.14648385f, 0.65030301f, -0.01468942f, 0.29116365f, 0.04417346f, -0.04769246f, -0.09082662f, 
    0.12509920f, -0.10585966f, 0.05282774f, 0.40306509f, 0.02333157f, -0.09161630f, -0.08231615f, 0.01302841f, 
    -0.07654571f, -0.10734718f, 0.13895884f, 0.10275905f, 0.05793554f, -0.10659519f, -0.01242913f, 0.01854696f, 
    0.21937157f, 0.15038711f, 0.15142430f, 0.21497503f, 0.12212315f, -0.01093925f, 0.24270482f, -0.15921415f, 
    0.02813883f, 0.13001555f, 0.09235974f, 0.24554034f, 0.14061268f, -0.15194361f, 0.07822674f, 0.07930216f, 
    -0.39584559f, 0.37410146f, 0.63725805f, 0.05600694f, -0.02555810f, 0.31500176f, 0.03292839f, 0.00002958f, 
    0.35620120f, -0.32278085f, 0.39476383f, -0.13504331f, -0.14462678f, 0.46785840f, -0.02197840f, -0.04427813f, 
    -0.42459175f, 0.29164913f, 0.07866624f, -0.28044814f, -0.08564487f, 0.08696696f, 0.26842806f, 0.00161144f, 
    -0.03699610f, 0.01374068f, 0.10315715f, 0.41536239f, -0.10528271f, -0.25451946f, 0.09059057f, -0.08738535f, 
    -0.10183938f, -0.08675154f, 0.06561853f, 0.09253474f, -0.09251185f, -0.03484243f, 0.41229555f, 0.03805001f, 
    0.02642228f, 0.19233285f, 0.37536082f, -0.05081966f, 0.39414799f, 0.08578502f, -0.02633184f, 0.11967056f, 
    0.38803819f, 0.10278548f, 0.09164208f, 0.15548097f, -0.02226035f, 0.24270540f, 0.26100159f, 0.05983371f, 
    0.15373030f, 0.06310713f, 0.16143416f, 0.19319680f, 0.22901592f, -0.25051519f, 0.10418145f, -0.06914736f, 
    -0.33444810f, 0.35653648f, 0.09278868f, 0.07154007f, -0.00046044f, 0.16647804f, 0.08062268f, -0.19757947f, 
    0.73689622f, -0.51963943f, 0.27618825f, -0.10679919f, -0.08339766f, 0.16538359f, 0.09372539f, 0.01579974f, 
    -0.27318701f, 0.15508775f, -0.46712187f, -0.49153584f, 0.03016477f, 0.12449127f, 0.40425658f, 0.00476593f, 
    0.20105259f, 0.06513184f, -0.14301315f, 0.27742836f, 0.04225205f, -0.21020231f, -0.03212183f, -0.02271105f, 
    0.22956222f, 0.13821715f, -0.06701931f, 0.05824844f, -0.11159154f, -0.03924255f, 0.17653474f, 0.08651565f, 
    -0.11809224f, -0.08709746f, -0.01837827f, -0.12113385f, 0.11119819f, -0.03061660f, 0.02525851f, 0.02659945f, 
    0.07297520f, -0.12339546f, -0.02995895f, -0.10082138f, -0.04288188f, -0.08859947f, -0.10803540f, -0.05732147f, 
    0.02502739f, -0.09560816f, -0.06899217f, 0.00867963f, 0.10755935f, -0.13470334f, -0.13604930f, 0.10535816f, 
    -0.05822077f, -0.01009298f, -0.07873861f, -0.09903258f, 0.02701195f, 0.08860710f, 0.01349369f, -0.10409180f, 
    0.04563172f, 0.07577708f, -0.10229259f, 0.10306033f, -0.05456367f, -0.07731605f, -0.00284901f, -0.05221009f, 
    0.10240445f, -0.04490130f, -0.04384060f, -0.10182503f, -0.02350209f, -0.07131553f, 0.00854364f, 0.07466252f, 
    -0.11038817f, 0.00038449f, -0.07692900f, -0.10818109f, 0.09885826f, -0.13410190f, 0.00299581f, 0.07280236f, 
    -0.06596534f, 0.00620917f, -0.11448199f, -0.00119941f, -0.11803217f, 0.11935392f, 0.03690980f, 0.11957543f, 
    0.04741253f, 0.08160614f, -0.04533765f, 0.18855824f, -0.04394037f, 0.19526403f, -0.06697194f, -0.12998889f, 
    -0.06071823f, -0.32324794f, 0.50839537f, 0.19345947f, -0.20525040f, -0.01879995f, 0.35865310f, -0.25705656f, 
    0.01136166f, -0.08014829f, 0.00513533f, 0.10998938f, 0.27449945f, -0.04521430f, 0.12544848f, -0.01033151f, 
    0.19484968f, 0.18391520f, -0.08398405f, 0.01292755f, -0.17414795f, -0.03445616f, 0.32943302f, -0.29038563f, 
    -0.31995386f, -0.20775098f, -0.03644516f, -0.18501358f, -0.24099782f, -0.09822264f, 0.20589720f, -0.76204067f, 
    0.43280676f, -0.00834853f, -0.28942752f, -0.08187924f, 0.10825966f, -0.01728859f, 0.12380746f, -0.07590313f, 
    0.16887747f, 0.19318172f, -0.45702344f, 0.12048723f, 0.07473924f, 0.21748158f, 0.01444734f, -0.03976788f, 
    -0.46638983f, -0.09696460f, 0.16896275f, 0.13493843f, 0.09714107f, 0.27569541f, -0.06067484f, 0.06281781f, 
    -0.03144407f, 0.38351992f, -0.11951634f, 0.01653330f, 0.25205770f, 0.29443565f, 0.01399338f, 0.25361481f, 
    -0.26997423f, -0.06822523f, -0.19831051f, 0.07405870f, 0.19112113f, 0.09884258f, -0.36850047f, 0.28172892f, 
    -0.25135854f, -0.00653695f, 0.02869668f, 0.23635110f, 0.11435639f, 0.15270971f, 0.10371173f, 0.26734111f, 
    0.16415457f, -0.40262169f, -0.10729731f, 0.06003976f, 0.18881233f, -0.01928130f, 0.29892755f, 0.20087464f, 
    0.17675459f, 0.31491292f, -0.33061567f, 0.15695128f, 0.03459425f, -0.04274918f, -0.05249396f, 0.42640939f, 
    0.24715583f, -0.11864929f, 0.52690536f, 0.30363986f, 0.26530483f, 0.12021843f, -0.15139635f, 0.25344387f, 
    0.52668518f, 0.00072348f, 0.46451670f, -0.36712244f, 0.08855265f, 0.13096462f, 0.07932258f, 0.10969087f, 
    -0.22623308f, 0.01031266f, 0.04985872f, 0.10035400f, -0.03150344f, 0.08420941f, -0.19513053f, -0.07967819f, 
    -0.11666471f, 0.11396742f, 0.25185198f, 0.10157324f, -0.08652020f, 0.25311151f, 0.06585561f, -0.01154938f, 
    -0.15755469f, -0.17808926f, 0.08802679f, -0.17479359f, 0.04808709f, 0.19159323f, -0.23006973f, 0.06639992f, 
    -0.02299194f, 0.07992083f, 0.12386005f, -0.12934524f, 0.07354948f, 0.25637630f, -0.04010652f, -0.17146717f, 
    0.20497634f, -0.44338515f, -0.37749317f, 0.03156516f, 0.04421214f, -0.12757258f, 0.05210227f, 0.01664367f, 
    -0.18173851f, 0.24709027f, -0.41153401f, -0.07072173f, -0.37055540f, 0.12035411f, 0.10982769f, 0.67150396f, 
    0.22497879f, -0.24420111f, 0.21288371f, 0.21581985f, 0.06604610f, -0.01186168f, -0.18392490f, 0.15233339f, 
    0.39915040f, 0.10134008f, 0.37421310f, -0.06832236f, 0.13539660f, 0.50400800f, -0.08957547f, 0.02305457f, 
    0.68419087f, 0.06536810f, 0.15422232f, -0.13973540f, -0.10523568f, 0.25651681f, 0.00838271f, -0.06693670f, 
    -0.09532800f, 0.36295572f, 0.38182476f, 0.19516101f, -0.41814399f, -0.12978047f, 0.05436970f, -0.29588062f, 
    -0.40234452f, 0.25756091f, 0.05550930f, 0.17807646f, 0.38779449f, 0.46930984f, -0.18681821f, -0.07987007f, 
    0.34658098f, -0.04686696f, -0.03126244f, -0.02728605f, 0.23075503f, 0.25974113f, 0.19992700f, -0.43672308f, 
    -0.14227860f, -0.08790642f, 0.21245353f, -0.08612792f, -0.17422679f, 0.39135072f, 0.03997399f, -0.14186032f, 
    0.18729518f, -0.04127423f, -0.09831264f, -0.08441010f, -0.35859033f, 0.16444466f, -0.08401180f, -0.48337662f, 
    -0.28414774f, 0.27466267f, -0.45573312f, -0.56672871f, -0.27912048f, -0.41304606f, 0.18321973f, 0.14476833f, 
    0.29536930f, 0.22133832f, -0.70949948f, -0.08252783f, -0.31371549f, 0.16435072f, 0.03123265f, 0.04756130f, 
    0.11484921f, -0.49999586f, 0.00137898f, -0.15135947f, -0.05229229f, 0.45805144f, 0.07033077f, 0.11717813f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.21597636f, -0.07560519f, 0.04561756f, 0.01181843f, -0.01049952f, 0.00143655f, -0.01981837f, -0.21102872f, 
    0.30909073f, -0.14428286f, -0.01387524f, 0.20820874f, -0.05402532f, 0.22376077f, 0.13685834f, 0.05648790f, 
    0.23674645f, 0.18039989f, -0.03703893f, -0.09281060f, -0.07032695f, -0.16622786f, -0.05884669f, -0.07935887f, 
    -0.04037654f, 0.07171955f, -0.14371453f, -0.02450862f, 0.26066446f, -0.53869462f, 0.03563840f, -0.05758709f, 
    -0.02052316f, -0.09005383f, -0.01237890f, -0.12255163f, -0.08610880f, 0.21426471f, -0.13899578f, -0.05356570f, 
    -0.05759006f, -0.08235683f, 0.03342550f, 0.22579724f, -0.04028389f, 0.18259968f, -0.13540643f, 0.35279396f, 
    0.26277179f, 0.08745161f, -0.10217343f, 0.07436759f, -0.09370824f, 0.08385299f, -0.07718237f, -0.02526808f, 
    0.14431554f, -0.00904354f, 0.03282360f, -0.06375392f, 0.34603313f, 0.03884969f, -0.19084829f, -0.49176919f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    0.22077155f, -0.11568657f, 0.06209934f, 0.11513133f, 0.01161799f, 0.04533114f, 0.01939712f, -0.22639149f, 
    0.08532260f, -0.24258348f, -0.20169766f, -0.23866871f, -0.07797569f, -0.00971830f, -0.25458041f, -0.13485238f, 
    0.24955450f, -0.63405234f, -0.11209236f, 0.08777545f, 0.01989511f, -0.09090519f, 0.06404898f, -0.10900796f, 
    -0.03830069f, -0.42828047f, 0.09039172f, 0.43886796f, 0.00170769f, -0.82209474f, 0.31433994f, 0.03260707f, 
    -0.14151186f, -0.10426254f, -0.11753342f, -0.10954347f, -0.60479271f, -0.04318595f, -0.03837917f, -0.02476178f, 
    0.06706863f, -0.70021027f, -0.17945731f, -0.35421896f, -0.09360494f, 0.11485373f, 0.10397207f, 0.04120873f, 
    -0.13818344f, -0.11817674f, 0.04902802f, 0.02670782f, -0.08350599f, 0.07682505f, -0.16314723f, -0.14596283f, 
    -0.17917612f, -0.23857184f, -0.13427034f, 0.08551724f, 0.31605342f, 0.17207447f, 0.22262821f, -0.78607684f, 
    -0.07845367f, -0.15017340f, 0.05241916f, 0.18727961f, 0.09499642f, 0.01210608f, 0.10940517f, -0.02593350f, 
    0.09332997f, -0.12342191f, 0.11834078f, -0.32181153f, -0.06879546f, -0.52225929f, -0.04331340f, 0.05632705f, 
    0.15752004f, 0.04736952f, 0.04406996f, -0.08047264f, 0.03277384f, -0.08873039f, 0.00175270f, 0.05722314f, 
    -0.05328985f, 0.86609852f, -0.11689297f, 0.15596510f, -0.03714241f, 0.68405563f, -0.19690982f, -0.01542939f, 
    -0.02712755f, -0.03718846f, 0.17212535f, 0.01390190f, -0.12076578f, -0.29914421f, -0.06702590f, -0.03224083f, 
    0.07922889f, 0.09516815f, 0.08532675f, 0.08834612f, -0.14711168f, 0.11362588f, 0.33404148f, -0.04534701f, 
    -0.55743694f, -0.27483112f, -0.08787192f, -0.41697177f, -0.05135791f, -0.05753679f, 0.02699515f, -0.39915729f, 
    0.12980480f, -0.30022219f, -0.25550902f, 0.04115192f, -0.04243894f, 0.21251306f, 0.02563134f, 0.40443182f, 
    0.04080822f, 0.03769440f, -0.01488821f, -0.18041286f, -0.02163832f, 0.04300696f, -0.08885951f, -0.35491452f, 
    -0.30789182f, 0.02235861f, 0.44048783f, -0.22281465f, 0.08364929f, 0.12377767f, 0.03066654f, 0.12967707f, 
    -0.41712308f, -0.18535568f, -0.07731403f, -0.12028918f, -0.10523506f, 0.03197591f, -0.01116796f, -0.05668890f, 
    0.11677679f, -0.42971838f, 0.06965213f, 0.14301820f, -0.49765965f, -0.61919481f, -0.49585417f, -0.05694950f, 
    -1.01919782f, -0.03839500f, 0.15599973f, -0.03429090f, -0.70376027f, -0.03017714f, -0.05679746f, 0.06529391f, 
    0.09533455f, -0.60285372f, -0.18068922f, 0.14108881f, 0.01666684f, -0.04435764f, 0.03149620f, -0.06613563f, 
    -0.19355504f, 0.17548002f, 0.03541882f, -0.17317277f, -0.11069569f, 0.11081019f, -0.03729268f, 0.33556509f, 
    -0.24014427f, 0.15130316f, 0.27126965f, 0.07818843f, -0.85906094f, 0.16957213f, -0.08529572f, -0.52655655f, 
    -0.35677037f, -0.05456045f, 0.13301305f, -0.03384515f, -0.11019484f, -0.06652196f, -0.00314875f, 0.10949444f, 
    -0.51561314f, -0.77671146f, -1.04967391f, -0.45373687f, -0.02503618f, 0.19771397f, 0.08949199f, -0.20508476f, 
    -0.31880692f, 0.16850810f, -0.06440379f, -0.05116724f, -0.08723803f, 0.04324939f, -0.06900760f, -0.06087532f, 
    0.01371298f, -0.36173457f, 0.00727246f, -0.01032636f, 0.18205264f, -0.71403146f, -0.30671760f, 0.00071669f, 
    0.15943423f, 0.02743288f, -0.19475931f, -0.11473674f, 0.01805069f, 0.17009123f, 0.02780063f, 0.07503442f, 
    0.03126519f, 0.03568117f, 0.14737044f, -0.26798281f, -0.07609526f, -0.38535365f, -0.01314959f, 0.26604384f, 
    0.15855800f, 0.17644717f, 0.01652587f, 0.19000408f, 0.08591627f, 0.11437408f, -0.01265122f, 0.00907723f, 
    -0.11944448f, 0.08710819f, 0.10769051f, 0.01853748f, 0.18612188f, -0.45354524f, -0.30105951f, -0.13615064f, 
    0.07256130f, -0.11294729f, 0.07339584f, -0.52832210f, -0.12647721f, 0.04146774f, -0.04515794f, 0.08107720f, 
    0.17824933f, 0.14669207f, 0.15188999f, 0.14818272f, 0.07748636f, 0.02582753f, 0.10724339f, -0.23294407f, 
    0.15591447f, -0.43835735f, -0.10750856f, -0.00146022f, 0.01722609f, 0.01804113f, 0.06282333f, 0.00026723f, 
    0.10628723f, -0.70048797f, 0.08650187f, -0.05930606f, -0.26598597f, -0.83087152f, 0.15545036f, -0.15046309f, 
    -0.07546394f, 0.04848770f, -0.21285993f, -0.04215534f, -0.11522826f, 0.19225423f, -0.04856612f, -0.11793724f, 
    0.09142248f, 0.02048429f, -0.04302615f, 0.17002119f, -0.04711269f, 0.02301417f, -0.16490273f, 0.01734151f, 
    0.21112068f, 0.22260875f, 0.07570826f, -0.03837897f, -0.00372883f, 0.01114283f, 0.00850524f, 0.17675927f, 
    -0.14867191f, -0.12159035f, 0.10546378f, 0.11040855f, -0.01008015f, -0.08497781f, -0.02974292f, -0.22036420f, 
    -0.07776760f, -0.07997295f, -0.07304346f, 0.08920966f, -0.08993349f, -0.05540816f, -0.07150455f, 0.31945172f, 
    0.03921058f, 0.12454825f, -0.02376859f, 0.25929433f, -0.02382428f, -0.26408520f, 0.11140283f, 0.15812965f, 
    0.17387155f, 0.07124394f, 0.01826850f, -0.13489631f, 0.03352159f, 0.08649763f, 0.03355828f, 0.00151989f, 
    0.12434448f, -0.00759383f, -0.11025868f, -0.78295279f, 0.36810327f, 0.04619632f, 0.27636999f, -0.07020743f, 
    0.26987913f, -0.12382214f, -0.23198575f, 0.00418154f, 0.21459907f, -0.12932372f, 0.01337471f, 0.11391241f, 
    -0.09972027f, 0.22775957f, -0.05898478f, -0.10015352f, -0.12005617f, 0.23603998f, -0.02586273f, -0.06754532f, 
    -0.19121791f, -0.51674873f, -0.12355258f, -0.09689602f, -0.02485435f, 0.03611583f, -0.16692938f, -0.42653170f, 
    0.15301996f, -0.28082615f, -0.46206528f, 0.02701495f, 0.03705227f, 0.26175386f, 0.13108017f, 0.20438910f, 
    0.04773287f, -0.03072269f, -0.01704178f, -0.05595493f, -0.11458188f, -0.09513906f, 0.02967400f, -0.55167764f, 
    0.22293857f, -0.55094743f, -0.35591173f, 0.33704746f, 0.06891295f, 0.02876077f, 0.09191225f, 0.05886772f, 
    0.22314134f, -0.01370334f, 0.02239763f, 0.04279347f, -0.12245713f, 0.03049386f, 0.00287314f, -0.13317458f, 
    0.01685838f, -0.08582047f, 0.10685115f, -0.49003321f, 0.03798816f, -0.45501184f, -0.17622225f, -0.06145866f, 
    -0.37229529f, 0.02148352f, 0.14818935f, -0.17761296f, -0.16675775f, 0.22286846f, -0.03811977f, -0.04836152f, 
    0.08351448f, -0.03370107f, 0.10620467f, 0.18656932f, 0.04534038f, 0.21734634f, 0.04832097f, -0.02514508f, 
    -0.23401093f, -0.38254565f, -0.08070149f, 0.12136742f, -0.07691735f, -0.01665667f, -0.05314974f, -0.32071272f, 
    0.01298802f, 0.24017332f, 0.07521363f, -0.05062774f, -0.34509459f, -0.03509246f, -0.51953644f, 0.31433213f, 
    -0.09634957f, -0.05863119f, -0.03224320f, -0.38130704f, 0.05001687f, -0.00619680f, -0.03013805f, 0.33695704f, 
    -0.27143943f, 0.42835110f, 0.08587654f, -0.26360798f, 0.10029422f, -0.00166142f, -0.01501365f, -0.85530233f, 
    -0.06257202f, -0.59524393f, 0.04655430f, -0.02271882f, -0.06229363f, 0.05539797f, -0.13885593f, 0.01475886f, 
    0.04277399f, -0.71246052f, -0.03781787f, 0.04209629f, -0.26305729f, 0.76920968f, 0.04194041f, -0.10599807f, 
    0.29449600f, 0.05974580f, -0.57895994f, -0.02114188f, 0.15805013f, 0.05855072f, -0.01519717f, -0.08999668f, 
    0.02271428f, 0.19665913f, 0.07371590f, -0.45017183f, -0.13733864f, -0.43056339f, 0.02194855f, -0.10270534f, 
    0.10270384f, 0.20511113f, 0.03657832f, 0.09486885f, -0.00399968f, -0.00525911f, -0.02187541f, -0.30448750f, 
    -0.79270911f, 0.00115463f, -0.02351580f, -0.01051139f, 0.04009889f, -0.14893049f, 0.07822395f, 0.53585237f, 
    -0.41140854f, -0.00054124f, 0.04322944f, 0.24752179f, 0.00319647f, 0.09411959f, 0.02152565f, 0.05474911f, 
    0.02729203f, 0.32516539f, -0.10557457f, -0.65134221f, -0.01833375f, -0.42248270f, -0.97706002f, -0.06039026f, 
    -0.28675434f, 0.27688003f, -0.07490701f, -0.11734434f, -0.03697675f, 0.03769427f, 0.09961973f, -0.07823504f, 
    -0.08547629f, -0.35312015f, -0.00578237f, 0.30858728f, -0.74004561f, -0.44996670f, 0.23191456f, 0.03797349f, 
    0.25319999f, 0.08320876f, 0.23709862f, -0.01245343f, 0.43444964f, -0.40898266f, -0.08925990f, 0.10252400f, 
    -0.11973094f, -0.06401387f, 0.08833554f, 0.13703626f, 0.00391378f, -0.01608569f, 0.24030942f, -0.63510841f, 
    -0.53808725f, -0.20380814f, 0.10321882f, -0.17090444f, 0.00685020f, 0.02946468f, -0.03596405f, 0.49524906f, 
    0.25938380f, -0.50777107f, -0.60969323f, -0.01310858f, -0.52623779f, 0.07716864f, 0.13330890f, -0.04610465f, 
    0.15220651f, -0.15646331f, 0.09033415f, -0.28467530f, -0.09688383f, -0.01312917f, 0.06077028f, -0.12069860f, 
    0.15787256f, 0.28608865f, -0.01769074f, 0.20394190f, -0.11378471f, 0.05777184f, -0.18409249f, 0.08560251f, 
    0.18005015f, -0.49377185f, 0.05473486f, 0.00037893f, 0.00137644f, -0.04491159f, -0.01167280f, 0.01831053f, 
    -0.10359347f, -0.80807626f, -0.03038284f, -0.22872321f, -0.00369474f, 0.19069563f, 0.09166455f, 0.00769988f, 
    -0.20941241f, 0.06645302f, 0.14709891f, -0.10555563f, -0.49000382f, 0.24887128f, 0.04999542f, -0.05553983f, 
    -0.00389934f, 0.12644386f, -0.69356084f, -0.01866989f, -0.05365670f, 0.12950492f, -1.19546318f, -0.36492413f, 
    -0.14196377f, -0.30002886f, 0.04550086f, 0.26108932f, -0.08505297f, 0.06938776f, 0.02105376f, -0.15024209f, 
    0.13385567f, 0.00628623f, 0.11565554f, -0.05490005f, -0.07462451f, -0.16934247f, 0.10666814f, 0.22089459f, 
    -1.35932171f, -0.02416111f, 0.00288366f, 0.08187653f, 0.03373337f, -0.03956204f, 0.00818215f, -0.20981772f, 
    -0.79221070f, -0.79312778f, -0.33915693f, -0.32540709f, -0.01588383f, 0.09597895f, -0.02579948f, 0.11982216f, 
    -0.19824834f, 0.11883847f, -0.06331103f, -0.08904254f, 0.07433309f, 0.05356084f, -0.08663096f, -0.02304363f, 
    -0.02043131f, 0.46388587f, 0.04846554f, 0.10632969f, 0.18500084f, -0.68260372f, -0.72587270f, -0.01926360f, 
    0.10518627f, 0.07267785f, 0.09929558f, -0.00021594f, 0.15352015f, -0.00589514f, -0.04165648f, 0.10136802f, 
    0.02607952f, -0.19359377f, 0.28328434f, 0.10407656f, -0.05649197f, -0.14573839f, 0.28362623f, 0.26456529f, 
    0.36846757f, 0.29340503f, -0.04256475f, -0.08874226f, -0.12409216f, -0.02995950f, 0.05812718f, -0.00968794f, 
    -0.06894293f, 0.01024739f, -0.02513298f, -0.02766623f, 0.03091827f, -0.23751721f, -0.61966586f, -0.83674401f, 
    -0.31166258f, -0.01794046f, -0.01549295f, 0.25344676f, -0.01635472f, -0.02649336f, 0.09556552f, -0.58227581f, 
    -0.00031950f, 0.29284289f, -0.55738145f, 0.17843549f, -0.09897219f, -0.03577321f, -0.00751037f, 0.12276440f, 
    -0.32891968f, 0.10094685f, 0.02264860f, -0.09106828f, -0.09770906f, -0.00806319f, -0.09572814f, 0.01070623f, 
    -0.08644231f, 0.03018433f, 0.01413807f, 0.03087579f, -0.08214408f, -0.00251787f, -0.47347206f, -0.07883500f, 
    0.02002230f, 0.00391306f, 0.04893840f, 0.10131162f, 0.34143129f, -0.18221392f, -0.04181515f, 0.08865661f, 
    -0.03893277f, 0.17823721f, 0.15145989f, -0.01905189f, -0.12025622f, -0.29664880f, 0.05044757f, 0.18332200f, 
    -0.04542257f, -0.11830908f, 0.00904485f, 0.27060443f, -0.12121175f, 0.06539629f, -0.00809684f, 0.24657226f, 
    -0.05972653f, 0.31298926f, -0.03098259f, -0.07817999f, -0.08108550f, -0.26165050f, -0.21385959f, 0.08533541f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    0.24176428f, -0.08116088f, -0.41128218f, 0.11367458f, 0.12087762f, -0.15804635f, 0.06376540f, -0.60034430f, 
    -0.07649198f, 0.01214586f, 0.19778693f, 0.09577202f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
