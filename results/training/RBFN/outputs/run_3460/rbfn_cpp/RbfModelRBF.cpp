#include "RbfModelRBF.h"

// ==========================================
// Flash/PROGMEM Macros
// ==========================================
#if defined(ESP32) || defined(ESP8266)
    #define RBF_CONST const
    #define RBF_READ(x) (*(x)) // Fixed: Dereference pointer
#elif defined(__AVR__)
    #include <avr/pgmspace.h>
    #define RBF_CONST const PROGMEM
    #if RBF_FIXED_POINT
        #define RBF_READ(addr) (rbf_float)pgm_read_dword(addr)
    #else
        #define RBF_READ(addr) (rbf_float)pgm_read_float(addr)
    #endif
#else
    #define RBF_CONST const
    #define RBF_READ(x) (*(x)) // Fixed: Dereference pointer
#endif

// ==========================================
// Model Parameters
// ==========================================
static RBF_CONST rbf_float RBF_CENTERS[] = {-0.480896, 0.771281, 0.027177, -0.086221, 0.664504, 1.057014, 0.904025, 1.170471, 1.230610, 0.534214, -0.116198, -0.182642, -0.181829, 0.465279, 0.130451, 0.401650, 0.361453, 0.329111, 0.551991, 0.065244, -0.998218, -0.853735, -0.551329, -1.152261, -0.609332, -1.176069, -1.488751, -0.482255, -1.580014, -0.410145, -0.242894, -0.338526, -0.370889, -0.963803, -0.244684, -1.169549, -0.357325, -0.901589, 0.181839, 0.711137, -0.172169, 0.340909, 0.053452, -0.035293, 0.751363, 0.818230, -0.627326, -0.744902, -0.390324, 0.075801, -0.475863, 0.445803, 0.168136, -1.382227, 0.432843, 0.015102, -0.181871, -0.530453, -0.118526, -0.611562, 0.273066, -0.763416, -0.525684, -0.441757, 0.392414, 1.047016, 0.314177, -0.552569, -0.278541, -0.516426, -0.532347, -0.702429, -0.136862, 0.573696, 1.072462, 0.032423, 0.057030, 0.992310, 0.116503, 0.493934, 0.307925, 0.262446, 0.058313, -0.020284, 0.314692, 0.967792, -0.040321, -0.467080, -0.332186, -0.136147, -0.057645, -0.122672, 0.361979, -0.692236, -0.471579, -0.505282, 0.074601, 0.254134, 0.842575, 0.927369, 0.128240, 0.343261, 0.434115, -0.245544, 1.649214, 1.259949, -0.408467, -0.859872, -0.388125, -0.117416, -0.438639, 0.067428, 0.236825, -1.371286, 0.746206, -0.013487, -0.125136, -0.681730, -0.017910, -0.395809, 0.115563, 0.351238, 0.464388, 0.923416, -0.933224, -1.429736, -0.789905, 0.079308, -0.257335, -0.384619, 0.390961, 0.284201, 0.065031, 0.487667, 0.482180, 0.337272, 0.248016, -0.431053, 0.404908, 1.272974, 0.874948, 0.779689, 1.289823, 0.890354, 0.873370, 1.182857, 1.396843, 0.694132, 0.662152, 0.392906, -0.006090, 0.614863, 0.171439, -0.029178, 0.270837, -0.271303, -0.220618, 0.002338, 0.613965, 0.540248, -0.532806, -0.457083, 0.335833, -0.015254, 0.290794, 0.012064, 0.027217, -0.272724, -0.385912, -0.275572, 0.222603, -0.488908, 0.256275, -0.099933, 0.321422, -0.438797, -0.156012, 0.078203, -0.156110, 0.201095, -0.270060, 0.889775, 0.060766, 0.117828, 0.227290, -0.230676, -0.095920, 0.209225, -0.358482, 0.009457, -0.189160, 0.098866, 0.320093, -0.534603, -0.353295, -0.222164, -0.354758, -0.279884, -0.270638, 0.329680, 0.453835, -0.212308, -0.006224, 0.360111, -0.290766, -0.226050, 0.168568, 0.638054, 0.199685, 0.081480, 0.397330, 1.364409, 0.292326, -0.159268, 0.264347, -0.317609, -0.086430, -0.016508, 1.001885, 0.648550, -0.395962, -0.524952, 0.548196, 0.158821, 0.618028, -0.287731, 0.465671, -0.146740, -0.317642, -0.178869, 0.114724, -0.150611, 0.277557, -0.179663, 0.029346, -0.630873, -0.218152, 0.304194, -0.553043, 0.067480, -0.363683, -0.240637, 0.123708, 0.446368, 0.886233, 0.306355, 0.070064, -0.030580, -0.513812, -0.480749, 0.414316, -0.220953, -1.101204, 0.174341, -0.059791, -0.103627, 0.344810, 0.274956, -0.819178, -0.418568, 0.189610, 0.325569, 0.773560, 0.771251, 0.155456, 0.058336, -0.270295, -0.351216, 0.349004, -0.364499, -0.210821, -0.177975, -0.537130, 0.138101, 0.961789, -1.211461, -0.462691, 0.139239, 0.378843, -0.433987, -0.902362, -0.273222, 0.722075, -0.303676, 0.546195, 0.200931, -0.138761, -0.579170, 0.447892, -0.395254, 1.029897, -0.398741, -0.432899, -1.240366, -0.775137, -0.354542, 1.404345, -0.582447, 0.004543, -1.486552, -0.158218, -0.034664, -0.084847, 0.569780, 1.376062, 0.255072, -0.557582, -0.114587, 0.045148, 0.597386, -0.092448, -0.133773, 0.201341, -0.138430, -0.390668, -0.253916, -0.355721, -0.623565, -0.615583, 0.761156, 1.135158, 0.191908, -0.681243, -0.341205, -0.440644, -0.482015, -0.250369, -0.174600, -0.834038, -0.154975, -0.167596, -0.256868, -0.984305, 0.007269, 0.697779, -1.080311, -0.150574, -0.531733, 0.117643, -1.022434, -0.367739, 0.282632, 0.170770, -0.416216, 0.866377, -0.350014, 0.242215, -0.405056, 0.387621, -0.307110, 1.077384, -0.896599, 0.866435, -0.942742, -0.610579, -0.278161, 1.181040, -0.697050, 0.646797, -1.218329, 0.340856, 0.735536, 1.478773, 0.610591, 0.332514, -0.189362, -0.180167, 0.296864, -0.089419, 0.007589, -0.602571, 1.396282, 0.001609, 0.171834, -0.956136, -0.713895, -0.600728, -0.260135, 0.031270, -0.091587, -0.533626, -0.802979, -0.524902, -0.643286, 0.385595, 0.286579, -0.977487, -0.189606, -0.027631, 0.085258, 0.011841, 0.500787, 1.021083, 1.094407, 0.233884, -0.097778, 0.744593, 0.163585, -0.024802, 0.989961, 0.564172, 0.188530, 0.460303, 0.078610, 0.279747, 0.741352, 0.202562, 0.481118, 0.749485, 0.425276, 0.579143, 0.518362, 0.254484, -0.275488, -0.107796, 0.600359, 0.037117, 0.062022, 0.005796, -0.341725, 0.043304, -0.164472, -0.494148, -0.656254, -0.043783, 0.200206, 0.641092, 0.319128, 0.339876, -0.049468, -0.483967, -0.071251, 0.060520, 0.033337, -0.216100, -0.210096, 0.073608, 0.132995, -0.025659, -0.033916, 0.008002, 0.079527, 0.259029, 0.020064, 0.048839, -0.196160, 0.022178, -0.077690, -0.009123, 0.128276, -0.170743, -0.194525, 0.485032, 0.894728, 0.400541, -0.433822, 0.527121, 0.167582, -0.199874, 0.681379, 0.269816, 0.082891, 0.065907, 0.274008, -0.206907, 0.455089, -0.401088, 0.246752, 0.253765, -0.040839, 0.243726, 0.104148, -0.032445, -0.246538, -0.059884, 0.526714, 0.054581, 0.020850, -0.281515, -0.346429, 0.077077, -0.986607, 0.912703, 0.515718, 0.430642, 0.838473, 1.050925, -0.640960, -0.524643, -1.159497, 0.280885, 0.134045, 0.723051, 0.121704, 1.046191, 0.656318, 0.037425, 0.447429, -0.104417, -0.494817, -0.045370, -0.230060, 0.253550, -0.864005, 0.186010, -0.260799, 0.039945, 0.684948, 0.029727, 0.550089, -0.236196, -0.179610, 0.013159, -0.153782, 0.072464, 0.168440, -0.041740, 0.588151, 0.907243, 0.272522, 0.552991, 0.114742, 0.494017, -0.331865, -0.024109, -0.271479, -0.199537, -0.083612, 0.267572, 0.327659, -0.058481, 0.088559, -0.289267, -0.414722, -0.202981, -0.165154, -0.321919, 0.724892, -0.019356, -0.074365, -0.114468, -0.168738, 0.058816, 0.197136, -0.147354, 0.276508, -0.052711, -0.159895, 0.217194, 0.458984, 0.177210, -0.129711, -0.434941, -0.347217, 0.257826, 0.025030, -0.467771, 0.121280, 0.066582, 0.444705, 0.160100, 0.250141, -0.034404, -0.138304, 0.032288, -0.111135, -0.279299, 0.000455, 0.165559, -0.312130, -0.494946, -0.500633, 0.073228, -0.374619, -0.190837, -0.204526, -0.352910, -0.010943, 0.673350, -0.016676, 0.265395, 0.268121, 0.682919, -0.346737, 0.136032, -0.339128, -0.300105, -0.223346, -0.293516, 0.022263, -0.115136, 0.075396, -0.358532, -0.163893, -0.428126, -0.178413, -0.222061, 0.653440, -0.077038, 0.133397, 0.874754, 0.175195, -0.350879, -0.901231, -0.661662, -0.019709, -0.481583, 0.116583, 0.477675, 0.066154, 0.049162, -1.439030, 1.556332, -2.299597, 0.561160, 1.073562, -1.765578, -1.105414, -1.537892, -0.891683, -1.051544, -2.355606, -1.891345, -1.568613, -2.832752, -1.572575, -1.086468, -0.957421, -1.576405, -1.624590, -0.525931, -1.035720, -0.140951, -0.522092, -0.406101, -0.386488, -0.062730, -0.035406, -0.237986, -0.026913, -0.714361, -0.174435, -0.687494, 0.118808, -0.122923, -0.082801, 0.321435, -0.195572, -0.458960, -0.687784, 0.182104, -0.246020, -0.125026, -0.296377, 0.576879, -0.386123, -0.299649, -0.235544, 0.347006, -0.383514, 0.069165, -0.038177, -0.034637, -0.227105, -0.187185, 0.281070, 0.149684, 0.226793, 0.349268, -0.093722, 0.165122, 0.384972, 0.034788, 0.678400, 0.020504, 0.131107, -0.907645, -0.623789, 0.726743, 0.502305, 0.738987, -0.582510, -0.760712, 0.392097, -0.257131, 0.266716, 0.209529, 0.261790, -0.145699, -0.052914, -0.603733, -0.946707, -0.235277, -0.362821, 0.001973, -0.383525, -0.348583, 0.208700, -0.170718, 0.419169, -0.211764, -0.061253, -0.807407, 0.211480, -0.046056, -0.042457, 0.258173, -0.160414, -0.139088, -0.598008, 0.450480, -0.157921, 0.333882, -0.098689, 0.712102, -0.093045, 0.181522, -0.105119, 0.815740, -0.529968, -0.156744, -0.472890, 0.506831, -0.189914, 0.004478, 0.430071, 0.751821, -0.214654, -0.902928, -0.359876, 0.271923, -0.160381, 0.410994, -0.483255, 0.186961, 0.033883, -0.419784, 0.134060, 0.126807, 0.080657, -0.126651, -0.151378, 0.088628, 0.143244, -0.167349, -0.125251, -0.107404, 0.522064, -0.488985, -0.030100, -0.356089, -0.365539, 0.103329, 0.341202, -0.169224, -0.307576, 0.651786, -0.273287, -1.689486, -0.300076, -0.642700, -0.027077, -0.533550, 0.416492, -0.336892, -0.875482, -0.444830, 0.529972, -0.149158, 0.161501, -0.243037, -0.748193, 0.311736, -0.494249, -1.049490, 0.199632, 0.263526, 1.342247, 0.234616, -0.400634, 0.318218, 0.397517, -0.064353, 0.135176, -0.588185, -0.384479, -0.780338, -0.117961, 0.474435, 0.346174, -0.263547, 0.271658, 0.021128, 1.069178, 0.019186, -0.163420, -0.359132, -0.727992, -0.257794, -0.816247, 0.431535, 0.513110, 0.772051, -0.288190, -0.447273, -0.002348, -0.057944, -0.807520, -0.847827, 0.300115, -0.477172, -0.410553, -0.008801, 0.645825, -0.297457, -0.229531, 0.383215, -0.451097, -1.229297, 0.002014, -0.626888, 0.818375, -0.939294, 0.347159, -0.233762, -0.627862, -0.460523, 0.242126, -0.514304, -0.075430, -0.079984, -0.727402, 0.067479, -0.963433, -0.846304, -0.028465, 0.093281, 2.007247, 0.600946, -0.677461, 0.494882, 0.138626, -1.645473, -1.656105, -0.593676, -1.603472, -1.995162, 0.464624, -0.139593, -1.004564, -1.028718, -1.234211, 1.045765, -2.100473, -0.434292, 1.233993, -0.599108, -1.818442, 0.502295, -0.892009, -1.677694, -1.086948, 0.053928, -1.394819, -2.365544, 0.215587, -0.191233, -0.821748, -1.798383, -0.434086, -0.341400, -0.500041, -0.333806, -0.087458, -0.111985, 0.025779, -0.157713, -0.146530, -0.188812, -0.060417, 0.356494, -0.157633, -0.311961, 0.221223, -0.188962, -0.572026, -0.556938, -0.551332, -0.078798, -0.119776, -0.178919, -0.121571, -0.020149, -0.004860, 0.114463, -0.362521, -0.379249, 0.061255, -0.541565, -0.293396, -0.063518, 0.084193, 0.047198, 0.149303, -0.031047, -0.190949, 0.050311, -0.141379, 0.003821, -0.043911, 0.267959, 0.159587, -0.055900, 0.181939, 0.028230, 0.164614, -0.147491, -0.272008, 0.024928, -0.060426, -0.068839, 0.021858, -0.241009, 0.109590, 0.090858, -0.080865, -0.155233, -0.187485, 0.062075, -0.008005, -0.250461, -0.540473, -0.212492, -0.112917, -0.109397, -0.165854, -0.433795, -0.180213, -0.195380, -0.197620, -0.123127, -0.328801, -0.375437, 0.047206, -0.203764, -0.276214, -0.338871, -0.337869, -0.313246, 0.081222, -0.315585, -0.208128, 0.184205, -0.294452, -0.185860, -0.422809, -0.211484, 0.140427, -0.129144, -0.283809, -0.973635, 0.666799, -0.737434, -0.404292, -0.607617, 0.340080, 0.541605, -0.052198, -0.092851, 1.222260, 0.863560, -0.270006, 0.855961, 1.003036, 0.004459, 0.921795, 1.142033, 1.088972, 0.095329, -0.154082, -0.061712, 0.344362, 0.335910, -0.222412, -0.181462, -0.509749, -0.219588, -0.679833, 0.089768, 0.032806, -0.235345, -0.558873, -0.279088, -0.367917, -0.213581, -0.533402, -0.361792, -0.440537, -0.240629, -0.494967, 0.110563, 0.166759, -0.264969, -0.117012, -0.251836, -0.214601, -0.277020, -0.012162, -0.296624, -0.456271, -0.086923, -0.461865, 0.268467, 0.457191, 0.183191, -0.445876, -0.172407, 0.020306, -0.257230, -0.426754, 0.025103, 0.108232, -0.014645, -0.339536, -0.277687, 0.114736, 0.153988, 0.139207, 0.079830, -0.128564, -0.138997, -0.002420, -0.074324, 0.178722, 0.053938, 0.115825, 0.375211, -0.146760, 0.139534, -0.051883, -0.124243, -0.183229, -0.149538, 0.295943, -0.197227, 0.181457, 0.036079, 0.118747, 0.054314, -0.133203, -0.308279, -0.535984, -0.125031, -0.386974, -0.066283, -0.408107, -0.364045, -0.313835, -0.196098, -0.461227, 0.118725, 0.211242, -0.233686, -0.218015, -0.068503, -0.228264, -0.135183, -0.086618, -0.278063, -0.338338, -0.306597, -0.578457, 0.303732, 0.188346, 0.317549, -0.363309, -0.371899, -0.218818, 0.025948, -0.195285, 1.984588, 2.867548, 0.939967, 0.820024, 0.114552, 0.082079, -1.072207, -2.896362, -2.963217, -2.182693, -1.781857, -2.280564, -0.886825, -0.541371, -0.356300, -0.890756, -0.095652, -0.455554, -1.367921, 0.309205, -0.635166, 0.670066, -0.490418, -0.121267, -0.420590, -0.689112, -0.354578, -1.512798, -1.164985, -0.777192, 3.450668, 2.235632, 0.765388, 1.727145, 4.000607, 2.806629, 0.964439, 1.324361, -0.477835, -0.612028, 1.016794, 0.951614, 0.355510, 0.459203, 0.210618, 0.157520, -0.689183, -0.742897, -1.461332, 0.007962, -0.631609, 0.482965, -0.397486, -0.024286, -1.502444, -0.393306, 0.564757, -0.298676, -0.491366, -0.197238, -1.567152, 0.399407, 1.100721, 0.649939, 3.262582, 0.668027, -0.957730, 0.184848, 0.223262, 0.486124, -0.932995, 0.679040, -0.008650, -0.233894, 0.114139, 1.171889, 0.227205, -1.161659, -1.087743, -0.946725, -0.164496, -0.344670, -0.633789, 0.106532, 0.136754, -0.858907, -0.737337, -1.023381, -0.533640, 0.442714, 2.820168, 1.317234, -0.612794, 0.978179, 2.464171, 1.787672, 0.772387, 0.170713, -0.168831, 0.224252, 1.271040, 0.810803, -0.020719, -0.256528, -0.375926, -0.457725, -0.636369, 0.150339, -0.940895, -0.188209, 0.077329, 0.300408, 0.230616, 1.241361, 0.178738, -0.310980, 0.415112, -0.253833, -0.225938, -0.662976, 0.680480, -0.550162, -1.827952, -1.125860, -1.766618, -2.881183, -2.758239, -1.950268, -0.157204, -0.824267, -0.639092, 0.468333, -0.400360, -0.576806, 0.360942, 0.339164, -0.618613, 0.210861, 0.439593, -1.001178, 1.155258, -0.622067, 0.361097, -0.694826, -0.563820, 0.331745, 0.926570, -0.506051, -1.246177, 0.330615, -0.473902, -0.145849, -0.315992, 0.312642, -0.376667, -0.186402, 0.017686, 0.246103, -0.144907, -0.250132, 0.368074, -0.060234, 0.070293, -0.306252, 0.085208, -0.612925, 0.160886, 0.046816, -0.189632, -0.241205, -0.375445, 0.073028, -0.107928, 0.004332, 0.514088, -0.241649, 0.181233, 0.279685, 0.183189, 0.023273, 0.005085, 0.028003, -0.036212, 0.025597, 0.006483, -0.264075, -0.010938, 0.272026, -0.034011, -0.327782, -0.366599, 0.151572, -0.026481, 0.217456, 0.420801, 0.157486, -0.051276, 0.201653, 0.043417, 0.236828, 0.063351, -0.394972, -0.161937, 0.074459, -0.384132, -0.196323, 0.228678, 0.256281, 0.149144, 0.028174, -0.564073, -0.490536, -0.273665, 0.226894, -0.237498, -0.201434, -0.059034, -0.144291, -0.226922, -0.113504, 0.187923, -0.126127, 0.170721, -0.305139, 0.130241, -0.320357, -0.123641, 0.504058, -0.025078, -0.214406, -0.034885, 0.201571, 0.047220, 0.216735, 0.166288, -0.084541, 0.129933, 0.126290, -0.135664, 0.072587, -0.063163, -0.917007, -0.123037, 1.112607, 1.007323, 0.648319, 0.143033, -0.172136, -0.523753, -0.680033, -0.595677, -0.536835, -1.870484, 0.569594, -0.185325, -1.215953, 0.015062, -0.686833, -0.633921, -0.616813, 0.627566, 1.319168, 0.756457, 1.332022, 1.409211, 0.856319, 0.859831, 0.427976, 1.436548, 0.988804, -0.136846, -0.351068, -0.315812, -0.145150, -0.269884, 0.028618, 0.056951, 0.487964, 0.313309, -0.120555, -0.371364, 0.366072, 0.587073, 0.007849, 0.037309, -0.061319, -0.486943, 0.308115, -0.731086, -0.335626, -0.296910, -0.159638, -0.204520, -0.070050, -0.348803, -0.150172, 0.192647, -0.060886, 0.187474, 0.415381, -0.060964, 0.139641, 0.151623, -0.145305, 0.115914, -0.039634, -0.164389, -0.215551, -0.309289, -0.039993, 0.161306, 0.163739, -0.207013, -0.009089, 0.182322, 0.258475, -0.083236, 0.070787, 0.225658, -0.183164, -0.320727, -0.003231, 0.359509, 0.207776, -0.261569, 0.105051, -0.060210, 0.127145, 0.179637, 0.174765, -0.432689, -0.390510, -0.199319, 0.133821, -0.255411, 0.151381, 0.176214, 0.122510, -0.042460, -0.326110, -0.367153, 0.170335, 0.278456, -0.060493, 0.217080, -0.108252, -0.479722, 0.517953, -0.265758, -0.154759, -0.188560, -0.156202, -0.244557, -0.112614, -0.271295, -0.164158, 0.058633, 0.021374, -0.012909, 0.307192, 2.681103, -0.280816, -1.523841, -1.234785, -1.162527, -0.242083, -0.713808, -0.832373, -1.270693, -0.323593, -0.225471, -0.897421, 0.105623, 0.104761, 0.219195, 0.005910, 0.359501, 0.003880, 0.492079, 0.420770, 0.360735, 0.349250, 0.254116, 0.549479, 0.481278, 0.734675, -0.036402, 0.231640, 0.170314, -0.472910, 5.470434, 3.121870, 2.161238, 2.477572, 0.667634, 0.068971, 1.474037, -0.012808, 1.492179, 0.034869, 0.154683, 0.674763, -0.451766, 0.299928, 0.537846, 0.335394, -0.795361, 0.110722, 0.278780, -0.719843, -0.877873, 0.217658, -0.299113, -0.176790, -0.932693, -1.185364, -0.288846, -0.052220, -0.509367, -0.673407, 2.191883, -0.824059, -0.033620, 0.185867, -0.277873, -0.232845, -0.098264, -0.207126, -0.459107, -0.554082, -0.344157, -0.238470, 0.214195, -0.060822, -0.025096, 0.082622, -0.084433, -0.074005, -0.252585, -0.443295, -0.345593, 0.472367, -0.688824, -0.200779, -0.125366, 0.109010, 0.200818, 0.134251, 0.249402, 0.108416, 4.762414, 2.029104, 1.457330, 2.107607, 0.593225, 0.002539, 0.975363, -0.332825, 1.367885, 0.625741, -0.030528, 0.440442, -0.180490, 0.090845, 0.483244, 0.599975, -0.337049, 0.346676, 0.144213, -0.584683, -0.298321, 0.090247, -0.161208, -0.229282, -0.389242, -0.715697, 0.029150, -0.197955, -0.432761, -0.015752, 0.391555, 0.640754, 1.181299, 0.663516, 0.133077, -0.216966, -0.098082, 0.546866, 0.307631, 0.094355, -0.390698, 1.525750, -0.186048, 0.014779, -1.326777, -0.792233, -0.667779, -0.189302, 0.225944, 0.019362, -0.600187, -0.594068, -0.584981, -0.852206, 0.324590, 0.484815, -0.687047, -0.134059, -0.509529, -0.409771, -0.118502, 0.400718, 0.417366, 0.369987, 0.223399, 0.772997, 0.148206, -0.166390, 0.175201, -0.184286, 0.622494, -0.235026, -0.326132, -0.265504, 0.497483, -0.329512, 1.021208, 0.814415, 0.486056, 1.061101, 1.347443, 1.371383, 0.322405, 0.224719, -0.096304, 0.090907, -0.242266, -0.547711, -0.290209, -0.614298, 0.085408, 0.187480, 0.416071, 0.150309, -0.419514, -0.377052, -0.104731, -0.263875, -0.373937, 0.013196, 0.290567, -0.100263, 0.441759, -0.197970, -0.406396, -0.437691, -0.277357, 0.267724, 0.367113, 0.359921, -0.485698, -0.039003, -0.405759, 0.216892, 0.122638, 0.524037, -0.156831, -0.201254, 0.225781, 0.185426, -0.331748, -0.214120, 0.019689, -0.075074, 0.198668, 0.078581, -0.162144, 0.053538, 0.028174, -0.168468, -0.116972, -0.224325, -0.190755, 0.124910, -0.219125, -0.425989, 0.501078, 0.333231, -0.038786, 0.706612, 0.852937, 0.860779, 0.002000, 0.592555, 0.027975, 0.153259, -0.203193, -0.358824, -0.266143, -0.597996, -0.250557, -0.206471, -0.544481, -0.379770, 0.136401, 0.097615, -0.043596, -0.150259, -0.403255, 0.793190, 0.560178, -0.279934, -0.205996, -0.942016, -1.291016, -0.913804, -0.401973, -0.609206, -0.689335, 0.541986, -0.611185, -0.099250, -0.233587, 0.459949, 0.119713, 0.900193, 0.505740, 0.168881, 0.636244, -0.164222, 0.172722, 0.252727, 0.467438, 0.267666, -0.350513, -0.267396, 0.681285, 0.433043, 0.735512, 0.526958, 1.123771, 1.282694, -0.171477, 0.679038, 0.745561, 0.571019, -0.091666, -0.211990, 0.719833, 0.390782, -0.441090, 0.150592, 0.386971, -0.168751, -0.379202, -0.154467, 0.470806, 0.206865, -0.382131, 0.447490, -0.856853, 0.987806, 0.168326, -0.020635, -0.462552, -0.359787, -0.348772, -0.022621, 0.664660, 0.440115, -0.116002, -0.350343, -0.146321, -0.811025, -0.038563, 0.713754, 0.156712, -0.015669, -0.052180, -0.694166, 0.031817, -0.330636, 0.010514, -0.372674, -0.349908, 0.224883, 0.936533, 0.077934, -0.413357, 0.476428, 0.596477, 0.573462, 0.069619, 0.669097, -0.152052, -0.035659, 0.700725, 0.468526, 0.786087, 0.473808, 1.632617, 1.401994, -0.015553, 0.238276, 0.667083, 1.023256, 0.836365, -0.182775, 1.155635, 0.672713, -0.217369, 0.640331, 0.672780, 0.200053, -0.341751, 0.086567, 0.794289, 0.494813, -0.486568, 0.339004, 7.573179, -3.520919, -2.998120, -2.738148, -3.311286, -1.364107, -1.344757, -2.265100, -2.584293, -1.111523, -1.367061, -1.689917, -0.108861, -0.649743, 0.134367, 0.093143, -0.036086, -0.742622, -0.676015, 0.476501, 0.198162, 0.067910, -0.269469, 0.266284, 0.314383, 0.572789, -0.629337, -0.366717, -1.043046, -1.043736, 3.007034, 2.509247, 2.001375, 1.901606, 0.242871, 2.169059, 2.157239, -0.425258, -0.186157, 0.565076, 1.521837, -0.670157, 1.150134, -0.285465, -0.018723, 0.261276, -1.049627, -0.664831, -0.782834, -0.480541, -0.652821, -0.672198, -1.336451, -1.449535, -1.764426, -0.843486, -1.336008, -0.124394, -1.058074, -0.592098, 0.237777, -0.096236, -2.153625, -0.702462, 0.456245, 0.095788, 0.281038, -0.159122, -0.122468, -0.170517, 1.553320, -1.045945, -2.227368, 0.017817, 0.650745, 0.586698, 0.361893, 1.259755, 1.150926, 0.168069, -0.420825, 0.390331, -0.398784, -0.200626, -0.223852, 0.543885, 0.821184, 1.132843, 0.375166, -0.051118, 1.691601, 0.934416, 1.429215, 0.845207, 0.139896, 0.629952, 1.988479, -0.407422, -0.585243, 0.978749, 1.765663, -0.624723, 1.934043, 0.660084, -0.032678, 0.222998, -0.275805, 0.080674, -0.165842, 0.365868, -0.753939, -0.132641, -0.843738, -0.587197, -1.037485, 0.389569, -0.281227, -0.659999, -0.934962, -0.428082, -0.751683, 1.092392, -0.355144, -1.245245, 0.117107, -0.281237, 0.121715, 0.668866, 0.637501, 0.947848, 0.238853, 0.489482, 0.957656, -0.634837, -1.802938, -0.774308, -1.056543, -0.636384, 0.331855, -0.134059, -1.432061, -0.475738, -0.758867, 0.607783, -0.181059, 0.216906, -0.112857, 0.992814, -0.218956, 0.193067, -0.417143, -0.672667, -0.308741, -0.280541, -0.359866, -0.575265, -0.353988, -0.326797, -0.383331, -0.090873, -0.201541, 0.016265, 0.028984, 0.034543, 0.085051, 0.054153, -0.182051, -0.004535, -0.126523, -0.048093, -0.170686, -0.174636, -0.368738, -0.173944, -0.491406, 0.024143, -0.184295, -0.193590, -0.344006, -0.180902, 0.036719, 0.050118, 0.087230, 0.184540, -0.004628, -0.172716, -0.082840, 0.073744, -0.046534, -0.036808, 0.043095, 0.067690, -0.092221, -0.191048, -0.123143, 0.090196, 0.066529, -0.044190, 0.009929, -0.046576, 0.123209, 0.034321, 0.129261, -0.047112, -0.108792, -0.021167, -0.040204, -0.033359, 0.029493, -0.092007, -0.515390, -0.587230, -0.162312, -0.141606, 0.023105, -0.425911, -0.155385, -0.224021, -0.396900, -0.172086, -0.389025, -0.079534, -0.063575, -0.117116, -0.007340, -0.014037, -0.046733, -0.099897, -0.271704, 0.204760, 0.051134, -0.017759, -0.195960, -0.034931, -0.255061, 0.043570, -0.147654, -0.056919, -0.290320, -0.022600, -0.554667, -0.071025, -0.529679, 0.244813, 0.913583, 0.913368, 0.640419, 0.390576, 0.599456, 0.562230, 1.049561, 0.334432, -0.334302, 0.987615, 0.699341, 0.132875, 1.239833, 0.865225, 0.083099, 0.076162, 0.012723, 0.973312, -0.721528, -0.273615, 0.311290, -0.786114, 0.024769, -0.777298, 0.729380, 0.501002, 0.054775, 0.087698, -0.008821, -0.387902, 0.147168, -0.165453, -0.442161, 0.058355, 0.554240, 0.099814, 0.162263, 0.013626, 0.177322, -0.271876, -0.368541, -0.593517, 0.145202, -0.606400, -0.458991, -0.189714, -0.335714, 0.202926, -0.307750, 0.565052, 0.231308, 0.130944, -0.432433, 0.097770, 0.552628, 0.234913, 0.109300, -0.246976, 0.392959, 0.260965, 0.112815, 0.445301, -0.024798, 0.266597, 0.037891, -0.162636, -0.150869, -0.295314, -0.222379, 0.387942, 0.082591, -0.293054, -0.075568, -0.448962, -0.201468, -0.215783, -0.365568, 0.098913, 0.219658, 0.114812, -0.178991, -0.074956, 0.129796, -0.167727, -0.164816, 0.366886, 0.450115, 0.462974, 0.176347, -0.165067, 0.159851, 0.107729, -0.097508, 0.659540, 0.877228, 0.221577, 0.204207, 0.188509, 0.374324, -0.037076, -0.408120, 0.194785, 0.424918, -0.514911, 0.066958, -0.014487, -0.229066, -0.081328, -0.322095, 0.332111, 0.096655, 0.004902, -0.289833, -0.000875, 0.521261, 0.036842, 0.057960, 0.392643, 0.587923, 1.021375, -0.983627, -1.321272, -0.656668, 0.081568, -0.448751, 0.187885, -0.089739, 0.449777, -0.370168, 1.109506, 1.150482, -0.417056, 0.739705, -0.535327, -0.106062, 1.445231, 0.723441, 1.254623, 1.518200, 0.890224, 0.631323, 0.989315, 1.666493, 0.486668, 0.982604, 0.413938, 0.211890, 1.553712, -0.513887, 0.002773, -0.332585, -0.028694, 0.191713, -0.387796, -0.298206, -0.298445, -0.099796, -0.270858, -0.317025, -0.322953, 0.592985, 0.624788, 0.810807, 0.063921, -0.247058, 0.101618, -0.376487, 0.006422, 0.039953, 0.258614, 0.186849, -0.227732, 0.905341, 0.701453, -0.014015, -0.343718, -0.107251, 0.416593, 0.097949, 0.001297, 0.120949, -0.133560, 0.027143, -0.348503, -0.315955, -0.125393, 0.251832, 0.018478, 0.166162, 0.314039, -0.187697, -0.128482, -0.487102, 0.013639, 0.166357, 0.076860, -0.275028, 0.137096, -0.214078, -0.038540, -0.055701, 0.013506, 0.105190, 0.067417, 0.248448, -0.042281, 0.592285, 2.276220, -0.373365, 0.029713, -0.318177, 0.110889, 0.158222, -0.010494, -0.059880, -0.114402, 0.206056, -0.259055, -0.335105, -0.127032, 0.887353, 0.684198, 1.123469, 0.102100, -0.106110, 0.195751, -0.377719, -0.191691, 0.354247, -0.134102, 0.044280, 0.073600, 0.658573, 0.738342, 0.343991, -0.322132, 0.264617, -0.877076, 0.699837, 0.555692, 0.397405, 0.595778, 0.909834, -0.306568, -0.067699, -0.957995, 0.018996, -0.126143, -0.112520, -0.009595, 0.631597, 0.012952, 0.067817, 0.352507, 0.201484, 0.087336, 0.225980, -0.103392, -0.056466, -0.711798, -0.005871, -0.441981, -0.663655, -0.240601, -0.441928, -0.129096, -0.073644, -0.030100, -0.063610, -0.100118, -0.047398, 0.210648, 0.160790, 0.405074, 0.318146, 0.768781, 0.137836, -0.566935, -0.708798, 0.205771, 0.657939, 0.050276, -0.039237, -0.134957, -0.192970, 0.265719, 0.243132, -0.341983, -0.212046, 0.579624, 0.306762, -0.170505, -0.260284, 0.423240, -0.124403, 0.023989, -0.006905, 0.189009, -0.045694, 0.271505, 0.513493, -0.115007, -0.184741, -0.591069, -0.585628, -0.198202, 0.264184, -0.085733, -0.331770, -0.716235, -0.758406, 0.398271, 0.443084, -0.004975, -0.009376, 0.104977, 0.275905, 0.105707, -0.012213, 0.134500, 0.133351, -0.325691, -0.026761, 0.185145, 0.094823, 0.126612, -0.281296, -0.429873, -0.425590, -0.331520, -0.121037, -0.242337, 0.065103, 0.538033, 0.292052, 0.585264, -0.189791, -0.389798, -0.538388, -0.164957, 0.646327, -0.082398, 0.107597, -0.134954, -0.385271, 0.228295, -0.038683, -0.480835, -0.444229, 0.397446, 0.043745, -0.268568, -0.516865, 0.566229, -0.112503, -0.058750, -0.963203, 0.626923, -0.560909, -0.216576, -0.680919, 0.559421, 0.664356, -0.154470, -0.131050, 1.141921, 0.674060, -0.462749, 0.777038, 0.825286, -0.022570, 0.869498, 1.214171, 1.103557, -0.227557, 0.124839, -0.259121, 0.183916, 0.362902, -0.146459, -0.434222, -0.536813, -0.256995, -0.637367, -0.046624, -0.434332, -0.393917, -0.620203, -0.070397, -0.466556, -0.508952, -0.204078, -0.255717, -0.364718, -0.464126, -0.105617, -0.083519, -0.041170, -0.257389, -0.449093, -0.281082, -0.016815, 0.393348, 0.009109, 0.412486, -0.454399, -0.282002, 0.371474, 0.212327, 0.146930, -0.328872, 0.415861, 0.356517, -0.215580, -0.425826, -0.220957, -0.026425, -0.381942, 0.017856, 0.032632, 0.175931, -0.065762, -0.017049, 0.058620, 0.396233, 0.789259, 0.288245, 0.123399, -0.177837, 0.079673, -0.110628, -0.384343, -0.505459, -0.575520, -0.070982, -0.043114, 0.140478, 0.827610, 0.575795, -0.078871, 0.143497, 0.153105, -0.361324, 0.166098, 0.410365, 0.003377, -0.469696, -0.568516, 0.028822, -0.459536, -0.427466, 0.065776, -0.038174, -0.301555, -0.361921, 0.016825, 0.118514, 0.109523, -0.200286, -0.396481, -0.355133, 0.198821, 0.654751, -0.070882, 0.374204, -0.259522, -0.232144, 0.404157, 0.227866, -0.405821, -0.066757, 0.386669, 0.022661, -0.236282, -0.488342, -0.281292, 0.006660, -0.940710, 0.136236, 0.207289, 0.627927, 0.614397, 0.603173, -0.579333, -0.414727, -0.702351, 0.277865, 0.477035, 0.443494, 0.537688, 1.195761, 0.634183, 0.661386, 0.604642, 0.309526, -0.453083, -0.242194, -0.017938, 0.437320, -0.236725, 0.247095, -0.167110, 0.235202, 1.119230, 0.100128, 0.983208, -0.136460, 0.211950, 1.466717, -0.007337, 0.557549, 0.948735, 0.577251, 0.106635, 0.381770, 0.508566, -0.871696, 0.055389, -1.080118, -0.417108, -0.048611, 1.676415, 0.746006, -0.339417, -1.192558, -0.556957, -0.707802, 1.067903, -0.220753, 0.612659, 0.418343, -0.294337, 1.578629, -0.736830, -1.040651, -0.578126, -0.300116, 0.542125, -0.330635, -0.333907, -0.601471, -0.642259, 0.307618, -0.597339, -0.402638, 0.537832, 0.301342, 0.444299, 0.036485, 0.620995, 0.671191, 0.401213, 0.114562, 0.214302, -0.158832, -0.059969, 0.182453, 0.450380, -0.817849, -1.351292, 0.126719, -0.256882, 1.199835, 0.658854, -0.227588, -0.170503, -0.042084, -0.052223, 1.031465, -0.330243, 0.071769, 0.852661, -0.113130, 0.372676, 0.518262, 0.369671, -0.182692, 0.005344, -0.696459, -0.005276, 0.655975, 1.149496, 0.333290, -0.073281, -1.114583, -0.365150, -0.463158, 0.380497, -0.346897, 0.742732, 0.464103, -0.351980, 1.933615, -0.622825, -0.915603, -1.149925, -0.420188, 0.745630, -0.281346, -0.418687, -0.240512, 0.248148, 0.344279, 0.373541, 0.479833, 0.735547, 0.450531, -0.147859, 0.200132, 0.759589, 0.330154, 0.454000, 0.615760, 0.405387, -0.134013, 0.325486, 0.541953, 0.204782, -0.048867, -0.112341, -0.162249, -0.301264, -0.551849, -0.603200, -0.033400, -0.116748, -0.221748, -0.404581, -0.215392, -0.172526, -0.321064, -0.444973, 0.044239, 0.359771, -0.102487, -0.068182, -0.174322, 0.285019, -0.272132, 0.484182, 0.430039, 0.154098, 0.500628, 0.772425, 0.629601, -0.350229, 0.131733, -0.059194, -0.611977, -0.187281, 0.418892, 0.151694, -0.344332, 0.078697, 0.182965, -0.195472, 0.101323, -0.183361, 0.320226, 0.076520, 0.093549, -0.206135, -0.396106, -0.279584, -0.172909, -0.297761, -0.133617, 0.123886, 0.310202, -0.146880, -0.225317, 0.522327, 0.804304, 0.863446, 1.076480, -0.398746, -0.727222, -0.060013, -0.404354, -0.132281, 0.573444, -0.207859, 0.040273, 0.056153, -0.008359, -0.228101, -0.182455, -0.378809, -0.352337, -0.400175, -0.189551, -0.317184, 0.147339, 0.318423, 0.005790, 0.043300, -0.142588, 0.084838, -0.421311, 0.585551, 0.446201, 0.158940, 0.201868, 0.858327, 0.528892, -0.485746, 0.141318, 0.133747, -0.445683, -0.434142, 0.537696, -0.111491, -0.354463, 0.010118, -0.083446, -0.380932, -0.246655, 0.085782, 0.345778, 0.222986, 0.128555, 0.721839, 0.312603, 0.610379, 0.411565, 0.164444, 0.171141, 0.318260, 0.380046, 0.121197, 0.459531, 0.643449, 0.659892, 0.164606, 0.640159, -0.103897, -0.301726, -0.456911, -0.623974, -0.560312, -0.656601, -0.697317, -0.732478, -1.052549, -0.708151, -0.290533, -0.047167, 0.446500, -0.120897, 0.242421, 0.289161, 0.198457, 0.507577, -0.485724, 0.214107, 0.263153, -0.176670, -0.372798, -0.297126, -0.100590, 0.118957, -0.919061, -0.375048, 0.542415, 0.215617, -0.003121, 0.261000, 0.367806, 0.051951, -0.006613, 0.317798, 0.512210, 1.547958, 0.139306, -0.521212, 1.008454, 0.337421, -0.622920, 0.440784, 0.297210, 0.327395, -0.322719, -1.142076, -0.379339, -0.172396, -0.344942, -0.513999, -0.788806, -0.333504, 0.482493, 0.495458, -0.091551, 0.172569, -0.162827, 0.547484, 0.296864, 0.175989, 0.875601, -0.616662, -0.887107, 0.233208, -0.213391, 0.187002, 0.097222, -0.067435, 0.476060, 0.247144, 0.353865, -0.020537, -0.220614, 0.307869, 0.512776, 1.132209, -0.355280, 0.037254, 0.242286, -0.436288, -0.212232, -0.270124, -0.097237, 0.147163, -0.646900, -0.511121, 0.592591, 0.058155, 0.244642, 0.229638, 0.759369, 0.215932, -0.376157, 0.198382, -0.262817, 1.306390, 0.645827, -0.240670, 1.259805, -0.406110, -0.208898, -0.568023, -0.341257, 0.067577, -0.009520, -0.008798, -0.047735, -0.461520, 0.766820, 0.343178, -0.388890, -0.052806, -0.920808, -1.296087, -0.864751, -0.278248, -0.199337, -0.302753, 0.134130, -0.276872, -0.510697, -0.433425, 0.678958, 0.216263, 0.900365, 0.858882, 0.800308, 0.438601, -0.126905, 0.061250, -0.246564, 0.123351, -0.064440, 0.654775, 0.846536, 0.780513, 0.072635, -0.350613, -0.063339, -0.191997, -0.248872, -0.004784, -0.173373, 0.047767, -0.697817, -0.193311, -0.045634, 0.201938, -0.305848, -0.482592, -0.088866, 0.249532, -0.249117, 0.012326, 0.236499, -0.498003, -0.629462, 0.138901, -0.578646, 0.267448, 0.122324, -0.312467, -0.088320, -0.204518, -0.185233, -0.089822, 0.073888, -0.211165, -0.078300, 0.186769, -0.022994, 0.071688, -0.002188, -0.093255, 0.158464, -0.281802, 0.135381, 0.187454, -0.304444, 0.007825, -0.034210, -0.244396, -0.096630, -0.355511, -0.449823, 0.018344, -0.291824, -0.080385, 0.084072, 0.452055, 0.206725, 0.432918, 0.005106, 0.336043, 0.606595, 0.590176, 0.066100, -0.429250, 0.059437, 0.146684, -0.078043, 0.074095, -0.335466, -0.192624, -0.463905, 0.127430, -0.177695, 0.426747, -0.185840, -0.162554, -0.283058, 0.339668, -0.362441, 0.309037, 0.542105, -0.155309, -0.495775, 0.227966, -0.296162, 3.991829, -1.418350, -2.303277, -1.803893, -2.116166, -1.162802, -1.042134, -1.530771, -1.813667, -0.569388, -0.881317, -1.275103, 0.136607, -0.175861, 0.059640, 0.052762, -0.416476, -0.830381, 0.081623, 0.246219, -0.109510, 0.676800, 0.029935, 0.107454, 0.036568, -0.130673, 0.056096, -0.464243, -0.085293, -0.758510, 7.478610, 4.831896, 2.413184, 2.588215, 0.976569, 0.122333, 0.576968, 0.375752, 0.388225, 0.596920, -0.592826, 0.870376, -0.605844, 0.433729, -0.648134, 0.213178, -0.242297, 0.458143, 0.009447, -1.003093, -0.054399, -0.553049, 0.129226, -0.157203, -0.029838, -0.819814, 0.205126, -0.964488, -0.734566, -0.012720, -3.680669, 0.637068, 0.407117, 0.462838, 0.561473, 0.579364, 0.334997, 0.239222, 0.357079, 0.345924, -0.395705, -0.412775, 0.507315, 0.255862, -0.373943, -0.036185, 0.032399, 0.713765, 0.233172, -0.280539, -0.183718, 0.240426, 0.565560, 0.785111, 0.281820, -0.484390, 0.575905, 0.179202, -0.013478, -0.041572, 6.899383, 2.772092, 1.968171, 2.205677, 1.001856, -0.186680, -0.306332, 0.521977, 0.196324, 0.257961, -0.304225, 0.841742, 0.199118, 0.365543, 0.148449, 0.322687, -0.468133, 0.817881, 0.095810, -0.486091, -0.013218, 0.133052, -0.011950, -0.009502, 0.138803, -0.621541, 0.400291, -0.775855, -0.375661, 0.282236, -0.073970, -0.935667, -0.018412, 1.218581, 0.918997, 0.715406, 0.184867, -0.336375, -0.541971, -0.490524, -0.540601, -0.661071, -1.935252, 0.636573, -0.271148, -1.470969, -0.002945, -0.413992, -0.366607, -0.395974, 0.559404, 1.060329, 0.538556, 1.367572, 1.370301, 0.731689, 1.127877, 0.537128, 1.498704, 1.136762, -0.176836, -0.404580, -0.541957, -0.397421, 0.015597, -0.410647, -0.127663, 0.494579, -0.349889, -0.171926, -0.293463, -0.206132, 0.774128, 0.558041, 0.046069, 0.312831, 0.104775, -0.095935, -0.595369, -0.446416, -0.485868, -0.513270, -0.121186, 0.054079, -0.032591, -0.306777, -0.094350, 0.067392, 0.157462, -0.153967, 0.095981, -0.021317, -0.215401, -0.317845, -0.218353, 0.115596, 0.134714, 0.500549, 0.270730, -0.408855, -0.077123, -0.022413, -0.136896, 0.019849, -0.058103, -0.280174, 0.240682, 0.037934, -0.123857, 0.274158, 0.302127, -0.207773, -0.026944, 0.012577, -0.044322, -0.276950, 0.404747, 0.011446, -0.192511, 0.001948, -0.426726, -0.435015, -0.438596, -0.159111, 0.424335, -0.168711, -0.088204, 0.294651, -0.411672, -0.023694, -0.086393, -0.232812, 0.138300, 0.585410, 0.335079, 0.283288, 0.159788, -0.269858, -0.123450, -0.148054, -0.242450, -0.413177, 0.141291, 0.163200, 0.021440, -0.244065, -0.274624, 0.131377, 0.042213, -0.549268, -0.065173, -0.883210, -0.055357, 1.056413, 0.995150, 0.520718, 0.231907, 0.082368, -0.339948, -0.584318, -0.481246, -0.502358, -1.402787, 0.050392, -0.468227, -1.399938, -0.089000, -0.196276, -0.324925, -0.565281, 0.313253, 1.212287, 0.602850, 1.122976, 1.333759, 1.023284, 0.954795, 0.339258, 1.227631, 0.768208, -0.099916, -0.207155, 0.010306, 0.024120, 0.106037, -0.366690, -0.068807, -0.104486, 0.436234, -0.167249, 0.801652, -0.017484, 0.500102, -0.037019, -0.089701, -0.050191, -0.291045, -0.763565, -0.078412, -0.262793, -0.002037, 1.125548, -0.422672, -0.055007, -0.065496, -0.042087, 0.555654, 0.123183, -0.060217, 0.366878, 0.165625, -0.063628, -0.746073, -0.562458, 0.135111, 0.993264, -0.259738, -0.745153, 0.176233, 0.065840, 0.427086, 0.342314, 0.310108, 0.044125, -0.352297, -0.110802, 0.364165, 0.077585, -0.465080, 0.405026, 0.248308, -0.958020, 0.006060, 0.217412, 0.294160, -0.180798, -0.840876, 1.244074, -0.487316, -0.014036, -0.196962, -0.327878, 0.775441, 0.182406, 0.625409, -0.532653, -0.100178, -0.189627, 0.408346, -0.305994, 0.717376, 0.149810, 0.411021, -0.106894, 0.057519, -0.246910, -0.108994, -0.462145, -0.061153, -0.469726, -0.213513, 1.481205, -0.649511, -0.380049, 0.167427, 0.040225, 0.646351, 0.276681, 0.250567, 0.554720, 0.888396, 0.131737, -0.012136, -0.702085, -0.484990, 0.075508, -0.720980, 0.173198, 0.703438, -0.252800, 0.276351, -1.574411, 1.612131, -2.345326, 0.918332, 0.833654, -1.998252, -1.371423, -1.980267, -1.077353, -0.891176, -2.325816, -2.204886, -1.549717, -2.496017, -1.669971, -1.411179, -1.135886, -1.280147, -1.658212, -0.540749, -0.847801, -0.413138, -0.483719, -0.358034, 0.239033, 0.549957, 0.062814, 0.938990, -0.247559, 0.021992, -0.040762, -0.137928, -0.587147, -0.656382, 0.219315, -1.089844, -0.004365, -1.107665, -0.588840, 0.385396, 0.375668, -1.033096, -0.412092, 0.206211, -0.228110, -0.333558, -0.113328, -0.207385, -0.328453, 0.307734, 0.220098, -0.349482, -0.362139, 0.474366, 0.258306, -0.650409, -0.882435, -0.209214, 0.666509, 0.431886, 1.107860, -0.020466, 0.108497, -0.177030, 0.064632, -0.103868, -0.159890, -0.000042, 0.025930, -0.445278, -0.435542, 0.144167, -0.596893, 0.127495, 0.313150, -0.704743, -0.793661, 0.591303, 0.192617, -0.563894, -0.955096, -0.256978, -0.303543, -0.210243, -0.300219, 0.644342, 0.567265, 0.489514, -0.761166, -0.175262, 0.065478, 0.151141, -0.122699, -0.526610, -0.113493, -0.823922, -0.163259, -1.057666, -0.358641, -0.311962, 0.214692, -0.139865, -0.056654, 0.260435, -0.156945, -0.085080, -0.519888, 0.629278, -0.749339, -0.950075, 0.865266, -0.753614, -0.939741, -0.981161, 0.008275, 0.318045, -0.555042, -0.008923, 1.612892, 0.985509, -0.002385, 0.951841, 1.316002, 0.058153, 1.021476, 1.110871, 1.337198, -0.117288, 0.009578, -0.074529, 0.630969, 0.376494, 0.190897, 0.179554, -0.469161, -0.081715, -0.472303, -0.288386, 0.177265, -0.285714, -0.669545, -0.358433, -0.182147, -0.601203, -0.625019, 0.066962, 0.033263, -0.404912, 0.537671, -0.550763, -0.264186, -0.434215, -0.245225, -0.142523, -0.268922, -0.756773, -0.018575, 0.005511, -0.274615, -0.199936, -0.329334, -0.201996, 0.318461, 0.454566, 0.144740, -0.035602, -0.159784, -0.336668, 0.625459, 0.169504, -0.291624, 0.005693, 0.110063, 0.169500, 0.233304, 0.328860, -0.095496, 0.082950, -0.297804, -0.387131, -0.263721, 0.037762, 0.073703, -0.522767, -0.626264, -0.188910, 0.354192, -0.322367, -0.106881, -0.131318, -0.283946, 0.196801, 0.350038, 0.156395, 0.165157, -0.054326, -0.036585, 0.029095, 0.321708, -0.403081, -0.681874, -0.362006, -0.261852, -0.559027, -0.720384, 0.267344, 0.050381, -0.005805, 0.854102, -0.538056, -0.097972, -0.405038, -0.098516, -0.196722, -0.083437, -0.550235, 0.141234, 0.009298, -0.210632, -0.248798, -0.045509, -0.081376, 0.439195, -0.186236, -0.044440, -0.023577, -0.225061, -0.142798, 0.329083, 0.074032, -0.203794, 0.893375, 0.769807, 0.969268, 0.557281, 0.715276, 0.657333, 0.002904, -0.779702, -0.033899, -0.701157, -0.366140, 0.075330, -0.252417, -0.280410, -0.362366, -0.331015, -0.520933, -0.242065, -0.146114, -0.597951, 0.060685, -0.671237, 0.315205, -0.069738, -0.792737, -0.552076, -0.537047, -0.342920, -0.114070, 0.010327, -0.002373, -0.579599, -0.605377, 0.037117, -1.042849, -0.220436, -0.079844, -0.240810, -0.288903, -0.576076, -0.209177, -0.287250, 0.075747, 0.229098, -0.095178, -0.108002, 0.589683, 0.091144, -0.034496, 0.436520, 0.751052, 0.723569, -0.247799, -0.077673, -0.271277, -0.673416, 0.044960, 0.502025, -0.239330, -0.224471, 0.028964, -0.064770, -0.153932, 0.249580, 0.193456, -0.022912, 0.298416, 0.713834, 0.188320, -0.425682, -0.079106, 0.168768, -0.223256, 0.019215, 0.106698, -0.115503, -0.367540, -0.504073, -0.401189, -0.584038, -0.131950, 0.316672, -0.229584, 0.150449, 0.107458, -0.345587, -0.110848, 0.032546, -0.343162, -0.494157, -0.359819, -0.681393, -0.524671, 0.263824, -0.943461, -0.320154, -0.252920, -0.326675, -0.468094, -0.375163, -0.278408, -0.464302, -0.239011, 0.125984, -0.274105, -0.779283, 0.375563, 0.006986, -0.237524, -0.029649, 0.312291, 0.723385, -0.412673, -0.244142, -0.153584, -0.780357, -0.370202, 0.299218, 0.003991, -0.761657, 0.252797, 0.666153, 0.622211, 0.041083, -0.013281, -0.085336, -0.821668, -0.258139, -0.312545, 0.287958, -1.031794, 0.345066, 0.836663, -0.010929, 0.439757, 0.446584, 0.310127, 0.252090, 0.129689, 0.527589, 0.240260, 0.087869, 0.257158, -0.208466, -0.519516, -0.200240, 0.382419, 1.242073, -0.106691, 0.277721, -0.309717, 0.495356, 0.343253, 0.429473, 0.116571, 1.119716, 0.626668, -0.512503, -0.219543, -0.046873, -0.485924, 0.230400, 0.029908, 0.238506, 0.054116, -0.681263, 0.652942, -0.107633, 0.150032, -0.159225, 0.830284, -0.042266, -0.020405, -0.079940, -0.147856, 0.101022, 0.172967, 0.047037, -0.022796, 0.235199, -0.279518, 0.153685, -0.115554, -0.642614, -0.051283, 0.000027, 0.530049, 0.608678, -0.387800, -0.269667, -0.087364, 0.913104, 0.425114, -1.219855, -0.741706, -0.284954, -0.086304, 0.533173, 0.589910, -0.390890, 0.259531, 0.429964, -0.543897, -0.319997, 0.414957, 0.160188, 0.669025, 0.635346, -0.211706, 0.097074, -0.234060, 0.343397, -0.156167, 0.038539, 0.092384, 1.188263, 0.295479, -0.556795, -0.036297, -0.523677, -0.702988, -0.093868, -0.241769, 0.594863, -0.057233, -0.645853, 0.374402, -0.408333, 0.438892, 0.022187, 1.226777, -0.359352, 0.128868, 0.005799, -0.261718, -0.214012, 0.224234, 0.149407, 0.171025, 0.515372, 0.526843, 0.652168, -1.079479, -1.563684, -0.862826, 0.312747, 0.001252, -0.256738, 0.170665, 0.584459, 0.048596, 0.229532, 0.498238, 0.543145, 0.020709, -0.546383, 0.074062, 0.700798, 1.214761, 0.822697, 1.973635, 1.235830, 1.100596, 1.023769, 1.368434, 0.547702, 0.490528, 0.364685, 0.062088, 0.765432, -0.338094, -0.196241, 0.245695, -0.616205, 0.336859, -0.408605, 0.811812, 0.452943, -0.672494, 0.875867, 0.202279, 0.530376, 0.014122, -0.342661, 0.333480, 0.310549, -0.239002, 0.794337, 0.576923, -0.451810, 0.083218, 0.284734, -0.458851, -0.086256, 0.185582, 0.217025, 0.889397, 0.034044, -0.091016, -0.064887, -0.260599, 0.188329, -0.178611, -0.232871, 0.074778, 0.156740, 0.076436, 0.552873, 0.104166, -0.027948, 0.102019, -0.428416, -0.199178, 0.082981, -0.722066, -0.093176, 0.185926, -0.380256, -0.043038, 0.007201, 0.251195, 0.031649, -0.007145, 0.185001, -0.278462, -0.079822, -0.050269, -0.590516, 0.330863, 1.330246, 0.077615, -0.085471, -0.020410, -0.455967, 0.746488, -0.064152, 1.285363, 0.648174, -0.450924, 0.749738, 0.272685, 0.374049, 0.265039, -0.363074, 0.868928, 0.586694, -0.430271, 1.011798, 0.667104, -0.286759, -0.203807, 0.093658, -0.569250, -0.708596, 0.078392, 0.357854, 0.758586, 0.335584, -0.881082, 0.438421, -0.667117, -0.888028, -0.879794, 0.114948, 0.166876, -0.463665, -0.027324, 1.661694, 0.973778, 0.161623, 0.765951, 1.320890, 0.205289, 1.268258, 0.960993, 1.328653, -0.186675, -0.052316, -0.023045, 0.928952, 0.382251, 0.399439, 0.165738, -0.243593, 0.074488, -0.320308, 0.096500, -0.266514, -0.306686, -0.598825, -0.508330, -0.381066, -0.244612, 0.018386, -0.481294, -0.055503, -0.288007, 0.001092, -0.471415, 0.542560, 0.241557, 0.023205, -0.499296, 0.128688, -0.174383, -0.371319, -0.313934, -0.106653, -0.152745, -0.010221, -0.181874, -0.163872, 0.693711, -0.071027, 0.689184, -0.263934, 0.243750, 0.192490, 0.033832, -0.215913, -0.226380, -0.511428, -0.027051, 0.024551, -0.306567, 0.073915, 0.153636, -0.116867, 0.032846, 0.214728, -0.256756, 0.054973, -0.091608, 0.224641, 0.009969, -0.041259, 0.511656, 0.120496, 0.218670, 0.234505, 0.496292, -0.332637, -0.541783, -0.112562, -0.309934, 0.014493, 0.325776, -0.355418, -0.352134, -0.528338, -0.598280, -0.202876, 0.063161, 0.059926, -0.192959, -0.077833, -0.374274, -0.033307, -0.258078, 0.600146, -0.174108, -0.046857, -0.625869, 0.071279, -0.447985, -0.452788, -0.406444, 0.024757, -0.008341, -0.211253, 0.124745, -0.243270, 0.620921, 0.012360, 0.638841, -0.254366, 0.066084, 0.038343, -0.252919, 0.171638, -0.336852, -0.518955, 0.343095, 0.290187, -0.192391, -0.048651, -0.295740, 0.800272, 0.195038, -0.437395, -0.257464, -0.811355, -0.664805, -0.272987, -0.009104, -0.164399, -0.892509, 0.122705, -0.781587, 0.079098, -0.974283, -0.159978, -0.067692, 0.014563, 0.308678, 0.192357, -0.438258, -0.254849, -0.039227, -0.138464, -0.223540, -0.385051, -0.151179, 0.069499, -0.411067, 0.168155, 0.188176, 0.951455, 0.665071, 0.634566, 0.254903, 0.060840, 0.045206, -0.048804, 0.264614, 0.522812, 0.584120, -0.606054, -0.591595, 0.745018, 0.271397, 0.115881, 0.178820, 1.435305, 0.277332, 0.720717, 0.624221, -0.274926, -0.045878, -0.077771, 0.053355, -0.009010, -0.092487, -0.055457, -0.108336, 0.656584, -0.113177, -0.530295, -0.248251, 0.239152, 0.010968, 0.348773, -0.411924, -0.482369, 0.048123, -0.028568, -0.097067, 0.042824, 0.137044, -0.214829, -1.118590, 0.321832, -0.374369, 0.611814, 0.654107, 0.110689, -0.033649, 0.184712, 0.373456, 0.324019, -0.255365, 0.056341, -0.086151, 0.563565, -0.547439, 0.696982, 0.090877, 0.890101, 1.042197, 0.479040, 0.849225, -0.311752, 0.085092, -0.437073, 0.063807, 0.576433, 0.610541, -0.148362, -0.355164, 1.067815, 0.386549, 0.232388, 0.446676, 1.963068, 0.563710, 1.090103, 0.582226, -0.468880, 0.864547, 0.097777, -0.359063, -0.829916, -0.483066, 0.040852, -0.492157, 0.291812, 0.536014, -0.157713, 0.147076, -1.423532, 1.694917, -2.380637, 0.501210, 0.993002, -1.731158, -1.527025, -1.751289, -1.231209, -0.534030, -2.285644, -2.286114, -1.570974, -2.565217, -1.685979, -0.949060, -0.971890, -1.247716, -1.701072, -0.494596, -0.912232, -0.450643, -0.581716, -0.694162, -0.417165, -0.339987, -0.427147, -0.098159, -0.148346, -0.421796, -0.034686, 0.034768, -0.040815, -0.674635, -0.778417, -0.720336, -0.809417, -0.379082, -0.251505, -0.343097, -0.448660, -0.884353, -0.575752, 0.568609, 0.262322, 0.484930, -0.521952, -0.467161, -0.365488, 0.122551, 0.238888, -0.307522, -0.217594, -0.048941, 0.162115, 0.000860, 0.300391, 0.194925, 0.347416, 0.217304, -0.700532, -0.216712, 0.168858, 0.036572, -0.193656, -0.228739, -0.214687, -0.052165, -0.067027, 0.489884, 0.261372, -0.550649, -0.010289, 0.121445, 0.444255, -0.538323, 0.202973, 0.557845, -0.244997, -0.419881, -0.816733, -0.496643, -0.412193, -0.563904, 0.102800, -0.094948, -0.462809, -0.273247, -0.093926, -0.367826, -0.050358, -0.313306, 0.377461, -0.432674, -0.568909, -0.372576, -0.708513, -0.369195, -0.154595, -0.218084, -0.302489, -0.274396, -0.713570, 0.544551, 0.536814, 0.574139, -0.279225, -0.386983, 0.121718, -0.932152, 1.336705, 0.477751, -0.424164, 0.628553, 0.850170, 0.633892, 0.933011, 0.355139, 0.269660, -0.029472, -0.280180, 0.578025, -0.387270, -0.766592, -0.171003, -0.449077, -0.737740, -0.668110, -0.789466, -0.893386, -1.328328, -0.603798, 0.348064, -0.146212, -0.230026, -0.373000, 0.412545, -0.625182, 0.395566, -0.378970, -0.840692, 0.117562, -0.420121, -0.677877, 0.331264, -0.339323, -0.087524, -0.293816, -0.015840, -0.443016, -0.856409, 0.321407, -1.108839, -0.037420, 0.069586, -0.626341, -0.385466, -0.503079, 0.584594, -0.053731, 0.232960, 0.728757, -0.819186, -0.176181, -0.591704, 0.126844, 0.233089, 0.058593, 1.470823, 0.151159, 0.300095, 0.215211, 0.562475, 0.787650, -0.590975, -0.785683, -0.669703, 0.215008, 0.118464, 0.307241, -0.139232, -0.814518, -0.214841, 0.345839, 0.144142, 0.040093, -0.137578, -0.025509, 1.435553, -0.065932, -1.404516, -0.612556, -0.529096, -0.062706, -0.582830, -0.317646, -0.060192, -0.785961, -0.469379, -0.356021, -0.780678, 0.016686, -0.667488, -0.767840, -0.086970, 0.158877, 0.006163, -0.046682, 0.469466, -0.473114, -0.611556, -0.016113, -1.051258, 0.261385, -0.046176, -0.491829, -0.445196, -0.258454, 0.375529, -0.307620, 0.202060, 1.129564, -0.455690, 0.024511, -0.870240, 0.067523, 0.577661, -0.129962, 1.938859, -0.343062, -0.602892, 0.373564, -0.312143, 0.091024, 0.677349, 0.452098, -1.062761, -0.685407, -1.090202, -1.017734, -1.112445, 0.315904, -0.096363, 0.612699, 0.390438, -0.200879, 0.730647, 1.128605, 0.536538, 0.963867, 0.468915, 0.533890, -0.059938, -0.265235, -0.442976, -0.549823, 0.691518, -0.432538, -0.063492, -0.435267, -0.426805, 0.502464, 0.837892, 0.311255, -0.297948, -0.145260, -0.754411, -0.547746, 0.104693, -0.834189, 0.982679, -0.946763, 0.139622, 0.862227, -0.169462, -0.674819, -0.102237, -0.679465, 0.051130, -0.055089, 0.382542, 1.365235, -0.819530, 0.426600, -0.573692, -1.174297, 0.558108, -0.379708, 0.509975, -0.053983, 0.127387, 0.027862, 0.431755, 0.884189, -0.012113, 0.025608, -0.450129, -0.841191, -0.494695, 0.185566, 0.571971, -0.134251, 0.039229, 1.726980, 0.014898, -0.881656, -0.334151, 0.282802, 0.610244, 0.767186, 0.835876, 0.463708, 0.113180, -0.300569, 0.471742, -0.573270, 1.129808, -0.400211, -1.755677, -0.646066, -0.655880, -0.003067, 0.611819, 0.574416, -0.412510, -0.172238, -1.155047, -0.508873, -0.374880, -0.339069, 0.287578, -0.899357, 0.859238, 0.689114, 0.114028, -0.314764, 0.153566, -0.543889, 0.043182, -0.431398, 0.177680, 1.192928, -0.369825, 0.342948, -0.409272, -1.257909, -0.253724, 0.289491, 1.196306, 2.778610, -0.673834, -1.708982, -0.536839, -1.077400, -0.299316, -0.596846, -0.928638, -1.270992, -0.237978, -0.542313, -1.193656, -0.081999, -0.097580, -0.004231, -0.000048, 0.580332, -0.247707, 0.512744, 0.432942, -0.174828, 0.597717, 0.077625, -0.091211, 0.007045, -0.246663, -0.040531, -0.709068, 0.002310, -0.792777, 8.820232, 3.446084, 3.463341, 4.508594, 3.520218, 1.156335, 1.595627, 1.366071, 1.048299, 0.022487, 0.822591, 1.275753, -0.821331, -0.051709, -0.593227, 0.401392, 0.221886, 0.679726, 0.763691, -0.955103, -0.778018, -0.442950, -0.176914, -0.176656, 0.657189, -0.624175, 0.026100, -1.417335, -0.369674, 0.085274, -9.052057, 1.633055, 2.652329, 2.779061, 0.925160, 1.527730, 1.623554, 1.519822, 1.387162, 1.367037, 1.455986, 1.234245, 0.465870, 1.558859, 1.172872, 0.084999, 0.506120, 1.242108, 0.513020, 0.394043, 0.278489, -0.440882, 0.102106, 0.007141, 0.045473, -0.442487, 0.723216, 0.134693, -0.829682, 0.691306, 8.834722, 2.660075, 3.689147, 3.680537, 2.569820, 0.990720, 1.229798, 1.376773, 1.382430, 0.148016, 1.274229, 1.059942, -0.632440, 0.472093, 0.030105, -0.136171, 0.048859, 1.212946, 0.288378, -0.248232, -0.135126, 0.085139, 0.580925, 0.659128, 1.028341, -0.441402, -0.671138, -0.868347, 0.207261, 0.774669, 4.444351, -2.374429, -1.942360, -1.153457, -2.097318, -0.582402, -0.212097, -1.162337, -2.180782, -0.266214, -0.104654, -1.385928, 0.323543, 0.168861, -0.076874, 0.470457, 0.028535, -0.528715, 0.237385, 0.152471, 0.231160, 0.809691, -0.204845, 0.257929, 0.282727, 0.664393, 0.062664, 0.282434, 0.144054, -0.798791, 7.128196, 5.150461, 4.003639, 3.160051, 3.241152, 1.569313, 0.857015, 1.419504, 1.382563, 0.275767, 0.708700, -0.240085, 0.121512, -0.374219, -0.645893, -0.520263, -0.800399, -0.585521, -0.278178, 0.700896, -0.463001, -1.347152, 0.214864, 0.379216, -0.783740, -0.523308, -0.972967, -0.814571, 0.074232, -1.163052, 2.305929, -1.591002, 0.581266, -1.670223, 0.181852, -0.567109, -0.106330, 0.456102, -0.409337, -0.285074, -0.924118, -0.477188, -0.402311, -0.128255, -0.219669, -0.911993, -0.517463, -0.148285, 0.376001, 0.353491, -0.252895, -0.559032, 0.018570, 0.247874, -0.142993, -0.524545, -0.189075, -0.344354, -0.607764, -0.044975, 5.251785, 2.712080, 2.696989, 2.438016, 2.517262, 0.865628, 1.253469, 1.617713, 0.876672, 0.526301, 0.980458, -0.209999, 0.091268, 0.001357, -0.308401, -0.206671, -0.511812, -1.012781, -0.033800, 0.304401, -0.252810, -0.700739, 0.880108, -0.407913, -0.052648, -0.399810, -0.607041, -0.624771, 0.447080, -0.779199, -0.714957, 0.478356, -0.156463, -0.765573, 0.081875, 0.483671, 0.154172, -0.050903, -1.114586, -1.127216, -0.934260, -0.546919, 0.235678, -0.484835, 0.145689, 0.812171, 0.531187, 0.239061, 0.962074, 0.597048, 0.605672, 0.434637, 1.227222, 1.295229, 0.192194, -0.148726, -0.530476, 1.482402, -0.281365, 0.030291, -0.122232, -0.680977, -0.053502, -0.256136, 0.435735, 0.333628, 0.223310, -0.330908, -0.025901, -0.099508, -0.441208, 0.113679, -0.151665, -0.005531, -0.256506, -0.288232, 0.415478, -0.201374, 0.137798, 0.482688, 0.015115, 0.202457, -0.633749, 0.225040, -0.130848, -0.363683, -0.364751, -0.410180, -0.403885, -0.338466, 0.120628, 0.119586, 0.123989, -0.223205, -0.355832, -0.394562, -0.068135, 0.055528, -0.122169, -0.146172, -0.278233, -0.139196, 0.316793, 0.047945, 0.125850, 0.174248, -0.306970, -0.126815, 0.111550, 0.000133, -0.136017, 0.053033, -0.118474, -0.059619, -0.123733, 0.131993, -0.501510, -0.098312, 0.112154, 0.103040, -0.186481, -0.555775, 0.037511, -0.164757, 0.451835, 0.320276, 0.201420, -0.085207, -0.235776, -0.209956, -0.472457, -0.263021, -0.080196, -0.337958, -0.194284, -0.297525, -0.031135, -0.434150, 0.046556, -0.016340, -0.024168, 0.004175, -0.563092, 0.535189, -0.314527, -0.458483, -0.450891, -0.121858, -0.087791, -0.175323, 0.153894, 0.723536, 0.444090, 0.182922, -0.078559, -0.136848, -0.218778, -0.117876, -0.046863, 0.619669, -0.256174, 0.433277, -0.322999, -0.205907, -0.810387, -1.000138, -0.094698, -0.267073, -0.363515, 0.390395, -0.706205, -0.933285, -0.249253, -0.152666, 0.298593, 0.779816, -0.132563, 0.672434, 0.295311, -0.097610, -0.116233, -0.190669, 0.006723, -0.090163, 0.209826, -0.341633, -0.692094, -0.344776, -0.937535, -0.395489, -0.053083, 0.082435, -0.299947, -1.006166, 0.184817, 0.298549, -0.628312, 0.390034, -0.261693, 0.348748, 0.386745, -0.035132, -0.259960, 0.436130, 0.392163, -0.005827, 1.103931, 0.551735, 0.557466, -0.085483, 0.187283, 0.167297, 0.051572, -0.121691, 0.264306, 0.029016, 0.284328, -0.119084, 0.034970, -0.036597, 0.331190, 0.161448, 0.053255, -0.267596, -0.413682, -0.546086, -0.005038, 0.182584, -0.076851, 0.152712, -0.054215, -0.105091, -0.191094, 0.113115, -0.152424, -0.625951, 0.628746, 0.359098, 0.120930, -0.466754, -0.204507, -0.303979, 0.220836, -0.217986, 0.361779, -0.479610, -0.749152, -0.435291, -0.790976, -0.264046, -0.468358, -0.163098, -0.186252, -0.719794, 0.221110, -0.087281, -0.611377, 0.340329, -0.503007, 0.526046, 0.222601, -0.439147, -0.164615, 0.191140, -0.000806, -0.041421, 1.264748, 0.734665, 0.262704, -0.032441, 0.905150, 0.198188, -0.053042, -0.589719, -0.704750, 0.245070, -0.337824, -0.107759, 0.252639, -0.395856, -0.059684, -1.239678, 1.582092, -2.546197, 0.499524, 1.201764, -2.189552, -1.211207, -1.640774, -1.261682, -1.006018, -2.676235, -1.865091, -1.387689, -2.339596, -1.618352, -1.145530, -0.793278, -0.956814, -2.256992, -0.619117, -0.979027, -0.546601, -0.381109, -0.566601, -0.252665, -0.295538, -0.250426, 0.133227, 0.694895, -0.525383, 0.128597, 0.526499, 1.294786, -0.439866, 0.195922, 0.016633, 0.869810, -0.249208, -0.021391, -0.632943, -0.043222, -0.546699, 0.171363, -0.603159, -0.339767, -0.761838, -0.424415, -0.135133, -0.578899, 0.017830, 0.415506, -0.219976, -0.934736, 0.600883, 0.289385, 0.565198, 0.624805, -0.433805, 0.416754, 0.352030, -0.715781, 0.063850, -0.194342, -0.698620, 0.098375, -0.194997, -0.614252, 0.526212, 0.225000, -0.195124, 0.645495, 0.505601, 0.935256, -0.160490, -0.226648, -1.123136, 0.219738, 0.742757, 0.335943, -0.578470, -0.984427, -0.179362, -0.030170, -0.691084, -0.459899, -0.116897, 0.163800, -0.183119, 0.592697, -0.463929, -0.105990, -0.207699, 0.914976, -0.372267, 0.460293, -0.280864, 0.474570, -0.074547, -0.453267, 0.433250, -0.224343, 0.102266, 0.559959, -0.845197, -0.348239, -0.966272, -0.728933, -0.739822, -0.613881, 0.422248, -0.935859, 0.656788, 1.338290, 1.211644, 0.170220, 1.069416, 1.682111, 1.033314, -0.418656, -1.503526, -0.153752, -0.611956, -1.180575, 0.305441, -0.803427, 0.352931, -0.695568, 1.213068, -0.441211, 0.838012, 0.091290, 0.248552, 0.846509, 0.293718, 0.927702, -0.310475, 0.437294, 0.039358, 0.134712, 0.120893, -0.211263, -0.145844, -0.327426, 0.165913, -0.177690, -0.097568, -0.004068, -0.182404, 0.239831, -0.130763, -0.172801, 0.178642, 0.366724, 0.657415, 0.579704, -0.154073, -0.162593, -0.096934, -0.324529, -0.303846, -0.185069, -0.303702, -0.107069, 0.021009, 0.211525, 0.032634, -0.406925, 0.036050, 0.070042, -0.003444, 0.134850, 0.043213, 0.181215, -0.102152, -0.134749, -0.066717, 0.072196, 0.037154, 0.056932, -0.007458, -0.170204, -0.173829, 0.021618, 0.296202, 0.173482, 0.109844, 0.155961, -0.224714, -0.137024, -0.047459, -0.233007, 0.012034, 0.127072, -0.177449, -0.017557, -0.114752, 0.111978, -0.190724, -0.011943, -0.260141, -0.482332, -0.138380, -0.192252, -0.262545, -0.245794, -0.132573, -0.172700, -0.149529, 0.183982, 0.368255, 0.046184, -0.041999, 0.064786, 0.078242, 0.179223, -0.316767, -0.337655, -0.150359, -0.260778, -0.180149, -0.117460, -0.176624, 0.078632, 0.063022, 0.093243, -0.026932, -0.246967, -0.097043, 0.003698, -0.490168, -0.238048, -0.486878, -0.171646, 0.302194, 0.132939, 0.109894, 0.014410, -0.459855, 0.829821, 0.508117, -0.075888, -0.090164, -1.170941, -1.224345, -1.336110, -0.470840, -0.145358, -0.287268, 0.239845, -0.297334, -0.452509, -0.467813, 0.436184, 0.365298, 0.976558, 1.001885, 0.731842, 0.721161, 0.127241, 0.151721, -0.072374, -0.100787, -0.309570, 0.355031, 0.596438, -0.036779, -0.106607, -0.265578, 0.219917, 0.443644, 0.200472, -0.308248, -0.791913, 0.082418, -0.162157, -0.152080, 0.140158, -0.364464, 0.358190, 0.128181, 0.531002, 0.223618, -0.385904, -0.386928, 0.173167, -0.385928, 0.302157, 0.121842, -0.018896, 0.142120, -0.206813, 0.043480, -0.118149, -0.193135, 0.141071, -0.027676, -0.114817, 0.411284, 0.297334, -0.384904, -0.365501, -0.352527, 0.195933, 0.224546, 0.032966, 0.331864, 0.337131, -0.300783, -0.055285, -0.125788, 0.205335, 0.223203, 0.172410, -0.048930, 0.149902, 0.385421, -0.719759, -0.131363, -0.008052, 0.547620, 0.471690, -0.094240, 0.073623, -0.141404, 0.242487, -0.298627, -0.319353, -0.021106, 0.220998, 0.850263, 0.149551, -0.243728, -0.579604, 0.185207, -0.343321, 0.137261, 0.162676, -0.115113, 0.548502, 0.381732, 0.725240, 0.165509, -0.332131, -0.116884, 0.115245, -0.072404, 0.537132, -0.098804, -0.050969, -0.745404, 0.372993, -0.168077, -0.841409, -0.078817, 0.603910, 0.203419, 0.148647, -0.622157, -0.858180, -0.303465, -0.575298, 0.529001, 0.015330, -0.161695, 0.639674, 0.530492, 0.052084, 0.585640, 0.520981, 0.753461, 0.204422, 1.340942, 1.015589, 0.135126, -0.498012, -0.503886, 0.703251, 0.022012, -0.246052, -0.361024, -0.666107, -0.219372, -0.564274, -0.509335, -0.309553, -0.395576, -0.025944, 0.102960, 0.205807, 0.031537, -0.000545, 0.496066, 0.071944, 0.361941, -0.216898, -0.774808, 0.187578, -0.160475, 1.603102, 0.730506, 0.319467, 0.325034, 0.268493, 0.214892, -0.478579, -0.379187, 0.067386, -0.427118, 0.293216, 0.352216, 0.128673, -0.432302, -0.120085, -0.096141, 0.229350, 0.536448, 0.340728, -0.124022, -0.594521, -0.160370, 0.312284, -0.180776, -0.421660, 0.244217, 0.108095, -0.342077, -0.698148, 0.385847, 0.309444, 0.501711, 0.551419, -0.584342, -0.017025, -0.518756, 0.343527, 0.131508, -0.500787, 0.394836, 0.055115, -0.352926, -0.477208, 0.133485, -0.134589, -0.270821, -0.412911, 0.181674, 0.095185, 0.416748, 0.808731, -0.125089, -0.230029, 0.272748, 0.335488, 0.505794, -0.096191, -0.687331, -0.090443, -0.366349, 1.600897, 0.406430, -0.088320, 0.233903, 0.251462, -0.193642, -0.734545, -0.539850, 0.142954, -0.065978, -0.062727, -0.717970, 0.609751, 0.074519, -0.293237, 0.275566, 0.682541, 0.217115, 0.161623, -0.991449, -0.855631, -0.337821, -0.466856, 0.727855, -0.092804, 0.202465, 0.647399, 0.359641, -0.327526, 0.479314, 0.538330, 0.570917, -0.133303, 0.362476, 0.067449, -0.623420, -0.742485, -0.531243, 0.040918, -0.323076, -0.066480, -0.345907, -0.793165, -0.400922, 0.029715, -0.805656, -0.320914, -0.468971, -0.174157, -0.150614, 0.634838, 0.174334, 0.445187, -0.345448, -0.384905, 0.504012, 0.217465, 0.617067, 0.903283, -0.225523, 1.147878, 1.053891, -0.549250, -0.004962, 0.005125, -0.183326, 0.138811, 0.541835, 0.220484, 0.023785, 0.366219, -0.032254, 0.034712, -0.039036, 0.459961, 0.153644, -0.263200, 0.067895, -0.111781, 0.008889, 0.746625, 0.481303, -0.186595, 0.305004, -0.111759, -1.044631, 0.180429, 0.238209, 0.144797, 0.399737, 0.085064, -0.254454, -0.340899, 0.258039, 0.074300, -0.122490, -0.270755, 0.040496, 0.411337, -0.561986, -0.432069, -0.302796, -0.546342, -0.339207, -0.105166, -0.604688, -0.246198, -0.432192, -0.199805, -0.113057, 0.071891, 0.155990, 0.465235, -0.196352, -0.365475, 0.524129, -0.022056, 0.872784, 0.631365, -0.368394, 0.665538, 0.438117, -0.661373, 0.322988, 0.259609, -0.343019, 0.058054, 0.445765, 0.120915, 0.048447, 0.548171, -0.000864, 0.399127, 0.493544, 0.985410, -0.779847, -1.459549, -0.724726, -0.066614, -0.634763, 0.260218, -0.034964, 0.453825, -0.385128, 0.725210, 1.098071, -0.664134, 0.944387, -0.407473, -0.184716, 1.680984, 0.858523, 1.236894, 1.640689, 1.158291, 0.641021, 1.068041, 1.689401, 0.862619, 0.927873, 0.692950, 0.117850, 1.442001, -0.221898, -0.010270, 0.330876, 0.145040, -0.380661, 0.201388, -0.149033, -0.429874, 0.289571, 0.075493, 0.133266, 0.166922, -0.040594, 0.766163, 0.032347, 0.718870, 0.060790, 0.422220, 0.185349, 0.147732, 0.209298, 0.179500, -0.155227, -0.577267, -0.153499, 0.177148, 0.430668, -0.149797, -0.616490, 1.823967, -0.577053, -0.619115, -0.605308, -0.627616, 0.007619, -0.219628, 0.008299, -0.003575, 0.483011, 0.072823, 0.591839, 0.059491, -0.278702, 1.043960, -0.021990, -0.234938, 0.158679, -0.755452, 0.341152, -0.540488, -0.038785, -0.420800, -0.233139, -0.260169, 0.646985, 0.399492, -0.147518, 0.388520, 0.641497, 2.283242, -0.227274, -0.032539, 0.247816, 0.272626, -0.336396, 0.140066, -0.458326, -0.090184, 0.422748, -0.120849, 0.594345, 0.030319, 0.104314, 1.025145, 0.000351, 0.573494, 0.185489, 0.891808, -0.095850, 0.007903, 0.400080, 0.035884, -0.172577, -0.422136, -0.320386, -0.060509, 0.338565, -0.336791, 0.797364, -0.622358, -1.493483, -1.102358, -1.463100, -2.543382, -2.505108, -1.800205, -0.205874, -0.638508, -0.884220, 1.101145, -0.259301, -0.645664, 0.448735, 0.787424, -0.821335, 0.304370, 0.965027, -1.600493, 0.841694, -0.527865, 0.134666, -0.578866, -0.416277, 0.005707, 0.995967, -0.558402, -1.349897, 0.222642, -0.323975, -0.033417, -0.296837, 0.332247, -0.118410, -0.308428, 0.402081, -0.007240, -0.297288, 0.019607, 0.412150, 0.162071, 0.101190, 0.847436, -0.602993, -0.239662, 0.346108, 0.337837, -0.463778, 0.274519, -0.163144, -0.930497, 0.357632, -0.080883, -0.159595, -0.318631, 0.056884, -0.183096, -0.677832, -0.015987, 0.093283, 0.384192, 0.443343, -0.342202, 0.214865, 0.132121, -0.385621, -0.096541, 0.212650, -0.035420, 0.467730, -0.093691, -0.074788, -0.016498, -0.317425, -0.398161, -0.473641, -0.726014, -0.470986, 0.543465, -0.130270, 0.032427, -0.169875, 0.173181, -0.025754, 0.145847, -0.363043, -0.005841, -0.110523, -0.221717, -0.333320, -0.142947, 0.017576, 0.229290, -0.019797, -0.201854, 0.584938, 0.113909, -0.267191, -0.260001, -0.112603, 0.245966, 0.315349, 0.470490, -0.836245, -0.357045, 0.060111, 0.780760, -0.096927, 0.367744, -0.225969, -0.564027, 0.802806, -0.338704, -0.143393, -0.115291, 0.245391, -0.238701, -0.625679, -0.093776, 0.332138, -1.148237, 0.503109, 0.387752, 0.200310, 0.560407, 0.911790, -0.580373, -0.334016, -0.828742, -0.244624, 0.179431, 0.342537, 0.361874, 0.909722, 0.226435, 0.131501, 0.244386, -0.115681, -0.165348, -0.170005, -0.238466, 0.053376, -0.744111, -0.168982, -0.219170, -0.221366, 0.352251, -0.096672, 0.153409, -0.230837, -0.280621, -0.336927, -0.211695, -0.243023, -0.253862, -0.214694, 0.551282, -0.011893, -0.209679, 0.573939, -0.245385, -0.403419, -0.472569, -0.623051, 0.124664, 0.499692, 0.104893, 0.705228, 0.012101, 0.125208, -0.473612, 0.523626, -0.537406, -0.200074, -0.184158, 0.122366, 0.521689, -0.499186, -0.424549, -0.081632, -0.065316, 0.243052, 0.013171, 0.041638, -0.256065, -0.519841, -0.164363, 0.245808, 0.242947, -0.027366, -0.201361, 0.074936, -0.070680, 0.150080, 0.253235, 0.347037, 0.013544, -0.094014, 0.199857, -0.389676, -0.259984, -0.718626, 0.153023, -0.013908, 0.168286, 0.649619, -0.234664, 0.051384, -0.035834, -0.423546, -0.683853, -0.393554, -0.242544, -0.089625, -0.128586, -0.425160, -0.176964, 0.030838, -0.199457, 0.440014, -0.412459, -0.209299, -0.339545, -0.506648, -0.060821, 0.595663, -0.225574, 0.350273, -0.093193, 0.182126, -0.038677, 0.355419, -0.529108, -0.422779, -0.342568, 0.133513, 0.258943, -0.514549, -0.629990, 0.022558, -1.207069, -0.649367, 0.836565, 0.408960, 0.346805, -0.187322, -0.103568, -0.433238, -0.890386, -0.257697, 0.358573, -1.472593, 0.306405, 0.942995, -0.535711, 0.674696, 0.300135, 0.379472, -0.190900, 0.500041, 0.885673, 0.399790, 0.903651, 0.569725, 0.585974, 1.304241, -0.452282, 1.480537, 1.112428, -0.000128, -0.212530, -0.214376, 0.133218, -0.269955, 0.479090, 0.165698, 0.031628, -0.182738, -0.162392, 0.070580, 0.003865, 0.681059, -0.420303, -0.186345, 0.205146, -0.129897, -0.485914, 0.052297, -0.224713, -0.308370, 0.295680, 0.168049, -0.188881, -0.157655, 0.713766, 0.329577, -0.312066, 0.543399, 0.224823, -0.012590, 0.016295, -0.325698, 0.276706, 0.056320, 0.088905, 0.630283, 0.407868, -0.104841, -0.487397, -0.402082, -0.202242, -0.329407, 0.062588, 0.005679, -0.163379, 0.310278, -0.048973, 0.385017, -0.101224, -0.538666, -0.177798, 0.505344, -0.016686, -0.169126, 0.234904, 0.054405, -0.480413, 0.244919, -0.089629, -0.230486, -0.517356, -0.163158, 0.041619, -0.235233, 0.359009, 0.127155, -0.203940, -0.185386, -0.125247, -0.041472, 0.164863, -0.006729, -0.480864, -0.010520, -0.321742, -0.004891, -0.430771, -0.035873, -0.187709, 0.034338, 0.285857, 0.138121, -0.391027, -0.156947, 0.919048, 0.235963, -0.666846, 0.323932, 0.196261, 0.052143, -1.012030, 0.921754, 0.362142, 0.426427, 0.770152, 1.111968, -0.620794, -0.357846, -0.820081, 0.246689, 0.350810, 0.372775, 0.228553, 0.976303, 0.492040, 0.159942, 0.435538, 0.237539, -0.212058, 0.136909, -0.288110, 0.089592, -0.702361, 0.149179, -0.341873, -0.099947, 0.693235, 0.131040, 0.708611, -0.162958, -0.002293, -0.113410, -0.144999, -0.197254, -0.517417, 0.277311, -0.036331, 0.132347, -0.076908, 0.332505, 0.073042, -0.415928, 0.625897, -0.964967, -0.052611, -0.243917, -0.200458, -0.302056, 0.184829, 0.177632, 0.094881, 0.210515, -0.122696, -0.119383, 0.400288, -0.676519, -0.090255, -0.019895, 0.066376, -0.031078, 0.093382, -0.007714, -0.022553, -0.057436, -0.086496, 0.047737, 0.084100, -0.033474, -0.414218, -0.144075, 0.072450, 0.241015, 0.648610, 0.373976, 0.134889, 0.087109, 0.142519, 0.046951, -0.525951, -0.439463, 0.171929, -0.025703, -0.094556, -0.093801, -0.601475, -0.434276, 0.207927, 0.472924, 0.309558, -0.285208, -0.212626, -0.434624, -0.210040, -0.052951, -0.671383, -0.057295, -0.566494, -0.034811, -0.021914, -0.214810, 0.353644, -0.478737, 0.739445, -0.936898, -0.355040, -0.319588, -0.068282, -0.352692, 0.226694, 0.011846, 0.061108, -0.335325, -0.016225, 0.081942, 0.085757, -0.879081, -0.286681, -0.059486, -0.078664, 1.380038, -1.052772, -1.673817, -1.523722, -0.765768, -2.377014, -2.608142, -0.876792, -0.088157, -0.065554, -2.550012, 2.756678, -0.426472, -0.351972, 0.259100, 2.119981, -1.595497, -0.218712, 0.837981, -1.157734, -0.043754, 0.159146, 0.407178, -0.107564, -0.659889, -0.335351, 1.561037, -0.752728, -0.591744, -0.101980, -0.491429, -0.158768, -0.310636, 0.412584, -0.174419, -0.232214, 0.298052, 0.089272, -0.442144, -0.091887, 0.638194, -0.148491, -0.119949, 0.498894, -0.320512, -0.171538, -0.104048, -0.062309, -0.020749, 0.121939, -0.186690, -0.404119, -0.193579, 0.478574, -0.378543, -0.261491, 0.205602, 0.489904, 0.022264, 0.224322, -0.049385, 0.187874, -0.128945, -0.068071, -0.246474, -0.267706, 0.040471, 0.056842, -0.030216, 0.088885, 0.276468, 0.003345, 0.099261, -0.021744, 0.048426, -0.196690, 0.162950, 0.291215, 0.367577, -0.022940, -0.092229, 0.048172, -0.081893, 0.069441, -0.124208, -0.302156, 0.054426, -0.580961, 0.016754, -0.030082, -0.545238, -0.304878, -0.344466, 0.325671, -0.110816, -0.025708, 0.671269, 0.084243, -0.491154, -0.120691, 0.377662, -0.119252, 0.277980, 0.476646, -0.118398, 0.078100, -0.158982, -0.150706, 0.097041, -0.076594, -0.132631, -0.387030, -0.229235, 0.401562, 0.269275, -0.072436, 0.086278, 0.489154, -0.249451, 0.417189, 1.314358, -1.157262, -1.903279, -2.078013, -1.466390, -2.593747, -3.055931, -2.222631, -0.767415, -0.016049, -2.972889, 1.701522, -0.653119, -0.742367, 0.051685, 2.235399, -1.725710, -0.420220, -0.055781, -2.061791, -0.541534, 0.373024, -0.251080, -0.541324, -0.757334, -0.620909, 1.233824, -1.535438, -0.955659, -0.939164, -0.460631, -0.377240, 0.077408, 0.279392, 0.443128, -0.239393, -0.364079, 0.325263, -0.362948, -0.489760, 0.571565, -0.137870, -0.381296, 1.073041, -0.259094, -0.397816, 0.211736, -0.418992, 0.099557, -0.155647, -0.148030, -0.431402, -0.378999, 0.046843, 0.228596, 0.068837, 0.130697, 0.110392, -0.280778, -0.516379, 0.131732, 0.179231, 0.493036, 0.243485, -0.328763, 0.170874, -0.256307, -0.561002, -0.278415, -0.020215, 0.053496, -0.129757, 0.583186, 0.559721, 0.288016, -0.199830, -0.586827, 0.016136, 0.110935, 0.201278, 0.346890, -0.356891, 0.213007, -0.290870, 0.140172, 0.413422, 0.229965, 0.057796, -0.262315, -0.006873, -0.527518, -0.425393, 0.094970, 0.355792, 0.316475, 0.004163, -0.153938, -0.044568, -0.341527, -0.488338, 0.030770, -0.212350, -0.087330, 0.693127, -0.032424, -0.217323, 0.393625, -0.269850, 0.206915, -0.154047, 0.011495, -0.416428, -0.414397, -0.163191, 0.623662, 0.035914, 0.178428, 0.067345, 0.254765, -0.421918, 0.046854, -0.069806, 0.599039, 0.644069, 0.774557, 0.341511, 0.449266, 0.484980, 0.330034, 0.009287, -0.634155, 0.314357, -0.390080, -0.026710, -0.010097, -0.148843, 0.135008, 0.135256, 0.156001, 0.059918, -0.421425, -0.007542, -0.132732, -0.188560, -0.274516, 0.312757, -0.320971, -0.751270, 0.017757, -0.465181, -0.201137, 0.053794, 0.026563, -0.464123, -0.326987, 0.082059, -0.398197, 0.848247, -0.298122, 0.157516, -0.000170, -0.502469, 0.639081, -0.136556, 0.169196, -0.610831, 0.008002, 0.491082, 0.807823, 0.334034, 0.171649, -0.097522, -0.040399, -0.336932, -0.369006, 0.391740, 0.708100, 0.291763, -0.253130, -0.160310, -0.466286, -0.029976, -0.634235, -0.286382, 0.191298, 0.461774, 0.501690, 0.720662, -0.027919, -1.039232, -0.162470, 0.527072, 0.480509, -0.575036, 0.713659, -0.109071, 0.045613, -0.155657, 0.730033, 0.041973, -0.557110, -0.571315, 0.166321, 0.761156, 0.710825, -0.122578, -0.414151, 0.309687, -0.645271, -0.588215, -0.253364, -0.117040, -0.295067, -0.624556, -0.492197, -0.476559, -0.447378, 0.849913, 0.229855, 0.373166, -0.258200, -0.077730, 0.601861, 0.188754, 0.486634, -0.673318, -0.394981, 0.037363, 0.548702, 0.119230, -0.079042, -0.056858, 0.108279, -0.454103, -0.457187, 0.296640, 0.327840, 0.434351, -0.508945, -0.108488, -0.002447, -0.371791, 0.328829, 0.087671, 0.610583, 0.726137, 1.041152, -0.205756, 0.631969, -0.556077, 0.176926, -0.325205, 0.046896, 0.216772, 0.542791, -0.052444, -0.277334, 0.202131, 0.130589, -0.379189, 0.222515, -0.407005, -0.144087, -0.555863, -0.095290, -0.295881, -0.381900, 0.182431, -0.213866, 0.249680, -0.069209, -0.335548, -0.049189, 0.086871, 0.199702, -0.401819, -0.567888, -0.056726, 0.359365, -0.480988, 0.165510, -0.961872, -0.056562, -0.653860, 0.405371, -0.628928, -0.430311, 0.353494, 0.471457, -0.311586, -0.174479, 0.792788, 0.186039, -0.790550, -0.107792, 0.033116, 0.171910, -0.581319, -0.233748, 0.786532, -0.146167, -0.302113, 0.004508, -0.023631, 0.142359, -0.787348, 0.698595, -0.081937, -0.521569, -0.094610, -0.225743, 0.717477, 0.905142, -0.062741, -0.671670, -0.075306, 0.291643, 0.553310, 0.182855, -0.351580, 0.233587, -1.030680, 0.099731, 0.587221, -0.411391, 0.756161, -0.847113, -0.157193, -0.750182, 0.164963, -0.046737, -0.270068, 0.044306, -0.112778, -0.357108, -0.246600, -0.077988, -0.365734, 0.651657, -0.576705, 0.223578, -0.955208, -0.174512, -0.653764, 0.896177, -0.295291, -0.036586, -0.188135, 0.099133, -0.831106, -0.624487, 0.305907, 0.212501, -0.360690, -0.124569, -0.266858, 0.383385, -0.473551, -0.811908, 0.354350, 3.677564, -2.245900, -1.602158, -0.939465, -2.050215, -0.258824, 0.063634, -0.932155, -1.873393, 0.182765, 0.235014, -0.935094, 0.498008, 0.050912, 0.147447, 0.846000, 0.262017, -0.360179, 0.995109, 1.289163, 0.509738, 1.231998, 0.652559, 0.587874, 0.966363, 1.037929, 0.035570, 0.899557, 0.328851, -0.782524, 6.208731, 4.445088, 4.144582, 4.033008, 2.548072, 2.460370, 1.871802, 0.197300, 1.210235, 0.391843, -0.494219, 0.302566, 0.611690, 0.618579, -0.716712, -0.910341, -0.188553, -0.743605, -1.131824, -0.822694, -1.153610, -1.729085, -1.350142, -1.391235, -1.168125, -1.796236, -0.576147, -1.506193, -1.187047, -0.725674, -0.104355, 0.309346, 0.524959, 0.310980, 0.007740, 0.544937, -0.665038, -0.563623, -0.541043, -0.794589, 0.038957, -0.062624, 0.899942, -0.205800, 0.305625, -0.192624, -0.094218, -0.432632, -0.601328, -0.166591, 0.265616, -0.324961, -0.375527, -0.077631, -0.123011, 0.004969, 0.485967, -0.195945, -0.425045, 0.406470, 4.874753, 2.119901, 3.282390, 2.688433, 2.033086, 1.361844, 1.794796, 1.102254, 0.591514, 0.110675, -0.719412, 0.617022, 0.728939, 0.516875, -0.866930, -0.424760, 0.155638, -0.060808, -1.061915, -0.875308, -0.314453, -0.474009, -0.547140, -0.441448, -0.142693, -0.891363, -0.555501, -1.048631, -0.972547, -0.386144, 0.764697, -1.338750, 0.969330, 1.278626, -3.614559, 2.239262, -2.990454, 1.099611, 1.124713, -3.930253, 4.889657, -3.328777, 2.008558, 0.193535, -2.272656, 4.876368, -3.491829, 0.392798, 1.126672, -4.953836, 5.096262, -3.810910, 0.862035, 1.116045, -4.240688, 4.248219, -3.012268, 0.957101, 1.029469, -3.740037, -0.273865, 0.095260, 0.547652, 0.186868, 0.649822, 1.734506, 1.334169, 0.029964, -0.299143, 1.186759, 0.780117, 0.950099, 0.106922, -0.231068, 0.317655, 0.274510, 0.254154, 0.679331, -0.484541, 0.713138, 1.334688, 0.057322, -0.325333, -0.771156, 1.332781, 0.637855, 0.393437, -0.299917, 0.604650, 1.058687, -0.198578, -0.827887, -0.070549, 0.107621, -0.302555, -0.354942, 0.284497, 0.789017, -0.003190, -0.144642, 0.695663, 0.195136, -0.327526, 0.014191, 0.493456, 0.033034, 0.058888, 0.121584, 0.689667, 1.126582, -0.588430, 0.011559, 0.530707, 0.899820, 0.040604, 0.066247, 0.288615, -0.234763, -0.071145, 0.714612, -0.057245, 0.455953, 0.467024, 0.096106, 0.518269, 1.286330, -0.128046, 0.718011, 0.341437, 0.573470, 0.003750, 0.752849, -0.241335, -0.144514, 0.267580, 0.000486, 0.233674, 0.613020, -0.463697, 0.526336, 0.698008, -0.521805, 0.210172, -0.622684, 0.338045, 1.158651, 0.397546, 0.304111, 0.271027, 0.791485, -0.046668, 0.488460, 0.744585, 1.148368, -1.160878, -1.431118, -0.751288, -0.128130, -0.260983, 0.299418, 0.477261, 0.580535, -0.576848, 0.849671, 0.915565, -0.332150, 0.882027, -0.882889, 0.170725, 1.469176, 0.854431, 0.872197, 1.367657, 1.217980, 1.021921, 0.515857, 1.747384, 0.330733, 0.983790, 0.367390, 0.121494, 1.195436, 0.354283, -0.003964, 0.344011, 0.117954, 0.754930, -1.199639, 0.115113, 0.060333, -0.147570, 0.975035, 0.194416, 0.172372, 0.417927, 0.063888, 0.636305, -0.161439, -0.571434, 0.248274, 0.433425, -0.409478, 1.206556, -0.298328, 0.605657, 0.970975, -0.781247, 0.849030, -0.795980, 0.130993, -1.357705, 2.183402, 0.570084, 0.450382, 0.411886, -0.478316, -0.467446, -0.477569, -0.696199, -0.184022, 0.811118, 0.975474, 1.744624, -0.584919, -1.024095, -0.290304, -0.031161, 0.158881, 0.239673, -0.599389, -0.733135, -0.429569, 0.285902, 0.843862, 0.920070, 0.756433, 0.154745, 0.341385, 0.634644, 0.230082, 0.783381, 2.469561, 0.601461, 0.091040, 1.202301, 0.033531, 0.962061, -0.760824, 0.692069, 0.839617, 0.222515, 0.583762, 0.802942, 0.162233, 0.529101, 0.407019, 0.905883, -0.334332, 0.193586, 0.451697, 1.276811, -0.536351, 0.220774, -0.341849, 0.852439, 0.378329, -0.609511, 0.197374, -0.853192, -0.220015, 0.148631, 0.437985, 0.569532, 0.847186, -0.930992, -1.445858, -0.664168, 0.327621, -0.377620, -0.612729, 0.137722, 0.303302, 0.167256, 0.368282, 0.525937, 0.701630, -0.178353, -0.416785, 0.548359, 0.993162, 1.426642, 0.965717, 1.729792, 0.917924, 1.105297, 1.476358, 1.389754, 0.840527, 0.551051, 0.358603, 0.046740, 0.814220, -0.032612, -0.249088, 0.033591, 0.017923, -0.515060, 0.021933, 0.878256, 0.134086, -0.432647, -0.445417, -0.091550, 0.134867, -0.325390, -0.503605, -0.045823, 0.315708, 0.146070, -0.501775, -0.065445, 0.021636, -0.432792, 0.568715, 0.478346, 0.392962, -0.089949, 0.499651, 0.038182, -0.442068, 0.211539, -0.386517, -0.670986, -0.397020, 0.266285, 0.385834, 0.545963, 0.763504, 0.619411, -0.264478, -0.391154, -0.109554, 0.027721, 0.425449, 0.162832, -0.207109, 0.124818, 0.442431, 0.499926, -0.058264, 0.668947, 0.163232, -0.142301, -0.513138, -0.433928, -0.301747, -0.550468, -0.418680, -0.074733, -0.176730, 0.299769, 1.469169, 0.550700, -0.031959, -0.134984, -0.172899, -0.227062, 0.195907, 1.341585, 0.025883, -0.283278, -0.349473, -0.048984, 0.521926, -0.269368, -0.270159, 0.351542, 0.575718, 0.544607, -0.256918, 0.327174, -0.247978, -0.055313, 0.752505, -0.001156, 0.218004, 0.063422, 0.428670, 0.055410, -0.295711, -0.038817, -0.976528, -0.183110, 1.090994, 0.986038, 0.589203, 0.152188, -0.180171, -0.586604, -0.623184, -0.542992, -0.252596, -2.096152, 0.389869, -0.009669, -1.254105, 0.150818, -0.185954, -0.125146, -0.404560, 0.257625, 1.051177, 0.462028, 0.918671, 1.453923, 0.975900, 1.419758, 0.147393, 1.742692, 0.926516, -0.142043, -0.282621, -0.173701, -0.353875, -0.176187, 0.023633, 0.465219, 0.262706, -0.014735, 0.087584, -0.579569, -0.145916, 1.167822, -0.505417, -0.128256, 0.364738, -0.204653, -0.516350, -0.731130, 0.367126, -0.748743, 0.361173, -0.257618, 0.704477, 1.010989, 0.340198, 0.222071, 0.581260, -0.269100, 0.038507, -0.116135, -0.139300, -0.362221, 0.013055, 0.185143, -0.566940, -0.297502, 0.567721, 0.380356, 0.267491, -0.017256, -0.136654, 0.088769, 0.064214, -0.150307, -0.045236, -0.042182, -0.159073, 0.093901, -0.188458, 0.327238, 0.604303, -0.103208, -0.085925, -0.038075, -0.000993, -0.762987, 0.190797, 0.153276, 0.509019, -0.300613, -0.461207, 0.165197, -0.178680, -0.195743, 0.094802, 0.562251, 0.262779, -0.237946, -0.083994, -0.260668, -0.172811, 0.504550, -0.097518, -0.282483, -0.001735, -0.219552, 0.029249, -0.367699, 0.551028, -0.205234, 0.541967, -0.348786, 0.529886, 1.116912, 0.303522, 0.060710, 0.527017, -0.464420, -0.218036, -0.033044, -1.094083, -0.243590, 0.979454, 0.653745, 0.368214, -0.049883, -0.286944, -0.426305, -0.882553, -0.298732, 0.098110, -1.546548, 0.499993, 0.379563, -0.965935, 0.296835, -0.096443, 0.126113, -0.342888, 0.321014, 1.203375, 0.475244, 1.067079, 1.156163, 0.464459, 1.140357, -0.087018, 1.469086, 1.228655, -0.079112, -0.466410, -0.315910, -0.307303, -0.614649, 0.048549, -0.396522, 1.203490, -0.064958, -0.084673, -0.334247, -0.455192, 0.708234, -0.144262, 0.302647, -0.669838, 0.245898, -0.169054, -0.481764, -0.848470, -0.487676, -0.231500, 0.204598, 0.242895, 0.515063, -0.000071, 0.430285, 1.141688, 0.774782, 0.403515, 0.163125, 0.057681, -0.110243, -0.301205, -0.036817, 0.304801, 0.124363, -0.003026, 0.070628, 0.021822, -0.274863, -0.349396, 0.240475, 0.045511, -0.123375, 0.482309, 0.223563, -0.139021, -0.462118, -0.262554, 0.406506, 0.271887, -0.008669, -0.501654, 0.077464, 0.357736, 0.116943, -0.928060, -0.256541, 0.290083, -0.371742, -0.402761, -0.131882, -0.236885, 0.038395, 0.003501, -0.095886, 0.949377, -0.195111, -0.245059, -0.275236, -0.311858, 0.416810, -0.291956, 0.257731, -0.456420, 0.221793, -0.001105, 0.029730, -0.493128, -0.194060, -0.019261, -0.082578, 0.086270, 0.171886, 0.080470, 0.199070, 1.271380, 0.557737, 0.085177, 0.155519, 0.435618, 0.268125, 0.861486, -0.840103, -1.363322, -0.684801, 0.173569, -0.430808, 0.006379, -0.109201, 0.235411, -0.188771, 0.794768, 0.848362, -0.152551, 0.742956, -0.446390, 0.301511, 1.574763, 0.744329, 1.125381, 1.508855, 1.034011, 0.576893, 0.906164, 1.295416, 0.310029, 0.955339, 0.292424, 0.181517, 1.478719, -0.394133, -0.434254, -0.457000, -0.325435, -0.484841, -0.255766, -0.028813, -0.248965, -0.163968, -0.212546, -0.303259, -0.319152, -0.100590, 0.578412, 0.118210, 0.208791, -0.176162, 0.601085, -0.222933, 0.570585, -0.181823, -0.272923, 0.109561, -0.204276, 0.196016, 0.411520, 0.234165, 0.367942, 0.879280, -1.551397, 0.038059, 0.464979, 0.018642, 0.343191, 0.230428, 0.021194, 0.270331, -0.028034, -0.106582, -0.094655, -0.427975, -0.015137, 0.463050, -0.976946, 0.148214, -0.095739, -0.258572, 1.081493, -0.144534, 0.527602, 0.390484, 0.223404, 0.029004, -0.236563, -0.320036, -0.093037, -0.400945, -0.371221, 0.618030, 2.200788, -0.351834, -0.401639, -0.506706, -0.155228, -0.312814, 0.289469, 0.249081, -0.275087, 0.136749, -0.329331, -0.047247, -0.186785, 0.018165, 0.608443, 0.318409, 0.575531, -0.167091, 0.935408, -0.193157, 0.755407, -0.001319, -0.343547, -0.119203, -0.388575, 0.129445, 0.478151, 0.291768, -0.108582, -0.200630, 0.453675, -0.670481, -0.725440, -0.304440, -0.008322, -0.329339, 0.254727, -0.023638, 1.165971, 0.748118, -0.757006, 0.009036, -0.650086, -0.577057, -0.291725, -0.585125, -0.944203, -0.857142, 0.061712, -0.234279, 0.472422, -0.261897, 0.184565, 0.357130, -0.002605, -0.248622, -0.331948, -0.636652, -0.122854, 0.015598, -0.003062, 0.600814, 0.210567, 0.586641, 0.088448, 0.191836, 0.191513, 0.302251, 0.574870, 0.032668, 0.746782, 0.430240, 0.691062, -0.126832, 0.331755, 0.655932, 0.142982, 0.194522, -0.005884, 0.490762, 0.357645, 0.194481, 0.497944, -0.093528, -0.595125, 0.019834, -0.141041, 0.292906, -0.135208, -0.226068, -0.466394, -0.154268, 0.290726, 0.614462, 0.322244, 0.414138, -0.372028, 0.101780, 0.698493, 0.282663, -0.224945, -0.239618, 0.060901, -0.656489, 0.225040, 0.952600, 0.645743, -0.107932, -0.341864, -0.330204, -0.060915, -0.189169, 0.097633, 0.027944, -0.228393, 0.349529, -0.083086, 0.013820, 0.119972, 0.089550, 0.305683, 1.202021, 0.296009, -0.264596, 0.141485, -0.317698, 0.406822, 0.071646, 0.460967, 0.604472, 0.911071, 0.362008, 0.870415, -0.186112, 0.448102, 1.009121, 0.857135, 0.433363, 0.223528, 0.485012, 0.549796, -0.157895, 0.940859, 0.566764, -0.276965, 0.203419, -0.488037, 0.309053, -0.193362, 0.634421, 0.523206, -1.960023, -0.981655, -1.818285, -0.639189, -0.415761, -1.568187, -0.452901, 0.632812, -0.336567, 0.011104, 0.321877, 1.005277, -0.391124, -0.007670, 0.958383, 1.019016, 0.902193, 0.680382, 1.226423, 0.031011, 0.306902, -0.661512, -0.488150, 0.212746, -0.184269, -0.264699, -0.187036, -0.905297, 1.447344, 0.297571, 6.259329, 2.229431, -0.351318, 0.450528, 0.416768, 0.641599, 0.121068, 0.444226, 0.335610, 0.339962, -0.656151, 0.386503, 0.017581, 0.517317, -0.453634, 0.512439, 0.475641, -0.354528, 2.239728, 0.946882, -0.440358, -0.788100, 2.404278, 0.592603, -0.074944, -0.492014, 0.178380, 0.079817, 0.950895, -0.796319, -3.082188, -1.567092, -0.382443, -0.324923, -0.573234, -0.979983, 0.056513, 0.574897, 0.098507, 0.508969, -0.888192, 1.074930, -0.770225, 0.224412, 0.581577, -1.027630, 0.251881, -0.350567, -0.526485, 0.503439, 1.670495, -0.339541, -0.142192, 0.516057, 0.141074, -0.023821, 1.227791, 0.173125, 1.376056, 0.152563, 4.733303, 3.145847, -0.539652, 0.895975, -0.041005, 0.671500, 0.116024, 0.529537, 0.018621, 0.804640, -0.045789, -0.116472, 0.407628, 0.438992, -0.930083, 0.389607, -0.231423, -0.353194, 2.402069, 0.646369, -0.066083, -0.229509, 2.138099, -0.472034, 0.307082, 1.034150, -0.160598, 0.536481, 7.096402, -3.196914, -2.626298, -2.747828, -2.936230, -1.291300, -1.172739, -1.876583, -2.829453, -0.483247, -0.702009, -1.557934, -0.147213, -0.236601, -0.055076, -0.034588, -0.181160, -0.374511, -0.341714, 0.411351, 0.116946, 0.319252, -0.173771, -0.035827, 0.063634, 0.310104, -0.017288, -0.046642, -0.428219, -0.863365, 3.930272, 2.569787, 2.846862, 2.164391, 1.690365, 1.117780, 0.544370, 1.024351, 0.594893, 0.147886, -0.303282, -0.389509, -0.313527, -0.581530, -0.549140, -0.536488, -0.741819, -0.699327, -0.764889, -0.981132, -0.925968, -1.165866, -0.941915, -1.199433, -1.132471, -1.036731, -1.174972, -1.094372, -1.032069, -0.925047, -0.228177, 0.044136, 0.614130, 0.616386, -0.132759, -0.050663, -0.317701, 0.112104, 0.128611, 0.051160, -0.031184, -0.190832, -0.014257, -0.095278, -0.203414, -0.223634, -0.035351, -0.126751, 0.040982, -0.214665, 0.088786, 0.108876, 0.202870, 0.287388, 0.173109, -0.275739, 0.203535, 0.070659, 0.069780, 0.155061, 1.991628, 1.158542, 2.132878, 1.480225, 0.921680, 1.057228, 0.262411, 0.754093, 0.588580, 0.249063, -0.243278, -0.155725, -0.041317, -0.082259, -0.380527, -0.247728, -0.125262, -0.096468, -0.186546, -0.531762, -0.390838, -0.353827, -0.136358, -0.684395, -0.763999, -0.476337, -0.584440, -0.296546, -0.419070, -0.484863, 0.079771, 0.228400, 0.605415, 1.001528, -0.658241, -1.428853, -0.730616, 0.341241, -0.376955, -0.490895, 0.098268, 0.236917, 0.090616, 0.440506, 0.814238, 0.273105, 0.393099, 0.016170, 0.358716, 1.402708, 1.340247, 1.089631, 1.574930, 0.923630, 0.898847, 1.148872, 1.186688, 0.384594, 0.720788, 0.286234, 0.017319, 1.280332, -0.184629, -0.294140, 0.688168, -0.252561, -0.190073, -0.306120, -0.133677, 0.236315, -0.117849, -0.033031, 0.006753, 0.278755, -0.564402, -0.148697, 0.612820, -0.547208, -0.560832, 0.092706, -0.578262, -0.251691, -0.576763, 0.327780, 0.824319, -0.745551, 0.626846, 0.600289, -0.278937, -0.019338, 0.464644, -2.028553, 0.227429, 0.883213, 0.389553, 0.093680, 0.031728, 0.227730, 0.290064, -0.757222, -0.495558, 0.390741, 0.546254, 0.154463, 0.116443, 0.095393, 1.171463, 1.089767, -0.135166, -0.124341, -0.139658, 0.245838, -0.055893, 0.125295, 0.754176, -0.244648, 0.185588, -0.777475, 0.000841, -0.827769, 0.323071, 2.087462, -0.116470, -0.266581, 0.435680, -0.225259, -0.132911, -0.032018, 0.139016, -0.025822, -0.352752, 0.328392, 0.035856, -0.222679, -0.365670, -0.314520, 1.015391, 0.059026, -0.618128, -0.206891, -0.313098, 0.022730, -0.482389, -0.228090, -0.043365, -0.787190, 0.566914, 0.175180, -0.204162, 0.422944, -0.654666, 1.096464, -0.285988, -1.017300, -0.035530, -0.074595, 0.082814, 1.031475, 0.709233, 0.710295, -0.010591, 0.005968, 0.426087, -0.561960, -0.954763, -0.365627, -0.688518, -0.665448, 0.273375, -0.564989, -1.177654, -0.495966, -0.622767, 0.219914, -0.297822, 0.000851, -0.015042, 1.135049, -0.235888, 0.160207, -0.342671, -0.427247, 0.048015, 0.392821, -0.299883, -0.088940, 0.691283, 0.422365, 0.037610, 0.239155, 0.051265, 0.171896, -0.190658, 0.289732, 0.361771, 0.799940, -0.217276, 0.410378, 1.144439, 0.071106, 0.486427, -0.296828, -0.236304, 0.354297, 0.176742, 0.835493, -0.044790, -0.688467, -0.165633, 0.163388, 0.129122, -0.298152, -0.002281, -0.287036, -0.099744, 0.447336, 0.770022, 0.065770, 0.099832, 0.726443, 0.525323, -0.096443, -0.101154, -0.057115, -0.691314, -0.478326, 0.245687, -0.147854, 0.130999, 0.112113, -0.246984, -0.037130, 0.265220, 0.116776, -0.122308, -0.135108, -0.422128, -0.233008, 0.429912, 0.628364, -0.407356, -0.485414, 0.183292, 0.186261, -0.592843, -0.391907, 0.291170, 0.008340, -0.108013, 0.285263, 0.136084, -0.203430, 0.021961, 0.123052, 0.133975, 0.656653, -0.278354, 0.312624, 0.387901, -0.079663, 0.568623, -0.011449, -0.254693, 0.211100, 0.103517, 0.720815, -0.134886, -0.282665, 0.299480, 0.281657, -0.300371, 0.487214, 0.394506, 0.033987, -0.104681, 0.389023, 0.368619, 0.271737, 0.451272, 0.129991, -0.167558, 0.144312, 0.297759, 0.003612, 0.035302, 0.164789, 0.062853, 0.125330, 0.485142, 0.257816, 0.017909, -0.594464, -0.226966, 0.020620, 0.053520, -0.168197, -0.727674, -0.517297, 0.023144, -0.088997, -0.139892, -0.193106, -0.268961, 0.108167, 0.549203, 0.734056, 0.515091, -0.352026, 0.121933, 0.683809, 0.326077, -0.193416, 0.529450, 0.306054, -0.051308, -0.114081, 0.326933, 0.529202, -0.185342, 0.199472, 0.729642, -0.449188, 0.235425, -0.175212, 0.180441, -0.276015, 0.338266, 0.056834, 0.885494, 0.107002, 0.208620, 0.270005, 0.200368, -0.170938, -0.276047, -0.706672, -0.617921, 0.274446, 0.487870, 0.087077, -0.359917, -0.339592, 0.172461, 0.424839, 0.549877, 0.016641, -0.610285, -0.492339, 0.058864, 0.488275, -0.230571, -0.374810, -0.050739, -0.103574, 0.095584, -0.213361, -0.061866, 0.651273, 0.263671, -0.404255, -0.102429, 0.003689, -0.277498, -0.143157, 0.926458, 0.475590, 0.747270, -0.055221, 0.359368, 0.377545, 0.286462, -0.150878, 0.937062, 0.223055, 0.161723, -0.018956, 0.219226, 0.579488, -0.193586, -0.160834, -0.013912, -0.319907, 0.116427, -0.142289, 0.442769, -0.309817, 0.169473, 0.259697, 1.083080, 0.157122, 0.738562, 1.054550, 1.807597, 0.596445, -1.389606, -0.974397, -1.607480, -0.323926, 0.911895, 0.309512, 0.951775, 2.148750, -0.446473, 0.804691, -1.549956, -0.382615, -1.339356, -0.444434, -0.355816, -0.787037, -0.228698, -0.794241, -0.357675, -0.585069, 0.377044, 0.378465, -1.141036, -0.117657, -0.195182, -0.575015, -0.042820, 0.416991, 0.848114, 1.201083, 1.078187, 1.315620, 1.514199, 0.787621, 0.777157, 1.123580, 1.434609, 0.907075, 0.450418, 1.007550, 0.433847, 0.781952, 1.484015, 1.047446, 1.048669, 1.738124, 1.159586, 1.229608, 0.883517, 0.637357, 0.814954, 0.747402, 0.821398, 0.363915, 0.103808, 0.569663, 0.320621, -0.019157, 0.072362, -0.085997, -0.259335, -0.954485, -0.721497, -0.227140, -0.448997, 0.157145, 0.262186, 0.091116, 0.148571, -0.129045, -0.265258, 0.663712, -0.001480, 0.230887, -0.477237, 0.352023, 0.308878, 0.217553, 0.313474, -0.475491, -0.301903, 0.651232, 0.446112, 0.054475, 0.243711, 0.163765, -0.144619, -0.075326, 0.411899, 0.499693, 0.905490, 0.855222, 1.002601, 0.997673, 0.562125, 0.374183, 1.090230, 0.706102, 0.150594, 0.759675, 0.085128, 0.409045, 0.470676, 0.623369, 0.665000, 1.023333, 1.048882, 1.132523, 0.243668, 0.283202, 0.611999, 0.483968, 0.714544, 0.428844, 0.114659, 0.344282, 0.164742, 0.514373, 0.283434, 0.584637, -1.194918, -1.371466, -0.700292, 0.310853, -0.380470, -0.007595, 0.219603, 0.487122, 0.046291, 0.885210, 0.928255, -0.279281, 0.343632, -0.996117, -0.023272, 1.652190, 1.215320, 0.991933, 1.853996, 1.170063, 0.782542, 1.060515, 1.670224, 0.284679, 0.699747, 0.253875, 0.135157, 1.245380, -0.120188, -0.055823, 0.059495, 0.057605, -0.231931, -0.387340, -0.137859, -0.084369, -0.387144, 1.235584, -0.113018, 0.702554, 0.490230, 0.708170, 0.460651, -0.380123, 0.514387, 0.887743, -0.014561, 0.023180, -0.255675, 0.264733, 0.612140, 0.202857, -0.016527, 0.432025, -0.563637, -0.125346, 0.273557, -0.680851, 0.567466, 0.343729, 0.335558, -0.020908, -0.383968, -0.019176, -0.193522, -0.487702, 0.059461, 0.111648, -0.713222, -0.698642, 0.524608, 0.170184, 0.204389, 0.195529, -0.128037, 0.240561, -0.576135, -0.352843, 0.249512, -0.049272, 0.564257, 0.272575, 0.040390, -1.084897, 0.380360, 0.164314, 0.380246, 1.868859, -0.151819, -0.503552, -0.065325, 0.048010, -0.293206, -0.199798, -0.083120, -0.085223, -0.776534, 0.762470, -0.188790, 0.539681, 0.845902, 0.695736, 0.592607, -0.208146, 0.831901, 0.945489, 0.178514, 0.111882, -0.397765, 0.100656, 0.569011, 0.502704, 0.131454, 0.649760, -0.065712, 0.184250, 0.847839, 0.149113, 0.005339, -0.551416, -0.425554, 0.074926, -0.342827, -0.170051, 0.906298, 0.237100, -0.329550, -1.485455, 1.794202, -2.428452, 0.678392, 0.852350, -1.936382, -1.467953, -1.747325, -1.023215, -0.602296, -2.394040, -2.090879, -1.168437, -2.380008, -1.900478, -1.409302, -1.118397, -1.510174, -1.951555, -0.600669, -0.839171, 0.111099, -0.121197, -0.636741, 0.046315, -0.109237, 0.358158, -0.251294, -0.872970, 0.589114, -0.573530, -0.202496, 0.066186, 0.013957, 0.284525, -0.900702, -0.164961, -0.235515, -0.087167, -0.650449, -0.023401, -0.600135, -0.280090, 0.093197, 0.588404, -0.775264, -0.067756, -0.537031, -0.209911, 0.103230, -0.527490, -0.072899, 0.006364, -0.614667, -0.192350, 0.453193, 0.703142, 0.035601, -0.460818, -0.248267, 0.282706, 0.267749, 0.633581, 0.060697, -0.401102, -0.356568, 0.273363, -0.353899, -1.144059, -0.172785, 1.302939, 0.083414, -0.319534, 0.568375, -0.276359, 0.135875, -0.267064, -0.309198, -0.233193, -0.608977, -0.695101, -0.212343, 0.172494, -0.260392, -0.003464, -0.262858, 0.013998, -0.376100, -0.960561, 1.312687, -0.119598, -0.258557, 0.452648, 0.459957, -0.020294, -0.451003, -0.160699, 0.076631, 0.107844, -0.422901, 0.142752, -0.950061, -0.327480, 0.278181, -0.007341, -0.178733, -0.184637, 0.093530, -0.342987, -0.379919, 0.216353, 0.076570, 0.155700, 0.190434, 0.763131, 0.597738, 0.377261, 1.032995, 0.255426, -0.109386, 0.427916, 0.040036, 0.340087, 0.463496, 0.271878, 0.917496, 0.796930, 0.385254, -0.033186, 0.015385, -0.262984, -0.745494, -0.755707, -0.570569, -0.725799, -0.652974, -0.313947, -0.216019, 0.003968, -0.073925, 0.101113, -0.317592, -0.097417, -0.027236, -0.295128, -0.541685, -0.056675, -0.406892, -0.125014, -0.548938, -0.831867, -0.576366, 0.052462, 0.255795, -0.102052, -0.231094, -0.346278, -0.034954, -0.383831, -0.460886, 0.424189, 0.418191, 0.275453, -0.489601, 0.463554, 0.129743, -0.362280, -0.284887, 0.509151, -0.345119, 0.955917, 0.179585, -0.327727, -0.219041, 0.046056, -0.186829, -0.176413, -0.516884, 0.265103, 0.236431, -0.337894, 0.240705, 0.313644, -0.129377, 0.032060, -0.233560, 0.271143, 0.137476, 0.176292, -0.129821, -0.355823, 0.055105, -0.666217, -0.141663, -0.012302, -0.429400, 0.321877, -0.217318, -0.768116, 0.243542, 0.552891, -0.245720, -0.094968, 0.070520, -0.234368, -0.162063, -0.082084, -0.255125, -0.155121, -0.360278, -0.405700, -0.414059, 0.004016, 0.127986, -0.155696, -0.175124, -0.390839, -0.051569, -0.528838, -0.672499, 0.131127, 0.618907, 0.527709, -0.208764, 0.777528, 0.124001, -0.275054, -0.353775, 0.812288, 0.825825, -0.665627, -1.808046, -1.256732, -1.388672, -2.838786, -2.634421, -1.938064, -0.013131, -0.435252, -1.753454, 1.187856, -0.469974, -0.719714, 0.385630, 0.825479, -1.029571, 0.157156, 0.631660, -1.545398, 0.958763, -0.497742, -0.088943, -0.562498, -0.411428, 0.056459, 0.579119, -1.093842, -1.359075, 0.105329, -0.441273, -0.291501, -0.035700, 0.604210, -0.314198, 0.042725, 0.183618, -0.265607, -0.322666, 0.466641, 0.264474, 0.210481, -0.631799, 0.663302, 0.426830, 0.172350, 0.167256, 0.471673, -0.158714, 0.561715, 0.096417, 0.074648, -0.032704, -0.089074, 0.151062, -0.604275, 0.199067, -0.201517, 0.585929, -0.373268, -0.135273, -0.556996, -0.546000, -0.050957, -0.250252, -0.519446, -0.250339, 0.470900, 0.423303, 0.687290, -0.370048, -0.564685, -0.190243, -0.382191, 0.015123, 0.741462, -0.029087, -0.188524, -0.143968, 0.622959, 0.585466, 0.217048, 0.131784, -0.264165, -0.150599, 0.396729, 0.182216, 0.046109, 0.343987, 0.358452, -0.550326, -0.571071, 0.225331, -0.176080, -0.259694, 0.005871, 0.235155, -0.303555, -0.184017, 0.170009, -0.245224, 0.495978, -0.257807, -0.091483, 0.162784, 0.402263, -0.148525, 0.666930, -0.352403, 0.245967, 0.419048, 0.148667, 0.409112, 0.099979, 0.054782, -0.194006, 0.294531, -0.175805, 0.406857, -0.295523, 0.238044, -1.119809, 1.162102, 0.087648, -0.017739, 0.662508, 0.992298, -0.807085, -1.014340, -1.261172, -0.421136, -0.376982, 0.467803, -0.634549, 0.875652, 0.094606, -0.093747, 0.801028, 0.307061, 0.461111, 0.171934, 0.075545, 0.212660, -1.089249, -0.629719, -1.158783, -1.104194, -0.434373, -1.281788, -0.930421, -0.154904, -0.257479, 0.665346, 0.244736, 0.154406, 0.329375, 0.782657, 0.062364, -0.189660, 0.158597, -0.194297, -0.061237, -0.467254, -0.263920, -0.315296, -0.599154, -0.435480, -0.180211, 0.320596, -0.132050, 0.155895, 0.295876, 0.326595, -0.002418, -0.264398, 0.148107, -0.217699, 0.345853, -0.000222, -0.094844, 0.043429, 0.070242, 0.150202, 0.046800, 0.172399, 0.269417, 0.088583, 0.003946, 0.084841, -0.111807, -0.257498, -0.139578, 0.345665, 0.204845, 0.090773, -0.234942, -0.059022, -0.236783, -0.118024, -0.283627, -0.206411, -0.007301, 0.093927, -0.126757, 0.480768, 0.279084, -0.145913, 0.124300, -0.371424, 0.018382, -0.493812, -0.512106, 0.056996, 0.068912, 0.238860, 0.237574, 0.457404, -0.018430, -0.133467, 0.329113, -0.059156, -0.104460, -0.207298, -0.193878, -0.269604, -0.339653, -0.185565, -0.455196, 0.194301, -0.277481, 0.054091, 0.060758, 0.269900, 0.036218, -0.481947, -0.062282, -0.251802, -0.011917, 0.183715, -0.348336, 1.132105, 1.289700, 0.150647, -1.277099, -0.975971, -1.336326, -1.424120, 0.605675, 1.820398, 1.641178, -0.580279, 1.852188, -2.569293, 0.531092, -0.831510, 0.887345, -0.482925, -0.185470, -0.227224, -0.572232, -0.561533, -0.794683, 0.058741, -0.419066, 0.438426, -0.856812, -1.299831, -1.014361, 0.257354, -0.251539, 0.308023, 0.192310, 2.300736, 2.980986, 0.967588, 1.923484, 1.889901, 1.120552, 2.291019, 1.556446, 1.748399, 0.643074, 1.699336, 0.436342, 0.597744, 0.856185, 1.283479, 1.385607, 1.661498, 1.678114, 1.077250, 0.568735, 1.352258, 0.765035, 0.975398, 0.158638, -0.297437, 0.073524, 0.426967, 0.289491, -0.020762, -0.018248, -0.809496, 0.095627, 0.726872, -0.282219, 0.698865, 0.355253, 0.355311, -0.243923, -0.055516, -0.370320, -0.243661, -0.346962, -0.412841, 0.642359, 0.497948, -0.083594, -0.242355, 0.396304, 0.338724, -0.422759, -0.097968, 0.376691, 0.179276, 0.518234, 0.152614, -0.025475, -0.150147, 0.654703, 0.287591, 0.127826, 1.678073, 2.192859, 1.442856, 1.800181, 1.485421, 1.235356, 1.642390, 1.615513, 1.458223, 0.456852, 1.567869, 0.374273, 0.499910, 0.869552, 0.983250, 0.714266, 1.589622, 1.083525, 0.885045, 0.269357, 0.803149, 0.523422, 0.803714, 0.188956, -0.233202, -0.050999, 0.821885, 0.338653, 0.865410, 0.160158, -0.349188, -0.810002, -0.360949, 0.034286, -0.525977, 0.221096, 0.677908, 0.327441, 0.179202, -1.334213, 1.655996, -2.485912, 0.326431, 0.552733, -2.011090, -1.142708, -1.336656, -1.145977, -0.655834, -2.207257, -2.027971, -1.422700, -2.379524, -1.817224, -1.203577, -1.176576, -1.283012, -1.941172, -0.480625, -0.794463, -0.097288, -0.242729, -0.577247, -0.629592, -0.497010, -0.501124, -0.177121, -0.177865, -0.138962, 0.269642, -0.506354, -0.815312, -0.455580, -0.393873, -0.956557, -0.119072, -0.804320, 0.213817, -0.862304, -0.390900, -0.289550, -0.567909, -0.596015, 0.254481, -0.242953, 0.317583, 0.585515, -0.551688, -0.232778, 0.324019, 0.023753, 0.439795, 0.008857, -0.582166, -0.158208, 0.562774, 0.204604, -0.117671, 0.120796, -0.556777, 0.645374, 0.420157, 0.717360, 0.882063, 0.375280, -0.007821, -0.188678, -0.288118, -0.357561, -0.275259, -0.722780, -0.419098, -0.196585, -0.151276, -0.067459, -0.889154, -0.243757, 0.395208, -0.458685, -0.635291, 0.008848, -0.503318, -0.359061, -0.029563, -0.479188, -0.496306, 0.023631, 0.136720, -0.074386, 0.348164, -0.486882, -0.571228, -0.354770, -0.315666, -0.403943, -0.186311, -1.015389, -0.021811, -1.218837, -0.497977, -0.379627, -0.424847, -0.460175, 0.809937, -0.205254, 0.640676, 0.817163, -0.135407, 0.239666, -0.916789, 0.757651, 0.629152, 0.661165, 0.501365, 0.999921, 0.248253, 0.362609, -0.940949, -0.223242, -0.451982, 0.148860, -0.196224, 0.364603, -0.286184, -0.156508, -0.278239, 0.396152, 0.101256, 0.470626, -0.041617, 0.232226, -0.463909, 0.125704, -0.449419, -0.550221, 0.327380, -0.025719, -0.106830, -0.172880, -0.263324, 0.090884, 0.331372, 0.399231, -0.059558, 0.051131, 0.117942, -0.597105, 0.074793, 0.062920, 0.398196, -0.217580, 0.143993, 0.367036, 0.371262, 0.642475, 0.908036, 0.229396, 0.529910, 0.281308, 0.248203, 0.141116, -0.705949, -0.206945, 0.603958, 0.007959, 0.149151, 0.305589, 0.161607, -0.149184, -0.414882, -0.021348, 0.546209, -0.135039, -0.038364, 0.072625, -0.255475, 0.106818, -0.016141, 0.014287, 0.118331, 1.028257, -0.182496, 0.007261, 0.211691, 0.062831, 0.204455, 0.101335, -0.199675, -0.333300, -0.457165, 0.036952, 0.105288, -0.460261, -0.431434, -0.200512, -0.336824, 0.498767, 0.878011, -0.384771, -0.528125, -0.204869, 0.494518, -0.090928, -0.141099, -0.034190, 0.073701, -0.281060, 0.021113, -0.096863, 0.085922, 0.321132, -0.225920, 0.155043, -0.117465, 0.728265, 0.950803, -0.205715, 0.148465, 0.393781, 0.553403, -0.159933, -0.450680, -0.235446, 0.417258, 0.101326, -0.394626, 0.458111, -0.023979, -0.101631, 0.416720, 0.239715, 0.558456, 0.080224, 0.098511, 0.316274, -0.276811, 0.440751, 0.018764, 0.233493, 0.187508, -0.816705, 0.555459, 0.749684, -0.084485, 0.848305, 0.335725, 0.037487, 0.432156, -0.009215, 0.497974, -0.249269, -0.595876, 0.174424, -0.291819, 0.026824, 0.217335, 0.352215, 0.574809, -0.030431, 0.175305, -0.122806, 0.107493, 0.788792, -0.141862, 1.018229, -0.072514, 0.231729, -0.320858, -0.115732, 0.065300, 0.248887, -1.434477, -0.474605, -0.153624, 0.601005, -0.855021, -0.235831, -1.163115, -0.289679, -0.195979, 0.689820, 0.156115, 0.422701, -0.063070, 0.442235, 0.071171, 0.193267, 0.186305, 0.461689, -0.291678, -0.060777, -0.343693, 0.734290, 0.779957, 0.284891, 0.221924, 0.574387, 0.407402, -0.368587, 0.076186, 0.575845, 0.246801, 0.231917, -0.459048, -1.368095, 0.022545, 0.675679, 0.083656, -0.388327, -0.255247, -0.288023, -0.641232, 0.352625, 1.009585, -0.254041, 0.301438, -0.217201, -0.161757, 0.270942, 0.798852, -0.358063, -0.219255, 1.294698, 0.170276, 0.390482, -0.068750, 0.393332, -0.177804, -0.263293, 0.518933, 0.249301, -1.174841, -0.579495, 0.670613, 0.789991, -0.905810, -0.245072, -0.931358, -0.758045, 0.282789, -0.054533, -0.418183, 0.032138, -0.013697, 0.483158, -0.124141, -0.028368, -0.064035, 0.218176, 0.250475, 0.394831, 1.114673, -0.740933, -1.353703, -0.873715, -0.178718, -0.664323, -0.060135, 0.038407, 0.543814, 0.109231, 0.406607, 0.535029, 0.121112, 0.408918, -0.095399, 0.481029, 1.468528, 1.032956, 0.906520, 1.491924, 0.836677, 0.687054, 0.972509, 1.154331, 0.540132, 0.908053, -0.028413, 0.102954, 1.400699, 0.275110, 0.077792, 0.228308, -0.258718, -0.146540, -0.066269, 0.461139, 0.235075, 0.287687, 0.128371, -0.097363, 0.501911, -0.524643, 0.170884, -0.004005, -0.279294, 0.681860, 0.037817, 0.066210, -0.207069, 0.100387, -0.377311, 0.320453, 0.350886, 0.284576, 0.676018, 0.369335, 0.021751, -0.389511, 1.365808, 0.535789, -0.173667, -0.418466, -0.263188, -0.534449, -0.806040, -0.605859, 0.268430, 0.513867, 0.075234, -0.051138, -0.203096, -0.336028, 0.124705, -0.232211, -0.265020, -0.487346, -0.230721, -0.318793, -0.069654, -0.277076, -0.168018, 0.006393, 0.170308, 0.792830, 0.443529, 0.301976, 0.064211, 0.343293, 1.966653, 0.381016, 0.175143, 0.341948, -0.189682, 0.059321, 0.315887, 0.509829, 0.114857, 0.112261, 0.033382, -0.216518, 0.370139, -0.318488, 0.138529, 0.070052, -0.155871, 0.543298, 0.302189, -0.210042, -0.284692, 0.081890, -0.086966, -0.094868, 0.590658, 0.483924, 0.208747, 0.286943, 0.253643, -0.386157, 0.338968, 0.014469, 0.194259, 0.046819, 0.896316, 0.505119, 1.208850, 1.090129, 0.292616, 0.118774, 0.279305, 0.491093, -0.077423, 0.334401, 0.444867, 0.768584, 0.395301, 0.486782, -0.048266, -0.386211, -0.406934, -0.919211, -0.986450, -1.064740, -1.025273, -1.132355, -1.210525, -1.224330, -0.643509, -0.168979, 0.108833, -0.257761, -0.407708, -0.181331, -0.350126, 0.107914, -0.504180, -0.033852, 0.295328, 0.058583, -0.088171, -0.002938, 0.082941, 0.472535, -0.432089, 0.244789, -0.290062, 0.403489, -0.133834, -0.550035, 0.017319, 0.237179, 0.295964, -0.165878, -0.244595, 0.090199, -0.214724, -0.006330, -0.151915, 0.153100, -0.008488, -0.654951, -0.363084, -0.018490, -0.054167, 0.121181, 0.336524, 0.105225, 0.002442, 0.032344, 0.160464, 0.074841, 0.134876, -0.143828, -0.303706, 0.231263, 0.189943, 0.061988, -0.260662, -0.204698, -0.013157, -0.054316, -0.027486, 0.187530, 0.001430, -0.019307, 0.009803, -0.232677, 0.281068, 0.166129, 0.441354, -0.011692, -0.188895, -0.117186, -0.262507, 0.192981, -0.194883, 0.042347, 0.279063, 0.181385, -0.123200, -0.030892, 0.175865, 0.669653, -0.242595, 0.300226, 0.023124, 0.414869, 0.080545, -0.373542, 0.157918, 0.183957, 0.162381, 0.002668, -0.060223, 0.207603, -0.150191, 0.099936, 0.097836, -0.501803, 0.760118, 0.113919, -0.477205, 0.681609, -1.114227, -1.367398, -0.332759, 0.107538, 0.372721, 0.729188, -0.651973, 0.395384, -0.328849, -1.683499, 0.540162, -1.417609, -1.187451, -0.985951, 0.196782, -0.817503, 0.691820, -0.316153, 0.565803, -0.485006, -0.171871, -0.513324, 0.262421, -0.921266, -0.435145, -0.386499, -0.389799, -0.102573, -0.646582, -0.197810, -0.477739, -0.396472, -0.324911, -0.207199, -0.506456, -0.159713, 0.191238, -0.585929, -0.176559, 0.173634, -0.063214, 0.323639, -0.009269, 0.537626, -0.520019, 0.013893, -0.043593, -0.096908, -0.362376, 0.098982, 0.126106, -0.316613, -0.163485, -0.305103, -0.660852, 0.051541, -0.075934, 0.277707, 0.221054, 0.213841, -0.428908, -0.241433, -0.040445, -0.246684, -0.054582, 0.010292, 0.126398, 0.048728, -0.072744, 0.411540, 0.309410, 0.040288, 0.040828, -0.336308, -0.290395, 0.108398, 0.045606, -0.477134, -0.051572, -0.244436, -0.193008, 0.170622, -0.016708, 0.162519, -0.251285, -0.453958, -0.478296, 0.166699, -0.612952, -0.239862, -0.506538, -0.399796, -0.440334, -0.036712, -0.364885, -0.116452, 0.204535, -0.301844, -0.069321, -0.023518, 0.105429, 0.338342, 0.235367, 0.210917, -0.775361, 0.300221, 0.023908, 0.416977, -0.231606, 0.204612, -0.018548, -0.077359, -0.013056, -0.007370, -0.704058, 0.912724, 0.313490, 0.009445, -0.846156, -0.632757, 0.034573, -0.394506, -0.256281, 0.884574, 0.174259, 0.415541, -1.542083, 1.354617, -2.152381, 0.810932, 0.743883, -2.289921, -1.193527, -1.761937, -0.964426, -0.554941, -2.682028, -2.162985, -1.623373, -2.716193, -1.823914, -1.453760, -0.844053, -1.426090, -1.917040, -0.532396, -0.846763, -0.291961, -0.795027, -0.791665, -0.213201, -0.620963, -0.808831, -0.423121, 1.186999, -0.065208, 0.775385, -0.464307, -0.224440, 0.340799, -0.312865, 0.104511, 0.348175, -0.587837, -0.268680, 0.577328, 0.106280, -0.378486, -0.280070, -0.232456, -1.453116, -0.143905, -0.031887, -0.915334, -0.202483, -0.108473, 0.026522, 0.212772, 0.142050, -0.169683, 0.195972, -0.034450, 0.595392, 0.334143, -0.561094, -0.586605, -0.809111, -0.085400, 0.506664, -0.948276, -0.273300, 0.596194, 0.032291, 0.051072, 0.552100, 0.662706, 0.418400, 0.198986, -0.466434, -0.727697, -0.250415, -0.396404, -0.110641, 0.705085, 0.393477, -0.600285, -0.708032, -0.027722, -1.037672, -0.281414, -0.247910, -0.177296, -0.407468, -0.727641, 0.337138, 0.025767, 0.435369, 0.232420, -0.028265, 0.787026, -0.702657, 0.102823, 0.077914, -0.953784, -0.341370, 0.383904, 0.225510, -0.141094, -0.529856, 0.146657, -1.001878, 0.235505, -0.015121, -0.477830, -0.147146, 1.027454, 1.793040, 2.604588, -1.152449, -1.494674, -1.071247, -2.013246, -2.151083, -1.480069, 0.843599, 0.960269, 2.689665, -0.326702, 1.866174, -0.048409, 0.417082, -1.111479, -0.940719, -0.472641, -1.050891, -1.923108, -2.124958, -1.768155, -0.044364, 1.573400, 0.695319, -0.986184, -0.542228, -0.193808, -0.195924, 0.048957, 0.907792, 1.691146, 2.466322, 1.368760, 1.082261, 2.552133, 2.853567, 2.439398, 0.063742, 0.816583, 1.811834, 2.376269, 2.075443, 2.394848, -0.502456, 1.543801, 2.684524, 2.138833, 2.052766, 1.643482, 1.997185, 1.786175, 3.051451, 0.873652, 3.663638, 0.496608, 1.036681, 0.972641, -0.426067, -0.009375, 1.572429, -1.776515, -3.226478, -0.966267, 0.734574, 0.043750, 0.984806, -0.869413, 0.139425, 0.420708, -0.304068, -0.007931, 0.294156, 0.144757, 0.920438, -1.418635, -0.849269, -0.509459, -1.326341, -0.343290, 0.046857, 1.236090, 1.160903, 1.890746, 1.957455, 0.180285, 0.645279, -1.272779, -0.266013, 0.485642, 0.504154, 1.189620, 3.393312, 2.113286, 1.049245, 2.881969, 3.660812, 1.324504, 0.204156, 0.786505, 0.531524, 1.416139, 0.799077, 2.135951, -0.330386, 0.554728, 2.024656, 1.814868, 1.337151, 1.090746, 2.603758, 0.934650, 1.261877, -0.068082, 2.367436, 1.708205, 1.591260, 0.429292, -0.217478, -0.442030, 0.351057, 0.398817, 0.082222, 0.681520, 0.294887, 0.202305, 0.204305, -0.041202, -0.345688, -0.432651, -0.599099, 0.361127, -0.480085, -0.641900, -0.202263, -0.025824, -0.427854, 0.279569, -0.239333, -0.252277, -0.148462, -0.481020, 0.060684, -0.279440, -0.623452, -0.453586, -0.058243, -0.465967, -0.549334, -0.269880, -0.529132, 0.197016, 0.182849, -0.063829, -0.019937, -0.282419, -0.919953, -0.531022, 0.267048, 0.594175, -0.119594, -0.198198, 0.223909, -1.182711, -0.140497, -0.129360, 0.161697, -0.223724, 0.273270, -0.271138, 0.291318, -0.881499, -0.764336, 0.151558, 0.019918, 0.060464, -0.419258, -0.620303, 0.213326, -0.214187, -0.155092, -0.040012, 0.026952, -0.017387, -0.079866, -0.276694, 0.038353, -0.102899, 1.313977, 1.119591, 0.042390, 0.111016, 0.269565, -0.188398, -0.847552, -0.588436, -0.341150, 0.154499, 0.303000, 1.248763, 0.603735, -0.203824, 0.048391, -0.394507, -0.311982, 0.393306, -0.072520, 0.285312, 0.650696, -0.354293, -0.403910, 0.418032, 0.544264, 0.133333, -0.204176, -0.517479, -0.907216, -0.511737, 0.359154, 0.443014, 0.139172, -0.426642, -0.255885, -1.347060, -0.281700, -0.375822, -0.291698, -0.324272, 0.321656, -0.001204, 0.433487, -0.903992, -0.287211, -0.036369, 0.019110, 0.119843, -0.172802, -0.627925, -0.009272, -0.278541, -0.530361, -0.408919, 0.356549, 0.621595, 0.698901, 0.309635, 0.094355, 0.393777, -0.161988, 0.758960, 0.439778, -0.678050, 0.772755, 1.032858, 0.018245, 1.144341, 1.257913, 0.814981, 0.390934, -0.043500, 0.820634, -0.509865, -0.388802, 0.022590, -0.703912, 0.194818, -0.882276, 0.594131, 1.073341, 0.003249, 0.109746, -0.207690, -0.010103, -0.420202, 0.071605, -0.677230, 0.075776, -0.214481, -0.268868, 0.003790, -0.071384, 0.330263, -0.097930, 0.491934, 0.760664, 0.019816, -0.200680, -0.211802, -0.229281, -0.032594, 0.057612, 0.686681, -0.309078, -0.100096, -0.036159, 0.006987, -0.329149, 0.003282, -0.202071, 0.031073, 0.346803, 0.013593, -0.367024, -0.119478, -0.348390, -0.034697, 0.078074, -0.510445, -0.237864, 0.285612, -0.238505, -0.150497, 0.050726, 0.448330, 0.751651, -0.118783, -0.090082, -0.005608, -0.103969, 0.086608, 0.051754, 0.173720, -0.119175, -0.160752, -0.495902, -0.116490, -0.046547, -0.402394, 0.192418, 0.199607, 0.102471, -0.425156, 0.285303, -0.088890, 0.107414, -0.413374, 0.165561, 0.000240, -0.088736, 0.129409, -0.373293, 0.474346, -0.091596, 0.583772, 0.947192, 0.064231, -0.191189, -0.388393, -0.117704, -0.314300, -0.275321, 0.210004, -0.007445, -0.040536, 0.285381, -0.143974, -0.373594, -0.030377, -0.335544, 0.193230, 0.557523, 0.233032, 0.591828, -1.084439, -1.592566, -0.605824, 0.488531, -0.047595, -0.114697, 0.096138, 0.143700, -0.077034, 0.313197, 0.480647, 0.232036, 0.244625, -0.189054, 0.159288, 0.807556, 0.960955, 1.112822, 1.732167, 1.254008, 0.889786, 0.970532, 1.434675, 0.484308, 0.885590, 0.467158, 0.009622, 1.290611, 0.395462, 0.023924, 0.416586, -0.083801, 0.311222, 0.250869, 0.406984, 0.264225, 0.230557, -0.403496, -0.093271, 0.902313, -0.366414, 0.505204, 0.668705, -0.337885, -0.180022, -0.088164, 0.221871, -0.119343, -0.280773, 0.204973, -0.549484, 0.066712, 0.069661, -0.252441, 0.513858, 0.657656, 0.707111, -1.893219, -0.380641, -0.341921, 0.219630, 0.458590, 0.633177, 0.321890, 0.792542, 0.017554, 0.028320, 0.205858, -0.384948, 0.498133, 0.468835, -0.381192, 1.028317, 0.470562, -0.030230, 0.259859, 0.262072, 0.021877, 0.123270, -0.303345, -0.373979, -0.049948, -0.174435, -0.636039, -0.263268, -0.152636, 0.431928, 2.062190, 0.488943, -0.022451, 0.334433, 0.093300, 0.432803, 0.288072, 0.396017, 0.284287, 0.265060, -0.473595, 0.133084, 1.143080, -0.194523, 0.285906, 0.773301, -0.165451, -0.168599, 0.215136, 0.574044, -0.379199, -0.466463, 0.095419, -0.599257, 0.415444, 0.599025, -0.275898, 0.371177, 0.762210, -0.788189, 1.178710, -0.303306, -0.970115, -0.157168, -0.140672, 0.135656, 1.172361, 1.631896, 0.818962, -0.212846, 0.078921, 0.565789, 0.126243, -0.675248, -0.868097, -0.951422, -0.406925, 1.026929, -0.530960, -0.837461, -0.519038, -0.914397, -0.077185, -0.433963, -0.169528, -0.313597, 0.357451, -0.689030, 0.191374, -0.372273, -0.555728, -0.542741, -0.540001, -0.156239, 0.160149, -0.032006, 0.086823, -0.566424, 0.370801, -0.278053, 0.281915, 0.638578, -0.254950, 0.307418, -0.064569, 0.881996, 0.100602, 0.751479, 0.524161, -0.789511, 0.040730, -0.848566, -0.324728, 0.260619, 0.538661, 0.121863, -1.021271, 0.473488, -0.429013, 0.121924, 0.112286, 0.166877, 0.094332, 0.403740, 0.581913, -0.027448, -0.743032, -1.035493, 0.352446, -0.320650, -0.544900, -0.726776, 0.777379, 1.337319, 0.204411, -0.064773, -0.053153, -0.013810, -0.220709, -0.671771, 0.133295, 0.226051, 0.199552, -0.733168, -0.664699, 0.046507, 0.292264, 0.480145, -0.621298, -0.299994, -0.485880, -0.563129, -0.285074, 0.196075, 0.239958, -0.015868, 0.583427, -0.391231, 0.378064, -0.692800, 0.607787, 0.091371, 0.581686, 0.227389, 0.010619, 0.524736, -0.405780, 0.465595, 0.829716, -0.550712, 0.129760, -0.989560, -0.241819, 0.229460, 0.482722, 0.121657, -0.050185, 0.264810, -0.400261, -0.528053, -0.065905, -0.340390, 0.266196, 0.703288, 0.873957, 0.574277, 0.366949, 0.685650, 0.434870, 0.904743, 0.272723, -0.739908, 0.746191, 0.789205, 0.086639, 1.208990, 0.984316, -0.003056, 0.120779, 0.165965, 0.872111, -0.637034, -0.173367, 0.415481, -0.684541, 0.135791, -0.359853, 0.579905, 0.797873, 0.132510, 0.217570, -0.210339, -0.193861, -0.059319, 0.700772, 0.019747, -0.295006, -0.160339, 0.332154, -0.097367, -0.186039, 0.075838, -0.039082, -0.286450, 0.338051, -0.109879, -0.159129, 0.000872, -0.518967, -0.038593, -0.022196, 0.000131, -0.216888, -0.108195, 0.023375, 0.067978, 0.611537, 0.611262, 0.321232, -0.613468, 0.759441, -0.055408, -0.246416, -0.293697, -0.965434, -0.534311, -0.256741, -0.350393, 0.445009, 0.298939, -0.331116, 0.143623, 0.314893, 0.074657, 0.766982, 0.258353, 0.176304, 0.172275, 0.036035, 0.177129, -0.009838, 0.236875, -0.176980, -0.052117, 0.334039, 0.067630, 0.134529, -0.515364, -0.056856, 0.632318, 0.598380, -0.277591, -0.018564, 0.227805, 1.306326, 0.316947, -0.100676, 0.009943, 0.354224, 0.022187, -0.055092, 0.217515, 0.039722, -0.106788, 0.725811, -0.055233, -0.038033, 0.197422, -0.382152, 0.031162, 0.073258, -0.162208, -0.118566, -0.313474, 0.257095, -0.020013, 0.229878, 0.335518, 0.312236, -0.025581, -0.861866, -0.089274, 1.104430, 0.864001, 0.561440, 0.307369, -0.059455, -0.461125, -0.623742, -0.565285, -0.758448, -1.991759, 0.559850, -0.214235, -1.189044, 0.201486, -0.577319, -0.595031, -0.144170, 0.462172, 1.238489, 0.494207, 1.231292, 1.432988, 1.087909, 0.803503, 0.570643, 1.287984, 0.762185, -0.142678, -0.286991, -0.733680, -0.533807, -0.484809, -0.499897, -0.124271, 0.943712, 0.654821, -0.449625, -0.384595, 0.313920, 0.975393, -0.375666, 0.131457, 0.187297, 0.138663, -0.569765, 0.252035, 0.126612, -0.130005, -0.769877, -0.316211, 0.339211, 0.129904, 0.525353, 0.002047, -0.420222, 0.369198, 0.395178, 0.291253, 0.035554, -0.098322, 0.135380, 0.049017, 0.000962, -0.189202, -0.277523, -0.026182, 0.007139, -0.286835, 0.341485, 0.554720, 0.125375, -0.288076, -0.018065, 0.169222, 0.317969, -0.245367, 0.226678, -0.128753, 0.105691, -0.267468, -0.291229, 0.741357, -0.349392, -0.115386, -0.209454, -0.111322, -0.247951, -0.493342, -0.389560, -0.587524, -0.379562, -0.160743, -0.392356, -0.063386, 0.744151, 0.369291, -0.285288, -0.292507, 0.321702, 1.005616, -0.356625, 0.226062, 0.011904, -0.205266, -0.374571, 0.247564, -0.151297, -0.157841, -0.729117, -0.229678, 0.187725, 0.512409, 0.664783, -0.196776, -0.220815, 0.291335, -0.222763, 0.884979, 0.156244, -0.012825, -0.676606, -0.481208, 0.028482, -0.490893, -0.048003, 0.703981, 0.287873, 0.336427, -1.600588, 1.505642, -2.488156, 0.636198, 0.944899, -1.926748, -1.316265, -1.523257, -1.012481, -0.832691, -2.439516, -2.156106, -1.231655, -2.833559, -1.992478, -1.279172, -0.681295, -1.723385, -1.871876, -0.546706, -0.663768, 0.020087, -0.272436, -0.596423, 0.269936, -0.686904, -0.224704, -0.524808, -0.380378, 0.222137, -0.392933, -0.922169, -0.063948, -0.506452, -0.425694, -0.066716, -0.077387, -0.780736, -0.255527, -0.619519, -0.085588, -0.365346, -0.000704, 0.023330, -0.161221, -0.636787, -0.441092, -0.365503, -0.136735, -0.124720, -0.213727, 0.103913, 0.464722, 0.417962, 0.522612, 0.153973, -0.280829, -0.035550, 0.079891, -0.324638, -0.109133, 0.089286, -0.028087, 0.019257, -0.121906, 0.061546, -0.382151, -0.047581, 0.037817, -0.159686, -0.569905, 0.561783, 0.251883, 0.188257, -0.028779, 0.043451, 0.369273, -0.300160, -0.015959, -0.587992, -0.430103, 0.007569, -0.486574, -0.410548, 0.730584, -0.479056, -0.181762, -0.516144, -0.135714, 0.624385, -0.401544, -0.752658, -0.018674, -0.247718, -0.344916, -0.004872, 0.130516, -0.736341, -0.297181, -0.362830, -0.203711, -0.395665, -0.203809, -0.015861, -0.239308, -0.221164, -0.285055, -0.446218, -0.159024, 0.154869, 1.511624, 1.081125, 0.183768, -1.078933, 0.024558, -0.271693, -0.583751, 1.119016, 0.093019, -0.329914, 1.098409, -0.294490, -0.052274, -1.108219, -1.318328, -0.000687, 0.533085, 0.247728, 0.239752, -0.542731, -1.195211, 0.309714, 0.163219, 0.563573, 0.927961, -0.306756, 0.110716, 0.243771, -0.421725, -0.039170, -0.143907, -0.183738, 0.125862, -0.328209, 1.193928, -0.006990, -0.724768, 0.097484, -0.207687, 0.208115, 0.254866, -0.244806, -0.888948, 0.051229, -0.002816, 0.166702, 0.276865, -0.189112, 0.504108, 0.423995, 0.203727, 0.243726, 0.217701, 0.024321, 0.116556, -0.548639, 0.618133, 1.040039, 0.381217, 0.144526, 0.143881, 0.420740, -0.060179, -0.065472, -0.168422, -0.331847, -0.271538, -0.205877, -0.144538, -0.018455, -0.002204, -0.020122, -0.003737, 0.358101, -0.160355, 0.088837, -0.342308, -0.186834, 0.245002, 0.458167, 0.258742, 0.328433, -0.285155, -0.258750, 0.105429, -0.497045, 0.084366, 0.419384, 0.053822, -0.276726, -0.399436, -0.367481, -0.241963, -0.583418, 0.351079, -0.453980, -0.496037, -0.009903, -0.148810, -0.093011, 0.036236, -0.297242, -0.272526, 0.040539, -0.599026, 0.230842, 0.119288, -0.395794, 0.256637, 0.327132, -0.164260, -0.015656, -0.464658, -0.318876, 0.116524, -0.668989, 0.544240, 0.426988, 0.481174, -0.845477, 0.436373, 0.089624, -0.518878, 0.305171, 0.585694, 0.050729, -0.154287, -1.236575, -1.220295, -0.888306, -0.516786, 0.323670, -0.494229, 0.042795, 0.625304, 0.305972, 0.350015, 1.021275, 0.521472, 0.824575, 0.252877, 1.093329, 1.244848, -0.055586, -0.245634, -0.664028, 0.847402, -0.223208, -0.349150, -0.371707, -0.758896, -0.500586, -0.436877, -0.284427, -0.390047, -0.220604, -0.446440, -0.360994, -0.104270, 0.090552, -0.165113, -0.219589, 0.017198, -0.057323, 0.086514, -0.161977, -0.044631, -0.439920, 0.004806, 0.278971, -0.006569, 0.119668, -0.183418, -0.201357, -0.092447, -0.201891, -0.195030, -0.044263, -0.285829, -0.059204, -0.239594, -0.419716, -0.292846, 0.059310, 0.260733, 0.257706, -0.365823, 0.327879, 0.378881, -0.345028, -0.406590, 0.040328, 0.016098, 0.116365, 0.029770, 0.270506, 0.044197, -0.235833, -0.113313, 0.252769, -0.036792, -0.108495, 0.014651, 0.218687, -0.279584, 0.171767, 0.194507, -0.547511, 0.107980, -0.436032, -0.641964, -0.330735, -0.171715, -0.349080, -0.300898, -0.245967, -0.195698, -0.427708, -0.260652, 0.146761, -0.095256, -0.518998, -0.109300, -0.366468, -0.031991, -0.373914, -0.229881, -0.597385, -0.146076, 0.074126, 0.125465, -0.066062, -0.333335, 0.059473, -0.428121, -0.190642, -0.111818, 0.166847, -0.061062, -0.411622, 0.668271, -0.926461, -0.593541, -0.523663, 0.143675, 0.250855, -0.182346, -0.036278, 0.842573, 0.902807, 0.217265, 1.001709, 0.918331, 0.203552, 0.720988, 0.909550, 0.913916, 0.139258, 0.535482, 0.548032, 0.764451, 0.442186, 0.191345, 0.247282, -0.281904, 0.098551, -0.118166, 0.264441, -0.057448, -0.116653, -0.500797, -0.515523, 0.044280, -0.295520, -0.739611, -1.083838, -0.095548, -0.147425, -0.065826, -0.317171, -0.543136, 0.194651, -0.086186, -0.090826, -0.062216, 1.025553, -0.466020, 0.435298, 0.111267, -0.182764, -0.459087, -0.362694, 0.564905, 0.792409, -0.008411, 0.045433, 0.272301, 0.725086, 0.269109, 0.339922, -0.254867, 0.282663, -0.233401, 0.092754, -0.100800, 0.149797, -0.205571, 0.519631, 0.271971, -0.542298, -0.031230, 0.602457, 0.360575, -0.291326, -0.449697, -0.338403, -0.257322, -0.368283, -0.456922, -0.062025, 0.285367, 0.249772, -0.203843, 0.423912, 0.184076, 0.140810, 1.081786, -0.195747, -0.202880, -0.055755, -0.297132, -0.263236, 0.593976, -0.213860, -0.296010, -0.968118, -0.059536, -0.219942, 0.018110, -0.360428, -0.756585, 0.022298, -0.094598, -0.412687, -0.019898, 1.678520, -0.294910, 0.400786, -0.108846, -0.178456, -0.387471, 0.013706, 0.546377, 1.025852, -0.150823, -0.481622, 0.313202, 1.169240, 0.355474, 0.397361, -0.846590, 0.821722, 1.204555, 1.133449, 0.750311, 0.995130, 0.296765, 1.204554, -1.065053, -0.067036, -1.277596, -1.217237, 0.277473, 0.007653, -0.611355, -0.323733, -0.055160, -0.446626, 0.176082, 0.413444, 0.015179, 0.123178, -0.756423, 0.345501, 0.081235, -0.359628, -0.081220, -0.292001, -0.408337, -0.111079, 0.042825, 0.050745, 0.370808, -0.172345, -0.087059, -0.224114, -0.521138, 0.142922, 0.051910, -0.465798, -0.043164, 0.405057, 0.082943, 0.337860, 0.045047, 0.341357, 0.322606, 0.150903, -0.131360, 0.009910, -0.738701, 0.091858, -0.583612, -0.049532, -0.533350, -0.467674, -0.040434, -0.216325, 0.286642, 0.187479, -0.002291, -0.209639, -0.033821, -0.034518, -0.042244, 0.213045, 0.052832, -0.288414, -0.204440, -0.122593, -0.031574, -0.087196, -0.282964, 0.186320, 0.000720, -0.153898, -0.088778, -0.209239, -0.191781, 0.448643, 0.379037, -0.184542, 0.125889, -0.276997, -0.007989, 0.068356, 0.126461, -0.071439, -0.126425, -0.381180, -0.530987, -0.115059, 0.416303, -0.170854, -0.233704, -0.146627, -0.238953, -0.249500, -0.053962, -0.464148, 0.002677, -0.226542, 0.033409, -0.310711, -0.103620, 0.034791, -0.234306, 0.070165, -0.424448, -0.194626, -0.538812, 0.097181, -0.318344, -0.274020, -0.441589, -0.406635, -0.101088, -0.269425, -0.000966, 0.412616, -0.910785, 0.612378, 1.170686, 1.182558, 0.953182, 1.052824, 0.262039, 1.072334, -1.185737, -0.150584, -1.417090, -1.127130, 0.377681, -0.159023, -0.295576, -0.216212, -0.124774, -0.593598, 0.404964, 0.176279, -0.104333, -0.194604, -0.608392, 0.443995, 0.384611, -0.008612, -0.041483, -0.555208, -1.051046, 0.072873, 0.253764, 0.574970, -0.325146, -0.084354, 0.235355, -0.768374, -0.309754, 0.969784, -0.026420, -0.320002, -0.432101, 0.723776, 0.383782, 0.527879, 0.100615, 0.542169, 0.476125, -0.542424, -0.134650, 0.088200, -0.529428, 0.378881, -0.199396, 0.093934, 0.668378, -0.231022, -0.072388, 0.142907, -0.586178, 0.104296, 0.274013, -0.001200, -0.387705, -0.086543, 0.613434, -0.112829, 0.340986, 0.368420, 0.072760, -0.441367, -0.174599, 0.526968, -0.214192, -0.055072, -0.097568, -0.352422, -0.117590, -0.245763, 0.117757, 0.291243, -0.019484, -0.241249, -0.514597, -0.595695, -0.303924, 0.414140, -0.024709, 0.424442, 0.242052, -0.164340, -0.375617, 0.264768, -0.602080, -0.301103, 0.195265, -0.668667, -0.537622, 0.505728, -0.265347, -0.137186, 0.011479, 0.367030, 0.154225, 0.315702, -0.042767, -0.115273, -0.022419, -0.537400, -0.084477, -0.263675, -0.499930, 0.321056, 0.221932, 0.371482, 0.943430, -0.502993, -0.223160, -0.012851, -0.371150, -0.394243, 0.280228, 0.576865, 0.644732, 0.587990, 0.516218, 0.682019, -0.497010, 1.184160, -0.140817, -0.239015, 0.276449, -0.670547, 0.564915, 0.641117, 0.317595, 0.848865, 0.333606, 0.744851, -0.240170, -0.247454, -0.200844, -0.402122, -0.909992, -0.058891, -0.148437, -0.224447, 0.296034, 0.433225, 0.910426, 0.111356, 0.348363, 0.121681, -0.218613, 0.167933, -0.255747, 0.149178, -0.354111, 0.561527, 0.210402, -0.361496, -0.490805, -0.076736, -0.048555, -0.191958, 0.281353, -0.196161, -0.107112, -0.243290, -0.283928, -0.001551, -0.138737, 0.131183, 0.643781, 0.501208, 0.214133, 0.248069, 0.274928, 0.241262, 0.620323, 0.150871, -0.445051, -0.249836, -0.169221, 0.177404, 0.148069, -0.063824, 0.118708, 0.715441, 0.052676, -0.036016, -0.019144, -0.080980, -0.041030, 0.123724, 0.013994, 0.001667, 0.113030, 0.106570, -0.210183, 0.287429, -0.015102, 0.098478, 0.295649, 0.326319, -0.209577, -0.214774, 0.024851, 0.093177, 0.194848, 0.540325, 1.107382, 0.139752, -0.425788, 0.196473, 0.056348, 0.378861, -0.439068, 1.129288, 0.018010, -0.105888, -0.477581, -0.020673, 0.022258, -0.197334, 0.299845, -0.011539, 0.265507, 0.103844, -0.264273, -0.089831, -0.212474, -0.275384, 0.253586, 0.065887, 0.103951, 0.116576, -0.017316, 0.104259, 0.470092, -0.549093, 0.799921, 0.091373, -0.123386, 0.449042, 0.825376, 0.631699, 1.263165, 1.259384, 0.614168, -0.177422, 0.126527, 0.446468, -0.048398, 0.282930, 0.593359, 0.465217, 0.103607, 0.139716, -0.084279, -0.283166, -0.540281, -0.934272, -0.997439, -0.987853, -1.132223, -1.299520, -1.014299, -1.350526, -0.826166, -0.213383, -0.183300, -0.059530, -0.238387, -0.134114, -0.516152, -0.358053, -0.191190, 0.302431, -0.018440, 0.271017, -0.199250, 0.064443, 0.177143, -0.033878, -0.122162, -0.313097, 0.333953, 0.189295, 0.132722, 0.211252, 0.156259, -0.155772, -0.342132, -0.200490, -0.157054, -0.172205, -0.502430, -0.079235, 0.046163, 0.455712, -0.262403, -0.377708, -0.018181, 0.042878, -0.162590, 0.085817, 0.016592, -0.005920, 0.215700, 0.468716, 0.225882, -0.209507, -0.365188, 0.242106, 0.288118, -0.294089, -0.816333, -0.680164, 0.258338, 0.678858, 0.266022, 0.133020, 0.261087, 0.192632, 0.217933, 0.446909, 0.027477, 0.129283, -0.378219, 0.078300, 0.122899, -0.124237, -0.189818, 0.079661, -0.234748, -0.218308, 0.009546, -0.078579, 0.186115, 0.258295, -0.041784, 0.434294, 0.109137, 0.008283, 0.202812, -0.393257, 0.506771, 0.276109, 0.341199, 0.368225, -0.077499, 0.084589, -0.241674, -0.167971, -0.085029, -0.277084, -0.430339, 0.050620, 0.180977, 0.094247, -0.139252, 0.315026, 0.847382, -0.631798, -0.935485, -0.514984, -0.256687, -0.392831, -0.575130, 0.304989, 0.276484, 0.129728, 0.518034, 0.351400, 0.275764, 0.396430, -0.311712, 0.181364, 0.883895, 1.129783, 0.600309, 1.022908, 0.995685, 0.684875, 1.212735, 1.419968, 0.660731, 0.797603, 0.517155, 0.000037, 0.466937, 0.216097, -0.318580, -0.010042, -0.423045, -0.223395, -0.047373, 0.618177, -0.538589, 0.278424, 0.356830, -0.135172, 0.103978, -0.692004, -0.222921, -0.752001, 0.467772, 0.014932, -0.095652, 0.185825, 0.227699, -0.176145, 0.658607, -0.150190, 0.515971, 0.381645, 0.250090, -0.165721, 0.110253, -0.008993, 0.056028, 0.003467, 0.240915, 0.344364, 0.140075, 0.002234, -0.157144, -0.177173, 0.441718, 0.109917, -0.141957, -0.054382, -0.148978, -0.357307, -0.167970, -0.246390, -0.758107, -0.454209, 0.669781, 0.419680, -0.310581, 0.059529, 0.083025, 0.333289, 0.172118, 0.670132, -0.190898, -0.411287, 0.346450, 0.325401, 0.917750, 0.408879, -0.507904, 0.122315, -0.116225, -0.073834, -0.262402, 0.871225, -0.700428, 0.614897, 0.518581, -0.325910, 0.172009, -0.754861, -0.254018, -0.627647, 0.615774, 0.140729, 0.066931, 0.401792, 0.576527, -0.178960, 0.635917, -0.124282, 0.268456, 0.360539, 0.125452, -0.273605, -0.126009, 0.123428, -3.246899, 4.546455, -3.061863, 0.451586, 1.167254, -0.955249, 1.702645, -0.283025, 0.321551, 1.163821, -0.877435, 2.197484, -0.107037, 0.589772, 0.833489, -1.257699, 0.720113, -2.189247, -0.535343, -1.406615, -1.105360, 1.320940, -0.715433, 0.670772, -0.476099, -0.483908, 0.452051, -0.749032, 1.148697, -0.180371, 1.672436, 3.182095, 2.653413, 1.931616, 1.265736, 1.062574, 0.705637, 0.753004, -0.090068, 0.395622, 1.913864, 0.892635, 1.164600, 0.797320, 0.090272, -0.462866, -0.123172, 1.124325, 0.618615, 0.044035, -0.084861, 1.127440, -0.067933, 0.835359, 0.146331, 0.277990, 0.329430, 0.978876, 0.871119, 0.140251, 0.323100, 0.818814, -0.190534, 0.638532, -0.165388, -0.120468, -0.124310, -0.999084, -0.578109, -0.334414, 0.227990, -0.114431, -0.349526, -0.562513, 0.094415, -0.165558, 0.455518, 0.484944, 0.225222, 0.139185, 0.244967, 0.583248, -0.193305, 0.175565, 0.024280, 0.134288, -0.261852, -0.272275, -0.328241, -0.022848, 0.772049, 2.115083, 1.626166, 0.943983, 0.949568, 0.944255, 1.159048, 0.870204, 0.424768, 0.697852, 1.761934, 0.712110, 0.430728, 0.324641, -0.297920, -1.019703, -0.653555, 0.513079, 0.409050, -0.384109, 0.567753, 0.318530, 0.247150, 0.220974, -0.440899, 0.562120, 0.003979, 0.834258, 0.531701, -0.943865, 0.672277, -0.526164, -0.388495, -0.861047, 0.318453, 0.539143, -0.439720, -0.291811, 1.174752, 0.602711, -0.223985, 0.921981, 0.966260, 0.166985, 0.974469, 0.932745, 0.959090, -0.000737, -0.135629, -0.402230, 0.446776, 0.323877, 0.067296, 0.071266, -0.554229, 0.055006, -0.609959, -0.128762, -0.292576, -0.250121, -0.600795, -0.417798, -0.417323, -0.638042, 0.064099, -0.071461, -0.329645, -0.174298, -0.451930, 0.115495, -0.587188, -0.034963, 0.065957, -0.263154, -0.466022, -0.281899, -0.666600, -0.002863, 0.262469, -0.446523, 0.037757, 0.369157, 0.124206, -0.600318, 0.070651, 0.042260, -0.489845, -0.435465, -0.601777, -0.136163, -0.126852, 0.459607, 0.187134, -0.122970, -0.765834, -0.384583, 0.317626, 0.301200, 0.257578, 0.175609, -0.177860, -0.272799, -0.376912, -0.353254, 0.049029, 0.497904, 0.361312, 0.882148, 0.166547, -0.144120, -0.078388, -0.366607, -0.395689, -0.186846, 0.055967, -0.146304, 0.069092, -0.162903, 0.365857, -0.292546, -0.579167, -0.353251, -0.346840, -0.458449, 0.214353, 0.090203, -0.200081, 0.073472, -0.528746, 0.157562, -0.449985, -0.214271, 0.094274, -0.059354, -0.564136, -0.321625, -0.349762, 0.021030, 0.042218, -0.645291, 0.093266, -0.048619, -0.131925, -0.335875, -0.024650, 0.032462, -0.279596, -0.068904, -0.460775, 0.902877, 0.154753, -0.238793, -0.776633, -0.553893, 0.039461, -0.531720, 0.264077, 0.606090, 0.110136, 0.346040, -1.686709, 1.545331, -2.213605, 0.736941, 0.747478, -2.075111, -1.261367, -1.711802, -1.509530, -0.459529, -2.442437, -2.531208, -1.356907, -2.701594, -1.656911, -1.125049, -1.087093, -1.360116, -1.247763, -0.586198, -0.832405, -0.383662, -0.334908, -0.236199, -0.175304, -0.661513, -0.222611, -0.753418, -0.140482, -0.683030, -0.066312, -0.768006, -0.220134, 0.007478, -0.296224, -0.114982, -0.811418, -0.086500, 0.086725, 0.016801, -0.433976, 0.484662, 0.457020, -0.482358, -0.916626, -0.323269, -0.920352, -1.071081, -0.229629, 0.146120, 0.120771, 0.307249, 0.549640, -0.134733, -0.296532, 0.522608, -0.380781, -0.659726, -1.266508, -0.564980, 0.037209, 0.148155, -0.315577, 0.128298, 0.465383, 0.387222, 0.312791, -0.161517, -0.535558, -0.511291, 0.470590, -0.640220, -0.218615, 0.617550, -0.160671, 0.185154, -0.005325, -0.122996, -0.599529, -0.708914, -0.464618, -0.361200, -0.155907, -0.161575, -0.187427, -0.708167, 0.194941, -0.416317, 0.176046, -0.687692, -0.311392, -0.519858, -0.387597, -0.520620, -0.240545, -0.025336, -0.465296, 0.134160, -0.039345, -0.396212, -1.164784, -0.052019, 0.769408, -0.409704, -0.698010, 0.178982, 0.035867, -0.890787, 0.338568, 0.199465, 1.157115, 1.060464, 0.095315, -0.658102, 0.079529, -0.040245, -0.306167, 0.578477, 0.208538, -0.256512, 0.820029, -0.169974, -0.174551, -0.962689, -0.841936, -0.014542, 0.152315, 0.011981, 0.261074, -0.642742, -1.014403, 0.175247, 0.451249, 0.409189, 0.688736, -0.277901, 0.217968, 0.730751, -0.451305, 0.050902, 0.044469, -0.092996, 0.470803, 0.147497, 0.813012, 0.157617, 0.283137, 0.340740, -0.163765, -0.274131, -0.130869, 0.136906, -0.348913, 0.181361, 0.685246, -0.315700, -0.650981, -0.196763, -0.463858, 0.254119, 0.349930, 0.269550, 0.642641, -0.131368, 0.234540, 0.653190, 0.103668, 0.297279, 0.984966, -0.168228, -0.018918, 0.216160, 0.572856, -0.119603, -0.510932, -0.263652, 0.076584, 0.175544, -0.563681, -0.201955, 0.076254, 0.095290, 0.178034, 0.093138, 0.235919, -0.336842, -0.062234, -0.060744, 0.049384, 0.182253, 0.264295, -0.088261, -0.277203, 0.262851, 0.227454, 0.005122, 0.301678, 0.063375, -0.221721, -0.204529, -0.290345, -0.226672, 0.099057, 0.227497, 0.096254, -0.009690, 0.783582, -0.151510, -0.334557, -0.092865, -0.062962, 0.508438, -0.627506, -0.213653, 0.467628, 0.023984, -0.484783, -0.555340, -0.125486, 0.259218, 0.040494, 0.454632, 1.252971, -0.021833, -0.123220, 0.438535, 0.078802, 0.134043, 0.696871, 0.496619, 0.624929, 0.846129, 0.647531, -0.039968, -0.302633, 0.073073, -0.298902, -0.299922, 0.364541, -0.244907, 1.503638, -0.299488, 0.171288, -1.033872, -0.384507, -0.597309, 0.151976, 0.037647, -0.221839, -0.286042, -0.738457, -0.343208, -0.435929, 0.178794, 0.173764, -0.711200, -0.449082, 0.206062, -0.214413, 0.088548, 0.116020, 1.644230, 1.065238, 0.110960, 0.777126, 0.554204, -0.136591, -0.176106, -0.155845, 0.438785, 0.830145, 0.094750, -0.103315, 0.280954, 0.939646, 0.829688, 1.365725, 1.408961, 0.065218, 0.394374, 0.217195, 0.181610, 0.186385, -1.155399, -0.734845, -0.004348, -0.085308, 0.363013, 0.454206, 0.381511, 0.248079, -0.173659, -0.544672, 0.212847, 0.354067, -0.735791, -0.639381, 0.066264, 0.444348, -0.181408, 0.050245, 0.327706, -0.510705, 0.084251, -0.333932, -0.330380, -0.164388, -0.402380, 0.321261, 0.061801, -0.102452, 0.678947, -0.280058, 0.113216, 0.308061, -0.589521, -0.120931, -0.703438, 0.305047, -0.025037, -0.388700, 1.343994, 0.423446, 0.268746, 0.930678, 0.470860, -0.432987, -0.473080, -0.063080, -0.306743, 0.071042, -0.322094, -0.057911, 0.165080, 0.058251, 0.581112, 0.769316, 0.551167, -0.360777, -0.180192, -0.491382, 0.369108, 0.046171, -0.984282, -0.418653, -0.132095, 0.047859, 0.220766, 0.062548, -0.680480, 0.919208, 0.223356, -0.347832, 0.391114, 1.094085, 0.614276, 0.836227, 0.444396, 0.578632, -0.152562, -0.300820, 0.562020, -0.401465, -0.444123, 0.203168, 0.065196, -0.589026, -0.268906, -0.892262, -0.806349, -0.910113, -0.707403, -0.743985, -0.714526, -0.894845, -0.708873, -0.039992, -0.790976, 0.029293, -0.303250, -0.399495, -0.443748, -0.009785, 0.281675, 0.156045, 0.920231, -0.288561, 0.418329, 0.622117, -0.463617, 0.610067, -0.748575, 0.642318, -0.389150, 0.211221, 0.103433, -0.355960, -0.094707, 0.219559, 0.439202, 0.152679, -0.273712, 0.297359, 0.339053, 0.241480, 0.968424, -0.088329, 0.029292, -0.418790, 0.012071, 0.464284, 0.128249, 0.119914, 0.179969, 0.391502, 0.275761, 0.063283, -0.406236, -0.627997, 0.244787, 0.026184, 0.444366, 0.473376, 0.037811, -0.267403, -0.179720, 0.403078, -0.672662, -0.665539, 0.147412, 0.341032, 0.254818, 0.102519, -0.228752, -0.551460, -0.639129, -0.539141, 0.194591, 0.038120, -0.230225, -0.317091, -0.107377, 0.111162, 0.414265, 0.051007, 0.637214, -0.253738, 0.904440, 0.715172, -0.028307, 0.757171, -0.740556, 0.348408, -0.455433, 0.502619, 0.104752, -0.143493, 0.332199, 0.137512, 0.133675, -0.096325, -0.002490, 0.395160, 0.096718, -0.122092, 0.926155, 0.139537, 0.101965, -0.094090, 0.103214, 1.192132, 0.933644, 0.235656, -0.846443, 0.149880, -0.060390, -0.572205, 0.795635, 0.142920, -0.236711, 0.977862, -0.351790, -0.040417, -1.090792, -1.140118, 0.011080, 0.141146, 0.025643, 0.892354, 0.341924, -1.018429, -0.015898, -0.195280, 0.456385, 0.667453, -0.055853, 0.373130, 0.433854, 0.030598, -0.031312, -0.130554, -0.446937, -0.149016, -0.051318, 0.987399, 0.004029, -0.113944, 0.316930, -0.223034, -0.090017, 0.099578, -0.027442, -0.319746, -0.267405, 0.016826, 0.013204, -0.119376, -0.267963, 0.500907, 0.222285, -0.180499, -0.214268, 0.082584, 0.026238, 0.108457, 0.598191, 0.304730, 1.363682, 0.624681, -0.141263, -0.231922, -0.511335, 0.226781, 0.288274, 0.862113, 0.658648, -0.287355, -0.391607, -0.384109, -0.321740, 0.090350, 0.754110, 0.307651, -0.160749, 0.239347, 0.115942, -0.291469, 0.269860, -0.002658, -0.265965, 0.069206, -0.481085, 0.139450, -0.017836, 0.785943, 0.655636, -0.296246, -0.359666, 0.300000, -0.126469, -0.323004, -0.462136, -0.373396, 0.077262, 0.399047, -0.097438, -0.164461, -0.113395, -0.183708, -0.041437, -0.377435, 0.072287, -0.098784, -0.285730, -0.298091, -0.375972, -0.193058, -0.188195, 0.511610, -0.085543, -0.290863, -0.550234, -0.017815, -0.242249, -0.206027, 0.434395, -0.342578, 0.888472, 0.616409, -0.293793, -0.116087, -0.571388, -0.657288, 0.394612, 0.076575, -0.193808, 0.033994, -0.793049, 0.970618, 0.912228, -0.365787, 0.052541, -0.777432, -1.103429, -1.134781, -1.016847, -0.469765, -1.416494, -0.349998, -0.633997, -0.045035, -0.664123, 0.775849, 0.209374, 0.508342, 0.496446, 0.437305, 0.007481, -0.005301, -0.079550, -0.209507, 0.007481, -0.023158, 0.217338, 0.575711, 0.382369, -0.139664, 0.147598, 0.452553, -0.002848, -0.044267, 0.024809, -0.169915, -0.014936, -0.276458, -0.247470, -0.503918, -0.039670, 0.744153, -0.415291, -0.292499, -0.214985, 0.351301, -0.606775, 0.313301, -0.003394, 0.045758, 0.007811, -0.083448, -0.362973, -0.166380, 0.056068, -0.189524, 0.410652, 0.808578, 0.675804, 0.413592, 0.113094, 0.278034, 0.316931, -0.074286, 0.240712, 0.416405, 0.197084, -0.362555, -0.475495, -0.238222, -0.015887, 0.232519, 0.283709, 0.326269, 0.191732, -0.287041, 0.072967, 0.709780, 0.012571, 0.212156, 0.207203, 0.137413, 0.173007, 0.030722, 0.030941, 0.154098, 0.058534, 0.722336, -0.117160, -0.341689, -0.197443, 0.224331, 0.008577, 0.081337, 0.231191, 0.001792, 0.058881, -0.426728, 0.162750, -0.304099, 0.101120, 0.977299, -0.265763, -0.365038, -0.299978, 0.552393, -0.696504, 0.323800, 0.101418, -0.077154, 0.076822, -0.283083, 0.303312, -1.291171, -0.939046, -1.156085, -1.868935, -1.467640, -0.235711, 2.274909, 1.788531, 2.219767, -0.924050, -0.978548, -0.454737, -0.275913, 0.509020, 0.788955, -2.613837, 0.182452, -1.342051, -3.349422, -1.518285, -0.621505, 0.820391, 0.495703, 2.255569, 0.843307, 1.368330, 0.504502, -0.348144, -0.285373, 1.261593, 8.559605, 0.512146, 3.096065, -0.690688, 0.690260, -0.212982, -1.342806, 0.053488, -0.461898, -0.721679, 0.759517, -0.618053, 1.188754, 2.819515, -1.030556, -0.113111, -1.578923, 0.334617, 2.695625, 0.238467, 1.091914, 2.868098, 0.938112, 1.561310, 0.425850, 0.648380, -0.698519, 0.352038, -2.193791, 0.247806, -2.314366, 1.066710, 0.466540, 0.185235, 1.124780, -0.128097, -0.481417, 0.593626, -0.171510, 0.121161, 0.965428, 0.352717, -0.186335, 1.817742, 1.774042, -0.393337, 0.785727, -0.093555, -0.638467, 0.496260, -0.782060, -0.233775, 1.025521, 0.036646, 0.701059, -0.175325, -1.153830, -2.950357, 1.111774, 1.817924, 7.141747, 1.579527, 3.044568, -0.647380, 0.402022, 0.502123, -1.034767, -0.608912, -0.372118, -1.163337, 0.634237, -0.030166, 1.845542, 1.627799, 0.195767, 0.636708, -1.089716, -0.544888, 0.583901, -0.043968, 0.677361, 1.005368, 1.731795, 1.863349, 1.114627, 1.742327, -0.229882, 0.331858, -0.703775, -0.207829, -1.091903, -0.272644, -0.013708, -0.016273, 0.211094, 0.130476, 0.128600, -0.397497, 0.924940, 0.443763, -0.055540, -0.152343, -1.029359, -1.239016, -1.117236, -0.524960, -0.153841, -0.295423, 0.075917, -0.387252, -0.583614, -0.466589, 0.500279, -0.125896, 0.550639, 0.526255, 0.632842, 0.442575, -0.019369, 0.741549, 2.898842, 0.460826, 0.809154, 0.796483, 0.890975, 0.355188, -0.017885, 0.161756, -0.010729, 0.417928, -0.004813, -0.206381, -0.276271, -0.746131, 0.410474, -0.404826, -0.226431, -0.038344, -0.006616, -0.132692, 0.054666, 0.295922, 0.364042, -0.457916, 0.499378, -0.243687, -0.154282, 0.575358, 0.004239, 0.588058, -0.093751, -0.299163, 0.051724, 0.209078, 0.409261, -0.051728, -0.252795, -0.267118, -0.152939, 0.215568, 0.416397, 0.079244, 0.185189, -0.408385, -0.058363, -0.176352, -0.110976, -0.506005, 0.307504, 0.598561, 0.242118, 0.217737, -0.123747, 0.332258, 0.274007, 0.036745, -0.158608, 0.536415, -0.323480, 0.883956, 1.927680, 0.262612, 1.167543, 0.312904, 0.659577, -0.066284, -0.077517, 0.350471, -0.041490, 0.419212, 0.082194, -0.117952, -0.390860, -0.503647, -0.278430, -0.473384, -0.042602, 0.075978, 0.077895, 0.198897, 0.218143, 0.047818, -0.065413, -0.022889, 0.372031, -0.132668, -0.034568, 0.111887, -0.253831, 0.177383, -1.025355, 0.821983, 0.608736, 0.416983, 0.887786, 0.984019, -0.678024, -0.222322, -0.871652, 0.392738, 0.251516, 0.306778, 0.291267, 0.956554, 0.248379, -0.322109, 0.379898, 0.023676, -0.035810, 0.101927, -0.315358, 0.043751, -0.857914, 0.038236, -0.118117, 0.009201, 0.625543, 0.146904, 0.528776, -0.063337, -0.096163, -0.039503, 0.154910, 0.638420, 0.056279, 0.069007, 0.349107, 0.076240, -0.462181, -0.010064, 0.281608, -0.000562, -0.256908, -0.391169, -0.650981, -0.840425, -0.302117, -0.238168, -0.191151, 0.431416, -0.230068, -0.293699, 0.117621, 0.659270, -0.026756, -0.189855, 0.192378, -0.520775, -0.449639, 0.491381, 0.291893, -0.174241, -0.414921, -0.112874, -0.221445, -0.024548, -0.071123, -0.219136, 0.082230, 0.348041, -0.055672, -0.173541, -0.174266, -0.159544, 0.326496, 0.526475, 0.049708, 0.419064, 0.275357, -0.530676, 0.036821, -0.301869, -0.570152, -0.436410, 0.283956, 0.509362, 0.184658, -0.085066, -0.011433, -0.242102, -0.687079, -0.054738, 0.072351, 0.486142, -0.108398, -0.009430, -0.113947, -0.420035, -0.631989, -0.370419, 0.130996, -0.025274, -0.312903, -0.378259, -0.542522, -0.701609, -0.355424, -0.365588, -0.484029, 0.328746, -0.258174, -0.262842, 0.218742, 0.572320, 0.127968, -0.390030, -0.265785, -0.262400, -0.249684, 1.116933, 0.359865, -1.433205, -0.653181, -1.141073, -0.022785, -0.071804, -0.223820, -0.784312, 0.550708, 0.199824, -0.061030, 0.330350, 0.942444, 0.876789, 0.650960, 0.606912, 0.398734, 0.103818, 1.243436, 0.378019, 1.003819, 0.156388, 0.396099, 0.672353, 0.457882, 0.598475, -0.175960, 0.557625, -0.247607, 0.369539, -0.014250, -0.081867, -0.007051, -0.299774, 0.011341, -0.265829, -0.069979, -0.286839, -0.212487, 0.024124, 0.367217, 0.072891, 0.209267, 0.322098, -0.478231, 0.208894, -0.031964, 0.195495, 0.015767, -0.220603, -0.057508, 0.047322, -0.034664, -0.321728, 0.660582, 0.713474, 0.193648, 0.217646, -0.056907, 0.025159, -0.043861, -0.029324, 0.157435, 0.007294, 0.232075, 0.371978, -0.139579, -0.180173, 0.290881, 0.035293, -0.148751, -0.246840, 0.173692, 0.154365, 0.330090, 0.068815, 0.114565, -0.352698, 0.332898, 0.099985, 0.354250, -0.093579, -0.168434, 0.190269, -0.490647, 0.021025, 0.064020, -0.069502, 0.195954, 0.481326, -0.093781, 0.092664, -0.000182, -0.268909, 0.221777, -0.316369, -0.026790, -0.167307, -0.140529, -0.200787, 0.058216, 0.101965, 0.324143, 0.475422, -0.280291, 0.268674, -0.265815, 0.111313, -0.241330, -0.188506, 0.098176, 0.010717, -0.075917, -0.279453, 0.642222, 0.633214, -0.170863, 0.196153, -0.070622, 0.053970, 0.540729, 0.732189, 1.107467, -1.106312, -1.490981, -0.880502, 0.182981, -0.212800, -0.061858, 0.093523, 0.541122, -0.095118, 0.829561, 0.967542, -0.426809, 0.614162, -0.572782, -0.015076, 1.264375, 0.788885, 0.782388, 1.754525, 1.167833, 0.625450, 1.254511, 1.310301, 0.444074, 0.916203, 0.146323, 0.146451, 1.614486, -0.016179, 0.030915, -0.016258, 0.186805, 0.004293, -0.238847, 0.153116, -0.064321, 0.584319, 0.332793, -0.218985, -0.036821, -0.150888, 0.107115, 0.372292, 0.036557, -0.129367, 0.272256, 0.272762, 0.123615, 0.733349, 0.244829, 0.606696, 0.038247, -0.157667, -0.060859, 0.306408, 0.506323, 0.412140, -1.074062, 0.428551, 0.393478, -0.421257, -0.379436, -0.141431, 0.458989, 0.643644, -0.242122, -0.535618, -0.099935, -0.129405, 0.089438, 0.151569, -0.116852, 0.647737, 0.321872, 0.202231, -0.093422, -0.108054, -0.119340, -0.506397, -0.819701, -0.270527, 0.158262, 0.303221, -0.225992, -0.197608, 0.753443, 0.487437, 2.431208, 0.135337, -0.059220, -0.112950, 0.571947, -0.096439, -0.178966, 0.614333, -0.249328, 1.069991, 0.346231, -0.203371, -0.386598, 0.013005, -0.036350, 0.300152, -0.353818, -0.351130, 0.478640, -0.113178, 0.334305, 1.089612, 0.391058, 0.910184, 0.150168, -0.262960, 0.020664, 0.339724, 0.289234, -0.519082, -0.114002, -0.497245, -0.330720, 0.077907, 0.007534, -0.147854, -0.102554, -0.625148, 0.705419, 0.732088, -0.182046, 0.029957, -1.089741, -1.119522, -1.059879, -0.056156, 0.187170, 0.052763, 0.617690, 0.362134, -0.408533, -0.266392, 0.532965, 0.063488, 1.249042, 1.150620, 0.677045, 0.884613, -0.387146, 0.203381, -0.301947, -0.072598, 0.022316, 0.468079, 0.655631, 0.174042, -0.379937, 0.000862, -0.486243, 0.676658, -0.048513, -0.506812, 0.716002, 0.211045, -0.008856, -0.637986, -0.129638, -0.469717, 0.009800, 0.014617, -0.590264, -0.261917, -0.713257, -0.114672, 0.068323, -0.068555, 1.175381, -0.014910, -0.217911, -0.213831, 0.002545, -0.467568, -0.064768, -0.007358, 0.162693, 0.520440, 0.434371, 0.091237, -0.065991, -0.171878, 0.012876, 0.157500, 0.266093, -0.249619, -0.402495, -0.110921, 0.057971, 0.518875, -0.076186, -0.354249, -0.232052, 0.024358, 0.290064, 0.054875, -0.274482, -0.164970, 0.495725, 0.503524, 0.004299, 0.705754, 0.012919, -0.200626, 0.518492, 0.063536, 0.367102, -0.292294, -0.462828, 0.108138, -0.182898, 1.122324, 0.477254, -0.169842, 0.479752, 0.210677, 0.129594, -0.678955, 0.005401, -0.154971, 0.251808, 0.496004, -0.335052, -0.247665, -0.454650, -0.028716, 0.303249, -0.148973, 1.300068, -0.142088, -0.096873, -0.535798, -0.042572, -0.506307, 0.181022, 0.935224, 0.821126, 0.502862, 0.484061, 0.551836, 0.369280, 0.802179, 0.274843, -0.401823, 0.601525, 0.688876, 0.123949, 1.175767, 1.138936, 0.119574, -0.051399, 0.130230, 0.669114, -0.274209, 0.063823, 0.322943, -0.449134, 0.213314, -0.618951, 0.584255, 0.998464, 0.129794, -0.057201, -0.279497, -0.363685, -0.252196, -0.127681, -0.160506, 0.569381, -0.141957, 0.099502, 0.137488, -0.454401, 0.308834, -0.125243, -0.555589, 0.211366, -0.187214, 0.054942, -0.370027, 0.272791, -0.267225, -0.204813, -0.196878, 0.239714, 0.327071, 0.551627, 0.012252, -0.309075, 0.171872, 0.385379, -0.493185, -0.065521, -0.001921, 0.040367, 0.155720, 0.242971, 0.232306, -0.299835, -0.021258, 0.280057, 0.619090, 0.404344, -0.169959, -0.153831, -0.351762, -0.176449, -0.047707, 0.371591, 0.075316, 0.339583, -0.199218, -0.318661, 0.086530, 0.412059, 0.472813, 0.537801, 0.171128, -0.175798, 0.131609, -0.622097, 0.537488, 0.207312, -0.064582, -0.375277, -0.301005, 0.066473, -0.029896, 1.247961, 0.075911, 0.353360, 0.077175, -0.313517, 0.676539, 0.104420, -0.560420, 0.788382, 0.081955, 0.010791, 0.120869, 0.453036, -0.179834, -0.160212, -0.213924, 0.214994, 0.128638, 0.406763, 0.170550, -0.498805, -0.164537, -0.000050, 0.403028, 0.713268, -1.361397, -0.274319, -0.668371, -0.060467, 0.027105, 0.226493, 0.085316, 0.170648, 0.025870, -0.226487, 0.508626, 0.939765, 0.835620, 0.505715, 0.723875, 0.119453, -0.111334, 0.318784, 0.283877, 0.625615, 0.168603, -0.287903, 0.397129, -0.077335, 0.362224, -0.149293, 0.265577, 0.019363, 0.783968, 0.584501, 1.801234, 0.464969, 0.213285, -0.172993, -0.306521, 0.709829, 0.638393, -0.029990, 0.455665, -0.558332, 0.391216, -0.430125, 0.592590, 0.157407, -0.189226, -0.065276, 0.495760, -0.536627, 0.833474, 0.646752, 0.318728, 0.149543, -0.176107, -0.484216, -0.294500, -0.059392, -0.181799, 0.747511, 0.233989, 1.119952, 0.499890, -0.884313, -0.425150, -0.471601, 0.063613, -0.526898, -0.713365, -0.598396, -1.052942, -0.154847, -0.081068, 0.717441, 0.782567, -0.107836, -0.426801, -0.076956, -0.080000, -0.188228, -0.099806, 0.029078, -0.214087, 0.024024, -0.593840, -0.362787, -0.196078, 0.068184, 0.059530, -0.326552, 0.839906, 0.424266, 1.446792, 0.262148, 0.076998, -0.007442, -0.362451, 0.539901, 0.406090, 0.013435, 0.409368, -0.780219, 0.521339, -0.622734, 1.014533, -0.029954, -0.183469, 0.152205, 0.672825, -0.293851, 0.593787, 0.232137, 0.378122, 0.092371, -0.358198, -0.414873, -0.054244, -0.048023, -0.393200, 0.554064, -0.054989, -1.454628, -0.562208, 0.627253, -0.115803, -0.024658, -0.460879, -0.459870, -0.631696, -0.852718, 0.360440, 0.289278, -1.052873, 1.131905, 1.652117, 0.375154, 1.190565, 1.685888, 0.912323, 0.210754, 0.409095, 0.658887, 0.137549, 0.420927, -0.464697, -0.099037, 0.264159, -0.802339, 1.501177, 0.045251, -0.122429, -0.270895, -0.065089, -0.020846, -0.273610, -0.497451, 0.106363, 1.358842, -0.438006, 0.229788, -0.743030, 0.101157, 0.836039, 0.492652, -0.405702, 0.455346, -0.289190, -0.557530, -0.030838, -0.163034, -0.215899, 0.321099, -0.354199, 0.469873, 0.179630, -0.188595, 0.900733, 0.144605, 0.450623, -0.096689, -0.106340, -0.155582, 0.344464, 0.679598, 0.503829, 0.095078, -0.237486, 0.192302, 0.148891, -0.079934, -0.579234, -0.780101, 0.088867, -0.348815, -0.491986, -0.172899, 0.337079, 0.228876, 0.168291, -0.100123, -0.580943, -0.015040, -0.309820, 0.336924, 0.232633, -0.207262, -0.242967, -0.271581, -0.052176, 0.364236, -0.293729, -0.436601, -0.080477, -0.095370, 0.265517, -0.674864, 0.294160, 0.325197, -0.500148, 0.350198, -0.418856, 0.863153, 0.709446, 0.855858, -0.045058, -0.047163, -0.329457, -0.714980, -0.149725, -0.256671, -0.269435, 0.114728, -0.282826, -0.105804, 0.235908, -0.022900, 0.835682, 0.250174, 0.850218, -0.323269, 0.051645, -1.058141, 0.785913, 0.447427, 0.434347, 0.897088, 1.107274, -0.802203, -0.425980, -0.715706, 0.519143, 0.313902, 0.645166, 0.133154, 0.994691, 0.359667, -0.000337, 0.546201, 0.172348, -0.167340, -0.104402, -0.502932, -0.027661, -1.000169, 0.124283, -0.435331, -0.006431, 0.735644, 0.253375, 0.741956, -0.219590, -0.276610, 0.022143, -0.068249, -0.564055, -0.331695, 0.864670, 0.787162, 0.397062, -0.430440, -0.084795, 0.012454, -0.069272, 0.024798, -0.378602, -0.333185, -0.065221, 0.823361, -0.035134, -0.355127, 0.352162, -0.035399, -0.001179, -0.373478, 0.130980, -0.388875, -0.176677, 0.667908, -0.391387, -0.690465, -0.043270, -0.120477, 0.103167, 0.318373, -0.075655, 0.105468, -0.074182, 0.042403, 0.051287, -0.010254, 0.294036, 0.035630, 0.240082, 0.153779, 0.215462, -0.076916, -0.556368, -0.556788, -0.057268, -0.095662, -0.235867, -0.705659, -0.325639, 0.247017, -0.106332, 0.553287, 0.300709, -0.076016, -0.031493, -0.175977, -0.371602, -0.511244, -0.119429, -0.251518, -0.663804, -0.448061, 0.404209, 0.667817, 0.033029, -0.396280, -0.274966, -0.439117, -0.078353, 0.026214, -0.218638, 0.128301, -0.285171, 0.700193, 0.051745, -0.610139, 0.075188, -0.231503, -0.110093, -0.030889, -0.163454, -0.214723, -0.074326, 0.294317, -0.392421, -0.602223, -0.174346, -0.232034, 0.557974, 0.245976, 0.262374, 0.545150, 0.424027, 0.031449, 0.198124, -0.773472, -0.116307, 0.133622, 0.250002, 0.310640, 0.497505, 0.251224, 0.484934, 0.528834, 0.633862, 0.305185, 0.330802, -0.299719, -0.121050, -0.671931, -0.455771, -0.805688, -0.708847, -0.281081, -0.434451, 0.027019, -0.162271, -0.033692, -0.306704, -0.431964, -0.491463, -0.245300, 0.095544, -0.812588, -0.693694, -0.168802, 0.118720, 0.315692, -0.332975, -0.065950, -0.325157, -0.688071, -0.209734, -0.048155, -0.152130, 1.121073, 0.712693, 0.466643, -0.152918, -0.187204, 0.425849, 0.146776, -0.288918, 0.034352, -0.360434, -0.048540, 0.124355, 0.561218, 0.296513, -0.129661, 0.414584, 0.340529, -0.911745, -0.299625, -0.189528, 0.093048, 0.030445, -0.052206, 0.157502, -0.408726, 0.266819, 0.200123, 0.021855, -0.223829, -0.179559, -0.408346, 0.133694, 0.393651, -0.373774, -0.256366, 0.119918, 0.058882, 0.083287, -0.221150, -0.470138, -0.082064, -0.228593, -0.155240, -0.106073, -0.211734, -0.211724, -0.682817, 0.127723, -0.581116, -0.620578, -0.443649, 0.150037, -0.031263, -0.193890, -0.007884, -0.276461, -0.597153, -0.731729, -0.090136, -0.364977, 0.955186, 0.357729, 0.528915, -0.213868, -0.186146, 0.148980, -0.007964, -0.069728, -0.120790, 0.008082, -0.210686, -0.562077, 0.880524, 0.134757, -0.237973, 0.869644, -1.290062, -1.493149, -0.225595, 0.023148, -0.061213, 0.803835, -0.964774, 0.408764, -0.166057, -1.471129, 0.654014, -1.525324, -1.108298, -0.989145, -0.353096, -0.696998, 0.844026, -0.212263, 0.716381, -0.230228, -0.561591, -0.212413, 0.351457, -0.903565, -0.268218, -0.323998, -0.444934, -0.193328, -0.132434, -0.571905, -0.317292, 0.039724, -0.496927, -0.080385, -0.552282, -0.259827, -0.202547, 0.097027, 0.438798, 0.074029, 0.079692, -0.325439, -0.435495, 0.296574, -0.192087, -0.155468, -0.231422, -0.575200, 0.164034, -0.786529, -0.055736, -0.649267, -0.504083, -0.408887, -0.335943, -0.243979, -0.340262, 0.353337, 0.219702, 0.225483, 0.169675, 0.087925, 0.045662, 0.073268, -0.192761, -0.216768, 0.261358, 0.346259, -0.177111, 0.154436, -0.215089, -0.387489, -0.096725, -0.480236, 0.271692, 0.073565, 0.288210, 0.505235, 0.050315, 0.068152, -0.019811, 0.068792, -0.290066, 0.097744, 0.339558, -0.378542, -0.558523, 0.194067, -0.173100, -0.505103, -0.235270, -0.030607, -0.526211, -0.321423, -0.199401, -0.441887, -0.085123, 0.236358, 0.534552, -0.092535, 0.327446, 0.247710, -0.128756, 0.331029, -0.217401, -0.032727, 0.101028, -0.547527, 0.366380, -0.602550, -0.240728, -0.407577, -0.318380, -0.280762, -0.099172, -0.902734, 0.585920, -0.633755, -0.546702, -0.629293, 0.226917, 0.429970, -0.470865, -0.030033, 1.181985, 0.782118, -0.246813, 0.806606, 1.290735, 0.224325, 0.755103, 0.950779, 1.194556, -0.311572, 0.288373, 0.267589, 0.530001, 0.669793, 0.232461, 0.195307, -0.221175, -0.141641, -0.422987, -0.232048, -0.077623, -0.292269, -0.658383, -0.401647, 0.191444, 0.272512, 0.197348, 0.223250, -0.292644, -0.204797, -0.298774, -0.456708, -0.494226, -0.573966, 0.151858, -0.021501, 0.162055, -0.324026, 0.504335, 0.127549, -0.051458, 0.073541, 0.084201, -0.121440, 0.004909, 0.187218, 0.514423, 0.080757, 0.225218, -0.156613, 0.540520, 0.011110, -0.042246, 0.018868, 0.346403, 0.490984, 0.491038, -0.269823, -0.546199, -0.397812, 0.453952, 0.216858, -0.386842, -0.124036, -0.264021, 0.729006, 0.768829, 0.671522, -0.242660, -0.719746, 0.349195, 0.171250, -0.276006, 0.269866, 0.571720, 0.350766, -0.031136, -0.330878, -0.114506, -0.201235, -0.773820, -0.297914, -0.573448, -0.273968, 0.074608, 0.242441, 0.150831, 0.025875, -0.161410, -0.229453, -0.124216, -0.194083, -0.497743, -0.507335, 0.097240, 0.498370, 0.392481, -0.203272, 0.761861, -0.126475, -0.310191, -0.044522, 0.097904, -0.243564, -0.322550, 0.239803, 0.359525, -0.028439, 0.104788, -0.176964, 0.509565, 1.273520, 0.737884, 1.306052, -0.601518, -2.035012, -2.140622, -0.711482, 0.462741, 1.240779, 0.717307, 2.508842, 2.225703, -2.972844, 1.538955, -2.262135, -0.717792, -1.351399, 1.088668, 0.098047, 0.139441, -0.889496, 0.183738, -1.590106, -1.231851, -0.800706, -0.811432, 0.630803, 1.370571, -0.261792, 0.508658, 0.592613, 0.957730, 1.843270, 2.823173, -0.173764, 3.399717, 3.310253, 2.149984, -0.475199, 2.298598, 2.057932, 1.620641, 1.966959, 1.160918, 0.058730, 0.909877, 1.438303, 1.831851, 1.862415, 0.945770, 1.976150, 2.874357, 1.073265, 1.063131, 2.538547, 0.453577, 2.727693, 1.786864, 1.053078, 1.469931, -0.541373, -2.333089, 0.998100, 1.498347, -0.020710, 0.120611, 1.156560, 0.130978, 0.762935, -1.563476, 0.787166, 0.858546, 0.731939, 1.756417, -0.873388, -2.099189, -0.747655, -1.555201, 0.197779, -0.212325, 0.241316, 2.904963, 0.148491, -0.015516, 0.580841, 0.838085, -0.298432, -1.643171, -1.015022, 0.067384, 1.319319, 0.773892, 1.380580, 2.768268, -0.046947, 2.979595, 4.534420, 2.325150, -0.916446, 1.861684, 1.514373, 1.237068, 1.628585, 1.092045, 0.299699, 0.901159, 0.953963, 1.724301, 1.714265, 0.213580, 2.443954, 2.117526, 1.927006, 1.643732, 3.013832, 1.290305, 2.758774, 0.773260, 1.915987, 1.204911, -0.715842, 0.992129, 0.267192, -0.066489, 0.817048, 0.957420, 0.734131, 0.761216, -0.425448, -0.693329, -0.877930, -0.903029, -0.138914, -0.208287, -0.146959, 0.467985, -0.166495, -0.804614, 0.305898, -0.064179, 0.335848, -0.419287, -0.354723, -0.497242, -1.175723, -1.401483, -1.328086, -0.764356, -1.377662, -1.086619, -0.319634, -0.751126, -0.610783, -0.467851, 0.016196, -0.002965, 0.110118, -0.125467, -0.292792, -0.280957, -0.362486, -0.637556, -0.545428, -0.268659, -0.639763, 0.056801, 0.313004, 0.398812, 0.585441, 0.750426, 0.316644, 0.134363, 0.126459, -0.129073, -0.139957, 0.144812, -0.340363, -0.853901, -0.326496, -0.283431, -0.095956, 0.398635, 0.334997, -0.037223, 0.144265, -0.150028, -0.328927, -0.064586, 0.192522, 0.051374, -0.150364, -0.037033, -0.163225, 0.111165, 0.368337, 0.451044, 0.356569, 0.119059, -0.008774, -0.087230, -0.418391, -0.804946, -0.704085, -0.126726, -0.061020, -0.201004, 0.475441, 0.717220, -0.254730, -0.146571, -0.230653, -0.513662, -0.294913, -0.079576, 0.218377, 0.114076, 0.220985, 0.082975, -0.135813, -0.045850, -0.410477, -0.456022, -0.350219, 0.105436, -0.406498, 0.174189, -0.086750, 0.192864, 0.188962, 0.399976, 0.611037, -0.235887, -0.079756, -0.065983, -0.173683, 0.077771, -0.372577, -0.735449, -0.226153, -0.273798, 0.313024, 0.695418, 1.437245, 0.829860, -0.030921, 0.087291, -0.103623, 0.694327, 0.413027, -0.177994, -0.464166, 1.606816, -0.283858, 0.022827, -1.136742, -1.237263, -0.615778, -0.688775, -0.007749, -0.122079, -0.272874, -0.612818, -0.591958, -0.505171, 0.763155, 0.229037, -0.941335, -0.290882, -0.301947, -0.300618, -0.150319, 0.796347, 0.466564, 0.204145, -0.235923, 0.497856, -0.017763, -0.495324, -0.111896, 0.082694, 0.143327, 0.253456, 0.346353, -0.262942, 0.265678, 0.432642, 0.869451, 1.360028, 1.161561, 1.267569, 1.694052, 0.506506, 0.038277, -0.322011, -0.006192, 0.197236, -0.391066, -0.321358, 1.069514, -0.158909, -0.187759, 0.039494, 0.345239, 0.281159, -0.071970, -0.115648, 0.208891, 0.531540, 0.188433, -0.346287, -0.034923, 0.019994, -0.782916, 0.010530, 0.293294, 0.404541, -0.235932, -0.188573, -0.206925, 0.143531, 0.239120, -0.334579, 0.110401, 0.042875, -0.141523, -0.352020, 0.261157, -0.043527, -0.290547, -0.454786, -0.359417, -0.046548, -0.038054, 0.075582, -0.395111, 0.121839, -0.514658, -0.500961, -0.145402, 0.121156, 0.071362, -0.157582, 0.140274, -0.206310, -0.106488, 0.018040, 0.305009, 0.969631, 0.493245, 0.742603, 0.940278, 0.047846, -0.247737, -0.379816, 0.185021, 0.467062, -0.188281, 0.082121, 0.854064, -0.153409, -0.130990, -0.171488, -0.366725, -0.436137, 0.732245, 0.195227, -0.372100, -0.082792, -0.758787, 0.746711, 0.324303, -0.748798, -0.310535, -0.476369, -0.974220, -1.036940, -1.036154, -0.599409, -1.366894, 0.016442, -0.649827, 0.144701, -0.876210, 0.342069, 0.275021, 0.085394, 0.262868, 0.214596, -0.445821, -0.377940, -0.042270, -0.141697, -0.279980, 0.008139, 0.201918, 0.600934, 0.643597, 0.000239, 0.227701, -0.390777, 0.239512, -0.435680, -0.464125, -0.062716, -0.265830, 0.389261, 0.009885, 0.306343, 0.293786, -0.142275, 0.316884, 0.230933, -0.180960, 0.159062, -0.317617, 0.090423, 0.480914, 0.173809, 0.022489, -0.220521, 0.208259, 0.143918, -0.145766, -0.131689, -0.151206, -0.052588, -0.232918, -0.167571, -0.260659, 0.243127, 0.272165, 0.188515, -0.046537, -0.382998, -0.112707, 0.155930, 0.065295, 0.105752, -0.006907, -0.297460, 0.116959, 0.226514, -0.209658, -0.128700, 0.204800, 0.007150, -0.273178, 0.269132, -0.021498, -0.271447, 0.328726, 0.369991, -0.200017, 0.228198, 0.060705, 0.513494, 0.070185, -0.203709, 0.493605, -0.132412, 0.423494, -0.221960, -0.180702, 0.077140, -0.258391, 0.032410, 0.391186, 0.484382, 0.589772, 0.110284, 0.913694, 0.436346, -0.000459, 0.209516, -0.155707, 0.107173, 0.337273, 0.238095, 0.195806, 0.018950, 0.096354, 0.333588, -1.255582, -0.285190, 0.430769, -0.189726, -1.051766, -0.750668, -0.424728, 0.398377, -0.739893, -0.964414, 0.630316, -0.822648, -0.148769, 0.864095, -0.323351, -1.195301, 1.070441, 0.144085, -0.611229, -0.102656, 0.066128, 0.036197, -0.472683, 0.754277, 0.448799, -0.276781, -0.519471, -0.494317, 2.286485, 0.714919, 5.983678, 1.452261, 1.318450, 0.153038, -0.046972, 1.533176, 0.489517, 1.218906, 0.692508, 0.699593, -0.464845, 1.446076, 0.684449, 0.469690, 1.304464, 0.603491, 1.461729, -0.978696, 0.647592, 0.407345, -0.031248, -0.169679, 0.165630, 0.621134, 0.440420, 0.009659, -0.305427, 0.254581, -2.962977, 0.769901, 2.687381, 0.787684, 0.306836, 0.374103, 0.325271, 0.625784, 0.786750, -0.378743, 0.551009, 0.810501, -0.627634, -0.032289, 0.083211, 0.298294, 0.153576, -0.107731, -0.428281, 0.259490, 0.496241, -0.285057, -0.853112, 0.439732, -0.545283, 0.470616, -0.006550, 0.168625, 0.399956, -0.119923, 2.740784, 1.029848, 5.147986, 2.188385, 1.495210, 0.988419, 0.393850, 1.713862, 0.851024, 1.316208, 1.088383, 0.259712, 0.449332, 1.258356, 0.618467, 0.343987, 1.131298, 0.492893, 2.050239, -0.748523, 0.707257, 0.263807, 0.120461, -0.112736, -0.221333, 0.130215, -0.048627, -0.101357, -0.032498, -0.646409, -0.821219, 1.318596, 0.560597, -0.348492, 0.784070, 0.892060, 0.449054, 1.314617, 0.411347, -0.116072, -0.361755, -0.213736, 0.263351, -0.338021, -0.332341, -0.069061, -0.378162, -0.975503, -0.757193, -1.246045, -1.078990, -1.254796, -0.396047, -0.496573, -1.079645, -0.690576, -0.957609, -0.378667, -0.550746, 0.149826, -0.258547, -0.778719, -0.602241, -0.415549, -0.510113, -0.547192, -0.263016, -0.244743, -0.353439, -0.097042, -0.472367, -0.164531, -0.072318, -0.613713, 0.239117, -0.517749, 0.169941, 0.121336, 0.001776, 0.155478, -0.149112, 0.071966, -0.154214, -0.241870, -0.225373, 0.201350, -0.307725, 0.097802, -0.100541, 0.103551, -0.042245, -0.047397, 0.030414, 0.002572, -0.082271, -0.082926, 0.033065, 0.279519, 0.128876, -0.052828, -0.205998, 0.088636, 0.198720, 0.014198, 0.077688, -0.048017, -0.320674, -0.093584, -0.292025, -0.113136, 0.095315, 0.233247, -0.006375, 0.024320, -0.050345, 0.029800, 0.100836, -0.045535, -0.011090, -0.215085, -0.280398, -0.751789, -0.421449, -0.268758, -0.632445, -0.473912, -0.197912, -0.173062, -0.214529, -0.229478, -0.400440, -0.345124, -0.066790, -0.655558, -0.011837, -0.668662, -0.352457, -0.324945, -0.076076, 0.051564, -0.380109, -0.087467, -0.377632, -0.296767, -0.178681, 0.038097, -0.475751, 0.201755, -0.042198, -0.089491, 0.215103, 0.357608, 0.502183, 0.710890, -1.034790, -1.563940, -0.721931, 0.445757, -0.195865, -0.493715, 0.112563, 0.492264, 0.261101, 0.441535, 0.544568, 0.450160, -0.269479, -0.326091, 0.761225, 1.150880, 1.643719, 0.972094, 1.462147, 1.051264, 1.016305, 1.178975, 1.292215, 0.639066, 0.814342, 0.349570, 0.033820, 1.011669, 0.088980, -0.139062, 0.249851, 0.016073, 0.058490, 0.045858, 1.182572, 0.133568, -0.484050, 0.636192, 0.028628, -0.110416, 0.021911, 0.190223, 0.389259, 0.455667, -0.055621, -0.137519, 0.231510, -0.038692, 0.042365, -0.479649, 0.380484, 0.650660, 0.729268, 0.078741, 0.194220, 0.623041, -0.033060, 0.081923, 0.307853, -0.216141, -0.466293, -0.255401, -0.011683, 0.109859, -0.184274, -0.376724, -0.531161, 0.254501, -0.305618, -0.247527, 0.283057, 0.407064, -0.007521, -0.505657, 0.145233, 0.057339, -0.173557, 0.183214, 0.448380, 0.229484, 0.223236, 0.630776, 0.468282, 0.410190, -0.070379, 0.118057, 0.306308, 1.757014, 0.497071, -0.324435, -0.004689, -0.004719, 0.383143, 0.045130, 1.706877, 0.159351, -0.776394, 0.425699, -0.171890, 0.262131, 0.319413, 0.138658, 0.691068, 0.766885, -0.000446, 0.113048, 0.138061, 0.023829, -0.041447, -0.394130, 0.103331, 0.312550, 0.913007, 0.555252, 0.423641, 0.593205, 1.025432, -0.108987, -0.876791, -0.526770, -0.143711, 0.682025, -0.161500, -0.379161, -0.217128, -0.177526, 0.465959, -1.075782, 1.028208, -0.094998, 0.944895, 0.256757, 0.566451, 0.304336, -0.328993, 0.185622, 0.045358, -0.440713, -0.800021, -1.203849, 0.448293, -0.164608, -0.233492, -0.363561, -0.236609, -0.499623, 5.234320, 1.004220, 1.091579, 1.934720, 1.301195, 1.813015, 0.328908, 0.806463, 1.267089, 0.544444, 0.063373, 0.838683, 0.013825, -0.394564, 0.435380, -0.468464, 0.435726, -0.138713, -0.422137, 0.100932, 0.258929, 0.600889, 0.781536, 0.026057, -0.108609, 0.664138, 0.103947, -0.529662, 0.644420, -0.110523, -6.127906, 0.464168, 0.490384, 1.115726, 0.541190, 1.029313, 1.690746, 0.344851, 0.837080, 0.663660, 0.748894, 0.157199, 1.394261, 0.368968, -0.678748, 0.377971, 0.344424, 0.866583, 0.435555, -0.138991, -0.320207, 0.212852, 0.462145, 0.541300, -0.610030, -0.144948, 0.856397, 0.029981, 0.264185, -0.454869, 5.779249, 0.542764, 0.215522, 1.795915, 0.750937, 1.118977, 0.960849, 1.036665, 0.812131, -0.520518, 0.298757, 1.401634, 0.537280, -0.679905, 0.001253, 0.049076, 0.609668, 0.207934, 0.264571, 0.060282, 0.430479, 1.361300, 1.032861, 0.192269, 0.241457, 0.319063, 0.405948, -0.708797, -0.174435, 0.576001, 0.284501, -0.873847, 0.606816, 0.827495, 0.794984, 0.448311, 0.389620, 0.106216, 0.856532, -1.112347, 0.229467, -0.122229, -0.165232, 0.610851, 0.631513, 0.071219, 0.166842, 0.441247, 0.266212, 0.467178, 0.339284, -0.153950, -0.441787, -1.023940, 0.104842, -0.596233, -0.598652, -0.411774, -0.407955, -0.279331, -0.163238, 0.132885, -0.231795, -0.119944, 0.090847, -0.346136, -0.505207, 0.089040, -0.004426, 0.014844, 0.502762, -0.353997, -0.113743, -0.994280, -0.081466, -0.803787, 0.113647, 0.771384, -0.321037, -0.269348, 0.194618, 0.319057, 1.042689, 0.148529, 0.318888, 0.380447, 0.179941, 0.065873, 0.122320, 0.160640, -0.138813, 0.002760, -0.095744, 0.152355, -0.203156, -0.365751, 0.453072, 0.217366, 0.182433, -0.367891, -0.595491, 0.448629, 0.283410, 0.155136, 0.126462, -0.031009, -0.215373, 0.739361, 0.479644, -0.110270, 0.055509, 0.573969, 0.208620, -0.036364, 0.139806, -0.358012, -0.940022, -0.036604, 0.372207, -0.118449, -0.327686, -0.286315, -0.296410, 0.223160, -0.053817, -0.373794, -0.490461, 0.012471, -0.627890, -0.298117, 0.184521, -0.125399, -0.178730, -0.678475, -0.199509, -0.416002, -0.014474, 0.593646, -0.073997, -0.757508, -0.236526, -0.174033, 0.403872, 0.495111, -0.003369, 0.183664, 0.124236, 0.148469, 0.218838, -0.196455, -0.610074, 1.005734, 0.068722, -0.488855, 0.785471, -1.273343, -1.530584, -0.325380, -0.056341, 0.235142, 0.740100, -0.817803, 0.166050, -0.298358, -1.450520, 0.673387, -1.268823, -1.107296, -1.600508, -0.120376, -0.400062, 0.722597, -0.147200, 0.731019, -0.261174, -0.504242, -0.396350, 0.545619, -0.737008, -0.300162, -0.511335, -0.648780, -0.461064, -0.160668, 0.189776, -0.167683, -0.584693, 0.049750, -0.307394, -0.185787, 0.147102, 0.079078, 0.047255, 0.156141, -0.008254, -0.408920, -0.266310, -0.249756, -0.045427, -0.145936, -0.042551, -0.550010, -0.160231, -0.570093, -0.168531, 0.001404, -0.202277, -0.270388, -0.404703, 0.217327, 0.181595, 0.130976, -0.082659, -0.238310, 0.066067, 0.232746, -0.108911, -0.215799, 0.063205, 0.164933, 0.033398, 0.110230, -0.029850, -0.108178, -0.396115, -0.138094, 0.021332, 0.091143, 0.177925, -0.058931, 0.102222, -0.152196, -0.107411, -0.108809, 0.113914, 0.344465, -0.057753, -0.053822, -0.173319, -0.190738, -0.491033, -0.645957, -0.318891, 0.217273, 0.361921, -0.037837, -0.400747, -0.022374, -0.224809, -0.162699, -0.171750, -0.140010, -0.155245, 0.112608, -0.097793, -0.297908, -0.210064, -0.371727, 0.080470, -0.450422, 0.262538, -0.347111, -0.275787, -0.392162, -0.168043, -0.080087, -0.170003, -0.124852, -0.260536, 0.154228, 0.214169, -0.844117, 0.658246, 0.404183, 0.357880, 0.641217, 0.992880, -0.672893, -0.525523, -1.223329, -0.113166, 0.317323, 0.537283, 0.178335, 0.930658, 0.360117, -0.209562, 0.356587, -0.069258, -0.413606, -0.175435, -0.383372, 0.285188, -0.691662, 0.048412, -0.299506, -0.163756, 0.641130, 0.077504, 0.483553, -0.263289, -0.213256, -0.127652, 0.146520, -0.211493, -0.203193, 0.449277, 0.716163, -0.269257, -0.247405, -0.003079, -0.136737, -0.110094, 0.401663, 0.094537, -0.299339, -0.021071, -0.302435, -0.339123, 0.104092, -0.165317, -0.274706, 0.389922, 0.116295, 0.389525, -0.410771, 0.549071, -0.330237, -0.266304, -0.011216, -0.023903, -0.032160, -0.291641, -0.159263, -0.098236, 0.238340, 0.398596, 0.099933, 0.016574, -0.236478, -0.264930, 0.368143, -0.067991, -0.179053, -0.273965, 0.089730, 0.361522, 0.112463, -0.208725, -0.135714, -0.092181, -0.193905, 0.406838, -0.094370, 0.445288, 0.234247, -0.363028, -0.094752, -0.230222, -0.123644, -0.487933, -0.570597, -0.300321, 0.203754, -0.427854, -0.013700, 0.369424, 0.173839, -0.534212, -0.250955, -0.380401, 0.008996, -0.291080, 0.226952, 0.216691, -0.352137, -0.143536, -0.274973, -0.001681, -0.303191, -0.225426, -0.329699, 0.298565, 0.086148, 0.079303, -0.299280, 0.422694, -0.360191, -0.267733, 0.241607, 1.417765, 2.199469, -0.123363, -2.369997, -2.502666, 0.536488, -0.971097, 1.307839, 2.347513, 2.389284, -1.823545, 3.864693, -2.665267, 1.120596, -0.979104, -1.312239, -0.826201, -1.306878, 1.176867, -0.306406, -0.153576, -1.369043, 0.016339, -2.039188, 0.978433, -1.186604, -1.486628, 0.452200, -0.515449, 1.954916, 0.566691, 1.579759, 4.356233, 3.060998, 2.722338, 0.503655, 0.955158, 1.847550, 6.413731, 5.033020, 2.723917, 1.457132, 2.521505, 2.444487, 0.035210, -0.854816, 2.742990, 2.492530, -0.223033, 0.541888, 0.569457, 3.096430, 2.770888, 4.140659, 1.424551, -1.064123, 2.995568, 1.578968, 0.439226, -0.721054, 0.602961, 0.508372, 0.006211, -2.521645, -3.057321, -1.334333, -1.144252, -1.005835, 1.735101, 3.498006, -0.925810, -1.005561, -3.138366, -0.271377, -0.955417, 0.218746, -0.487057, 0.648975, 0.251508, -0.836510, 0.953089, 1.936209, 0.720324, -1.699783, 2.260576, -0.264235, 1.680585, 1.754071, 0.314197, -1.810089, 0.358090, 0.774861, 1.570408, 1.445263, 2.361754, 0.598036, 1.833860, 3.034789, 1.868780, 1.957919, 0.771788, 2.200564, -0.591151, 1.373453, -1.073696, 0.270672, 3.136533, 1.388874, 0.037968, -0.514842, 0.507929, 2.485067, 2.068264, 3.163396, 3.034250, -0.045752, 3.027893, 1.746469, 0.849832, 1.242942, 0.184457, 0.948846, 1.181288, 0.446733, -0.002347, -0.042237, -0.021419, -0.116546, 0.223936, 0.032187, -0.341355, 1.133865, 0.162656, -0.001995, -1.183771, -1.063766, -0.348222, 0.067593, 0.321788, 0.261670, -0.570828, -0.931286, 0.014378, -0.106366, 0.334289, 0.643096, -0.719658, -0.391190, 0.370351, -0.306939, -0.096046, 0.000312, 0.250279, 0.069868, -0.068964, -0.045607, 0.360169, -0.424584, -0.472716, -0.239294, 0.024745, 0.238244, 0.103009, -0.097742, 0.290670, 0.068740, 0.532519, -0.070393, 0.653771, 0.298124, 0.693285, 0.174629, 0.012924, -0.541004, -0.371105, -0.582970, 0.063247, -0.109042, 0.133661, 0.271113, -0.075371, -0.088886, -0.184227, -0.418262, -0.007905, 0.241162, 0.188534, 0.089551, -0.058262, -0.087068, -0.011699, 0.140442, -0.144466, -0.094119, 0.110483, -0.060872, 0.160442, 0.098676, 0.281176, -0.228136, -0.300966, -0.152904, -0.258190, 0.207337, 0.170129, -0.125234, -0.117659, 0.119820, 0.074057, 0.139924, -0.256259, -0.386632, -0.263102, -0.209138, -0.378553, -0.094500, -0.003078, -0.202316, -0.527063, -0.215992, -0.004144, 0.011438, 0.095838, 0.140436, -0.191965, -0.155237, 0.047293, -0.275882, 0.457763, 0.178646, 0.294780, 0.056756, -0.133129, -0.579015, -0.339300, -0.443248, -0.305227, -0.098724, -0.024770, 0.262743, -0.488092, -0.083637, -0.499113, 0.084669, 0.766726, 0.808508, 0.697880, 0.629454, 0.582677, 0.521118, 0.983683, 0.294234, -0.631351, 0.817520, 0.888236, 0.282985, 1.266778, 0.880321, -0.225454, -0.024973, -0.118333, 0.863022, -0.341382, -0.154942, 0.357904, -0.611266, 0.206740, -0.583180, 0.630992, 0.589939, 0.096880, 0.186491, 0.082367, -0.156107, 0.143044, -0.001021, 0.079465, -0.135880, -0.110593, 0.384687, -0.065463, -0.071507, 0.679332, -0.000328, -0.201582, 0.603121, -0.412182, -0.247651, -0.147409, -0.617815, -0.116566, 0.109644, 0.332670, -0.213243, 0.137198, -0.368939, 0.300347, 0.230849, 0.320902, 0.401944, 0.716300, -1.359560, 0.155877, 0.610732, 0.236015, 0.357505, 0.394694, 0.106397, 0.292070, -0.174037, -0.330770, 0.145526, -0.212873, -0.553170, -0.377017, -0.744785, 0.336997, -0.089862, -0.262033, 0.030864, -0.493343, 0.375573, -0.229736, -0.035287, 0.002537, -0.221773, 0.219163, -0.268192, -0.005602, 0.171318, 0.496082, 0.632123, 0.165065, 0.133665, -0.034757, 0.293884, 0.450940, -0.012031, 0.241899, 0.541859, -0.007947, -0.092230, 0.940320, 0.282033, -0.116346, 1.118613, -0.315025, -0.213164, -0.087269, -0.502094, 0.073763, -0.068141, 0.068519, -0.149942, 0.156772, -0.225774, 0.375326, -0.056329, 0.313394, 0.263586, 0.284427, -1.092172, 0.718360, 0.840060, 0.924996, 0.639794, 0.568067, 0.262934, 1.036760, -0.845868, 0.105803, -0.376359, -0.469582, 0.601209, 0.373224, 0.042176, 0.246198, 0.396205, 0.213581, 0.176932, 0.378185, -0.243017, -0.515201, -1.117363, 0.201871, -0.599585, -0.436897, -0.271398, -0.206338, -0.656552, -0.219401, 0.381527, -0.105173, -0.198169, -0.418251, -0.425456, -0.559463, -0.142889, 0.019459, 0.844158, 0.120499, 0.196558, -0.166348, -0.038231, -0.443917, -0.156759, 0.076462, 0.171227, -0.210595, 0.331767, 0.176159, 0.191091, 0.002893, -0.455155, 0.834057, -0.676031, -0.255223, 0.043370, 0.338633, -0.140006, 0.232508, -0.403816, -0.006040, 0.146747, 0.170808, -0.152777, -0.186919, -0.101088, -0.141047, -0.145684, 0.549205, 0.422856, -0.443128, -0.417079, -0.378059, -0.574549, -0.209959, 0.369899, 0.542085, 0.225875, -0.315883, 0.180473, 0.268545, -0.053527, -0.071803, 0.070734, -0.004743, 0.198118, 0.309430, -0.058791, -0.395292, -0.245744, -0.219632, -0.401862, -0.278629, -0.263590, -0.407094, -0.229130, -0.113854, 0.683795, 0.360619, 0.248211, -0.100107, -0.165891, -0.703844, -0.088084, -0.085413, -0.185302, -0.098180, 0.013594, -0.264823, 0.219888, -0.258709, -0.577522, 0.558897, -0.581886, -0.262222, -0.102720, -0.003405, -0.011579, -0.274062, -0.366912, -0.526271, 0.013971, 0.183776, -0.088528, 0.235629, -0.321464, -0.744126, 0.575463, 0.417714, -0.233867, 0.188054, -0.098266, -0.560740, -0.751087, 0.017992, -0.136783, 0.158079, 0.536293, -0.067939, -0.076276, 0.529757, 0.862498, 0.305828, 0.738958, 0.686399, 0.754557, 0.882680, 0.210982, 0.254297, 0.453830, 0.392564, -0.449887, 0.939205, 1.021980, 0.087458, 0.523675, -0.166661, 0.418150, 1.125206, 0.890751, 0.722038, 1.206768, 0.860165, 1.073799, 0.966998, 0.594137, -0.364282, 0.371814, -1.272470, 0.083947, 1.009308, 0.854785, 0.487477, 0.322563, -0.827936, -0.303530, 0.234720, 0.974648, 0.988177, -0.521709, -0.302701, -0.230970, -0.601578, -0.289912, 0.041497, -0.939043, -0.061153, -0.614820, -1.051801, -0.455019, 0.800568, 1.195314, 0.204925, 0.242333, 0.254196, -0.165542, -0.216395, 0.533290, 1.103356, 0.320354, -0.372785, -0.259039, 0.030760, 0.858119, -0.519847, 0.072394, -0.446884, -0.472239, 0.743779, 1.093882, 0.707284, -0.054277, 1.127585, 0.141136, -0.261068, 0.224493, -0.693338, -0.037271, 1.444699, 0.598009, 0.712043, 1.027706, 0.615701, 0.618059, 0.850856, 0.754772, 0.212584, 0.495994, -0.849290, -0.433039, -0.010028, 0.286654, 1.049705, -0.311586, -0.639367, -0.545013, 0.328652, 0.316566, -0.852789, 1.191004, 0.226435, -0.387391, 0.163064, 0.559333, 0.386218, 0.188783, 0.084503, 0.792177, 0.060890, -0.425312, 0.323508, 0.182117, -0.331691, 0.032655, 0.051561, -0.129113, -0.361465, -0.669856, -0.649623, -0.507997, -0.129320, -0.098783, -0.428916, -0.603482, -0.527588, -0.195809, -0.214110, -0.323338, -0.279437, -0.775878, -0.446852, -0.521685, -0.821777, -0.237659, -0.748996, -0.187942, -0.453531, -0.806934, -0.251445, -0.225845, -0.461520, -0.044136, -0.160414, -0.133886, -0.252627, -0.522109, 0.098571, -0.855851, 0.016027, 0.563560, -0.538283, 0.880356, -0.209034, -0.197332, -0.165991, 0.270397, 0.066011, 0.205153, -0.270020, 0.051203, 0.373283, 0.075051, 0.240518, 0.279185, -0.106805, -0.619505, 0.056603, 0.225079, 0.089164, 0.052477, -0.491463, -0.051192, 0.162175, -0.193155, 0.016948, -0.278388, -0.146795, -0.010393, -0.075468, -0.176521, -0.398681, -0.005317, 0.627658, -0.057751, -0.030494, -0.318379, 0.086138, 0.227315, -0.291268, -0.656950, -0.145246, -0.404088, -0.787384, -0.027322, -0.745821, -0.139828, -0.370652, -0.541210, -0.349771, -0.004757, -0.500678, 0.152945, -0.066662, -0.356935, -0.523699, -0.466334, 0.107773, -0.658574, 0.098807, 0.475393, -0.143469, 0.648280, -0.080926, -0.174513, -0.365291, -0.056017, -0.250501, 0.290554, -0.208742, -0.026720, -0.435180, -0.290786, 0.223696, 0.237912, 0.201513, -0.188543, -0.739600, 0.609597, 0.423051, -0.224884, 0.007352, -0.547159, -0.867983, -0.637884, -0.213558, -0.011642, -0.072632, 0.534730, -0.349342, 0.043989, -0.329182, 0.704480, 0.615384, 0.584005, 0.084628, 0.075682, 0.073325, -0.461598, 0.079366, 0.009503, -0.200481, 0.045572, -0.133700, 0.562535, -0.163750, -0.878538, -0.714017, -0.777873, -0.535970, 0.349738, 0.023897, -0.360988, -0.167269, 0.672774, 0.023304, 0.165801, 0.200589, -0.193171, -0.457195, 0.441485, 0.649956, 0.172996, 0.117863, -0.321630, -0.477017, 0.626959, 0.784469, -0.380156, -0.076559, 0.201736, -0.054194, 0.203806, -0.078006, -0.130335, -0.146355, -0.098892, 0.250193, -0.098614, 0.235986, 0.857999, -0.542865, -0.616268, -0.436952, 0.219745, 0.130331, -0.107678, -0.393809, -0.116578, 0.106073, -0.402777, 1.437790, 0.010655, -0.103429, -0.161530, -0.130517, 0.214763, 0.503353, -0.495645, 0.345870, 0.140232, 0.363978, 0.222909, -0.374006, 0.746158, -0.360381, -0.947186, -0.516175, -0.446131, -0.076565, 0.109414, -0.293760, 0.033296, -0.306443, 0.836089, 0.289264, 0.829645, -0.061083, 0.141414, -0.320202, 0.426820, 0.705229, -0.075789, 0.187324, -0.750725, 0.315022, 0.197441, 0.748992, -0.470906, 0.092864, -0.966901, -0.296842, 0.885050, 0.888319, 0.332155, 0.188315, 0.374754, -0.483390, -0.683045, -0.705506, -0.519310, -1.585472, 0.470133, 0.664907, -0.707941, 0.481129, 0.055506, 0.034620, -0.392460, 0.102387, 0.932783, 0.611560, 0.854594, 0.652090, 0.694559, 0.647124, 0.431626, 1.159418, 1.671516, -0.028451, -0.369052, -0.551725, -0.036517, 0.762882, -0.323290, -0.301630, 0.030124, -1.031342, -0.365673, -0.791039, -0.909054, 0.394953, -0.111169, 0.565168, 0.443148, -0.373616, -0.589180, 0.726774, 0.325814, -0.277329, 0.483068, -0.179400, -0.207101, -0.144082, -0.248683, 0.392032, 0.208212, -0.196955, 0.606620, 0.254563, -0.836151, -0.959031, 1.119348, 1.061345, -0.028435, -0.925596, -0.104883, 0.243770, 0.328870, -0.508312, -0.280906, 0.105361, 0.882109, 0.254315, -0.288025, -0.362243, -0.130680, -1.002463, 0.288519, -0.206878, -0.005753, 0.582345, -0.557064, 0.190977, 0.115325, -0.115798, 0.059770, -0.721330, -0.541965, -0.238622, -0.417904, -0.430322, -0.040698, 0.452762, -0.356086, -0.383265, -0.698510, -0.326909, -0.052038, -1.169902, -1.191997, 0.140072, 0.353012, 0.478241, 0.100544, -0.581117, -0.145974, 1.051031, 0.001379, 0.259693, 0.969519, 0.081156, -0.421674, 0.236083, 0.449348, 0.144500, -0.017976, 0.087563, 0.950155, 4.286694, -0.508382, -1.952830, -1.614682, -1.917387, -0.819065, -1.111525, -1.903213, -1.876348, -0.395497, -0.770514, -1.838615, 0.088723, -0.447406, 0.093361, -0.216186, -0.258147, -0.825190, 0.058708, 0.648632, -0.308292, -0.033345, -0.405659, -0.569962, -0.228794, 0.436596, -0.401790, -0.231322, -0.740819, -0.966630, 8.972971, 4.472180, 2.819494, 3.119841, 2.783035, 1.448490, 0.418501, 0.015756, 1.182211, -0.959525, -1.125373, -0.472082, -0.269512, -0.103977, -0.723233, -0.663068, -0.612157, -0.721313, -1.375029, -1.436096, -1.661325, -1.051797, -1.324884, -1.998883, -1.857897, -1.285870, -0.179249, -1.155648, -1.218519, -1.044649, -6.072367, 1.348654, 0.609819, 2.466798, 2.417631, 1.040106, 0.179092, 1.063138, 1.143693, 0.382446, 1.087094, 0.365735, 0.236970, 0.189586, 0.252741, 0.850464, -0.107722, -0.051931, 0.378259, 0.138304, 0.269076, 0.403641, 0.464174, -0.472716, 0.229576, -0.288809, -0.829569, -0.304537, 0.257328, -0.338478, 9.313084, 3.220296, 2.831462, 2.623580, 2.287649, 0.911337, 0.689830, -0.487300, 0.567707, -0.261115, -0.740947, 0.368349, 0.531320, 0.480286, -0.360990, -0.423437, 0.039493, -0.140338, -0.676463, -0.614451, -1.055642, -0.563090, -0.866134, -0.827736, -1.352747, -0.696468, 0.662069, -0.579303, -0.713184, -0.480113, 1.106432, 1.320717, -0.795504, -0.609743, 0.334579, -1.977273, -0.861991, 3.354959, 3.496949, -0.132063, -1.575963, 1.612837, -1.213403, -0.504205, -2.864809, 1.404412, -0.925861, -0.558165, -1.749111, 0.437803, -0.226118, -0.246412, -1.568071, -0.654933, -0.365419, 0.346828, -0.003527, -0.908495, 0.679644, -1.009137, -0.248740, 0.283666, -0.465920, -0.952127, 1.942545, -0.229579, -0.844631, 0.546784, 1.539797, 1.731192, -0.227465, -0.667429, 1.732751, 1.834417, 0.187376, -0.072599, 2.281311, -0.620124, 1.585933, 2.254743, 1.853519, 1.469420, 0.067484, -0.819385, 2.425460, 0.859319, -0.625101, 0.985698, -0.467969, -0.238566, -0.493566, -0.913547, 2.478377, 0.458568, 1.862653, 0.086888, 0.101835, 0.176485, -1.598616, -0.577365, 0.261349, 0.227036, -1.797530, 2.500124, 0.240245, -0.223183, -1.779905, -0.384604, 3.077058, 1.774863, 1.219958, 1.243129, -0.306907, -0.188535, -1.650250, 0.340070, -1.718568, -0.251189, 1.460991, 0.590882, -0.385560, -0.163104, -0.229174, -0.668689, 0.294152, -0.216431, -0.427268, 1.390024, -0.045790, 1.231359, 0.668713, -1.292979, 0.018572, 1.285080, -1.273067, -0.039032, -0.730105, -1.394104, 2.360820, 1.569151, 2.778356, -0.277529, 1.086495, -0.643414, 3.089914, 1.491560, -1.023540, 0.395575, -0.473627, 0.740203, -0.689333, 0.774128, 0.218972, -0.282525, 0.281151, 0.526140, 0.337758, 0.275956, -0.335843, -0.352190, -0.685376, -0.593338, 0.169904, -0.225367, 0.023451, 0.545184, -0.032091, -0.410918, 0.067793, 0.036011, 0.294522, -0.104512, 0.399887, 0.108969, -0.770595, -0.845914, -0.927044, -0.304596, -0.808505, -0.408311, -0.310833, -0.699403, -0.434852, -0.360708, -0.268540, -0.636124, -0.839167, 0.133869, -0.819793, -0.222195, 0.293018, 0.088286, -0.605440, 0.387820, 0.477449, 0.516282, 0.248728, 0.101499, 0.349011, 0.190709, 0.106828, 0.115911, -0.176679, -0.472928, 0.123954, -0.613851, -0.165270, -0.490138, -0.083879, -0.022801, 0.261186, -0.000210, 0.367036, 0.341658, -0.800482, -0.157808, -0.050845, 0.573812, -0.263012, -0.603238, -0.401751, -0.226641, -0.055071, 0.259761, -0.137164, 0.085904, 0.042091, 0.024900, -0.042412, 0.105141, 0.178928, -0.049938, 0.031630, -0.395293, -0.145499, -0.388426, -0.504645, -0.038379, -0.075176, -0.119605, -0.295885, -0.604135, -0.376708, -0.130069, 0.100022, -0.603770, -0.811083, 0.062202, -0.594291, 0.041986, 0.117177, -0.187994, -0.477061, 0.288834, 0.451798, 0.332606, -0.109615, -0.192504, 0.090220, -0.369021, -0.318648, 0.113555, -0.264592, -0.240294, 0.222318, -0.591829, -0.173983, -0.366193, 0.065792, -0.010727, -0.386811, -0.089989, -0.595524, -0.372120, 0.021187, 0.093956, 0.166584, -0.205886, -0.667587, 0.657028, 0.358418, -0.095304, 0.104188, -1.040616, -1.069658, -1.211252, -0.294646, -0.023081, -0.302154, 0.472603, 0.087711, -0.253899, -0.233920, 0.321645, 0.234742, 1.046582, 0.944337, 0.724711, 0.868678, 0.080072, 0.104140, 0.124410, 0.138553, 0.209652, 1.223418, 0.615335, -0.019614, 0.084577, 0.348523, 0.444698, 0.144974, 0.113265, -0.321724, 0.125343, 0.116214, 0.276638, -0.102954, -0.295927, -0.352557, -0.173907, -0.038898, 0.443776, -0.135218, 0.103183, -0.263529, 0.294199, 0.028363, 0.087816, -0.082770, -0.069091, 0.023613, 0.356253, 0.180456, -0.171791, -0.477310, -0.148369, -0.112169, -0.018378, 0.054199, -0.051704, -0.027720, 0.243101, -0.142478, 0.013255, 0.006708, -0.146723, 0.162056, 0.026665, 0.308118, 0.001046, -0.168237, -0.274386, -0.212452, 0.296631, 0.168715, 0.107062, -0.145516, 0.332685, 0.053589, -0.036723, 0.461200, 0.513629, 0.253991, 0.139009, 0.931748, 0.471451, -0.086567, -0.127314, 0.106786, 0.058743, 0.217887, 0.311627, -0.071283, 0.089010, 0.257412, 0.458575, 0.119022, -0.246282, -0.166277, 0.166289, 0.092122, 0.754413, -0.074465, 0.345655, -0.100624, 0.320478, 0.170798, 0.217442, -0.179416, 0.124917, -0.045403, -1.069132, -0.502905, 0.625875, 0.328775, 0.010118, -0.223039, -0.293648, -0.730348, -0.712311, -0.232838, -0.094164, -1.272694, 0.869637, 1.543114, -0.204256, 0.967988, 0.815643, 0.351873, 0.088719, 0.589885, 0.726303, 0.287703, 0.704182, 0.082118, 0.405108, 0.306601, 0.224498, 0.987018, 0.967115, -0.091680, -0.350088, -0.083422, 0.100826, -0.136163, -0.009828, 0.088050, 0.595189, 0.132479, -0.224941, -0.023525, 0.211720, 0.412682, -0.027981, -0.167125, 0.808379, 0.379692, -0.209552, 0.374661, -0.125804, -0.345620, 0.073406, -0.239325, 0.622581, 0.059790, 0.209013, 0.081601, -0.061641, 0.150837, 0.609422, 0.236905, -0.039133, -0.475803, -0.208460, -0.019822, 0.504805, 0.197470, -0.125214, -0.035501, 0.142276, 0.409933, 0.257205, 0.197912, -0.417139, -0.221601, -0.417412, -0.392002, 0.153015, -0.007156, -0.317239, 0.206419, 0.107637, -0.105563, -0.013971, 0.102582, -0.093583, 0.299876, -0.236058, 0.202074, -0.304776, -0.343881, -0.395109, 0.040307, 0.169519, 0.045728, 0.020346, 0.158228, 0.384976, -0.219658, -0.401492, -0.223910, 0.224787, 0.044505, -0.109106, -0.066835, 0.440776, -0.068716, 0.010446, 0.366533, 0.038904, -0.164098, -0.093015, 0.158883, 0.394808, 0.316843, 0.100378, 0.108674, -0.151137, 0.009755, 0.329410, 0.428973, 0.774894, 1.339512, 0.690858, 0.290875, -0.586616, -0.340176, 0.378580, 0.059877, 0.723860, -0.601431, 1.492777, -0.245903, -0.284232, -1.092668, -0.701228, -0.652066, -0.307485, -0.271121, -0.344567, -0.242300, -0.661476, -0.159077, -0.394002, -0.042804, 0.216154, -0.822835, -0.408605, 0.257628, -0.587249, -0.217665, 0.151166, 0.627810, 0.196381, 0.091217, -0.082921, 0.288896, 0.331160, -0.023506, -0.551704, 1.282293, 0.422001, 0.633512, -0.018614, 0.526125, -0.078959, 0.274691, 0.641022, 1.071890, 0.401385, 0.996907, 0.398394, 0.956708, 0.586467, 0.110584, -0.144746, 0.301917, 0.109045, -0.223715, -0.058600, -0.036950, -0.287732, -0.062168, 0.183464, 0.250046, 0.445027, 0.209283, -0.502300, -0.003137, 0.037620, 0.121881, 0.192407, -0.217280, -0.106872, 0.110452, 0.265626, 0.094251, -0.423175, -0.481524, -0.465002, -0.592480, -0.039320, 0.184263, -0.130057, 0.038907, 0.107140, 0.331386, 0.243945, 0.010349, 0.107306, -0.352234, -0.141041, 0.412768, 0.062052, 0.316076, 0.026032, 0.129261, 0.171132, -0.243228, -0.574399, 0.778756, 0.112505, 0.601203, -0.188030, 0.140715, -0.447447, -0.115641, 0.098697, 0.820879, 0.060746, 0.324562, 0.101573, 0.945037, 0.267969, 0.021363, -0.141741, 0.114302, 0.323244, -0.030946, 0.039025, -0.938212, 0.899071, -0.365718, -1.291721, -0.674922, 0.021842, -0.027373, 0.425964, 0.303478, 0.928730, 0.372128, 0.270505, 0.871999, 0.385710, 0.093095, 0.900869, 0.647441, 0.771062, 0.333551, -0.365707, 0.263883, 0.412510, 0.465706, 0.176377, 0.346455, 0.201737, 0.219453, 0.643201, -0.019600, 0.729041, -0.442743, -0.853504, 0.082844, -0.323077, -0.634616, -0.309081, 0.343390, 0.868204, 0.553259, 0.088324, -0.130196, 0.813195, -0.039327, -1.050717, -0.173984, -0.205872, 0.237570, -0.251556, -0.710420, -0.441759, 0.212596, 0.155550, 0.573560, 0.819470, -0.312555, -0.475750, -0.147569, -0.422142, -0.241966, 0.233129, 0.255743, 0.456457, -0.931543, -0.606437, 0.115272, -0.781198, -0.738554, -0.618343, -0.017082, 1.084843, 1.105280, 0.588796, -0.292795, -0.393306, -0.247779, -0.471322, -0.176509, 0.024329, 0.259553, 0.245804, 0.470930, -0.812832, 0.315800, 1.095967, -0.621991, -0.182404, -0.638000, -0.703789, 0.797791, 0.382605, -0.616249, -0.838118, 0.312323, -0.598356, -0.410171, -0.225138, 0.270112, 0.086431, 0.608872, 0.878988, 0.227110, 0.600834, 0.354722, -0.734420, -0.208714, -0.401226, -0.204967, -0.195783, -0.810333, -0.502575, 0.439750, -0.213656, 0.559411, 0.897857, -0.385868, -0.358683, -0.195474, -0.054817, -0.046823, 0.252375, -0.767673, 0.717420, -0.313532, -0.364318, -0.157433, 0.495460, 0.520391, 0.224375, 0.177624, 1.019689, 0.403015, -0.304749, 0.535153, 0.669898, 0.074661, 0.474048, 0.770662, 0.453355, -0.039726, -0.024537, -0.230874, 0.293567, -0.051913, -0.225778, -0.364325, -0.823826, -0.475286, -0.628915, -0.205904, -0.279170, -0.264833, -0.477399, -0.477002, -0.414615, -0.008088, -0.008887, 0.135613, -0.227849, -0.230295, -0.208571, -0.704728, -0.111843, 0.207962, -0.323041, 0.649055, -0.438733, -0.029510, -0.336278, -0.397249, 0.360715, -0.098704, 0.384615, -0.044350, 0.598742, 0.214555, 0.473663, -0.258164, -0.045811, -0.250899, -0.313670, 0.324970, -0.111069, 0.145952, 0.218984, -0.330769, -0.535423, 0.022897, -0.125152, -0.266575, -0.516230, -0.245063, -0.281293, 0.149257, 0.317991, 0.501274, 0.091103, 0.302563, 0.393343, 0.052500, 0.457648, 0.456021, -0.006557, 0.111723, 0.431839, -0.005615, -0.304997, -0.033438, -0.101145, 0.003165, 0.653026, -0.192855, -0.296127, -0.399738, -0.332141, 0.085521, 0.145742, 0.222808, -0.051607, -0.091630, 0.079718, -0.337919, -0.106790, -0.184510, -0.554376, 1.238030, -0.155489, -0.202542, -0.086431, -0.680765, 0.473324, -0.200786, 0.403845, -0.138170, 0.664420, 0.231595, 0.103811, -0.513891, -0.177748, -0.384787, -0.197529, -0.014783, -3.545193, 4.330442, -3.866667, 0.979905, 0.997026, -0.152433, 2.021183, 0.120796, 0.365614, 0.666346, -0.341523, 1.414789, -1.109074, 0.966688, -0.672280, 0.213307, 0.526739, -0.885727, 0.934506, -1.378207, -0.407758, -0.514108, -0.067516, -0.116628, -0.204282, -1.028163, 0.886970, -0.465287, 0.811147, -0.157569, 1.874722, 4.738497, 5.584600, 4.649197, 3.119471, 0.602911, 0.272365, 0.917109, 1.655478, 0.194610, 0.171318, -0.065934, -0.063060, 0.705243, 1.547092, 0.318787, 0.592914, 0.626980, 0.385268, 1.181120, -0.063386, 0.029866, 0.168399, 0.444718, 0.584238, -0.111197, -0.533851, -0.454721, -0.132526, 0.303372, -0.294731, 0.022869, 1.218484, -1.522922, 0.558918, -0.449024, 0.384435, 0.240048, -0.229913, -0.579158, 0.114137, 0.069081, 0.242150, -0.197117, 0.343408, -0.032606, 0.311811, -0.388741, -0.070652, -0.632913, -0.004766, 0.502978, -0.145130, 1.213853, 0.175603, 0.317928, -0.148894, -0.438384, -0.987172, -0.161355, -0.155465, 1.015088, 1.191018, 1.111111, 1.068865, 0.254742, 0.360881, 0.145962, 0.913035, 0.393539, 0.303053, -0.562928, -0.189881, -0.376315, 0.911270, 0.211439, 0.019218, 0.349987, 0.593025, 1.139627, -0.414139, -0.558414, -0.761393, 0.402184, 0.366453, -0.180620, -0.676201, -1.003929, -0.046332, -0.288384, 0.114833, 0.375926, 0.202944, 0.588719, 0.527520, 0.498720, 0.094647, 0.463054, 0.077306, 0.306036, 0.348816, -0.001018, 0.429760, 0.191575, 0.222478, 0.653785, 0.876554, 0.009308, -0.298158, -0.033844, -0.063966, -0.165117, -0.338382, 0.103737, -0.248645, -0.042730, -0.472535, 0.080175, 0.327221, 0.135699, 0.323415, -0.008064, -0.308760, -0.514899, 0.209776, 0.379507, 0.094735, 0.586194, -0.563060, -1.104218, -0.420844, 1.097574, -0.221976, 0.389559, -0.121116, -0.249858, -0.480820, 0.061826, -0.608002, -0.104800, 0.046615, -0.250373, -0.444777, 0.374969, -0.342452, -0.291605, -0.177168, 0.723720, 0.449492, 0.025375, 0.736412, -0.019717, -0.080759, 0.030913, 0.560501, -0.115111, -0.683907, -0.978436, 0.108724, -0.108806, -0.101257, -0.027616, -0.501491, 0.012461, -0.264336, -0.696792, 0.263691, 0.070445, 0.229288, 0.364880, -0.370610, 0.145194, -0.249037, 0.061542, -0.059276, 0.057704, -0.068677, 0.389460, 0.711754, 0.240091, 0.409029, -0.297394, -0.425533, -0.199067, 0.537719, 0.787586, 0.166700, 1.077396, -0.076008, -0.901418, -0.202420, 0.650979, -0.450089, 0.335573, 0.088881, -0.154732, -0.553589, 0.133786, -0.295126, -0.322931, 0.058559, 0.211465, -0.645159, -0.122500, -0.408128, -0.112974, -0.202264, 0.005686, 0.520711, 0.857060, 0.095619, -0.092385, -0.784139, -0.447098, 0.145612, -0.436826, 0.117393, 0.553132, 0.034279, 0.282180, -1.683418, 1.566255, -2.432622, 0.719344, 1.097797, -1.943850, -1.096190, -1.384524, -1.314593, -0.790731, -2.676393, -2.297937, -1.552118, -2.508725, -1.594330, -1.292588, -0.988340, -1.394901, -1.325055, -0.475038, -0.861384, 0.010555, -0.164045, -0.521763, -0.509916, -0.068371, -0.135474, 0.052043, -0.154979, -0.241280, -0.453977, -0.232495, 0.114616, -0.390255, -0.123160, 0.034766, 0.160124, -0.264994, 0.230742, -0.220883, 0.377329, 0.116201, 0.019685, -0.297092, -0.182423, -0.504967, -0.121648, -0.594946, -0.524503, 0.041859, 0.358772, 0.163418, -0.219026, -0.272002, -0.207132, -0.557337, 0.063464, -0.404037, 0.136652, 0.675801, 0.331021, -0.228429, -0.583958, -0.163476, -0.076156, -0.149481, 0.402400, -0.067367, -0.089712, -0.245097, 0.260612, 0.299197, -0.109843, 0.648779, -0.104906, 0.159370, 0.134595, 0.300239, 0.199490, -0.477424, -0.679814, 0.321785, 0.222487, -0.568287, -0.627549, -0.033532, -0.015586, 0.135797, 0.123279, -0.598525, -0.138795, -0.636929, -0.028497, 0.225571, -0.057520, 0.319307, 0.264141, -0.141256, 0.213986, -0.136291, 0.483381, 0.129119, 0.147818, 0.017777, -0.001703, -0.074591, 0.205110, -0.389578, -0.006514};
static RBF_CONST rbf_float RBF_WIDTHS[] = {5.815423, 4.463504, 7.020917, 4.309270, 4.108936, 4.490563, 6.173822, 6.591603, 3.594580, 12.601808, 4.190336, 3.360486, 8.814716, 4.607722, 5.495434, 8.344665, 4.299229, 3.874027, 4.501024, 4.382591, 3.826362, 7.062501, 4.652142, 5.347158, 3.933147, 9.024671, 3.360486, 4.992995, 5.014775, 3.819209, 4.800591, 5.073739, 4.357958, 3.687834, 5.625273, 4.490563, 5.795904, 6.776073, 10.590479, 8.188748, 3.666544, 5.043832, 5.081524, 5.025842, 3.567102, 4.839817, 4.957175, 4.669273, 4.246985, 3.986494, 4.033123, 4.175576, 4.552665, 4.552665, 5.157276, 5.147325, 8.188748, 16.793728, 6.301378, 4.729265, 4.264956, 4.229399, 4.501024, 5.091095, 11.261278, 8.344665, 5.077276, 4.299229, 5.233706, 6.883006, 4.941067, 4.711191, 4.330199, 4.190336, 4.680407, 7.820043, 4.954930, 4.900126, 5.319416, 4.463504, 3.639879, 3.571125, 5.236509, 12.541470, 5.382061, 3.981133, 4.851368, 5.315528, 3.981133, 3.953164, 4.340780, 4.324255, 3.666544, 5.020670, 4.132742, 4.132742, 4.629982, 3.639879, 4.763510, 9.824356, 3.594580, 4.816210, 4.668836, 5.169548, 5.281004, 4.455773, 4.330165, 15.727615, 5.093865, 3.973263, 5.247398, 4.847520, 4.081175, 3.874027, 6.014672, 4.879413, 3.986494, 4.576635, 3.573007, 4.392986, 13.419037, 4.746372, 4.607722, 4.330165, 11.137012, 4.414448, 4.357958, 10.416191, 4.482838, 3.571125, 3.973263, 16.683289, 4.309270, 3.939128, 4.307170, 6.438273, 4.414448, 5.097430, 5.791990, 9.024671, 13.407537, 4.567041, 3.567102, 4.033123, 4.321990, 5.706921, 4.139800, 9.824356, 4.932161, 4.340780};
static RBF_CONST rbf_float RBF_WEIGHTS[] = {-0.790188, -4.243255, 3.104874, -12.392812, 3.946257, 10.141421, -3.061191, -1.142947, -2.792309, -1.486319, 7.252064, 1.449332, -1.166641, -5.471513, 5.682258, -14.704849, 7.936801, 3.492166, -22.808441, 6.336247, 12.070696, -1.486430, 3.937939, 5.832833, -4.891593, 5.685879, -2.948806, 1.108150, 0.837484, -2.132562, 0.252936, 3.898568, -2.764410, 2.004473, 1.371259, -2.629264, 2.334683, -1.241238, -4.028735, -7.864839, -6.756901, -1.467392, 5.173781, 9.828816, 2.347343, -18.288571, -2.832221, 22.997017, 5.930625, -9.202584, 3.154352, 3.043519, -8.813505, -7.800848, -4.791760, 7.800913, 4.452869, 20.535931, -20.708059, 6.370811, -1.671330, 5.745750, 1.352288, 2.506987, -7.262739, -3.227055, 7.371459, 4.497975, 2.979113, -5.644230, -6.747174, -0.022423, -0.180000, -2.413443, 2.462849, -6.282324, 5.228068, 5.939708, -2.259553, -3.252911, -4.781983, -0.394252, 0.749400, 5.350002, 4.953446, -0.909914, 1.176121, -9.219656, -12.710857, -5.524314, 1.418761, 10.496935, -0.026813, 1.389446, 0.151676, 8.770689, 33.161338, -8.951295, 3.156692, 7.706237, -31.045054, -30.582865, 7.695518, -2.663365, 2.836605, -4.533607, 2.902526, 21.539013, -1.456874, 8.239976, -1.773400, 1.923967, -6.769684, 1.313270, 2.813990, -1.524654, 0.267259, -2.678801, -2.736766, 2.235004, -2.076455, 2.721406, -6.139391, -4.546494, 5.741335, 4.321070, 0.618892, 17.386971, -4.658827, -6.954114, -6.605001, 0.117778, -9.480967, 3.363409, 29.439817, -5.920375, -7.237179, 12.596148, -33.356982, 5.881069, 1.436130, 4.007943, -3.740023, 2.517276, 0.271222, 0.078010, 2.821647, 2.657754, 3.655486, -4.558181, 4.560810, -2.166233, -1.261776, -1.330679, -5.599413, 1.095527, 12.163649, 1.711399, 9.051035, 1.208315, -2.121524, 7.390488, -17.395054, -0.052954, -3.259587, -4.563959, -8.967337, 5.293622, 1.690451, 3.849353, 0.556471, -0.040120, -0.412483, -7.841842, -5.051183, -3.746742, -6.769839, 0.748216, 12.252600, 4.981086, 0.033659, 3.155763, 1.931217, 0.058085, 1.338710, -0.544793, -1.546656, -1.584866, 0.498499, -1.088751, 0.869412, -3.139234, -15.269745, 7.224487, 15.128291, 73.197620, -29.948580, -8.763842, 12.660202, 0.395606, 7.125475, 3.759852, -44.136468, -21.572132, -8.005327, 39.175775, -14.867713, -0.971427, 3.456580, -37.417518, -0.290847, 17.347412, -0.875425, -0.000598, -9.226740, 11.146777, -5.398078, 2.823506, -10.271683, 3.869756, 6.182992, -10.389827, -0.034899, 3.722938, 5.371769, 8.300868, -1.688569, -2.855776, -4.621912, -4.944592, -1.375161, 3.398116, 0.260810, 11.405646, -3.564678, -5.227077, 2.549726, 5.141269, -5.095211, 1.870019, 38.512431, -18.841831, -2.153763, 5.355725, -9.255501, -3.666633, 1.661062, 8.558840, -1.011740, -6.084879, -13.717285, 2.002525, 2.339527, -3.064362, 8.614053, 1.622842, -10.819079, -2.634113, 5.445230, -2.277606, -2.705826, 1.940432, 1.543340, 0.167913, -9.462966, 2.221802, -5.705098, -6.928865, 4.715125, -0.993589, 1.971047, 8.445401, -2.699012, 4.577424, -3.632276, 7.156700, -5.883883, 6.928257, -2.827650, 4.078022, 1.736650, 3.150521, 0.824149, 0.149039, -2.545435, 0.702023, -4.425284, -2.081091, 0.247580, -5.207232, -5.718651, -14.406832, -7.022735, -1.323088, -4.398566, 0.490222, 5.213157, 5.217299, 22.231361, 4.283069, -0.839766, 0.513506, 0.080474, -4.735270, -3.656643, -5.939639, -7.507820, 12.023948, -2.781654, 5.771791, 1.515247, 5.404074, 3.296193, -0.548746, 22.877739, -1.790942, 6.385229, 11.247167, -4.451706, -0.078458, -16.102139, -0.888609, -21.494499, 2.245161, 3.233946, 3.721830, -0.832020, 1.794876, -2.532277, -1.188280, 9.108345, 5.296881, 0.205754, -2.240722, -8.282505, -8.266782, 0.505426, -2.252979, 0.028725, 1.493713, 1.901607, 5.876764, -4.789685, 1.145235, -3.153764, -5.369574, 6.024847, -1.294095, 18.193977, -17.975846, 2.870118, -12.725795, -4.457718, -5.899532, 7.052712, -0.026829, 0.743443, -0.715193, 11.359786, 2.226349, -14.598951, 6.102232, -4.467622, 2.660163, 7.916949, -3.715374, 8.254996, 1.510276, -4.163455, 1.683714, -1.014029, -0.466235, 4.450104, -4.599655, -2.538234, -2.904316, -6.004318, -1.043047, 16.464128, 5.975990, 4.164348, -9.116631, 0.649215, -5.424107, -1.531442, 12.754012, -2.538521, 6.893114, -13.778217, -2.195687, 3.402095, -5.650957, 7.428027, -1.967974, -3.137200, -0.044507, 8.983850, -5.832451, -4.383999, -20.329787, 7.605792, -0.549626, 0.929796, -4.724414, 3.140166, 8.032796, 8.137918, -0.975680, 6.321939, -6.895683, -2.053705, 0.941747, 0.196719, 0.579719, 1.460926, -3.159087, 7.566777, 0.873995, 4.919724, -10.746541, -1.897212, 1.525664, -0.862618, -5.381622, 0.982628, -12.265987, -1.312256, 5.200639, -0.955968, 2.186624, 1.359978, 11.423299, 6.714935, -8.542122, 7.330256, 2.253033, 1.159168, -1.857807, 2.015137, -1.967169, 2.072686, -6.306324, -0.946685, -1.483604, -1.157753, 9.445673, -4.665275, 0.925576, 5.634474, -5.599345, -9.474986, -3.923674, -0.188365, 5.330949, -4.290420, 7.882687, 0.679070, 2.521535, 4.266313, -1.011595, -1.686675, 3.979288, -0.915305, -3.368202, -1.247941, -2.667516, -1.198422, 0.709669, 1.828745, 0.771260, -2.574856, -2.610409, 0.252848, 1.080909, 1.366111, 2.969253, 2.404744, 0.053861, -1.023246, -4.628580, -8.811785, -2.373484, -2.301859, -15.893263, 20.653912, -1.604834, 19.438552, 12.673008, -7.007049, -26.831580, 5.960385, 6.436999, 0.079683, 8.548120, -8.158815, -5.534308, -2.463594, -11.107082, -6.455738, -1.353237, 1.474182, 9.687994, 0.392492, 14.665357, 2.602061, -1.654537, 2.232273, -3.089053, -0.052288, 5.399081, -3.372324, -1.949858, -0.839886, -0.510992, 3.863175, -2.583063, 15.207895, 3.641155, -19.601595, -3.661649, -19.424650, -16.077950, 46.994627, -2.840004, -6.948629, 2.622079, -1.965102, 2.505948, -5.320711, 6.273373, -6.612838, -0.996219, -1.956068, 11.989709, -0.635146, 4.893794, 4.975211, 2.438791, 0.418212, -16.160780, 3.817164, 1.397249, -3.425082, -2.870102, 10.867081, -6.082579, 8.491977, 9.001706, -8.984776, 0.814634, 0.042844, -12.806051, 9.264525, -7.563073, 1.786654, -7.235044, 4.270098, 6.468005, 7.192569, 1.993772, -5.672560, -10.181432, 5.237381, -5.044287, 2.899318, -6.047689, -5.374196, 5.472913, -1.361443, 2.428208, 4.021240, -3.150680, 5.999896, 2.496801, -4.070684, -3.331817, -5.090754, 0.337401, 0.694313, -2.995757, 8.266916, -2.579477, 1.794328, 2.975817, -6.774969, -1.386505, 4.667544, 0.172754, -13.228494, 0.772345, 5.723362, 4.134191, -4.753388, 8.242106, -13.914685, -13.722244, -0.676557, 17.416490, 5.716195, 3.750675, -8.405082, -15.279494, 17.245737, 8.507898, 12.918349, 13.103322, -6.681133, -11.507296, -3.081021, 4.156892, -6.932547, -3.770982, -2.672618, 4.431776, -4.867586, -1.742582, -9.053741, 1.347355, -7.399513, -0.368425, -7.543854, 16.750687, 3.891663, 6.923887, 7.706017, -2.899215, -5.103820, -12.062312, -4.711626, -0.609903, 5.532664, 10.799068, -7.258070, -0.916020, 9.493287, 0.186280, -1.549421, -5.000285, -1.808157, 1.634704, 6.286521, 2.204043, 2.975753, 1.996367, 6.521529, -4.138996, -2.977595, -6.219900, -4.013276, 5.806493, -7.143106, 9.994926, 2.205940, 7.435464, 5.011866, -0.075545, -6.702136, -2.792656, -1.988417, -7.772578, -1.968438, 1.306295, -0.558238, -3.291727, 3.390790, -7.903408, -5.119742, -0.944259, -0.613034, 6.599869, -1.079664, 10.165796, 0.025053, 6.631358, 2.286186, -0.930744, -1.619255, -1.964738, -4.900014, -0.316947, -2.765222, -0.138264, 3.138626, 0.528781, -0.770040, -0.770732, 0.043372, 0.259245, 0.169798, 2.429935, -1.541698, 1.281784, 3.550410, -0.787556, -0.602426, -3.396894, 1.404312, -3.801162, 0.326410, -4.409610, 1.164696, -2.622592, 7.321658, -1.394423, 2.719617, -0.937836, 3.693129, -3.429531, -3.840709, 15.295284, 1.587595, -1.373369, -0.356473, -6.594165, -8.070183, -3.300861, 8.203134, 1.315831, -8.728615, 5.468430, -8.449370, 4.178414, 7.159084, 11.509041, 3.197177, 5.151425, -9.335547, -7.843472, 0.064208, 7.812602, -11.353838, -2.282327, 15.005427, -15.885445, 4.702105, 0.753735, -5.811425, -0.329716, 7.792661, -1.910743, -6.980339, -10.217489, 13.776183, -0.002173, -1.264916, -10.672309, 0.811975, 1.689608, -0.329478, 2.657594, 6.351975, -5.351320, -0.387942, -0.115998, 3.661211, 3.126495, 3.276323, -14.204809, 0.446192, 3.778366, 8.210990, -0.220128, 5.986607, -8.801128, -6.102713, 7.376833, 12.383352, -11.721635, -1.604848, -0.746433, -1.638182, -0.475634, -3.188592, 4.315829, 2.607487, -1.224625, 1.682115, -1.735827, 0.116841, 1.786886, -1.141200, 7.232246, -2.984002, 1.537947, -0.027971, 4.322779, 2.239779, -8.989172, 0.157103, -2.391690, -2.787163, 2.794082, 3.382914, -5.352740, -2.140279, 2.755103, -0.490767, -2.917188, -0.994890, -3.056040, 5.710622, -1.480197, 1.366830, 3.323228, -8.445663, 14.974094, 1.029001, 14.687400, 9.069261, -15.234048, 1.707294, -4.054892, 2.686756, 5.049013, -7.122768, -14.593559, 1.915455, -12.552720, 3.279707, 11.938807, 6.446731, -1.344861, 2.956848, -8.920483, 2.982535, 6.955676, -4.972479, -8.395564, -4.265093, 5.869673, -0.692259, -0.807076, 11.103925, -5.337118, 6.207925, -4.421607, -5.911432, -3.742555, -2.278854, 4.496190, 0.897293, 5.896708, -0.587201, -4.962860, -2.670268, 0.632709, -3.377748, 2.461382, 3.153859, 3.913012, -4.789375, -0.835699, 3.510760, -4.989384, -2.407010, 5.820561, 3.012861, 1.190061, 3.541353, 4.987841, 1.905960, -5.074455, -5.474605, -5.846342, -7.884320, -14.240218, 2.988212, -5.571335, -4.772849, 30.671640, -8.999837, 4.473312, 1.338327, -5.225829, 5.631836, 1.204613, -2.701844, 6.868689, 0.256955, 8.796801, 1.452588, -4.917902, -6.815469, 5.629095, 4.745618, 5.491292, -8.082918, -11.050338, -1.786489, 3.554359, 9.696581, 19.276236, -21.830447, -23.557915, -12.782024, -6.704827, 6.094621, 42.514602, -4.594480, -10.484885, -2.279314, -3.555955, -2.585611, -2.659731, -9.728208, 1.110580, -3.035124, -1.057797, 3.494841, 9.576271, 0.021942, 10.398402, 0.621978, -2.440645, -0.886178, -1.624212, -7.945362, 6.602689, -1.381549, 0.650128, 1.438069, 1.982620, 1.963946, 0.848823, 7.258735, -1.355853, -5.428686, -10.972674, -7.339672, 7.652295, -1.308307, 7.406066, 1.931508, 0.238116, -0.707297, 2.488019, -0.566697, 1.807958, -2.743461, -4.808726, 0.744086, 8.715512, -0.318090, 2.106678, -1.475830, -0.556669, -0.561984, -2.493468, 3.990117, -6.694356, -0.482210, -1.960541, 9.342696, 4.234327, -0.126201, 3.694688, 8.889686, -6.823095, -9.836008, -4.145340, -17.773980, -3.297575, 11.084145, 3.180577, -12.791190, 51.092896, -21.450729, -7.639336, -6.418934, -0.563039, -3.052300, 6.972366, -3.991170, 7.297457, 5.348780, 10.302433, 7.371480, 9.033422, -0.826797, 0.533819, -15.079986, -5.893675, -10.301527, -3.440052, -1.263590, 3.948391, -3.722008, 1.554341, -0.446788, -3.148165, 0.669877, 3.948135, -0.679160, -0.868399, 1.227455, -1.315911, -0.142359, 0.319376, -1.301454, 2.023660, 1.170310, -2.763170, 2.883811, -0.252631, -2.323733, -0.252499, -0.844428, 1.595731, -5.782557, 3.681433, -4.219797, 2.074273, -2.015060, 3.593085, -10.795646, -6.085164, 0.144297, 13.249814, 4.618745, 1.101641, 4.593828, -11.021710, -3.177170, -10.144982, 17.682845, -22.809428, 10.024360, -4.652848, 14.390324, -4.149855, 16.634572, -7.175804, 6.324449, -17.126439, -0.425351, -6.878026, 3.312951, -7.357022, 5.946660, 0.111365, 13.313153, 3.990070, 6.929964, -8.138346, 6.503216, -10.520734, -4.450397, -1.840914, -0.611343, 6.480192, -4.736201, 0.749141, 4.321999, 1.180037, 6.408416, -3.458585, -1.900341, 37.971072, -2.382669, 10.183282, -3.300127, -19.665512, -10.719242, 14.599198, -4.245805, -2.121694, -24.579630, 5.909128, 6.033488, -13.817081, 5.536412, -12.206084, -1.617132, 10.518499, -7.704958, 5.044482, 4.445787, -4.350220, 6.560189, 1.620786, -3.550734, -0.949837, 15.192273, -8.476060, 1.385740, -0.953891, -2.446201, 4.892200, -2.739998, -2.580504, -4.003231, 4.309398, -15.818443, 2.535030, 8.219467, -2.031914, -8.717114, 10.387297, -4.506246, -4.902462, -7.583142, 1.635624, 2.967217, 17.514420, -13.469335, 3.581115, -9.424988, -2.861736, 40.013779, 11.387837, -29.147643, 1.790719, 3.222673, -14.848180, -2.129611, 11.751401, -3.389705, 6.670120, 4.039914, 1.057178, -1.693176, 9.677179, -3.303362, -3.775301, -8.812092, 7.370524, -0.317136, -7.668575, 8.432351, -14.411443, -9.438144, -7.655527, -2.665055, 15.342564, 31.621612, 10.485965, 6.242822, -23.444067, 2.416472, -16.744662, 3.124527, 10.700947, -6.529038, 1.331916, 0.330103, -26.870092, 7.635720, 3.553000, 0.050517, 5.123572, -9.542319, 11.249011, 3.453554, -20.497371, 5.451521, -3.721016, 7.558480, 49.111547, -10.420756, -6.868188, -15.430161, -11.759721, 14.595507, -11.007213, -4.004765, -26.494788, 23.360721, -14.704456, -4.457662, 37.705090, -11.347780, -5.799726, 8.316365, 1.186817, 3.929972, -8.001696, 0.288428, -0.754965, -7.203181, -6.607584, -0.279498, 1.441459, 8.764026, 1.497363, 5.117998, -1.835304, 2.662620, -3.308710, -1.713180, -0.006211, 1.547873, -5.265151, 10.313783, 0.576152, -1.565925, 1.866797, -3.251555, -0.535337, -0.984565, -0.904468, 21.445793, -6.726763, 0.023218, -8.876742, 1.815344, 3.920320, 8.739927, 3.490744, 1.941543, -15.623549, -1.944406, -7.504030, -1.417314, -3.834651, 1.051274, -0.060553, -0.519625, 9.481462, -3.266988, -0.817320, -2.102949, 0.263700, 2.542388, -1.356870, -2.667768, -1.523142, -14.348154, -7.691325, -2.495219, 5.629443, 0.694862, 4.340570, -0.705074, 4.921219, 4.655263, 8.854591, 1.097402, -6.135120, -3.374495, 0.972983, 2.430128, -1.036386, 1.873840, -3.340695, 5.606467, 5.826495, -0.623863, -3.368893, -2.695748, 2.598142, 6.204304, 9.506399, 11.440780, 6.917978, -4.222692, 2.536356, 5.891748, -7.058606, -22.081564, -9.033692, 10.695487, -4.895303, 4.688215, 7.313320, 1.460964, -10.414310, 0.583757, -0.222785, -3.161639, -1.092281, -8.209821, 3.945882, -3.340897, -6.352056, -9.071787, -13.846979, 5.728816, 13.255977, 9.777998, 2.073945, 5.839888, -17.730126, 9.994366, 3.517932, -0.751970, -3.349988, 2.808295, 9.993521, -2.852372, 2.336187, -2.968466, -3.526746, 0.310442, -0.129132, -0.912977, -0.868722, 12.045035, 0.453330, 5.810179, 13.040974, -0.946111, -10.004025, -0.152283, -2.852168, -16.991059, -0.093545, -1.984292, 2.665771, -2.842362, -5.605977, -7.389652, -2.937260, 8.320275, 17.283073, -3.296756, -1.554551, 0.637730, 0.163202, 4.809357, -7.814397, -26.547394, 35.967711, 2.080593, 3.197282, 1.311836, 4.056354, -4.114771, -6.411700, -17.304702, 1.117107, -5.104019, 11.105776, -5.756728, 3.565694, 3.650731, 6.151333, 0.522946, 8.306569, -5.679293, 4.119855, 0.553081, -1.812338, -8.063518, -5.796430, -0.393162, -5.554678, 5.989144, 7.585708, -0.970470, 3.051560, -5.934033, -6.406476, -2.056608, -2.824375, 15.559576, -7.896214, -25.286562, 43.289094, -14.546549, -1.577239, 0.046151, 2.486625, -13.946407, 1.938188, 0.611814, 4.417801, -11.959195, 13.127759, 1.995767, 6.815296, 0.650028, 8.531481, -9.670615, 14.246433, -1.688160, -6.302590, -1.836310, 0.879978, -5.703145, -8.037963, 0.563958, -13.368792, 14.378202, -0.854169, 2.875139, 5.589291, -0.961997, -6.732354, 1.324743, -9.369623, 6.716872, 0.231605, -8.741156, -1.148515, -1.833763, -1.574413, 0.510808, 13.240464, -1.283076, -4.669602, -2.848200, 7.062127, 3.429480, -2.513918, -2.494110, -11.743321, 2.740062, 0.582364, -12.681483, 8.025532, 16.334322, -1.029334, 4.754418, -4.353099, 7.680756, -7.967191, 0.969916, -6.113822, -2.589105, 11.218077, -9.396108, 0.138914, 0.323733, -16.684369, -5.169763, 3.595098, 15.003204, 9.004344, 13.326230, 3.930632, 0.359018, 6.838093, -1.738839, -9.884575, 13.850026, 2.644591, -6.667253, -11.189251, -3.669370, -7.075614, 1.610023, -0.660961, -0.499480, -4.448303, 0.787539, 2.262962, 0.779728, 1.291580, -0.390401, -4.437411, -0.206304, 3.997396, 4.182759, 8.289245, -1.526404, 7.298952, 10.443479, -13.923582, 0.959578, -5.616317, -0.040467, -5.344415, -5.028645, 0.709328, 8.006384, -5.506406, 1.169200, -3.106210, -13.278330, 2.325582, -9.692791, 4.663548, -9.524258, 3.264552, 8.185044, 13.798948, 1.864354, -6.642639, -7.632245, -30.672782, -4.518098, -11.000169, -0.328034, 4.210614, 11.002719, 1.840257, 35.185760, 6.175102, 0.054914, -6.143133, 0.127992, 2.258542, 5.326846, -1.880064, -1.666520, 4.606193, 1.067240, -3.052764, 3.058783, -3.655326, -7.814782, 14.300951, -7.029933, -21.745801, 54.797746, -28.311386, -6.886758, -10.542390, 2.561182, -1.679364, 19.029117, -6.634478, 1.111340, -5.087807, -2.296110, 2.637529, -5.897660, -5.506966, 2.299511, -0.985714, 8.832197, -0.259181, 6.825035, -1.809697, 2.226976, -7.060671, 1.298864, 2.267290, -4.479137, 7.926478, 6.281598, -5.587735, 3.180372, 2.044875, -0.473103, -7.636028, -1.511476, -3.860487, 4.921236, 3.118512, 7.757239, -18.715322, 26.019099, -3.792447, 5.239749, -10.695404, 4.384335, -12.540581, -3.390022, -0.533356, 4.542236, 37.293082, -22.717153, 9.050418, -1.006394, -10.889294, 0.446561, 12.399230, -22.849497, -2.414618, 8.127785, 8.633564, -20.292240, 3.593455, -14.382463, -17.616966, -4.948144, 2.689867, 8.047928, 29.137163, -1.409014, -2.200533, 0.006328, 2.329574, 0.011539, -0.209958, -1.514350, -3.079416, -1.145561, 0.052939, -0.730161, -0.690454, 0.499139, 4.498303, 2.578476, 16.805478, 0.521281, -11.042458, 0.304936, -21.644489, 1.363969, 9.934414, 6.472240, -3.536658, -13.718305, 11.848154, -8.348163, 30.465604, -15.005404, -2.584359, -5.340328, 1.050215, -8.649583, 9.573249, -0.735675, 1.361944, -8.451490, 5.810598, 3.876297, -3.385356, 0.435287, 10.305736, -0.249577, -20.487724, 32.885325, -1.353785, -1.401832, -20.375373, 7.129955, -6.644040, -3.195795, 5.967160, -4.884389, -1.654525, 0.874238, -2.353216, 0.618043, 3.138420, 3.850415, -2.165162, 2.640113, -3.138087, 5.696167, -9.634487, -5.587740, -14.468134, 15.694444, 0.170389, 1.070435, -1.301796, 15.570556, -1.978561, 1.004811, -6.338690, -8.397717, 1.782801, -3.058671, -4.240172, 0.029652, 15.686868, -3.285799, 3.137029, 2.752619, -0.371377, 3.315182, -7.942719, 2.812892, 1.414936, 1.913582, -2.668517, -3.175746, -16.014379, 2.494090, 3.804145, 1.887467, -1.414931, 5.704895, 3.346030, 1.079358, -4.984484, -2.947704, -0.171350, 11.014511, -3.841211, 3.631320, 0.033077, -0.597922, -1.934686, -0.043322, -0.990311, 0.229309, -2.218518, 2.651366, 1.602724, -3.600750, 1.333969, -3.455717, -4.233748, -2.079219, 3.786609, 2.284889, 3.762504, -7.821032, 5.485626, 2.045343, 2.148993, 2.553003, 13.538776, -19.810067, -15.127812, -3.064071, 7.430197, 6.797752, 5.538097, 0.878217, -18.440045, 0.962771, -15.897062, 5.624337, -2.363176, 5.547112, -3.383612, -14.527729, -0.879405, 33.857983, 9.177797, 0.822539, -4.934521, 36.793094, 25.028969, -13.350986, -10.748255, -11.603220, -4.785562, -3.797852, -3.302157, -8.302346, -1.133374, -1.994366, 3.622935, 7.551299, -5.842035, 7.968655, -5.744254, -5.174584, -1.748656, 1.252726, -9.675037, -1.745373, 11.734015, -4.818421, 4.147539, -3.857448, 1.680745, 9.793447, -1.512549, -5.822876, -1.935236, -4.986783, 1.341173, 1.756627, 4.235541, 6.932428, -0.870986, 2.639959, 3.679142, -9.635565, -6.848918, -3.691268, 1.474507, 5.014835, 6.818435, -2.797889, -2.736030, -1.772904, -3.119964, 1.852315, -1.528491, 13.599499, 2.136418, -2.750931, -0.940445, 0.221160, -2.408097, 0.627035, -5.824203, 0.345798, -3.275993, -7.158027, 9.068266, -1.517805, 1.021758, 9.943756, -9.425427, -4.491188, 0.798200, 8.632250, -3.748078, 4.133507, 12.137454, -8.862004, -1.781687, -1.505146, -19.179995, 5.982554, 10.444932, 4.122891, 0.473003, -7.846713, 1.764286};
static RBF_CONST rbf_float RBF_BIAS[] = {0.657345, -0.109762, -2.123306, -0.544634, -3.101252, -1.339861, 0.144800, 1.862862, 1.222704, 3.860312, 0.255503, -0.903882};

#if RBF_USE_NORMALIZATION
static RBF_CONST rbf_float NORM_IN_MEAN[] = {0.007725, -0.007038, 0.007455, 0.011877, 0.001866, -0.003087, 0.004067, 0.002325, 0.003148, -0.006066, 0.004758, 0.000636, 0.004189, -0.007824, 0.003690, -0.004952, -0.002980, -0.015579, -0.010094, 0.002106, 0.004459, 0.006238, -0.002720, -0.000873, 0.007270, 0.009699, 0.006898, 0.001832, 0.005006, -0.007759, 0.005082, 0.013317, -0.002149, -0.000781, 0.011293, 0.011511, 0.005884, -0.005790, -0.009952, -0.009337, 0.005552, 0.014381, 0.010618, 0.015250, 0.005429, 0.003803, 0.008677, -0.012048, -0.007581, -0.018476, -0.000717, 0.010397, 0.001276, -0.002031, -0.007865, -0.015925, -0.004742, -0.004977, 0.008823, 0.009801, -0.012115, 0.003178, 0.000795, 0.004078, -0.008358, -0.003247, 0.002985, -0.001700, 0.003416, -0.003666, -0.008242, 0.004791, 0.002949, 0.003835, 0.013085, 0.002617, -0.000862, -0.003491, 0.012320, 0.005680, -0.008778, -0.010445, 0.013855, -0.000230, -0.028151, -0.007351, -0.002369, 0.003762, -0.006667, 0.005783, 0.009740, 0.013742, 0.000966, 0.002236, 0.001234, 0.012526, 0.005553, 0.000584, 0.001718, -0.007526, 0.010426, 0.019006, 0.001946, -0.000085, -0.001752, 0.006428, 0.012480, -0.011479, -0.004705, -0.011416, 0.002779, 0.019718, 0.009155, -0.006767, -0.002370, -0.006690, -0.004474, -0.008191, 0.013075, 0.004443};
static RBF_CONST rbf_float NORM_IN_SCALE[] = {0.996629, 0.996456, 1.006960, 1.000724, 0.998965, 1.007205, 0.996358, 1.008930, 0.999738, 0.999265, 1.000178, 1.004599, 1.005564, 1.001433, 0.999537, 0.996337, 1.004369, 1.001488, 1.006371, 1.002854, 1.013769, 1.009204, 1.012719, 1.009145, 1.007766, 1.013448, 1.006060, 1.004181, 1.004699, 1.012301, 1.011381, 1.004705, 1.005709, 0.999788, 1.014250, 1.007092, 0.998332, 0.999420, 1.000578, 0.986307, 0.990726, 1.000894, 0.987749, 1.003016, 1.003188, 1.002182, 0.999670, 1.003895, 1.005160, 0.987971, 1.003442, 0.998074, 1.001403, 0.997493, 1.004569, 0.999488, 1.000520, 1.005482, 1.005012, 0.999332, 1.021121, 1.009623, 1.005972, 1.000076, 1.007258, 1.004143, 1.013018, 1.009041, 0.999489, 0.987664, 1.004903, 0.995086, 1.004900, 0.999231, 0.991359, 1.003120, 1.001450, 0.991679, 1.002761, 0.996638, 0.996337, 1.011198, 0.990578, 1.001591, 0.993474, 0.997636, 0.995683, 0.991396, 1.004184, 1.003337, 1.017125, 1.011451, 1.014767, 0.996731, 0.999880, 0.999353, 1.003289, 0.993435, 1.000970, 0.994051, 1.002609, 1.002306, 1.001798, 0.999421, 1.000606, 1.006095, 1.006228, 1.003175, 1.000111, 0.992152, 1.000916, 1.003823, 0.992797, 0.989172, 1.004844, 0.997501, 1.006134, 1.001482, 1.007577, 1.002577}; // StdDev
static RBF_CONST rbf_float NORM_OUT_MEAN[] = {0.078289, 0.085565, 0.081781, 0.081781, 0.081490, 0.084692, 0.082654, 0.084692, 0.087602, 0.085565, 0.083818, 0.082072};
static RBF_CONST rbf_float NORM_OUT_SCALE[] = {0.268625, 0.279720, 0.274031, 0.274031, 0.273586, 0.278422, 0.275359, 0.278422, 0.282715, 0.279720, 0.277115, 0.274475}; // StdDev
#endif

// ==========================================
// Implementation
// ==========================================

RbfModelRBF::RbfModelRBF() {
    for(int i=0; i<RBF_HIDDEN_DIM; i++) hidden_activations[i] = 0;
}

void RbfModelRBF::predict(const rbf_float* input, rbf_float* output) {
    // 1. Prepare Input (Normalize if needed)
    rbf_float processed_input[RBF_INPUT_DIM];
    #if RBF_USE_NORMALIZATION
        normalizeInput(input, processed_input);
        const rbf_float* in_ptr = processed_input;
    #else
        const rbf_float* in_ptr = input;
    #endif

    // 2. Hidden Layer (RBF)
    for (int i = 0; i < RBF_HIDDEN_DIM; i++) {
        rbf_float dist_sq = euclideanDistanceSq(in_ptr, i);
        rbf_float width = RBF_READ(&RBF_WIDTHS[i]);
        hidden_activations[i] = computeKernel(dist_sq, width);
    }

    // 3. Output Layer (Linear)
    for (int j = 0; j < RBF_OUTPUT_DIM; j++) {
        #if RBF_FIXED_POINT
            int64_t sum = 0;
        #else
            float sum = 0.0f;
        #endif

        for (int i = 0; i < RBF_HIDDEN_DIM; i++) {
            rbf_float weight = RBF_READ(&RBF_WEIGHTS[i * RBF_OUTPUT_DIM + j]);
            #if RBF_FIXED_POINT
                sum += (int64_t)hidden_activations[i] * weight;
            #else
                sum += hidden_activations[i] * weight;
            #endif
        }

        #if RBF_FIXED_POINT
            sum = sum / RBF_SCALE_FACTOR;
            output[j] = (rbf_float)sum + RBF_READ(&RBF_BIAS[j]);
        #else
            output[j] = sum + RBF_READ(&RBF_BIAS[j]);
        #endif
    }
    
    // 4. Denormalize Output
    #if RBF_USE_NORMALIZATION
        denormalizeOutput(output);
    #endif
}

void RbfModelRBF::normalizeInput(const rbf_float* input, rbf_float* norm_input) {
    for(int i=0; i<RBF_INPUT_DIM; i++) {
        rbf_float mean = RBF_READ(&NORM_IN_MEAN[i]);
        rbf_float scale = RBF_READ(&NORM_IN_SCALE[i]);
        #if RBF_FIXED_POINT
             // (Input - Mean) * SCALE_FACTOR / StdDev
             int64_t diff = (int64_t)input[i] - mean;
             norm_input[i] = (rbf_float)((diff * RBF_SCALE_FACTOR) / scale);
        #else
             norm_input[i] = (input[i] - mean) / scale;
        #endif
    }
}

void RbfModelRBF::denormalizeOutput(rbf_float* output) {
    for(int i=0; i<RBF_OUTPUT_DIM; i++) {
        rbf_float mean = RBF_READ(&NORM_OUT_MEAN[i]);
        rbf_float scale = RBF_READ(&NORM_OUT_SCALE[i]);
        #if RBF_FIXED_POINT
             // (Output * StdDev) / SCALE_FACTOR + Mean
             int64_t val = (int64_t)output[i] * scale;
             output[i] = (rbf_float)(val / RBF_SCALE_FACTOR) + mean;
        #else
             output[i] = (output[i] * scale) + mean;
        #endif
    }
}

rbf_float RbfModelRBF::euclideanDistanceSq(const rbf_float* input, int center_idx) {
    #if RBF_FIXED_POINT
        int64_t sum = 0;
    #else
        float sum = 0.0f;
    #endif
    int base_idx = center_idx * RBF_INPUT_DIM;
    for (int k = 0; k < RBF_INPUT_DIM; k++) {
        rbf_float c = RBF_READ(&RBF_CENTERS[base_idx + k]);
        rbf_float diff = input[k] - c;
        #if RBF_FIXED_POINT
            sum += ((int64_t)diff * diff) / RBF_SCALE_FACTOR;
        #else
            sum += diff * diff;
        #endif
    }
    return (rbf_float)sum;
}

rbf_float RbfModelRBF::computeKernel(rbf_float dist_sq, rbf_float width) {
    #if RBF_FIXED_POINT
        if (width == 0) return 0;
        double d = (double)dist_sq / RBF_SCALE_FACTOR;
        double w = (double)width / RBF_SCALE_FACTOR;
        return (rbf_float)(exp(-d / (2.0 * w * w)) * RBF_SCALE_FACTOR);
    #else
        return exp(-dist_sq / (2.0f * width * width));
    #endif
}

void RbfModelRBF::printInfo() {
    Serial.println(F("Model Loaded: RbfModelRBF"));
    Serial.print(F("Normalization: ")); 
    Serial.println(RBF_USE_NORMALIZATION ? F("YES") : F("NO"));
}
