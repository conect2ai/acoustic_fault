#include "RbfModelRBF.h"

// ==========================================
// Flash/PROGMEM Macros
// ==========================================
#if defined(ESP32) || defined(ESP8266)
    #define RBF_CONST const
    #define RBF_READ(x) (*(x)) // Fixed: Dereference pointer
#elif defined(__AVR__)
    #include <avr/pgmspace.h>
    #define RBF_CONST const PROGMEM
    #if RBF_FIXED_POINT
        #define RBF_READ(addr) (rbf_float)pgm_read_dword(addr)
    #else
        #define RBF_READ(addr) (rbf_float)pgm_read_float(addr)
    #endif
#else
    #define RBF_CONST const
    #define RBF_READ(x) (*(x)) // Fixed: Dereference pointer
#endif

// ==========================================
// Model Parameters
// ==========================================
static RBF_CONST rbf_float RBF_CENTERS[] = {0.448142, 0.189345, -0.782815, -0.281408, -0.593591, -0.657995, -0.434262, -0.345331, -0.341542, -0.334218, -0.304673, -0.343398, -0.378717, -0.431045, -0.301554, -0.367663, -0.450437, -0.529317, -0.619213, -0.613878, -0.480574, -0.387935, -0.301473, -0.405356, -0.483638, -0.483826, -0.475777, -0.556229, -0.619366, -0.510985, -0.560384, -0.587355, -0.150986, 0.240612, -0.122647, 0.007258, -0.027866, -0.028280, -0.076697, -0.030313, -0.045727, -0.028108, -0.089693, -0.185959, -0.169645, -0.087189, 0.083271, -0.070525, -0.122285, -0.088689, -0.012966, -0.138491, 0.041911, 0.006725, -0.149433, 0.026415, 0.069950, -0.063327, -0.078685, 0.208603, 0.667827, 0.289664, 0.781632, 0.744597, 0.613069, 0.754714, 0.791614, 0.789684, 0.842732, 0.978724, 0.796090, 0.739717, 0.809419, 0.883831, 0.814936, 1.029215, 1.032325, 0.920992, 0.684249, 0.910467, 1.054247, 0.980633, 1.012970, 1.101961, 0.910429, 0.937613, 1.146372, 1.044236, 1.040900, 1.419753, 0.159254, -0.506495, -0.055457, 0.292099, 0.039624, 0.096108, 0.116718, 0.126293, -0.078264, -0.002238, 0.002577, 0.019133, 0.014818, 0.072437, -0.059027, 0.149442, 0.429903, 0.094958, 0.067385, 0.195615, 0.451001, 0.334070, 0.518605, 0.339335, 0.021757, 0.257153, 0.405839, 0.304704, 0.292269, 0.770558, 0.887277, 0.701155, 0.557015, 0.322700, -0.155863, -0.280712, -0.246201, -0.015304, 0.168248, 0.235056, 0.027786, 0.018171, 0.097956, 0.165980, 0.253410, 0.308493, 0.370418, 0.546266, 0.377593, 0.370442, 0.399575, 0.601649, 0.690753, 0.569251, 0.525610, 0.425436, 0.499807, 0.533621, 0.563531, 0.827257, 0.075191, 0.185999, -0.470981, -0.232855, -0.335136, -0.152946, -0.290232, -0.222194, -0.148577, -0.110000, -0.325558, -0.158808, -0.108075, -0.118881, -0.187929, -0.098021, -0.033599, 0.255173, -0.165790, -0.096712, -0.216380, -0.057065, -0.213998, -0.285517, -0.119802, -0.306852, -0.131333, -0.012641, -0.119143, 0.109180, 0.170427, -0.025421, 0.202293, 0.251015, 0.134406, 0.158808, 0.186412, 0.362105, 0.315944, 0.178034, 0.060947, 0.139369, 0.210654, 0.325229, 0.200165, 0.302783, 0.495156, 0.558872, 0.394837, 0.291721, 0.322087, 0.296523, 0.205342, 0.187862, 0.287130, 0.309983, 0.314930, 0.312902, 0.307297, 0.297779, -0.515199, -0.726853, -0.237472, -0.167039, -0.264446, -0.222337, -0.388216, -0.237655, -0.138201, -0.129906, -0.492050, -0.237185, -0.242854, -0.234206, -0.349417, -0.238073, -0.218820, -0.028623, -0.287499, -0.201170, -0.427441, -0.455921, -0.497434, -0.545465, -0.339492, -0.569795, -0.412531, -0.400471, -0.499864, -0.417059, 1.800962, 2.245358, 2.978058, 3.240578, 3.049738, 3.053219, 2.965415, 3.336513, 3.623926, 3.680506, 3.787137, 3.850850, 3.878402, 3.850055, 3.631982, 3.357848, 3.082305, 3.184789, 3.452255, 3.722482, 3.401455, 3.095682, 3.129269, 3.355724, 3.200196, 3.434593, 3.238617, 2.988437, 3.034169, 3.060564, 2.583200, 5.424440, 7.078904, 7.395834, 7.164155, 7.026085, 7.308290, 6.982755, 6.637755, 7.250209, 7.799986, 7.932869, 7.615268, 7.543768, 7.199329, 7.332428, 7.065862, 7.089330, 7.533225, 7.768017, 7.112953, 6.991724, 6.883110, 7.370032, 7.533509, 7.326832, 7.525699, 7.556897, 7.299375, 7.097321, -2.337861, -1.915974, -1.653225, -2.047462, -2.104820, -1.731480, -1.674561, -1.681793, -1.919185, -1.778239, -1.282232, -1.898381, -1.947688, -1.518975, -1.784750, -1.766022, -1.994436, -1.905599, -1.732090, -2.092518, -1.797021, -1.846880, -1.595786, -1.649757, -1.758618, -1.670444, -1.957078, -1.727523, -1.746788, -2.009954, 2.630271, 4.859167, 6.532063, 5.831874, 5.824676, 5.784944, 6.124216, 6.301888, 6.105740, 6.360955, 6.649827, 7.156918, 6.649034, 6.328409, 6.053753, 6.371437, 6.065130, 6.043247, 6.736337, 7.022472, 6.516197, 5.513323, 5.027166, 6.174767, 6.939431, 5.974714, 6.303916, 6.853830, 6.356528, 5.817849, 0.905657, 0.310880, 0.579865, 0.802845, 0.826709, 0.825586, 0.776806, 0.944093, 1.059402, 1.083778, 0.985344, 1.086919, 1.057250, 0.972630, 0.978593, 0.824685, 0.650823, 0.756241, 0.892019, 0.875761, 0.729833, 0.735381, 0.725463, 0.592947, 0.532599, 0.634665, 0.562499, 0.489590, 0.414183, 0.337920, 0.437391, 0.231604, 0.194484, 0.015159, -0.083735, -0.142560, 0.250647, -0.224160, -0.011592, 0.017724, -0.033435, -0.048282, -0.288522, -0.163549, -0.031816, -0.112825, -0.212563, -0.144166, 0.017050, -0.128389, -0.363916, -0.250288, -0.224108, -0.424464, -0.262725, -0.252709, -0.259152, -0.257708, -0.277655, -0.251874, -0.160522, -0.074042, -0.125742, -0.049489, -0.191447, -0.314422, -0.511733, -0.432854, -0.355962, -0.422046, -0.336739, -0.005824, 0.023349, -0.299009, -0.333228, -0.305120, -0.363637, -0.442620, -0.335923, -0.225972, -0.228672, -0.368640, -0.223425, -0.153981, -0.070750, -0.188687, -0.237218, -0.172177, -0.059290, -0.147470, 0.438630, 0.370963, 0.458214, -0.047967, -0.295411, -0.141275, 0.205564, -0.349099, -0.012176, 0.086059, -0.052655, -0.221950, -0.205117, -0.181691, -0.120264, -0.035317, -0.308428, -0.159865, -0.035116, -0.130012, -0.360655, -0.285203, -0.132894, -0.382527, -0.301525, -0.211435, -0.374774, -0.321587, -0.357532, -0.305502, -1.178803, -0.210369, -0.393841, -0.849581, -0.298951, 0.199860, 0.193806, -0.195077, -0.442081, -0.452197, -0.419792, -0.611023, -0.539219, -0.389898, -0.361945, -0.202460, -0.403838, -0.700829, -0.716039, -0.511287, -0.684032, -1.122812, -1.077596, -0.767023, -0.662110, -0.796580, -0.781390, -0.696148, -0.234423, -0.602658, -0.052249, -0.330271, -0.376430, -0.388054, -0.248251, -0.096146, -0.196266, -0.390419, -0.219929, -0.212206, -0.234110, -0.277879, -0.357356, -0.306437, -0.335335, -0.254547, -0.377466, -0.515635, -0.329729, -0.134397, -0.291016, -0.619725, -0.637761, -0.387465, -0.330344, -0.531249, -0.491077, -0.482445, -0.455138, -0.652066, 0.081614, 0.246809, 0.216824, 0.179642, 0.119070, 0.165860, 0.108421, 0.031137, 0.027268, 0.100623, 0.222142, 0.208791, 0.072561, 0.028229, 0.081112, 0.069720, 0.085039, 0.062918, 0.040577, 0.090478, 0.281326, 0.214532, 0.099788, 0.131316, 0.110390, 0.054458, 0.075756, 0.163822, 0.128538, 0.107983, -0.561113, 0.043860, -0.315229, -0.406338, -0.205762, -0.087895, -0.214005, -0.306601, -0.093625, -0.168875, -0.165991, -0.318330, -0.356351, -0.241882, -0.271551, -0.215866, -0.369374, -0.525645, -0.289050, -0.137609, -0.272242, -0.566635, -0.648777, -0.455157, -0.396139, -0.549505, -0.504281, -0.509038, -0.525634, -0.660956, 0.189106, -0.518259, 0.202322, 0.073228, 0.262499, 0.317772, 0.122706, 0.000450, 0.006166, -0.224976, -0.464094, -0.458816, -0.434451, -0.346619, -0.378019, -0.204513, 0.007088, 0.062807, 0.224426, 0.027134, -0.162070, 0.028540, 0.047862, -0.153298, -0.117400, 0.181450, 0.196570, 0.115138, 0.061906, 0.072761, 0.292322, -0.103718, -0.055553, -0.288216, -0.081933, -0.122325, -0.151991, -0.265313, -0.185674, -0.129055, -0.221155, -0.041891, -0.144736, 0.053088, 0.195532, 0.243402, 0.162366, 0.258141, 0.255931, 0.226114, 0.166049, 0.630926, 0.891080, 0.555815, 0.473146, 1.169911, 0.995576, 0.865594, 1.021580, 1.030495, 0.723952, -0.161793, 0.036541, 0.323781, -0.220473, -0.070439, 0.277806, 0.439473, 0.413174, 0.565822, 0.520921, 0.445358, 0.494789, 0.715069, 0.775867, 0.782258, 0.829388, 1.047064, 1.150954, 1.183504, 1.107495, 1.427550, 1.641300, 1.197710, 1.326187, 1.712136, 1.589442, 1.621274, 1.766468, 1.681381, 0.103799, -0.297609, -0.169859, -0.296922, 0.244889, -0.009132, -0.061796, -0.099689, -0.055713, 0.050560, -0.158002, -0.004232, 0.003821, 0.268668, 0.478309, 0.574598, 0.456142, 0.738124, 0.802762, 0.601933, 0.677929, 1.294960, 1.415587, 0.963819, 0.947596, 1.578528, 1.451694, 1.347889, 1.589167, 1.419880, 3.570819, 3.693738, 4.633262, 5.077153, 4.860706, 4.698262, 4.747957, 5.118768, 5.416233, 5.694942, 5.954139, 6.008724, 5.903644, 6.090358, 5.766609, 5.246305, 4.860368, 5.272373, 5.840362, 6.125123, 5.731117, 5.220454, 5.295227, 5.631822, 5.554477, 5.671629, 5.626371, 5.414316, 5.495672, 5.382281, 0.739386, 4.880580, 5.426504, 5.212330, 4.761817, 5.047043, 5.180298, 5.385477, 5.422911, 5.262078, 5.510755, 5.387120, 5.274347, 5.620124, 5.916404, 5.522058, 5.989073, 6.122030, 5.981033, 5.844320, 5.705908, 5.535745, 5.340117, 5.913005, 5.800768, 5.728244, 6.041102, 6.173215, 6.158990, 6.098691, 0.685312, 0.368349, 0.377844, 0.100605, 0.010381, 0.137713, 0.305539, 0.284207, 0.283810, 0.362909, 0.979716, 0.354882, 0.247685, 0.721380, 0.571153, 0.451688, 0.377818, -0.009963, 0.138587, 0.476400, 0.561055, 0.428687, 0.728501, 0.767896, 0.908409, 0.960120, 1.030551, 0.856001, 0.870104, 1.222070, 0.097527, 2.420563, 1.939879, 0.853802, 0.691530, 0.761238, 0.842624, 1.680135, 1.664094, 1.114457, 1.063171, 1.460750, 1.317192, 1.058110, 1.327563, 1.025767, 1.572531, 1.440566, 1.116608, 1.283644, 1.396646, 0.880326, 1.130152, 1.276329, 1.577498, 1.628222, 1.710174, 1.822255, 1.875872, 1.561843, -0.759640, -0.588063, -0.739647, -0.743406, -0.649264, -0.519776, -0.534025, -0.543110, -0.578796, -0.574743, -0.475877, -0.636109, -0.687348, -0.688614, -0.761639, -0.724144, -0.864860, -1.020482, -0.930577, -0.822817, -0.893752, -1.085942, -1.086397, -0.951397, -0.806995, -0.912258, -0.900052, -0.922226, -0.869944, -0.905988, 0.061452, -0.115918, -0.161426, -0.184488, -0.157249, -0.069870, -0.092372, -0.112074, -0.151229, -0.254612, -0.082738, -0.116353, -0.207827, -0.078231, -0.252851, -0.249962, -0.268413, -0.330927, -0.197152, -0.125984, -0.221136, -0.530817, -0.600459, -0.353531, -0.246149, -0.416794, -0.446851, -0.418859, -0.455544, -0.574039, -0.553781, -0.630539, -0.591798, -0.630643, -0.696921, -0.704137, -0.651957, -0.659656, -0.603038, -0.730974, -0.814488, -0.634176, -0.564678, -0.578794, -0.449755, -0.462743, -0.590244, -0.587128, -0.596837, -0.658668, -0.604783, -0.586526, -0.562560, -0.617646, -0.690776, -0.608897, -0.496632, -0.552234, -0.487934, -0.468964, -0.080279, -0.103007, -0.102486, -0.064523, -0.124787, 0.020675, -0.071398, -0.115916, -0.186306, -0.279279, 0.031488, -0.054653, -0.118826, -0.067272, -0.270469, -0.234716, -0.248984, -0.388951, -0.254230, -0.171153, -0.221145, -0.528743, -0.607933, -0.397307, -0.267388, -0.513702, -0.522501, -0.458196, -0.572480, -0.638516, 0.337688, 0.109277, -0.935931, -0.478391, -0.746847, -0.732680, -0.525107, -0.360536, -0.299271, -0.367699, -0.393591, -0.330828, -0.402501, -0.442197, -0.378649, -0.431890, -0.529269, -0.639490, -0.664028, -0.656875, -0.549844, -0.527906, -0.430326, -0.465055, -0.518267, -0.508929, -0.571147, -0.627762, -0.671110, -0.631089, -0.657512, -0.722734, -0.263052, 0.029134, -0.367873, -0.136709, -0.180512, -0.230985, -0.137740, -0.252611, -0.017374, -0.109201, 0.011554, -0.217437, -0.146701, -0.246616, 0.038187, -0.226884, -0.188835, -0.140384, -0.164604, -0.211372, -0.200276, -0.165836, -0.165485, -0.082968, -0.178921, -0.168400, -0.108688, -0.073173, -0.388108, -0.065920, -0.223986, -0.315229, -0.229064, -0.150841, -0.076054, -0.000470, -0.058410, -0.270524, -0.401623, -0.392058, -0.401158, -0.309420, -0.097827, -0.113776, -0.278231, -0.245899, -0.212166, -0.420239, -0.522854, -0.535926, -0.487146, -0.416905, -0.539208, -0.554944, -0.425263, -0.597267, -0.607950, -0.589906, -0.089414, -0.549725, -0.068261, 0.221759, -0.307369, -0.100950, -0.201927, -0.038732, -0.156807, -0.210298, 0.100934, 0.061547, 0.112311, -0.090659, -0.242014, -0.338619, 0.100220, -0.128970, -0.132844, 0.007549, 0.083964, 0.235835, 0.198359, 0.061383, -0.061432, 0.178156, -0.023547, 0.005683, 0.161166, 0.292397, -0.731253, -1.354226, -1.464931, -0.964354, -0.823598, -0.714821, -0.683485, -0.557908, -0.661824, -0.839760, -0.644634, -0.660193, -0.814462, -0.755039, -0.794601, -1.079858, -1.233903, -1.181565, -0.904842, -0.758807, -0.893692, -1.066671, -1.141919, -1.072627, -1.011540, -1.075863, -1.201405, -1.144255, -1.164230, -1.234727, -0.228026, 0.031220, 0.129466, 0.012275, -0.382569, -0.175234, -0.242182, -0.101481, -0.166012, -0.426426, -0.188074, -0.248010, -0.259905, -0.153038, -0.261821, -0.248858, -0.323805, -0.355492, -0.341214, -0.242473, -0.430749, -0.632818, -0.685315, -0.420870, -0.349757, -0.513742, -0.583698, -0.479237, -0.518281, -0.632813, 0.109517, -0.034574, -0.135127, -0.267112, -0.237251, 0.022175, 0.103847, -0.014343, -0.119175, -0.140485, -0.057793, -0.093996, -0.108957, -0.111553, -0.131656, -0.225830, -0.254090, -0.178109, -0.179701, -0.153176, -0.267158, -0.148966, -0.074201, -0.059457, -0.159247, -0.147750, 0.037632, -0.045889, -0.099371, -0.103108, -0.149486, 0.112011, -0.023092, 0.176193, -0.341377, -0.109441, -0.161355, -0.104230, -0.169925, -0.401327, -0.110793, -0.192338, -0.283015, -0.084812, -0.215526, -0.257144, -0.407002, -0.453569, -0.363539, -0.264695, -0.453282, -0.596710, -0.656418, -0.474267, -0.404088, -0.561197, -0.626481, -0.517815, -0.559565, -0.659626, 0.516737, 0.137352, -0.476534, -0.169522, -0.396062, -0.525966, -0.414338, -0.159025, -0.093790, -0.175720, -0.159200, -0.146323, -0.168689, -0.244197, -0.239526, -0.386730, -0.355333, -0.310951, -0.339796, -0.366024, -0.295536, -0.155595, -0.055318, -0.153543, -0.326691, -0.240138, -0.243085, -0.315244, -0.316749, -0.258734, -0.695885, -0.329254, 0.007499, 0.147284, -0.178039, -0.092667, -0.150178, -0.066837, -0.055857, -0.175768, -0.290661, -0.308309, -0.205247, -0.060967, -0.070660, 0.027770, 0.170596, -0.114341, -0.240087, -0.234439, -0.144715, 0.090930, 0.322492, 0.041682, -0.208041, 0.026130, -0.059321, -0.152961, -0.039602, 0.264874, -0.102096, -0.648263, -0.502619, -0.310889, -0.557466, -0.624689, -0.600993, -0.384976, -0.311069, -0.132501, -0.128459, -0.248600, 0.036172, 0.236153, 0.092972, 0.119545, 0.247936, 0.215346, -0.216177, 0.057130, 0.421272, 0.637597, 0.826743, 0.566825, 0.325135, 0.552258, 0.363585, 0.318706, 0.497264, 0.667433, 0.171628, -0.173784, 0.047583, 0.271183, 0.136796, -0.010867, -0.278071, -0.009260, 0.000860, -0.128919, -0.143083, -0.176664, -0.151918, -0.001684, -0.178918, 0.254410, 0.568686, 0.025819, -0.282201, -0.198297, 0.122772, 0.547361, 0.868787, 0.333315, -0.057187, 0.355355, 0.065221, 0.054641, 0.208683, 0.706564, 2.810375, 2.206001, 3.069818, 3.380754, 3.103145, 3.060734, 3.173829, 3.517132, 3.722902, 3.800250, 3.998153, 4.150746, 3.989800, 3.889369, 3.662988, 3.309236, 3.135126, 3.520268, 3.942537, 4.308431, 3.885131, 3.429999, 3.605377, 3.881272, 3.761740, 3.792062, 3.702555, 3.451828, 3.554917, 3.392065, 0.567360, 3.714425, 4.961402, 5.530365, 5.075953, 4.718731, 4.564836, 4.626646, 4.774091, 5.264144, 5.489192, 5.371087, 5.276747, 5.930945, 5.731637, 5.703624, 5.772234, 5.946558, 5.830405, 5.514649, 5.820979, 5.621457, 5.255603, 5.743454, 5.957639, 5.862048, 5.834827, 6.230203, 6.103530, 6.118640, -0.768578, -0.606098, -0.379781, -0.223184, -0.078326, -0.257110, -0.528410, -0.701622, -0.562854, -0.791196, -1.001356, -0.689057, -0.655643, -0.423746, -0.187520, -0.477387, -0.463624, -0.300552, -0.562926, -0.730531, -0.824991, -1.144149, -1.415517, -1.375211, -0.904986, -0.374792, -0.478659, -0.499875, -0.700932, -0.226074, 0.179005, 3.228114, 3.857844, 2.937653, 3.009992, 2.723702, 2.435990, 2.406747, 1.967108, 2.658385, 3.085114, 2.746227, 3.127458, 3.265822, 3.013458, 3.129171, 2.956576, 2.958175, 2.963737, 2.718494, 3.176091, 2.796796, 2.529781, 3.194526, 3.832631, 3.028195, 3.145406, 3.607711, 3.669673, 3.383729, 0.569467, 0.376938, 0.122974, 0.269961, -0.046830, -0.386980, -0.505430, -0.429978, -0.063244, 0.098592, 0.118539, 0.150126, 0.063784, -0.032330, -0.215385, -0.177444, 0.017469, 0.195158, 0.059830, 0.176897, 0.365300, 0.485324, 0.488690, 0.388836, 0.504386, 0.463612, 0.307219, 0.398575, 0.458993, 0.758408, 0.214341, 0.119625, -0.280455, 0.185891, 0.090965, -0.012114, -0.014054, -0.117684, -0.065015, -0.056836, 0.055059, 0.012317, -0.113689, -0.066292, -0.176934, -0.132022, -0.220620, -0.197939, -0.292176, -0.146484, 0.063303, 0.068101, -0.266523, -0.371522, -0.232903, -0.087919, -0.220406, -0.149705, -0.233460, -0.018086, 0.557227, 0.597398, 0.574527, 0.592711, 0.775131, 0.762887, 0.696571, 0.585424, 0.620681, 0.735891, 0.649799, 0.730586, 0.646383, 0.506137, 0.497697, 0.370605, 0.381828, 0.340130, 0.346803, 0.366768, 0.438700, 0.300290, 0.299443, 0.377345, 0.500220, 0.404453, 0.405362, 0.375610, 0.280596, 0.277992, -0.195695, -0.452675, -0.186755, -0.081998, 0.016327, -0.001471, 0.078965, -0.071739, -0.088857, -0.122228, 0.117920, -0.114186, -0.188096, -0.078257, -0.240155, -0.199773, -0.292223, -0.361979, -0.351454, -0.241669, -0.263213, -0.488655, -0.532974, -0.566600, -0.314125, -0.335792, -0.513475, -0.440534, -0.534708, -0.517910, 0.343647, -0.599275, 0.427609, 0.377667, 0.612587, 0.608274, 0.321656, 0.176872, 0.139429, -0.124274, -0.467489, -0.363528, -0.314967, -0.232520, -0.209806, -0.035092, 0.181775, 0.216874, 0.403173, 0.275964, 0.035065, 0.243776, 0.218135, 0.069278, -0.070029, 0.112130, 0.111699, 0.007639, -0.128465, -0.046848, -0.019125, 0.035528, 0.166998, -0.296519, -0.002087, -0.144993, 0.004144, -0.025967, 0.129322, 0.161535, 0.002791, 0.107180, 0.083971, 0.405627, 0.450847, 0.493561, 0.268884, 0.355395, 0.297524, 0.332251, 0.185110, 0.800272, 0.974123, 0.579022, 0.384067, 0.700997, 0.542675, 0.490447, 0.665547, 0.594097, -0.392731, -0.235272, -0.224579, -0.331337, 0.116027, -0.179650, -0.273530, -0.687295, -0.793529, -0.798854, -0.682270, -0.632636, -0.897614, -1.050341, -1.230686, -1.142446, -0.901044, -0.984023, -0.994438, -1.266412, -1.207556, -1.630936, -1.793218, -1.411402, -1.466851, -1.565183, -1.670557, -1.515214, -1.751101, -1.776421, 0.025882, 0.032446, 0.104306, -0.282378, 0.127571, -0.167262, 0.060966, 0.061759, 0.344870, 0.406744, 0.095043, 0.349833, 0.289221, 0.638544, 0.841908, 0.713646, 0.522421, 0.801859, 0.671890, 0.559415, 0.548641, 1.605407, 1.758322, 1.122579, 0.819545, 1.322476, 1.215495, 1.119321, 1.313418, 1.187348, -0.652339, -1.288997, -1.434993, -0.947647, -0.781973, -0.628001, -0.611866, -0.515219, -0.622300, -0.769795, -0.573621, -0.566592, -0.757691, -0.712059, -0.781726, -1.083669, -1.262485, -1.217943, -0.924905, -0.768067, -0.932180, -1.093775, -1.147488, -1.112954, -1.093325, -1.107609, -1.216621, -1.133507, -1.165670, -1.245051, -0.420917, -0.096569, 0.204019, 0.145395, -0.322868, -0.134300, -0.355239, -0.123415, -0.230962, -0.267829, -0.081874, -0.171242, -0.243500, -0.169607, -0.250554, -0.170175, -0.246396, -0.369654, -0.304592, -0.257212, -0.406124, -0.528909, -0.610816, -0.375068, -0.274689, -0.444452, -0.503999, -0.394356, -0.429919, -0.537493, 0.045345, 0.257744, 0.391031, 0.366041, 0.286257, 0.232289, 0.339225, 0.506120, 0.637231, 0.498721, 0.385308, 0.281954, 0.335101, 0.431263, 0.483878, 0.440959, 0.330815, 0.288684, 0.381244, 0.431250, 0.350804, 0.388227, 0.323872, 0.425595, 0.385973, 0.317140, 0.377511, 0.401177, 0.348390, 0.365314, -0.375377, -0.122874, 0.009409, 0.361144, -0.355734, -0.213846, -0.441771, -0.178233, -0.117911, -0.240395, -0.091305, -0.254307, -0.313651, -0.286014, -0.318381, -0.256975, -0.276013, -0.432940, -0.329088, -0.273315, -0.472259, -0.494507, -0.600271, -0.404727, -0.304852, -0.500410, -0.570874, -0.509665, -0.508444, -0.538609, -1.004377, 0.067102, 0.078800, -0.707826, -0.411136, -0.089760, 0.043625, -0.125211, -0.305558, -0.134801, -0.028930, 0.071749, 0.162310, 0.184646, 0.062711, -0.041254, -0.235865, -0.107460, 0.056798, 0.006409, -0.081633, -0.321228, -0.346391, -0.220918, -0.050273, 0.114404, -0.014751, -0.100378, 0.086269, -0.141927, 1.770949, -0.854917, -0.073321, -0.522081, -0.341011, -0.286029, -0.067203, -0.149450, -0.291277, -0.041440, -0.041116, -0.078505, -0.034734, -0.177758, -0.090060, -0.111074, -0.436611, -0.343552, -0.127372, -0.080916, -0.160864, -0.260972, 0.073244, 0.159916, -0.088017, 0.011976, 0.312554, 0.111576, 0.120308, 0.123443, 0.334129, 0.110294, 0.124764, -0.104899, -0.074497, -0.044320, -0.133694, -0.033293, -0.093269, -0.001714, 0.035967, 0.203024, 0.201798, 0.132836, 0.171487, 0.005603, -0.020084, 0.066787, 0.037745, -0.136698, -0.221405, -0.060353, -0.101508, 0.032878, -0.155712, 0.038226, 0.174578, 0.111811, 0.155094, 0.039747, 1.445762, -0.400275, 0.026386, -0.316257, -0.398815, -0.267897, 0.132860, -0.143508, -0.379955, 0.139875, 0.229862, 0.270575, 0.340443, 0.140208, 0.139131, -0.005949, -0.331034, -0.237104, -0.021408, 0.062367, 0.023911, 0.044661, 0.507052, 0.437061, 0.043715, 0.231578, 0.835417, 0.537641, 0.445741, 0.535056, 0.078078, 1.822067, 0.227412, 0.752615, 0.874412, 0.742930, 0.993249, 1.039009, 1.201103, 1.012957, 0.690286, 0.877717, 1.189453, 0.873612, 0.707653, 1.093927, 0.895639, 0.352111, 0.347538, 0.602617, 1.079934, 0.750560, 0.055250, 0.795801, 1.333634, 1.172320, 0.513019, 0.232979, 0.617554, 0.976619, -1.533178, -1.512370, -0.408918, -0.197271, -0.292303, -0.586845, -0.255965, -0.486958, -0.130608, -0.053088, -0.256840, -0.287510, 0.015519, -0.151096, -0.331696, -0.269921, -0.372828, -0.410516, -0.191398, -0.427544, -0.229324, -0.483233, -0.691654, -0.185824, -0.336741, -0.406491, -0.525747, -0.514328, -0.514043, -0.539199, 0.060586, 0.008003, 0.071025, -0.009344, 0.001538, 0.024236, -0.037790, 0.014162, -0.000183, 0.060178, 0.069719, -0.029343, 0.054677, -0.053177, 0.014568, 0.011849, 0.004558, 0.101631, -0.012639, 0.077739, -0.035827, -0.108888, -0.022975, 0.087575, 0.068861, 0.010358, -0.009706, -0.048758, -0.046392, -0.070152, -0.771305, -1.087879, -0.282145, -0.111638, -0.119139, -0.433727, -0.126488, -0.376672, -0.127737, -0.202716, -0.427791, -0.369920, -0.044040, -0.217754, -0.401263, -0.258010, -0.267523, -0.306040, -0.145494, -0.423841, -0.367083, -0.516344, -0.643508, -0.284885, -0.304249, -0.386232, -0.568162, -0.516431, -0.555262, -0.531335, 0.922541, 1.116338, 0.910739, 0.433205, 0.533694, 0.584943, 0.734097, 0.292064, -0.057664, 0.305167, 0.423472, -0.092382, -0.140238, -0.199564, 0.048653, 0.116911, 0.003829, -0.069418, -0.116933, 0.018985, -0.025971, 0.242278, 0.322333, 0.083582, 0.028649, -0.085656, 0.254076, 0.306420, 0.194160, -0.088290, -0.223518, 1.031143, -0.531354, -0.517891, -0.028523, -0.136808, -0.033587, -0.170359, -0.042671, 0.128831, 0.065942, -0.055981, 0.003832, -0.111733, 0.020089, -0.139758, -0.209549, -0.194491, -0.151179, -0.018418, -0.039389, 0.405940, 0.359830, -0.046172, 0.003065, -0.153964, 0.148701, -0.045388, -0.046037, -0.207716, -0.038298, 0.356361, 0.360690, 0.470619, 0.399084, 0.452802, 0.470779, 0.367748, 0.528676, 0.482046, 0.496589, 0.664428, 0.571392, 0.453057, 0.452182, 0.467281, 0.424372, 0.416187, 0.484174, 0.412417, 0.352891, 0.438288, 0.390082, 0.380804, 0.521974, 0.479015, 0.438019, 0.364161, 0.461524, 0.395252, -0.689048, 0.386941, -0.633605, -0.616675, -0.103551, -0.363064, -0.135173, -0.203502, -0.125074, 0.133264, 0.164803, -0.033066, 0.049443, -0.115486, -0.043207, -0.157352, -0.299619, -0.239257, -0.201458, -0.087838, -0.188879, -0.151798, -0.277497, -0.329056, -0.228333, -0.336978, -0.256260, -0.404655, -0.306543, -0.485876, 1.652350, 3.547178, 4.985480, 5.728924, 5.303339, 5.366006, 5.449831, 6.233596, 6.423460, 6.533746, 7.159101, 6.889844, 6.442746, 6.262536, 6.658586, 5.931611, 5.381063, 5.530843, 6.405471, 6.526008, 5.806357, 5.334833, 5.512667, 5.776629, 5.948085, 6.177386, 5.937815, 5.470582, 5.683383, 5.718588, 1.459198, 2.856359, 4.836527, 5.422337, 5.901351, 6.328373, 7.389206, 7.747968, 8.045387, 8.374146, 9.266948, 8.780303, 9.054564, 9.998716, 10.046144, 10.269948, 8.877315, 8.768029, 8.952692, 8.722667, 11.080588, 10.320036, 9.096550, 10.060250, 10.384700, 8.755828, 9.282490, 8.907900, 9.528036, 8.922774, -1.500063, 2.386107, 4.026552, 4.118918, 4.005744, 4.478374, 6.083685, 7.350970, 6.571774, 7.782130, 7.717031, 6.172290, 6.919976, 7.316604, 7.008448, 7.612735, 8.046352, 6.978959, 7.351694, 6.707404, 9.609748, 8.018655, 7.538990, 8.862368, 9.065064, 8.577249, 9.835804, 8.492944, 8.695919, 8.194789, 3.087770, 5.510531, 7.121910, 8.793783, 8.447962, 9.303242, 9.295560, 8.648383, 9.622732, 10.388199, 11.753206, 12.041667, 11.147207, 12.076743, 12.658831, 12.769855, 9.671738, 9.466227, 10.125064, 11.003134, 12.375681, 9.797839, 8.645519, 10.997481, 12.297468, 9.727294, 10.584767, 10.322402, 10.278182, 9.281795, 0.715406, 0.561650, 0.394168, 0.304594, -0.131277, -0.342299, -0.353072, -0.236380, 0.001973, 0.173896, 0.101907, 0.111330, 0.107508, 0.089584, 0.043793, 0.111547, 0.208820, 0.369702, 0.266729, 0.327769, 0.427630, 0.560962, 0.617297, 0.513600, 0.575530, 0.472867, 0.421323, 0.497449, 0.567809, 0.844265, 0.196100, 0.180508, -0.271704, -0.026318, -0.175208, -0.156106, -0.226355, -0.026716, -0.184210, -0.057873, -0.155802, -0.155364, -0.081479, -0.083969, -0.138858, -0.179131, -0.055636, -0.046513, -0.254787, -0.141118, -0.122767, 0.036877, -0.245717, -0.307147, -0.218200, -0.247505, -0.239897, -0.142608, -0.146344, 0.046858, -0.162863, 0.029318, -0.258214, -0.223791, -0.163558, -0.222226, -0.223694, -0.354248, -0.384225, -0.316904, -0.273879, -0.304714, -0.355505, -0.306349, -0.180594, -0.111267, -0.222120, -0.297264, -0.263030, -0.142212, -0.124761, -0.118322, -0.218386, -0.237450, -0.192618, -0.161845, -0.178600, -0.299196, -0.233807, -0.226114, -0.275081, -0.615285, -0.077275, -0.038202, -0.175324, -0.137360, -0.198648, -0.021007, -0.146388, -0.031227, -0.129683, -0.200326, -0.152320, -0.189882, -0.253691, -0.286934, -0.201247, -0.250319, -0.334404, -0.283421, -0.369446, -0.412261, -0.524720, -0.470179, -0.358708, -0.437732, -0.514044, -0.422281, -0.475992, -0.442462, 0.927184, 1.114689, 0.933448, 0.435230, 0.491577, 0.587722, 0.688377, 0.279831, -0.019829, 0.340950, 0.441422, -0.147314, -0.184284, -0.211279, 0.068910, 0.115437, -0.018795, -0.037963, -0.084426, 0.007449, -0.036999, 0.263189, 0.300238, 0.038379, 0.002447, -0.109982, 0.202319, 0.266408, 0.135013, -0.089594, -0.204670, 1.138457, -0.488395, -0.658679, 0.013697, -0.189139, 0.017720, -0.158891, -0.027807, 0.021812, 0.084362, -0.154725, -0.103733, -0.141758, 0.026298, -0.125455, -0.206429, -0.242148, -0.232799, -0.024512, 0.037288, 0.429167, 0.444016, -0.060739, 0.020506, -0.179634, 0.204317, -0.052862, -0.088826, -0.163284, -0.070701, -0.115202, -0.263930, -0.333280, -0.285510, -0.406778, -0.424328, -0.393169, -0.425032, -0.224883, -0.100333, -0.276561, -0.389070, -0.410691, -0.467636, -0.345164, -0.310448, -0.319882, -0.367099, -0.340619, -0.323332, -0.190269, -0.193476, -0.226243, -0.335537, -0.281346, -0.239568, -0.188824, -0.191838, -0.183837, -0.729325, 0.381165, -0.512017, -0.655843, -0.216479, -0.312076, -0.103441, -0.251892, -0.077128, -0.071674, 0.048888, -0.074770, -0.048988, -0.201501, -0.058549, -0.173777, -0.184904, -0.394114, -0.290058, -0.077223, -0.026368, -0.084531, -0.240870, -0.380993, -0.180554, -0.379323, -0.195475, -0.286198, -0.329990, -0.432265, 2.035874, 2.094299, 2.702019, 3.111192, 2.706988, 2.600704, 2.662625, 2.984141, 3.019400, 3.166297, 3.227024, 3.357956, 3.300276, 3.390914, 3.258054, 2.865143, 2.553541, 2.665298, 2.993139, 3.155774, 2.784763, 2.557826, 2.631878, 2.652965, 2.553950, 2.798625, 2.610446, 2.308646, 2.341604, 2.429793, 2.188050, 5.622827, 7.926595, 7.973617, 8.333418, 8.555962, 8.208180, 8.246437, 8.575754, 8.307904, 8.284049, 8.017699, 8.227599, 8.068319, 8.049524, 8.232895, 7.998495, 7.780230, 8.114603, 8.457672, 8.318487, 7.622659, 7.138212, 7.989162, 8.187478, 7.712982, 7.817964, 7.868374, 7.767836, 7.340761, -1.446797, -3.959442, -5.482570, -5.048234, -5.057349, -5.061959, -5.112185, -5.268991, -5.123685, -5.280682, -5.280380, -5.331021, -5.285900, -5.383766, -5.442525, -5.704214, -5.335215, -5.241186, -5.366899, -5.738408, -5.677161, -5.536204, -5.320816, -5.763398, -6.215700, -5.983572, -6.365978, -6.229022, -6.463209, -6.310641, 3.008294, 5.381131, 7.596887, 6.695219, 7.483189, 7.779446, 7.299468, 7.624598, 8.044009, 7.917109, 7.312973, 7.480003, 7.775337, 7.831248, 7.578381, 8.153152, 7.980598, 7.677378, 7.937611, 8.648854, 8.381578, 6.802142, 5.856146, 7.449880, 8.426579, 7.258911, 7.276275, 7.889626, 7.336227, 6.706556, 1.313530, 1.049219, 1.132579, 1.442755, 1.728006, 1.950824, 2.125683, 2.169115, 1.819806, 1.558262, 1.568229, 1.408665, 1.608327, 1.559028, 1.421990, 1.311201, 1.213776, 1.303089, 1.135097, 1.069640, 0.992598, 1.078841, 1.318809, 1.139018, 0.842889, 0.804906, 1.180616, 1.467346, 1.201371, 0.630896, -0.002393, 1.233363, 0.116270, 0.643313, 0.925524, 1.421710, 1.849562, 2.160843, 1.647020, 0.798345, 0.544688, 1.045066, 1.263901, 1.517976, 1.408485, 1.220223, 1.029549, 0.774019, 0.558892, 0.620385, 0.577635, 0.540625, 0.516030, 0.485209, 0.570037, 0.382924, 0.590804, 0.819533, 0.687056, 0.422288, -0.182357, -0.357260, -0.155689, -0.391175, -0.391135, -0.343763, -0.307920, -0.187601, -0.122119, 0.067522, 0.009920, 0.183561, -0.041031, -0.255773, 0.058017, -0.068497, -0.259565, -0.325563, 0.000116, -0.052715, -0.222004, -0.381948, -0.100212, -0.328796, -0.413676, -0.553175, -0.538162, -0.422897, -0.298138, -0.147319, -0.148467, 0.930376, 0.176332, 1.099754, 1.169647, 1.679010, 2.140949, 2.240566, 1.638702, 0.670025, 0.655336, 1.325298, 1.122194, 1.422074, 1.189031, 0.964012, 0.958411, 0.804481, 0.717728, 0.612463, 0.556340, 0.225191, 0.155680, 0.395922, 0.397658, 0.227825, 0.441739, 0.631575, 0.535217, 0.187463, 0.775049, 1.462199, 1.815002, 1.876424, 1.515850, 1.331057, 1.277212, 1.440673, 1.414224, 1.384631, 1.290613, 1.284352, 1.308613, 1.350518, 1.425250, 1.344540, 1.072523, 0.971834, 1.018799, 1.082286, 1.024741, 0.979417, 0.877250, 0.765526, 0.792782, 0.696547, 0.777019, 0.464223, 0.577019, 0.712339, 0.186283, 0.789577, 1.801718, 2.029662, 2.454207, 2.560630, 2.718556, 2.895103, 2.182579, 1.794324, 1.971288, 2.235278, 2.582884, 2.076846, 1.720915, 1.346579, 1.303986, 1.816293, 2.390668, 2.641469, 2.542964, 2.542604, 2.250080, 2.168734, 2.148616, 1.670922, 1.468709, 1.593409, 1.901193, 1.908226, -1.206874, -1.658544, -2.678104, -3.201143, -3.000976, -3.020751, -2.998947, -3.276874, -3.152377, -2.617330, -2.602903, -2.476877, -2.679595, -2.847551, -2.481969, -2.021061, -2.073467, -2.579489, -3.013188, -2.710830, -2.790870, -3.109013, -2.753703, -2.872751, -3.154187, -2.745682, -2.432256, -2.161668, -2.663451, -2.949262, 1.594401, 1.128837, 1.227805, 1.134522, 1.347299, 1.291106, 1.133468, 1.355568, 0.760508, 1.033470, 1.128063, 0.666737, 1.345161, 1.232358, 0.490324, 0.567192, 0.572349, 1.407980, 1.729776, 1.826555, 1.995687, 1.758691, 1.255573, 1.456564, 1.218409, 1.385669, 1.057864, 1.342238, 1.624833, 1.602957, 1.113915, 1.326603, 1.036325, 0.976629, 1.336149, 1.458996, 1.332122, 0.876067, 0.361954, 0.477235, 0.521297, 0.148142, 0.223720, 0.200237, 0.408037, 0.535997, 0.557531, 0.566632, 0.352773, 0.424977, 0.371711, 0.507215, 0.595074, 0.632642, 0.470596, 0.183227, 0.597559, 0.944855, 0.843778, 0.255028, -0.377300, 1.526723, -0.276174, 0.109435, 1.160180, 0.896488, 1.020535, 0.662956, 0.477824, 0.004320, -0.061507, -0.012828, 0.038302, -0.108050, -0.012220, -0.138984, 0.021489, -0.024515, -0.122530, 0.029758, -0.196727, 0.179031, 0.034660, 0.027185, -0.090935, -0.292932, 0.036041, 0.064806, 0.075070, -0.216788, -0.113621, -0.126838, 0.049327, 0.122698, 0.491961, 0.335907, 0.270976, 0.361901, 0.082659, 0.014191, 0.048291, 0.154519, 0.175791, 0.009590, 0.007730, 0.082893, 0.164869, -0.006645, -0.007119, 0.219583, 0.164665, 0.043632, -0.136868, -0.038731, 0.129730, 0.094683, 0.018448, 0.007740, 0.080674, 0.052432, -0.576714, 0.646408, -0.550805, 0.244279, 1.193556, 1.076699, 0.992179, 0.761208, 0.502551, -0.052710, -0.004869, 0.049807, 0.054879, -0.116851, -0.043072, -0.234285, 0.030516, 0.020072, -0.134344, 0.057447, -0.215019, -0.174632, -0.334414, -0.037992, -0.064292, -0.369179, -0.247880, -0.172920, -0.011068, -0.438257, 1.515488, 1.411865, 2.111121, 2.307146, 2.090613, 2.025908, 1.851549, 2.074868, 2.228712, 2.335840, 2.517225, 2.481083, 2.425816, 2.371590, 2.281272, 2.013515, 1.833771, 1.799220, 1.967867, 2.060642, 1.834406, 1.543535, 1.543103, 1.735298, 1.732703, 1.799043, 1.691847, 1.584533, 1.548304, 1.419482, 1.012312, 2.064538, 3.227304, 3.350962, 2.933029, 2.731056, 2.714655, 2.807457, 3.014871, 3.183217, 2.515758, 2.670901, 2.822800, 2.522298, 2.908939, 3.148030, 3.013757, 2.842247, 3.725660, 4.088388, 3.977881, 3.352679, 2.942794, 3.413702, 3.882409, 3.586869, 3.697405, 3.857506, 3.914335, 3.783517, 0.143705, 1.252893, 1.519073, 1.284267, 0.920438, 0.561047, 0.353938, 0.619974, 0.877846, 0.581728, 0.518801, 0.901511, 1.107484, 0.737366, 0.930286, 0.980073, 1.079658, 0.789570, 0.973656, 1.457583, 1.583059, 1.454248, 1.241642, 1.142962, 1.097168, 1.138292, 1.226504, 1.014705, 1.270230, 1.230676, 1.015223, 2.644339, 3.369853, 2.778138, 2.328020, 2.257917, 2.470385, 2.521633, 2.364922, 2.759465, 2.289608, 2.253936, 2.138438, 2.196103, 2.506661, 2.477461, 2.568206, 2.742928, 3.818343, 3.796382, 3.556868, 3.094202, 2.085809, 2.632822, 3.714190, 3.134889, 3.211380, 3.654561, 3.569030, 3.375624, -0.945909, -0.172223, -0.127568, -0.771270, -0.521700, -0.320118, -0.125890, -0.383078, -0.606532, -0.351900, -0.215774, -0.051893, -0.085529, -0.132797, -0.094961, -0.190170, -0.408781, -0.303309, -0.167973, -0.240111, -0.299198, -0.371783, -0.492113, -0.401596, -0.254263, -0.102652, -0.199470, -0.287792, -0.253821, -0.331203, 1.723464, -0.629552, -0.066400, -0.204897, 0.008589, -0.105814, 0.095613, -0.071803, -0.192477, 0.195402, -0.013680, -0.022227, 0.022484, -0.014089, 0.038479, -0.042920, -0.203125, -0.116270, 0.056111, 0.061511, 0.051728, -0.003085, 0.206481, 0.239166, 0.098729, 0.286100, 0.399861, 0.263868, 0.263343, 0.332981, -0.421465, -0.437538, -0.706490, -0.910872, -0.645555, -0.585608, -0.504260, -0.554338, -0.563004, -0.600696, -0.525338, -0.638642, -0.621587, -0.561717, -0.612994, -0.717860, -0.720320, -0.717386, -0.897549, -0.945471, -1.042668, -1.109579, -1.201717, -1.030198, -0.954626, -1.077241, -1.170366, -0.924583, -0.982956, -1.019723, 1.469298, -0.468299, -0.029556, 0.121936, -0.010121, 0.109006, 0.472121, 0.172522, -0.099297, 0.344724, 0.227395, 0.300203, 0.376083, 0.278997, 0.384859, 0.016431, -0.081739, 0.136835, 0.277437, 0.168833, 0.316475, 0.408489, 0.732599, 0.590348, 0.390401, 0.674615, 0.989960, 0.728841, 0.706515, 0.886930, 2.240615, 3.043099, 4.109368, 4.836177, 4.704546, 4.754455, 4.898241, 5.317174, 5.408720, 5.648559, 5.891941, 5.875073, 5.841894, 5.945423, 5.676978, 5.316667, 4.960783, 5.092346, 5.420152, 5.807384, 5.390647, 4.970349, 4.913381, 5.239716, 5.174799, 5.371215, 5.379599, 5.285795, 5.406853, 5.242350, 1.871248, 3.691515, 5.152885, 5.529673, 5.200032, 5.156013, 5.224977, 5.458596, 5.905340, 6.929582, 6.855051, 6.868285, 7.068962, 7.081500, 6.768307, 6.693163, 6.265741, 7.331151, 8.273427, 7.524876, 7.336615, 7.634233, 7.536907, 8.079925, 8.188579, 7.669048, 7.851149, 7.841663, 7.842272, 7.353512, -0.366444, -1.875094, -2.012683, -1.783231, -2.448569, -2.948353, -3.343948, -2.889075, -2.747502, -3.275448, -3.229983, -3.281774, -3.154966, -2.700470, -2.731174, -2.766801, -2.861622, -3.188167, -3.982674, -2.937468, -3.468835, -3.633800, -3.950502, -4.010190, -3.616132, -4.242620, -4.691134, -4.450193, -4.644207, -4.076699, 3.050895, 3.532086, 3.737701, 2.867699, 3.046801, 2.551155, 2.307149, 2.252481, 3.122788, 3.965371, 3.143950, 3.698093, 4.496282, 3.811478, 4.040972, 4.150957, 3.566063, 4.634702, 5.098140, 4.521857, 4.369294, 4.542896, 4.281844, 5.097212, 5.644562, 4.642577, 4.924438, 4.805578, 4.831741, 4.181437, 0.472047, 0.149045, -0.478177, -0.117723, -0.442623, -0.619221, -0.438804, -0.273132, -0.327699, -0.398510, -0.422072, -0.313630, -0.361581, -0.371228, -0.280741, -0.427115, -0.432624, -0.405047, -0.527685, -0.527780, -0.371729, -0.254792, -0.109750, -0.286477, -0.494768, -0.521872, -0.467213, -0.406556, -0.466420, -0.356833, -0.696274, -0.288466, -0.150962, 0.152098, -0.151101, -0.047263, -0.066151, -0.111770, -0.183747, -0.116067, -0.179177, -0.053232, -0.033781, 0.023645, -0.107038, -0.017168, 0.287959, 0.117923, 0.012993, 0.073135, 0.047017, 0.003674, 0.286841, 0.181331, -0.033584, 0.007701, 0.077966, -0.106181, 0.025503, 0.381928, -0.749571, -0.442578, -0.445196, -0.115830, 0.012929, -0.086071, -0.520140, -0.627475, -0.534048, -0.581899, -0.568985, -0.731426, -0.861549, -0.793035, -0.752583, -0.981200, -1.129534, -1.021298, -0.997265, -0.996526, -0.957678, -1.089190, -1.149697, -1.218861, -0.803096, -0.922754, -1.121401, -0.862237, -1.093653, -1.340364, 0.057605, -0.397178, -0.052054, 0.082191, -0.022236, -0.162376, 0.030739, 0.164485, 0.043774, 0.110924, -0.073602, 0.126041, 0.268425, 0.277058, 0.022870, 0.344515, 0.911336, 0.567764, 0.268246, 0.378821, 0.545461, 0.646823, 0.901612, 0.734555, 0.330785, 0.380917, 0.554576, 0.352190, 0.656494, 1.212522, -2.203680, -0.905688, -0.098859, 0.725209, 1.124787, 1.149498, 1.228137, 1.069129, 0.723427, 0.492737, 0.231811, 0.428057, 0.408334, 0.651963, 0.915389, 1.132825, 1.389025, 0.869739, 0.618128, 0.466269, 0.749902, 0.509097, 0.191036, 0.376585, 0.487790, 0.237552, 0.410154, 0.509061, 0.274332, 0.616368, -0.763494, -0.475998, -0.053239, -0.123988, -0.173634, -0.241675, -0.257447, -0.323229, -0.304801, -0.201706, -0.157157, -0.080242, -0.084361, -0.151638, -0.191104, -0.402399, -0.282346, -0.354195, -0.338395, -0.352620, 0.266549, -0.248591, -0.560364, -0.426663, -0.180428, -0.455295, -0.461471, -0.356416, -0.548206, -0.487659, -0.063349, 0.013366, -0.011370, 0.054765, 0.090618, 0.033981, 0.044885, 0.004200, 0.123031, 0.080423, -0.114788, -0.136095, 0.020494, -0.048428, -0.119120, 0.113479, 0.110673, 0.053554, 0.075661, -0.059704, -0.060987, 0.004779, 0.027275, 0.037772, 0.028988, -0.014680, 0.007399, 0.031457, 0.141683, -0.032265, -0.462407, -0.162196, -0.118107, -0.077625, -0.128470, -0.073868, -0.246967, -0.314868, -0.296144, -0.200726, -0.232182, -0.157523, -0.171358, -0.317434, -0.159476, -0.336387, -0.247841, -0.181861, -0.327001, -0.399091, -0.003039, -0.176393, -0.703040, -0.522740, -0.348454, -0.553676, -0.541653, -0.420050, -0.558207, -0.559782, -1.011821, -0.377115, -0.189337, -0.930173, -0.597389, -0.360879, -0.116053, -0.475582, -0.727265, -0.369827, -0.184064, -0.130101, -0.150269, -0.213605, -0.246903, -0.264678, -0.448056, -0.337792, -0.154062, -0.181288, -0.340579, -0.348621, -0.492595, -0.435689, -0.342573, -0.202089, -0.246277, -0.336223, -0.298009, -0.353079, 2.225069, -0.343966, 0.178705, -0.051304, -0.011218, -0.206753, 0.056026, -0.126149, -0.281129, 0.042292, -0.041396, -0.012379, 0.100990, 0.039536, -0.015958, -0.018566, -0.199490, -0.077415, -0.001096, 0.000064, -0.102334, -0.005731, 0.197063, 0.185794, 0.082836, 0.234880, 0.422162, 0.274862, 0.259684, 0.415329, 0.393374, 0.362671, 0.473484, 0.734380, 0.703543, 0.613825, 0.732236, 0.699394, 0.576350, 0.536602, 0.652580, 0.726407, 0.826770, 0.731751, 0.695551, 0.673942, 0.444370, 0.569710, 0.728475, 0.657360, 0.823698, 0.793264, 0.788881, 0.764739, 0.759745, 0.819496, 0.778350, 0.616899, 0.673525, 0.565769, 1.856501, -0.087134, 0.379512, 0.164794, -0.214398, -0.199371, 0.268414, -0.024470, -0.157154, 0.264273, 0.230163, 0.370477, 0.440964, 0.234489, 0.282789, 0.202719, 0.020286, 0.198309, 0.122033, -0.023954, 0.143642, 0.413852, 0.692247, 0.629673, 0.442080, 0.718835, 1.004341, 0.757768, 0.835742, 1.018258, 0.479355, -0.490908, 0.548998, 0.404522, 0.718351, 0.768400, 0.389681, 0.317516, 0.342100, -0.015120, -0.442387, -0.377750, -0.407164, -0.361449, -0.259805, 0.109581, 0.356140, 0.344677, 0.385065, 0.287854, 0.078392, 0.136521, 0.090837, 0.063020, 0.077824, 0.038758, 0.042430, 0.072652, -0.051233, -0.025377, -0.190472, -0.193533, 0.323877, -0.344105, -0.074689, 0.017382, -0.186772, -0.157314, -0.275527, -0.030073, -0.230197, -0.188012, -0.100671, -0.073637, 0.163615, 0.212719, 0.048300, 0.048128, 0.037775, -0.188930, -0.054311, 0.538170, 0.693295, 0.379772, 0.122056, 0.191085, 0.130918, 0.159774, 0.255129, 0.413481, 0.523156, -0.599959, -0.485936, -0.287552, -0.507505, -0.583653, -0.489810, -0.166419, 0.022600, -0.001897, -0.216907, -0.210812, -0.349177, -0.091394, 0.516300, 0.658703, 0.565170, 0.447121, 0.157834, 0.141005, 0.353595, 0.917933, 0.935145, 0.632980, 0.490704, 0.715155, 0.687441, 0.771864, 0.698053, 0.905707, -0.051866, 0.136193, 0.302194, -0.214725, 0.248554, 0.106812, -0.159829, -0.122329, -0.174690, 0.060147, -0.194383, -0.199522, -0.172029, 0.019133, 0.424178, 0.429306, 0.223379, 0.429783, 0.246192, -0.044688, 0.379494, 1.280925, 1.230218, 0.905209, 0.475113, 0.610027, 0.549541, 0.596327, 0.669096, 0.918637, 3.980999, 4.717678, 5.880404, 6.482581, 6.174156, 6.084759, 6.260171, 6.958774, 7.136598, 7.411377, 7.835605, 7.852721, 7.599566, 7.638000, 7.450419, 6.918466, 6.334437, 6.721522, 7.350830, 7.494308, 7.021027, 6.666235, 6.701272, 6.942995, 6.936553, 7.220032, 7.229750, 6.948952, 7.073878, 6.835116, -0.425218, 1.223103, 1.777558, 1.761287, 1.783857, 1.831137, 1.824247, 1.888647, 1.711300, 1.894465, 1.991131, 2.063227, 2.298793, 2.196734, 2.158035, 2.508622, 2.488547, 2.516448, 2.827211, 2.676370, 2.733159, 2.438178, 2.366692, 2.800295, 2.826134, 2.581796, 2.553777, 2.889392, 2.778899, 2.717821, -0.100570, 0.134765, 0.304424, -0.013565, -0.052329, 0.079176, 0.022802, -0.032408, -0.190066, -0.433051, -0.437643, -0.406434, -0.307909, -0.196170, -0.224799, -0.216074, -0.215384, 0.120797, 0.077001, -0.091618, -0.182966, -0.164276, 0.041715, 0.238244, 0.004163, 0.015492, -0.025310, -0.208397, -0.261023, -0.310594, -0.088491, 0.963345, 1.251517, 0.745459, 1.014916, 0.938175, 0.950087, 0.947338, 0.684387, 0.907621, 0.774908, 1.168266, 1.459711, 1.194657, 1.071344, 1.468789, 1.540945, 1.525218, 1.605036, 1.557465, 1.552791, 1.135917, 1.032712, 1.554079, 1.837606, 1.221393, 1.181894, 1.551234, 1.451377, 1.457661, 0.372458, 0.668562, 0.553676, 0.891126, 0.842959, 0.452148, 0.482778, 0.629035, 0.796262, 0.880831, 0.698870, 0.908722, 1.088822, 1.005331, 0.940602, 0.761037, 0.620471, 0.581150, 0.615630, 0.792962, 0.648412, 0.521078, 0.482217, 0.625644, 0.827412, 0.741795, 0.367098, 0.313982, 0.316247, 0.585672, 0.544285, 2.105668, 3.593178, 3.661212, 3.616009, 3.981730, 3.523803, 3.595495, 3.489553, 3.544564, 3.506157, 3.885893, 3.918618, 3.955779, 3.553593, 3.319721, 3.731913, 3.720194, 3.862858, 4.339663, 3.855909, 3.129182, 3.003368, 2.787341, 3.005714, 2.904988, 3.016884, 3.322567, 3.168309, 2.927272, -2.044165, -3.075097, -4.161674, -3.808567, -3.693397, -3.726004, -3.509230, -3.687452, -4.002870, -3.777246, -3.155962, -3.957498, -4.258157, -3.801281, -4.002326, -3.775591, -4.236577, -4.069633, -4.070568, -3.951233, -3.967294, -3.538939, -3.590255, -3.655058, -4.131930, -4.235633, -4.491786, -4.745916, -4.161845, -4.082005, 0.969803, 2.584316, 4.485410, 4.293933, 4.171349, 4.272660, 3.536449, 3.898738, 3.403304, 3.112860, 3.329505, 3.323738, 3.843744, 4.163542, 3.782388, 3.222646, 3.814827, 4.041246, 3.993659, 4.992385, 4.516372, 2.994786, 2.448592, 3.291817, 3.708133, 3.180942, 3.240393, 3.769323, 3.642948, 3.134288, -1.123361, -0.580210, -0.266221, -0.988448, -0.731944, -0.428431, -0.067446, -0.517649, -0.801411, -0.439772, -0.217983, -0.167423, -0.269050, -0.337704, -0.395204, -0.346902, -0.502672, -0.455838, -0.282339, -0.269117, -0.420547, -0.433855, -0.628795, -0.571278, -0.453162, -0.309945, -0.350870, -0.463343, -0.457618, -0.445054, 2.306908, -0.087797, 0.112201, -0.238669, -0.060060, -0.352450, -0.117517, -0.308588, -0.254729, -0.052137, -0.150013, -0.188943, -0.059561, -0.082422, -0.042767, 0.007678, -0.268631, -0.223114, -0.127993, -0.156768, -0.332152, -0.179221, -0.067655, -0.081453, -0.091125, 0.177443, 0.280231, 0.073817, 0.164330, 0.293258, -0.318020, -0.183846, -0.042561, -0.274316, -0.209606, -0.035806, 0.107262, 0.041506, -0.009599, -0.029275, -0.040371, -0.373714, -0.353078, -0.201153, -0.200132, -0.166592, -0.166638, -0.178410, -0.016854, -0.157624, -0.097294, 0.012374, -0.026349, -0.128318, -0.233153, -0.400821, -0.204611, -0.268346, -0.332116, -0.240299, 2.111246, -0.134060, 0.332363, 0.119017, -0.143762, -0.346263, -0.007726, -0.243523, -0.207346, 0.175251, 0.182216, 0.131009, 0.193056, 0.026270, 0.125095, -0.011326, -0.088921, 0.054907, -0.033946, -0.113221, -0.133291, 0.198419, 0.295502, 0.282250, 0.201467, 0.627638, 0.868844, 0.645351, 0.771651, 0.897007, 0.394674, -0.276104, -0.724319, -0.339257, -0.547264, -0.702625, -0.556736, -0.367027, -0.390202, -0.441008, -0.330601, -0.233802, -0.242738, -0.283767, -0.240360, -0.459643, -0.453447, -0.371513, -0.434027, -0.522769, -0.410505, -0.283883, -0.115307, -0.172678, -0.285440, -0.152935, -0.260054, -0.246140, -0.275758, -0.242222, -0.790010, 0.004955, -0.065534, 0.268760, -0.278430, -0.073636, -0.209412, -0.152252, -0.173056, -0.189849, -0.186736, -0.096305, -0.256857, -0.309832, -0.317408, -0.196486, -0.020170, -0.052390, -0.110560, -0.175176, -0.095248, 0.019807, 0.242167, 0.189831, -0.051241, 0.102150, 0.150987, 0.248067, 0.178028, 0.383760, -0.050923, 0.394731, 0.285479, 0.448241, 0.582566, 0.488981, 0.367406, 0.306639, 0.251158, 0.298399, 0.259450, 0.385981, 0.264323, 0.059597, 0.098170, -0.208767, 0.002587, 0.104480, 0.061262, 0.216606, 0.050264, -0.180477, -0.278229, -0.149743, -0.024642, -0.033549, -0.106652, -0.153658, -0.211653, -0.263380, -0.065534, 0.116522, 0.024569, 0.194284, 0.009707, 0.072425, -0.095592, -0.080151, -0.102564, -0.108622, -0.266560, -0.045123, -0.200246, -0.261813, -0.176467, -0.003990, 0.221451, 0.245338, -0.015071, -0.095446, 0.114874, 0.457804, 0.730210, 0.450202, 0.210355, 0.380158, 0.446066, 0.502566, 0.456773, 0.701234, -1.525521, -0.545127, 0.293686, 1.226942, 1.851706, 1.778123, 1.532617, 1.523634, 1.441684, 1.152067, 0.999041, 1.292157, 1.203558, 1.452282, 1.714406, 2.094854, 2.331084, 1.456480, 0.824375, 1.039441, 1.701979, 1.288622, 0.876433, 1.092102, 0.885862, 0.953782, 1.403638, 1.984117, 1.604125, 0.932677, -0.155719, -0.283411, -0.013096, -0.191883, 0.046373, -0.239667, -0.192910, -0.216227, -0.206041, -0.184243, -0.367272, -0.332067, -0.271250, -0.334011, -0.350522, -0.416350, -0.075669, -0.396693, -0.498250, -0.394962, 0.712356, -0.053791, -0.604027, -0.229038, -0.411158, -0.497969, -0.453909, -0.308549, -0.508714, -0.522309, -0.303898, -0.502554, -0.336719, -0.063138, -0.076243, 0.017760, -0.006729, -0.264486, -0.150192, 0.070129, -0.062636, -0.109720, 0.065878, 0.094513, -0.125843, -0.295150, -0.175276, -0.215071, -0.057972, -0.210313, -0.169506, -0.107373, -0.207098, -0.059513, -0.152751, -0.015592, -0.083469, -0.220424, -0.289811, -0.054462, 0.333637, 0.034725, 0.015399, -0.206766, 0.232231, -0.203575, -0.272591, -0.374078, -0.230718, -0.098899, -0.270317, -0.135704, -0.143710, -0.152740, -0.370337, -0.335932, -0.019865, -0.427097, -0.516391, -0.397907, 0.322161, -0.325132, -0.646617, -0.379427, -0.471098, -0.503220, -0.519638, -0.348829, -0.554171, -0.542920, -0.203616, -0.398198, 0.287408, -0.198704, -0.362910, -0.530580, -0.728473, -0.510710, -0.349037, -0.416366, -0.325145, -0.165365, 0.022244, 0.106185, 0.081404, -0.177688, 0.091922, 0.460409, 0.383175, -0.027221, -0.044504, 0.225781, 0.495952, 0.289205, -0.036748, 0.115878, 0.261638, 0.133207, 0.065272, -0.005219, -0.336550, -0.242165, 0.124576, -0.016281, 0.081115, -0.120730, -0.254440, 0.020974, -0.130167, -0.204583, -0.175325, -0.163567, -0.223601, -0.255094, -0.145369, -0.176192, 0.037442, 0.215286, 0.119200, -0.195100, -0.229023, -0.295989, -0.208570, -0.177723, -0.055202, -0.045805, -0.143512, -0.201428, -0.067622, -0.318804, 0.124057, 0.368118, 0.336980, 0.368535, 0.398658, 0.455666, 0.465416, 0.476491, 0.434000, 0.470651, 0.545595, 0.656513, 0.547684, 0.492764, 0.474816, 0.417573, 0.365939, 0.367591, 0.355398, 0.356888, 0.301338, 0.312125, 0.314121, 0.423877, 0.451036, 0.321806, 0.239021, 0.284188, 0.217121, 0.236178, -0.199846, 0.629274, -0.424771, -0.258541, -0.099904, -0.025610, -0.278140, 0.056745, -0.118137, -0.269945, -0.319713, -0.196224, -0.298667, -0.315182, -0.138085, -0.245427, -0.160343, -0.044912, -0.056444, -0.251675, -0.297716, -0.456664, -0.432170, -0.369964, -0.275589, -0.367112, -0.371501, -0.418749, -0.330660, -0.459601, -0.671170, -0.154270, -0.473805, -0.491284, -0.760957, -0.804406, -0.851433, -0.764452, -0.592336, -0.571451, -0.474459, -0.661026, -0.682480, -0.724689, -0.879966, -0.761722, -0.854288, -1.088810, -1.077058, -1.006314, -0.988887, -1.107917, -1.125595, -0.953319, -0.750273, -0.883163, -0.811159, -0.923089, -0.986320, -0.881267, 0.295005, -0.211689, -0.726161, -0.601595, -0.289544, -0.319022, -0.283761, -0.219333, -0.281509, -0.389927, -0.166418, -0.311173, -0.218442, -0.298069, -0.344107, -0.328562, -0.394281, -0.433926, -0.278669, -0.287480, -0.453956, -0.693814, -0.677149, -0.482575, -0.351796, -0.566492, -0.529120, -0.532043, -0.573636, -0.608821, -0.163553, -0.059082, -0.027733, 0.130797, 0.105728, 0.050008, 0.056312, 0.122050, -0.005081, 0.046920, 0.025205, 0.028948, 0.154298, 0.212306, 0.028399, 0.088174, 0.000057, 0.084677, 0.260323, 0.221348, 0.137866, 0.040454, 0.122025, 0.063118, 0.151062, 0.219859, 0.032848, 0.024352, 0.043465, 0.109087, 0.388857, -0.555520, -0.466460, -0.445303, -0.267912, -0.273548, -0.183268, -0.204369, -0.247091, -0.388582, -0.100278, -0.310676, -0.181002, -0.373642, -0.410775, -0.262065, -0.357772, -0.462180, -0.297022, -0.186117, -0.378352, -0.645072, -0.700975, -0.492381, -0.330022, -0.576115, -0.554015, -0.532180, -0.606408, -0.631719, 0.404227, -0.484100, -0.888084, -0.673125, -0.847034, -0.812695, -0.687041, -0.516407, -0.512987, -0.637864, -0.470586, -0.194059, -0.150154, -0.247980, -0.238740, -0.552324, -0.473373, -0.265458, -0.349095, -0.567693, -0.569865, -0.469997, -0.223934, -0.407353, -0.653937, -0.405071, -0.511687, -0.513490, -0.534737, -0.535277, -0.625277, 0.153818, 0.296700, 0.290066, -0.250201, -0.055105, -0.115256, -0.086846, -0.019806, -0.276507, -0.136928, -0.011898, -0.091425, -0.191119, 0.029508, -0.002946, 0.204528, 0.158882, 0.090733, -0.068630, -0.089052, 0.114392, 0.566630, 0.218621, 0.026061, 0.461887, 0.090817, 0.056452, 0.123871, 0.072559, 0.472908, 0.863754, 0.610259, 0.154404, -0.065063, -0.018888, 0.036787, 0.162454, 0.245105, 0.163025, 0.206610, 0.192706, 0.204573, 0.398189, 0.435850, 0.480682, 0.539130, 0.701572, 0.779725, 0.548157, 0.539201, 0.849178, 1.195368, 0.939397, 0.758704, 1.082125, 0.893210, 0.902117, 0.997008, 0.838618, -0.266017, 0.740692, 0.327752, 0.430106, -0.039371, -0.055984, -0.098558, -0.002241, 0.110918, -0.149163, -0.006810, 0.024311, 0.003474, 0.021075, 0.233369, 0.139319, 0.386334, 0.515271, 0.452085, 0.168277, 0.180493, 0.638410, 1.134556, 0.643636, 0.304295, 0.886165, 0.502677, 0.425357, 0.634400, 0.459165, 0.619458, 0.071083, 0.183792, 0.359782, 0.434772, 0.575018, 0.524242, 0.572967, 0.640372, 0.584148, 0.290046, 0.371130, 0.384962, 0.258580, 0.265505, 0.254898, 0.231589, 0.298470, 0.370797, 0.351442, 0.217542, 0.200681, 0.256048, 0.227814, 0.100441, 0.163890, 0.135287, 0.076793, 0.025796, -0.027044, 0.144072, -0.119880, 0.216100, 0.093735, -0.098254, 0.148509, 0.342732, 0.390464, 0.320850, 0.128331, -0.033394, 0.318335, 0.263863, 0.070296, 0.096968, -0.014721, -0.064821, -0.065606, -0.035088, -0.151976, -0.214696, -0.068387, 0.082066, 0.032464, -0.144431, 0.099629, 0.046124, 0.040863, 0.036070, 0.065368, 0.848306, 0.240615, 0.163805, 0.027725, -0.022567, 0.115280, 0.665621, 0.723757, 0.702856, 0.714313, 0.678643, 0.775330, 0.751936, 0.764540, 0.697819, 0.472963, 0.476444, 0.484472, 0.489717, 0.558349, 0.672724, 0.878621, 0.825549, 0.682917, 0.714167, 0.988389, 1.016382, 1.044999, 1.052525, 1.054442, 0.341091, 0.263683, 0.234253, 0.115235, -0.081198, 0.006689, 0.357423, 0.467662, 0.271828, 0.245027, 0.027093, 0.600905, 0.408971, 0.293807, 0.336121, 0.025872, -0.011606, 0.023601, 0.031184, -0.067511, -0.073372, 0.123865, 0.281837, 0.142474, -0.107453, 0.335832, 0.374132, 0.313698, 0.314568, 0.383409, 0.419659, -0.654770, -1.017520, -0.660198, -0.865539, -0.803149, -0.743793, -0.572094, -0.542495, -0.680520, -0.490440, -0.217011, -0.155908, -0.211862, -0.230833, -0.590311, -0.529714, -0.217380, -0.285821, -0.655899, -0.624944, -0.482146, -0.180935, -0.381638, -0.663281, -0.375450, -0.526721, -0.544141, -0.545051, -0.543657, -0.478830, 0.363286, 0.448342, 0.336454, -0.249696, -0.058204, -0.302054, -0.170404, 0.030069, -0.067450, 0.010711, -0.052608, -0.155442, -0.216546, -0.040489, -0.093550, 0.007754, 0.091161, 0.076707, -0.220357, -0.185392, 0.172197, 0.433206, 0.164655, 0.010462, 0.490381, 0.080072, -0.021058, 0.053488, -0.019732, -0.791945, -1.497609, -1.196604, -0.540626, -0.381188, -0.527872, -0.552904, -0.577171, -0.739023, -0.743557, -0.618186, -0.417693, -0.472946, -0.556541, -0.767887, -0.785116, -0.765235, -0.835120, -0.767128, -0.683539, -0.888195, -1.237751, -1.308996, -1.249607, -0.981285, -1.354445, -1.131939, -0.918891, -0.910591, -0.998651, 0.034628, 1.330751, 0.833628, 0.423378, -0.150965, -0.080369, -0.195687, -0.086917, 0.205821, 0.161750, 0.141439, -0.060963, 0.003510, -0.068308, 0.147193, 0.226436, 0.241062, 0.489106, 0.413880, -0.037887, 0.051547, 0.843401, 1.129288, 0.795140, 0.437720, 1.117537, 0.712408, 0.441959, 0.674047, 0.525168, 0.461710, -0.419130, 0.432769, 0.389406, 0.630662, 0.611776, 0.306050, 0.203611, 0.268677, 0.052445, -0.354438, -0.266122, -0.248591, -0.200140, -0.136669, 0.076495, 0.266425, 0.310699, 0.410063, 0.299939, 0.096679, 0.238838, 0.165797, 0.004715, -0.138612, 0.040161, 0.077564, 0.062453, -0.063614, -0.090395, -0.213381, -0.127541, 0.199828, -0.329507, -0.190243, -0.069508, -0.006988, 0.029532, 0.226423, 0.244652, -0.154672, 0.051398, -0.066040, 0.057241, 0.206185, 0.342801, 0.279097, 0.287253, 0.178661, 0.170760, 0.061821, 0.598313, 0.964168, 0.418841, 0.166052, 0.590282, 0.473902, 0.363531, 0.423903, 0.407638, 0.186582, 0.820458, 0.816915, 0.548892, 0.596996, 0.726720, 0.694344, 0.653701, 0.953181, 1.017117, 0.738323, 0.710425, 0.713155, 0.580933, 0.418390, 0.455013, 0.629151, 0.478568, 0.655764, 0.686094, 0.622931, 0.504167, 0.599159, 0.478618, 0.365606, 0.363972, 0.396946, 0.533897, 0.450381, 0.478747, -0.087740, 0.162141, 0.242434, -0.066899, 0.232121, 0.203625, -0.186646, 0.114104, 0.183986, 0.320408, -0.088745, -0.058086, -0.055146, 0.121129, 0.277849, 0.436915, 0.430969, 0.536027, 0.378309, 0.376390, 0.418247, 1.168158, 1.368995, 0.705558, 0.473651, 1.074129, 0.934228, 0.863401, 0.801434, 0.798499, -0.166217, -0.352017, 0.301364, -0.231591, -0.360645, -0.530113, -0.746048, -0.540082, -0.350404, -0.402547, -0.320016, -0.155364, 0.000538, 0.097724, 0.089744, -0.143336, 0.068474, 0.416374, 0.345313, -0.022117, -0.004674, 0.221969, 0.446773, 0.283542, -0.030050, 0.090653, 0.237165, 0.155549, 0.097745, -0.002820, -0.428859, -0.310279, 0.117300, 0.037859, -0.024901, -0.151270, -0.346732, 0.055983, -0.039458, -0.224828, -0.184713, -0.197131, -0.256349, -0.249795, -0.248464, -0.176973, 0.071086, 0.220186, 0.130365, -0.260525, -0.255636, -0.323595, -0.180295, -0.112240, -0.110163, -0.089327, -0.252622, -0.224117, -0.062452, -0.342996, -0.070796, -0.223842, -0.241066, -0.284713, -0.401120, -0.316163, -0.321001, -0.269311, -0.258837, -0.257784, -0.234449, -0.353458, -0.289784, -0.201566, -0.113297, -0.181597, -0.048451, -0.105750, -0.099772, -0.137767, -0.201304, -0.185405, -0.255569, -0.277809, -0.241000, -0.208590, -0.185449, -0.228498, -0.186041, -0.147577, -0.252025, 0.726241, -0.300485, -0.303333, -0.197271, -0.080125, -0.342623, -0.072275, -0.079254, -0.345444, -0.214461, -0.228722, -0.325433, -0.250570, -0.254387, -0.272345, -0.136027, 0.013175, 0.039232, -0.266087, -0.274272, -0.461702, -0.417157, -0.330089, -0.316048, -0.332690, -0.396093, -0.382811, -0.316157, -0.463469, -0.353067, -0.390098, -0.021744, 0.219432, 0.061335, -0.006043, 0.188857, 0.273649, 0.204144, 0.513537, 0.493151, 0.336377, 0.261583, 0.437570, 0.276852, 0.305338, 0.122085, -0.153042, -0.004134, 0.350333, 0.317872, 0.083168, 0.095703, 0.046611, 0.040159, -0.152500, -0.069344, -0.182541, -0.331929, -0.221760, 0.380262, 0.702195, 1.628720, 1.041300, 1.907086, 2.133298, 1.506517, 2.194042, 2.478380, 1.904744, 1.809475, 2.057530, 2.329132, 2.893250, 2.533834, 3.080997, 2.906224, 2.039166, 2.344191, 3.269591, 2.424619, 1.534473, 1.812534, 1.768116, 1.117961, 0.925448, 0.916684, 0.981994, 0.716103, 0.600387, -0.213740, 0.484632, 1.387122, 1.309295, 1.598285, 1.476660, 1.344983, 1.356186, 1.035569, 1.286480, 1.096065, 1.391486, 1.633204, 1.375255, 1.409665, 1.900967, 1.269144, 1.300542, 1.976806, 2.263605, 1.128536, 0.962341, 1.721800, 1.690728, 1.085760, 0.897180, 0.855443, 1.483066, 1.409341, 0.793652, 0.582602, 1.000471, 1.305156, 0.795233, 1.160136, 1.411077, 1.020300, 1.943538, 2.110880, 1.476223, 1.377507, 1.496074, 2.341426, 2.163099, 1.579817, 2.309305, 2.961542, 1.878813, 1.596620, 2.912151, 2.488727, 1.472175, 1.103359, 1.306734, 0.965461, 0.851171, 0.859517, 0.744425, 0.654182, 0.526443, -0.123446, -0.044946, 0.412641, 1.113841, 1.490252, 1.279449, 1.169085, 1.334462, 1.381746, 1.179137, 1.155389, 1.312549, 1.261771, 1.354534, 1.410939, 1.476085, 1.627193, 1.230683, 1.006986, 1.109376, 1.468810, 1.234154, 0.976654, 1.025644, 0.903281, 1.021637, 1.141822, 1.376846, 1.175297, 0.801135, 0.283398, -0.094944, 0.026330, -0.104252, -0.165841, -0.195227, -0.358178, -0.322075, -0.121791, -0.073562, -0.358183, -0.298554, -0.281614, -0.090351, -0.178447, -0.196511, -0.176852, -0.367445, -0.313415, -0.204291, 0.316679, -0.238457, -0.552921, -0.259074, -0.246524, -0.411851, -0.372446, -0.252386, -0.335642, -0.439262, 0.695201, 0.801873, 0.581365, 0.620814, 0.707195, 0.613472, 0.522688, 0.568267, 0.545768, 0.361758, 0.177446, 0.011193, 0.221526, 0.442488, 0.307826, 0.252441, 0.192537, 0.434671, 0.576824, 0.525263, 0.410880, 0.355832, 0.366317, 0.146596, 0.377664, 0.207659, 0.155816, 0.411642, 0.549285, 0.436765, 0.564711, 0.138221, 0.102412, -0.066622, 0.013828, -0.130606, -0.418061, -0.332612, -0.097831, 0.062038, -0.309175, -0.288298, -0.158659, -0.051700, -0.248985, -0.093487, -0.202159, -0.304677, -0.470712, -0.156772, 0.099109, -0.386351, -0.574944, -0.362839, -0.207973, -0.408131, -0.409574, -0.422398, -0.405692, -0.472669, 2.370921, 1.882182, 2.723297, 3.040512, 2.836999, 2.797996, 2.853536, 3.248609, 3.262171, 3.470204, 3.619460, 3.637166, 3.654991, 3.589013, 3.368733, 3.160891, 2.857072, 3.162865, 3.521821, 3.763357, 3.344923, 3.129019, 3.166124, 3.214216, 3.112251, 3.217834, 3.301107, 3.069139, 3.087093, 2.955458, 0.698773, 3.170571, 4.214621, 4.562465, 4.920050, 4.401690, 4.281868, 4.084193, 4.546291, 4.728785, 4.723032, 5.224461, 5.189953, 4.926980, 5.160500, 5.245969, 5.329199, 5.607732, 5.561625, 4.839257, 5.148645, 5.287227, 4.752265, 5.767740, 6.143723, 5.472480, 5.616967, 5.882160, 5.967574, 5.893167, 1.583079, 2.169519, 2.286877, 2.258291, 2.230827, 1.566203, 1.466567, 1.481246, 1.918764, 2.510950, 1.867066, 1.899242, 1.833554, 1.524729, 1.873374, 1.996932, 2.077909, 2.038982, 1.904218, 1.783626, 2.254283, 2.320978, 2.370103, 2.722417, 3.314523, 3.140731, 2.956869, 3.089339, 3.032846, 3.061538, 0.197071, 2.285734, 2.811432, 2.591023, 2.836039, 2.011081, 1.887943, 1.764019, 2.332108, 2.710594, 2.835607, 3.028075, 3.164169, 3.358530, 3.080581, 3.468928, 3.509187, 3.374193, 3.806473, 3.229523, 3.572809, 3.151061, 2.528399, 3.856328, 4.775347, 3.647925, 3.771531, 4.257247, 4.262265, 4.154634, -0.675897, -0.557240, -0.626152, -0.583435, -0.694977, -0.675933, -0.697525, -0.617336, -0.487116, -0.549614, -0.399904, -0.512669, -0.644109, -0.712835, -0.825132, -0.693919, -0.804532, -0.999481, -0.959816, -0.868944, -0.907828, -1.071558, -1.057471, -0.939228, -0.736889, -0.859555, -0.848968, -0.892693, -0.876593, -0.862905, 0.329199, -0.031965, -0.108512, -0.188300, -0.012078, -0.031737, -0.025731, -0.019333, -0.112307, -0.221504, 0.011573, -0.160719, -0.218290, -0.210478, -0.225706, -0.177695, -0.223586, -0.277980, -0.185766, -0.057657, -0.257734, -0.562196, -0.430298, -0.334164, -0.194274, -0.450358, -0.400555, -0.370402, -0.411030, -0.494567, 1.066726, 0.865628, 0.922866, 0.831757, 0.864973, 0.862206, 0.760663, 0.707878, 0.717103, 0.589878, 0.738803, 0.765284, 0.715937, 0.600776, 0.484671, 0.639920, 0.804169, 0.708060, 0.684117, 0.888789, 0.755243, 0.744758, 0.687633, 0.771568, 0.761685, 0.653413, 0.651778, 0.717845, 0.692472, 0.691430, 0.217674, -0.156328, -0.025978, -0.077254, -0.109460, -0.045647, 0.158251, -0.005029, 0.064645, -0.186325, 0.028566, -0.185135, -0.195889, -0.189148, -0.188476, -0.226775, -0.233023, -0.305043, -0.225071, 0.067593, -0.250811, -0.503390, -0.483612, -0.425302, -0.228446, -0.494544, -0.511228, -0.468897, -0.495118, -0.499186, 0.461352, -0.575199, 0.502445, 0.459642, 0.711938, 0.754333, 0.435694, 0.296007, 0.261363, -0.021550, -0.438147, -0.380908, -0.349262, -0.307841, -0.283605, 0.048140, 0.311601, 0.310757, 0.453210, 0.314025, 0.061397, 0.171114, 0.153021, 0.028015, -0.070929, 0.061022, 0.040991, 0.041928, -0.079684, -0.047440, -0.206015, -0.198024, 0.190019, -0.354864, -0.035431, -0.077838, -0.151711, -0.230395, -0.144878, -0.015012, -0.169111, -0.130882, -0.234470, -0.080720, 0.130128, 0.075553, -0.032413, 0.126373, -0.007287, -0.046004, -0.105234, 0.377742, 0.635673, 0.285504, -0.012616, 0.254761, 0.105867, 0.187814, 0.308985, 0.341694, -0.488315, 0.236503, 0.228083, -0.028968, 0.199938, 0.314581, 0.136763, -0.083009, -0.097501, -0.093578, -0.083433, -0.132912, -0.157798, -0.180047, -0.267313, -0.210152, -0.258330, -0.293676, -0.246542, -0.238842, -0.285072, -0.491328, -0.582255, -0.563488, -0.353401, -0.433396, -0.487545, -0.433037, -0.507852, -0.564041, 0.022412, 0.010913, 0.067445, -0.171321, 0.364562, -0.086145, -0.242749, -0.226897, -0.143484, 0.085619, -0.129911, -0.058160, -0.238537, 0.011818, 0.363895, 0.251364, 0.066030, 0.421976, 0.270983, 0.126310, 0.278503, 0.978577, 1.075544, 0.767793, 0.329855, 0.578338, 0.552978, 0.657562, 0.762135, 0.831402, 0.525986, 0.290621, 0.182444, 0.201771, -0.056433, -0.370260, -0.486388, -0.394079, -0.118416, -0.001652, 0.047024, 0.092574, 0.036876, -0.045887, -0.165332, -0.116923, 0.079747, 0.220438, 0.100126, 0.141403, 0.309616, 0.460664, 0.499029, 0.367459, 0.404963, 0.395167, 0.316417, 0.375917, 0.386728, 0.608010, -0.062481, 0.057877, -0.234874, 0.160572, 0.127444, 0.093661, 0.166113, 0.043836, -0.028395, -0.016621, 0.067531, 0.055743, 0.035741, -0.000339, -0.061066, -0.122092, -0.198665, -0.130340, -0.093420, -0.082933, -0.027374, -0.012396, -0.214540, -0.304491, -0.152440, -0.025411, -0.112510, -0.113513, -0.192226, -0.049578, -0.500938, -0.665917, -0.714991, -0.552509, -0.710320, -0.975258, -0.999375, -0.801143, -0.756945, -0.857888, -0.653132, -0.689725, -0.671656, -0.660553, -0.743572, -0.767075, -0.648762, -0.707203, -0.750689, -0.758161, -0.564651, -0.533914, -0.402010, -0.409230, -0.608568, -0.706521, -0.674358, -0.659370, -0.611919, -0.517628, -0.395481, -0.423193, -0.129007, -0.153149, -0.051523, 0.121390, 0.271122, 0.077007, 0.012161, -0.016451, -0.078917, -0.042592, -0.139826, -0.051225, -0.060885, -0.148816, -0.307877, -0.232499, -0.180368, -0.141738, -0.197027, -0.473000, -0.491246, -0.500054, -0.281247, -0.274001, -0.339028, -0.347926, -0.473180, -0.453649};
static RBF_CONST rbf_float RBF_WIDTHS[] = {3.681883, 2.775458, 19.781219, 4.233552, 2.825784, 4.854466, 15.249630, 3.291694, 3.579957, 2.872660, 3.891457, 15.249630, 2.775458, 5.009712, 2.872660, 3.083316, 4.700274, 3.578096, 53.446709, 2.973413, 3.526480, 22.068493, 8.205912, 16.150513, 4.890287, 14.802613, 4.228755, 19.781219, 3.712312, 4.571602, 4.381852, 4.091424, 20.293806, 17.369373, 3.083316, 3.579957, 4.176137, 2.946427, 2.825784, 3.681883, 4.279811, 3.712312, 4.279811, 3.080958, 13.403784, 4.176137, 14.802613, 3.224516, 4.317250, 2.973413};
static RBF_CONST rbf_float RBF_WEIGHTS[] = {2.116523, -3.522356, 2.026421, -5.005535, -12.479549, 28.519947, -1.093222, -3.587140, -5.996374, -3.936327, -1.638448, 4.579233, 2.305648, 1.014472, -13.647284, 8.180051, -3.989032, -3.152801, 54.305187, -7.913333, -7.172157, -26.459846, 6.094970, -8.911318, 1.115346, -4.299249, 3.258966, 0.042769, 1.801135, -0.615416, -0.492910, 0.654419, -1.773715, 0.490433, -0.450608, 0.435166, -0.736663, 13.398238, -0.004380, 2.164010, -0.558190, 12.516658, -2.298271, -16.675566, 0.867887, -0.473431, -2.707791, -5.686308, -20.627755, 5.915940, -9.698724, 62.660505, -30.626027, 0.466756, 6.301812, -11.302902, -0.602169, 4.220118, 2.977019, -10.206412, 1.726532, -3.331147, 1.233778, -0.001558, 1.719443, -1.870431, -3.845475, -1.172742, 6.600439, 1.763737, -4.248774, 1.399372, 0.111060, -0.030019, 0.382338, -0.553803, 1.169771, -0.300945, 0.039744, 0.035247, -0.333094, -0.170793, 0.234789, -0.563147, -6.446214, -6.810110, -2.199704, 11.020212, 22.728976, -11.000815, 0.576032, 0.250791, 7.039968, -3.407274, -5.351383, -6.261896, -4.572273, 5.499058, 1.613849, -4.229535, -6.482805, 9.283193, -4.058649, -5.958141, 5.559623, 0.339359, -2.764082, 5.361114, 34.664832, -7.315027, 0.690577, -18.217228, -25.811728, 8.061203, 5.286700, 3.722987, -4.328835, -5.196718, 4.192475, 5.019855, 2.884734, -9.663300, -1.253902, -5.614060, 2.961208, 16.109135, -7.537033, 0.684995, -4.305577, 2.569441, 1.663835, 1.592059, 1.121460, 5.681167, -0.230241, 1.654719, -3.413130, 0.582677, -0.135647, -5.001075, 1.051062, 0.659044, -1.052467, -0.981029, -0.504383, 1.142837, -9.714117, -3.473463, -3.798002, -6.702493, -26.269378, -1.492576, 5.705543, 54.003773, -3.348774, -6.583799, -0.246279, -5.600267, 2.213757, 0.003446, 1.066616, -2.957496, -3.709434, -0.891394, 14.114975, 1.618247, -2.110919, -3.759517, 25.644085, -6.159974, 0.709668, -1.852999, -15.186749, -13.187553, -1.064240, -3.297113, 1.317101, 3.958211, 7.013394, 2.777234, 14.106862, -1.171167, -0.829223, -5.084469, -4.989561, -2.105757, -0.017742, -1.342861, -7.967145, -2.639005, 8.186027, 4.411869, 0.454531, -3.126372, 3.735002, -1.218172, 1.036244, -7.415593, -7.508478, 15.076752, 0.849925, -3.237287, 3.179723, -1.829652, 5.025024, -2.854960, -1.406878, -4.501410, -3.424685, -1.046225, -9.574919, 1.020242, -5.457952, 2.343868, 0.076948, 20.091508, -2.544166, -0.390119, -1.115175, -2.139349, 1.105094, -3.159226, -0.532139, 6.583765, 4.123705, -2.981366, 2.424877, -1.562039, -3.134731, -0.785774, -17.032842, 3.181551, 5.413525, 0.863017, 14.309990, -1.461844, 4.726242, 7.698858, -6.236641, -7.864517, 0.663358, -1.008160, 1.442102, -6.026542, 0.179127, -0.157683, -6.410669, 2.841893, -7.808543, -8.581549, 3.288613, 21.953464, 0.456531, 4.187920, -0.277773, -0.799873, -0.520717, 0.229037, 0.907905, 0.393598, -1.989855, -2.376699, 1.583989, -1.789752, -0.021875, 2.589777, 1.000422, -2.197222, -1.813695, -1.839873, 2.579692, -2.860480, -2.256977, -0.795353, -2.166998, 7.887916, -0.874146, -1.445713, -1.227735, 0.083468, 0.092279, 2.884903, 0.987981, 2.128700, -3.195513, -2.590496, 2.064475, 1.149540, 0.470672, -4.524570, 0.196416, 0.997676, -0.129121, -2.536147, 3.854510, -0.803553, -2.343729, -7.330689, 4.167069, 8.285457, -0.139274, 2.846420, -0.494525, -2.873695, 1.580399, -0.436309, -3.225336, 2.636455, 0.927370, 0.184779, -0.206389, -0.908227, -1.383139, -2.696416, 1.232398, 2.682689, 0.068654, -4.679083, 1.535076, -0.134194, -8.911579, -3.718030, 18.079879, -1.818711, -2.470159, -0.744645, -2.155214, -0.210667, 1.095010, -0.705586, -0.622116, 6.140183, -0.542022, -0.463821, 0.482217, 0.102471, 4.585003, -11.398776, 4.156769, -1.061593, -5.982666, 25.047914, 3.913447, 1.311624, -12.124461, -6.554117, -1.844463, 0.367806, 1.282781, 1.421688, -5.328097, -9.227970, 3.344526, 2.896409, -2.628435, 12.654086, -5.334589, -0.871942, -0.505140, 2.250650, -0.842952, -3.629933, 1.916499, 1.090060, -5.739482, -7.346323, 1.152246, 0.238196, -6.549521, -2.117473, 21.136297, 0.862346, -1.595086, -5.126807, 0.272344, 1.939709, -1.014303, -4.008388, -2.984047, -1.072236, 12.629978, 5.353370, -0.624496, -4.098558, -0.711016, 4.399741, 0.139552, -0.447736, -0.154865, -1.329866, -0.060804, 0.666680, -1.008033, -0.909061, 0.881387, -1.517322, -0.758851, -1.964895, 0.798777, -0.975306, 1.165116, -1.889271, 0.544491, 0.018508, 3.106354, 1.392886, -0.286813, -1.218102, -6.004061, -2.482991, -1.542482, -2.128034, -0.728350, 2.960019, -2.574686, 2.840115, 5.400666, 3.181128, -2.861477, 3.580837, -5.337650, 1.863702, -10.084285, 3.255090, 12.027773, 7.262633, 1.436239, 3.766495, -6.806222, 0.022273, -1.136173, -6.339753, -2.487131, -6.709756, -2.234356, 4.867813, -0.015223, -2.715348, 3.953857, 10.203634, 1.615717, 0.142183, -1.484646, -5.214686, 1.490664, -3.049101, 35.581397, -6.230779, 0.582252, -3.497990, -1.528955, -0.303639, 1.048338, -22.304755, -2.129579, 0.956383, -22.160309, 12.769601, -0.712494, -26.887695, 42.246364, -1.593409, -3.936257, 4.736297, 2.040431, 2.945231, -8.152972, -1.990585, -6.273347, 28.430280, -4.481030, 4.235757, -1.813217, -18.034264, 4.561921, 3.961016, -8.854509, 3.103053, -3.692563, -1.396618, -6.200193, 5.455236, -1.928666, 3.694022, 7.981225, 4.076620, 4.505614, -0.862269, 8.130772, -5.988549, -7.927083, -11.258568, -3.731655, 26.340858, -6.412642, 0.468785, -1.224488, -12.639715, 2.181736, 1.403532, -3.910984, 2.651973, -5.778518, 0.331527, 1.765745, -4.957301, 0.227978, -1.877511, 0.068062, -3.166519, 4.868122, 0.429288, 4.732110, -2.594890, 1.943593, -1.396250, 0.727266, -8.758377, 30.212045, -4.615425, -2.749704, 1.558463, -19.773812, -0.578544, -0.057922, -2.096066, 3.654830, 2.748842, -0.373448, -2.920858, -0.101498, 4.976266, 1.478256, 1.257451, 1.005320, 0.651548, -4.439452, 2.188196, 0.813568, -4.421880, 0.845145, 3.658240, 3.671330, -2.216601, -1.435344, 2.541626, -6.372797, -3.076133, -3.691723, 3.949780, 0.528170, 1.602600, -0.699917, 0.855541, -0.156523, 0.115492, -0.732141, -0.246561, 2.012987, -0.811821, -1.588204, -1.199912, 0.381127, 2.111910, -8.361161, -5.568928, -1.808065, -0.585657, 26.617863, -3.428272, 1.916733, 4.179023, 6.921195, -7.044661, -9.613576, -3.211616, 1.197388, 1.899962, -2.444400, 0.576633, 2.284391, -8.172925, 0.990513, -2.740879, 18.031138, 0.818102, -8.933334, -3.830265, 2.612482, 0.488790, 0.539628, -1.094660, -5.450760, -9.991171, 2.222488, -0.610971, -0.059533, 19.753982, -1.986822, -6.606951};
static RBF_CONST rbf_float RBF_BIAS[] = {2.983869, -2.056093, 0.180311, 2.003747, -2.036465, 3.620293, -0.164123, -8.101957, 0.650958, 3.829152, -3.720093, 2.918273};

#if RBF_USE_NORMALIZATION
static RBF_CONST rbf_float NORM_IN_MEAN[] = {0.012524, 0.011168, 0.010055, 0.004432, 0.005949, 0.006603, 0.003790, 0.003309, 0.004367, 0.005556, 0.002002, 0.004671, 0.004016, 0.000928, 0.004592, 0.007021, 0.007635, 0.008629, 0.008452, 0.009150, 0.008997, 0.008806, 0.009148, 0.008658, 0.007862, 0.009718, 0.007429, 0.005916, 0.007701, 0.011219, -0.001548, 0.000633, 0.006765, 0.001602, -0.000169, 0.006551, 0.001026, 0.002136, 0.001794, 0.004300, 0.000263, 0.001040, -0.000124, -0.000095, -0.004503, -0.004034, 0.001382, 0.010836, 0.007101, 0.005748, 0.003493, 0.008363, 0.013820, 0.014134, 0.003639, 0.010138, 0.006532, 0.008933, 0.005145, 0.010096, -0.010780, -0.010349, -0.013454, -0.000409, -0.004171, -0.005631, -0.008223, -0.007632, -0.000969, -0.003737, -0.006464, -0.013815, -0.012234, -0.003141, -0.016746, -0.009154, 0.001259, -0.014103, -0.010193, -0.004995, -0.006756, 0.000544, -0.005190, -0.008718, -0.009975, -0.014948, -0.005028, -0.012734, -0.014397, -0.009037, 0.004989, 0.008941, 0.007144, 0.007440, 0.002708, 0.002041, -0.006991, 0.003740, 0.002342, -0.003869, -0.006632, 0.000336, 0.004626, 0.004286, -0.000564, -0.001144, -0.000722, 0.015728, 0.008321, 0.006889, 0.013381, 0.014494, 0.020972, 0.021008, 0.004303, 0.015498, 0.011255, 0.012804, 0.008647, 0.015148};
static RBF_CONST rbf_float NORM_IN_SCALE[] = {0.997338, 0.995202, 0.993008, 0.994557, 0.997468, 0.999854, 0.998349, 1.000235, 1.001992, 0.999279, 0.999906, 0.999074, 0.999159, 0.998852, 0.997974, 0.994508, 0.993709, 0.993968, 0.997303, 1.000558, 0.998086, 0.994645, 0.994647, 0.998962, 1.003583, 0.999004, 0.995026, 0.995603, 0.997072, 0.998984, 1.007682, 1.015553, 1.015839, 1.013344, 1.012521, 1.013557, 1.012583, 1.013301, 1.010982, 1.004945, 1.013300, 1.009507, 1.004639, 1.003466, 1.005021, 0.998558, 1.012246, 1.014717, 1.019581, 1.019733, 1.014228, 1.011177, 1.009326, 1.011706, 1.004440, 1.012002, 1.011833, 1.015081, 1.014339, 1.011649, 1.002443, 1.007082, 1.013958, 1.002171, 1.007335, 1.013750, 1.007755, 1.008978, 1.010783, 1.011220, 1.006845, 1.011117, 1.006592, 1.005554, 1.005010, 1.002849, 1.008369, 1.016702, 1.005056, 1.006811, 1.010217, 1.013220, 1.016792, 1.022904, 1.014390, 1.013852, 1.014976, 1.022773, 1.019057, 1.014189, 1.003253, 1.015721, 1.024795, 1.011496, 1.004809, 1.002934, 1.004258, 1.016177, 1.013370, 1.007935, 1.011621, 1.005717, 1.007669, 1.012225, 1.011813, 1.009335, 1.016833, 1.016397, 1.024124, 1.025141, 1.021932, 1.016820, 1.016858, 1.019304, 1.015818, 1.015055, 1.024281, 1.020812, 1.015767, 1.016519}; // StdDev
static RBF_CONST rbf_float NORM_OUT_MEAN[] = {0.078289, 0.085565, 0.081781, 0.081781, 0.081490, 0.084692, 0.082654, 0.084692, 0.087602, 0.085565, 0.083818, 0.082072};
static RBF_CONST rbf_float NORM_OUT_SCALE[] = {0.268625, 0.279720, 0.274031, 0.274031, 0.273586, 0.278422, 0.275359, 0.278422, 0.282715, 0.279720, 0.277115, 0.274475}; // StdDev
#endif

// ==========================================
// Implementation
// ==========================================

RbfModelRBF::RbfModelRBF() {
    for(int i=0; i<RBF_HIDDEN_DIM; i++) hidden_activations[i] = 0;
}

void RbfModelRBF::predict(const rbf_float* input, rbf_float* output) {
    // 1. Prepare Input (Normalize if needed)
    rbf_float processed_input[RBF_INPUT_DIM];
    #if RBF_USE_NORMALIZATION
        normalizeInput(input, processed_input);
        const rbf_float* in_ptr = processed_input;
    #else
        const rbf_float* in_ptr = input;
    #endif

    // 2. Hidden Layer (RBF)
    for (int i = 0; i < RBF_HIDDEN_DIM; i++) {
        rbf_float dist_sq = euclideanDistanceSq(in_ptr, i);
        rbf_float width = RBF_READ(&RBF_WIDTHS[i]);
        hidden_activations[i] = computeKernel(dist_sq, width);
    }

    // 3. Output Layer (Linear)
    for (int j = 0; j < RBF_OUTPUT_DIM; j++) {
        #if RBF_FIXED_POINT
            int64_t sum = 0;
        #else
            float sum = 0.0f;
        #endif

        for (int i = 0; i < RBF_HIDDEN_DIM; i++) {
            rbf_float weight = RBF_READ(&RBF_WEIGHTS[i * RBF_OUTPUT_DIM + j]);
            #if RBF_FIXED_POINT
                sum += (int64_t)hidden_activations[i] * weight;
            #else
                sum += hidden_activations[i] * weight;
            #endif
        }

        #if RBF_FIXED_POINT
            sum = sum / RBF_SCALE_FACTOR;
            output[j] = (rbf_float)sum + RBF_READ(&RBF_BIAS[j]);
        #else
            output[j] = sum + RBF_READ(&RBF_BIAS[j]);
        #endif
    }
    
    // 4. Denormalize Output
    #if RBF_USE_NORMALIZATION
        denormalizeOutput(output);
    #endif
}

void RbfModelRBF::normalizeInput(const rbf_float* input, rbf_float* norm_input) {
    for(int i=0; i<RBF_INPUT_DIM; i++) {
        rbf_float mean = RBF_READ(&NORM_IN_MEAN[i]);
        rbf_float scale = RBF_READ(&NORM_IN_SCALE[i]);
        #if RBF_FIXED_POINT
             // (Input - Mean) * SCALE_FACTOR / StdDev
             int64_t diff = (int64_t)input[i] - mean;
             norm_input[i] = (rbf_float)((diff * RBF_SCALE_FACTOR) / scale);
        #else
             norm_input[i] = (input[i] - mean) / scale;
        #endif
    }
}

void RbfModelRBF::denormalizeOutput(rbf_float* output) {
    for(int i=0; i<RBF_OUTPUT_DIM; i++) {
        rbf_float mean = RBF_READ(&NORM_OUT_MEAN[i]);
        rbf_float scale = RBF_READ(&NORM_OUT_SCALE[i]);
        #if RBF_FIXED_POINT
             // (Output * StdDev) / SCALE_FACTOR + Mean
             int64_t val = (int64_t)output[i] * scale;
             output[i] = (rbf_float)(val / RBF_SCALE_FACTOR) + mean;
        #else
             output[i] = (output[i] * scale) + mean;
        #endif
    }
}

rbf_float RbfModelRBF::euclideanDistanceSq(const rbf_float* input, int center_idx) {
    #if RBF_FIXED_POINT
        int64_t sum = 0;
    #else
        float sum = 0.0f;
    #endif
    int base_idx = center_idx * RBF_INPUT_DIM;
    for (int k = 0; k < RBF_INPUT_DIM; k++) {
        rbf_float c = RBF_READ(&RBF_CENTERS[base_idx + k]);
        rbf_float diff = input[k] - c;
        #if RBF_FIXED_POINT
            sum += ((int64_t)diff * diff) / RBF_SCALE_FACTOR;
        #else
            sum += diff * diff;
        #endif
    }
    return (rbf_float)sum;
}

rbf_float RbfModelRBF::computeKernel(rbf_float dist_sq, rbf_float width) {
    #if RBF_FIXED_POINT
        if (width == 0) return 0;
        double d = (double)dist_sq / RBF_SCALE_FACTOR;
        double w = (double)width / RBF_SCALE_FACTOR;
        return (rbf_float)(exp(-d / (2.0 * w * w)) * RBF_SCALE_FACTOR);
    #else
        return exp(-dist_sq / (2.0f * width * width));
    #endif
}

void RbfModelRBF::printInfo() {
    Serial.println(F("Model Loaded: RbfModelRBF"));
    Serial.print(F("Normalization: ")); 
    Serial.println(RBF_USE_NORMALIZATION ? F("YES") : F("NO"));
}
