#include "RbfModelRBF.h"

// ==========================================
// Flash/PROGMEM Macros
// ==========================================
#if defined(ESP32) || defined(ESP8266)
    #define RBF_CONST const
    #define RBF_READ(x) (*(x)) // Fixed: Dereference pointer
#elif defined(__AVR__)
    #include <avr/pgmspace.h>
    #define RBF_CONST const PROGMEM
    #if RBF_FIXED_POINT
        #define RBF_READ(addr) (rbf_float)pgm_read_dword(addr)
    #else
        #define RBF_READ(addr) (rbf_float)pgm_read_float(addr)
    #endif
#else
    #define RBF_CONST const
    #define RBF_READ(x) (*(x)) // Fixed: Dereference pointer
#endif

// ==========================================
// Model Parameters
// ==========================================
static RBF_CONST rbf_float RBF_CENTERS[] = {0.516101, 0.405034, -0.938893, -0.450079, -0.906195, -0.881849, -0.651310, -0.581694, -0.467208, -0.474675, -0.415260, -0.422499, -0.591847, -0.547547, -0.556412, -0.525902, -0.496359, -0.751136, -0.849992, -0.718310, -0.582030, -0.550216, -0.462880, -0.567046, -0.580138, -0.658452, -0.662888, -0.756929, -0.754238, -0.693549, -1.067908, -1.272337, -0.285210, 0.652815, -0.134137, -0.183917, -0.145183, -0.042126, -0.582397, -0.672420, -0.636276, -0.557306, -0.196006, -0.432046, -0.084040, 0.035909, 0.459172, -0.088743, -0.075038, -0.439742, -0.282193, 0.009295, -0.247059, -0.163616, -0.245595, -0.201818, -0.494040, -0.186496, -0.110105, 0.205123, -0.642463, -0.961422, -0.029495, 1.039217, -0.088522, -1.323257, -1.243807, -0.173790, -0.342815, -0.076434, 0.051294, -0.008067, -0.216972, -0.054540, 0.100108, -0.326651, -0.166410, 0.027351, -0.181767, 0.110630, 0.107574, 0.523132, 0.446058, 0.025276, 0.350532, 0.731098, 0.279256, -0.098918, 0.255975, 0.450656, -0.372511, -0.624219, -0.131390, 1.735269, 0.846616, 0.675282, -0.258652, 0.058328, -0.349440, -0.774725, -0.794064, -0.409013, 0.176593, -0.246189, -0.089591, 0.042868, 0.844641, 0.024605, 0.076464, -0.014773, 0.046461, 0.609285, 0.219530, 0.011299, 0.007121, 0.049773, -0.310229, 0.009062, 0.184171, 0.580758, 2.160908, 2.348359, 2.966930, 3.363488, 3.141556, 3.107576, 3.101952, 3.550947, 3.738203, 3.727919, 3.772830, 3.925274, 3.907305, 3.859210, 3.590013, 3.397906, 3.112484, 3.076157, 3.335213, 3.649433, 3.365999, 3.100000, 3.075249, 3.231284, 3.111440, 3.431571, 3.289937, 2.981948, 2.955724, 2.956406, 2.206400, 5.530221, 7.156455, 6.631561, 6.531600, 6.664540, 6.932851, 6.579021, 6.101040, 6.800493, 7.279130, 7.377726, 7.437764, 7.126218, 6.764295, 6.844268, 6.331594, 6.844594, 7.104291, 7.246311, 6.743250, 6.738478, 6.391391, 7.029256, 7.337163, 7.062698, 7.266763, 7.289317, 6.940422, 6.800376, -2.141992, -1.695110, -1.620570, -1.744520, -1.683671, -1.471396, -1.289933, -1.439016, -1.755874, -1.732133, -0.912207, -1.391132, -1.573362, -1.319345, -1.527856, -1.410983, -1.311159, -1.460769, -1.141520, -1.249473, -1.132767, -1.276067, -1.003958, -1.151570, -1.027393, -1.100228, -1.465597, -1.453532, -1.632710, -1.618764, 2.015929, 4.756771, 6.469053, 5.272357, 4.936122, 5.375744, 6.032714, 5.977777, 5.543262, 5.930468, 6.178722, 6.702536, 6.356112, 5.718286, 5.781375, 5.917940, 5.365984, 5.981767, 6.407769, 6.529594, 6.225258, 5.313525, 4.558129, 5.730647, 7.032588, 6.076561, 6.152473, 6.570884, 5.907407, 5.623735, -0.871890, -0.315521, -0.677704, -0.967314, -0.484543, 0.128371, 0.240705, 0.010053, 0.156707, 0.406337, -0.036559, -0.309450, -0.403594, -0.370192, -0.369726, -0.091953, -0.359042, -0.556427, -0.527759, -0.495727, -0.685190, -0.944268, -1.008578, -0.724200, -0.687716, -0.854524, -0.787513, -0.745112, -0.383797, -0.667007, 0.660707, -0.162585, -0.344173, -0.329374, 0.088101, 0.336017, 0.144848, -0.418683, 0.519466, 0.783797, 0.295148, -0.185473, -0.249897, -0.178257, 0.207247, -0.098329, -0.084397, -0.415203, -0.429028, -0.219732, -0.403679, -0.831136, -0.493710, -0.579942, -0.332424, -0.371439, -0.464735, -0.474394, -0.494000, -0.595750, 2.090442, 0.647415, 0.071536, -0.179456, -0.223979, 0.081169, 0.445054, 0.180708, -0.341452, -0.063400, 0.292545, -0.118470, 0.260771, 0.334458, 0.381313, 0.722630, 1.102039, 0.038461, -0.225470, -0.108040, -0.045853, 0.107596, -0.323158, 0.507865, 0.324917, 0.073599, -0.044563, 0.637500, 0.479570, 0.651605, 0.742279, 0.041767, -0.233173, -0.288664, -0.217999, 0.201023, -0.316436, -0.072471, 0.480416, 1.054225, 0.268165, -0.598820, -0.278103, -0.196696, 0.051735, 0.043634, -0.141187, -0.234094, -0.462792, 0.030489, -0.354037, -0.875257, -0.635299, -0.357507, -0.356373, -0.225100, -0.564026, -0.481197, -0.494295, -0.382883, -0.159008, 0.040826, 0.774199, -0.132554, -0.099926, -0.126528, -0.422294, -0.355392, -0.272574, -0.184525, -0.155751, -0.049753, 0.107810, 0.292354, 0.351563, 0.039904, 0.209583, 0.532085, 0.467976, 0.084546, 0.201169, 0.448053, 0.619368, 0.416780, 0.166203, 0.042521, 0.239483, 0.441611, 0.224656, 0.090916, -0.759566, -0.675666, -0.242759, -0.078609, -0.262436, 0.193376, 0.364147, 0.093441, -0.448475, 0.142270, -0.115381, -0.148566, -0.028442, 0.106256, 0.174313, 0.140479, 0.078325, 0.345182, 0.006116, -0.087644, -0.040329, -0.280374, -0.247629, -0.362648, -0.244423, -0.324292, -0.429440, -0.440049, -0.220806, -0.239862, 0.410940, 0.153322, 0.527027, -0.547905, -0.382259, -0.233568, -0.895897, -1.188711, -0.768028, -0.990396, -0.341796, 0.023977, -0.679729, -0.940480, -0.842087, -1.448031, -0.777448, -1.169039, -0.785402, -0.494263, -1.161058, -0.951171, 0.086000, 0.021075, -0.183396, 0.251792, -0.203210, -0.327932, -0.283502, -0.189514, -0.651711, -0.334336, -0.788316, -0.336390, -0.200278, 1.057671, 0.532431, -0.056434, -0.514134, -0.228501, -0.442898, -0.125205, -0.090187, 0.375684, 0.539363, 0.807061, 0.226909, 0.688074, -0.136476, -0.266658, 0.168182, -0.438029, -0.608477, -0.846031, -0.493253, -0.471766, -0.610594, -0.889561, -0.525273, -0.422595, 0.805979, 0.618406, 0.359298, 0.348368, -0.120614, -0.211894, -0.241468, -0.097498, 0.005426, 0.146837, -0.079198, -0.013542, 0.068048, 0.112861, 0.226376, 0.186597, 0.235193, 0.501657, 0.346742, 0.329884, 0.259510, 0.459001, 0.700962, 0.549622, 0.481546, 0.325796, 0.261320, 0.471275, 0.534259, 0.628944, 0.131058, 0.644649, -0.400475, -0.050216, -0.482916, -0.062392, -0.025849, -0.333042, -0.298673, -0.129604, -0.312531, -0.133181, -0.235002, -0.351557, 0.011324, 0.005054, -0.160292, 0.301199, -0.138772, -0.227557, -0.288108, -0.250453, -0.146993, -0.221270, -0.094477, -0.282969, -0.321860, 0.207336, -0.033498, -0.032546, -0.304371, -0.005036, 0.296911, 0.594873, 0.564914, 0.358666, 0.202404, 0.335328, 0.704563, 0.720649, 0.278237, 0.050054, 0.186982, -0.189660, -0.839582, -0.444653, 0.517463, 1.044247, 0.712023, 0.116595, 0.049609, -0.115028, -0.174043, -0.052678, 0.525732, 0.356753, 0.183084, 0.275489, 0.226733, -0.098713, -0.395741, -0.249618, -0.465326, -0.215358, -0.492808, -0.006740, 0.151942, -0.262621, -0.111202, -0.083735, -0.478789, -0.079343, -0.333489, -0.472395, -0.011102, -0.049928, -0.292937, -0.102596, -0.465668, -0.283591, -0.583398, -0.513366, -0.535647, -0.300093, -0.473195, -0.658666, -0.618809, -0.251645, -0.430069, -0.377734, 4.586664, 4.419111, 5.333059, 5.657330, 5.460634, 5.251698, 5.385772, 5.807860, 6.147583, 6.645715, 6.926517, 6.958478, 6.950287, 6.937250, 6.706729, 6.104996, 5.468481, 5.811250, 6.590447, 6.815598, 6.254845, 5.943252, 6.060153, 6.398942, 6.054059, 6.005226, 5.907003, 5.870138, 5.995277, 5.797606, 0.523519, 5.185309, 4.164761, 4.112724, 3.569475, 3.854783, 4.146909, 4.534910, 4.237078, 4.121192, 4.711665, 5.081495, 4.946797, 5.488910, 5.010783, 4.045799, 4.747989, 5.519250, 5.196205, 4.702197, 4.465806, 4.650689, 4.527887, 5.823036, 4.777797, 5.091187, 5.432549, 5.488094, 5.935142, 5.419916, 0.321164, 1.706356, 2.502012, 1.459338, 0.132975, 0.933153, 1.626146, 2.055881, 0.805145, 0.318815, 1.824706, 1.502676, 1.928207, 2.138997, 1.960833, 0.740310, 0.836007, 0.857224, -0.427681, 1.135995, 2.628382, 1.890018, 1.862683, 0.963567, 1.098124, 0.689435, 1.030847, 2.021621, 2.208552, 3.166358, 0.926948, 3.001023, 0.908572, 0.292550, -0.460259, -0.908843, -0.579225, 1.049288, -0.088624, -0.220882, 0.718013, 0.169299, 0.227634, 0.885967, 0.067253, -0.403266, -0.574766, -0.179789, -0.482680, 0.241249, 0.738692, 0.664968, 0.672054, 0.951327, 0.543825, 0.418662, 0.081176, 0.680475, 1.530535, 0.730960, -0.665345, -1.467168, -1.702669, -0.966568, -0.812292, -0.721707, -0.710689, -0.495146, -0.550508, -0.804345, -0.646102, -0.564098, -0.817294, -0.727043, -0.707850, -1.104693, -1.230516, -1.187930, -0.882636, -0.740124, -0.847689, -0.975186, -1.006472, -0.936641, -0.992504, -1.006620, -1.172195, -1.077835, -1.199089, -1.256971, -0.515804, 0.007256, 0.648048, 0.527746, 0.236760, 0.112828, -0.221176, -0.133465, -0.219436, -0.125063, 0.221993, 0.250201, 0.045587, -0.021995, -0.226064, -0.006096, -0.179186, -0.065604, -0.050934, 0.059328, -0.299639, -0.406331, -0.674810, -0.416866, -0.200164, -0.261445, -0.397692, -0.353305, -0.469298, -0.507796, -0.284809, -0.127619, -0.249634, -0.787851, -0.492211, -0.266889, -0.184292, 0.226659, 0.522367, 0.256463, -0.138089, 0.224357, 0.327609, -0.057253, -0.346615, -0.299332, 0.117406, -0.050201, -0.356989, 0.018136, 0.083084, 0.368574, -0.227200, -0.178434, -0.094198, -0.019997, 0.211453, -0.089838, -0.035696, -0.037701, -0.677075, 0.206459, 0.526896, 0.855801, 0.256099, -0.034861, -0.293408, -0.040204, -0.083939, -0.534767, 0.297233, 0.453541, 0.169119, -0.063766, -0.285090, -0.213354, -0.189171, 0.118917, 0.019381, 0.066744, -0.410851, -0.360912, -0.697969, -0.393258, -0.063401, -0.456516, -0.442092, -0.368358, -0.581061, -0.713098, 0.486804, 0.044461, -0.560743, -0.180433, -0.478546, -0.636137, -0.443386, -0.289270, -0.370504, -0.449742, -0.429318, -0.322335, -0.368677, -0.368210, -0.316760, -0.458948, -0.444850, -0.369703, -0.513803, -0.588307, -0.420670, -0.273572, -0.106339, -0.302362, -0.547723, -0.512667, -0.476827, -0.429818, -0.479368, -0.354655, -0.619799, -0.174091, -0.051331, 0.069372, -0.277883, -0.173306, -0.314948, -0.240091, -0.245534, -0.058755, -0.122628, -0.178485, -0.078972, -0.062261, -0.125313, -0.034516, 0.187037, 0.154554, -0.013965, -0.025520, -0.002217, 0.079358, 0.310183, 0.129003, -0.058161, 0.089480, 0.040734, -0.127714, 0.051890, 0.368703, -0.790755, -0.821889, -0.636448, -0.238326, -0.012636, -0.037112, -0.394845, -0.569596, -0.500808, -0.712127, -0.619576, -0.676172, -0.860537, -0.846353, -0.761993, -1.058232, -1.163030, -1.135751, -1.035399, -1.051067, -1.069638, -1.292361, -1.301960, -1.378032, -0.981531, -1.237912, -1.191527, -0.978112, -1.239893, -1.486904, 0.105249, -0.107829, 0.036595, -0.114643, -0.229779, -0.288879, -0.210601, -0.013363, -0.066700, 0.063172, -0.074153, -0.051586, 0.313327, 0.267751, 0.091587, 0.453349, 0.824018, 0.697487, 0.344672, 0.378537, 0.529008, 0.819191, 1.006116, 0.791262, 0.483104, 0.662965, 0.528203, 0.392260, 0.734267, 1.213108, 3.861148, 4.969688, 6.120192, 6.777129, 6.409221, 6.328104, 6.575268, 7.165145, 7.421687, 7.766475, 8.359928, 8.117489, 7.772182, 8.056004, 7.909856, 7.266767, 6.629391, 7.038218, 7.741813, 7.738784, 7.245368, 6.790056, 6.757846, 7.131306, 7.169067, 7.458992, 7.499719, 7.295953, 7.414463, 7.239616, -0.857735, 0.497447, 1.083788, 1.043000, 0.995220, 0.788503, 1.412346, 1.727410, 1.402757, 1.676616, 1.105906, 0.814051, 1.716081, 1.928584, 1.948281, 2.161099, 2.566692, 1.953665, 2.403085, 2.185641, 1.908666, 1.753617, 1.877601, 2.146307, 1.994751, 1.872732, 2.007567, 2.228539, 2.150357, 2.046016, 0.383168, -0.846518, -0.479228, -0.684658, -1.041479, -0.633921, -0.813000, -0.820153, -1.040600, -1.415086, -0.864134, -0.741942, -2.236557, -1.681613, -1.448624, -2.269134, -2.822697, -2.180428, -1.367574, -1.216549, -1.462857, -2.122703, -1.843109, -0.938214, -1.438941, -1.555707, -1.344374, -1.392310, -1.744567, -2.019709, -0.091790, 0.850226, 0.951576, 0.412665, 0.673451, 1.265148, 2.130545, 2.223312, 0.855155, 1.191351, 0.527993, 0.272872, 1.578151, 1.489232, 1.757591, 2.645422, 3.131726, 2.544700, 2.622131, 2.286280, 1.655869, 1.382670, 1.884160, 2.361472, 1.949125, 1.310048, 1.683357, 1.870418, 1.561671, 1.206816, -0.616682, -0.344512, -0.071408, -0.720436, -0.401285, -0.246748, -0.203963, -0.418398, -0.540143, -0.307343, -0.235725, -0.186960, 0.050951, 0.080781, -0.182877, -0.276451, -0.139352, 0.000630, 0.144346, -0.034204, -0.122460, -0.190530, -0.268558, -0.249136, -0.035176, 0.077517, -0.009481, -0.065293, -0.028211, -0.152568, 1.345647, -0.355609, 0.394563, 0.029950, -0.005818, -0.062594, 0.257254, -0.098359, 0.084300, -0.067736, -0.335479, 0.196223, 0.219755, 0.433536, 0.341279, 0.363100, 0.100105, 0.356303, 0.280979, 0.712593, 0.453287, 0.527364, 0.645611, 0.731629, 0.738053, 0.688964, 0.583991, 0.599075, 0.464012, 0.445426, 0.722755, 0.359385, 0.446036, 1.177101, 1.273013, 0.975936, 1.365094, 1.575523, 1.656651, 1.611632, 1.117869, 1.140324, 1.034082, 0.993284, 1.438393, 1.621508, 1.408807, 1.497775, 1.451191, 1.669664, 1.367751, 1.407158, 1.658756, 1.816676, 1.365952, 0.886849, 1.049626, 1.422901, 1.258223, 1.205829, 0.982033, 0.039103, 0.511024, -0.043293, -0.259561, 0.197064, 0.592104, 0.238106, 0.250101, 0.091986, -0.102692, 0.255312, 0.334618, 0.467563, 0.714186, 0.783372, 0.457313, 0.724978, 0.759458, 0.910356, 0.997506, 1.162884, 1.174860, 1.206332, 1.250434, 1.077706, 1.083478, 1.008922, 0.753724, 0.839877, 2.394287, 2.978554, 3.316818, 3.807756, 3.407514, 3.108927, 3.207966, 3.573869, 3.572306, 3.806292, 3.883936, 3.916672, 3.874112, 3.969971, 3.899873, 3.381339, 3.013651, 3.090939, 3.377214, 3.786631, 3.487814, 3.232430, 3.319641, 3.207148, 3.111908, 3.294241, 3.152789, 2.823207, 2.976885, 3.002148, 2.569271, 6.024604, 8.985350, 8.692096, 8.444326, 8.940115, 8.618814, 8.630180, 8.581141, 8.309994, 8.930557, 8.802738, 8.169692, 7.581227, 7.381133, 7.958728, 7.744076, 7.463266, 8.588359, 8.782053, 8.499479, 7.269122, 6.672069, 8.002430, 8.407864, 7.887441, 7.806980, 7.455490, 6.987330, 6.520734, -1.104971, -3.000921, -4.849102, -4.905840, -4.884778, -4.205521, -4.068942, -4.257926, -4.410911, -4.536240, -4.947092, -5.034934, -4.599733, -4.400895, -4.286124, -4.708021, -4.248874, -4.114132, -5.389194, -5.899638, -5.488048, -4.512375, -4.150859, -5.014603, -5.691284, -5.518565, -5.561302, -5.348508, -5.403034, -4.448439, 3.386016, 5.748456, 9.122348, 8.125155, 8.079491, 8.861629, 8.678850, 9.195804, 9.221548, 8.282984, 8.205509, 9.176939, 8.544458, 7.708050, 7.022470, 8.119214, 8.505336, 8.159324, 9.375571, 9.598629, 9.513918, 7.245845, 6.151538, 8.074205, 9.442804, 8.390447, 8.190853, 8.463489, 7.523394, 6.524347, -0.167643, -0.555562, 0.033135, -0.111558, -0.293800, -0.529785, -0.730368, -0.465084, -0.328554, -0.410349, -0.322274, -0.146345, -0.047859, 0.071220, 0.011183, -0.179040, 0.115254, 0.443818, 0.341432, -0.048191, 0.010836, 0.270455, 0.457887, 0.295134, -0.031515, 0.114970, 0.232469, 0.178721, 0.150488, 0.045374, -0.362248, -0.090023, 0.186774, 0.241657, 0.038881, -0.023831, -0.088133, 0.190591, -0.022104, -0.301081, -0.168882, -0.209977, -0.120479, -0.201266, -0.259891, -0.350277, 0.139461, 0.243345, -0.025225, -0.228568, -0.219548, -0.344689, -0.151544, 0.032392, -0.018810, 0.103841, -0.155316, -0.125762, 0.027580, -0.279606, -0.264729, -0.436778, -0.378724, -0.440439, -0.419787, -0.346182, -0.636502, -0.595030, -0.460211, -0.421916, -0.419182, -0.517308, -0.484871, -0.217425, -0.012015, 0.027386, 0.056216, 0.088354, -0.006450, -0.142768, -0.229380, -0.307661, -0.289641, -0.432904, -0.582199, -0.490945, -0.416182, -0.642262, -0.559921, -0.476408, -0.198508, 0.826926, -0.316555, -0.064977, -0.117431, -0.044049, -0.031459, 0.061578, -0.064015, -0.343412, -0.267516, -0.260722, -0.232331, -0.142758, -0.303277, -0.509947, -0.182892, -0.040453, -0.165446, -0.227537, -0.184219, -0.467971, -0.411507, -0.206929, -0.200417, -0.190038, -0.303045, -0.306904, -0.270302, -0.431012, 0.935583, 0.965742, 0.811436, 0.387655, -0.222594, -0.350134, -0.298343, -0.084449, 0.060802, 0.182510, -0.183974, 0.010613, 0.126038, 0.267572, 0.334927, 0.230663, 0.273166, 0.620895, 0.504178, 0.340509, 0.260315, 0.529689, 0.838201, 0.667742, 0.677435, 0.405236, 0.307918, 0.544359, 0.658290, 0.856521, -0.093411, 0.336070, -0.519326, -0.484570, -0.366522, -0.263950, -0.315023, -0.267972, -0.311300, -0.095706, -0.381916, -0.268049, -0.050457, 0.362019, -0.028508, -0.358386, 0.128258, 0.352301, -0.089388, -0.156395, -0.323258, -0.097477, -0.071702, -0.186425, 0.010856, -0.378603, -0.459927, -0.037889, -0.028828, 0.209189, -0.422893, 0.015120, 0.285107, -0.249290, -0.555911, -0.945988, -0.452697, -0.026880, -0.175827, -0.153977, -0.189731, 0.206124, -0.076485, -0.295481, -0.162622, -0.055225, 0.148528, 0.234279, 0.252884, -0.034858, -0.015026, 0.512828, 0.279322, 0.028372, 0.194740, 0.351342, -0.083274, 0.074602, 0.493390, 0.348728, -0.727509, -0.703872, -0.607543, -0.345279, -0.300428, -0.299875, -0.317877, -0.520586, -0.440465, 0.044089, -0.344048, -0.387620, -0.153212, 0.122949, -0.439099, -0.573251, -0.274950, -0.201561, -0.257038, -0.349271, -0.403301, -0.248249, -0.489816, -0.482296, -0.220704, -0.557202, -0.555670, -0.442973, -0.387460, -0.350340, 0.540466, -0.421432, 0.624039, 0.626323, 0.906716, 0.854185, 0.527185, 0.428679, 0.277989, -0.084319, -0.424484, -0.313955, -0.254763, -0.245825, -0.230999, 0.006170, 0.311605, 0.301787, 0.458119, 0.416368, -0.005151, 0.074911, 0.139879, -0.058759, -0.120298, 0.051819, -0.080933, -0.005740, -0.108092, -0.107775, 0.043862, -0.161612, 0.422353, -0.209507, -0.061074, 0.319120, -0.075921, 0.233003, -0.033869, 0.093690, -0.190285, 0.027913, -0.062061, -0.257056, -0.185574, -0.287884, -0.305406, 0.128815, 0.176031, 0.000756, -0.291255, 0.614565, 0.817643, 0.354830, -0.064527, 0.408583, 0.146813, 0.269136, 0.351333, 0.543118, 1.115805, 0.130483, 0.426373, 0.023860, 0.383041, 0.887135, 1.163651, 0.559605, -0.009128, 0.556058, 0.588244, 0.675020, 1.264973, 1.392606, 1.094472, 0.642311, 0.267728, 0.311569, 0.356105, 0.658007, 0.501998, 1.207765, 1.948690, 1.117871, 0.740803, 1.547416, 1.130309, 1.073657, 1.395777, 1.530340, 0.166276, 0.155952, 0.478216, 0.419115, 0.432746, 0.907341, -0.518393, -0.375158, -0.357740, 0.325456, -0.104456, 0.099933, 0.396046, -0.128377, 0.134529, -0.208775, -0.319350, 0.116839, 0.160935, 0.334588, -0.139552, 1.173360, 1.277817, 0.728067, 0.321649, 1.103869, 0.669639, 0.842711, 0.877057, 1.074108, -1.050271, -0.446528, -0.217261, -0.995665, -0.643884, -0.306904, -0.065476, -0.393212, -0.657599, -0.390848, -0.175666, -0.066577, -0.185300, -0.270500, -0.341708, -0.324706, -0.445735, -0.372659, -0.141942, -0.201908, -0.323734, -0.365676, -0.595512, -0.498251, -0.408397, -0.280082, -0.359398, -0.393083, -0.357785, -0.397663, 2.274478, -0.227184, 0.120108, -0.327877, -0.344316, -0.642025, -0.252285, -0.078216, -0.219579, -0.167199, -0.283935, -0.177401, 0.051014, 0.111601, -0.087833, -0.158065, -0.415587, -0.364439, -0.131213, -0.117410, -0.288428, -0.077939, 0.158543, 0.033796, -0.029322, 0.158983, 0.468760, 0.208177, 0.304088, 0.425376, 1.148319, 0.088078, 0.124255, -0.277028, -0.263424, -0.120354, -0.144996, -0.229633, -0.103168, 0.326960, 0.145414, 0.201739, 0.420956, 0.712762, 0.811714, 0.314625, -0.083981, -0.157548, 0.322264, 0.027708, -0.078863, 0.467118, 0.561058, 0.345109, 0.065526, 0.363644, 0.592066, 0.446459, 0.620945, 0.365805, 1.777628, -0.255947, 0.125778, -0.291772, -0.566828, -0.515514, -0.035374, -0.119002, -0.071057, -0.060365, -0.201761, 0.102513, 0.323456, 0.311493, 0.245928, -0.016409, -0.266100, -0.117487, -0.101742, -0.081935, -0.068670, 0.399149, 0.709114, 0.416535, 0.174304, 0.558752, 0.974388, 0.703842, 0.881507, 0.971581, 1.180325, 0.914198, 0.874039, 1.213453, 1.316019, 1.192083, 0.991217, 0.756827, 0.517245, 0.661097, 0.744573, 0.598121, 0.627997, 0.529696, 0.666058, 0.654170, 0.712455, 0.762043, 0.712724, 0.809641, 0.552914, 0.509700, 0.614973, 0.719244, 0.543079, 0.449392, 0.638994, 0.770263, 0.733736, 0.349184, 0.025872, 1.276410, 0.402367, 0.303313, 0.660311, 0.563964, 0.756834, 0.084617, 0.174161, -0.063220, 0.012414, -0.095410, -0.290416, -0.191153, -0.001311, -0.042263, -0.047306, -0.025076, -0.074785, 0.182559, 0.009253, 0.039531, -0.077006, 0.042953, 0.054308, -0.146289, -0.060518, 0.003065, 0.101473, -0.198529, -0.251604, 0.222883, 0.592945, 0.878774, 0.701294, 0.572703, 0.469982, 0.466357, 0.741864, 0.772392, 0.697667, 0.640004, 0.531273, 0.601441, 0.926821, 0.616004, 0.791206, 0.569686, 0.587572, 0.730099, 0.683181, 0.726102, 0.572367, 0.298311, 0.650248, 0.808593, 0.707892, 0.953050, 1.207696, 0.684354, -0.356401, 1.001401, 0.091064, 0.370219, 0.894775, 0.484177, 0.361837, -0.010981, 0.127008, -0.071417, -0.001447, 0.067225, -0.204914, 0.002808, 0.189863, -0.149291, -0.132552, 0.064852, 0.204264, 0.531766, 0.185821, -0.198427, -0.280560, -0.003590, 0.204773, 0.049426, -0.064687, 0.066191, 0.330126, -0.293677, 1.179284, 1.809106, 2.323096, 1.958404, 1.374560, 1.180735, 1.045470, 1.071908, 1.178611, 1.313994, 1.262573, 1.088109, 1.246584, 1.365041, 1.378301, 1.139601, 0.828232, 1.086269, 1.190152, 0.998274, 0.938952, 1.013285, 0.986663, 0.798712, 0.947667, 0.818975, 0.759459, 0.534387, 0.727203, 0.925835, 0.172873, 0.424987, 1.131475, 2.353451, 2.835257, 2.570060, 2.536980, 2.627213, 2.381345, 1.870052, 2.420672, 2.351915, 2.430148, 2.128787, 1.771129, 1.559237, 1.164402, 1.583387, 2.416683, 2.720154, 2.597647, 2.421345, 2.172081, 2.343596, 2.454102, 1.755035, 1.718464, 1.863780, 2.150632, 2.466284, -2.367864, -1.497371, -2.274842, -3.771696, -3.392422, -3.336095, -3.217540, -2.954159, -3.010428, -2.860131, -3.400744, -3.068003, -2.978803, -3.108920, -2.476211, -2.057858, -1.837671, -2.452643, -3.108795, -3.109733, -3.170954, -3.503570, -2.991931, -3.169013, -3.734570, -3.020076, -2.882635, -2.352323, -3.242604, -4.070545, 1.182145, 0.331953, 0.423216, 1.003515, 1.864330, 1.722606, 1.427695, 1.238901, 0.797122, 0.984176, 1.523104, 0.925429, 1.385248, 1.065541, 0.197421, 1.008202, 0.615310, 1.408189, 1.564737, 1.617360, 2.046846, 1.839493, 1.260634, 1.598418, 1.077961, 1.167461, 1.048661, 1.434344, 1.714640, 1.704250, -0.636362, -1.421430, -1.627242, -0.938951, -0.717016, -0.608166, -0.656133, -0.463591, -0.565394, -0.813629, -0.562570, -0.441114, -0.671242, -0.687600, -0.777642, -1.127957, -1.298936, -1.275380, -0.923593, -0.732187, -0.883201, -1.055243, -1.139953, -1.067810, -1.042468, -1.066378, -1.235887, -1.038234, -1.079390, -1.203638, -1.041547, -0.196781, 0.346817, 0.336595, -0.292001, -0.022297, -0.396769, -0.242423, -0.427329, -0.383575, -0.186002, -0.428453, -0.383934, -0.151281, -0.190581, -0.160321, -0.186609, -0.233335, -0.260491, -0.280898, -0.398587, -0.556878, -0.689256, -0.378761, -0.279837, -0.480640, -0.461737, -0.329418, -0.353786, -0.548835, 0.106686, -0.265966, -0.218091, -0.137925, -0.022755, 0.262862, 0.484164, 0.337823, 0.192082, 0.019002, -0.194683, 0.009977, 0.214423, 0.213200, 0.615012, 0.535619, 0.191437, 0.036706, 0.088336, 0.213223, 0.164208, 0.143892, 0.173356, 0.389353, 0.024438, -0.016439, 0.348446, 0.294942, 0.429299, 0.391610, -0.823403, -0.314034, 0.038365, 0.749060, -0.137925, 0.131779, -0.405246, -0.279646, -0.424769, -0.354919, -0.082278, -0.514930, -0.415609, -0.310876, -0.159529, -0.135316, -0.305903, -0.420353, -0.302660, -0.157907, -0.306145, -0.458447, -0.704741, -0.449621, -0.274635, -0.513877, -0.591849, -0.448903, -0.519175, -0.553930, 2.182130, 1.290762, 1.658519, 2.074897, 1.960632, 1.984132, 1.820305, 2.207238, 2.289842, 2.517399, 2.677484, 2.526346, 2.413981, 2.179368, 2.272816, 1.838561, 1.628129, 1.765884, 2.147118, 2.292360, 1.940993, 1.633630, 1.599242, 1.723378, 1.667136, 1.895041, 1.725511, 1.477500, 1.471277, 1.344211, 0.004462, 1.848404, 3.180196, 3.026876, 2.094870, 1.459965, 1.239104, 1.472390, 1.488676, 1.896254, 1.692033, 2.194872, 2.095764, 1.933805, 2.161025, 2.609831, 2.500682, 2.455879, 3.930178, 4.181702, 4.380860, 3.870660, 2.971459, 3.011163, 3.608708, 3.661471, 4.180507, 4.264460, 3.599626, 3.715547, 0.398409, 2.392501, 2.894503, 2.033597, 1.874303, 1.512576, 0.838626, 1.001319, 1.092792, 1.626661, 0.899772, 1.266269, 0.892101, 1.031821, 1.786035, 2.394629, 2.529607, 2.127872, 2.037594, 2.530879, 3.186221, 2.798640, 2.463407, 2.446377, 2.659719, 3.510623, 3.555897, 3.170524, 3.083786, 3.331458, -0.502617, 3.263837, 3.918794, 2.867890, 2.419626, 1.683215, 2.009084, 1.297845, 0.586959, 1.325804, 1.748775, 2.609032, 2.500592, 3.014275, 2.886219, 3.009053, 3.480590, 3.549207, 5.148604, 4.848804, 5.506158, 4.959425, 3.266528, 3.101908, 3.990765, 3.836513, 4.309662, 5.057388, 4.121965, 3.969774, -0.862579, -0.961764, -0.671765, -0.477687, -0.761397, -0.829651, -0.912794, -0.832977, -0.600792, -0.651220, -0.427875, -0.582976, -0.669985, -0.709950, -0.867194, -0.791099, -0.834763, -0.987263, -0.979319, -0.886015, -0.918463, -1.022660, -1.000567, -0.802712, -0.658179, -0.816499, -0.798383, -0.894123, -0.912061, -0.844216, 1.022534, -0.242350, -0.283780, -0.453638, -0.238011, -0.540871, -0.445200, -0.356593, -0.346546, -0.488411, -0.246165, -0.271208, -0.135256, -0.204821, -0.437474, -0.344940, -0.507516, -0.526148, -0.347809, -0.399705, -0.529125, -0.763027, -0.612526, -0.477369, -0.325895, -0.596568, -0.570250, -0.440717, -0.576361, -0.671341, 0.243937, 0.040237, -0.040559, 0.145310, 0.075505, 0.029266, -0.106849, -0.132968, -0.320388, -0.249231, -0.098015, 0.043874, 0.296315, 0.181392, 0.203545, 0.086292, -0.178513, -0.114096, 0.071514, 0.072276, -0.047574, -0.154243, 0.076062, -0.010889, -0.263690, 0.012147, 0.031324, -0.092818, -0.102200, 0.054076, 1.089270, -0.329938, -0.036501, -0.286874, -0.302223, -0.545017, -0.364400, -0.275914, -0.312172, -0.529696, -0.301490, -0.228330, -0.110644, -0.240548, -0.410046, -0.015419, -0.350164, -0.548699, -0.453986, -0.324749, -0.365969, -0.714477, -0.670987, -0.463237, -0.296967, -0.634778, -0.508757, -0.515407, -0.568581, -0.653418, -0.142337, 1.688473, 0.249516, 0.138433, 0.339911, 0.463253, 0.879156, 0.961825, 0.709613, 0.627361, 0.601035, 0.741031, 0.980712, 0.532989, 0.530865, 1.207144, 1.010126, 0.130823, 0.016552, 0.594492, 1.080340, 0.556452, -0.260812, 0.297710, 0.781699, 1.119730, 0.635545, 0.409860, 0.304220, 0.702931, -0.433529, -0.842481, -1.306848, 0.153765, 0.304777, 0.778465, -0.410642, -0.484676, -0.548025, 0.049740, -0.984930, -0.844881, 0.125619, -0.183362, -0.408259, -0.455718, -0.973242, -0.405831, -0.191000, 0.452056, 0.005886, 0.396578, -0.561186, 0.307877, 0.005872, -0.288175, -0.048391, -0.644248, -0.670892, -0.517374, 0.781962, 1.273473, -1.379779, -1.572861, -0.018458, 0.966717, 0.848395, 0.250483, -0.023769, 0.879809, 0.300006, 0.749496, 1.120990, 1.256761, 0.629492, -0.224471, 0.255961, 0.745698, -0.435895, -1.069505, -0.496680, -0.916115, -1.434337, -1.417670, -1.330915, 0.190269, -1.124626, -0.898914, -0.918135, 0.700554, 0.160733, 0.074803, -0.827874, -0.421921, -0.199291, -0.274818, 0.293526, 0.072811, -0.159229, -0.232614, -1.100734, -1.439121, -0.176232, -0.638305, -0.099249, -0.056759, -1.118741, 0.523114, -0.597116, 0.605730, 0.383658, -0.239338, -0.331835, 0.522030, 0.383591, -0.883873, -0.232744, -0.578767, -0.291851, -0.342344, -2.308697, -1.122973, -0.078184, 0.932063, 1.407240, 1.444483, 1.342901, 1.007804, 0.539171, 0.377450, 0.186899, 0.464965, 0.370435, 0.760542, 1.148625, 1.153468, 1.260166, 0.924775, 0.657036, 0.285429, 0.905356, 0.648845, 0.329628, 0.411465, 0.507049, 0.193610, 0.551529, 0.774326, 0.310899, 0.654822, -0.943135, -0.171573, 0.267458, 0.070308, -0.296190, -0.484050, -0.426174, -0.745024, -0.046264, 0.019162, -0.085308, 0.044813, 0.187321, -0.279145, 0.126328, -0.498087, -0.523193, -0.697009, -0.637431, -0.441514, 0.220763, 0.149421, -0.564479, -0.576035, -0.168934, -0.506418, -0.457875, -0.209296, -0.510437, -0.428670, -0.220775, 0.118742, 0.747903, 0.546572, 0.456482, 0.431844, 0.450414, -0.288642, -1.205052, -0.804931, -0.426682, 0.034176, -0.300684, -0.571911, 0.483004, 0.991037, 0.211326, -0.804713, -0.919654, -0.016278, -0.619694, -0.757095, -0.012810, 0.301073, 0.701953, 0.689510, -0.245361, -0.480290, 0.193238, 0.590149, -0.713618, 0.219506, 0.718731, 0.192785, -0.412887, -0.455163, -0.336461, -0.473572, 0.293406, 0.032863, -0.010067, -0.071987, 0.108815, -0.271130, 0.337350, -0.306913, -0.717797, -0.708637, -0.653719, -0.672577, -0.343866, 0.121033, -0.690012, -0.810650, -0.537211, -0.577229, -0.392114, -0.144352, -0.605766, -0.623972, 0.427949, -0.556953, 0.485341, 0.458246, 0.741839, 0.686793, 0.310660, 0.204600, 0.317085, -0.040322, -0.551019, -0.467018, -0.376813, -0.175995, -0.259320, -0.119887, 0.165592, 0.289957, 0.505687, 0.310516, -0.052149, 0.233007, 0.233447, -0.120804, -0.315796, 0.110517, 0.164477, 0.031100, -0.154300, -0.102301, 0.159605, -0.018521, -0.263366, -0.402568, -0.207170, -0.134461, -0.011165, -0.188856, -0.244223, -0.129694, -0.209917, 0.003530, -0.143053, 0.014885, 0.215442, 0.022230, -0.044977, 0.188723, 0.473569, 0.223456, -0.054362, 0.561233, 0.942420, 0.317892, 0.260587, 1.207375, 0.786178, 0.412142, 0.480632, 0.577417, -0.173204, -0.440969, -0.269777, 0.245884, 0.238106, -0.238888, -0.358158, -0.389856, 0.029307, -0.189181, -0.317297, -0.455510, -0.320883, -0.295748, -0.241318, -0.136652, -0.085758, -0.302375, -0.620189, -0.451015, -0.046993, 0.338437, 0.371462, 0.227523, 0.183885, 0.483154, 0.236881, 0.062251, 0.391354, 0.234755, 0.099093, -0.451429, -0.438499, -0.160932, 0.292392, -0.109692, 0.195620, -0.248518, -0.185082, 0.011636, -0.275126, -0.083889, -0.049883, 0.196387, 0.604515, -0.106477, -0.128153, 0.449218, 0.879729, 0.744088, 0.365878, 1.081857, 1.357827, 0.640328, 0.675784, 1.722501, 1.436965, 0.901273, 0.853733, 1.004300, 1.159009, 2.934697, 3.878492, 4.627157, 4.560384, 4.566363, 4.658746, 5.119117, 5.335340, 5.501869, 5.749793, 5.823417, 5.873601, 5.994651, 5.763671, 5.446535, 5.130430, 5.114855, 5.462151, 5.874259, 5.421997, 5.070445, 5.061652, 5.497709, 5.423715, 5.632759, 5.492918, 5.383780, 5.589142, 5.569694, 2.836449, 2.454783, 4.870831, 6.140328, 5.669345, 5.406215, 5.728817, 5.778419, 6.507189, 7.577741, 7.728897, 7.385047, 6.789338, 7.184134, 7.272896, 7.170218, 6.986829, 8.373027, 9.512698, 8.679037, 8.040541, 8.299802, 8.806087, 8.884918, 8.789371, 8.617752, 8.468311, 8.534221, 8.510813, 7.785191, -0.621618, -1.148530, -2.056851, -2.297596, -2.384422, -2.422440, -2.897973, -2.407049, -1.847303, -2.703019, -2.834494, -2.119864, -2.040778, -2.594211, -2.443479, -1.872478, -2.149096, -2.627026, -3.067080, -2.769438, -3.376720, -3.159314, -3.561265, -3.043361, -2.901907, -3.350180, -3.670530, -3.117306, -3.244393, -2.841206, 5.218919, 3.713440, 5.368869, 5.321733, 5.390165, 4.568300, 4.559430, 4.642154, 6.006131, 6.560218, 5.957284, 6.115516, 6.575835, 6.310071, 6.341558, 6.502038, 5.942293, 7.501048, 8.109806, 7.657588, 6.908638, 6.772089, 6.472732, 7.347538, 7.967181, 6.764265, 6.833116, 7.372499, 7.182605, 6.030141, -0.572517, -0.243391, -0.854181, -0.968325, -0.879135, -0.758221, -0.456230, -0.561967, -0.699690, -0.530055, -0.447120, -0.723334, -0.826744, -0.839358, -0.732978, -0.644604, -0.866330, -1.176916, -1.157002, -1.089172, -0.988836, -1.177599, -1.232322, -1.241920, -1.123930, -1.049595, -0.942964, -1.137017, -1.142530, -1.045037, 0.149497, 0.281533, -0.072583, 0.002617, 0.420811, -0.168385, -0.262998, -0.064572, 0.070305, -0.203432, -0.096487, -0.190563, -0.027290, -0.047880, -0.360355, -0.041024, -0.059391, 0.054354, -0.147085, 0.138021, -0.140538, -0.484057, -0.345171, -0.231567, -0.083796, -0.454767, -0.406009, -0.381842, -0.389153, -0.298372, 1.392687, 1.271219, 1.702587, 1.505995, 0.913135, 0.708389, 0.895801, 1.188173, 1.066480, 0.992406, 0.792143, 0.696919, 0.916535, 1.015449, 0.788873, 0.276114, 0.553332, 0.953015, 0.915250, 0.912032, 0.856784, 0.696239, 1.169967, 0.897119, 1.436710, 0.749909, 0.619359, 0.899592, 0.912183, 0.995662, -0.032668, 0.235981, 0.123508, -0.196490, 0.278358, -0.548088, -0.556666, -0.238466, 0.121810, -0.296505, -0.040293, -0.144044, -0.121362, 0.112933, -0.436353, -0.031374, 0.110671, 0.263072, -0.210847, 0.365214, -0.066070, -0.489930, -0.187437, -0.138666, -0.048424, -0.532914, -0.573906, -0.573979, -0.480265, -0.359201, 1.652350, 3.547178, 4.985480, 5.728924, 5.303339, 5.366006, 5.449831, 6.233596, 6.423460, 6.533746, 7.159101, 6.889844, 6.442746, 6.262536, 6.658586, 5.931611, 5.381063, 5.530843, 6.405471, 6.526008, 5.806357, 5.334833, 5.512667, 5.776629, 5.948085, 6.177386, 5.937815, 5.470582, 5.683383, 5.718588, 1.459198, 2.856359, 4.836527, 5.422337, 5.901351, 6.328373, 7.389206, 7.747968, 8.045387, 8.374146, 9.266948, 8.780303, 9.054564, 9.998716, 10.046144, 10.269948, 8.877315, 8.768029, 8.952692, 8.722667, 11.080588, 10.320036, 9.096550, 10.060250, 10.384700, 8.755828, 9.282490, 8.907900, 9.528036, 8.922774, -1.500063, 2.386107, 4.026552, 4.118918, 4.005744, 4.478374, 6.083685, 7.350970, 6.571774, 7.782130, 7.717031, 6.172290, 6.919976, 7.316604, 7.008448, 7.612735, 8.046352, 6.978959, 7.351694, 6.707404, 9.609748, 8.018655, 7.538990, 8.862368, 9.065064, 8.577249, 9.835804, 8.492944, 8.695919, 8.194789, 3.087770, 5.510531, 7.121910, 8.793783, 8.447962, 9.303242, 9.295560, 8.648383, 9.622732, 10.388199, 11.753206, 12.041667, 11.147207, 12.076743, 12.658831, 12.769855, 9.671738, 9.466227, 10.125064, 11.003134, 12.375681, 9.797839, 8.645519, 10.997481, 12.297468, 9.727294, 10.584767, 10.322402, 10.278182, 9.281795, -1.633197, -0.036809, -0.076430, 0.378119, 0.539927, 0.488400, 0.899039, 1.166161, 1.034295, 0.773722, 0.609225, 0.656227, 0.394000, 0.640042, 0.770721, 1.299707, 1.320597, 0.222802, 0.174264, 0.468217, 0.237323, -0.230425, -0.336773, 0.071660, 0.473078, 0.314106, 0.250893, -0.073804, 0.038286, 0.295059, -1.071030, -0.701208, -0.386021, -0.270533, -0.086464, 0.014990, -0.060898, -0.168695, -0.413686, -0.129690, -0.234634, 0.049989, -0.448654, 0.012462, -0.057199, -0.081635, -0.073600, -0.509596, -0.323390, -0.261502, -0.318351, -0.505248, -0.622161, -0.430012, -0.344414, -0.606461, -0.360714, -0.406345, -0.573678, -0.631104, -0.020790, 0.145200, 0.440241, 0.223256, 0.436621, 0.455210, 0.196654, 0.096046, 0.103396, 0.117692, 0.306684, 0.016993, 0.107091, -0.138578, -0.214654, -0.245368, 0.150243, 0.362746, 0.152422, 0.279780, 0.162392, 0.076762, 0.190473, 0.346630, 0.187966, 0.047202, 0.136014, 0.240169, 0.185641, 0.265527, -0.619850, -0.765311, -0.192499, -0.415196, -0.169688, 0.151503, -0.037248, -0.480555, -0.569497, -0.126962, -0.288289, 0.002666, -0.320884, -0.339671, 0.023287, 0.174043, 0.122913, -0.479718, -0.371322, -0.134899, -0.443188, -0.463964, -0.613041, -0.485503, -0.199077, -0.574967, -0.548114, -0.494183, -0.532610, -0.587035, -0.302336, 0.010564, 0.822197, -0.476261, -0.742075, -0.867077, -0.943250, -0.679878, -0.483757, -0.288299, -0.296817, -0.114737, 0.071764, 0.178104, 0.062870, -0.155233, 0.142697, 0.263370, 0.239462, -0.269539, -0.094062, 0.229712, 0.385644, 0.255588, -0.092795, 0.264952, 0.400088, 0.234185, 0.181139, -0.142035, -0.020863, -0.869050, -0.246523, -0.423075, 0.145830, -0.281527, -0.342012, -0.311383, -1.382563, -1.018531, -0.678132, 0.131076, 0.566551, -0.035621, -0.104928, -0.474719, -0.069260, 0.777049, 0.223594, -0.566786, -0.336796, 0.141926, -0.263598, -0.440876, 0.319576, 0.044770, 0.147426, -0.038477, 0.250431, -0.662668, 0.334348, 0.162430, 0.466632, 0.506075, 0.566558, 1.039397, 1.070449, 0.427490, -0.301454, 0.247151, 0.426448, 2.156955, 1.881189, 1.746468, 0.532986, -0.058836, -0.582030, -0.677107, -1.070261, 0.221761, 0.594114, 0.932822, 0.055973, -0.239281, 0.196158, 0.265263, -0.120312, 0.180572, 0.226229, -0.702907, 0.309067, 0.152521, -0.558000, -0.565910, 0.438124, 0.058863, -0.454721, -0.590868, -1.689510, -0.892913, -0.925584, 0.877711, 0.885191, 0.215914, -0.383012, -0.600607, -0.384190, -0.159025, -0.250682, -0.647568, -0.172233, -0.102188, -0.202159, -0.358324, 0.178993, -0.198517, -0.462674, -0.544064, -0.243826, -0.577101, 4.188606, 4.428516, 5.848627, 6.752478, 6.433438, 6.352293, 6.459161, 7.235791, 7.426003, 7.760872, 8.223497, 8.148233, 8.064650, 7.802957, 7.634255, 7.369033, 6.469851, 6.800463, 7.587313, 7.850160, 7.450444, 7.102003, 7.074405, 7.107592, 7.186287, 7.389515, 7.256278, 7.108429, 7.333591, 7.303944, -0.873878, 0.448416, 1.112762, 0.733929, 0.996629, 1.593585, 1.538790, 1.285314, 1.128311, 1.873827, 2.311131, 2.870047, 3.126604, 2.420763, 2.422309, 2.835819, 2.283595, 2.758556, 2.965607, 2.651579, 2.859128, 2.557951, 2.116863, 3.030560, 3.047540, 2.548311, 2.074928, 3.377029, 2.854450, 2.679420, -0.304551, -0.507387, -0.190174, 0.190646, -0.437264, -1.754787, 1.251137, 1.758723, 0.430933, 0.432345, 0.960822, 1.900347, 2.825596, 1.527932, -0.240394, -0.076703, 0.928321, 0.985187, -0.107452, 0.051372, -0.079057, -0.974047, -0.526788, -0.672065, -0.526121, 0.011867, 0.121399, 0.449425, 1.104796, -0.150755, -0.471032, 0.606310, 0.086380, -0.957063, 0.099367, 1.237101, 1.610237, 0.720569, 0.237895, 2.224444, 1.856483, 1.735544, 2.312984, 1.064443, 1.134862, 1.243848, 1.033151, 1.518270, 2.067454, 2.118260, 2.220423, 0.660916, 0.294932, 1.524171, 1.701784, 0.268600, 0.176747, 1.619754, 0.762790, 1.141684, 2.365347, 2.142821, 3.079959, 3.346205, 3.171094, 3.068873, 3.056232, 3.419627, 3.587020, 3.643747, 3.848168, 3.922049, 3.784073, 3.715085, 3.505747, 3.181600, 2.943679, 3.211324, 3.544220, 3.677039, 3.194171, 2.827240, 2.877029, 3.079402, 3.023228, 3.069788, 3.041858, 2.860073, 2.842243, 2.645785, 0.294889, 1.992909, 2.864676, 4.037500, 3.528616, 3.482619, 3.247070, 3.260665, 3.582855, 3.843851, 3.707170, 4.104119, 4.174091, 4.478601, 4.194349, 4.534572, 4.359643, 4.331925, 4.596985, 4.727662, 5.151349, 5.147263, 4.427852, 4.954401, 5.426408, 4.756557, 4.893369, 5.433531, 5.222180, 5.263057, -0.693259, -0.420507, 0.222410, 0.103194, 0.578757, -0.276958, -0.475058, -0.694635, -0.896165, -0.791987, -0.760640, -0.379596, -0.812975, -0.906442, -0.169662, -0.388578, -1.236954, -1.101623, -1.046406, -0.802452, -0.602535, -1.238260, -0.910565, -1.142382, -0.965496, -0.705632, -0.523932, -0.486417, -0.998985, -1.025090, 0.305483, 2.033329, 2.997928, 2.638782, 2.510968, 2.283696, 1.941298, 2.298508, 2.280866, 2.466831, 2.610323, 2.704150, 2.854117, 3.014929, 3.085503, 3.377438, 3.003392, 2.076241, 2.835251, 3.021811, 3.406727, 3.280974, 2.539865, 3.194003, 4.062691, 2.931113, 3.361681, 4.089956, 3.735620, 3.566130, 2.664408, 1.380911, 2.274191, 2.737971, 2.475670, 2.345043, 2.499490, 3.006267, 3.242290, 3.211401, 3.361927, 3.546023, 3.372934, 3.311331, 3.213661, 2.805824, 2.613637, 3.009086, 3.534021, 4.354833, 4.017923, 3.381033, 3.585160, 4.056127, 4.017574, 3.923003, 3.668933, 3.321634, 3.609709, 3.357747, 0.639645, 4.696593, 6.007059, 6.123532, 5.888656, 5.168344, 5.466221, 5.831671, 6.372064, 6.322577, 6.140077, 6.196510, 6.145229, 6.844884, 6.888237, 6.396337, 6.205670, 6.386549, 6.250912, 5.253483, 5.287374, 5.061604, 4.938144, 5.990973, 6.161627, 6.165809, 6.098857, 6.574535, 6.998386, 6.824701, -1.242824, -0.070265, -0.837620, -0.425019, -0.634245, -0.559378, -0.809575, -0.506689, -0.571878, -0.975204, -1.194444, -0.787704, 0.303430, 0.428265, 0.361705, 0.528527, 0.960775, 1.153230, -0.198460, -1.116673, -1.540949, -1.468685, -2.334562, -1.396994, -0.487836, 0.006037, -0.936939, -1.437716, -1.463904, -0.489453, 0.078094, 4.468057, 4.675652, 2.365671, 2.711124, 2.530321, 2.587450, 2.911677, 2.755346, 2.825243, 3.274435, 2.928003, 4.175859, 4.221819, 3.763055, 3.606859, 2.954394, 4.077901, 3.523583, 2.947838, 3.060030, 2.241099, 2.293453, 3.238331, 3.891346, 3.269679, 3.373641, 3.897666, 4.637228, 4.032645, 0.702776, 0.374283, 0.064102, -0.005247, -0.079108, -0.374222, -0.489559, -0.477778, -0.188645, -0.013768, -0.028075, -0.034689, -0.064105, -0.141630, -0.229573, -0.114227, 0.034219, 0.199275, 0.064701, 0.121573, 0.266238, 0.408774, 0.424152, 0.286876, 0.340248, 0.328288, 0.220964, 0.360819, 0.328231, 0.685700, -0.074500, -0.034016, -0.508553, 0.447111, 0.053283, 0.029760, -0.061341, -0.177529, -0.050034, -0.190230, 0.355968, 0.405169, 0.040110, -0.038244, -0.011923, 0.121748, 0.242905, 0.111505, 0.013827, 0.069165, 0.362420, 0.173589, -0.264179, -0.411158, -0.061215, -0.006984, -0.145590, -0.033192, -0.200726, 0.069020, 0.573980, 1.268770, 1.107684, 0.920634, 0.701172, 0.574766, 0.722429, 0.682182, 0.728072, 0.825589, 0.843367, 1.173742, 0.788724, 0.596178, 0.486614, 0.593445, 1.123304, 0.996358, 0.744918, 0.358395, 0.663133, 0.634186, 0.645774, 0.554934, 0.860107, 0.805224, 0.474721, 0.320277, 0.150005, 0.160568, -0.454433, -0.494001, -0.357088, 0.034536, 0.000572, -0.302100, -0.242216, -0.033914, -0.081332, -0.309567, 0.356123, 0.327158, -0.110841, -0.131636, -0.137753, -0.017947, 0.355259, 0.138388, -0.100581, -0.151626, 0.018857, -0.372855, -0.475219, -0.642915, -0.194271, -0.231499, -0.417942, -0.378170, -0.626198, -0.441354, 0.387112, 1.024053, 0.524834, 0.956572, 0.861880, 0.599433, 0.695747, 0.832191, 0.995146, 0.978557, 0.745478, 1.041267, 1.072848, 1.084632, 1.116752, 1.067984, 0.800186, 0.413042, 0.256357, 0.605157, 0.571181, 0.402939, 0.314574, 0.516311, 0.657322, 0.482350, 0.380201, 0.161677, 0.158619, 0.479019, 0.391856, 1.551330, 3.499167, 3.446800, 3.442000, 3.817689, 3.315263, 3.112806, 2.785462, 2.874259, 3.236160, 3.436898, 3.513664, 3.698124, 3.122787, 2.585033, 3.474503, 3.708442, 4.150005, 4.538119, 4.149000, 3.204907, 3.336539, 2.855144, 3.217782, 2.873718, 2.770445, 2.993279, 2.951073, 2.568819, -1.211454, -1.906798, -3.564675, -3.570491, -3.219255, -3.509151, -3.418564, -2.988764, -3.049059, -2.986672, -2.680088, -3.392192, -3.812675, -4.043666, -3.689617, -3.007044, -3.800777, -3.852853, -3.768976, -3.489237, -3.367950, -2.950088, -3.535364, -3.485020, -3.976226, -3.888980, -3.589152, -3.919534, -3.466863, -3.285035, 1.441545, 1.785421, 4.015201, 4.243681, 3.595630, 3.819516, 2.961255, 2.770700, 2.247014, 2.003367, 2.728871, 2.383128, 3.333261, 4.072502, 2.958088, 1.992291, 3.621579, 3.924445, 4.230146, 5.558134, 4.952463, 3.187520, 2.823130, 2.951650, 3.423821, 2.800425, 2.671596, 3.222085, 3.030257, 2.413716, 0.918898, 0.575617, 0.456613, 0.287235, -0.028635, -0.065321, -0.000455, 0.121538, 0.347960, 0.461252, 0.195511, 0.160962, 0.186393, 0.237117, 0.399172, 0.482508, 0.524115, 0.682017, 0.460935, 0.410211, 0.527310, 0.671789, 0.678625, 0.596731, 0.498139, 0.436996, 0.602549, 0.514368, 0.489550, 0.721103, -0.218366, 0.418858, -0.217948, 0.475901, 0.330757, 0.604693, 0.306885, 0.306914, 0.037627, -0.104651, -0.305805, -0.079071, -0.252395, -0.129883, -0.164621, -0.184946, 0.128227, 0.119510, -0.235675, -0.010848, -0.157261, -0.103861, -0.161194, -0.285989, -0.121620, -0.137922, 0.158344, -0.048570, -0.029809, 0.039034, 0.288785, 0.572145, 0.200148, 0.466836, 0.454802, -0.076736, -0.310700, -0.294713, -0.068195, -0.118363, -0.256923, -0.037003, -0.074569, -0.163705, 0.090155, 0.030705, -0.572773, -0.886279, -0.540511, -0.142442, 0.012315, -0.153363, -0.508344, -0.385142, -0.423299, -0.274510, 0.023371, 0.043898, -0.148113, -0.163707, -0.622362, -0.273724, -0.120086, 1.023951, 0.475155, 0.701449, 0.769624, 0.483941, 0.132767, 0.138890, -0.268638, -0.209576, -0.259851, -0.051709, -0.233074, -0.299364, -0.184084, -0.136114, -0.187771, -0.027052, -0.118667, -0.363938, -0.323392, -0.507488, -0.289587, -0.267902, -0.166989, -0.364311, -0.323734, -0.441561, 0.421654, -0.377669, -0.868900, -0.721855, -0.808657, -0.565727, -0.591373, -0.507684, -0.273879, -0.434545, -0.342877, -0.169990, -0.044209, -0.265612, -0.220021, -0.486187, -0.493502, -0.286682, -0.378642, -0.636184, -0.596159, -0.479101, -0.226534, -0.348027, -0.563930, -0.396935, -0.551716, -0.524876, -0.511628, -0.492713, -0.730327, -0.097759, 0.647549, 0.378695, 0.102427, 0.504280, 0.552833, 0.206149, 0.064766, 0.025674, 0.239092, 0.068423, 0.212386, 0.118338, -0.098492, -0.107797, 0.182640, 0.062843, 0.027748, 0.067483, 0.082233, 0.330297, 0.565956, 0.216159, -0.042606, 0.324151, -0.150129, -0.089800, 0.044759, 0.064400, 0.572872, -0.092257, -0.751388, -0.904736, -1.095476, -1.170976, -0.806025, -0.605122, -0.202307, 0.122972, 0.200643, -0.027177, -0.089653, 0.438503, 0.119647, -0.123906, 0.092142, 0.226817, 0.219408, 0.555808, 0.356539, 0.439757, 0.867817, 0.806096, 0.616038, 0.817684, 0.382113, 0.245631, 0.565145, 0.435064, -0.245794, 0.218978, 0.640619, 0.488747, 0.326820, 0.421174, 0.203852, 0.080353, 0.002951, 0.122503, 0.392334, 0.118959, 0.702352, 0.622133, -0.070865, -0.114543, 0.465514, 0.395812, 0.257277, 0.165159, 0.069274, 0.734730, 1.178015, 0.650919, 0.210448, 0.765749, 0.084332, 0.067528, 0.424337, 0.439721, -0.258982, -0.082589, 0.538549, -0.294078, -0.423155, -0.530089, -0.711207, -0.566022, -0.327713, -0.386909, -0.274902, -0.147022, -0.000557, 0.063195, 0.063436, -0.195006, -0.034398, 0.345415, 0.306377, -0.024666, -0.089084, 0.103682, 0.382312, 0.224978, -0.038391, 0.022219, 0.192057, 0.139955, 0.103074, 0.008677, -0.306133, -0.252435, 0.040600, -0.175297, 0.182513, -0.197324, -0.436218, -0.058645, -0.325690, -0.101693, -0.010148, -0.324086, -0.515703, -0.433781, -0.354364, -0.166972, -0.064346, 0.189790, 0.152419, -0.219950, -0.275566, -0.223792, -0.189054, -0.112125, -0.094064, -0.172425, -0.246282, -0.207239, -0.019843, -0.263131, -0.092530, -0.469013, -0.370053, 0.038714, -0.034030, -0.227841, -0.179071, -0.064131, 0.239006, 0.483185, 0.724212, 0.690323, 0.035232, -0.165840, 0.140505, 0.293528, 0.493149, 0.288678, 0.332193, 0.058497, 0.048856, -0.026086, -0.090252, -0.020135, 0.070629, 0.102932, -0.053730, -0.069367, -0.070642, 0.075870, -0.190033, 0.810947, -0.408736, -0.564582, -0.009365, -0.104441, -0.589008, -0.118883, -0.324888, -0.243132, 0.192770, -0.204486, -0.585206, -0.508691, -0.385663, -0.393151, -0.264794, 0.064244, -0.015542, -0.307781, -0.468239, -0.543593, -0.384891, -0.307933, -0.277924, -0.499951, -0.442829, -0.411143, -0.204816, -0.477949, 1.026222, 0.861461, 0.684650, 0.380864, -0.055410, -0.181010, -0.144116, 0.052086, 0.124826, 0.269881, 0.062414, 0.244025, 0.305264, 0.347224, 0.409863, 0.449040, 0.456178, 0.632375, 0.575353, 0.467332, 0.395242, 0.653074, 0.873590, 0.741025, 0.654144, 0.413928, 0.443181, 0.551776, 0.630122, 0.790733, -0.185051, 0.597422, -0.292362, -0.034958, 0.071069, 0.474269, 0.335683, 0.553120, 0.265199, 0.390042, 0.023276, -0.000338, 0.317367, 0.530693, 0.498326, 0.532804, 0.257189, 0.293695, 0.011374, 0.195638, -0.148291, 0.144672, 0.031184, 0.057686, 0.145373, -0.103304, -0.023565, 0.027399, 0.074217, 0.288493, 0.085545, 0.216026, -0.292123, -0.162163, -0.353144, -0.329237, 0.026134, -0.592376, -0.394391, -0.021834, -0.165329, -0.187848, -0.185880, -0.053493, -0.482079, -0.769650, -0.504510, -0.746875, -0.677081, -0.572358, -0.630154, -0.698237, -0.597850, -0.329421, -0.412086, -0.318970, -0.471018, -0.626027, -0.478464, -0.720387, -0.991617, -0.367032, -0.105133, 0.230263, 0.122281, 0.685692, 0.346809, 0.621173, 0.369586, 0.291781, -0.226685, 0.160179, 0.360623, 0.577416, 0.428647, 0.383391, 0.002512, 0.095080, 0.021143, 0.119392, -0.216780, -0.090350, -0.322376, -0.243826, -0.174652, -0.305927, -0.131046, -0.249525, -0.395696, -0.203769, -0.638355, -0.147418, -0.760489, -0.816133, -0.716932, -0.572969, -0.406500, -0.319071, -0.392143, -0.334910, -0.199825, -0.461763, -0.630734, -0.605012, -0.614016, -0.646015, -0.677486, -0.985142, -1.022605, -0.877077, -0.880398, -1.112149, -1.055095, -0.946869, -0.753223, -0.805672, -0.728198, -0.907600, -0.800714, -0.848039, -0.168146, -0.227376, -0.243941, -0.132355, -0.063469, 0.074181, -0.184499, 0.208125, 0.124647, 0.129459, -0.110846, -0.220398, -0.185887, -0.164164, -0.059754, -0.198474, -0.208619, -0.464240, -0.195871, -0.184484, -0.266496, -0.450394, -0.340759, -0.134587, -0.016694, -0.366539, -0.159390, -0.347272, -0.432499, -0.573855, 1.202313, 0.947724, 0.572782, 0.387141, 0.708045, 0.695821, 0.125587, 0.282925, 0.332879, -0.102076, -0.000508, 0.527940, 0.367002, 0.673453, 0.501244, 0.622557, 0.585028, 0.232896, 0.614792, 1.091076, 0.814258, 0.749691, 0.853912, 1.053869, 0.981286, 0.839440, 1.093428, 0.753274, 0.401243, 0.358565, -0.206818, -0.499415, -0.367802, -0.167973, -0.075479, 0.375228, 0.291845, 0.180326, 0.605633, 0.069829, -0.393124, -0.424186, -0.406008, -0.382248, 0.042942, -0.235429, -0.251568, -0.884280, -0.524396, -0.238140, -0.246504, -0.497866, -0.356993, -0.358575, -0.071714, -0.525258, -0.319134, -0.424426, -0.425822, -0.525148, -2.341888, -1.157742, -0.128086, 0.839791, 1.311032, 1.331884, 1.382765, 1.129707, 0.651648, 0.392981, 0.214814, 0.436113, 0.440541, 0.628669, 0.966125, 1.158504, 1.453115, 1.144313, 0.745601, 0.480728, 0.865390, 0.737122, 0.336092, 0.489639, 0.541442, 0.267460, 0.425172, 0.613702, 0.363909, 0.692279, -0.692625, -0.492766, 0.112982, -0.078734, -0.176976, -0.203482, -0.350438, -0.422787, -0.409550, -0.261308, -0.380524, -0.353363, -0.216994, -0.301375, -0.228417, -0.638017, -0.553609, -0.352006, -0.386473, -0.411690, 0.503496, -0.200020, -0.571085, -0.381186, -0.184389, -0.389211, -0.422194, -0.310795, -0.535620, -0.512740, -0.105289, 0.602307, 0.397862, 0.279763, 0.220302, 0.376250, 0.138696, 0.134860, 0.335965, 0.165263, -0.041726, -0.294663, 0.100430, 0.070589, -0.061625, -0.032171, -0.317162, -0.597159, -0.277200, -0.198637, -0.849294, -0.546194, -0.104688, -0.313975, -0.125267, -0.089442, 0.058274, 0.188047, 0.214929, 0.046205, -0.610073, -0.068427, -0.284687, -0.159919, 0.026548, 0.038875, -0.402849, -0.611833, -0.365391, -0.314585, -0.457651, -0.275796, -0.269841, -0.245093, -0.318125, -0.723804, -0.461202, -0.061082, -0.407226, -0.666170, 0.313863, -0.179405, -0.759037, -0.449408, -0.503732, -0.587370, -0.600249, -0.418846, -0.632347, -0.624735, -1.427091, 0.011567, 0.088642, 0.686877, 0.791511, 0.672221, 0.768386, 0.886595, 0.972389, 0.858048, 0.534401, 0.627614, 0.504926, 0.647069, 0.919279, 1.063686, 1.146168, 0.263284, 0.245226, 0.463528, 0.541035, 0.177935, -0.163378, 0.202341, 0.558367, 0.449176, 0.384836, 0.092150, 0.063790, 0.365513, -0.419275, -0.674042, -0.246247, -0.263714, -0.393681, -0.285856, 0.077198, -0.188239, -0.238039, -0.416324, -0.287720, -0.076207, -0.165290, -0.337097, -0.583479, -0.240476, 0.252185, -0.028485, -0.135619, -0.244395, 0.071833, -0.301968, -0.776624, -0.457702, -0.462741, -0.445161, -0.424989, -0.371290, -0.344101, -0.512819, -0.357711, 0.060187, -0.492492, -0.296414, -0.077390, -0.245635, -0.580019, -0.476751, -0.566632, -0.884384, -0.673894, -0.294836, -0.017346, -0.086623, -0.203696, -0.153501, -0.697451, -0.713147, -0.481941, -0.599945, -0.783926, -0.601203, -0.277580, -0.305841, -0.178870, -0.255248, -0.248758, -0.228252, -0.205004, -0.340578, 0.066071, -0.438847, -0.218791, -0.266325, -0.454915, 0.000713, 0.060995, -0.476450, -0.459286, -0.380819, -0.526740, -0.340669, -0.426977, -0.279605, -0.697124, -0.365225, 0.512388, 0.052884, -0.107681, -0.179091, -0.011233, -0.178372, -0.619489, -0.426019, -0.476485, -0.508033, -0.507754, -0.622570, -0.460058, -0.569313, 0.132822, 0.072937, 0.517120, -0.082170, -0.260398, -0.404038, -0.589462, -0.466852, -0.239615, -0.243335, -0.142168, -0.062908, -0.007461, 0.056263, 0.001533, -0.169408, -0.046439, 0.273894, 0.271485, 0.072898, 0.126562, 0.236330, 0.420318, 0.266863, 0.112016, 0.189950, 0.241083, 0.178845, 0.169089, 0.220452, -0.199035, -0.484259, 0.086085, -0.089911, -0.028596, 0.071169, -0.265161, -0.111600, -0.362702, -0.058166, 0.035086, 0.061236, 0.036065, 0.023577, -0.147058, -0.211165, -0.238334, -0.089135, 0.031285, -0.111111, -0.010142, -0.314692, -0.276633, -0.241420, -0.244851, -0.256562, -0.212690, -0.194919, -0.051765, -0.273668, 0.093619, -0.322945, -0.151550, -0.323185, -0.082751, 0.659510, 0.404128, 0.287500, -0.082556, -0.048845, -0.506020, -0.703953, -0.668352, -0.994029, -0.647417, -0.646237, -0.130611, 0.031224, 0.021404, -0.076542, -0.133557, -0.209171, 0.012320, 0.070790, -0.005571, 0.178155, 0.008996, -0.201008, -0.290617, -0.057218, -0.276857, 0.053349, -0.051277, -0.365753, -0.173041, 0.210613, -0.182811, -0.213947, -0.524749, -0.329846, -0.125940, -0.019202, 0.200918, 0.138343, 0.086046, -0.015632, -0.398303, -0.227075, -0.242143, -0.352292, -0.030344, -0.676797, -0.487054, -0.268554, -0.252897, -0.419980, -0.371820, -0.366424, -0.397739, -0.484283, -0.109090, -0.129024, 0.616879, -0.240326, -0.313226, -0.427978, -0.754858, -0.626246, -0.470723, -0.414494, -0.273991, -0.161497, 0.031561, 0.175957, 0.156889, -0.153800, 0.044368, 0.401461, 0.371132, 0.055571, -0.019755, 0.193986, 0.532125, 0.340427, -0.004353, 0.126795, 0.273484, 0.181701, 0.107459, -0.012738, -0.420752, -0.841429, -0.276094, -0.201555, -0.158865, -0.180504, -0.219871, 0.130268, 0.085952, -0.102777, -0.358281, -0.322938, -0.488973, -0.589933, -0.241757, -0.167932, -0.158280, -0.242139, -0.034825, -0.406342, -0.255202, -0.489477, -0.308548, -0.201641, -0.142230, -0.231057, -0.293537, -0.281538, -0.095959, -0.330827, -0.349550, 0.195566, 0.429741, 0.277869, 0.314035, 0.782238, 1.222368, 0.626963, 0.333133, 0.363919, 0.404588, 0.224388, 0.293112, 0.404226, 0.354318, 0.114791, 0.091942, 0.126785, -0.147570, -0.055616, -0.258222, -0.169455, 0.091795, 0.327751, 0.270093, -0.044460, 0.210327, 0.233461, 0.082953, 0.155865, 0.114196, 0.278926, -0.440261, -0.404127, -0.531258, -0.153501, 0.069101, 0.110255, 0.019660, -0.020737, -0.413450, -0.480976, -0.745706, -0.618260, -0.168116, -0.164589, -0.173400, -0.359026, -0.279228, -0.587695, -0.345954, -0.514043, -0.384234, -0.253410, -0.414928, -0.496560, -0.403567, -0.444274, -0.420213, -0.437195, 0.338846, -0.410559, 0.611243, 0.560429, 0.931505, 0.934961, 0.569497, 0.732927, 0.701782, 0.281872, -0.025116, 0.013964, -0.020999, 0.209309, 0.233083, 0.545452, 0.798035, 0.386979, 0.364238, 0.334918, 0.319784, 0.357774, 0.150605, 0.646834, 0.849739, 0.198882, 0.100740, 0.066883, -0.074488, 0.143823, -0.358215, -0.012961, 0.468368, -0.381665, -0.036805, -0.123849, -0.375931, 0.428874, 0.130258, 0.103346, -0.305028, 0.197617, 0.342223, 0.854033, 0.982210, 0.557240, 0.854522, 0.754685, 0.074413, 0.749294, 0.223775, 0.628841, 0.416370, 1.053085, 0.892298, 0.199671, -0.199468, 0.135980, -0.061785, 0.297277, -0.428124, 0.159384, 0.184363, -0.241882, -0.088662, -0.227184, -0.505460, -0.863907, -1.071221, -0.893785, -1.293645, -0.757973, -0.796970, -1.116543, -1.737920, -1.429156, -0.821033, -0.764539, -0.742704, -1.190053, -1.034892, -1.282004, -1.337636, -1.147997, -1.255705, -1.030741, -0.911573, -0.914932, -0.721093, -1.186411, -0.124819, 0.257846, 0.264081, -0.449140, -0.151983, 0.040338, -0.449421, 0.137673, 0.160723, 0.169821, -0.245664, 0.172173, 0.308253, 0.814735, 1.450306, 1.014296, 1.271180, 1.368721, 0.399450, 1.029284, 0.747562, 1.464624, 1.022651, 1.654022, 1.587363, 0.600768, -0.008612, 0.237799, 0.020246, 0.668662, 0.541490, -0.008635, -0.477921, -0.226059, -0.453081, -0.670269, -0.502720, -0.312159, -0.380602, -0.439823, -0.463410, -0.390075, -0.331379, -0.340688, -0.300991, -0.478661, -0.500027, -0.441846, -0.503924, -0.574257, -0.456618, -0.231362, -0.041585, -0.250367, -0.586029, -0.582921, -0.494093, -0.402222, -0.477841, -0.308373, -0.847153, 0.018676, -0.140313, 0.116924, -0.190764, -0.190392, -0.327509, -0.211965, -0.122637, -0.191037, -0.183620, -0.086394, -0.307557, -0.182704, -0.134495, 0.109409, 0.322394, -0.015556, -0.111615, -0.214851, 0.004886, 0.040767, 0.570468, 0.278205, -0.126612, -0.039652, -0.047859, 0.027489, 0.146329, 0.570635, 0.650775, 0.442318, -0.193515, -0.340937, -0.692438, -0.267467, -0.073917, 0.197854, 0.224573, 0.090277, 0.156507, 0.166252, 0.210785, 0.307668, 0.295576, 0.378623, 0.463285, 0.476797, 0.133434, 0.438589, 0.657397, 0.526814, 0.554209, 0.501773, 0.385071, 0.344957, 0.476357, 0.480499, 0.547868, 0.791916, -0.150609, -0.298723, -0.216864, -0.012190, 0.185605, -0.152379, -0.410389, 0.000259, -0.086095, 0.167928, -0.020205, 0.014496, -0.207689, -0.128077, -0.066644, 0.355918, 0.886651, 0.358409, 0.029567, -0.130417, 0.498780, 0.619643, 1.188206, 0.762745, 0.084433, 0.184909, 0.151975, 0.366704, 0.620926, 1.327777, 1.763115, 1.554388, 2.060801, 2.646087, 2.031332, 2.155653, 2.207031, 2.404928, 2.477823, 2.699484, 2.962832, 2.943170, 2.787304, 2.694971, 2.493963, 2.386865, 2.258842, 2.432126, 2.885199, 2.882197, 2.183414, 1.981091, 2.116572, 2.429225, 2.628077, 2.663158, 2.029175, 1.812354, 1.692202, 1.802013, 2.891921, 7.185389, 9.498261, 10.177688, 10.833721, 10.734095, 10.849492, 10.889028, 11.634687, 11.834881, 9.769278, 9.326378, 10.748430, 11.039107, 11.771504, 11.164368, 11.411944, 10.733838, 10.573971, 11.382502, 11.298091, 10.064754, 10.086751, 11.170147, 10.762632, 9.829151, 10.311579, 10.894805, 9.868690, 9.189087, -0.863666, -3.807676, -5.400042, -5.093090, -4.303706, -4.592308, -4.741914, -6.088056, -6.481115, -6.092166, -5.422561, -5.781548, -6.138991, -7.772601, -7.665044, -7.192428, -7.419830, -5.645465, -5.376562, -6.266908, -5.881071, -6.076075, -6.587203, -7.189497, -6.928466, -6.136586, -7.429506, -7.547112, -8.727883, -8.000203, 2.468981, 4.455432, 6.358686, 4.492334, 5.637950, 6.819142, 5.896942, 5.614898, 6.348356, 7.749906, 5.889536, 5.466966, 7.485247, 8.539250, 8.057117, 8.623453, 8.283811, 7.382369, 7.171910, 9.673097, 9.475513, 5.767555, 5.290718, 7.238869, 7.891654, 6.452588, 6.585951, 7.603937, 5.688953, 5.371523, -0.008774, 1.741371, 0.213946, 0.727796, 0.851784, 0.718658, 1.011837, 1.019006, 1.258886, 1.101569, 0.799018, 0.915944, 1.177265, 0.873089, 0.782232, 1.216131, 0.988137, 0.363927, 0.378570, 0.640944, 1.075413, 0.685806, 0.053484, 1.033816, 1.504269, 1.188296, 0.563924, 0.271201, 0.622877, 0.921359, -1.234769, -1.307152, -0.342089, -0.046016, -0.314641, -0.598925, -0.409545, -0.330466, 0.051816, 0.057899, -0.449814, -0.416602, 0.126086, -0.150198, -0.468353, -0.352367, -0.464311, -0.391897, -0.185805, -0.460883, -0.251218, -0.638291, -0.740627, 0.077415, -0.103613, -0.308542, -0.639525, -0.575616, -0.602908, -0.549273, 0.445233, 0.472493, 0.171478, 0.364616, 0.640249, 0.155890, 0.187340, 0.357738, 0.821420, 0.880167, 0.231753, -0.093467, 0.202701, 0.294145, 0.251008, 0.182615, 0.108374, 0.186648, 0.349429, 0.097916, 0.134432, 0.338473, 0.284868, 0.770014, 0.734507, 0.396153, 0.323474, 0.414354, 0.129290, -0.036237, -0.280811, -0.779537, -0.391897, 0.308996, 0.161403, -0.505020, -0.205016, -0.176091, 0.197302, 0.171888, -0.502137, -0.475306, 0.208698, -0.285270, -0.631873, -0.473789, -0.467949, -0.418172, -0.189694, -0.460763, -0.454163, -0.647517, -0.779255, -0.228160, -0.127307, -0.155164, -0.539490, -0.539899, -0.617819, -0.549329, -0.844080, 0.089453, -0.397060, -0.808362, -0.541743, -0.238208, -0.117876, -0.229989, -0.293024, -0.271825, -0.284974, -0.620363, -0.568398, -0.421286, -0.429095, -0.385500, -0.573266, -0.867475, -0.840104, -0.593426, -0.704520, -1.044311, -1.030676, -0.875013, -0.713981, -0.791247, -0.756353, -0.749155, -0.518656, -0.713211, -0.210047, -0.541098, -0.770474, -0.652206, -0.493593, -0.496601, -0.405649, -0.162103, 0.172532, 0.151982, -0.279064, -0.636903, -0.451346, -0.383481, -0.521987, -0.315187, -0.426768, -0.613781, -0.483534, -0.186432, -0.335863, -0.586891, -0.588799, -0.494463, -0.458823, -0.558331, -0.551734, -0.571595, -0.613816, -0.697009, -0.253575, 0.161150, 0.338334, 0.076679, -0.289177, -0.158721, -0.070318, -0.224174, -0.039113, 0.216674, 0.308378, -0.190928, -0.210914, -0.202088, -0.074552, -0.033847, 0.183039, 0.104640, 0.167538, -0.061965, 0.090387, 0.136894, -0.008506, -0.182257, -0.098199, 0.095772, 0.220734, 0.043673, 0.008218, -0.147354, -0.440487, -0.541740, -0.599190, -0.650414, -0.591490, -0.585790, -0.447553, -0.001715, 0.409880, 0.186640, -0.191984, -0.793504, -0.256086, -0.230095, -0.463483, -0.466586, -0.230657, -0.383769, -0.595788, -0.287632, -0.189837, -0.491859, -0.519102, -0.455626, -0.477150, -0.504160, -0.610778, -0.524565, -0.668294, -0.722877, 0.184988, -0.603093, 0.358078, 0.158436, 0.465386, 0.508630, 0.226167, 0.088436, 0.127227, -0.234839, -0.516366, -0.455596, -0.452457, -0.295094, -0.297220, -0.171526, 0.063965, 0.156956, 0.374049, 0.124410, -0.162569, 0.154510, 0.067110, -0.245811, -0.433157, 0.011202, 0.049813, -0.124928, -0.296851, -0.240575, 0.723667, -0.233419, -0.332810, -0.532998, -0.077508, -0.370506, -0.183816, -0.152467, -0.114779, -0.181522, -0.453339, -0.201998, -0.239026, 0.183857, 0.298338, 0.189821, 0.094710, 0.263094, 0.179587, 0.180192, 0.080262, 0.900803, 1.107461, 0.622351, 0.028852, 1.006126, 0.989371, 0.455421, 0.590477, 0.500181, 0.958388, -0.346825, -0.130403, 0.320266, -0.702204, -0.309000, 0.353936, 0.579386, 0.391365, 0.398309, 0.350726, 0.208676, 0.369953, 0.735248, 0.999871, 0.736156, 0.615256, 1.002972, 1.448756, 1.326757, 1.253180, 2.030119, 2.102585, 1.347616, 1.069819, 1.844527, 1.788509, 1.634233, 1.842278, 1.692183, 0.516329, -0.402575, -0.279254, -0.261890, 0.190142, -0.366121, -0.049696, 0.128861, 0.012710, -0.077993, -0.317343, -0.242459, 0.105170, 0.552778, 0.902772, 0.514268, 0.227550, 0.739581, 0.799329, 0.641876, 0.764504, 1.904621, 1.859193, 1.152062, 0.585818, 1.872371, 1.870019, 1.321987, 1.569215, 1.308824, 1.172690, 1.080299, 1.380243, 1.196547, 1.075152, 0.964410, 0.817212, 1.285687, 1.613454, 1.735659, 1.700742, 1.510749, 1.190767, 1.504855, 1.349075, 1.205414, 1.279037, 1.345225, 1.203747, 1.272915, 1.110794, 1.040653, 0.921225, 0.571976, 0.538854, 0.560864, 0.878296, 0.729608, 0.441716, 1.029131, 0.430600, -0.533364, -0.019233, 0.116370, 2.410641, 2.986253, 1.072539, 1.488536, 0.955114, 0.933130, 1.793251, 2.003665, 2.029565, 2.225195, 1.753017, 0.940367, 1.601713, 0.739413, 0.576756, 1.108993, 0.804628, 0.221128, -0.394756, -0.463782, 0.118825, -0.483947, -0.134317, -0.028762, -0.011707, 0.283093, 0.289242, 0.793246, 1.612082, 1.895390, 2.559242, 3.047307, 1.341970, 0.539931, 0.744057, 1.489220, 0.658754, 1.252186, 1.944389, 0.728575, 0.322345, 1.282493, 1.512909, 0.150740, -0.023331, 0.866529, 0.322051, 0.356878, 0.606323, 0.408166, -0.300976, -0.195584, 0.226881, -0.015245, -0.718565, 0.058073, 0.231297, -0.986779, 0.406410, 0.029318, 0.298838, 0.844875, 0.549421, 0.909815, 0.636737, -0.348116, 0.190214, 0.904530, 0.904529, 1.501985, 1.385411, -0.072613, 0.974776, 0.745482, 1.190460, 0.581460, 0.643077, -0.221979, -0.350044, -0.522238, -0.076372, -0.678840, -0.492319, 0.069688, 0.073274, -0.236678, -0.274508, 0.159342, -0.699496, -0.685270, -0.746406, -0.681779, -0.644762, -0.540260, -0.499688, -0.466807, -0.483852, -0.653621, -0.703040, -0.712514, -0.807354, -0.704671, -0.813184, -1.082241, -1.047820, -0.981210, -0.977207, -1.064816, -1.061221, -0.985995, -0.842922, -0.953544, -0.873261, -0.929366, -0.961115, -0.928622, -0.462703, -0.477654, -0.660029, -0.251047, -0.243146, -0.007999, -0.011861, -0.022422, 0.094366, -0.246923, -0.260402, -0.266243, -0.150578, -0.172108, -0.231948, -0.255461, -0.207850, -0.306155, -0.173192, -0.030271, -0.264797, -0.495589, -0.561021, -0.320128, -0.178604, -0.373237, -0.397752, -0.359118, -0.414566, -0.443580, -0.543055, -0.119267, -0.203086, -0.471838, -0.533676, -0.741881, -0.982324, -0.783766, -0.417762, -0.218549, -0.487343, -0.656774, -0.635894, -0.678166, -0.456780, -0.291791, -0.320565, -0.381285, -0.555728, -0.827181, -0.559678, -0.621066, -0.572339, -0.727922, -0.692338, -0.658022, -0.585357, -0.612235, -0.518945, -0.617319, -0.382631, -0.656001, -0.492592, -0.181716, -0.128645, 0.059603, 0.236361, 0.216052, 0.028224, -0.303068, -0.313321, -0.233149, -0.241978, -0.200067, -0.294726, -0.185272, -0.129598, -0.390467, -0.090887, 0.057627, -0.206927, -0.390086, -0.489534, -0.235997, -0.142427, -0.391476, -0.447725, -0.376222, -0.435761, -0.314892, -0.460876, -0.171118, -0.258500, -0.645736, -0.511452, -0.406735, -0.258400, -0.476668, -0.636622, -0.487841, -0.341359, -0.052290, -0.104825, -0.125814, -0.141286, -0.261720, -0.272523, -0.212934, -0.145086, -0.209757, -0.290231, -0.291765, -0.345968, -0.390514, -0.368131, -0.085192, -0.268562, -0.439301, -0.360259, -0.395717, 1.516384, -0.561777, -0.116731, -0.328926, -0.312767, 0.178033, 0.253945, 0.338758, 0.124530, -0.082141, 0.084851, 0.211434, -0.347683, 0.010241, 0.321452, 0.103181, 0.120844, -0.359414, -0.325596, -0.370206, -0.176671, -0.011309, 0.321214, 0.308421, 0.128345, 0.077178, 0.123644, 0.093408, -0.062531, -0.016540, -1.827768, -0.159293, -0.194204, 0.258675, 0.982760, 0.448443, -0.354182, -0.679916, -0.769197, -0.280181, -0.212592, -0.295101, -0.444234, -0.474581, -0.437018, -0.408789, -0.135051, -0.569626, -0.944481, -0.851760, 0.008539, -0.525071, -0.977538, -1.257225, -1.235222, -0.732186, -1.192261, -0.694494, -0.242165, -0.645552, 2.642688, -0.431867, 0.024988, -0.571946, -0.107083, 0.336671, 0.978922, 1.060517, 0.481283, 0.046532, 0.437348, 0.774433, -0.024759, 0.439607, 0.811018, 0.070358, 0.445998, 0.082305, 0.167985, -0.140537, 0.217439, 0.771222, 1.146758, 0.956974, 0.546901, 0.538571, 0.829333, 0.740664, 0.245296, 0.554504, -0.789642, 0.074061, -0.045856, -0.580239, -0.257116, -0.140343, -0.037154, -0.252155, -0.448826, -0.277812, -0.199136, -0.155435, -0.003101, 0.116646, 0.094028, 0.000852, -0.260442, -0.239619, -0.090788, -0.025295, -0.194510, -0.412222, -0.352733, -0.335808, -0.190538, 0.007432, -0.057196, -0.144740, -0.030186, -0.223816, 1.753816, -0.953137, 0.355883, -0.087961, -0.361487, -0.252077, 0.135125, -0.183760, -0.658502, -0.234260, -0.057988, 0.022479, 0.234878, -0.101589, 0.272078, 0.122023, -0.198540, -0.087890, -0.030358, -0.140445, -0.320592, -0.317491, 0.121674, 0.456378, -0.086140, 0.002591, 0.605373, 0.333100, 0.161295, 0.414077, 0.545546, 0.264969, 0.500012, 0.303635, 0.176325, 0.623025, 0.659731, 0.619914, 0.504526, 0.293489, 0.653823, 1.032167, 0.901877, 0.333666, 0.106846, 0.540405, 0.499733, 0.409218, 0.601969, 0.193947, 0.513646, 0.809451, 0.720980, 0.601905, 0.752116, 0.739479, 0.923644, 0.629666, 0.634767, 0.840947, 0.968755, -0.016386, 0.606292, 0.274619, -0.218623, -0.282074, 0.475369, 0.033246, -0.505314, -0.015983, 0.375672, 0.468423, 0.698770, 0.288881, 0.519605, 0.483443, 0.038175, 0.110867, 0.121584, -0.198106, -0.059179, -0.047449, 0.644021, 0.988472, 0.193023, 0.285158, 1.294358, 0.691996, 0.508593, 1.011425, 0.423406, 0.205930, -0.989512, -0.550402, -0.815247, -0.645389, -0.472374, -0.363375, -0.364801, -0.415107, -0.334810, -0.293769, -0.232420, -0.384416, -0.262942, -0.392677, -0.526024, -0.646068, -0.692903, -0.761896, -0.618986, -0.674961, -0.541153, -0.550014, -0.612755, -0.592890, -0.625091, -0.637870, -0.636982, -0.656087, -0.597203, -1.067905, -0.085269, 0.438228, -0.169905, 0.256343, 0.143669, -0.054708, 0.010459, -0.032280, -0.190459, -0.070531, -0.123171, -0.132362, -0.227870, -0.158191, -0.009409, -0.032233, -0.087856, -0.032229, -0.105746, -0.145672, 0.075272, -0.175715, -0.081280, 0.086043, 0.021945, -0.147219, -0.201330, -0.027579, 0.440975, 0.138427, 0.725855, 0.828508, 0.837639, 1.407277, 1.311658, 0.424500, 0.575902, 0.877531, 0.817902, 0.752134, 0.581957, 0.791955, 0.972660, 0.953036, 0.777969, 0.725463, 0.666811, 0.893089, 1.120291, 1.292566, 1.409763, 1.132920, 0.987335, 1.095444, 1.207472, 0.772688, 0.957639, 1.577967, -0.215291, -0.840935, 0.111031, 0.617075, 0.363879, 0.684694, 0.099348, -0.388214, -0.233375, -0.315240, -0.453219, -0.059700, -0.221601, -0.185025, -0.007589, 0.218485, 0.290742, 0.142490, 0.168666, 0.271910, 0.270846, 0.267196, 0.607463, 0.082634, 0.057021, 0.254406, 0.326794, 0.032644, -0.122416, 0.383402, -1.328566, -0.484705, 0.245698, 1.205531, 1.864850, 1.749362, 1.464771, 1.456275, 1.460543, 1.188801, 0.992673, 1.270001, 1.194995, 1.467045, 1.757571, 2.173572, 2.357356, 1.468591, 0.865165, 1.052193, 1.745609, 1.319430, 0.893644, 1.099781, 0.907919, 1.010095, 1.438654, 1.962574, 1.604221, 0.944503, -0.248175, -0.488484, -0.034995, -0.205202, -0.029758, -0.282040, -0.032221, -0.221039, -0.246996, -0.161108, -0.494368, -0.270988, -0.310330, -0.364560, -0.434719, -0.594828, -0.113261, -0.437281, -0.542059, -0.416419, 0.725983, -0.005094, -0.618819, -0.249764, -0.342897, -0.491360, -0.427170, -0.300000, -0.469014, -0.490822, 0.033067, -0.586051, -0.492922, -0.039098, -0.203640, 0.026344, 0.136476, -0.181626, 0.075500, 0.260923, 0.207324, 0.176010, 0.100328, -0.038923, -0.076278, 0.026674, 0.074771, -0.131803, 0.004743, -0.119920, 0.062592, 0.003755, -0.128733, 0.084431, -0.327176, -0.039872, -0.184072, -0.321216, -0.194962, -0.125870, 0.278284, -0.091986, -0.062064, -0.267782, 0.263456, -0.255156, 0.017016, -0.388597, -0.283291, -0.044582, -0.399363, -0.123045, -0.207852, -0.174667, -0.520092, -0.670395, -0.104074, -0.533642, -0.525252, -0.431004, 0.288969, -0.323864, -0.672426, -0.448272, -0.397771, -0.513785, -0.488019, -0.396088, -0.516957, -0.491972, -0.824453, -1.036881, -1.045235, -0.804238, -0.754348, -0.685900, -0.743200, -0.626101, -0.687171, -0.784105, -0.592670, -0.662046, -0.749330, -0.721588, -0.737469, -0.835873, -1.030383, -0.998062, -0.767509, -0.664940, -0.785976, -0.948592, -0.959425, -0.824284, -0.679329, -0.823805, -0.965421, -0.999821, -0.964152, -1.015729, 0.487572, 0.110862, 0.098343, -0.143658, -0.246037, -0.050974, 0.073305, 0.234694, 0.065747, -0.104377, -0.221684, -0.171402, -0.333370, -0.317255, -0.256624, -0.308748, -0.430483, -0.297045, -0.233904, -0.211101, -0.295263, -0.679505, -0.597297, -0.356858, -0.252880, -0.466963, -0.446506, -0.500915, -0.475376, -0.596938, -0.652748, -0.190291, 0.162900, 0.278808, 0.146852, 0.041522, 0.273171, 0.562606, 0.421070, 0.578357, 0.787085, 0.119452, -0.039628, -0.412934, -0.333133, 0.118112, 0.305122, 0.072828, -0.101496, -0.177776, -0.186580, -0.084283, -0.235572, -0.149542, -0.242743, -0.107165, -0.026293, -0.258010, -0.216249, -0.089273, 0.509335, 0.137914, -0.152239, 0.101937, -0.046758, 0.074829, 0.341421, 0.234761, -0.102974, -0.341801, -0.007368, -0.180210, -0.439494, -0.400009, -0.171409, -0.420826, -0.570143, -0.329973, -0.163900, -0.164325, -0.315898, -0.727313, -0.595187, -0.427172, -0.251920, -0.565958, -0.497922, -0.501454, -0.496015, -0.557937, 0.417865, -0.533633, 0.513347, 0.361084, 0.609741, 0.710192, 0.323709, 0.175078, 0.163733, -0.091665, -0.448079, -0.433422, -0.431907, -0.355415, -0.320622, 0.126990, 0.393312, 0.348725, 0.387466, 0.295513, 0.206772, 0.145539, 0.202260, 0.207988, 0.152250, 0.115440, 0.034823, 0.094614, 0.028020, 0.043985, -0.258855, -0.195494, 0.461683, -0.621481, -0.126109, -0.233733, -0.417964, -0.297136, -0.199922, -0.203189, -0.560887, -0.328483, 0.058392, -0.283300, 0.221441, 0.202916, 0.114910, 0.023990, -0.346218, -0.112074, -0.159354, 0.142904, 0.466129, 0.246132, -0.211741, -0.348590, -0.439828, -0.113377, 0.067865, 0.242704, -0.298625, 0.108984, 0.180766, -0.192267, -0.005361, -0.114463, -0.410318, -0.154089, 0.138554, -0.000552, -0.417591, -0.785440, -0.816448, -0.413733, -0.333806, -0.311908, -0.518057, -0.403050, -0.554744, -0.706161, -0.407651, -0.643505, -1.102982, -0.991118, -0.576690, -0.447674, -0.394619, -0.318389, -0.850443, -0.834646, -0.128398, 0.443224, 0.407299, -0.702989, -0.033922, -0.198979, -0.494700, -0.116272, -0.158004, -0.021063, -0.574858, -0.175613, 0.076667, -0.030063, 0.498836, 0.586590, 0.352684, 0.396901, -0.129672, 0.132500, 0.192096, 0.592094, 0.970814, 0.782070, -0.004589, -0.283443, -0.118390, 0.167663, 0.515037, 0.931795, 1.597873, 0.757349, 1.137252, 1.532386, 1.856211, 2.156733, 2.129591, 1.990927, 1.802869, 1.724427, 1.874545, 1.651514, 1.653702, 1.465446, 1.310975, 1.240542, 1.446741, 1.831747, 1.897926, 1.514445, 1.350075, 1.307079, 1.539789, 1.588663, 1.254921, 1.300379, 1.218126, 1.374849, 1.526835, 1.026316, 0.097061, 1.152987, 0.824925, 0.880580, 0.814845, 1.417182, 1.706812, 1.852950, 1.774752, 1.241529, 1.232512, 1.205743, 1.179731, 1.000284, 1.000906, 1.231936, 1.406696, 1.592793, 1.277805, 1.240194, 1.123322, 1.052343, 1.081836, 1.422863, 1.402668, 1.327960, 1.275632, 1.236774, 1.461059, 1.099732, 0.109129, -0.392548, -0.395439, 0.228438, 0.335941, 0.526018, -0.698020, -0.488963, 0.662571, 0.290288, -0.289784, -0.123538, -0.396070, -0.736004, -0.070906, -0.028562, -0.051247, 0.057954, 0.674640, 0.422716, 0.060109, -0.125974, 1.521358, 0.822805, 0.189686, -0.306544, -0.167076, 0.170524, 0.473867, 0.464441, -0.643009, 1.171026, 1.083830, 1.770464, 1.122251, 1.911639, 2.134008, 2.235537, 2.032491, 1.591681, 1.361197, 1.346569, 1.085824, 1.395802, 1.824037, 1.792635, 1.504944, 1.436761, 2.297079, 1.832029, 1.519908, 0.923445, 0.828698, 1.239083, 1.862010, 1.345400, 1.507116, 1.476367, 1.480664, 0.988925, -0.617481, -0.131832, -0.229818, -0.325865, -0.227898, -0.342196, -0.407419, -0.401987, -0.538007, -0.407776, -0.309471, -0.031277, -0.019942, -0.030752, 0.010828, -0.113548, -0.301067, -0.273951, -0.158954, -0.216077, -0.264511, -0.400491, -0.365502, -0.241718, -0.049245, -0.062604, -0.072960, -0.036587, -0.002011, -0.225882, 0.907770, -0.441754, 0.022900, -0.246327, 0.511169, 0.100011, -0.019127, 0.107923, -0.269851, 0.010377, -0.312599, -0.118533, 0.094709, -0.155586, -0.178530, -0.251136, -0.072025, 0.210375, 0.486703, 0.548334, 0.489355, 0.027646, 0.446763, 0.815810, 0.570199, 0.470416, 0.611476, 0.382402, 0.412263, 0.224138, -0.283614, -0.236118, -0.787027, -1.319012, -1.464960, -1.145590, -1.177425, -1.507936, -0.568644, -0.513745, -0.612692, -1.030407, -0.901266, -0.558418, -1.500975, -0.818503, -0.631383, -0.749243, -1.373847, -1.841044, -1.661074, -1.269155, -1.595050, -1.978685, -1.421216, -1.783617, -1.961480, -1.722972, -1.987500, -1.887944, 0.977549, 0.388610, 0.228830, 0.037277, 0.353078, 0.560429, 0.269361, 0.418952, -0.395726, 0.141281, -0.492320, -0.167677, 0.130672, -0.097068, -0.549803, -0.280156, -0.035114, 0.085984, 0.195173, 0.116961, 0.080917, -0.305810, 0.266152, 0.222141, 0.236832, -0.053084, 0.568116, 0.213940, 0.385565, 0.302870, 0.409370, -0.415219, 0.497469, 0.446214, 0.690910, 0.682390, 0.330925, 0.199616, 0.252291, 0.107940, -0.208549, -0.144984, -0.259516, -0.336110, -0.235497, 0.131029, 0.358874, 0.280997, 0.317703, 0.318545, 0.148343, 0.180033, 0.140365, 0.139993, 0.138501, 0.070265, 0.046022, 0.121828, 0.019170, 0.034694, -0.129417, -0.280125, 0.395261, -0.266014, -0.266604, -0.233462, -0.048541, -0.103403, -0.171688, -0.225412, -0.201004, -0.184343, -0.130824, -0.108480, 0.161386, 0.098383, 0.109755, 0.310751, -0.034674, -0.286836, -0.185655, 0.542723, 0.747086, 0.404653, 0.002844, -0.063771, -0.123816, 0.154600, 0.264451, 0.349258, 0.197010, 0.361111, 0.492016, 0.022509, -0.244142, -0.051575, 0.389766, 0.608023, 0.716965, 0.573589, 0.388149, 0.645590, 0.418378, 0.416369, 0.378716, 0.465243, 0.733713, 0.496619, 0.216671, 0.184523, 0.225421, 0.558310, 0.555995, 0.514576, 0.605676, 0.603559, 0.354100, 0.469693, 0.508322, 0.740284, -0.051655, 0.217443, 0.552238, -0.085280, -0.293085, -0.239222, -0.021721, 0.203205, 0.090222, 0.001266, -0.053158, -0.263667, -0.006095, 0.024504, 0.251120, 0.288733, 0.463680, 0.602354, 0.054754, -0.083744, 0.147490, 0.917920, 1.089747, 0.814452, 0.284240, 0.228788, 0.142552, 0.447264, 0.606001, 0.795434, 0.515834, -0.469170, -0.849711, -0.528037, -0.729212, -0.744188, -0.667434, -0.462104, -0.463563, -0.629694, -0.368581, -0.065872, -0.071698, -0.119078, -0.152193, -0.540443, -0.419118, -0.144284, -0.157930, -0.511129, -0.488251, -0.390123, -0.122074, -0.307942, -0.541168, -0.298026, -0.430029, -0.471212, -0.468862, -0.502440, -0.723763, 0.234971, 0.471749, 0.233605, -0.347740, -0.150386, -0.261354, -0.119377, 0.305781, 0.103303, -0.117614, -0.171768, 0.094632, -0.237959, -0.317127, -0.288701, -0.159687, 0.074618, 0.076168, -0.055039, -0.127870, -0.036767, 0.316376, 0.267403, 0.079834, 0.451995, 0.126942, 0.030309, 0.052296, -0.041675, -0.519944, -1.020556, -0.290598, 0.365772, 0.018107, -0.075789, -0.051706, -0.415599, -0.753987, -0.421289, -0.391646, 0.089883, 0.126957, -0.275894, -0.452814, -0.515538, -0.716434, -0.835083, -0.885058, -0.503860, -0.564036, -0.517172, -0.824091, -0.690809, -0.640421, -0.834478, -0.588677, -0.465335, -0.366343, -0.459564, -0.175029, 1.028705, 0.776165, 0.211376, -0.438342, -0.255764, -0.345551, 0.087277, 0.597369, 0.393434, -0.118703, -0.025192, 0.272267, -0.002852, -0.216806, -0.189961, 0.254858, 0.524535, 0.366902, 0.182959, 0.142971, 0.535766, 1.085625, 0.831352, 0.342081, 0.825794, 0.727744, 0.512298, 0.698789, 0.425631, 0.557197, 0.010890, -0.281839, -0.016071, -0.130898, -0.581225, -0.701340, -0.716115, -0.338437, -0.202306, -0.034749, 0.077473, -0.100541, -0.305750, -0.474926, -0.384889, -0.184310, -0.042183, -0.129584, 0.062082, 0.272616, 0.393172, 0.379687, 0.321141, 0.399666, 0.292312, 0.099369, 0.240681, 0.306160, 0.473358, -0.261950, -0.566457, -0.576300, 0.406732, 0.038088, -0.176553, -0.063711, -0.274861, -0.055804, -0.231500, -0.000773, 0.010845, -0.048987, -0.059375, -0.084562, -0.106486, -0.115315, -0.191438, -0.167748, -0.229052, 0.020688, 0.071964, -0.207483, -0.357338, -0.370465, -0.114089, -0.248411, -0.163114, -0.272374, -0.122364, -0.301938, -0.172002, -0.135833, 0.185890, 0.082736, -0.534692, -0.509583, -0.405185, -0.401066, -0.442362, -0.382823, -0.421161, -0.529261, -0.790111, -0.688878, -0.528646, -0.510122, -0.758279, -0.713571, -0.563111, -0.459113, -0.422506, -0.386034, -0.176174, -0.394494, -0.552570, -0.596862, -0.406165, -0.312610, -0.492383, -0.670502, -0.869741, -0.423914, -0.063892, -0.238448, -0.229557, 0.009308, -0.243011, -0.153657, -0.175261, -0.048165, -0.129132, -0.325135, -0.094656, -0.131768, -0.285406, -0.059286, -0.223593, -0.220896, -0.340011, -0.387122, -0.629578, -0.438762, -0.521061, -0.378452, -0.248650, -0.441495, -0.364022, -0.541823, -0.461748, -1.234267, -0.219984, -0.248783, -0.564158, -0.195585, 0.266231, 0.095233, -0.237706, -0.404856, -0.614458, -0.651712, -0.609875, -0.518066, -0.424222, -0.393708, -0.138335, -0.312771, -0.651076, -0.683636, -0.559396, -0.769795, -1.228084, -1.142306, -0.728063, -0.596035, -0.777155, -0.849144, -0.663429, -0.141314, -0.562602, -0.068233, -0.385812, -0.491811, -0.438438, -0.288834, -0.079766, -0.326808, -0.380274, -0.202066, -0.489701, -0.405257, -0.147819, -0.404304, -0.364576, -0.319277, -0.360561, -0.299846, -0.522733, -0.381061, -0.139711, -0.258593, -0.537020, -0.662473, -0.325317, -0.362460, -0.549710, -0.531145, -0.519338, -0.406581, -0.672614, -0.238821, 0.489386, 0.565304, 0.426692, 0.236147, 0.308053, 0.455376, 0.447523, 0.206729, 0.391338, 0.496752, 0.532669, 0.409054, 0.405275, 0.488474, 0.281920, 0.257919, 0.359819, 0.432714, 0.547223, 0.694669, 0.408476, 0.465562, 0.501206, 0.431738, 0.358703, 0.564008, 0.691935, 0.396517, 0.385498, -0.673410, 0.073189, -0.441333, -0.420333, -0.300179, -0.178213, -0.273973, -0.307443, -0.082248, -0.378502, -0.272403, -0.099943, -0.440553, -0.297728, -0.295582, -0.321816, -0.307525, -0.606294, -0.334481, -0.039870, -0.181072, -0.472692, -0.707320, -0.428947, -0.459943, -0.560162, -0.511428, -0.462699, -0.521111, -0.680784, 3.238131, 2.971579, 4.109304, 4.480681, 4.336516, 4.316938, 4.288281, 4.497700, 4.624657, 5.115555, 5.459961, 5.322891, 5.470369, 5.683909, 5.215807, 4.657773, 4.473005, 4.725679, 5.139509, 5.839684, 5.398739, 5.073285, 5.223952, 5.533031, 5.395199, 5.606696, 5.601847, 5.231445, 5.219193, 5.168733, 0.513027, 5.981927, 7.026340, 6.422418, 5.584161, 6.903978, 6.829758, 6.278781, 6.439250, 5.795155, 6.818801, 6.894254, 6.609169, 7.434088, 7.507270, 7.111312, 8.116482, 7.673792, 7.231594, 6.953253, 6.252416, 6.550994, 6.662107, 7.097823, 6.687293, 6.887391, 7.217917, 7.227446, 7.309361, 7.409154, 0.730714, -0.222259, -0.727002, -0.716826, 0.117524, -0.269976, -0.117232, -0.444180, 0.206650, 0.722544, 1.214116, 0.127433, -0.397101, 0.333277, 0.174591, -0.162994, 1.379536, 0.994950, 1.221192, 1.497497, 1.289743, 0.948208, 0.838836, 0.780857, 1.617793, 1.911312, 1.184959, 1.097041, 1.401582, 1.751117, -0.723357, 1.446292, 0.905417, -0.665952, -0.202003, 1.188733, 1.230681, 1.563285, 2.766555, 0.082671, 0.580467, 2.152857, 1.544193, 0.466036, 1.676849, -0.361313, 0.723508, 0.907762, 0.553744, 0.994089, -0.160055, 0.104217, 0.602690, 1.201476, 1.982265, 1.903045, 2.454348, 1.940562, 1.606591, 1.351745, 0.483871, -0.413723, 0.602929, 0.430414, 0.775850, 0.873720, 0.459129, 0.315403, 0.282741, -0.077704, -0.508749, -0.433321, -0.447265, -0.440150, -0.246213, 0.183354, 0.444970, 0.363792, 0.311445, 0.269418, 0.187722, 0.113045, 0.013524, 0.032900, 0.092450, 0.000007, -0.007125, 0.143848, 0.043148, 0.037696, -0.388969, -0.172962, 0.709519, -0.444373, -0.011560, 0.136765, -0.210092, -0.128149, -0.320552, -0.129358, -0.194676, -0.039766, -0.192339, -0.126635, 0.177701, 0.244563, -0.072441, -0.137164, -0.087563, -0.281530, -0.035186, 0.703855, 0.614921, 0.380395, 0.118993, -0.206935, -0.076121, 0.000004, 0.043105, 0.317334, 0.461843, -1.095366, -1.116398, -0.530047, -0.636033, -0.662504, -0.472240, -0.104362, -0.012904, 0.031516, -0.155236, -0.221444, -0.515205, 0.058254, 0.781543, 0.872521, 0.512104, 0.448475, 0.241413, 0.138741, 0.380654, 0.979640, 1.038289, 0.912767, 0.570059, 0.564129, 0.859664, 0.986062, 0.718690, 0.940617, -0.169758, 0.576940, 0.835616, -0.318915, 0.406206, 0.258086, -0.234047, -0.149796, -0.149559, -0.027250, -0.123024, -0.057436, -0.316879, -0.061767, 0.606104, 0.629658, 0.081380, 0.237493, 0.237069, -0.150587, 0.517860, 1.556444, 1.228527, 1.106770, 0.495443, 0.178070, 0.293340, 0.364990, 0.372249, 0.859370, 0.074307, -0.235464, 0.942962, 1.098408, 1.303445, 0.933246, 0.727832, 0.804491, 0.834039, 0.462235, 0.008085, 0.273350, 0.814786, 0.876008, 0.689238, 1.037492, 1.093353, 1.022314, 1.416041, 1.420042, 0.896072, 0.603918, 0.521064, 0.619910, 0.527920, 0.840717, 0.462896, 0.685368, 0.665753, 0.422661, 0.861013, 2.333285, 3.474675, 3.106652, 2.719913, 2.727396, 3.058447, 3.196523, 3.697694, 4.582682, 3.614878, 4.215777, 4.897794, 3.835135, 3.559675, 2.963790, 2.763584, 2.536551, 2.527378, 3.202331, 2.752445, 2.838180, 2.652515, 2.897418, 2.876232, 3.149863, 2.532349, 3.378412, 2.960544, 3.019022, -1.787710, -3.943476, -5.566169, -3.620078, -3.578444, -2.694993, -3.108484, -4.981661, -5.508992, -5.655998, -4.334789, -4.745340, -4.262712, -4.225805, -5.410653, -5.096924, -4.645939, -4.333342, -4.588173, -4.827684, -5.272441, -4.049520, -4.036887, -4.935071, -5.489041, -5.126970, -5.359874, -6.252090, -4.759222, -5.546570, 0.396619, 3.657534, 5.149666, 3.253644, 3.828011, 2.789942, 2.668165, 4.347224, 4.387821, 5.394174, 4.032485, 5.252506, 4.360878, 2.833394, 3.990200, 3.523740, 2.506624, 2.665602, 3.393857, 3.330673, 3.549391, 2.563211, 1.740172, 3.693375, 4.910666, 4.723608, 3.743037, 4.330537, 4.301515, 4.376161, 0.049423, -0.260677, 0.016719, 0.687704, 0.607045, 0.212050, 0.105291, 0.314105, 0.491323, 0.490090, 0.608289, 0.640667, 0.547526, 0.559368, 0.396599, 0.370771, 0.438399, 0.456609, 0.479701, 0.521434, 0.688003, 0.625125, 0.524843, 0.509815, 0.649304, 0.664445, 0.518670, 0.559435, 0.577811, 0.742721, 2.258605, 1.196468, 0.322823, 0.070596, 0.086338, 0.005003, -0.017466, -0.187920, -0.158378, -0.047682, 0.006813, 0.160684, 0.101252, -0.202456, -0.123921, 0.105435, -0.195771, -0.511558, -0.438937, -0.166931, 0.133076, -0.013573, -0.290408, -0.544797, -0.219688, -0.051266, -0.324167, -0.412394, -0.465755, -0.210085, 2.298862, 1.859451, 0.798354, 0.215307, 0.193813, 0.418804, 0.166678, 0.500297, 0.533189, 0.356509, 1.016871, 1.371025, 0.211797, -0.244625, 0.542594, 0.509546, 0.336276, 0.072274, 0.423321, -0.001988, -0.563658, 0.158375, 0.233147, 0.168490, 0.380646, 0.084082, 0.451669, 0.431560, 0.549378, 0.077059, 2.265732, 1.055944, 0.308847, -0.371960, 0.107792, 0.332655, -0.087488, -0.070655, -0.135718, 0.034612, 0.084972, 0.070181, -0.225415, -0.576102, -0.010279, 0.176585, -0.212366, -0.673214, -0.620791, -0.355992, 0.113642, -0.288744, -0.463702, -0.784733, -0.232846, -0.249010, -0.535470, -0.740674, -0.511959, -0.301702, 0.911405, 1.014919, 0.798926, 0.313266, 0.458965, 0.568293, 0.574279, 0.221012, 0.104458, 0.369893, 0.346274, -0.293689, -0.344386, -0.402356, -0.003686, 0.225608, 0.154489, 0.014459, -0.143898, 0.037963, 0.061074, 0.327814, 0.158361, -0.088272, -0.088818, 0.009881, 0.391911, 0.399901, 0.249914, 0.094505, -0.288918, 1.181576, -0.408167, -0.610519, 0.076236, -0.110197, 0.018619, -0.099986, 0.439817, 0.109089, -0.068749, -0.003035, 0.207636, 0.209626, 0.116453, -0.347333, -0.174617, 0.140473, 0.027751, 0.106255, -0.027779, 0.459998, 0.221184, -0.234330, -0.210060, -0.248241, 0.408390, -0.018617, -0.094115, -0.068075, -0.192242, -0.262782, -0.506062, -0.512202, -0.434180, -0.327031, -0.163808, -0.012249, 0.314098, 0.046652, -0.267344, -0.430214, -0.635391, -0.185985, -0.597643, -0.365991, -0.272083, -0.061235, 0.359864, 0.221567, 0.315086, 0.504476, 0.298609, -0.138973, -0.047838, 0.173451, -0.137449, -0.249281, -0.281229, 0.078213, -0.800070, 0.261492, -0.297859, -0.784285, -0.264459, -0.461620, -0.343721, -0.178136, 0.551131, 0.158587, -0.100422, -0.083166, 0.532599, 0.413454, -0.097702, -0.158368, -0.241318, 0.012665, 0.151749, 0.084604, -0.290175, -0.333437, -0.372635, -0.529038, -0.246080, -0.352388, -0.198522, -0.258363, -0.245520, -0.408432, 1.091640, 1.195696, 1.042800, 0.804294, 1.199682, 1.625932, 1.875816, 2.129914, 1.358585, 0.703417, 0.689827, 0.310299, 0.237451, 0.412412, 0.749301, 1.153869, 1.024039, 0.899633, 0.586201, 0.553930, 0.494826, 0.680205, 0.591478, 0.435504, 0.353901, 0.120461, 0.583746, 1.009711, 0.908708, 0.167663, -0.420464, 1.276022, -0.259927, -0.510642, 0.215850, 0.783718, 1.220641, 3.182552, 2.395132, 0.300687, -0.028700, 0.147805, -0.128081, 0.035384, 0.468200, 0.991008, 0.560969, 0.339135, 0.020237, -0.023505, -0.131614, 0.102178, 0.030627, -0.157604, -0.187073, -0.369037, -0.086261, -0.031149, 0.129545, -0.306454, 0.391681, -0.300992, -0.162565, -0.241684, -0.329398, -0.562804, -0.166057, 0.083636, -0.282637, 0.001302, 0.359557, 0.423249, 0.301467, 0.320127, 0.743358, 0.608718, 0.223449, 0.135316, 0.152594, 0.339299, 0.413517, -0.092641, 0.022938, 0.185795, -0.011680, -0.128224, 0.098353, 0.108999, 0.456801, 0.353988, -0.579309, 0.241878, -0.541912, -0.510616, 0.213724, 0.991714, 1.222170, 2.890447, 2.424751, -0.029092, 0.032577, 0.770400, -0.049460, 0.049561, 0.103317, 0.345287, 0.434749, 0.195724, -0.320109, -0.041378, -0.002429, -0.196510, -0.178396, 0.032021, -0.182082, -0.488258, -0.217232, -0.090821, -0.161373, -0.396602, -1.130637, -0.389388, -0.165931, -1.041857, -0.744053, -0.528873, -0.231131, -0.646940, -0.992265, -0.630627, -0.387334, -0.195842, -0.252446, -0.296416, -0.309019, -0.422537, -0.546463, -0.350204, -0.240108, -0.360414, -0.423144, -0.370275, -0.648395, -0.515647, -0.450225, -0.228759, -0.305793, -0.449675, -0.463311, -0.415909, 2.338294, -0.471902, -0.092631, -0.102970, -0.040866, -0.304793, 0.059134, -0.131999, -0.185443, 0.543355, 0.246300, -0.001040, 0.014578, 0.027710, -0.061202, -0.066761, -0.275216, -0.212629, 0.136323, 0.042407, -0.085638, 0.137884, 0.292944, 0.122529, 0.103964, 0.328185, 0.412100, 0.280473, 0.237946, 0.397555, -0.405025, -0.791900, -0.932377, -1.207903, -0.823074, -0.636561, -0.556884, -0.442662, -0.396401, -0.721957, -0.748014, -0.899956, -0.716762, -0.742976, -0.612699, -0.908889, -0.777071, -0.883471, -1.246521, -1.047574, -1.126495, -1.265136, -1.314690, -1.264711, -1.011473, -1.249009, -1.375660, -1.218491, -1.138740, -1.098992, 1.779653, -0.580999, -0.153701, 0.431034, -0.036861, -0.120433, 0.368945, 0.086026, -0.049762, 0.784034, 0.451156, 0.599408, 0.470142, 0.129275, 0.385407, 0.107933, -0.264717, 0.127455, 0.467188, 0.297069, 0.084684, 0.639571, 0.899495, 0.482005, 0.439497, 0.902643, 1.093976, 0.954996, 0.960070, 1.095307, 0.562709, 0.238562, 0.158256, 0.217675, -0.074359, -0.164170, -0.175429, -0.131327, -0.065830, -0.024733, -0.100786, -0.009921, 0.086645, 0.110210, 0.183267, 0.131996, 0.184067, 0.361615, 0.317294, 0.096738, 0.125104, 0.480067, 0.624619, 0.461771, 0.282942, 0.304957, 0.350206, 0.377732, 0.353797, 0.499381, 0.214056, 0.212914, -0.452594, -0.094999, -0.678371, -0.263262, -0.646080, -0.312519, -0.176605, -0.389571, -0.472651, -0.109202, -0.028095, -0.150901, -0.491975, -0.205093, 0.148836, 0.533737, 0.146380, -0.181794, -0.352135, 0.025600, 0.024223, -0.183560, -0.226391, -0.201580, -0.189622, 0.190396, -0.001402, 0.056393, -0.642525, 0.329659, 0.165403, 0.330815, 0.142119, 0.177157, 0.234944, 0.531650, 0.513295, 0.379702, 0.323326, 0.382631, 0.267544, 0.150083, 0.574244, 0.733335, 0.689277, 0.500630, 0.532437, 1.111131, 0.658337, -0.168358, 0.110678, 0.138808, 0.017358, 0.066315, 0.231258, 0.035298, -0.258439, -0.296195, 0.144039, -0.176935, -0.532467, 0.075466, -0.572500, -0.211915, -0.768447, -0.375805, -0.340125, -0.553616, -0.577009, -0.160713, -0.032299, -0.043314, -0.566484, -0.121920, 0.160118, 0.330986, -0.072629, -0.257546, -0.330757, -0.328459, -0.353812, -0.465829, -0.420733, -0.598092, -0.201931, -0.227992, -0.313341, -0.323588, -0.181402, -0.168948, 0.619597, -0.270673, -0.404970, -0.527537, -0.825389, -0.605439, -0.365866, -0.420333, -0.343021, -0.204309, 0.007318, 0.113064, 0.097799, -0.112922, 0.057211, 0.420106, 0.353265, -0.035709, -0.039073, 0.217126, 0.459107, 0.289715, -0.027911, 0.110927, 0.284152, 0.191166, 0.093322, -0.041434, -0.471746, -0.575103, 0.150008, -0.277834, -0.041689, -0.103172, -0.417234, 0.083183, -0.090147, -0.311689, -0.328963, -0.190249, -0.236599, -0.296864, -0.199305, -0.126280, 0.027462, 0.467836, 0.430271, -0.234773, -0.237470, -0.327071, -0.210563, -0.176242, -0.060210, -0.147400, -0.267621, -0.236185, -0.046028, -0.353627, -0.117897, -0.343032, -0.284179, -0.085530, -0.215922, -0.558008, -0.514808, -0.374872, -0.254991, -0.402371, -0.210205, -0.247873, -0.225051, -0.316546, -0.324797, -0.510640, -0.473790, -0.709417, -0.663203, -0.457628, -0.282240, -0.047527, -0.240374, -0.293979, -0.180320, -0.147264, -0.079073, -0.111115, -0.016465, -0.031486, -0.195030, 0.580395, -0.247617, -0.651387, -0.240302, 0.076884, -0.313295, 0.080508, -0.201560, -0.454012, -0.320935, -0.250403, -0.394068, -0.453500, -0.243439, -0.346125, -0.138617, 0.194824, 0.402667, -0.143484, -0.190625, -0.437511, -0.488599, -0.458063, -0.387303, -0.388406, -0.397857, -0.422746, -0.304515, -0.514246, 1.737745, 1.357725, 2.155549, 2.226340, 2.143996, 2.261648, 2.067314, 2.005922, 2.275588, 2.500613, 2.456238, 2.488531, 2.449442, 2.521938, 2.372918, 2.026825, 1.797482, 1.933503, 2.289710, 2.703535, 2.247573, 1.724416, 1.664881, 1.707822, 1.751969, 1.806419, 1.493789, 1.300810, 1.530165, 1.555613, 3.601683, 7.648947, 9.369097, 9.674153, 9.682509, 8.708548, 8.714645, 9.169518, 9.129262, 9.410845, 9.166351, 9.012297, 9.164173, 9.434023, 9.312615, 9.397364, 10.305891, 9.073574, 9.212234, 8.941145, 8.799200, 8.824932, 8.838339, 8.887220, 9.063530, 8.697474, 8.726074, 8.951294, 8.855911, 8.702040, -3.328556, -3.469107, -3.148439, -3.662805, -3.894759, -3.143423, -3.507949, -3.762154, -4.110547, -3.698315, -2.926630, -3.678349, -3.285029, -2.666127, -3.148893, -3.399660, -3.236747, -3.098892, -3.352899, -3.222461, -3.235300, -3.789103, -3.800235, -2.585896, -3.160793, -3.222138, -3.917065, -4.228426, -4.550951, -4.623213, 4.598493, 7.671319, 9.206695, 8.031245, 8.852020, 8.023679, 8.434401, 8.929476, 9.215975, 8.870338, 8.396126, 8.353216, 8.866545, 8.035915, 6.764575, 7.898622, 8.979155, 7.637459, 7.852986, 7.640311, 7.683687, 6.728658, 6.010339, 6.995950, 7.351118, 6.449083, 7.214753, 8.490961, 7.661620, 6.825768, 0.129306, 1.839394, 0.271587, 0.772768, 0.899055, 0.727576, 0.953321, 1.010299, 1.175119, 0.982984, 0.674059, 0.880145, 1.206422, 0.849040, 0.617055, 1.027380, 0.842550, 0.341466, 0.320301, 0.646490, 1.125123, 0.840220, 0.086917, 0.670425, 1.260706, 1.196742, 0.510577, 0.201101, 0.617471, 1.005940, -1.532801, -1.372054, -0.431503, -0.513168, -0.442470, -0.554446, -0.117326, -0.276073, -0.048200, 0.125770, -0.047634, -0.073252, 0.057308, -0.148689, -0.242047, -0.304660, -0.386992, -0.433626, -0.116988, -0.475116, -0.213670, -0.469155, -0.649121, -0.211011, -0.390405, -0.348946, -0.531427, -0.498793, -0.449900, -0.514713, -0.054654, -0.086569, 0.152782, 0.169856, 0.501316, 0.601261, 0.466282, 0.344681, -0.249492, -0.045902, 0.373952, 0.296440, 0.292874, 0.020419, 0.065701, 0.039062, -0.025675, -0.018423, -0.194467, -0.044320, -0.060683, -0.051512, 0.096298, 0.018190, 0.207363, 0.292281, 0.004775, -0.154455, -0.127747, -0.050863, -0.762882, -0.914044, -0.261932, -0.438357, -0.253128, -0.352457, -0.008831, -0.190558, -0.187752, -0.082189, -0.116921, -0.068999, -0.247820, -0.342915, -0.388147, -0.241690, -0.275233, -0.325905, -0.002648, -0.464677, -0.382949, -0.401247, -0.587383, -0.299532, -0.342459, -0.393493, -0.696265, -0.531098, -0.392264, -0.444082, 0.292778, -0.040229, -1.126157, -0.610996, -0.959289, -0.945254, -0.656992, -0.540095, -0.456884, -0.501833, -0.463365, -0.458123, -0.422105, -0.485609, -0.419164, -0.568081, -0.632960, -0.635671, -0.707796, -0.829867, -0.699032, -0.615340, -0.516579, -0.644225, -0.656052, -0.638918, -0.718891, -0.687046, -0.749005, -0.722918, -0.561298, -0.971182, -0.197370, -0.027480, -0.254391, -0.008199, -0.181621, -0.352675, -0.170133, -0.333718, -0.275027, -0.185311, -0.218768, -0.326388, -0.170321, -0.214321, -0.129869, -0.156062, -0.122045, -0.285209, -0.158065, -0.399009, -0.129242, -0.173623, -0.143540, -0.079693, -0.220297, -0.178431, -0.176995, -0.114133, 0.605726, 0.548779, 0.667687, 0.356436, 0.213321, 0.458502, 0.557677, 0.536379, 0.504441, 0.325546, 0.189726, 0.279861, 0.600051, 0.660704, 0.485959, 0.249709, 0.190515, 0.323858, 0.296468, 0.040670, 0.312762, 0.353402, 0.201756, -0.081537, 0.278310, 0.284614, 0.009053, 0.044523, 0.194249, 0.148215, -0.185080, -0.830933, 0.084456, 0.198562, -0.191532, -0.156655, -0.309883, -0.263233, -0.379767, -0.372636, -0.542637, -0.193582, -0.165935, -0.431378, -0.221425, -0.150785, 0.130976, -0.023261, 0.001420, -0.148617, 0.074304, -0.059362, 0.242404, -0.032805, -0.087625, 0.060453, -0.056501, 0.004514, 0.083955, 0.222112, 0.472901, 0.280393, -0.670357, -0.171654, -0.539056, -0.731430, -0.446375, -0.281209, -0.365531, -0.385708, -0.376972, -0.424131, -0.390873, -0.401385, -0.335855, -0.387325, -0.516864, -0.537165, -0.691075, -0.614160, -0.529939, -0.415588, -0.341808, -0.471914, -0.477884, -0.511218, -0.455068, -0.444397, -0.518646, -0.407202, -0.651198, -0.506192, -0.004541, 0.205871, -0.221927, -0.059188, 0.039031, 0.199571, 0.085204, 0.110622, 0.123033, 0.132303, 0.201712, -0.215910, -0.207822, -0.089701, 0.253687, -0.075338, -0.071440, -0.073476, 0.056538, -0.155449, 0.032317, 0.107470, -0.150462, 0.077255, 0.169623, -0.001792, 0.074735, 0.437717, 1.496482, 0.921534, 0.420564, 0.251959, 0.523855, 0.446799, 0.647645, 1.106147, 0.954388, 0.763616, 0.782425, 0.977729, 1.309154, 1.274108, 0.835887, 0.988194, 1.255876, 1.180797, 0.822586, 1.015499, 1.057722, 1.005143, 0.577542, 0.769743, 0.800256, 0.671991, 0.783596, 1.003693, 1.094696, 1.395663, 0.183358, -0.400354, 0.042105, 0.321987, 0.003615, -0.000330, 0.134860, 0.488546, -0.035926, 0.156752, 0.134048, 0.114792, 0.411341, 0.115042, -0.172741, 0.171357, 0.629700, 0.128406, 0.182319, 0.236058, 0.287261, 0.364501, 0.483284, 0.503609, 0.086020, 0.122524, 0.372131, 0.225159, 0.329353, 0.850428, 0.452790, -0.518183, -0.929978, -0.707439, -0.954989, -0.935764, -0.752909, -0.540062, -0.528732, -0.671653, -0.460742, -0.141825, -0.143447, -0.280026, -0.261298, -0.576813, -0.504384, -0.241046, -0.329732, -0.598501, -0.592694, -0.480822, -0.237772, -0.443081, -0.707566, -0.377940, -0.556473, -0.542453, -0.558245, -0.574470, -0.586372, -0.040817, 0.201461, 0.264137, -0.224374, -0.067433, -0.220365, -0.223200, -0.076170, -0.359112, -0.125802, -0.050828, -0.038250, -0.210014, 0.107162, -0.023035, 0.151488, 0.035435, 0.014183, -0.188581, -0.222759, 0.126201, 0.632497, 0.255394, 0.034276, 0.577914, 0.117934, 0.094072, 0.181407, 0.051637, 0.381026, 0.728677, 0.798952, 0.131467, 0.016030, 0.132639, 0.073126, 0.166078, 0.228887, 0.294020, 0.438991, 0.321237, 0.212653, 0.509657, 0.717549, 0.742077, 0.659446, 0.883892, 0.998257, 0.626775, 0.634895, 1.152657, 1.555930, 1.224475, 0.965308, 1.495709, 1.226253, 1.202083, 1.348003, 1.074542, -0.266803, 0.634014, 0.279764, 0.440551, 0.004824, -0.020015, -0.089009, -0.134633, 0.068599, -0.253445, 0.090066, -0.029236, -0.085952, -0.004602, 0.280058, 0.179540, 0.271455, 0.360831, 0.460262, 0.075454, 0.117513, 0.747663, 1.309099, 0.765491, 0.385469, 1.171727, 0.678462, 0.506681, 0.859080, 0.527357, 0.934270, 1.069182, 0.909530, 0.420955, 0.539418, 0.554015, 0.702169, 0.261047, -0.120855, 0.267074, 0.404909, -0.164242, -0.190714, -0.234623, 0.018963, 0.054995, -0.057012, -0.122708, -0.195656, -0.031523, -0.054500, 0.241731, 0.295782, 0.033837, -0.034236, -0.160804, 0.227053, 0.265627, 0.144053, -0.119324, -0.202089, 1.042962, -0.584966, -0.540595, -0.035356, -0.151847, -0.093690, -0.221178, -0.027558, 0.190831, 0.175661, -0.030198, 0.030455, -0.041200, -0.011613, -0.123394, -0.154691, -0.196181, -0.144093, -0.060357, -0.039184, 0.459467, 0.461094, -0.049431, -0.019475, -0.154576, 0.231863, -0.059256, -0.008986, -0.176423, 0.004138, 0.381996, 0.430885, 0.648626, 0.586065, 0.609115, 0.616230, 0.501235, 0.611516, 0.547653, 0.568575, 0.734887, 0.607132, 0.509189, 0.558796, 0.707323, 0.594870, 0.524069, 0.594661, 0.574812, 0.584472, 0.451261, 0.402051, 0.487502, 0.601709, 0.576619, 0.562670, 0.361435, 0.541508, 0.498967, -0.677198, 0.399376, -0.660520, -0.668701, -0.151116, -0.499666, -0.290140, -0.292028, -0.212370, 0.051024, 0.269348, 0.007922, 0.068514, -0.111193, 0.021965, -0.179620, -0.245828, -0.191708, -0.252541, -0.143104, -0.132572, -0.138221, -0.200914, -0.350411, -0.278714, -0.341048, -0.174919, -0.418365, -0.295618, -0.451384, -0.804068, -0.088142, -0.061572, -0.650589, -0.447808, -0.283706, -0.026455, -0.207499, -0.450565, -0.255248, -0.143666, -0.029124, -0.049103, -0.134137, -0.101898, -0.103127, -0.355880, -0.255657, -0.126346, -0.160993, -0.250207, -0.372180, -0.412687, -0.387395, -0.306747, -0.149402, -0.232020, -0.324583, -0.311026, -0.350683, 1.388657, -0.710291, 0.104209, -0.268519, -0.016248, -0.275589, -0.068135, -0.342865, -0.367991, -0.174663, -0.159265, -0.231810, -0.106713, -0.034540, -0.100395, 0.015152, -0.224246, -0.024270, -0.147750, -0.106556, -0.166441, -0.379370, -0.119217, 0.042344, -0.144949, 0.133711, 0.289166, 0.061063, 0.105052, 0.141926, -0.827615, -0.506923, -0.572869, -0.183077, -0.025959, -0.439670, -0.059531, 0.045339, -0.246836, -0.338340, -0.451664, -0.434932, -0.318249, -0.315302, -0.552091, -0.703524, -0.659675, -0.517765, -0.375865, -0.602210, -0.681010, -0.705140, -0.838130, -0.639874, -0.478743, -0.499397, -0.615006, -0.679472, -0.783421, -0.535419, 1.408114, -0.381453, 0.307953, 0.072853, -0.112837, -0.201295, 0.109263, -0.320146, -0.456743, -0.150795, 0.040427, 0.111278, 0.204387, 0.415880, 0.392088, 0.183045, 0.038328, 0.266334, 0.027684, 0.077759, 0.231586, 0.161999, 0.430414, 0.611382, 0.275453, 0.720574, 1.053806, 0.690017, 0.723373, 0.752005, -1.167201, -0.562842, -0.326503, -1.106452, -0.734954, -0.521786, -0.136934, -0.548376, -0.939807, -0.475026, -0.193170, -0.172027, -0.254300, -0.358229, -0.435444, -0.420191, -0.544449, -0.426140, -0.303700, -0.283774, -0.413216, -0.336158, -0.578941, -0.551781, -0.438808, -0.272480, -0.357585, -0.495940, -0.433352, -0.425689, 2.636842, -0.083317, 0.472976, 0.044526, 0.172401, -0.066286, 0.235940, 0.047877, -0.315761, 0.053004, -0.071424, 0.187939, 0.233738, -0.008147, -0.115114, 0.084207, 0.072142, 0.091650, 0.142534, -0.067284, -0.263981, 0.108809, 0.266907, 0.081858, 0.182126, 0.310006, 0.323144, 0.223292, 0.189885, 0.355745, 0.719098, 0.241504, 0.311912, 0.708221, 0.724880, 0.299553, 0.356297, 0.353178, 0.268841, 0.425713, 0.842972, 0.835936, 1.074227, 0.968370, 0.957419, 1.138098, 0.792906, 0.951304, 0.713448, 0.035275, 0.564905, 0.703785, 0.982062, 0.774335, 0.640236, 0.997515, 1.036510, 0.843587, 0.668869, 0.661010, 2.487747, -0.006064, 0.572905, 0.285320, -0.011722, -0.093896, 0.471310, 0.415096, -0.468708, 0.181414, 0.108952, 0.718405, 0.701963, 0.162060, 0.279759, 0.374658, 0.607047, 0.665722, 0.461112, -0.194371, -0.156066, 0.658719, 0.840603, 0.626142, 0.662364, 0.874782, 0.984575, 0.756939, 0.808618, 0.959096, 0.531883, -0.583148, 0.477741, 0.400514, 0.608200, 0.594045, 0.334757, 0.331312, 0.445823, 0.138667, -0.307531, -0.288126, -0.312025, -0.223748, -0.241401, -0.007304, 0.204655, 0.305905, 0.469401, 0.305477, -0.062812, 0.115663, 0.184529, 0.164886, 0.108822, 0.088584, 0.128135, -0.064083, -0.185438, -0.106003, 0.034067, -0.113508, -0.042223, -0.441636, -0.276695, -0.072406, -0.136195, -0.334220, -0.437350, -0.116425, -0.255485, -0.354399, -0.023377, -0.072981, 0.114248, 0.058681, 0.003297, 0.073166, 0.085366, -0.239198, -0.139702, 0.274802, 0.832385, 0.280012, 0.138025, 0.654445, 0.386519, 0.296478, 0.458820, 0.452383, 0.802070, -0.065510, -0.077622, -0.102470, -0.593634, -0.784389, -0.856830, -0.330005, -0.083148, -0.112020, 0.030247, -0.065769, -0.298586, -0.004159, 0.171282, 0.419952, 0.640278, 0.701291, 0.341548, 0.361279, 0.372598, 1.006755, 1.133225, 0.587665, 0.579796, 0.949769, 0.700409, 0.794734, 1.032813, 1.060919, 0.220916, -0.277895, -0.358673, -0.385494, 0.201745, 0.281209, -0.028818, -0.267847, -0.381004, -0.007564, -0.456500, -0.336184, -0.035405, 0.034392, 0.214907, 0.193250, 0.138874, 0.512178, 0.160925, -0.137212, 0.121481, 0.839074, 1.369630, 0.803857, 0.654246, 1.264171, 0.857551, 0.846882, 1.047075, 0.937467, 0.836753, 0.705192, 0.558347, 0.715574, 0.782934, 0.626971, 0.490562, 0.257311, 0.200140, 0.472146, 0.446146, 0.107015, 0.154948, 0.076826, 0.224676, 0.193575, 0.121845, 0.148113, 0.198370, 0.375600, 0.198425, 0.257216, 0.330418, 0.184944, 0.081133, 0.018800, 0.172972, 0.330520, 0.280118, 0.004407, -0.435744, 1.165734, -0.069715, 0.033736, 0.542528, 0.754355, 0.051727, -0.174729, 0.346543, 0.364748, 0.336885, 0.288539, -0.007398, 0.017356, -0.009680, 0.082867, 0.099335, -0.035802, 0.114388, -0.043296, -0.106071, 0.334974, 0.295844, 0.022147, 0.011628, -0.210295, 0.090734, -0.051387, -0.149398, -0.067906, -0.375602, -0.891458, -1.101485, -0.868999, -0.633919, -1.470501, -1.027251, -0.497784, -1.247361, -0.492811, 0.036681, -0.428079, -0.936969, -1.066266, -1.023642, -0.808433, -0.731877, -1.196964, -1.145807, -0.692880, -0.490578, -0.830426, -0.998023, -0.940800, -0.847705, -0.854924, -0.680759, -0.775809, -0.537383, -0.600051, -0.277391, 0.317976, -0.050731, -0.004253, 0.611850, 0.754180, 0.036945, -0.199133, 0.590702, 0.641746, 0.360824, 0.208921, -0.045019, 0.059631, -0.186506, -0.123806, 0.232566, 0.184038, -0.170274, -0.409701, -0.314619, 0.135293, 0.248137, 0.172441, -0.103459, -0.360317, -0.111031, -0.236217, -0.265325, -0.257536, 0.931677, 0.673064, 0.675264, 0.123383, -0.346270, -0.377843, -0.252075, 0.007494, 0.087877, 0.166986, 0.017789, -0.091281, -0.060250, 0.012199, 0.175963, 0.368810, 0.504359, 0.519446, 0.302086, 0.394726, 0.534865, 0.611586, 0.564619, 0.440129, 0.344255, 0.415883, 0.715752, 0.504924, 0.444470, 0.798139, 0.354421, 0.039653, 0.154910, -0.388277, -0.570695, -0.292143, -0.164044, 0.084266, -0.043909, -0.065763, -0.184882, -0.291886, -0.115987, -0.358533, -0.125977, 0.011414, 0.285482, 0.394965, -0.139164, 0.057291, -0.168486, 0.030089, -0.457762, -0.308250, -0.275644, -0.239998, 0.333131, -0.074359, -0.016310, 0.270154, -0.094728, 0.165086, -1.028952, -0.869080, -0.397829, -0.066675, -0.080108, -0.029548, -0.281567, -0.509580, -0.214628, -0.145493, -0.060324, -0.011556, -0.217503, -0.332217, -0.296360, 0.189334, 0.109208, -0.129692, -0.374364, -0.094713, 0.194092, -0.154346, 0.072256, 0.114186, -0.202045, -0.292443, -0.388531, -0.134506, -0.049845, -0.811795, 0.624310, -0.241737, -0.567954, -0.353743, -0.283931, 0.083489, 0.006320, 0.078169, -0.320719, -0.276923, -0.296032, -0.521266, -0.317827, -0.108758, 0.044703, 0.105791, -0.078394, -0.023970, -0.468847, -0.412890, -0.686328, -0.535891, -0.463513, -0.576824, -0.284074, -0.457688, -0.455396, -0.439221, -0.085811, -0.148104, -0.949806, -0.921390, -0.769571, -0.589886, -0.503469, -0.380834, -0.434221, -0.309498, -0.419494, -0.473498, -0.486378, -0.626583, -0.722469, -0.790851, -0.957909, -1.084074, -1.113974, -0.956457, -0.634094, -0.113289, 0.150650, 0.513920, 1.833616, 2.569589, 2.100496, 1.517451, 2.053110, 2.323710, -0.143119, 0.705958, -0.036262, 0.734736, 0.428892, -0.110961, -0.248522, -0.054412, -0.130258, -0.014198, -0.095692, -0.600241, -0.270101, -0.032798, -0.611755, -0.188653, 0.136501, -0.388431, 0.103897, -0.079918, -0.380933, 0.556466, 0.889178, 1.845981, 1.085969, -0.676749, 1.408855, 1.916623, 2.401174, 3.205564, 0.752096, 1.019327, 0.382006, 0.044208, 0.289521, 0.128823, 0.200781, 0.759410, -0.090386, 0.611237, 0.007927, -0.468914, -0.378963, 0.001214, 0.375804, 0.578284, 0.388051, 0.345559, 0.070184, 0.624888, 0.421498, 1.062055, 1.253618, 1.382664, 0.945503, -0.325653, -1.764091, -1.770775, -2.535923, -3.855677, -0.384894, -0.127732, -0.452788, 0.361492, 0.450873, 0.380318, -0.039679, -0.077115, -0.629154, -0.187552, -0.036003, -0.401630, -0.327071, 0.008605, -0.527693, -0.440626, -0.029194, 0.046954, 0.260767, -0.347594, -0.618043, -0.093784, 0.062696, 0.804213, 0.895312, -0.394581, -0.207869, 0.105575, 0.203011, -0.485134, -0.711346, -0.634433, -0.706102, -0.686759, -0.711490, -0.619780, -0.658805, -0.704934, -0.654899, -0.579324, -0.463607, -0.683114, -0.726239, -0.794972, -0.776952, -0.642735, -0.858126, -1.065434, -0.978265, -0.924053, -0.913591, -1.035101, -1.076486, -0.892636, -0.745700, -0.856078, -0.819753, -0.946468, -0.903328, -0.862942, 0.526259, 0.044554, -0.068764, -0.206224, -0.028965, -0.083859, 0.024515, -0.055990, -0.213736, -0.132807, 0.293836, 0.082550, -0.071712, -0.021350, -0.015870, -0.098494, -0.160801, -0.241511, -0.096359, -0.082183, -0.032775, -0.353839, -0.514939, -0.281202, -0.150313, -0.285469, -0.394130, -0.363843, -0.366496, -0.461020, -1.103914, -0.729814, -0.789095, -0.835246, -0.673510, -0.861176, -0.582656, -0.704136, -0.716735, -1.045206, -1.373614, -1.110230, -0.697728, -0.590390, -0.618731, -0.738102, -0.769486, -0.593679, -0.516867, -0.628274, -0.932847, -0.897132, -0.783585, -0.753933, -0.799751, -0.653482, -0.603164, -0.654255, -0.597973, -0.574633, 0.376585, 0.057878, 0.131987, 0.013955, 0.060316, 0.093642, 0.093862, -0.222798, -0.303069, -0.171980, 0.629033, 0.315172, 0.116652, 0.286057, -0.023570, -0.166650, -0.204893, -0.290124, -0.171019, -0.025626, 0.113468, -0.302935, -0.493948, -0.278583, -0.146803, -0.269327, -0.441939, -0.390449, -0.479002, -0.494447, 3.451391, 3.820978, 4.816291, 5.347534, 4.849709, 5.006228, 5.139127, 5.601122, 5.634669, 6.074879, 6.242809, 6.010721, 6.076398, 6.212915, 5.840426, 5.198357, 4.991253, 5.427261, 5.787693, 6.048208, 5.627197, 5.315385, 5.216614, 5.334770, 5.255203, 5.422811, 5.518939, 5.522549, 5.765001, 5.450472, -0.072166, 3.943889, 5.009687, 4.084819, 4.370114, 3.623295, 3.543396, 3.899390, 4.090218, 5.332092, 5.512327, 5.395321, 6.874728, 5.539775, 4.814162, 5.136738, 4.903348, 5.449799, 5.492641, 5.208989, 5.830717, 6.524841, 5.965222, 6.775668, 6.802362, 6.042156, 6.876073, 6.535851, 6.625149, 6.671756, -1.131969, -4.358902, -3.731606, -1.956535, -3.277599, -3.024497, -4.155395, -3.572725, -4.022905, -3.741107, -2.994979, -4.659313, -5.227172, -2.605498, -3.227516, -4.512344, -4.848868, -4.622924, -5.231193, -4.134708, -4.956503, -5.222092, -4.104934, -4.862618, -4.760288, -5.303665, -6.125093, -6.196517, -6.035272, -6.046359, 0.325963, 4.240018, 5.621937, 3.138039, 3.319407, 2.585354, 1.424107, 1.636229, 2.000769, 2.797171, 3.267827, 3.612954, 4.499428, 2.777206, 3.009655, 2.662838, 3.311096, 3.736614, 4.361479, 3.124089, 4.792629, 5.017882, 4.676394, 5.660293, 5.680531, 4.989480, 5.744223, 5.519407, 5.100046, 5.118147, -1.318713, -0.232406, -0.306547, -0.602507, -0.207503, 0.229660, 0.046652, -0.323156, -0.460669, -0.673798, -0.757854, -0.663669, -0.582057, -0.418809, -0.325096, -0.159684, -0.387298, -0.673868, -0.745340, -0.580032, -0.836223, -1.342892, -1.214838, -0.847679, -0.651184, -0.833088, -0.860002, -0.743997, -0.162405, -0.557352, 0.263725, -0.487336, -0.298200, -0.525836, -0.319270, 0.136848, -0.108458, -0.475107, -0.421069, -0.330583, -0.177466, -0.192314, -0.396167, -0.163142, -0.269846, -0.420655, -0.495552, -0.572938, -0.300722, -0.225193, -0.242093, -0.671847, -0.733220, -0.463826, -0.322564, -0.464428, -0.585003, -0.498613, -0.451533, -0.694713, 0.272179, -0.309714, 0.014919, -0.105331, -0.296145, -0.190917, -0.498001, -0.379644, -0.295499, -0.417925, -0.609666, -0.243593, -0.276604, -0.182605, 0.199476, 0.371149, 0.105840, 0.077910, -0.163818, -0.286865, -0.166799, 0.070280, -0.275678, -0.510492, -0.333879, -0.376857, -0.211487, 0.049742, -0.037368, -0.211261, -0.345382, 0.045584, -0.274860, -0.554809, -0.243148, 0.351620, 0.043125, -0.121385, -0.288586, -0.437735, -0.153912, -0.349902, -0.393034, -0.140897, -0.015887, -0.254202, -0.293227, -0.555069, -0.291084, -0.267778, -0.247037, -0.697568, -0.761445, -0.474023, -0.299313, -0.534259, -0.551737, -0.621963, -0.573522, -0.729488, 0.482803, -0.463269, 0.554987, 0.505248, 0.653348, 0.679887, 0.351640, 0.137387, 0.107493, -0.161555, -0.539515, -0.305352, -0.285919, -0.381883, -0.303366, 0.049345, 0.363535, 0.389141, 0.484041, 0.259021, 0.073805, 0.089405, 0.141465, 0.032584, -0.129632, -0.027324, -0.045181, -0.024396, -0.112099, -0.111209, -0.402181, -0.391358, 0.271661, -0.184666, -0.351793, -0.136376, -0.136767, -0.207184, -0.181731, -0.097488, -0.111119, -0.104706, -0.307551, 0.019630, 0.039178, -0.069877, -0.191362, -0.103016, 0.021421, -0.101919, -0.181799, 0.312197, 0.666339, 0.298164, 0.129644, 0.105928, -0.051102, 0.203375, 0.231847, 0.249355, -0.475697, 0.157499, 0.414302, 0.027840, 0.400865, 0.796676, 0.418678, -0.005462, 0.275714, 0.429486, 0.711214, 0.255492, -0.415635, -0.571112, -0.424245, 0.033576, 0.086241, -0.041838, -0.311901, -0.613086, -0.435462, -0.656963, -0.664341, -0.826379, -0.309242, -0.610089, -0.626675, -0.640693, -0.757104, -0.894419, -0.027315, 0.001570, 0.185999, 0.081122, 0.086104, -0.312573, -0.405887, -0.258195, -0.444723, -0.067242, -0.079613, -0.248190, -0.262925, 0.293758, 0.560422, 0.251447, -0.173899, 0.017987, 0.262349, 0.020533, 0.116976, 1.009948, 1.228611, 0.971254, 0.692062, 0.527452, 0.412376, 0.991083, 0.786815, 0.835747, 0.331493, 0.366748, 0.097750, 0.330034, 0.020704, -0.350574, -0.517740, -0.501674, -0.126577, 0.054539, 0.106282, 0.100342, -0.094271, -0.144601, -0.423661, -0.328777, -0.096989, 0.002742, -0.153376, 0.054641, 0.348022, 0.452210, 0.355950, 0.187489, 0.455619, 0.475157, 0.212778, 0.246658, 0.338760, 0.735411, 0.436981, 0.338912, -0.225358, -0.049456, 0.040800, -0.079946, 0.096339, -0.214605, -0.156634, -0.092181, 0.260566, 0.059288, 0.117761, -0.109393, -0.229168, -0.215284, -0.358645, -0.315095, -0.231315, -0.156658, 0.120888, 0.195187, -0.268750, -0.455397, -0.278110, -0.059580, -0.179646, -0.277399, -0.311660, 0.009808, -0.799579, -0.388737, -0.628137, -0.734419, -0.997960, -0.973593, -1.276061, -0.773321, -0.313221, -0.517647, -0.590348, -0.638518, -1.022092, -0.945705, -0.864821, -0.640493, -0.402349, -0.311188, -0.620560, -0.872551, -0.558491, -0.574858, -0.442803, -0.411073, -0.425625, -0.518893, -0.348130, -0.309958, -0.100849, -0.075112, 0.150292, -0.258630, 0.010569, -0.133977, 0.095081, -0.149884, 0.340909, -0.090660, -0.258421, -0.188388, 0.256538, 0.027195, -0.145608, -0.128900, -0.135616, -0.256719, -0.546867, -0.526829, -0.369500, -0.063433, 0.016814, -0.259392, -0.522012, -0.715452, -0.464502, -0.356984, -0.483767, -0.545599, -0.591050, -0.356663, 0.991116, 0.192927, 0.553938, 0.901431, 0.953885, 0.953005, 0.855365, 1.079578, 1.196848, 1.167170, 1.169008, 1.310006, 1.306312, 1.211283, 1.143913, 0.912040, 0.735693, 0.837061, 1.063063, 1.027113, 0.851634, 0.846286, 0.869148, 0.733769, 0.638997, 0.787221, 0.666676, 0.588917, 0.522120, 0.341528, 0.490009, 0.239071, 0.210678, 0.084296, -0.123920, -0.201289, 0.151761, -0.329844, -0.116406, -0.056135, -0.050673, -0.017970, -0.275525, -0.216273, -0.063637, -0.207282, -0.367712, -0.204573, -0.117784, -0.137629, -0.315326, -0.350917, -0.264595, -0.412962, -0.291155, -0.229467, -0.354624, -0.316723, -0.303538, -0.348885, 0.043232, 0.038282, -0.041338, -0.006969, -0.046311, -0.080906, -0.228703, -0.092923, -0.012329, -0.376901, -0.384786, 0.009440, 0.192336, 0.027546, -0.114987, -0.153149, -0.220817, -0.169320, -0.045981, 0.024610, -0.023398, -0.099498, -0.195871, -0.120713, 0.039973, -0.140448, -0.276848, -0.049631, 0.230896, 0.072586, 0.374026, 0.393268, 0.480560, 0.034107, -0.303355, -0.216785, 0.169605, -0.364682, -0.080100, 0.007081, -0.005499, -0.164370, -0.083708, -0.282833, -0.060408, 0.004801, -0.345896, -0.139016, -0.100919, -0.159023, -0.362597, -0.386017, -0.146830, -0.383676, -0.284278, -0.177495, -0.464617, -0.250523, -0.264314, -0.312582, -0.713085, -1.342909, -1.531072, -0.908582, -0.782628, -0.725214, -0.761454, -0.564498, -0.652527, -0.845202, -0.671238, -0.622421, -0.796659, -0.748435, -0.759240, -1.151296, -1.346288, -1.173310, -0.844793, -0.715880, -0.913385, -1.052552, -1.151189, -1.144463, -1.126180, -1.150945, -1.272560, -1.185783, -1.244624, -1.259289, -0.665051, -0.003328, 0.070162, -0.059343, -0.478401, -0.171011, -0.320032, 0.007159, -0.197038, -0.459148, -0.397614, -0.185151, -0.145205, -0.084335, -0.384198, -0.261179, -0.253055, -0.423509, -0.423047, -0.271005, -0.467681, -0.698218, -0.799447, -0.527275, -0.419635, -0.571269, -0.653404, -0.508364, -0.555413, -0.636433, -0.331591, -0.276875, -0.132352, 0.325201, 0.168974, 0.411876, 0.346109, 0.187395, 0.207242, 0.024650, -0.145034, -0.601308, -0.866847, -0.485871, -0.151219, -0.240147, -0.245676, 0.012165, -0.064806, 0.007833, 0.073699, 0.011045, 0.080071, -0.028236, 0.138553, 0.115993, 0.027560, 0.063565, 0.096954, -0.073908, -0.498861, 0.052469, -0.107984, -0.102353, -0.566819, -0.153347, -0.329000, 0.008163, -0.130365, -0.390678, -0.423531, -0.235795, -0.151536, -0.112523, -0.417125, -0.370014, -0.277450, -0.516572, -0.440137, -0.303501, -0.514769, -0.606616, -0.753387, -0.544189, -0.410908, -0.633882, -0.703544, -0.565904, -0.644690, -0.643418, 0.411092, 0.375939, 0.074848, 0.398970, 0.017729, -0.381854, -0.480584, -0.514510, -0.090859, 0.104003, 0.177401, 0.164376, 0.010195, -0.183917, -0.424879, -0.370599, -0.144541, 0.046871, -0.058917, 0.067923, 0.378395, 0.480784, 0.375730, 0.267375, 0.514030, 0.448943, 0.218695, 0.326832, 0.444039, 0.750941, 0.290546, -0.072557, -0.232505, 0.012802, -0.103941, -0.443350, -0.256780, -0.427444, -0.319329, -0.249202, -0.041104, -0.026959, -0.236472, -0.189501, -0.327491, -0.250143, -0.403233, -0.490489, -0.540449, -0.373725, 0.050703, 0.177241, -0.399808, -0.608575, -0.429506, -0.203745, -0.340560, -0.305576, -0.249148, -0.201616, 0.179123, -0.050778, 0.417953, 0.138428, 0.013157, -0.124325, -0.357274, 0.195091, 0.198086, -0.018429, -0.532161, -0.550441, 0.095327, 0.549796, 0.636812, 0.185394, 0.107139, 0.008205, -0.016506, 0.016062, -0.038791, -0.174256, -0.253947, -0.158889, 0.237174, 0.296399, 0.250422, 0.149984, -0.050648, -0.054928, -0.092529, -0.650111, -0.146167, -0.260588, -0.095546, -0.356908, -0.164107, -0.241217, -0.147850, -0.183211, -0.127333, -0.057704, -0.339026, -0.325394, -0.468417, -0.372160, -0.278880, -0.503219, -0.695424, -0.475005, -0.383044, -0.541240, -0.650762, -0.672311, -0.491889, -0.414852, -0.574497, -0.470148, -0.468669, -0.552403, -0.715307, -1.575645, -1.567026, -0.909345, -0.798448, -0.719928, -0.687720, -0.511689, -0.578387, -0.823893, -0.593811, -0.609117, -0.788370, -0.730387, -0.798178, -1.097698, -1.311718, -1.251894, -0.885863, -0.712987, -0.843061, -0.966652, -1.099969, -1.095889, -0.997668, -1.084940, -1.260740, -1.127257, -1.171301, -1.284249, 0.189829, 0.097831, 0.066124, -0.139776, -0.600260, -0.219419, -0.467265, -0.066915, -0.197557, -0.364635, -0.013038, -0.235881, -0.239666, -0.057973, -0.051313, -0.231170, -0.158570, -0.257912, -0.300453, -0.163951, -0.519274, -0.730166, -0.673810, -0.382440, -0.269922, -0.522382, -0.655024, -0.520140, -0.550783, -0.629281, 1.451705, 0.705628, 0.324801, -0.111875, -0.250601, -0.271351, -0.135858, -0.156937, -0.342581, 0.027523, 0.512161, 0.145432, -0.018691, -0.031562, -0.331528, -0.000043, -0.215518, -0.150549, 0.257876, 0.154929, 0.011562, 0.033128, -0.116287, -0.017539, -0.048028, -0.118474, 0.050938, 0.092391, 0.068534, 0.092352, 0.577480, 0.083894, -0.107704, 0.188172, -0.541960, -0.129821, -0.220133, -0.078446, -0.232873, -0.232923, 0.254199, -0.069518, -0.367284, -0.180916, -0.129842, -0.201716, -0.400103, -0.354115, -0.254329, -0.192102, -0.597604, -0.749281, -0.606399, -0.331672, -0.313323, -0.521088, -0.744864, -0.623536, -0.574678, -0.688076, -1.036068, -0.354713, -0.386377, -0.636106, -0.289422, -0.150328, -0.508984, -0.596911, -0.770367, -0.585925, -0.568617, -0.733718, -0.414958, 0.075979, 0.067776, 0.044102, -0.374036, -0.837261, -0.791746, -0.302657, -0.434892, -1.226329, -1.181799, -0.863393, -0.888418, -1.041112, -1.067551, -1.179797, -0.992477, -0.881245, 0.227011, -0.125091, 0.451563, 0.130917, 0.019684, 0.908441, -0.712433, -0.490901, 0.323434, 0.413732, 0.296928, 1.246972, 2.082524, 2.489800, 1.506211, 1.978528, 2.478663, 1.208375, 1.429735, 3.707401, 3.012118, 0.584645, 0.906763, 1.019697, 0.982762, 1.030154, 0.416636, 0.107963, 0.234654, 0.198112, 1.384521, 1.064072, 0.364242, -0.024247, 0.242092, 0.117443, 0.586842, 0.870916, 0.649086, 0.418728, 0.596885, 0.997880, 1.049869, 0.420425, 0.647344, 0.239771, 0.287412, -0.727959, -0.414843, 0.545368, -0.025507, 0.328372, 1.113944, 0.944738, 0.161567, -0.625598, -0.376883, 0.398782, 1.064393, 1.283169, -0.416246, 0.485242, 0.667561, 0.468005, -0.572631, 0.197054, -0.781430, -0.020673, 0.401802, -0.381496, 0.836451, 2.231693, 3.164403, 3.750411, 1.529278, 1.720375, 2.963527, 1.048085, 1.324412, 4.607866, 4.127400, 0.787706, 0.609925, 0.812322, 0.633886, 0.980676, 0.289236, 0.036006, 0.049529, -0.087401, 2.673991, 3.379266, 4.366727, 4.839632, 4.378551, 4.384531, 4.471253, 4.673944, 4.677826, 4.729311, 4.744547, 4.916728, 4.904242, 5.076326, 4.965342, 4.492877, 3.930695, 4.140821, 4.493054, 4.789470, 4.330629, 4.034548, 3.998331, 4.202650, 3.966637, 4.196897, 4.089837, 3.873427, 3.880834, 3.925775, 2.125661, 5.175258, 7.094382, 7.011101, 7.383492, 7.827828, 7.302991, 7.227221, 8.825351, 8.441849, 8.308287, 7.217603, 7.618040, 7.564304, 7.950377, 7.769498, 7.216638, 8.086987, 7.958137, 8.584790, 8.058537, 7.467847, 7.112690, 8.267172, 8.696350, 8.039652, 8.342997, 8.076901, 8.256441, 7.923198, -2.213588, -3.879015, -5.812055, -5.611194, -5.250801, -5.296891, -5.473480, -5.311265, -5.867942, -6.202073, -5.887856, -6.518031, -6.477655, -6.235407, -6.811269, -6.842813, -5.469737, -6.426049, -6.282161, -6.518984, -6.771368, -6.639460, -6.816611, -7.497319, -7.631585, -7.948554, -8.302259, -8.009258, -8.058431, -7.835602, 2.634315, 4.030641, 7.019542, 5.426869, 7.218780, 7.509666, 6.665208, 7.065370, 8.906931, 9.212926, 8.689642, 8.129576, 8.600819, 9.370270, 9.347662, 8.621921, 8.127905, 9.315729, 9.211187, 10.825846, 9.737343, 8.241398, 7.205713, 9.646292, 10.995920, 8.570210, 9.180056, 9.680303, 9.346315, 9.054413, 3.398162, 4.096388, 5.223397, 5.789806, 5.729748, 5.735866, 5.798162, 6.446920, 6.458985, 6.745791, 7.233249, 7.129208, 7.031963, 6.851490, 6.627239, 6.066686, 5.517837, 5.894387, 6.523913, 6.664927, 6.224236, 5.857660, 5.823634, 6.019197, 6.065645, 6.311444, 6.223451, 5.929875, 6.143065, 5.808509, 0.048763, 2.099043, 3.096524, 2.942473, 3.082713, 3.019528, 2.672828, 3.138532, 3.194770, 2.844452, 2.513834, 3.164868, 3.626690, 2.860465, 3.327730, 3.335354, 3.417619, 4.167356, 4.078820, 3.987602, 4.500307, 4.111877, 3.841761, 3.996281, 4.165793, 3.992478, 4.323240, 4.911286, 4.715587, 4.679058, -0.283872, -0.173564, -0.002508, -0.126084, 0.458338, -0.150113, -0.976540, -0.688365, -0.372643, -0.109169, -0.858983, -1.356416, -1.272635, -1.370237, -0.687927, -0.706865, -0.045690, 0.041168, -0.438392, -0.750106, -1.801366, -1.251223, -1.081898, -0.462765, -0.406289, -1.625401, -1.762594, -2.274123, -2.768643, -2.225759, 0.229556, 1.563625, 1.452829, -0.054561, 0.780219, 1.169113, 0.459808, 1.191681, 1.813266, 0.871069, 0.268759, 1.322244, 2.482569, 1.438212, 1.069540, 1.500606, 1.666966, 2.677604, 2.045347, 1.243829, 1.837027, 1.559632, 0.981602, 1.793959, 2.668485, 1.940948, 1.915016, 2.860872, 2.645957, 3.199139, -1.095877, -0.871050, -0.133154, -0.480605, -0.532778, -0.681228, -0.259875, -0.394828, -0.554106, -0.305916, -0.258825, 0.040086, 0.348937, 0.552658, 0.423978, 0.292104, -0.029350, -0.274043, -0.131675, 0.126613, -0.173727, -0.405240, -0.441111, -0.170207, -0.121642, -0.144142, -0.155926, -0.562945, -0.587731, -0.529023, 2.846916, 0.409075, -0.071070, 0.263382, -0.293249, 0.418722, 0.336855, 0.076160, -0.179178, 0.068241, 0.127399, 0.536151, 3.866609, 6.493129, 3.864973, 3.998803, 5.412641, 2.410796, 1.132861, 3.827272, 4.304527, 1.403913, 0.966853, 0.852464, 0.573663, 1.229948, 0.566343, -0.211200, -0.085930, 0.079787, -0.586079, 0.626566, 0.004694, -1.030576, -1.712281, -1.479924, -1.746221, -1.401731, -0.644518, -0.995685, -2.353167, -2.622002, -3.346524, -3.337821, -2.534939, -1.922421, -1.285762, -0.809395, -2.335545, -3.048928, -2.829159, -1.716441, -1.519810, -1.137310, -1.774031, -0.914878, -0.329022, -0.483721, -0.120899, -0.608348, 1.153866, 0.617054, 0.891056, -0.381428, -0.082435, -0.287910, 0.674047, 0.186531, -0.790359, -1.111322, -0.301311, -0.071579, 4.293384, 6.199081, 2.808952, 3.097527, 5.325829, 3.333624, 0.433424, 3.734892, 3.741245, 1.192518, 1.142426, 0.760260, 0.839417, 1.443749, 0.735385, 0.120243, 0.687597, 0.229814, -0.933971, -0.400120, -0.084510, -1.066615, -0.928622, -0.604387, -0.188421, -0.486229, -0.886904, 0.000233, -0.002602, -0.066157, -0.041907, 0.103373, -0.036999, -0.077352, -0.113354, 0.130201, 0.787336, 0.483019, 0.636134, 0.838558, 0.841996, 0.917179, 1.349295, 1.242771, 1.121356, 0.852605, 1.269343, 0.860759, 1.038270, -0.870439, -1.251671, 0.012103, 0.314700, 0.206561, 1.078913, -0.287156, 0.286222, -0.495348, -0.113188, -0.132922, -0.024702, -0.287204, 0.640013, 1.371679, 0.590076, 1.232024, 1.652109, 2.581023, 3.453166, 2.263712, 1.849650, 2.278407, 2.797384, 2.140911, 2.169041, 1.964146, 3.065510, 2.426902, -0.471631, 0.163607, 0.249442, -1.113891, 0.302220, -0.442473, -0.420392, -1.163896, -1.785993, -1.442374, -0.260122, -0.320238, -0.489950, -1.445677, -2.070511, -2.513170, -3.341074, -2.546106, -3.493745, -4.996892, -5.088943, -3.936579, -3.785517, -4.434294, -4.895509, -3.431959, -4.360613, -3.496804, -4.490111, -4.891522, 1.650627, -0.722842, -0.436911, 0.388676, -0.630370, -0.507527, 0.279457, -0.974868, 0.107353, -0.746734, -0.921420, 0.429095, -0.107107, -0.264809, 0.825570, 0.572223, -0.277992, -0.055223, -0.179613, -0.283626, 0.064013, 0.288394, 0.765560, 0.604239, -0.099073, 1.121299, 0.930874, -0.202276, 0.660563, 0.574180, 3.686949, 3.293407, 4.376549, 4.859012, 4.612810, 4.792010, 5.066377, 5.335093, 5.457416, 5.615047, 5.942646, 6.096816, 5.972850, 5.785943, 5.413231, 4.984958, 4.688672, 5.089184, 5.574755, 5.860387, 5.485633, 5.048126, 5.310893, 5.538567, 5.399389, 5.473703, 5.476891, 5.368954, 5.379228, 5.276545, 0.898774, 5.241537, 6.274994, 6.187325, 5.632493, 6.031508, 5.795864, 5.645380, 5.600751, 6.312405, 6.862749, 6.261928, 6.746883, 7.280579, 6.802136, 6.929853, 6.861088, 6.635855, 6.876475, 6.376741, 6.557039, 6.563417, 6.446280, 6.960980, 6.808170, 6.568307, 6.762756, 6.776053, 6.537199, 6.658878, -0.563385, -0.304960, 0.466422, -0.261439, -0.520482, -0.785558, -0.714499, -0.752414, -0.474352, -1.037962, -1.673306, -1.564641, -1.645519, -1.217688, -1.141953, -1.567222, -0.847895, -0.940103, -1.879750, -0.969339, -0.930737, -1.254116, -2.073329, -2.259315, -1.914364, -2.139073, -2.438643, -1.756071, -1.715010, -1.236133, 0.245170, 3.673789, 2.753973, 1.554227, 1.962978, 2.437773, 2.461473, 1.872186, 1.330028, 3.653847, 2.430587, 1.824157, 2.630089, 2.840679, 2.595339, 3.654907, 2.846830, 2.706813, 2.895580, 2.671428, 2.463775, 2.641266, 2.785494, 3.612118, 3.328946, 2.819993, 3.030940, 2.558683, 3.118791, 2.816244, -1.164764, -0.198848, -0.353640, -0.817043, -0.252993, 0.327334, 0.277005, -0.125914, -0.383185, -0.369776, -0.320186, -0.471360, -0.445083, -0.357319, -0.358217, -0.095721, -0.295097, -0.622061, -0.607774, -0.338575, -0.547905, -1.044374, -0.945513, -0.663145, -0.574690, -0.730797, -0.715261, -0.612846, -0.149329, -0.531304, -0.033693, -0.451746, -0.354139, -0.382790, -0.437177, -0.278641, -0.307945, -0.480868, -0.183875, -0.265386, -0.255311, -0.170156, -0.242592, -0.121315, -0.398973, -0.209487, -0.272953, -0.463950, -0.191528, -0.206146, -0.268877, -0.633446, -0.603576, -0.423854, -0.360321, -0.493907, -0.409786, -0.393291, -0.428876, -0.565445, 0.026134, -0.197407, -0.399508, -0.300479, -0.088079, -0.024929, -0.116709, -0.361143, -0.493248, -0.803176, -0.812445, -0.388509, -0.360073, -0.491881, -0.588894, -0.405924, -0.584820, -0.573476, -0.412428, -0.471502, -0.514429, -0.316738, -0.491579, -0.376458, -0.286880, -0.275960, -0.423617, -0.572124, -0.273272, -0.273527, -0.600504, -0.078482, -0.282288, -0.505669, -0.568192, -0.320428, -0.442557, -0.546408, 0.015944, -0.112933, -0.140135, -0.141605, -0.250957, -0.073973, -0.313739, -0.238096, -0.327219, -0.397352, -0.234764, -0.326166, -0.336022, -0.605672, -0.632409, -0.506790, -0.381801, -0.506813, -0.482469, -0.572611, -0.518521, -0.649108, 0.098434, 1.851016, 0.165010, 0.785366, 0.873257, 0.719096, 1.020804, 1.067851, 1.221035, 1.044034, 0.731764, 0.891128, 1.171996, 0.897113, 0.729429, 1.083307, 0.899936, 0.363162, 0.391406, 0.598874, 1.012473, 0.695171, 0.079910, 0.883152, 1.390597, 1.123245, 0.479277, 0.233701, 0.641802, 0.967748, -1.665894, -1.767505, -0.405172, -0.160528, -0.098956, -0.526115, -0.227196, -0.498230, -0.111297, -0.200771, -0.356878, -0.370367, -0.049807, -0.026073, -0.193354, -0.249511, -0.388787, -0.313775, -0.149384, -0.415632, -0.298659, -0.516691, -0.711681, -0.054849, -0.267958, -0.403343, -0.500714, -0.523948, -0.529832, -0.549285, -0.098665, -0.167301, -0.069559, -0.606895, -0.850494, -0.387581, -0.276634, -0.152496, 0.090601, -0.096161, -0.094531, -0.153388, -0.184379, -0.428310, -0.232645, 0.146838, -0.003045, 0.054061, -0.369981, -0.090458, -0.220223, -0.402656, -0.174437, 0.051887, -0.163505, -0.367975, -0.223925, -0.221707, -0.195913, -0.320360, -0.986344, -1.371920, -0.246363, 0.089978, 0.333489, -0.230478, -0.032643, -0.373200, -0.044073, -0.282195, -0.603762, -0.524481, -0.031106, -0.060788, -0.199061, -0.243751, -0.221870, -0.230111, -0.117994, -0.526680, -0.484140, -0.559817, -0.704847, -0.166226, -0.208915, -0.295208, -0.547102, -0.542912, -0.641465, -0.570570, 1.188902, 1.548204, 1.147501, 1.584759, 2.356073, 2.099771, 1.953046, 1.677452, 1.011159, 0.930274, 0.886330, 0.377019, 0.757225, 0.659427, 0.536902, 0.688339, 0.544799, 0.626158, 0.327821, 0.387233, 0.343208, 0.481480, 0.767261, 0.780558, 0.576360, 0.358324, 0.869232, 1.402859, 1.173832, 0.348676, -0.537229, 1.847752, -0.577234, 1.030844, 2.579994, 1.323263, 1.360138, 1.238234, 0.851255, 0.485422, 0.332441, 0.333082, 0.341177, 0.711047, 0.170423, -0.172658, 0.178573, -0.010586, -0.093058, 0.166635, -0.041050, -0.003558, -0.148246, 0.113852, -0.071874, -0.256058, 0.254487, 0.413227, 0.144427, -0.260624, -0.622184, -0.607705, -0.140850, -0.191450, 0.209677, -0.364540, -0.599488, -0.216468, 0.120520, 0.099299, -0.061585, 0.115597, 0.194615, -0.023923, -0.143898, -0.064699, 0.145380, 0.149008, 0.313159, 0.068644, -0.134890, -0.547639, -0.228561, -0.536985, 0.160920, -0.319082, -0.548417, -0.284208, -0.364423, -0.280450, -0.487361, 1.057021, -0.840136, 1.979031, 3.772354, 2.494204, 1.696010, 2.310157, 0.963370, -0.037977, 0.094566, 0.514588, 0.448456, 0.725535, 0.033519, -0.469114, 0.281538, 0.366535, 0.311818, 0.338940, 0.209851, 0.112340, -0.467855, -0.063602, -0.228036, -0.430041, 0.175152, 0.041192, -0.024503, -0.488486, 1.122615, 1.329925, 0.968354, 0.559650, 0.581453, 0.776134, 0.947989, 0.505861, 0.126705, 0.372385, 0.514346, 0.091556, -0.006147, -0.098420, 0.443650, 0.511989, 0.348981, 0.366219, 0.187447, 0.306547, 0.228965, 0.318114, 0.428509, 0.227583, 0.175135, 0.042414, 0.448703, 0.662757, 0.436548, 0.055034, -0.469391, 1.558510, -0.363760, -0.562335, 0.139090, 0.176012, 0.907698, 0.485811, -0.206821, -0.151672, -0.317407, -0.437822, -0.044383, -0.513886, 0.038875, 0.046412, 0.209668, -0.035906, -0.202870, -0.268697, -0.135210, 0.215536, 0.112533, -0.185490, -0.051434, -0.294431, 0.102783, -0.023618, -0.008537, -0.234242, -0.022997, -0.306060, -0.235675, -0.012357, -0.405591, -1.045068, -1.537062, -1.554526, -0.992797, -0.032342, 0.108054, -0.456894, 0.064507, -0.239509, -0.806812, -1.145018, -0.785985, -0.105563, 0.097053, -0.200161, -0.574974, -0.480879, -0.091294, -0.049218, -0.114624, -0.191835, -0.039434, -0.259981, -0.240872, 0.114047, -0.654394, 0.669377, -0.582219, -0.659877, -0.108774, 0.041593, 0.856584, 0.240398, -0.237517, -0.538985, -0.473838, -0.322335, 0.010322, -0.617373, 0.095417, 0.019744, 0.271193, -0.257255, -0.364873, -0.424715, -0.155053, -0.088297, -0.370328, -0.456687, -0.017586, -0.269447, -0.053625, -0.264756, -0.327167, -0.456767, 0.487350, -0.068358, -0.370049, -0.174421, -0.375273, -0.476785, -0.321663, -0.205071, -0.209331, -0.189240, -0.275027, -0.239834, -0.223937, -0.247585, -0.228862, -0.397365, -0.368022, -0.264642, -0.386157, -0.387339, -0.260589, -0.110171, -0.021625, -0.207677, -0.492076, -0.509544, -0.425462, -0.301268, -0.415341, -0.273147, -0.979568, -0.082811, -0.037469, 0.409532, -0.058802, 0.301852, 0.072925, 0.185279, 0.309499, 0.204697, -0.028710, 0.298198, 0.149108, -0.077559, -0.114889, 0.062082, 0.339889, 0.416465, 0.153458, 0.303954, 0.416935, 0.439391, 0.273074, 0.149984, -0.008635, 0.022190, 0.080729, 0.052348, 0.113378, 0.589669, -0.269951, 0.324458, 0.415880, 0.724444, 0.900266, 0.974139, 0.685978, 0.327818, 0.404456, 0.558859, 0.197969, 0.147030, 0.331109, 0.080159, 0.147188, -0.151369, -0.353370, -0.098221, -0.083193, -0.014666, -0.064511, -0.326466, -0.239159, -0.291486, 0.021254, 0.102347, -0.022356, -0.138318, -0.258840, -0.479186, -0.392814, -0.111316, 0.060919, 0.304510, 0.376315, 0.304314, 0.311917, 0.324125, 0.274966, 0.223894, 0.044454, 0.325973, 0.225737, 0.145359, -0.036807, 0.110502, 0.597700, 0.852333, 0.282271, 0.533999, 0.764094, 0.931403, 0.728865, 0.545062, 0.349484, 0.231594, 0.507748, 0.388098, 0.603450, 1.277957, -0.694511, -0.545582, -0.446895, -0.343440, -0.723067, -0.842638, -0.972595, -0.819111, -0.504041, -0.526421, -0.391260, -0.481481, -0.556411, -0.684218, -0.926771, -0.713638, -0.795328, -1.007735, -0.969511, -0.881446, -0.886656, -0.958031, -0.964593, -0.830800, -0.607620, -0.792710, -0.762178, -0.844426, -0.915623, -0.823566, 0.485042, -0.181400, -0.412951, -0.371242, -0.111364, 0.042263, 0.110678, -0.089211, -0.287718, -0.164705, 0.035082, -0.201905, -0.226291, -0.148398, -0.235624, -0.320688, -0.441549, -0.378395, -0.253678, -0.098630, -0.404451, -0.584202, -0.567342, -0.442821, -0.262304, -0.498381, -0.468706, -0.444726, -0.501138, -0.525545, 0.686658, 0.257683, 0.371249, 0.606821, 0.831718, 0.768321, 0.627020, 0.758265, 1.046873, 0.826288, 0.550997, 0.574989, 0.714934, 0.497792, 0.287201, 0.463082, 0.526568, 0.554937, 0.781485, 0.738093, 0.614786, 0.546720, 0.387412, 0.418121, 0.474053, 0.267990, 0.198162, 0.465999, 0.583831, 0.478860, 0.430400, -0.419252, -0.309392, -0.137784, -0.007518, 0.234133, 0.370884, -0.021672, -0.166000, -0.127725, 0.143916, -0.247429, -0.212969, -0.192552, -0.363057, -0.199176, -0.391342, -0.460475, -0.121257, 0.066936, -0.401709, -0.598108, -0.630324, -0.541391, -0.312657, -0.558419, -0.555156, -0.572729, -0.639246, -0.545864, 1.081264, 0.803459, 0.916799, 0.112575, -0.374404, -0.344875, -0.159779, 0.147399, 0.223662, 0.202999, 0.047072, -0.130098, -0.095035, 0.000627, 0.267506, 0.533035, 0.624323, 0.637221, 0.392851, 0.465591, 0.586566, 0.716715, 0.568566, 0.434663, 0.298293, 0.410127, 0.841622, 0.535415, 0.433353, 0.812588, 0.079741, 0.107129, 0.175556, -0.274398, -0.178724, 0.117922, -0.122892, -0.138808, -0.101942, -0.209288, -0.299624, -0.271347, -0.046340, -0.252569, -0.178884, 0.015289, 0.130807, 0.422918, -0.263523, 0.059194, -0.075575, -0.016887, -0.283686, -0.172944, -0.116577, -0.140074, 0.288315, -0.067975, -0.043974, 0.360178, 0.302026, 0.465936, 0.715277, 0.809678, 0.774814, 0.432484, 0.205991, 0.564617, 0.669108, 0.406687, 0.381205, 0.274921, -0.007948, 0.121133, 0.320488, 0.330513, 0.416299, 0.445580, 0.429948, -0.002730, 0.320672, 0.196231, 0.023784, 0.391268, 0.535349, 0.189301, 0.260215, 0.009032, 0.240215, 0.204779, -0.372785, -0.867582, 0.674007, 0.157673, -0.037319, 0.087413, -0.175633, -0.111552, -0.156946, -0.222721, -0.348077, -0.170436, -0.104072, -0.283022, -0.293671, -0.319120, -0.225889, -0.039427, -0.402028, -0.128903, -0.258970, -0.302886, -0.477655, -0.416307, -0.325458, -0.481073, -0.321140, -0.475437, -0.466050, -0.405514, -0.182897, -0.456819, 0.093816, -0.187784, -0.370615, -0.481521, -0.629556, -0.397099, -0.271596, -0.421451, -0.356855, -0.115595, 0.007845, 0.024300, 0.060825, -0.116447, 0.128222, 0.419266, 0.296725, 0.032135, 0.020941, 0.236487, 0.435019, 0.324299, 0.059231, 0.169028, 0.276245, 0.143689, 0.153504, 0.043847, -0.241125, 0.110999, 0.318735, -0.010782, -0.125062, -0.495157, -0.364584, -0.017915, -0.017848, -0.182850, 0.148348, 0.049912, -0.011007, 0.006582, -0.190522, -0.047072, 0.076616, 0.059309, 0.117199, -0.247652, -0.220565, -0.345081, -0.219207, -0.122475, -0.143832, 0.053785, -0.067971, -0.176396, -0.117564, -0.370873, 0.507744, 0.399670, 0.089661, 0.142900, -0.084836, -0.101514, 0.234539, 0.187367, -0.138286, -0.120923, 0.047141, 0.251506, 0.212029, 0.122434, 0.372401, 0.565040, 0.146210, 0.148519, 0.581964, 0.479770, 0.192676, -0.014255, -0.122611, 0.216035, 0.433726, 0.186165, 0.027792, 0.459071, 0.422552, 0.284431, -0.244781, 0.999936, -0.045114, -0.401121, -0.432532, -0.490779, -0.445110, -0.049449, 0.108179, -0.036097, 0.182722, 0.258389, -0.081570, -0.273076, -0.215843, 0.036117, -0.062560, -0.224267, -0.048056, -0.216169, -0.241383, -0.500893, -0.403267, -0.333136, -0.247642, -0.069843, -0.200961, -0.276716, -0.289236, -0.417922, -0.140855, -0.243326, 0.090543, -0.262642, -0.311841, -0.436763, -0.565740, -0.481301, -0.347475, -0.314405, -0.163269, -0.140776, -0.081201, -0.010765, -0.079354, -0.235052, -0.003239, 0.217098, 0.205588, -0.012167, 0.014244, 0.191022, 0.392142, 0.267455, 0.060288, 0.092768, 0.124061, 0.090155, 0.105526, 0.098328, -0.439355, -0.432206, -0.336661, -0.180604, -0.181669, 0.037786, -0.009950, -0.070068, -0.183830, -0.221255, -0.279806, -0.361341, -0.324333, -0.195954, -0.191988, -0.153662, -0.130921, -0.128913, -0.107265, 0.039572, -0.043187, -0.246522, -0.174356, -0.112390, -0.189043, -0.123301, -0.159816, -0.133872, -0.175989, -0.280440, 0.027518, 0.424163, 0.220376, 0.302925, 0.316024, 0.197212, 0.066032, 0.279632, 0.639808, 0.732332, 0.823559, 0.537481, 0.180224, 0.384602, 0.373356, -0.029410, -0.109088, 0.422397, 0.510457, 0.747715, 0.356067, 0.270616, 0.400098, 0.348177, 0.207654, 0.226868, 0.161832, 0.185476, 0.006339, -0.000558, -0.548911, 0.240533, -0.508838, -0.451381, -0.313453, 0.277412, 0.011861, 0.038071, -0.002187, -0.124437, -0.550496, -0.496061, -0.364032, -0.064691, -0.016671, -0.096970, -0.379719, -0.326844, -0.223798, 0.145805, -0.107877, -0.390396, -0.361243, -0.301224, -0.399088, -0.470317, -0.349214, -0.356599, -0.469202, -0.485148, -0.643097, -0.857390, -1.235044, -1.007177, -0.810434, -0.674347, -0.503588, -0.474304, -0.647463, -0.722361, -0.597866, -0.706875, -0.811788, -0.699353, -0.784633, -1.037816, -1.138635, -1.162732, -0.979556, -0.851795, -0.972646, -1.133844, -1.175287, -1.127613, -1.012058, -1.068009, -1.138926, -1.130736, -1.174138, -1.188733, -0.512426, 0.056765, 0.083470, -0.322634, -0.391516, -0.223823, -0.208035, -0.282450, -0.276465, -0.581838, -0.271562, -0.211870, -0.235222, -0.143324, -0.261079, -0.296804, -0.228307, -0.260515, -0.317036, -0.252236, -0.375433, -0.709974, -0.666263, -0.452375, -0.342083, -0.508705, -0.603037, -0.462056, -0.549855, -0.657637, 0.378330, 0.334780, -0.294009, -0.541204, -0.292283, -0.067030, 0.077635, -0.105287, -0.418839, -0.434693, -0.286856, -0.006285, 0.034229, -0.109132, -0.482242, -0.709510, -0.585558, -0.512136, -0.529066, -0.642987, -0.666809, -0.423521, -0.025518, -0.260895, -0.333028, -0.347003, 0.007985, -0.108858, -0.257556, -0.224916, -0.494716, -0.213841, -0.157449, -0.190702, -0.439040, -0.322226, -0.448889, -0.257017, -0.165086, -0.555708, -0.351895, -0.190508, -0.148099, 0.040285, -0.143307, -0.272447, -0.213200, -0.374515, -0.358203, -0.240706, -0.342079, -0.670176, -0.681517, -0.563730, -0.487385, -0.558452, -0.659848, -0.491598, -0.587868, -0.623059, 0.513996, -0.614258, 0.519399, 0.547739, 0.810426, 0.798140, 0.412307, 0.271957, 0.168536, -0.136479, -0.496834, -0.458400, -0.482225, -0.422064, -0.273183, -0.050580, 0.218775, 0.249045, 0.349775, 0.225316, 0.059700, 0.248397, 0.159089, 0.057603, -0.074953, 0.032028, 0.052658, 0.049667, -0.040310, -0.005885, -0.248791, -0.104185, 0.354245, -0.359841, -0.054332, -0.280386, -0.007046, -0.037617, 0.209223, 0.264422, 0.210685, 0.229025, -0.114236, 0.088514, 0.382869, 0.265469, 0.036748, 0.085378, 0.207082, 0.026405, -0.136185, 0.869905, 0.980257, 0.489527, 0.203912, 0.167276, 0.189124, 0.375381, 0.558615, 0.629886, -0.355917, 0.217380, 0.468912, -0.006524, -0.007759, -0.221985, -0.361320, -0.922490, -0.971839, -0.831575, -0.901234, -0.794505, -0.819899, -0.502736, -1.037824, -0.864055, -0.498004, -0.519435, -0.371299, -0.716388, -0.938157, -1.399412, -1.323772, -1.198712, -0.927784, -0.819684, -0.973368, -1.124050, -1.466113, -1.603476, 0.035233, 0.175674, 0.329641, -0.487498, -0.035607, -0.404578, -0.023833, 0.366560, 0.738531, 0.347229, 0.286576, 0.547112, -0.202976, 0.180920, 0.831776, 0.565970, 0.237201, 0.372871, 0.413133, 0.191614, 0.466115, 1.897201, 1.837644, 1.387036, 0.762452, 0.679638, 0.816284, 1.068976, 1.429321, 1.404729, 1.305036, 0.335252, 0.803676, 1.197213, 0.795716, 0.764232, 0.796263, 1.198784, 1.298411, 1.267329, 1.414083, 1.743176, 1.660589, 1.726366, 1.685762, 1.403025, 1.221402, 1.314997, 1.508431, 1.379585, 1.164199, 1.120065, 1.333669, 1.261346, 0.969153, 1.501684, 1.320451, 0.997042, 0.833581, 1.014905, 1.144313, 4.622106, 6.763659, 7.108613, 7.709239, 7.811931, 7.155352, 7.271279, 7.358474, 7.071849, 7.130618, 7.023733, 7.367287, 7.281184, 6.988950, 7.556055, 6.989568, 6.048949, 6.334798, 7.008270, 6.920938, 6.202053, 5.563319, 6.241846, 7.031332, 6.380307, 6.328672, 6.731826, 7.076489, 6.732873, -1.841002, -5.727824, -7.121427, -5.293659, -5.330349, -6.151943, -6.035656, -5.943508, -5.279760, -5.456079, -5.882020, -5.411991, -5.830434, -5.934321, -6.320174, -7.189237, -6.976115, -6.171657, -5.085593, -5.917213, -5.613502, -5.970484, -5.735721, -6.363364, -6.956728, -6.543504, -6.472920, -6.148737, -6.331615, -7.161756, 1.295631, 5.573144, 6.895394, 6.960181, 7.637659, 7.073774, 6.405292, 7.059183, 6.649230, 6.682336, 6.186888, 6.337844, 6.416282, 6.397913, 6.901602, 7.995935, 7.247184, 5.722527, 6.055745, 6.552185, 6.474686, 5.264298, 4.512714, 5.606170, 7.031442, 5.880870, 5.411535, 6.069056, 6.245736, 5.926549, 0.657018, 0.783685, 0.476943, 0.824318, 0.741111, 0.257632, 0.120231, 0.134877, 0.265121, 0.515891, 0.643176, 0.520816, 0.415027, 0.343645, 0.302988, 0.407247, 0.566565, 0.627307, 0.513968, 0.628919, 0.768605, 0.773246, 0.794078, 0.818010, 0.766252, 0.638519, 0.630228, 0.805656, 0.831890, 0.842761, 0.420795, 0.343184, -0.342775, 0.928332, 0.789195, -0.300547, -0.150891, -0.236333, -0.349142, 0.142622, 0.116603, -0.055852, 0.000099, -0.099680, -0.057832, -0.157291, -0.321816, -0.386940, -0.563668, -0.366684, -0.324717, -0.072716, -0.258209, -0.353338, -0.330572, -0.335965, -0.208045, -0.218884, -0.256798, -0.299796, -1.260209, -0.755665, -0.962750, -1.616842, -1.448168, -0.956518, -0.702421, -0.452032, -0.243383, -0.123478, -0.039831, -0.155327, -0.555474, -0.862965, -0.718254, -0.707537, -0.535923, -0.549710, -0.245181, 0.129801, -0.177233, -0.156461, -0.159089, -0.327905, -0.610922, -0.524103, -0.609130, -0.491654, -0.708400, -0.200217, -0.021104, -0.191774, -0.212412, 0.883060, 0.569040, -0.338208, -0.064884, -0.215043, -0.263067, -0.119224, 0.085371, 0.017732, -0.131055, -0.121948, 0.087195, -0.000419, -0.388383, -0.569105, -0.507085, -0.488311, -0.539934, -0.387955, -0.493405, -0.579609, -0.280994, -0.502116, -0.415263, -0.476283, -0.449560, -0.693947, 1.540536, 1.965131, 2.718460, 2.939316, 2.570120, 2.523452, 2.313575, 2.424646, 2.629478, 2.657422, 2.747817, 2.771555, 2.659518, 2.648490, 2.583015, 2.399872, 2.246707, 2.105273, 2.276708, 2.273390, 2.163729, 1.902810, 1.842561, 1.918075, 1.912174, 2.059044, 1.906351, 1.883007, 1.860954, 1.659687, 1.458587, 2.412288, 3.520141, 3.459373, 3.201086, 2.870312, 3.098631, 3.306825, 3.331034, 3.395296, 2.562073, 2.220519, 2.510628, 2.278835, 2.744374, 2.868156, 2.883535, 3.092131, 3.669475, 3.685049, 3.529497, 3.133024, 2.906521, 3.433320, 3.814759, 3.575131, 3.364263, 3.591408, 3.889003, 3.778086, 0.170873, 0.583546, 1.270240, 1.414582, 0.553050, 0.491310, 0.320713, 0.527417, 1.216051, 0.438590, 0.236338, 1.000249, 1.630455, 0.999285, 0.874387, 0.752128, 0.974937, 0.447142, 0.625524, 1.106081, 1.338117, 1.591289, 1.112567, 0.885872, 0.916143, 0.434696, 0.554691, 0.148824, 0.746241, 0.733756, 2.258227, 2.501706, 3.257982, 2.833342, 2.161563, 2.191039, 2.853747, 3.046548, 2.504265, 2.804310, 1.950123, 1.622578, 1.573532, 1.676035, 2.065490, 1.823392, 2.183370, 2.680303, 3.298395, 2.806772, 2.436606, 2.381531, 1.615213, 2.321845, 3.599376, 2.946269, 2.522917, 2.901256, 3.124069, 2.924142, 0.505613, 0.512545, 0.399583, 0.870417, 0.658871, 0.146605, 0.069658, 0.310571, 0.720922, 0.838428, 0.788347, 0.739590, 0.739304, 0.701676, 0.548154, 0.520433, 0.581264, 0.568891, 0.617360, 0.680897, 0.736706, 0.784746, 0.727878, 0.679444, 0.687761, 0.716998, 0.537198, 0.590020, 0.670248, 0.773560, 0.837697, 0.177947, -0.166582, -0.182197, -0.120356, -0.331545, -0.274926, -0.200712, -0.281763, -0.179142, -0.063770, -0.128852, -0.244720, -0.092971, -0.131872, -0.151445, -0.219820, -0.289578, -0.337189, -0.216541, -0.039734, -0.076631, -0.415985, -0.471271, -0.234931, -0.239679, -0.336996, -0.303944, -0.404911, -0.358512, 1.130214, 0.880812, 0.713337, 0.477900, 0.682106, 0.847192, 0.771568, 0.543278, 0.623428, 0.899773, 0.793389, 0.680682, 0.700896, 0.508003, 0.536604, 0.319165, 0.217756, 0.699012, 0.846419, 0.842511, 0.499098, 0.018987, 0.164855, 0.229314, 0.596411, 0.539758, 0.764128, 0.638602, 0.378894, 0.415043, 0.443556, -0.260477, -0.127915, -0.442260, -0.099675, -0.154414, -0.064055, -0.111930, -0.275111, -0.189638, -0.267309, -0.330385, -0.367724, -0.114027, -0.263771, -0.106135, -0.285312, -0.350950, -0.282914, -0.251073, -0.261465, -0.379375, -0.480220, -0.542589, -0.239906, -0.204731, -0.454811, -0.469314, -0.540854, -0.596144, 0.627890, 0.369545, 0.068021, 0.228970, -0.090294, -0.438793, -0.577411, -0.579215, -0.280051, -0.047601, 0.113166, 0.126939, -0.050036, -0.099909, -0.257425, -0.274760, -0.041868, 0.109525, -0.071791, 0.093142, 0.301621, 0.441453, 0.402084, 0.313496, 0.462640, 0.365400, 0.208986, 0.281815, 0.362636, 0.664045, 0.150558, -0.057730, -0.486006, 0.157183, -0.107685, -0.370594, -0.340203, -0.342279, -0.134076, -0.113490, -0.095092, -0.232602, -0.070143, -0.287481, -0.510712, -0.240033, -0.536784, -0.305253, -0.273045, -0.188818, 0.019532, 0.054711, -0.225833, -0.416707, -0.323408, -0.164827, -0.207998, -0.244956, -0.318561, -0.016893, -0.093625, 0.745108, 0.438585, 0.199597, 0.331605, 0.253899, 0.503457, 0.397009, -0.025962, -0.067927, -0.088521, 0.376570, 0.332866, 0.183119, 0.232595, 0.474827, 0.062307, -0.403078, -0.579898, -0.254121, 0.322949, 0.420932, 0.297352, 0.135540, 0.017666, 0.191950, 0.068125, 0.230583, 0.016327, 0.238950, -0.159088, -0.500783, -0.505041, -0.307708, -0.290889, -0.484587, -0.372384, -0.452929, 0.003820, -0.054098, -0.188000, -0.499794, -0.132934, -0.358365, -0.512269, -0.088062, -0.580343, -0.237901, -0.178204, -0.284695, -0.418782, -0.590804, -0.456396, -0.638003, -0.523181, -0.314878, -0.563664, -0.517606, -0.618681, -0.481321, -1.038681, -0.499418, -0.209463, -1.030302, -0.759646, -0.454338, -0.123882, -0.532190, -0.800312, -0.365916, -0.135635, -0.135067, -0.245054, -0.344352, -0.327812, -0.299491, -0.488391, -0.358625, -0.183999, -0.194454, -0.385711, -0.368452, -0.529804, -0.438063, -0.401772, -0.272745, -0.281139, -0.397149, -0.435226, -0.433950, 2.390304, -0.123850, -0.051581, -0.041979, 0.057041, -0.241528, 0.113554, -0.081801, -0.122283, 0.402042, 0.189948, -0.067715, -0.080541, -0.009522, -0.118158, -0.097432, -0.334065, -0.108491, 0.002395, 0.120647, 0.063884, 0.015600, 0.171172, 0.121586, 0.008646, 0.253254, 0.344129, 0.178678, 0.235398, 0.384881, -0.059243, 0.477458, 0.523727, 0.951110, 0.871137, 0.828454, 1.059542, 1.028689, 0.828607, 0.864882, 0.800544, 0.614399, 0.683724, 0.670437, 0.591177, 0.276169, 0.228891, 0.503444, 0.794268, 1.141647, 0.973424, 0.668365, 0.666639, 0.723837, 0.721034, 0.701535, 0.544444, 0.437577, 0.504263, 0.421251, 2.077275, -0.002497, 0.252970, 0.208465, -0.287645, -0.217359, 0.294753, -0.133921, 0.049431, 0.772918, 0.482084, 0.349775, 0.300034, 0.219713, 0.053845, 0.057884, -0.142906, 0.193103, 0.045615, 0.159070, 0.351422, 0.399128, 0.616441, 0.505618, 0.430345, 0.802908, 0.914945, 0.628128, 0.859418, 1.009224, 0.411143, -0.659311, 0.378774, 0.358375, 0.609877, 0.640869, 0.353904, 0.197214, 0.226984, -0.103122, -0.534309, -0.393581, -0.311647, -0.233673, -0.298133, -0.200598, 0.044050, 0.182898, 0.475325, 0.271814, -0.068249, 0.244681, 0.279100, -0.160228, -0.412258, 0.086018, 0.127970, -0.013325, -0.222008, -0.117839, -0.026428, 0.145360, 0.034694, -0.366550, -0.051164, -0.168305, 0.004063, -0.098158, -0.005201, 0.121127, -0.158233, -0.179801, -0.210703, 0.080014, 0.011353, 0.297324, -0.142667, 0.185377, 0.226802, 0.064856, -0.067061, 0.691142, 1.104084, 0.389866, 0.054950, 0.988705, 0.858658, 0.508767, 0.691134, 0.483181, -0.328736, -0.683911, -0.800449, -0.348406, 0.444311, 0.107188, -0.089181, -0.597736, -0.608986, -0.666026, -0.443449, -0.445225, -0.845583, -1.106534, -0.996313, -0.970668, -0.960505, -1.069640, -1.182875, -1.239388, -1.087223, -1.804731, -2.048928, -1.289639, -1.500385, -2.148664, -2.311416, -1.810507, -2.100821, -1.845714, -0.135126, -0.018029, -0.113197, -0.341043, 0.211444, -0.082608, 0.135646, -0.050878, 0.032671, 0.441822, -0.027568, 0.046374, 0.245326, 0.434456, 0.342984, 0.407102, 0.253673, 0.769260, 0.958744, 0.523805, 0.387413, 1.697118, 2.070981, 0.893117, 0.583539, 1.889965, 1.909362, 1.378456, 1.483431, 1.145947, 0.153029, -0.416058, -0.104988, -0.204221, -0.193840, -0.131458, -0.269257, -0.255566, -0.129123, -0.159868, -0.161421, -0.007709, 0.038420, 0.119452, 0.116708, -0.029972, 0.070398, 0.245365, 0.291422, 0.095180, 0.061565, 0.233649, 0.389639, 0.287997, 0.000701, 0.124671, 0.140881, 0.007955, -0.066372, -0.074933, -0.116800, 0.042398, 0.560139, 0.440269, 0.252924, 0.114316, 0.090825, 0.243311, 0.079145, -0.270958, -0.049084, 0.023489, -0.092510, -0.332138, -0.163953, -0.127308, 0.160485, 0.333491, 0.109741, -0.241458, -0.286761, -0.207104, -0.107989, -0.117098, -0.141854, 0.262848, -0.016325, -0.049228, 0.042718, -0.101648, 1.214029, 0.580920, 0.942635, 1.166555, 1.025792, 0.543016, 0.595624, 1.354333, 1.076300, 0.806945, 0.671281, 0.710658, 0.907366, 1.055677, 0.946777, 1.185103, 1.410616, 1.564122, 1.292849, 0.889390, 0.515759, 0.639752, 0.628498, 0.644046, 0.810764, 1.330085, 1.078579, 1.035606, 1.139914, 1.147746, 0.305802, 0.545325, -0.065190, 0.025257, 0.211283, 0.146270, 0.164379, 0.334110, 0.191902, -0.318463, -0.112091, 0.106184, 0.136286, -0.151860, -0.067448, -0.118825, 0.261001, 0.429709, 0.179413, -0.414949, -0.298741, -0.215034, -0.117661, -0.154981, -0.232082, 0.205433, -0.103551, -0.210809, -0.004330, -0.063137, -0.187587, 0.821170, 1.207307, 1.221988, -0.545531, -0.441088, -0.296448, -0.650321, -0.277848, 0.191003, 0.521080, 0.682151, -0.001549, -0.360635, -0.228100, -0.148049, -0.116736, -0.000500, -0.059703, 0.199945, 0.233118, 0.295770, 0.395915, 0.229696, 1.531530, 2.040540, 1.663922, 1.730490, 1.452951, 1.676898, 1.308913, -0.103673, -0.745750, -1.011994, -0.783625, -1.376944, -0.378458, 0.328041, -0.303761, 0.533336, 0.322307, -0.710220, -0.909883, -0.070340, -0.181596, -0.995608, -0.381955, -0.895580, -0.364558, 0.149826, 0.247915, 0.154639, -0.915065, -0.478550, 2.418612, 4.789495, 2.362225, 4.551034, 2.228408, 1.470560, 0.541529, 0.606827, -0.323509, 0.089549, 0.100131, 0.761438, 0.769140, 0.211981, -1.493521, -0.043439, -0.980192, -0.166006, -0.726076, 0.244918, 0.384692, 0.381924, 0.457186, 0.417867, 0.367870, 1.933749, 1.355394, 0.657961, 0.370803, -0.444419, 3.734744, 4.014819, 2.545154, 2.706483, 2.697884, 1.861503, 1.904616, 0.187908, -0.406570, -0.897537, -1.143588, -1.096512, 0.046378, 0.764354, 0.020131, 0.428078, 1.102103, -0.005919, -1.196356, -0.690006, 0.457191, -0.838031, 0.172974, -1.141808, -0.481302, -0.382578, -0.372954, -1.150441, -0.919319, -0.688371, 0.069831, 1.245563, 0.372572, 1.907068, 0.264552, -0.089922, -0.833510, -0.201186, -0.653046, -0.815251, -0.420634, 0.549126, 0.633371, -0.027819, -0.075426, 0.155874, -0.000250, -0.259263, -0.236443, -0.286422, -0.343366, -0.238609, -0.391227, -0.708613, -0.636132, -0.373461, -0.416981, -0.809302, -0.787620, -0.639048, -0.520750, -0.737019, -0.659543, -0.623954, -0.470082, -0.678218, -0.062110, -0.192322, -0.247207, -0.283554, -0.224077, 1.622840, 1.454776, -0.321766, -0.010021, 0.093057, -0.471201, -0.226474, 0.396777, 0.021245, 0.283626, -0.193711, -0.595378, -0.445811, -0.192554, 0.292532, 0.026927, -0.330316, -0.341679, -0.248109, -0.229991, -0.342423, -0.558673, -0.472538, -0.507909, -0.673241, 0.379655, 0.052667, -0.484958, -0.540029, -0.231451, 0.276041, -0.041762, -0.302423, -0.329277, -0.586340, -0.081962, -0.419443, -0.676884, -0.586163, -0.745073, -0.457256, -0.684081, -0.547419, -0.293289, 0.370424, -0.047873, -0.293935, -0.281351, -0.059618, -0.622353, -0.616069, -0.409913, -0.767675, -0.460838, 0.022158, -0.068012, -0.106431, -0.180133, -0.205807, 0.060337, 1.619392, 1.536504, -0.041478, -0.015146, -0.134652, -0.276616, 0.115022, 0.645163, 0.195539, 0.411889, 0.023371, -0.310040, -0.177040, -0.269107, 0.217437, 0.222510, -0.209471, -0.263743, -0.364846, -0.182329, -0.318202, -0.646031, -0.277687, -0.497260, -0.629496, 0.941947, 0.697516, 0.690349, 0.227004, -0.107515, -0.238527, -0.295858, -0.028453, 0.158127, 0.281421, 0.188940, 0.152085, 0.240131, 0.242503, 0.343604, 0.312585, 0.471159, 0.627890, 0.466354, 0.366761, 0.503484, 0.653023, 0.702036, 0.592239, 0.503601, 0.448554, 0.612258, 0.570392, 0.520991, 0.842742, -0.201022, 0.645243, 0.160413, 0.051716, -0.006347, 0.375692, 0.388947, 0.322245, -0.026226, 0.153467, -0.193728, 0.011875, -0.139774, 0.040801, -0.106015, -0.145106, 0.099669, 0.250970, 0.043708, 0.090713, -0.180672, -0.052891, -0.104331, -0.236538, -0.021660, -0.116783, 0.036591, -0.051422, -0.043790, 0.121701, -0.144299, -1.231575, -1.445427, -0.851613, -0.907481, -1.219154, -1.063539, -0.623145, -1.024271, -1.183773, -0.919096, -1.144435, -0.790032, -0.624220, -0.649212, -1.065430, -0.885567, -1.313560, -1.379853, -1.057453, -0.518194, -0.603049, -0.451137, -0.797123, -0.841387, -1.204512, -0.919336, -0.705843, -0.853550, -0.852817, -0.645814, -0.403553, 0.243801, -0.204692, -0.202225, 0.527123, 0.191671, -0.027122, -0.261260, -0.110346, -0.591845, -0.090741, -0.127350, -0.109818, -0.146782, -0.215623, 0.014888, -0.060426, 0.015739, -0.000900, -0.354690, -0.504182, -0.542181, -0.421462, -0.175907, -0.386043, -0.171504, -0.309473, -0.326685, -0.450437, 1.058149, 1.461776, 1.042266, 1.232806, 1.736897, 2.126703, 3.268138, 2.671610, 1.688088, 1.454763, 1.326665, 1.414178, 1.846337, 2.064400, 1.043097, 0.363116, 0.292202, 0.413503, 0.130869, 0.026025, 0.192934, 0.532287, 0.997768, 0.739029, 0.541614, 0.392323, 1.067091, 1.457647, 1.026527, 0.303684, 0.034753, 1.851646, -0.244879, 1.022812, 1.598251, 2.028513, 3.761186, 3.114712, 0.400013, 0.165695, 0.397167, 1.730284, 2.895461, 3.621598, 2.237705, 0.494948, 0.972240, 0.356644, -0.008683, -0.078267, 0.245776, 0.440385, 0.510702, 0.307170, -0.057464, -0.078920, 0.488196, 0.767162, 0.107220, -0.254730, -0.243631, -0.327898, -0.771420, -2.417002, -2.538109, -2.422830, -1.768197, -1.273485, -1.866666, -1.356592, -0.590364, -0.379845, -0.664522, -0.840411, -0.638116, -1.073609, -0.489101, -0.333476, -0.557469, 0.485271, -0.504541, -0.479033, -0.169375, -0.924281, -2.003575, -1.066669, -1.015085, -1.763308, -0.639957, 0.189700, -0.242562, 1.518049, -0.879711, 1.971773, 3.252093, 2.630131, 4.849722, 4.325277, 1.466059, 0.535149, 0.128546, 1.752844, 3.267080, 4.691628, 1.822467, 0.906074, 0.822393, -0.195286, -0.363036, -0.121217, 0.462282, -0.317995, -0.127876, 0.200695, 0.003133, -0.051544, -0.114867, 0.959902, 0.244518, -0.394948, 2.772460, 1.873859, 2.752228, 3.132039, 2.911594, 2.895956, 2.863102, 3.272884, 3.452586, 3.718715, 3.916376, 4.019425, 4.004583, 3.895836, 3.553065, 3.394639, 3.167137, 3.571647, 3.997992, 4.340840, 3.824873, 3.451478, 3.513575, 3.683299, 3.590500, 3.748827, 3.808058, 3.570134, 3.605439, 3.404850, 0.679192, 3.883951, 5.086758, 5.259014, 5.076501, 4.556499, 4.611821, 4.325338, 4.385164, 5.084064, 5.248706, 5.172137, 4.960163, 4.943168, 5.245403, 5.488969, 5.832517, 6.015975, 6.018601, 5.643140, 5.668081, 5.724261, 5.274654, 6.375218, 6.397471, 5.831600, 6.216150, 6.573029, 6.461187, 6.263290, 0.699795, 1.145721, 1.364122, 1.064187, 0.719079, 0.536844, 0.540060, 0.609258, 1.192863, 1.585232, 0.925252, 0.627065, 0.517914, 0.414461, 0.657065, 0.594216, 0.755322, 0.619986, 0.938389, 0.841089, 0.997971, 1.307644, 1.372431, 1.231388, 1.587333, 1.796282, 1.813305, 1.968970, 1.939644, 2.362094, -0.285924, 2.862553, 3.533736, 3.155972, 3.582211, 2.685707, 2.237387, 1.788035, 1.804947, 2.655772, 3.123063, 2.870313, 2.792112, 2.837520, 2.601568, 2.934355, 3.106997, 3.181941, 3.523811, 3.257015, 3.513831, 3.082444, 2.676061, 3.882402, 4.519233, 3.338460, 3.568617, 3.704470, 3.726189, 3.574619, -2.155524, -0.630086, 0.191495, 1.271457, 1.876855, 1.809775, 1.600491, 1.639408, 1.422108, 1.042113, 1.005681, 1.373837, 1.154791, 1.411521, 1.643475, 1.886474, 2.231397, 1.475857, 0.747588, 1.027495, 1.744740, 1.261921, 0.816612, 1.087938, 0.868651, 0.889303, 1.399640, 2.085804, 1.691659, 0.894272, -0.593640, -0.505738, 0.064738, -0.055884, 0.045897, -0.312650, -0.337391, -0.004505, 0.188851, 0.006272, -0.128118, -0.456208, -0.115816, -0.249954, -0.386136, -0.071268, 0.119186, -0.375942, -0.503733, -0.327550, 0.644896, -0.076117, -0.654018, -0.247710, -0.513665, -0.562786, -0.488038, -0.224101, -0.497059, -0.555686, 0.142725, 0.300190, 0.635799, 0.263127, 0.250408, 0.318856, 0.156312, -0.225312, -0.036448, 0.196775, -0.603211, -0.702158, 0.016577, 0.301144, -0.218994, -0.625519, -0.101999, 0.227260, 0.166109, -0.134488, -0.088742, 0.026846, -0.106822, -0.259487, 0.226458, 0.173288, 0.091131, 0.038216, -0.295504, 0.082259, -0.081835, -0.216483, 0.221392, 0.045855, 0.276785, -0.208465, -0.491952, -0.099923, 0.081382, 0.051300, 0.094398, -0.109367, -0.042594, -0.250676, -0.438890, 0.172961, 0.046805, -0.273821, -0.657094, -0.177117, 0.344948, -0.258357, -0.718932, -0.292086, -0.333911, -0.539602, -0.487306, -0.362741, -0.581020, -0.553823, 0.482587, -0.496943, 0.494884, 0.455243, 0.788213, 0.890421, 0.594401, 0.580350, 0.581169, 0.292452, -0.156207, -0.126804, -0.167771, -0.183226, -0.114866, 0.213835, 0.353941, 0.330403, 0.420229, 0.290522, 0.144906, 0.179858, 0.137821, 0.107591, 0.037956, 0.072608, 0.022028, 0.098112, -0.014746, 0.015837, -0.126496, -0.141787, 0.519654, -0.183179, 0.152215, 0.109063, -0.197275, -0.142879, 0.209382, 0.501144, 0.053661, 0.094990, -0.190103, -0.082107, 0.474213, 0.268398, -0.087486, -0.117945, -0.204265, -0.006729, -0.069855, 0.235809, 0.500834, 0.181395, -0.118488, -0.004718, -0.067800, 0.070071, 0.332063, 0.277850, -0.444547, 0.567431, 0.415051, -0.072620, 0.091414, 0.217119, 0.220944, 0.039569, -0.040796, 0.154841, 0.205550, 0.146819, 0.269471, 0.236830, -0.053572, 0.001430, -0.062968, 0.039681, 0.437082, 0.524330, 0.313577, -0.079815, -0.387834, -0.479491, -0.129626, -0.131748, -0.136802, -0.285908, -0.285508, -0.439976, 0.119573, 0.256564, 0.283769, -0.093390, 0.589005, -0.109225, -0.354069, -0.351627, 0.373426, 0.805190, 0.113638, 0.131582, -0.298740, -0.002764, 0.733852, 0.533585, 0.087335, 0.259371, -0.063061, -0.022511, 0.290760, 0.815485, 0.936147, 0.528673, 0.168430, 0.229250, 0.273001, 0.424489, 0.652648, 0.684871, -0.868966, -0.028828, -0.039943, -0.625823, -0.431696, -0.140935, 0.041310, -0.262702, -0.472234, -0.239481, -0.133935, 0.035433, 0.124773, 0.068785, 0.048731, -0.079094, -0.266207, -0.175293, 0.016706, 0.015082, -0.106415, -0.296225, -0.284904, -0.174343, -0.078412, 0.106738, 0.048700, -0.029113, 0.120299, -0.098945, 1.828707, -0.713477, 0.031588, -0.309974, -0.387322, -0.246769, -0.207336, -0.182306, -0.198910, 0.064345, 0.103385, 0.064919, 0.236476, -0.162574, -0.073894, -0.020742, -0.281242, -0.245539, -0.084674, -0.079525, -0.151112, -0.098533, 0.147025, 0.159704, -0.244989, -0.058488, 0.323050, 0.033501, 0.018786, 0.250113, -0.952691, -0.283849, -0.073208, -0.062238, 0.086599, -0.068303, 0.029762, 0.208329, 0.045370, 0.056857, -0.297716, -0.496589, -0.612035, -0.248441, -0.085003, 0.088413, 0.043779, 0.260963, 0.172436, -0.454430, -0.263628, -0.170095, -0.238599, -0.531255, -0.507584, -0.275738, -0.379749, -0.177875, -0.149491, -0.104115, 1.962362, -0.318663, 0.324214, -0.182589, -0.642926, -0.517760, -0.203419, -0.102769, -0.164394, 0.319846, 0.525106, 0.559969, 0.762623, -0.190649, -0.058637, 0.016230, -0.085403, -0.118605, 0.154558, 0.169151, 0.164529, 0.232415, 0.647688, 0.290923, -0.118349, 0.144964, 0.869429, 0.536972, 0.247799, 0.807006, 0.930824, 1.596760, 1.780761, 1.343851, 1.366769, 1.300243, 1.616519, 1.541743, 0.839189, 1.189816, 1.402649, 0.709552, 1.092301, 1.056246, 1.452901, 1.401710, 0.796409, 1.115696, 1.039965, 0.627282, 0.749840, 1.509005, 1.253834, 0.776512, 0.422994, 0.475928, 0.840375, 0.659138, 0.522200, 0.498457, 1.017680, 1.336799, 1.920337, 4.182936, 5.322368, 4.999669, 3.829620, 5.097088, 6.321349, 4.897043, 5.111381, 7.759049, 6.772018, 5.943865, 5.495717, 4.942505, 4.971449, 5.886248, 5.934160, 4.112142, 5.128646, 4.232469, 3.336005, 4.006065, 6.018604, 5.830712, 4.472160, 4.586661, 4.747110, 4.462206, 4.605083, 3.214455, 2.800483, 4.482666, 4.749032, 3.906105, 3.273691, 3.859636, 4.175592, 5.302110, 4.783742, 4.687567, 5.132027, 4.788462, 4.850633, 5.013764, 4.933056, 4.731033, 4.334004, 4.250690, 5.857607, 5.025588, 4.132030, 5.504879, 6.777788, 6.405113, 6.300520, 7.068489, 7.149630, 5.706163, 1.592301, 0.263192, 0.550045, 2.266872, 2.386007, 2.194664, 0.972727, 2.165479, 3.393273, 2.589417, 2.032522, 3.747278, 3.358046, 2.597088, 1.760627, 3.476576, 3.348488, 3.247576, 3.781000, 2.472950, 3.407652, 1.861878, 1.222508, 1.807504, 4.081100, 3.267564, 2.931182, 4.233442, 3.677367, 3.221248, 4.192191, 4.833302, 5.898647, 6.344396, 5.977052, 5.904375, 6.081346, 6.744917, 6.752697, 7.207149, 7.495445, 7.397307, 7.310296, 7.280112, 7.066627, 6.712478, 6.181924, 6.436316, 7.097273, 7.379046, 6.976422, 6.548707, 6.469547, 6.660542, 6.766175, 7.073085, 7.034511, 6.735598, 6.825139, 6.649709, -0.404973, 2.120066, 2.428940, 1.553590, 1.853087, 2.629297, 2.452176, 2.077475, 1.967140, 2.697357, 2.710010, 2.439821, 2.656828, 2.225615, 2.149306, 3.015474, 3.016697, 3.277268, 3.738899, 3.201352, 2.806653, 2.180241, 2.407060, 3.159414, 3.358248, 3.032014, 2.970646, 3.121470, 2.964532, 2.987813, -0.319978, 1.634761, 1.039019, 0.660882, 0.373755, 1.445556, 1.139578, 0.481242, -0.077554, 0.212036, 0.090616, 0.036736, 0.041384, -0.233086, -0.303107, 0.169900, 0.903468, 0.871146, -0.157240, -0.255871, 0.689299, 1.477360, 1.244817, 1.355790, 1.787337, 1.224964, 1.039251, 0.341297, 0.331681, 0.153381, -0.243522, 1.732055, 1.568565, 0.204685, -0.367760, -0.195494, -0.207450, -0.081015, 0.270381, 0.580591, 0.303046, 0.161550, 0.408632, 0.338156, 0.618277, 0.300890, 0.403007, 0.201360, 0.568349, 0.326351, 0.903329, 0.474163, 0.118141, 1.037468, 0.914987, 0.243622, 0.318394, 0.492612, 0.924261, 1.077288, 0.643437, 0.599948, -0.107810, 0.504394, 0.177877, -0.137860, 0.527334, 0.787359, 0.635631, 0.630566, 1.022277, 0.764257, 0.321442, 0.244289, 0.056427, 0.170689, 0.099484, -0.034182, 0.280723, 0.537789, 0.609034, 0.531845, 0.622408, 0.488963, 0.265514, 0.404264, 0.590710, 0.122601, -0.121262, -0.225081, -1.419904, -0.062017, 3.316544, 2.820008, 5.889469, 6.340203, 3.934795, 6.570343, 6.518847, 4.025242, 2.880941, 3.880301, 4.381076, 3.454925, 3.194130, 2.590722, 2.550593, 3.056556, 4.053070, 3.673558, 2.670546, 2.335938, 1.785252, 2.061045, 1.546619, 1.035134, 1.328674, 1.151226, 0.846556, 0.877012, -0.873251, 2.512652, 3.398460, 2.499197, 3.257659, 3.131607, 1.651494, 1.573497, 1.447123, 0.479364, 0.738343, 1.738552, 2.674163, 1.376048, 0.660252, 0.375742, -0.653098, 0.965734, 2.068938, 2.626816, 1.624345, 0.896396, 1.481723, 1.444920, 0.970880, 0.503248, -1.268747, 1.153372, 0.279190, -1.347388, -0.375959, -0.112943, 1.048843, 0.945221, 3.124149, 3.553491, 2.112502, 5.516500, 5.237539, 3.177648, 2.141902, 2.353346, 2.633716, 2.215720, 3.093567, 2.348203, 3.234307, 2.404231, 2.593698, 2.221906, 2.602609, 2.536623, 1.108762, 1.543042, 1.499480, 1.054201, 1.659636, 1.328730, 0.810274, 1.774054, 4.129199, 4.919794, 6.010164, 6.601538, 6.282850, 6.231614, 6.432376, 7.112019, 7.356920, 7.586763, 7.946781, 8.070171, 7.744592, 7.775889, 7.531152, 6.955324, 6.388755, 6.803444, 7.437959, 7.596616, 7.103874, 6.737163, 6.853117, 7.135864, 7.105759, 7.348835, 7.383281, 7.114671, 7.185837, 6.919884, -0.542363, 1.051761, 1.517452, 1.397365, 1.364115, 1.630008, 1.399755, 1.529259, 1.224635, 1.269675, 1.520131, 1.504449, 1.573255, 1.686488, 1.423537, 1.888628, 2.008171, 2.009436, 2.169101, 2.082054, 2.291095, 1.925256, 1.844785, 2.330306, 2.180359, 1.913180, 1.975050, 2.361451, 2.158110, 2.100197, 0.168251, 0.612608, 1.352497, 0.313780, -0.308931, -0.147380, -0.052452, -0.000821, -0.019908, -0.388269, -0.610277, -0.591973, 0.102028, 0.319156, -0.133932, 0.043551, -0.170978, 0.369071, 0.382085, -0.276450, -0.404342, -0.095500, 0.148311, -0.142805, -0.131804, -0.008320, -0.249225, -0.295115, -0.098042, -0.357332, -0.161785, 0.898760, 1.432737, 0.772486, 0.976776, 0.824003, 0.681562, 0.638655, 0.343171, 0.298748, 0.500219, 0.883759, 0.663344, 0.698529, 0.317337, 0.986143, 1.220008, 1.287118, 0.992246, 1.130733, 1.178099, 0.953450, 0.797191, 1.107883, 1.441565, 0.843179, 0.875037, 1.320037, 1.214337, 1.169254, 0.486569, -0.531489, 0.348216, 0.397400, 0.534061, 0.499761, 0.275655, 0.186493, 0.202410, -0.057941, -0.433492, -0.420703, -0.383942, -0.290206, -0.289214, -0.070961, 0.146969, 0.191629, 0.375136, 0.239048, -0.070681, 0.139218, 0.107555, -0.061042, -0.162370, 0.023198, 0.005896, -0.064259, -0.186629, -0.134024, -0.351645, -0.136185, -0.113238, -0.233264, 0.095080, 0.016388, -0.028942, -0.200494, -0.048477, 0.017074, -0.172390, -0.098545, -0.067608, -0.049861, -0.097643, -0.074193, -0.004541, 0.281760, 0.074892, -0.087356, -0.158375, 0.235799, 0.588149, 0.268586, 0.010352, 0.406589, 0.329121, 0.176225, 0.275076, 0.347971, -0.528982, 0.046188, 0.053635, -0.559435, -0.507008, 0.115204, 0.009528, -0.376749, -0.622456, -0.576112, -0.584913, -0.368386, -0.227272, -0.317163, -0.125182, -0.383761, -0.780891, -0.721818, -0.418869, -0.227665, -0.361927, -0.599482, -0.773708, -0.739813, -0.641748, -0.667059, -0.876805, -0.600094, -0.698551, -0.613151, 0.003805, -0.189489, -0.226584, 0.149960, 0.566457, 0.229730, -0.032702, -0.068377, 0.065081, 0.215457, -0.059085, 0.182103, -0.028172, -0.087760, 0.047894, -0.042868, 0.167871, 0.659801, 0.383908, 0.129618, 0.265583, 0.899547, 1.094974, 0.772563, 0.238557, 0.794745, 0.860549, 0.684377, 0.802185, 0.896557, 1.016120, 1.131804, 0.892321, 0.537362, 0.397705, 0.320287, 0.372318, 0.231031, 0.032906, 0.300578, 0.359002, 0.139558, 0.139488, 0.081365, 0.301776, 0.284920, 0.221112, 0.300424, 0.248221, 0.426759, 0.409240, 0.456044, 0.514673, 0.348092, 0.294713, 0.235483, 0.445906, 0.537429, 0.459067, 0.409341, 0.014701, 0.724989, -0.419684, 0.056231, 0.523415, -0.025705, -0.253596, -0.268117, 0.109017, 0.010026, 0.060508, 0.238705, 0.508767, 0.206056, 0.093070, 0.129840, 0.051975, -0.027825, -0.199022, 0.262952, 0.124964, 0.217099, 0.087400, -0.082110, 0.029071, -0.169057, -0.108354, -0.149928, -0.181642, -0.063916, 0.073942, 0.291923, 0.244739, 0.165197, 0.507756, 0.703956, 0.443879, -0.245403, -0.570383, -0.439550, -0.025758, -0.012088, 0.367178, 0.300915, -0.254848, -0.543776, -0.366994, -0.185016, 0.165283, -0.109690, 0.250543, 0.269629, 0.053108, 0.185193, 0.219863, 0.024802, 0.092817, 0.082179, 0.128066, -0.169879, -0.479070, 0.194595, -0.374821, 0.112132, 0.571774, -0.088782, -0.229318, -0.376563, -0.002008, 0.064433, 0.195198, 0.341396, 0.621928, 0.281007, -0.015583, 0.218256, 0.048540, -0.116343, -0.045252, 0.182956, -0.044086, -0.279819, -0.373950, -0.278746, -0.107018, -0.201915, -0.358186, -0.513003, -0.444239, -0.304069, 0.438953, -0.637496, -0.973478, -0.580338, -0.823488, -0.866413, -0.854957, -0.685010, -0.674932, -0.659529, -0.386148, -0.177835, -0.160677, -0.342832, -0.289750, -0.580450, -0.506769, -0.244756, -0.339557, -0.602776, -0.588496, -0.472334, -0.182590, -0.378781, -0.641431, -0.336865, -0.537910, -0.530306, -0.540380, -0.595677, -0.609830, 0.603967, 0.091209, 0.272117, -0.396689, -0.281979, -0.217043, -0.212471, -0.314121, -0.281183, -0.171100, -0.089954, -0.315381, -0.394355, -0.234621, 0.095533, 0.032880, -0.071724, 0.113550, -0.174567, -0.216297, 0.058380, 0.427974, 0.137220, -0.268654, 0.386182, 0.055060, 0.049627, 0.011952, -0.113501, -0.521987, -0.642776, -0.122590, -0.128134, 0.335670, 0.330480, 0.127075, 0.493491, 0.273414, 0.446122, 0.395077, 0.255931, -0.083049, 0.126051, 0.200688, -0.310745, 0.242941, -0.027181, -0.317909, -0.106261, -0.389375, -0.569583, -0.847795, -0.698625, -0.466254, -0.492761, -0.801809, -0.815447, -0.629969, -0.447497, -0.131104, 1.110005, 0.159716, 0.219950, -0.151769, -0.062582, -0.029019, -0.415737, -0.352351, -0.347511, -0.159050, -0.333231, -0.609428, -0.350835, -0.178159, 0.407662, 0.171279, 0.197943, 0.431280, -0.106098, -0.047113, 0.690277, 1.004647, 0.478567, -0.165986, 0.924673, 0.567597, 0.523806, 0.639972, 0.262559, -1.028230, 0.049091, 0.073360, -0.714522, -0.415242, -0.028392, 0.167686, 0.074588, -0.050918, -0.062506, 0.048574, 0.276809, 0.319091, 0.261647, 0.159204, -0.020886, -0.213338, 0.015996, 0.101667, -0.062132, -0.125117, -0.422420, -0.433152, -0.248829, -0.052001, 0.100803, -0.063167, -0.170268, 0.021674, -0.203742, 1.780896, -0.913740, -0.133162, -0.393578, -0.093513, -0.087443, 0.058252, 0.361494, 0.225079, -0.193279, -0.234965, -0.181994, -0.138685, -0.251197, -0.217497, -0.020164, -0.311350, -0.449694, -0.265845, -0.047137, -0.122123, -0.313239, -0.009203, 0.007008, -0.148837, -0.050126, 0.230075, 0.015928, 0.081387, 0.065718, 0.201023, -0.073145, -0.225617, -1.056244, -1.059597, -0.419085, -0.331415, -0.248059, -0.310289, -0.432335, -0.395837, -0.316761, 0.003643, -0.022454, -0.003411, -0.584379, -0.550871, -0.474017, -0.251507, -0.303847, -0.248384, -0.165926, -0.434147, -0.077843, -0.123477, -0.242869, -0.120663, -0.055522, -0.173964, -0.355677, 1.275443, -0.447181, -0.125353, -0.005801, 0.164249, 0.042098, 0.359038, 0.325932, 0.096725, -0.106814, -0.108110, 0.097542, 0.065234, 0.045044, 0.061414, 0.003552, -0.092344, -0.387831, -0.174804, -0.095642, -0.172213, -0.079599, 0.335570, 0.337801, -0.043767, 0.305927, 0.774469, 0.403604, 0.452422, 0.519518, 0.575987, 0.257846, 0.089431, 0.109902, -0.209237, -0.408730, -0.509746, -0.549483, -0.328939, -0.085182, -0.129515, -0.124540, -0.046299, -0.090248, -0.300026, -0.302649, -0.064155, 0.084560, -0.045941, 0.016441, 0.156549, 0.307604, 0.464782, 0.265963, 0.300310, 0.364213, 0.251826, 0.297150, 0.212271, 0.339042, -0.432538, 0.052153, 0.061683, 0.060775, 0.013946, 0.144507, 0.369669, 0.150490, 0.294921, 0.178597, 0.770681, 0.487386, -0.124294, 0.101835, 0.078787, -0.277823, -0.328293, -0.013714, 0.048155, 0.042287, 0.099956, 0.184490, -0.193675, -0.146930, -0.125493, 0.111957, -0.123506, 0.070136, -0.145543, 0.056909, -0.656082, -0.787830, -1.118615, -1.260993, -0.791057, -0.627179, -0.746292, -1.485677, -1.607004, -1.327027, -1.308505, -1.689482, -1.216410, -1.492279, -0.979923, -0.859598, -0.742144, -0.731028, -0.816733, -0.838260, -0.721769, -0.816908, -0.384670, -0.225215, -0.713503, -0.870860, -0.958910, -1.091582, -0.800548, -0.440756, -0.560160, -0.120192, 0.246276, -0.165877, 0.088932, 0.054361, 0.507061, 0.772763, 0.633532, 0.275109, 0.819077, 0.341603, -0.244050, 0.128300, 0.081375, -0.016896, -0.382902, 0.006667, -0.016279, -0.042736, 0.040787, -0.260608, -0.407267, -0.502502, -0.251139, -0.058895, -0.202684, -0.176841, -0.259259, -0.230301, -1.024134, -0.530445, 0.359050, 1.197154, 1.826440, 1.667656, 1.541963, 1.587215, 1.479017, 1.137820, 0.986867, 1.262292, 1.186791, 1.453206, 1.687912, 2.083808, 2.339135, 1.515847, 0.770048, 0.948197, 1.768477, 1.371591, 0.871637, 1.043421, 0.801305, 1.008380, 1.422532, 1.994063, 1.616215, 0.968188, 0.462634, -0.143332, -0.091042, -0.262428, -0.213065, -0.230381, -0.317863, -0.615787, -0.369372, -0.289498, -0.555883, -0.444873, -0.449982, -0.239423, -0.311348, -0.357147, -0.298215, -0.567049, -0.353710, -0.413463, 0.834646, -0.189669, -0.737568, -0.222006, -0.342232, -0.585114, -0.425858, -0.260751, -0.489805, -0.548715, 1.325795, 1.108775, 0.406866, 0.566857, 0.855967, 0.826194, 0.342048, 0.202932, 0.258219, 0.288948, 0.162047, -0.149037, -0.010439, 0.232977, 0.331677, 0.191763, -0.107250, -0.020888, 0.267685, 0.445577, 0.583599, 0.413322, 0.379482, 0.329041, 0.582380, 0.403916, 0.036374, 0.092188, 0.128258, 0.272957, 1.130689, 0.237751, -0.080911, -0.302530, 0.147221, 0.025792, -0.459598, -0.738195, -0.275975, -0.289995, -0.470741, -0.271021, -0.342254, -0.037562, -0.290153, -0.106499, -0.231397, -0.517362, -0.519901, -0.252556, 0.338285, -0.508978, -0.798086, -0.450367, -0.276611, -0.558427, -0.502156, -0.341427, -0.599196, -0.668589, -0.622353, -1.222168, -1.415979, -0.925121, -0.788956, -0.664287, -0.676057, -0.545321, -0.640527, -0.817275, -0.627886, -0.649410, -0.785921, -0.656893, -0.732792, -1.095585, -1.209192, -1.068246, -0.834153, -0.714436, -0.879488, -1.095881, -1.114426, -1.064129, -1.042931, -1.046523, -1.186113, -1.087008, -1.090383, -1.188611, -0.506716, 0.089454, 0.105350, 0.132637, -0.204530, -0.114432, -0.294075, -0.111643, -0.267340, -0.276734, -0.052873, -0.046882, -0.397675, -0.144599, -0.294350, -0.256233, -0.342395, -0.427480, -0.284388, -0.257037, -0.337262, -0.544265, -0.603422, -0.324070, -0.290512, -0.520067, -0.523610, -0.419172, -0.471459, -0.582544, -0.442265, -0.935810, -0.726816, -0.433271, -0.669582, -0.484347, -0.316262, -0.431288, -0.710452, -1.000663, -0.871925, -0.604874, -0.492346, -0.501565, -0.374612, -0.519427, -0.509340, -0.686195, -0.874178, -0.494082, -0.521146, -0.604352, -0.394788, -0.465649, -0.849092, -0.765486, -0.533881, -0.509044, -0.611327, -0.593163, -0.380910, 0.009646, -0.016834, 0.349118, -0.256699, -0.036807, -0.301516, -0.257607, -0.422007, -0.178473, 0.153087, -0.000596, -0.358437, -0.287957, -0.409573, -0.259667, -0.399585, -0.629419, -0.453778, -0.427443, -0.396606, -0.548621, -0.519866, -0.381629, -0.296254, -0.583225, -0.574828, -0.431075, -0.532304, -0.732267, 0.251219, 0.238682, -0.824779, -0.358945, -0.591534, -0.590406, -0.385241, -0.287328, -0.254968, -0.253037, -0.154008, -0.267073, -0.318525, -0.347960, -0.316732, -0.466831, -0.553681, -0.568571, -0.616970, -0.583934, -0.421981, -0.465730, -0.374235, -0.327073, -0.332288, -0.360883, -0.414630, -0.541934, -0.645310, -0.579419, -0.801080, -0.424968, -0.457009, 0.091310, 0.150720, 0.012509, 0.391469, 0.305379, -0.280478, -0.235693, -0.189555, 0.105229, -0.386007, -0.345324, -0.383964, -0.194127, -0.062478, -0.201209, -0.284322, -0.155615, -0.250064, -0.323917, -0.275503, -0.115269, -0.294234, 0.075462, 0.053550, 0.091368, -0.072884, 0.131009, 0.219276, -0.550141, 0.794091, 1.250186, 1.376454, 1.637649, 1.784560, 1.513945, 1.195222, 0.930533, 0.321271, 0.667149, 0.988102, 0.730976, 0.517907, 0.996336, 1.100362, 1.287119, 0.885902, 1.242503, 0.809943, 0.907095, 1.034520, 1.039547, 1.166497, 1.477515, 1.547689, 1.497003, 1.515641, 1.784236, -0.091698, -0.103495, -0.383317, 0.288095, 0.106355, 0.209771, 0.858847, 0.667727, 0.109864, 0.035511, -0.172839, 0.151278, -0.278913, 0.042458, -0.438820, -0.374918, 0.124578, 0.003872, -0.101634, 0.248394, 0.222196, 0.112637, 0.113143, -0.070154, -0.168843, 0.475170, 0.369003, 0.435263, 0.233775, 0.574975, -1.172973, -0.145171, -0.165781, -1.004021, -0.721209, -0.295777, -0.171346, -0.527724, -0.780835, -0.482199, -0.283773, -0.225050, -0.080055, -0.158680, -0.153848, -0.045875, -0.136692, -0.091041, 0.103300, 0.204991, 0.263551, 0.137067, -0.101261, 0.085984, 0.379953, 0.411742, 0.331105, 0.323954, 0.302710, 0.102801, 1.506706, -0.868808, -0.447910, -0.366850, -0.040445, -0.469314, 0.011029, -0.133849, -0.497213, -0.301083, -0.329576, 0.235857, 0.115265, 0.006082, -0.240349, 0.220172, 0.495519, 0.318298, 0.838511, 1.600807, 1.702376, 1.537359, 1.795525, 1.496790, 2.459606, 1.834512, 1.260236, 1.512763, 1.575618, 0.935870, 0.230450, 0.036015, 0.491960, 0.166781, 0.361856, 0.457924, 0.404057, -0.295360, -0.594967, 0.224999, 0.509560, 1.455193, 0.449785, -0.078436, -0.274724, 0.268887, -0.082030, 0.061933, 0.346856, 0.302937, -0.026260, -0.242072, -0.107854, 0.036563, 0.297848, 0.229337, 0.096473, -0.286859, -0.164513, -0.249492, 1.097086, -0.774688, -0.479475, -0.000796, -0.114988, 0.099886, 0.357505, -0.226545, -0.613488, -0.398618, -0.043416, 0.884429, 0.688976, 0.034022, -0.364130, -0.548539, 0.585708, 0.099185, 0.728858, 1.119844, 1.286941, 0.994727, 1.224075, 1.159248, 2.002341, 1.315374, 0.664534, 1.255470, 1.372699, 0.806632, 0.861558, 0.749135, 0.492969, 0.412297, -0.161993, -0.374908, -0.332568, -0.142344, 0.121518, 0.268772, 0.032252, 0.090304, 0.250560, 0.271012, 0.252934, 0.224355, 0.290751, 0.525684, 0.380684, 0.378605, 0.330917, 0.556831, 0.729733, 0.680872, 0.630430, 0.442904, 0.392969, 0.568590, 0.645579, 0.906882, -0.078567, 0.360156, -0.549616, -0.308764, -0.227971, -0.031824, -0.376221, -0.138641, -0.100817, 0.102685, -0.332181, -0.254201, -0.189760, -0.131328, -0.136567, -0.094097, -0.136507, 0.050607, -0.188498, -0.157550, -0.395070, -0.156449, -0.257824, -0.336101, -0.032117, -0.375523, -0.358222, -0.134857, -0.202394, -0.043901, 0.569668, -0.409720, -0.569258, -0.083692, -0.286088, -0.352751, -0.179253, -0.109928, 0.129164, 0.255438, 0.127939, -0.313662, -0.478722, -0.478566, -0.288349, 0.063821, 0.187209, 0.138040, -0.138716, 0.082672, 0.219909, -0.056053, -0.097365, -0.192560, -0.216857, -0.239664, -0.147583, -0.471612, -0.403011, 0.008433, -0.671433, -0.790424, -0.357922, -0.288362, -0.240807, -0.052444, -0.450653, -0.193949, 0.027120, -0.042241, -0.313479, -0.313038, -0.235274, -0.165386, -0.417542, -0.303576, -0.418264, -0.250350, -0.319198, -0.213966, -0.507650, -0.520338, -0.600478, -0.510885, -0.210762, -0.559438, -0.572037, -0.387047, -0.556773, -0.489720, 0.964577, 1.247924, 1.176563, 0.867380, 0.671675, 0.806999, 0.847768, 0.575852, 0.178689, 0.518221, 0.710228, 0.225519, 0.241037, 0.119530, 0.234485, 0.314285, 0.151191, 0.132562, 0.151455, 0.124145, 0.013425, 0.241434, 0.209047, -0.004104, 0.044552, -0.063307, 0.295308, 0.373890, 0.212883, -0.038663, -0.168428, 0.924452, -0.776404, -0.661066, 0.287273, -0.208670, 0.054066, -0.075500, -0.170311, -0.515431, -0.020107, 0.141140, 0.203914, 0.174312, 0.303564, 0.145432, -0.246201, -0.120929, -0.331042, 0.110666, 0.042821, 0.353748, 0.252163, -0.072937, -0.179491, -0.189026, 0.200352, 0.102237, -0.078748, -0.162113, 0.266968, 0.172980, -0.762603, -1.086107, -0.882463, -0.627767, -0.846275, -1.201680, -0.675843, -0.212257, -0.199001, -1.037036, -1.089440, -0.942017, -0.465805, -0.284380, -0.295732, -0.471466, -1.019647, -1.237165, -0.662870, -0.238262, -0.275199, -0.766850, -0.990690, -0.671326, -0.325033, -0.575239, -0.702846, -0.678081, -0.682045, 0.436963, -0.690824, -0.467145, 0.143072, -0.431144, -0.302393, -0.264623, -0.342299, -0.812593, -0.311781, 0.077803, 0.060116, -0.129756, 0.364403, -0.065539, -0.298937, -0.617931, -0.724578, -0.067646, -0.221934, -0.110773, -0.348637, -0.341909, -0.529215, -0.383849, -0.176626, -0.313168, -0.449008, -0.519789, 0.925914, 0.794651, 0.661497, 0.391665, -0.103835, -0.206424, -0.174397, 0.082936, 0.263053, 0.280746, -0.008829, 0.057336, 0.229166, 0.324333, 0.370668, 0.371229, 0.444239, 0.684034, 0.528264, 0.507703, 0.462465, 0.595027, 0.828263, 0.773400, 0.705634, 0.509832, 0.532628, 0.609969, 0.636135, 0.868180, -0.097915, 0.264717, -0.488800, -0.157413, -0.113696, -0.073493, -0.190429, 0.013227, -0.029710, 0.079381, -0.235911, 0.126622, -0.156302, -0.216231, 0.017498, -0.056552, -0.065989, 0.119920, -0.140599, -0.037171, -0.150651, -0.043050, -0.299295, -0.283298, -0.001348, -0.301223, -0.216804, 0.021883, -0.092624, 0.067040, 0.010209, 0.016193, 0.426999, 0.309588, 0.379804, 0.557329, 0.512279, 0.267708, 0.225487, 0.323575, 0.423061, 0.480985, 0.567654, 0.649894, 0.375223, 0.622057, 0.624795, 0.625553, 0.740668, 0.729350, 0.704477, 0.703358, 0.554717, 0.510713, 0.285585, 0.655241, 0.714251, 0.688965, 0.574066, 0.525171, -0.835505, -0.676312, -0.322053, -0.180410, 0.016261, -0.148248, -0.354437, -0.160395, -0.111604, 0.046760, -0.199664, 0.064022, -0.266102, -0.409638, -0.210377, -0.211637, -0.255812, -0.062530, -0.243528, -0.014253, -0.345935, -0.433833, -0.580013, -0.536847, -0.202103, -0.530630, -0.482390, -0.347655, -0.437928, -0.481141, 0.353031, 0.189566, -0.602479, -0.102843, -0.283552, -0.283009, -0.035349, 0.195041, 0.221258, 0.160306, 0.146243, 0.090762, -0.053042, -0.073546, 0.039586, -0.081184, -0.188188, -0.332914, -0.279458, -0.206131, -0.176892, -0.181864, -0.127225, -0.094846, -0.139917, -0.128301, -0.215557, -0.388974, -0.450520, -0.421412, -0.679800, -0.479799, -0.153868, -0.099070, -0.507416, -0.317755, -0.331459, -0.328365, -0.121340, -0.163657, -0.407039, -0.250538, -0.007077, -0.163471, -0.154093, -0.260475, -0.153362, -0.335757, -0.323381, -0.222457, -0.222076, -0.258625, -0.155020, -0.216099, -0.328413, 0.008434, -0.040022, -0.161006, -0.224855, -0.097357, 0.641208, 0.680131, -0.255123, -0.214549, 0.093327, 0.128891, -0.207603, -0.163928, 0.358609, 0.213264, 0.187116, 0.631282, 0.434942, -0.113248, 0.380619, 0.156201, -0.137404, 0.000467, -0.046006, -0.073420, -0.060363, -0.231126, -0.237053, -0.143805, -0.135869, -0.333159, -0.136122, -0.105408, -0.075109, -0.160869, 0.357411, -0.234885, 0.022843, -0.162635, -0.483625, -0.351840, -0.373922, -0.290582, -0.113641, -0.182735, -0.238347, -0.407042, 0.042366, 0.022667, -0.005405, -0.110670, 0.057485, -0.332071, -0.225117, -0.177730, -0.022007, 0.073025, 0.295018, -0.078439, -0.383296, 0.233971, 0.136573, 0.109207, -0.009212, 0.259493, 0.974751, 0.851328, 0.558906, 0.375176, 0.354338, 0.196927, 0.275902, 0.259443, 0.243667, 0.393870, 0.210295, 0.072263, 0.195296, -0.005365, 0.149820, 0.177640, 0.100888, -0.030437, -0.066211, 0.131035, 0.180049, 0.326411, 0.447782, 0.291701, 0.276043, 0.071447, 0.259567, 0.333557, 0.232423, 0.064433, -0.292506, 0.504937, -0.338245, 0.351416, 0.620367, 1.023908, 0.988828, 0.599126, 1.251482, 0.830409, 0.257819, 0.065143, 0.528812, 0.317174, 0.015078, -0.014101, -0.084612, 0.051529, 0.316263, 0.175257, -0.195750, 0.286404, 0.342854, 0.062433, -0.145846, 0.187237, 0.483419, 0.308494, 0.215164, 0.256828, -0.001813, 0.256825, 0.527182, 0.139130, 0.631026, 1.065073, 1.752903, 1.749133, 2.209370, 2.033002, 1.623274, 1.279915, 1.010850, 0.959257, 0.755930, 0.846047, 0.642806, 0.639852, 0.276722, 0.655941, 0.320295, 0.142935, 0.474688, 0.602578, 0.678789, 0.872267, 0.986082, 1.182944, 0.952490, 0.617083, -0.539644, -0.193953, -0.361589, 0.182237, 0.423932, 0.944082, 0.949127, 0.310629, 0.683859, 0.417967, 0.478600, 0.361852, 0.413124, 0.088880, -0.239294, -0.141233, -0.363893, -0.178787, 0.152731, -0.157030, -0.318810, 0.029120, -0.047485, -0.339025, -0.117514, 0.059199, 0.186730, 0.102628, 0.220015, 0.040694, 1.215772, 1.748864, 1.207896, 1.262588, 1.298882, 2.652775, 3.194477, 2.065194, 2.831760, 1.893695, 1.037794, 0.505704, 1.102766, 1.168216, 1.671986, 2.361287, 2.031829, 1.140348, 0.279388, 0.709228, 0.785199, 1.278204, 1.491624, 0.671287, 0.426312, 0.375848, 1.444183, 2.570953, 1.590098, 0.428503, -1.131979, 1.308229, -0.678760, 1.385377, 1.201425, 3.100153, 3.676015, 1.325314, 3.500203, 0.966025, -0.321375, -0.287403, 0.570606, 0.561986, 0.484032, 2.470743, 3.410867, 1.957988, -0.438854, -0.219437, -0.583454, 0.628999, 0.646919, 0.132800, 0.013472, -0.696560, 0.071473, 1.094538, -0.040190, -0.497157, 1.235215, 0.043392, -0.151948, -1.417319, -1.762798, -0.896123, -1.211038, -1.358361, -2.528753, -1.736549, -0.476371, -0.449429, -1.621880, -1.986614, -1.237950, -2.119100, -4.287399, -3.262480, 0.063043, -1.324983, -0.597676, -2.552546, -1.767824, -0.811559, -0.869817, -1.001324, -1.748898, -2.970311, -1.156441, 0.327761, -0.988822, -0.157114, -1.044580, 1.830227, 0.999089, 4.076105, 5.243339, 0.719891, 0.159404, -0.589121, 0.420518, 0.078631, -0.272806, 0.625362, -0.263937, 0.579695, 3.542375, 2.458314, -0.429607, 0.090179, -0.397029, 0.700562, 0.048312, 0.417635, -0.101248, -1.201965, -0.575394, 0.690662, -0.091023, -1.024027, -0.974214, 0.042056, 0.089284, -0.635115, -0.342797, -0.033649, 0.019297, -0.122024, -0.248135, -0.062687, 0.017627, 0.092059, 0.206089, 0.267760, 0.081436, -0.033467, -0.244508, -0.090338, 0.084600, 0.003511, -0.134267, -0.324269, -0.325416, -0.261993, -0.054992, 0.083917, -0.044148, -0.138136, 0.083059, -0.162743, 1.530290, -0.892171, -0.082946, -0.472302, -0.171251, -0.187104, -0.170558, -0.519006, -0.500073, -0.174635, -0.095714, -0.172156, -0.168301, -0.275864, -0.180151, -0.140429, -0.486018, -0.408480, -0.166642, -0.199136, -0.218466, -0.391212, -0.095736, -0.042607, -0.235892, -0.096353, 0.170296, 0.038504, 0.067892, 0.001063, -0.042116, 0.098792, 0.308656, 0.516970, 0.593406, 0.424219, 0.333979, 0.359372, 0.159079, 0.048332, 0.341926, 0.472564, 0.486680, 0.308304, 0.318097, 0.207959, 0.308459, 0.308321, 0.124721, 0.217063, 0.395535, 0.202529, -0.021879, 0.262923, 0.117372, 0.188112, 0.257999, 0.303049, 0.269174, 0.072064, 1.510961, -0.307543, 0.073679, -0.164721, -0.089305, -0.157390, -0.109793, -0.538173, -0.604860, -0.034819, 0.228724, 0.053004, 0.012129, -0.065071, -0.103633, -0.036137, -0.532469, -0.345938, -0.048319, -0.091458, 0.042280, 0.038129, 0.387461, 0.250332, -0.088764, 0.101395, 0.680897, 0.588465, 0.536362, 0.433676, 0.495548, -0.074468, -0.793160, -0.412304, -0.601399, -0.696477, -0.489189, -0.312581, -0.392103, -0.481397, -0.426372, -0.278985, -0.275985, -0.340034, -0.329824, -0.456108, -0.390673, -0.378638, -0.522335, -0.601018, -0.438289, -0.298315, -0.177827, -0.318926, -0.525992, -0.463423, -0.489083, -0.463259, -0.507872, -0.458419, -0.626692, -0.276620, -0.206077, 0.194756, -0.340325, -0.460703, -0.344276, 0.051663, -0.152106, -0.359720, 0.034581, -0.070859, -0.098701, -0.032968, -0.151711, -0.086059, 0.251423, -0.028818, -0.206442, -0.080901, -0.194120, -0.075751, 0.030006, 0.062749, -0.224083, -0.020192, -0.061223, -0.162925, -0.088223, 0.151217, -0.754011, -0.013002, 0.044069, 0.027354, 0.082239, 0.040612, 0.061983, 0.153210, -0.022270, -0.334197, -0.222988, -0.265307, -0.524765, -0.683888, -0.484286, -0.220280, -0.011147, 0.251414, 0.176495, 0.098436, -0.089426, -0.033885, -0.097847, -0.046815, -0.211204, -0.232551, -0.338684, -0.251525, -0.235747, -0.390732, 0.027057, -0.142308, -0.244433, 0.363684, -0.249413, -0.486587, -0.440304, 0.235920, -0.008608, -0.137988, -0.067262, 0.213200, 0.116318, 0.020304, -0.123230, 0.071535, 0.413403, 0.170690, -0.053256, 0.015789, -0.031031, 0.346655, 0.549524, 0.414285, 0.042412, 0.325147, 0.171322, 0.112381, 0.372471, 0.660778, 0.689148, 0.538802, 0.484455, 0.357432, -0.035765, -0.243042, -0.245802, -0.111924, 0.099088, 0.236241, 0.184228, 0.152844, 0.163138, 0.126168, 0.097949, 0.212864, 0.253726, 0.391585, 0.368296, 0.433805, 0.502249, 0.633795, 0.647808, 0.529405, 0.612597, 0.509839, 0.516011, 0.590308, 0.637329, 0.885118, 0.414306, 0.245317, -0.468078, -0.043896, -0.131870, -0.316788, -0.355722, -0.022737, -0.238419, -0.021849, -0.176961, -0.207506, -0.145487, -0.193811, -0.219954, -0.318698, -0.056290, -0.049192, -0.174621, -0.117602, -0.123749, -0.046629, -0.263370, -0.247864, -0.226471, -0.217222, -0.271582, -0.103033, -0.178870, -0.006191, -0.554679, 0.034156, -0.225207, -0.219386, -0.129143, -0.289048, -0.408307, -0.786850, -1.011693, -1.027908, -0.712330, -0.529126, -0.568724, -0.386086, -0.104116, 0.088628, -0.037708, -0.139339, -0.175420, -0.139734, -0.108315, -0.096871, -0.136759, -0.289506, -0.164260, -0.373146, -0.298225, -0.300808, -0.290325, -0.418049, 0.141636, -0.516459, -0.250423, -0.052802, -0.146400, -0.255652, -0.356176, 0.004250, -0.131761, 0.049976, -0.220143, -0.186649, -0.164773, -0.335180, -0.239173, -0.449366, -0.143611, -0.206995, -0.289068, -0.305339, -0.366937, -0.459641, -0.530846, -0.476973, -0.453384, -0.436286, -0.544280, -0.348833, -0.518177, -0.471359, 2.432952, 2.369092, 3.288502, 3.831134, 3.541445, 3.497855, 3.668518, 4.125676, 4.227019, 4.234738, 4.441387, 4.739365, 4.359405, 4.386521, 4.184709, 3.636939, 3.376010, 3.464951, 3.879670, 4.161193, 3.675202, 3.071170, 3.520720, 3.700028, 3.487475, 3.697719, 3.652274, 3.326045, 3.332924, 3.326484, 0.560093, 3.174015, 4.704199, 4.189919, 5.101737, 4.394908, 4.345218, 3.053330, 3.529528, 4.003354, 3.676148, 4.166781, 4.650825, 5.109684, 5.854213, 5.600014, 4.894928, 5.047005, 4.674465, 4.547744, 5.070337, 5.735682, 4.941639, 5.340163, 5.329557, 4.815679, 5.527802, 5.377676, 5.545223, 6.217546, 2.061995, 3.048259, 2.660952, 2.206460, 3.857615, 2.245538, 2.017339, 1.268049, 1.499084, 2.026822, 1.397066, 1.996380, 1.849869, 3.021575, 3.210668, 3.192244, 3.337004, 4.101801, 3.144100, 2.960270, 2.778178, 2.403865, 2.831412, 3.853976, 4.495033, 4.014283, 3.802939, 3.822031, 4.021664, 3.967969, 0.022874, 2.023276, 2.829045, 1.664773, 1.766210, 0.729972, 1.067202, 0.968163, 2.215946, 1.762783, 1.920607, 2.806682, 3.401658, 4.381573, 5.138017, 4.148645, 3.816821, 3.019130, 3.086993, 2.598455, 3.173362, 3.509176, 2.611010, 4.246919, 4.804187, 4.102164, 4.002674, 4.653045, 4.826092, 5.155009, -1.195694, -0.477544, -0.503904, -1.404914, 0.128034, 0.283236, 0.467207, 1.591456, 1.145935, 0.389078, -0.162729, -0.515290, 0.015625, 0.504401, 0.343681, 0.149439, 0.572224, 0.608940, 0.284092, 0.520923, 1.058445, 0.387169, 0.018879, 0.133541, 0.705364, 0.506986, 0.431950, 0.819457, 0.647750, 0.174935, 0.362982, -0.010309, 0.228825, -0.114963, -0.475817, -0.328026, -0.400502, -0.319585, 0.762377, 0.617159, 0.215659, 1.094661, 0.113311, 0.766489, -0.723009, 1.166607, 2.053744, 1.852144, 1.390475, 2.084716, 3.651196, 2.909562, 2.485677, 3.161576, 3.306485, 3.121723, 3.301979, 3.780989, 3.103078, 2.748270, 1.168104, -0.675707, -1.311155, -0.069443, 0.010756, -0.499841, -1.590327, -0.139488, -0.634941, -0.492860, -0.573721, 0.093299, 0.283715, -0.235189, -0.206732, -0.122728, 0.731922, -0.473622, -0.407860, -0.976372, 1.438398, 1.402712, 0.800610, 1.122037, 1.739703, 1.015548, 1.102957, 1.054779, 1.084622, 1.191226, -0.719644, -0.124789, -0.139645, 0.337273, -0.306006, 0.262401, -0.018219, 0.290770, 1.525820, 1.580180, 1.418617, 1.352638, 0.624198, 1.162885, -1.060876, 1.587269, 2.440360, 1.545915, 1.189176, 0.788827, 4.877897, 3.323111, 2.760750, 3.296917, 4.624209, 3.991396, 3.651592, 4.473869, 3.500751, 3.188051, 0.005204, -0.269386, 0.350197, 0.090325, 0.178676, 0.163429, 0.095197, -0.065496, -0.174107, -0.205787, -0.303069, -0.047162, 0.306934, 0.274950, 0.154823, 0.313244, 0.150330, 0.174130, 0.417670, 0.477045, 0.232382, -0.006235, -0.060871, 0.068997, -0.019160, 0.038370, 0.011781, -0.120463, -0.132236, -0.202304, 0.580420, -0.650937, 0.586018, 0.172211, 0.676536, 0.267866, 0.703893, 0.282413, 0.585528, 0.783616, 1.122415, 2.082994, 2.054640, 2.519502, 2.523011, 1.606704, 1.663831, 1.044539, 0.989036, 1.758775, 2.028453, 1.704906, 1.693834, 1.711612, 1.436078, 1.537270, 1.386119, 1.946700, 2.075501, 1.572554, -1.287134, 0.392276, -0.787961, -0.751958, 0.175899, -0.490330, -0.530894, -0.449197, -0.064750, -1.100497, -0.536897, -1.703760, -2.254939, -1.827968, -1.593454, -1.753299, -1.094115, -1.735434, -2.048421, -2.274204, -1.735171, -1.396469, -1.527040, -2.131232, -1.960169, -1.937063, -2.334264, -1.825445, -1.843341, -2.297833, 1.108513, -0.520834, 1.266571, 0.491612, 0.855682, 0.374349, 0.217204, 0.100583, 1.020645, 1.342938, 1.196173, 2.563581, 2.131573, 2.304131, 2.381196, 2.058996, 0.463740, 0.476479, 0.493420, 1.360954, 2.071755, 0.882603, 1.561408, 1.354565, 0.899219, 1.210076, 1.745566, 2.171186, 2.069318, 1.313831, 0.960474, 1.067430, 0.850523, 1.027098, 1.362508, 1.841867, 2.066073, 2.116864, 1.695301, 1.458497, 1.563799, 1.331998, 1.595727, 1.449270, 1.418385, 0.979381, 0.948458, 0.963954, 0.506293, 0.427311, 0.545415, 0.956004, 1.285030, 0.954450, 0.357673, 0.331460, 1.075599, 1.406834, 0.722346, 0.060673, -0.186818, 1.380420, -0.249419, 0.063708, 0.261956, 1.215617, 1.745853, 2.084375, 2.297628, 1.025347, 0.478823, 1.300715, 1.935042, 2.562634, 2.637099, 1.502886, 0.503939, 0.222123, 0.169203, 0.078322, 0.081754, 0.376415, 0.329389, -0.065298, -0.191116, -0.286810, 0.032542, 0.359844, -0.117074, -0.239348, -0.565867, -0.150334, 0.269670, -0.230668, 0.023334, 0.410495, 0.765968, 1.009471, 0.767675, 0.613246, 0.282367, 0.977702, 0.602056, 0.505613, 0.710604, 0.165295, 0.200214, 0.228427, 0.386179, 0.460616, 0.271802, 0.549191, 0.100935, -0.142750, -0.167047, -0.418806, 0.021755, 0.975924, 0.445084, 0.121242, 0.217227, 0.641246, -0.647832, 0.114681, 0.546921, 1.509741, 1.865667, 1.949545, 2.599416, 1.277549, 0.933477, 1.568205, 1.757499, 2.036800, 2.157947, 1.532790, 0.554350, 0.168633, 0.475944, -0.051978, 0.010980, -0.063300, -0.075836, -0.150655, -0.481472, -0.154620, 0.177429, -0.107215, -0.189574, -0.377176, 1.055967, 1.276342, 2.401506, 1.952831, 1.794785, 1.669493, 1.293072, 1.608489, 2.004582, 2.278873, 2.599400, 2.273934, 2.551975, 2.697555, 2.726883, 2.241946, 1.939040, 2.440206, 2.458634, 2.577512, 2.377979, 1.954191, 2.213849, 2.621211, 2.133301, 2.176704, 1.930337, 1.557637, 1.498098, 1.779887, 3.571693, 5.814460, 6.127299, 8.856008, 9.285692, 9.049368, 9.202791, 8.103588, 7.929463, 7.377088, 8.569701, 9.864299, 8.602369, 8.433782, 7.605983, 7.719423, 6.864551, 6.383991, 7.050258, 8.521661, 7.194035, 6.461996, 6.164954, 6.595194, 6.298806, 6.510821, 6.970026, 7.226401, 7.498479, 6.232766, -1.813024, -2.821847, -1.858302, -3.344890, -4.056797, -3.809130, -3.946493, -3.387392, -2.961513, -2.583068, -3.287995, -4.405996, -3.619959, -1.786301, -1.304746, -1.976127, -3.565537, -2.873990, -3.298238, -4.355731, -3.203367, -3.272196, -2.087511, -2.621311, -3.618403, -2.965367, -2.726818, -2.938752, -2.383252, -3.547787, 3.275571, 3.994557, 3.675824, 4.299764, 5.318975, 4.781975, 4.010742, 4.517542, 4.919640, 4.259507, 4.597417, 5.942400, 4.469280, 6.319235, 5.574353, 5.230035, 4.419264, 3.293031, 4.535932, 6.538789, 4.607384, 3.045442, 2.628876, 3.684399, 3.175694, 3.100378, 3.977393, 4.287100, 4.870809, 3.609529, 3.246698, 3.544943, 4.713075, 5.422455, 5.260374, 5.142321, 5.146019, 5.388289, 5.936606, 6.173888, 6.435805, 6.772630, 6.628202, 6.792988, 6.296769, 5.968426, 5.228114, 5.902553, 6.472011, 6.307078, 5.933937, 5.326369, 5.613466, 5.971653, 6.046788, 6.079316, 6.064459, 5.858865, 5.897296, 5.683952, 0.062586, 4.242843, 4.555396, 4.317801, 4.410103, 3.425504, 3.333592, 4.792247, 4.600435, 4.350235, 4.650138, 3.976496, 3.893378, 4.336252, 5.108141, 4.590899, 4.950766, 4.484400, 4.978305, 5.323733, 5.198083, 4.821143, 4.669986, 4.731225, 5.365410, 5.098324, 5.219805, 5.548369, 5.155492, 5.099520, 0.930897, 0.899105, -0.186496, -0.860442, -0.995350, -0.604448, 0.140691, -1.701038, -1.731193, -0.914314, -0.973987, -0.927240, 0.286625, -0.223384, -0.869521, -0.542565, -1.318957, -1.159294, -0.959773, -1.342038, -1.588030, -0.655330, -0.144898, 0.697840, 0.376041, 1.180594, 1.357105, 0.810649, -0.392871, -1.332090, -0.308355, 4.380110, 2.604816, 2.125743, 2.565021, 1.793033, 1.279772, 3.843130, 3.490219, 2.228213, 1.813749, 1.933076, 1.547387, 1.708458, 1.845201, 1.672937, 3.461637, 2.041955, 2.323084, 3.013371, 3.112526, 1.450141, 1.011894, 1.210388, 2.272784, 1.980346, 2.046361, 2.340365, 2.063662, 2.362327, -1.112876, -0.352357, -0.593858, -1.207229, -0.714851, -0.301545, -0.131870, -0.461213, -0.759249, -0.487090, -0.334838, -0.854249, -0.922405, -0.713957, -0.703038, -0.609313, -0.859745, -1.149711, -1.127356, -1.009764, -1.060376, -1.419544, -1.441865, -1.264157, -1.157575, -1.191838, -1.031989, -1.113972, -0.986275, -1.057953, -0.103453, -0.137700, -0.344866, -0.405970, -0.365572, -0.358628, -0.241843, -0.436481, -0.381395, -0.426395, 0.022380, -0.227640, -0.356178, -0.247422, -0.476984, -0.114977, -0.345827, -0.470137, -0.313884, -0.257244, -0.499200, -0.556449, -0.682459, -0.402309, -0.400738, -0.598677, -0.489682, -0.560063, -0.485987, -0.633274, 0.119560, 0.272556, 0.149454, 0.208173, 0.044813, 0.068744, 0.239400, 0.415914, 0.407197, 0.358008, 0.407157, 0.328095, 0.246050, 0.265545, -0.110798, 0.028094, 0.118977, -0.006510, 0.148320, 0.083999, 0.223845, 0.141298, 0.034732, 0.086411, 0.194898, 0.223939, 0.054671, 0.008368, -0.047740, 0.130748, -0.801699, 0.262910, -0.210554, -0.607490, -0.541516, -0.366079, -0.235014, -0.468116, -0.365648, -0.469104, 0.138493, -0.286429, -0.291510, -0.144655, -0.416675, -0.088452, -0.406397, -0.490300, -0.149764, -0.236756, -0.543384, -0.487560, -0.678220, -0.461171, -0.440197, -0.607618, -0.520292, -0.594987, -0.465774, -0.628535, 4.252196, 4.549167, 5.618946, 6.249125, 5.981962, 5.821570, 6.063795, 6.750247, 6.849283, 7.050158, 7.493522, 7.514581, 7.377728, 7.552400, 7.355334, 6.772548, 6.228081, 6.747718, 7.438540, 7.450644, 6.983415, 6.678433, 6.810692, 6.951885, 6.826167, 7.087396, 7.146288, 6.913250, 6.985094, 6.750037, -0.394105, 1.827352, 2.579409, 2.837311, 2.711486, 2.316404, 2.310482, 2.187649, 2.623430, 2.715559, 3.081550, 3.486312, 3.547480, 3.314873, 3.465793, 3.555477, 3.058255, 2.968852, 3.728988, 3.800025, 3.501868, 2.986413, 2.821816, 3.022487, 3.503381, 3.134261, 3.000804, 3.291953, 3.454974, 3.352319, -0.230888, -0.983678, -1.328727, -1.219031, -0.214796, 0.512802, -0.022711, -0.478568, -0.193378, -0.517563, -0.697974, -1.275734, -1.554510, -1.841259, -1.061421, -0.228576, -0.071742, -0.620845, -0.106314, 0.378086, 0.655787, 0.200107, 0.469389, 0.814915, -0.051862, 0.331070, 0.665231, 0.422080, 0.498869, 0.631608, -0.724036, 0.951263, 1.541312, 1.678225, 1.548609, 1.260790, 0.970865, 0.922859, 1.268938, 1.584687, 1.589634, 3.676132, 3.433980, 3.118145, 2.475751, 1.999974, 2.321139, 1.552337, 2.265901, 2.417525, 2.014900, 1.431694, 1.265727, 1.282981, 2.469075, 1.805735, 1.420045, 1.538817, 1.457299, 1.774802, -0.167106, -0.318903, -1.091573, -0.634035, -0.953972, -1.029033, -0.948155, -0.681703, -0.515935, -0.658059, -0.829971, -0.531915, -0.615533, -0.477045, -0.317446, -0.604532, -0.845580, -0.830115, -0.784602, -0.712947, -0.622673, -0.658436, -0.573241, -0.820526, -0.672285, -0.786177, -0.826989, -0.782601, -0.760904, -0.892968, -0.582720, -0.888474, -0.049602, 0.335129, 0.053421, 0.864368, 0.680071, 0.384219, -0.169753, -0.103029, 0.155037, 0.936523, 0.816994, 0.878672, 0.599625, 0.371448, 1.360734, 0.255477, 0.097895, 0.513363, 0.168798, -0.597436, 0.295253, 0.579778, 0.348988, 0.282136, 0.131110, 0.003263, 0.231240, 0.138396, -1.054746, -0.072678, -0.492405, 0.732073, 0.461970, -0.296209, -0.614146, -0.558737, -0.345579, -0.880959, -1.827991, -1.861211, -1.111798, -1.704249, -1.580145, -1.334609, -2.347590, -1.692482, -1.135880, -1.238502, -1.367701, -0.582734, -1.074345, -1.390590, -0.615256, -1.044164, -0.954602, -0.536627, -0.686039, -1.091417, -0.254362, -0.958687, 0.285942, 0.732626, -0.090173, 0.206912, 0.403980, 0.645224, -0.265205, 0.400178, 0.781708, 0.949325, 0.855731, 1.312492, 1.310199, 0.982143, 2.114553, 0.503053, -0.043987, 1.086877, 0.963253, -0.209380, 0.488339, 0.700291, 0.535982, 0.391630, 0.436072, 0.010904, 0.730303, 0.710442, 0.228762, -0.454441, -0.210121, -0.184508, 0.095282, 0.187568, 0.052760, -0.029530, -0.204510, -0.231161, -0.171430, -0.188230, -0.227224, -0.185738, -0.296000, -0.157354, 0.032165, -0.000257, 0.096687, 0.121875, -0.135281, -0.181080, -0.258222, -0.093398, 0.186664, 0.402634, 0.156151, -0.097548, -0.032571, 0.058510, -0.359737, 0.192535, 0.445433, 0.862465, 0.551848, 0.157823, -0.127971, -0.167566, -0.178490, -0.451032, -0.530162, -0.207355, -0.334327, 0.140281, 0.233328, 0.639032, 0.241359, 0.247577, 0.156565, 0.315000, 0.324821, 0.314250, 0.172703, 0.319468, 0.364798, 0.780325, 1.158459, 0.870268, 0.668255, 0.761086, 0.621363, 0.487485, 0.861743, 1.752415, 1.553793, 0.784221, 0.962710, 0.876872, 0.446822, 0.420434, 0.764542, 0.505135, 0.479014, 0.494999, 0.511310, 0.478949, 0.391473, 0.376108, 0.667030, 0.825305, 0.838660, 0.708229, 0.662536, 0.993956, 0.622178, 1.110879, 1.362299, 1.521985, 0.715537, 0.862540, -0.269723, 0.127656, 0.415132, 1.955549, 1.343310, 0.394580, -0.046937, -0.267531, 0.158421, -0.620141, -0.616965, -0.253093, -0.283122, 0.405992, 0.233878, 1.070972, 0.573596, 0.429890, 0.101218, 0.790130, 0.609081, 0.595285, 0.328504, 0.375231, 0.655191, 1.250413, 1.563438, 1.160103, 0.716776, 0.968326, 0.982804, 1.341912, 1.004161, 0.332519, 0.446082, 0.518547, 0.617082, 0.194622, -0.114013, 0.434610, 0.538181, -0.011851, -0.160707, -0.231023, 0.146708, 0.268415, 0.077061, 0.042402, -0.124625, 0.128964, 0.148377, 0.298553, 0.436418, 0.288536, 0.080713, -0.145397, 0.298068, 0.338523, 0.154203, -0.114493, -0.138766, 1.594399, -0.501420, -0.805413, 0.013487, 0.035507, 0.726226, 0.504885, 0.103950, -0.275074, -0.360291, -0.387386, -0.224243, -0.400274, -0.274799, -0.384125, -0.677547, -0.653649, -0.677287, -0.400193, -0.034579, 0.435948, 0.366296, 0.089520, -0.071138, -0.342095, 0.048416, 0.020182, -0.075943, -0.201855, -0.225730, 0.100268, 0.346172, 0.162875, 0.336798, -0.193418, -0.555028, -0.703305, -0.621115, -0.132039, 0.108792, -0.279796, -0.143831, 0.045801, 0.057908, 0.367511, 0.337554, -0.292956, -0.528914, 0.126845, -0.007885, -0.178911, 0.253519, 0.256055, -0.156016, 0.235107, 0.492682, 0.550661, 0.286675, 0.021177, -0.489252, 0.918889, -0.730812, -0.667535, -0.488865, -0.410653, 1.050450, 0.622142, 0.055717, -0.514591, -0.359864, -0.709948, -0.507332, -0.203523, -0.504213, -0.549267, -0.701153, -0.541515, -0.448915, -0.147965, -0.078062, 0.118014, -0.099946, -0.075325, -0.254990, -0.532909, -0.254217, -0.306644, -0.368267, -0.278168, 0.446872, 0.198717, 0.022719, 0.256790, -0.057755, -0.460766, -0.618855, -0.588875, -0.258351, -0.002516, 0.122346, 0.170570, 0.081186, -0.059604, -0.277342, -0.219444, 0.002137, 0.172671, 0.039296, 0.125346, 0.355604, 0.478676, 0.507307, 0.360619, 0.488995, 0.481332, 0.297963, 0.394459, 0.413350, 0.709532, 0.089255, -0.095004, -0.485496, 0.093619, -0.102522, -0.422557, -0.052175, 0.126922, 0.106000, 0.006875, -0.075966, -0.169769, -0.071222, -0.030310, -0.210446, -0.191260, -0.328262, -0.534482, -0.224379, -0.217586, 0.021990, -0.006481, -0.240172, -0.428909, -0.200882, -0.028737, -0.364566, -0.248174, -0.320509, -0.107533, -0.242342, -0.405357, -0.509137, -0.562771, -0.886704, -0.528924, -0.389001, -0.803110, -1.086474, -0.944475, -0.714145, -0.290878, 0.173394, 0.275079, -0.436234, -0.391356, -0.336400, -0.316073, -0.391602, -0.233943, -0.178580, -0.298251, -0.520621, -0.543299, -0.446058, -0.279312, -0.306392, -0.512854, -0.305387, -0.298895, -0.316927, -0.521380, -0.367281, -0.247798, -0.320493, -0.417832, -0.056740, 0.085670, 0.293856, 0.180948, 0.057569, -0.253981, -0.184845, -0.149703, -0.123331, -0.237333, -0.544522, -0.566776, -0.308700, -0.389504, -0.412621, -0.571534, -0.560149, -0.460823, -0.144609, -0.211156, -0.553127, -0.441818, -0.554908, -0.523178, -2.358759, -1.087902, -0.133939, 0.721368, 1.140683, 1.214252, 1.311118, 1.065349, 0.605171, 0.333521, 0.167486, 0.464825, 0.460346, 0.683881, 0.974487, 1.098044, 1.354689, 0.912231, 0.694669, 0.483844, 0.850290, 0.646533, 0.292310, 0.452303, 0.462732, 0.186024, 0.499269, 0.625212, 0.256379, 0.634692, -0.829599, -0.487563, 0.079064, 0.257284, -0.042158, -0.495866, -0.492143, -0.447638, -0.247846, 0.346244, 0.002086, 0.005977, 0.137822, -0.012194, 0.037150, -0.353583, -0.352446, -0.555661, -0.464989, -0.388693, 0.067460, -0.418867, -0.483666, -0.415003, -0.160924, -0.323344, -0.380467, -0.233046, -0.564307, -0.331609, 0.471314, 0.140556, 0.372725, 1.034538, 0.792006, 0.279602, 0.334492, -0.036111, 0.094784, 0.525215, 0.412302, -0.148706, 0.117823, 0.314527, -0.005622, 0.030592, -0.036576, 0.016862, 0.398385, 0.281096, 0.674891, 0.453871, 0.049114, 0.211855, 0.078408, 0.000574, 0.245922, -0.099606, 0.050966, 0.104310, -0.504180, -0.134112, 0.153770, 0.500176, 0.221001, -0.593437, -0.551086, 0.011948, -0.137796, 0.190309, -0.250061, -0.186588, -0.109189, -0.317696, -0.268665, -0.353988, -0.380652, -0.356270, -0.615720, -0.462748, -0.245445, -0.281149, -0.710539, -0.622271, -0.264792, -0.482864, -0.455772, -0.191391, -0.600635, -0.395489, -2.223699, -1.103467, -0.064627, 0.824460, 1.244506, 1.245452, 1.255209, 1.007929, 0.631068, 0.477223, 0.247060, 0.408979, 0.416056, 0.658247, 0.867758, 1.028511, 1.439324, 1.082751, 0.680156, 0.416967, 0.876542, 0.651063, 0.324846, 0.381547, 0.467624, 0.212240, 0.404889, 0.684789, 0.297863, 0.662770, -0.608763, -0.324704, -0.122372, -0.343362, -0.141960, -0.262694, -0.285139, -0.309194, -0.171545, -0.377893, -0.152603, -0.448919, -0.067411, -0.011406, -0.139236, -0.202856, -0.271789, -0.392959, -0.297161, -0.305745, 0.316946, -0.187733, -0.645607, -0.450375, -0.112378, -0.492387, -0.487202, -0.347717, -0.555142, -0.486666, -0.223010, 0.006950, -0.554274, -0.843270, -0.125180, 0.406259, 0.667945, 0.639446, 0.455514, 0.366319, -0.302819, 0.320101, 0.645996, -0.034489, -0.835597, -0.166724, 0.424840, 0.911769, 0.434588, -0.146878, -0.028207, 0.376529, 0.132137, 0.031295, -0.022087, -0.013296, -0.012769, 0.218936, 0.665166, 0.190781, -0.305576, 0.105148, 0.046832, -0.217501, -0.356205, -0.384305, -0.218032, -0.260706, -0.005315, -0.278023, -0.054288, -0.676978, -0.199417, -0.437453, 0.072401, -0.195397, -0.531103, -0.240691, -0.165139, -0.250987, 0.145549, -0.008110, -0.756574, -0.638121, -0.415658, -0.612420, -0.561780, -0.306454, -0.558297, -0.673141, -0.892693, -1.183148, -0.459809, 0.341231, 0.180710, 0.767861, 1.296072, 1.035582, 0.513832, 0.465515, 0.252844, 0.193033, 0.090465, 0.737623, 0.734190, 0.218635, 0.063248, 0.074288, 0.482148, 0.661221, 0.343649, 0.417606, 0.296083, -0.041749, 0.114524, -0.413661, -0.049402, 0.286125, 0.019042, -0.353354, 1.855662, 3.088936, 1.605343, -0.284292, 1.205034, 1.312938, 1.623651, 1.484996, 1.301225, 0.819323, 0.745155, 1.199239, 2.605858, 4.018775, 3.688064, 3.632485, 3.074950, 2.086657, 3.271470, 3.337790, 1.775623, 1.353300, 2.063293, 1.885415, 1.434134, -0.067314, 0.543997, 0.972993, 0.060419, -0.127365, -2.380776, -3.733628, -0.905989, -0.002996, 0.392873, 0.550525, 0.910319, 1.056713, 0.324132, 0.506199, 0.990739, 1.897408, 2.104062, 2.011236, 0.859188, 1.897117, 2.791050, 1.792707, 2.488361, 2.751160, 0.642110, 1.052836, 1.891672, 2.218170, 0.659527, 0.530319, 1.324558, 1.526048, -0.008071, -0.190718, 3.633238, 5.114747, 2.380210, -0.408451, 0.469552, 0.094425, 0.631973, 0.079892, 0.307571, 0.806963, 0.410300, 0.202684, 3.563354, 2.493108, 1.506964, 1.163998, 1.349865, 1.973919, 1.908591, 1.243336, 0.992247, 1.110320, 1.402548, 0.719039, 1.081714, -0.471906, 0.453466, 0.998497, 0.407292, -0.091009, 0.394564, 0.790785, 0.931064, 1.569386, 1.716902, 1.660932, 1.704059, 2.340215, 1.898243, 1.684893, 1.877355, 2.057955, 1.809356, 1.277852, 1.433889, 1.154145, 1.127854, 1.047807, 1.249118, 1.374549, 1.153087, 1.102072, 1.069588, 0.989895, 0.527744, 0.332840, 0.308096, -0.047308, -0.192673, -0.307255, -0.926189, 0.876032, 2.167268, 1.566662, 2.150518, 3.890944, 4.001355, 4.791132, 3.115578, 2.023047, 1.177947, 1.752322, 2.571148, 1.362753, 1.209428, 1.667183, 1.474621, 1.096686, 0.515634, 1.637317, 2.027631, 2.193229, 1.550667, 1.242879, 0.670794, 0.577813, 0.373951, 0.385831, 0.663716, 0.397626, 1.272548, -2.468912, -3.802593, -2.786689, -2.979538, -3.077115, -3.208791, -4.234004, -4.463815, -1.984379, -1.360728, -2.283088, -2.680823, -1.443976, -1.789364, -1.865986, -2.189300, -2.695500, -3.253348, -2.219196, -2.862784, -3.432232, -2.382512, -2.118387, -1.552485, -1.458809, -1.686521, -0.892615, -0.428996, -0.173263, 0.041064, 1.553132, 0.593611, -0.118012, -1.189360, 0.155560, -0.302108, 0.522688, -0.163840, 0.221741, -0.224345, -0.605623, 0.014509, 0.291006, 0.657520, -0.097748, -0.974944, -0.386961, -0.849383, -0.484127, 0.162070, -0.003803, 0.019830, 0.045539, -0.357321, 0.257235, -0.282385, -0.110037, 0.282047, 1.040748, -2.460705, -1.216390, -0.141686, 0.720965, 1.346545, 1.533313, 1.499313, 1.109990, 0.718369, 0.379093, 0.090998, 0.337396, 0.385435, 0.646058, 0.991877, 1.271348, 1.543732, 1.252624, 0.971188, 0.522020, 0.806557, 0.755072, 0.376841, 0.453437, 0.519462, 0.265581, 0.355509, 0.562126, 0.409340, 0.717681, -0.800971, -0.382875, -0.080338, -0.045826, -0.167396, -0.083606, -0.092373, -0.228275, -0.223843, -0.258130, -0.151021, -0.002541, -0.196094, -0.001122, -0.097196, -0.582762, -0.606455, -0.239044, -0.300918, -0.245032, 0.458867, -0.059716, -0.396055, -0.307663, 0.095730, -0.378307, -0.539737, -0.359381, -0.519273, -0.422404, -0.142365, -0.537394, -0.211489, 0.505757, -0.017858, -1.143198, -0.909734, -0.498697, 0.097421, -0.161673, -0.447833, -0.541838, -0.751664, -0.556860, -0.163305, 0.231865, -0.078006, 0.009975, 0.136139, -0.393807, 0.755141, 0.879754, 0.415315, -0.109307, -0.256542, 0.013744, 0.021393, -0.206069, -0.132437, -0.616666, -0.500492, 0.130793, -0.250121, 0.177114, -0.023008, 0.264633, -0.064011, -0.131070, -0.084048, -0.477026, -0.322806, 0.138023, -0.140373, 0.063503, 0.226523, -0.509724, -0.776370, -0.313174, -0.493399, -0.188732, 0.131499, 0.121403, -0.768082, -0.445470, -0.012731, -0.493413, -0.617389, -0.516309, -0.450310, -0.490294, 3.453118, 3.868457, 4.694938, 5.148212, 4.822116, 4.529179, 4.630847, 5.041519, 5.220243, 5.292505, 5.439229, 5.583878, 5.301522, 5.642054, 5.332307, 4.713101, 4.579863, 5.034465, 5.554008, 5.838321, 5.432496, 4.767622, 4.748875, 5.121796, 5.237693, 5.412369, 5.258742, 5.171345, 5.216418, 5.148764, 1.125428, 4.391487, 5.270816, 5.030112, 4.800375, 5.663099, 5.513837, 5.264246, 5.351229, 5.251349, 5.457571, 4.930623, 4.915935, 5.370636, 5.565887, 5.395651, 5.693129, 6.226236, 6.066315, 5.925316, 6.000688, 5.421767, 5.031940, 5.753247, 6.032578, 5.720953, 5.811834, 6.201179, 6.073434, 6.100375, 0.573718, -1.466189, -0.818006, -0.357243, -0.475751, -0.767504, -0.437559, 0.281996, 0.395433, -0.089708, 0.760193, 0.367939, -0.032887, 0.532060, 0.386797, 0.744682, 0.039682, -0.410476, -0.224825, -0.215362, -0.094897, -0.390514, -0.101103, 0.140549, 0.321794, -0.291497, -0.484087, -1.007409, -0.944251, -0.201465, 0.075205, 0.944749, 2.003495, 0.714005, 0.428055, 1.063279, 1.069333, 0.764482, 1.126180, 1.251653, 1.067900, 1.695690, 2.011165, 1.685346, 2.109305, 2.471678, 2.119159, 2.291537, 1.720881, 1.361021, 1.969760, 1.187343, 1.269243, 1.298636, 1.681816, 1.639519, 1.816653, 1.805978, 1.745009, 1.554159, 3.613012, 4.528708, 5.992485, 6.568274, 6.182678, 5.976664, 6.043129, 6.943746, 7.162510, 7.413184, 7.855938, 8.033668, 7.678279, 7.645836, 7.614154, 7.172784, 6.601923, 6.875421, 7.281274, 7.531815, 7.031162, 6.813220, 6.745556, 6.980779, 6.974162, 7.417427, 7.426007, 6.964196, 7.223316, 6.941383, 0.108642, 0.877716, 1.271125, 2.067469, 2.114528, 1.679661, 1.992701, 1.951219, 1.440278, 1.795623, 2.107552, 2.124965, 2.167695, 2.170981, 2.156626, 2.464490, 2.218532, 2.290341, 2.616190, 2.412406, 2.698692, 2.958532, 2.865399, 3.371906, 3.380687, 3.291933, 2.898290, 2.890328, 2.946742, 2.927437, -0.834379, 0.379848, -0.193879, 0.547388, 1.287375, 0.816059, 0.617064, 0.615096, 0.049734, -0.420370, 0.172104, 0.862092, 1.139962, 1.792780, 1.959491, 1.180575, 0.889605, 1.766322, 1.452573, 1.557329, 1.311297, 1.146498, 1.351122, 1.879907, 1.127488, 1.623438, 1.599896, 1.367704, 0.849354, 1.495131, 0.764636, 0.467123, 0.821214, 1.534786, 2.307824, 1.095221, 1.343413, 1.117258, 0.511223, 1.373933, 1.231082, 0.693878, 1.225034, 0.751639, 1.273447, 1.880399, 0.869676, 1.230180, 1.804633, 1.949445, 2.007727, 1.396993, 1.466021, 2.402097, 2.257157, 2.046706, 1.682532, 1.670809, 1.751822, 1.358374, 0.786654, 0.846375, 0.858750, 0.370093, 0.491188, 0.590550, 0.849649, 0.388924, 0.005045, 0.325320, 0.485593, -0.199258, -0.206759, -0.232218, -0.115752, -0.125970, -0.341654, -0.333161, -0.286029, -0.259054, -0.259420, 0.218239, 0.272563, -0.024765, -0.106418, -0.266470, -0.012808, -0.047328, -0.093158, -0.242720, -0.159221, 0.540915, -0.698931, -0.804814, -0.118148, -0.335199, -0.092974, -0.248633, -0.149529, 0.216574, 0.251114, -0.251284, -0.168312, -0.163909, -0.115049, -0.174148, -0.307537, -0.340058, -0.104192, 0.124173, 0.112401, 0.594235, 0.738086, 0.018108, 0.159861, -0.093283, 0.085184, -0.156863, -0.129635, -0.275955, -0.058441, -0.307009, -0.448566, -0.290359, -0.129970, -0.404190, -0.531503, -0.355705, -0.459913, -0.322610, -0.201191, -0.212382, -0.459586, -0.650937, -0.380100, -0.229643, -0.065683, -0.292700, -0.651644, -0.491140, -0.702247, -0.423571, -0.339180, -0.248744, -0.351621, -0.251309, -0.310129, -0.455941, -0.250571, -0.212810, -0.839957, -0.085206, -0.574655, -0.699382, -0.256134, -0.384560, -0.176016, -0.320059, -0.270944, 0.072841, 0.320753, -0.209553, -0.134573, -0.300595, -0.177129, -0.276103, -0.269798, -0.387268, -0.036110, 0.168217, 0.095372, 0.065261, -0.102284, -0.339730, -0.052817, -0.341685, -0.231757, -0.335812, -0.279518, -0.482586, -0.861244, -0.243018, -0.588539, -0.901555, -0.525751, -0.306179, -0.112750, -0.402307, -0.547084, -0.405359, -0.298794, -0.651687, -0.624654, -0.539249, -0.544552, -0.510125, -0.651225, -0.834916, -0.815099, -0.627529, -0.677723, -0.945712, -0.991094, -0.858512, -0.739129, -0.806229, -0.714560, -0.830007, -0.668814, -0.814035, -0.194951, -0.256882, -0.120244, 0.092953, 0.494543, 0.178074, 0.066461, -0.242046, -0.257487, 0.096976, 0.069464, -0.404341, -0.210167, -0.124777, -0.130677, 0.017375, -0.341842, -0.243972, -0.194523, -0.028332, -0.162601, -0.506500, -0.452671, -0.213199, -0.162371, -0.430884, -0.295371, -0.297832, -0.285371, -0.528974, 0.002643, 0.679412, 0.683679, 0.387150, 0.402533, 0.286805, -0.004150, -0.157754, 0.294598, 0.470113, 0.601238, 0.253391, -0.273175, -0.049693, 0.239154, 0.500879, 0.323354, 0.011588, 0.212399, 0.252024, 0.265612, 0.181527, 0.272580, 0.512773, 0.467212, 0.221733, 0.199422, 0.301930, 0.358012, 0.182471, -0.576288, -0.134054, 0.014147, 0.153085, 0.728945, 0.242064, 0.140157, -0.207221, -0.233738, 0.127550, 0.252072, -0.333129, -0.017412, -0.137483, -0.167927, 0.122694, -0.382432, -0.256065, -0.186703, 0.077019, -0.065010, -0.405349, -0.554714, -0.357183, -0.176213, -0.396962, -0.325750, -0.255585, -0.269042, -0.450604, -0.565099, -1.497185, -1.592235, -0.953159, -0.755879, -0.652966, -0.716849, -0.533338, -0.608417, -0.852983, -0.645967, -0.566458, -0.759994, -0.748613, -0.830941, -1.188065, -1.355907, -1.245242, -0.876170, -0.711884, -0.952854, -1.076985, -1.142689, -1.141517, -1.123863, -1.126548, -1.259655, -1.142244, -1.146506, -1.268258, -0.261850, -0.182944, 0.097349, 0.308590, -0.450879, -0.212806, -0.393139, -0.075402, -0.358078, -0.474986, -0.238134, -0.193808, -0.336382, -0.371785, -0.365760, -0.419823, -0.245830, -0.421256, -0.354312, -0.413180, -0.402882, -0.582504, -0.599922, -0.372351, -0.355293, -0.411275, -0.542652, -0.399948, -0.456937, -0.527996, -0.033658, 0.123686, 0.513968, 0.660098, 0.472775, 0.282867, 0.490187, 0.864956, 1.195543, 0.966753, 0.672934, 0.305218, 0.238539, 0.401355, 0.469001, 0.477073, 0.613048, 0.660062, 0.594607, 0.509777, 0.521823, 0.694407, 0.678102, 0.797387, 0.552398, 0.551114, 0.598327, 0.636986, 0.491803, 0.561121, -0.059743, -0.178911, -0.040729, 0.625219, -0.437383, -0.437106, -0.472412, -0.088651, -0.116479, -0.400896, -0.409690, -0.401879, -0.592467, -0.407148, -0.521575, -0.588027, -0.227296, -0.366272, -0.293559, -0.416822, -0.539792, -0.494848, -0.610318, -0.357075, -0.440858, -0.432942, -0.567652, -0.441758, -0.523598, -0.576536, 0.662575, 0.251718, -0.117317, 0.158602, -0.125135, -0.225254, -0.114718, 0.133892, 0.159989, 0.169086, 0.078485, 0.104689, 0.122435, 0.050697, 0.096383, 0.043114, 0.105819, 0.129634, 0.102351, 0.092678, 0.137379, 0.378343, 0.457145, 0.341492, 0.227055, 0.276388, 0.248291, 0.145182, 0.080374, 0.110581, -0.352026, -0.011383, -0.166652, 0.042032, -0.334315, -0.439214, -0.416191, -0.132789, -0.273429, -0.086785, -0.396684, -0.463714, -0.320548, 0.027302, -0.139414, -0.106720, -0.075240, -0.240987, -0.270343, -0.256525, -0.333798, -0.114922, 0.064493, -0.152957, -0.379476, -0.215559, -0.143267, -0.185360, -0.270847, 0.012661, -0.441980, -1.367753, -0.275159, -0.116267, -0.374258, -0.150886, 0.003063, -0.303398, -0.308192, -0.398089, -0.360179, -0.369943, 0.033644, 0.454017, 0.448071, 0.377787, 0.497251, 0.349797, -0.186553, -0.006370, 0.384192, 0.743458, 0.951431, 0.726033, 0.279207, 0.477526, 0.360526, 0.521285, 0.625525, 0.746915, 0.247994, 0.184095, 0.053881, 0.119313, -0.344858, -0.356830, -0.382790, -0.051199, -0.460386, -0.262076, -0.572504, -0.542289, -0.192691, 0.099626, -0.235288, 0.039209, 0.073715, -0.274968, -0.485390, -0.238831, -0.159704, -0.003126, 0.255025, -0.049875, -0.348620, -0.001481, -0.064080, -0.142100, -0.254135, 0.187677, 0.848161, 0.926769, 0.876177, 0.341938, 0.380315, 0.448663, 0.558276, 0.118984, -0.156264, 0.238669, 0.346653, -0.301190, -0.335411, -0.352828, -0.036828, 0.065342, -0.061416, -0.136678, -0.197066, -0.123427, -0.092890, 0.219554, 0.267080, 0.015000, -0.075558, -0.220974, 0.073981, 0.160522, 0.108223, -0.139612, -0.301529, 0.870280, -0.412597, -0.631680, -0.090515, -0.219124, -0.128660, -0.236361, -0.335127, -0.149630, -0.028354, -0.229754, -0.213063, -0.212839, -0.013767, -0.236404, -0.159280, -0.151541, -0.254997, -0.118038, -0.131032, 0.471456, 0.378175, -0.002900, 0.039476, -0.185738, 0.110348, -0.083990, -0.127428, -0.107832, 0.279021, 0.346913, 0.287201, 0.078178, -0.113981, 0.080123, 0.106937, 0.203178, 0.266822, 0.080427, 0.035639, 0.235760, 0.289231, 0.146238, -0.229744, -0.227081, -0.218660, 0.022233, 0.198687, -0.025080, -0.157617, 0.092767, -0.105022, -0.011788, -0.131942, 0.040264, 0.090319, 0.289885, 0.126908, 0.117145, -0.697830, 0.255095, -0.571747, -0.861567, -0.263977, -0.351874, -0.270342, -0.464498, -0.406499, -0.173987, -0.007699, -0.266409, -0.278978, -0.189968, -0.206225, -0.403655, -0.218588, -0.489333, -0.326779, -0.208395, -0.252084, -0.021045, -0.278426, -0.280288, -0.245027, -0.446152, -0.425686, -0.314455, -0.429544, -0.472211, -1.244641, -0.708800, -0.335573, -1.073346, -0.792626, -0.497864, -0.128840, -0.596762, -0.894172, -0.476667, -0.270975, -0.254418, -0.389884, -0.430932, -0.474069, -0.361483, -0.571204, -0.569680, -0.374019, -0.338247, -0.466319, -0.464198, -0.714975, -0.658238, -0.482751, -0.344929, -0.396215, -0.544287, -0.544127, -0.503127, 2.542928, 0.114809, 0.129060, -0.333268, -0.062743, -0.405544, -0.084427, -0.302541, -0.295848, 0.040922, -0.144638, -0.203519, -0.082847, -0.027028, 0.133654, -0.003863, -0.258009, -0.145419, -0.083094, -0.217819, -0.360477, -0.196070, -0.108911, -0.059882, -0.048520, 0.219513, 0.260561, 0.079558, 0.217064, 0.344082, 0.235351, -0.025147, -0.012935, -0.343550, -0.352910, -0.092236, -0.066176, -0.254386, -0.271693, -0.234806, -0.053338, -0.398024, -0.426799, -0.292567, -0.380486, -0.216516, -0.187225, -0.204363, -0.190426, -0.247321, -0.230328, -0.072833, 0.002574, -0.045849, -0.266956, -0.519801, -0.218817, -0.249918, -0.331967, -0.292066, 2.087258, -0.105195, 0.327354, -0.064771, -0.234161, -0.366892, 0.136441, -0.103532, -0.152995, 0.392425, 0.318960, 0.034950, 0.125957, 0.106911, 0.411050, -0.046593, -0.139153, 0.170226, -0.033694, -0.217963, -0.140063, 0.136303, 0.134109, 0.237905, 0.307810, 0.708975, 0.858573, 0.605186, 0.863495, 0.971437, 0.402544, 0.205027, 0.113883, 0.495466, 0.062001, -0.246732, -0.311184, -0.186107, 0.078024, 0.161888, 0.171911, 0.211683, 0.174901, 0.119266, -0.045228, -0.085583, 0.172351, 0.373964, 0.241102, 0.244890, 0.340607, 0.578620, 0.657572, 0.525398, 0.531942, 0.542482, 0.419568, 0.536595, 0.576637, 0.773122, 0.478491, 0.550173, -0.211571, -0.015154, -0.101277, -0.176470, -0.098013, 0.028559, 0.137702, 0.326624, 0.142265, 0.007108, -0.043058, 0.080369, -0.272225, -0.304762, -0.309186, -0.230795, -0.275681, -0.114554, -0.138901, 0.198787, -0.234029, -0.202984, -0.232822, -0.046428, -0.267255, -0.181477, -0.236931, -0.181240, 0.609391, 0.400150, -0.015803, -0.180797, 0.015663, 0.311344, 0.081880, 0.202732, 0.907019, 1.392173, 1.193197, 0.792479, 0.664527, 0.548091, 0.147999, 0.072447, -0.070113, -0.050264, -0.128198, -0.139840, 0.115197, 0.430095, 0.306772, 0.683197, 0.515472, 0.251418, 0.280356, 0.130580, 0.207421, 0.363777, -0.027957, -0.368821, -0.329051, -0.273101, -0.211920, -0.261246, 0.079769, 0.317561, 0.454087, 0.663014, 0.335106, 0.111025, -0.017790, -0.007703, -0.412166, -0.332580, -0.278862, -0.499085, -0.297743, -0.292257, -0.392527, -0.512398, -0.590978, -0.426123, -0.260992, -0.469638, -0.597624, -0.388778, -0.451746, -0.545071, -0.085349, -0.235969, -0.616973, -0.332848, 0.041508, -0.040698, -0.327239, -0.244226, -0.008919, 0.109897, 0.412284, 0.031186, -0.122600, -0.286356, -0.522289, -0.312800, -0.260857, -0.345992, -0.473422, -0.491290, -0.342387, -0.271476, 0.078716, 0.055524, 1.860841, 2.599304, 2.777103, 2.712630, 3.090290, 2.813491, 0.351593, 0.133735, -0.199026, 0.119735, 0.181972, 0.712278, 0.287540, -0.223680, -0.343057, -0.316272, 0.957071, 0.257287, -0.159003, -0.029116, -0.298148, -0.066468, 0.166344, -0.306411, -0.088875, -0.392805, -0.491170, -0.131696, 0.830075, 0.376166, 1.812657, 3.156286, 3.681867, 3.480457, 4.494369, 4.824201, -0.013703, -1.017128, 0.919800, 0.744767, 0.681991, 0.501107, -0.141384, 0.409264, -0.091157, -0.176063, 0.233717, 0.382989, -0.461842, 0.017248, -0.281744, 0.134515, 0.303586, 0.262404, -0.276097, 0.298247, 0.556907, 0.617913, 0.853771, -0.172540, 1.561713, 2.125243, 2.729123, 2.694532, 2.889325, 2.472622, 0.030797, -0.641258, 0.038777, -0.229237, 0.596096, 1.017218, 0.494683, -0.364626, 0.009563, -0.057894, 1.758905, 1.235429, -0.575197, -0.336878, -0.120940, -0.029922, 0.156168, 0.428151, 0.027935, -0.643069, -0.581003, -0.292341, 0.787906, -0.008184, 1.889789, 1.763437, 2.888880, 3.436301, 3.140257, 2.829611, -0.804154, -1.585067, -1.523666, -0.952751, -0.747182, -0.590379, -0.557238, -0.465237, -0.646349, -0.846635, -0.643408, -0.643026, -0.777137, -0.710369, -0.762362, -1.132612, -1.314049, -1.258062, -1.012579, -0.826551, -0.965419, -1.197024, -1.247560, -1.183752, -1.180034, -1.189748, -1.234956, -1.181509, -1.142730, -1.291158, -0.192944, 0.062259, 0.073473, 0.081995, -0.363225, -0.033617, -0.175016, 0.152499, 0.040896, -0.237541, -0.022657, -0.391489, -0.365998, -0.277951, -0.281753, -0.288605, -0.362959, -0.439596, -0.212770, -0.356206, -0.551377, -0.539514, -0.598687, -0.348250, -0.328202, -0.564680, -0.588079, -0.505752, -0.479404, -0.605103, -0.230200, -0.294460, -0.103797, -0.340806, -0.473173, -0.359217, -0.274685, -0.392148, -0.397429, -0.195005, 0.045893, 0.460079, 0.579196, 0.615978, 0.393156, 0.014032, -0.049074, 0.325915, 0.413120, 0.292195, -0.245614, 0.106872, 0.067624, 0.330364, 0.192103, 0.058526, -0.093294, -0.039585, -0.003229, 0.142550, -0.158652, 0.314583, -0.093115, 0.303394, -0.129892, -0.068514, -0.280321, 0.057040, 0.136972, -0.042440, -0.089105, -0.295451, -0.379074, -0.165882, -0.261733, -0.331742, -0.482110, -0.518003, -0.264345, -0.498853, -0.571327, -0.589163, -0.567754, -0.433704, -0.449262, -0.620465, -0.646189, -0.578474, -0.583591, -0.631770, -0.589362, -0.536710, 0.485583, 0.043758, -0.122413, -0.356610, -0.484242, -0.226951, 0.068828, 0.182339, 0.500413, 0.458094, 0.685319, 0.832753, 0.323430, 0.085666, 0.017867, -0.201945, -0.536321, -0.184616, -0.478773, -0.798926, -0.619674, 0.157438, 0.351938, -0.292581, -0.238344, -0.469038, -0.487650, -0.080731, 2.040739, 1.308957, 3.033779, 3.542313, 3.974821, 4.572609, 3.894840, 3.674954, 4.121964, 4.603565, 3.695708, 4.381801, 4.955378, 4.285533, 4.362050, 4.370318, 4.085664, 2.775994, 3.860808, 5.499869, 4.628628, 1.990464, 2.265676, 2.486640, 3.489712, 3.253125, 2.970899, 2.896057, 3.571665, 2.858091, -0.576056, 1.737466, 0.756180, 1.147931, 0.569881, -0.515225, 0.309389, 0.543514, 0.121100, -0.416903, 1.390323, 0.753107, 0.752339, -0.039829, -0.100556, -0.578943, 0.023174, 0.849452, 1.939701, 1.998883, 1.017737, 0.300618, 0.794283, 0.962431, 0.500041, 1.694227, 1.039480, 1.145159, 1.073032, 1.190981, 0.928636, 2.255234, 2.951440, 3.754029, 3.554203, 3.546516, 3.454683, 3.691731, 4.918584, 5.723077, 5.215108, 4.130805, 3.827004, 3.614990, 3.778359, 3.126585, 3.045698, 3.260456, 4.565423, 5.629626, 4.157926, 1.976543, 1.586398, 2.452050, 3.776278, 3.044765, 3.402119, 3.744217, 4.402818, 4.351836, 0.504986, -0.568674, -0.994344, -0.702423, -0.904506, -0.953916, -0.886175, -0.651115, -0.635317, -0.759527, -0.545350, -0.207197, -0.157736, -0.248249, -0.223004, -0.638125, -0.556145, -0.254597, -0.300098, -0.616889, -0.629806, -0.525598, -0.269829, -0.443938, -0.682786, -0.398946, -0.522310, -0.551952, -0.547550, -0.556968, -0.565417, 0.621049, 0.431433, 0.479678, -0.379671, -0.063598, -0.122481, 0.128749, -0.016009, -0.146703, -0.201103, -0.047150, -0.331232, -0.510396, -0.164267, -0.205412, 0.001605, 0.292444, 0.035813, -0.221461, -0.247782, 0.052045, 0.533452, 0.231520, 0.166568, 0.411175, 0.155100, 0.062571, 0.027148, -0.058960, 0.637365, 1.295563, 0.987716, 0.721190, 0.172079, 0.017691, 0.139345, 0.199557, 0.276246, 0.030994, -0.016196, 0.126206, 0.340636, 0.310671, 0.066076, -0.198237, 0.191697, 0.234224, 0.363025, 0.280566, 0.026446, -0.007780, 0.449646, 0.447860, 0.532882, 0.607828, 0.702352, 0.485406, 0.381357, 0.460629, -0.148124, 1.479276, 0.548261, 0.691335, -0.108621, 0.047395, -0.061565, 0.248185, 0.223829, -0.055175, -0.240186, -0.067507, -0.297271, -0.335361, 0.059200, -0.130029, 0.051607, 0.614966, 0.229595, -0.041561, -0.215714, 0.454379, 1.028562, 0.639003, 0.497815, 0.727335, 0.566379, 0.459608, 0.321673, 0.094071, -0.013856, 0.110940, -0.669866, -0.649046, -0.497267, -0.634385, -0.676250, -0.507442, -0.440404, -0.430097, -0.441655, -0.639788, -0.573195, -0.534740, -0.780408, -0.760797, -0.845661, -1.135791, -1.172411, -0.856647, -0.698076, -0.453549, -0.327929, 0.406873, 1.670358, 1.885412, 1.295524, 1.631973, 1.626241, 1.696057, -0.081871, 0.265677, -0.309406, 0.067109, -0.142373, -0.430734, -0.513041, -0.067073, -0.305593, -0.233996, -0.197649, -0.130417, -0.088574, -0.010131, -0.320421, -0.274821, -0.282828, -0.422009, -0.293492, -0.252021, -0.263548, -0.092161, -0.356891, 0.344036, 0.904408, 1.208094, 1.330365, 3.048813, 2.012319, 1.952538, -0.320488, 0.088393, 0.178447, 0.301498, 0.127987, -0.193421, -0.308720, -0.341982, -0.150896, 0.001549, 0.177399, -0.014312, -0.372127, -0.444392, -0.360304, 0.079602, -0.055001, -0.279942, -0.299505, -0.247239, -0.454126, -0.401797, -0.621468, -0.491822, -1.069916, -1.023229, -0.446581, -0.091561, -0.030044, 0.141600, -0.118135, -0.356211, -0.032734, 0.050796, 0.259645, -0.088044, -0.435827, -0.192670, 0.133487, -0.163298, -0.099524, 0.048823, 0.181398, -0.014722, -0.306057, -0.179890, -0.616672, -0.702829, -0.417013, -0.291960, -0.416374, -0.269662, -0.674307, 0.133835, 0.366296, 0.282153, 0.898888, 2.554401, 1.248825, 1.174994, 0.223908, 1.860691, 0.345126, 0.788678, 0.900943, 0.817783, 1.060006, 1.147075, 1.291228, 1.090127, 0.731388, 0.982216, 1.237949, 0.808692, 0.746504, 1.053801, 0.847150, 0.442478, 0.416124, 0.564460, 1.167217, 0.842014, 0.214765, 0.768722, 1.211185, 1.112814, 0.575527, 0.337043, 0.590134, 0.923955, -1.565152, -1.786976, -0.517467, -0.072617, -0.296665, -0.672563, -0.394736, -0.931086, -0.283818, -0.231754, -0.170660, -0.133808, -0.030953, -0.114648, -0.266593, -0.105690, -0.323738, -0.364531, -0.231001, -0.352169, -0.163870, -0.478948, -0.646768, -0.370461, -0.369498, -0.446335, -0.566768, -0.563974, -0.390854, -0.506287, 0.079452, 0.234200, 0.436872, 0.335861, 0.215336, 0.376755, 0.290407, 0.313824, 0.143636, 0.260214, 0.468001, 0.552728, 0.482969, 0.659841, 0.448883, 0.179692, 0.564773, 0.795067, 0.945534, 1.128785, 0.826312, 0.408299, 0.309030, 0.230863, 0.165077, 0.188929, 0.256303, 0.481722, 0.838628, 0.469573, -1.017896, -1.449685, -0.171345, -0.096175, -0.545484, -0.622786, -0.352875, -1.135408, -0.154106, -0.385206, -0.345811, -0.239634, -0.064293, -0.064412, -0.047355, 0.019081, -0.327361, -0.181807, -0.145968, -0.213214, -0.188646, -0.660967, -0.645067, -0.479075, -0.404126, -0.431979, -0.575374, -0.602885, -0.534758, -0.451821, -0.501756, -0.168911, 0.702000, 1.227932, 1.773078, 1.861506, 1.621953, 1.552966, 1.446345, 1.120241, 1.015716, 1.258426, 1.384640, 1.633168, 1.726003, 1.980885, 2.247103, 1.493503, 1.062818, 1.138942, 1.573591, 1.335449, 1.016280, 1.060241, 0.895140, 0.850712, 1.297201, 1.776711, 1.345333, 0.932354, 0.543443, 0.548396, 0.441156, -0.140421, 0.557394, 0.210459, -0.092640, 0.124381, 0.008384, 0.045934, -0.007708, 0.150458, -0.294009, -0.243011, -0.015791, -0.188525, -0.040108, 0.009145, -0.105102, -0.284055, 0.669676, -0.094034, -0.584709, -0.157849, -0.251730, -0.375563, -0.423670, -0.305765, -0.521628, -0.513682, -3.248872, -2.128810, -1.233852, -0.363389, -0.100290, -0.639634, -0.309029, -0.097152, -0.913721, -0.743844, -0.249070, -0.329920, -0.380763, -0.878466, -0.693501, -0.585474, -0.588856, -0.632812, -0.596747, -0.664338, -1.137333, -0.710806, -0.494163, -0.556965, -0.675260, -0.703767, -0.153617, 0.085452, -0.188665, -0.027332, 0.642886, 0.325101, 0.897206, -0.254188, -0.014091, -0.307381, -0.538615, -0.057379, -0.286042, -0.084096, -0.259078, -0.046605, 0.161868, -0.081175, 0.019380, -0.050761, -0.038889, -0.093338, -0.134810, -0.273165, 0.419527, -0.458746, -0.663715, -0.150068, -0.620458, -0.486992, -0.594013, -0.383762, -0.650338, -0.632626, -2.228514, -1.024900, -0.090369, 0.764813, 1.153910, 1.206737, 1.186055, 1.039801, 0.755263, 0.539042, 0.096875, 0.318974, 0.416418, 0.652618, 0.847248, 1.001493, 1.279044, 0.805848, 0.609960, 0.477343, 0.851744, 0.635926, 0.327178, 0.435723, 0.428653, 0.175611, 0.462315, 0.684466, 0.345844, 0.677268, -0.765833, -0.442720, -0.027032, -0.256783, -0.224398, -0.230132, -0.357175, -0.328809, -0.415123, -0.416660, 0.078225, 0.193895, 0.086657, -0.295349, -0.308586, -0.492882, -0.034783, -0.180394, -0.355240, -0.438947, 0.489666, -0.145983, -0.519191, -0.466666, -0.150959, -0.488459, -0.549443, -0.460429, -0.571094, -0.452848, -0.201791, -0.476430, -0.472335, -0.457321, -0.539000, -0.333145, -0.104786, -0.027094, 0.358984, 0.201475, -0.304459, -0.158985, -0.065774, 0.089938, 0.186803, 0.565043, 0.699966, 0.445753, 0.293881, 0.016578, 0.011317, -0.189531, -0.271902, 0.012027, 0.171327, -0.086796, -0.127388, -0.042267, -0.074934, -0.320264, -0.380376, -0.155906, -0.170714, -0.280705, -0.240502, 0.167658, -0.386623, -0.253900, -0.538918, -0.168437, 0.028469, 0.073767, -0.018749, -0.566830, -0.331566, -0.304612, 0.147698, 0.166322, -0.109128, -0.454253, 0.074341, -0.206976, -0.611243, -0.497852, -0.436949, -0.517936, -0.531383, -0.546711, -0.579429, -0.464554, 0.338130, -0.603442, -1.225257, -0.730934, -0.947817, -0.891510, -0.805661, -0.661526, -0.575828, -0.686728, -0.536467, -0.250960, -0.260044, -0.374283, -0.290659, -0.629430, -0.626424, -0.406057, -0.462443, -0.692290, -0.724165, -0.597340, -0.327010, -0.504581, -0.759052, -0.493747, -0.633143, -0.686411, -0.718744, -0.636690, -0.695477, -0.258528, 0.397427, 0.477186, -0.411703, -0.149387, -0.304106, -0.204625, -0.339227, -0.323272, -0.205047, -0.276596, -0.552132, -0.340480, -0.106184, -0.246883, -0.023005, 0.039461, -0.285056, -0.357948, -0.182672, 0.181043, 0.358609, -0.146509, -0.164592, 0.462059, 0.008311, -0.065340, 0.017261, -0.013759, -0.626111, -0.557304, -1.277256, -1.437280, -0.926694, -1.028175, -0.788684, -0.858896, -0.735251, -0.537746, -0.349389, -0.502850, -0.541807, -0.612760, -0.862830, -0.272913, -0.534868, -0.739401, -0.517522, -0.875132, -0.899122, -1.332800, -1.366480, -0.807069, -0.720436, -1.356121, -1.099459, -1.083575, -1.088578, -1.038714, -0.002978, 0.323772, 0.644523, 0.742202, -0.291918, -0.112417, -0.237176, -0.170494, -0.132396, -0.367346, -0.185127, -0.378819, -0.455244, -0.354443, -0.131706, -0.264114, 0.244837, 0.370771, -0.150832, -0.200944, -0.064651, 0.839099, 1.038755, 0.403618, 0.129704, 1.107371, 0.532426, 0.193130, 0.554329, 0.512245, 0.977867, 1.093244, 0.795788, 1.041077, 0.956134, 0.906742, 1.053846, 0.902760, 0.544459, 0.349717, 0.597862, 0.549178, 0.424699, 0.250913, 0.522026, 0.729282, 0.980455, 0.832631, 0.258875, 0.378316, 0.655871, 0.620333, 0.422412, 0.744846, 0.813069, 0.597032, 0.598346, 0.807369, 0.739646, 0.525290, 0.211105, 1.772778, 1.038487, 1.052170, 1.384388, 1.931857, 1.592860, 1.874187, 3.156876, 0.848286, 0.548391, 1.196148, 0.714248, 1.314410, 1.177574, 2.792608, 2.206442, 0.807968, 0.399575, 0.976812, 0.978108, 1.052244, 0.749882, 1.739344, 0.723488, 0.808977, 1.244321, 1.807525, 1.306813, 0.410026, 0.072154, 1.890914, 2.733637, 2.755013, 1.987936, 0.994976, 1.485456, 2.971303, 3.566153, 2.827874, 1.993380, 1.572098, 1.856448, 2.103474, 2.551499, 4.683340, 4.490339, 2.643804, 2.209663, 2.887175, 2.289704, 2.534420, 2.107838, 2.150443, 1.670783, 2.605937, 3.088552, 3.063814, 2.349524, 1.612165, -0.011772, 0.784818, 0.977575, 0.881813, 1.641879, 2.751794, 2.447456, 2.614645, 3.837142, 1.590182, 0.511760, 1.159535, 0.741581, 0.210274, -0.187550, 2.067278, 2.892613, 0.951493, 0.046832, 1.364339, 0.859088, 0.973116, -0.135257, 1.081256, 0.946839, 0.728602, 0.968273, 1.397149, 0.962849, 0.026330, 0.360312, -0.773828, -1.084620, -0.794139, -0.989339, -0.864331, -0.795094, -0.576876, -0.550682, -0.671576, -0.509547, -0.298505, -0.207283, -0.237204, -0.224560, -0.609712, -0.596402, -0.224682, -0.316519, -0.721533, -0.677420, -0.550295, -0.139558, -0.343158, -0.684251, -0.383772, -0.554724, -0.547769, -0.562653, -0.574728, -0.409919, 0.649902, 0.533447, 0.493083, 0.091182, 0.364372, -0.030432, -0.038864, 0.227521, 0.036056, 0.208540, 0.254361, -0.231492, -0.122519, 0.261288, 0.006405, 0.142502, -0.025406, 0.152533, -0.123808, -0.200256, 0.227067, 0.505545, 0.244252, 0.131583, 0.654210, 0.183650, 0.039894, 0.108208, 0.000009, -0.898638, -1.996455, -1.811157, -0.864018, -0.681807, -1.091327, -0.843779, -0.605639, -1.056706, -1.176004, -1.078096, -0.867286, -0.688656, -0.572824, -0.867688, -0.951556, -0.875941, -0.935012, -0.637353, -0.507891, -1.020849, -1.313524, -1.441848, -1.600963, -1.336472, -1.492062, -1.153347, -0.835898, -0.831106, -0.980538, -0.073017, 1.783366, 1.076874, 0.866856, 0.376879, 0.530318, 0.099512, 0.089365, 0.291792, 0.468668, 0.582307, 0.337353, -0.123008, -0.143749, 0.476068, 0.455600, 0.137672, 0.403113, 0.637935, -0.095424, 0.069986, 0.849199, 1.150625, 0.900764, 0.722485, 1.394165, 0.894495, 0.517967, 0.643033, 0.482493, -0.644976, -0.873148, -0.918572, -0.745221, -0.830631, -0.761042, -0.776950, -0.734546, -0.668871, -0.750116, -0.549784, -0.613337, -0.758467, -0.839804, -0.960034, -0.920809, -1.029649, -1.092692, -0.970387, -0.899244, -0.989712, -1.125720, -1.093840, -0.995046, -0.872036, -0.976225, -0.998799, -0.989830, -1.030663, -1.010548, 0.329030, -0.011928, 0.105536, -0.173048, -0.239885, -0.283513, -0.237925, -0.173992, -0.044138, -0.314510, 0.043307, 0.037727, -0.161929, -0.173781, -0.144815, -0.040782, -0.192762, -0.396689, -0.301877, -0.152067, -0.185025, -0.588371, -0.473814, -0.413528, -0.305358, -0.434890, -0.423671, -0.365433, -0.429589, -0.525000, 0.972148, 0.876593, 0.980923, 0.929167, 0.785890, 0.747870, 0.622117, 0.283295, 0.187831, 0.343861, 0.805792, 0.957456, 0.886392, 0.746801, 0.843718, 0.844445, 0.964931, 0.666513, 0.614074, 0.903964, 0.722631, 0.686624, 0.691488, 0.765102, 0.701425, 0.862595, 0.788607, 0.678300, 0.585836, 0.677062, 0.255524, -0.155338, 0.313492, 0.045713, -0.506855, -0.486057, -0.274307, -0.147974, -0.031248, -0.301459, 0.133663, 0.056034, -0.022587, -0.173167, -0.083445, -0.242665, -0.189875, -0.443711, -0.423307, -0.098420, -0.309925, -0.552786, -0.528826, -0.431544, -0.317501, -0.455037, -0.467129, -0.437330, -0.505305, -0.508901, 1.986121, 3.429169, 4.418689, 4.700963, 4.335473, 3.958577, 4.172637, 4.813382, 4.726564, 5.005250, 4.715168, 4.740057, 4.624597, 4.681287, 4.089235, 3.653266, 3.396261, 3.555772, 4.109525, 3.959747, 3.558982, 3.293491, 3.231249, 3.386149, 3.611495, 3.553030, 3.577586, 3.261524, 3.569194, 3.529922, 2.839426, 5.572255, 7.511418, 7.547038, 7.616623, 8.479989, 8.700396, 8.517416, 7.985641, 7.720409, 8.073325, 9.099886, 8.509536, 8.701296, 8.703886, 8.108105, 7.797690, 8.422695, 8.577974, 8.168417, 8.735829, 8.880055, 8.411798, 8.711239, 7.007748, 7.696002, 8.124721, 7.758350, 7.526995, 7.519127, 0.805458, -2.207894, -3.328928, -3.548572, -4.655574, -4.751044, -5.122685, -5.351140, -4.425599, -4.921854, -4.196514, -4.158425, -3.977187, -5.440221, -4.870886, -3.695509, -4.611489, -5.815653, -6.384917, -5.636851, -6.146891, -5.755413, -5.014410, -5.955095, -5.925106, -5.107705, -5.775111, -5.200213, -5.469500, -5.933361, 5.566429, 4.871155, 5.271683, 4.749051, 4.894484, 6.509562, 6.056101, 5.252151, 5.603601, 5.534760, 5.341521, 6.294177, 6.040930, 6.611418, 6.239672, 6.030227, 5.669366, 6.724945, 6.146245, 6.604219, 6.651597, 7.060551, 5.986476, 6.806278, 5.722785, 5.840815, 6.194176, 6.404887, 5.891372, 5.038606, 0.925790, 0.775954, 0.818238, 0.795986, 1.028621, 1.160355, 1.454136, 1.219927, 0.545232, 0.474427, 0.384854, 0.086273, 0.306505, 0.420341, 0.351043, 0.431457, 0.441713, 0.371025, 0.224052, 0.234152, 0.239811, 0.389238, 0.366593, 0.391446, 0.262977, 0.060737, 0.276996, 0.682700, 0.723223, 0.254932, -0.279730, 0.803418, 0.266745, 0.164318, 0.761007, 0.970764, 1.963222, 2.173201, 0.980781, 0.077159, 0.058500, 0.006691, 0.320843, 0.338689, 0.443639, 0.038677, -0.330180, -0.151314, -0.408651, -0.369864, -0.077241, 0.212935, -0.185706, -0.144035, -0.205470, -0.488889, -0.147669, -0.073345, -0.109969, -0.106226, -0.244214, -0.269139, 0.712214, 0.784388, 1.237357, 2.076048, 2.455503, 2.173928, 0.361487, 0.279063, 0.206515, 0.059766, -0.236796, -0.205439, 0.299699, 0.528692, 0.507426, 0.557325, 0.619576, 0.342899, -0.009891, -0.034946, 0.063178, 0.321516, 0.641055, 0.294618, 0.299255, 0.400368, 0.396265, 0.925736, -0.716688, 0.546488, 0.168437, -0.138973, 0.305800, 0.795160, 1.752399, 1.881469, 1.341264, -0.152907, -0.033513, -0.087608, 0.428964, 0.031636, 0.426035, -0.131500, -0.130501, 0.152096, -0.649387, -0.411963, 0.090475, 0.192814, -0.164187, -0.598825, -0.363251, -0.537404, -0.371254, -0.352903, -0.124538, -0.400042, -0.034151, 1.707379, 0.183383, 0.701746, 0.857340, 0.814511, 1.034544, 1.044772, 1.136086, 0.929660, 0.597829, 0.811287, 1.149999, 0.921540, 0.757919, 1.108433, 0.945921, 0.337251, 0.358615, 0.591409, 1.027005, 0.670007, -0.022837, 0.706463, 1.267821, 1.192980, 0.514848, 0.234833, 0.621993, 0.994307, -1.548414, -1.341775, -0.380721, -0.092035, -0.466805, -0.699051, -0.337074, -0.642991, -0.328190, -0.142918, -0.282461, -0.433479, -0.050407, -0.379772, -0.581612, -0.312456, -0.254256, -0.454612, -0.307498, -0.444116, -0.245135, -0.442936, -0.671487, -0.415469, -0.493432, -0.537343, -0.487362, -0.442962, -0.567335, -0.588734, 0.316946, 0.042726, 0.064102, 0.268355, -0.117436, -0.618712, -0.827999, -0.478683, -0.315223, -0.191591, -0.411123, -0.580564, -0.376317, -0.234353, -0.076132, -0.428576, -0.376467, -0.146590, -0.083024, -0.055579, -0.293650, -0.255515, -0.174652, -0.190269, -0.284209, -0.319746, -0.102351, -0.179189, -0.140750, 0.022434, -0.704079, -0.938449, -0.293881, -0.316284, -0.630918, -0.707488, -0.301308, -0.448867, -0.389710, -0.399594, -0.480887, -0.467416, 0.001480, -0.318419, -0.698456, -0.224921, -0.133616, -0.315519, -0.405057, -0.423813, -0.333327, -0.503883, -0.577351, -0.299176, -0.496927, -0.605531, -0.405246, -0.406589, -0.614136, -0.621516, 0.523979, -0.149311, -0.138285, 0.028674, -0.029942, -0.165735, -0.132020, -0.114846, -0.144165, -0.241994, -0.346136, -0.322929, -0.370155, -0.398908, -0.302237, -0.226486, -0.156021, -0.178078, -0.228918, -0.277058, -0.271823, -0.100472, 0.000772, -0.143939, -0.369981, -0.392398, -0.322303, -0.268389, -0.312585, -0.187826, -0.535219, -0.078345, 0.000988, 0.045910, -0.112270, -0.088164, -0.273981, -0.261853, -0.086132, 0.023440, -0.136040, -0.097014, -0.161873, -0.016659, 0.070944, 0.092033, 0.103908, 0.177032, -0.092764, -0.136100, 0.137915, 0.271149, 0.476497, 0.327117, 0.065531, -0.153418, 0.023841, 0.132007, 0.255815, 0.641558, 0.255536, -0.080507, 0.555532, 0.430875, 0.086292, 0.105538, 0.158347, 0.384029, 0.721965, 1.020381, 0.904440, 0.752810, 0.566256, 0.694950, 0.974806, 1.358803, 1.348397, 1.107123, 0.929208, 1.058405, 1.599822, 1.386412, 1.668069, 1.634747, 1.109293, 1.001052, 1.164478, 1.278279, 1.386182, 1.763351, 0.074815, -0.180781, -0.037248, -0.155352, -0.186655, -0.275338, -0.229665, -0.183858, 0.044698, 0.045989, 0.082582, 0.097225, -0.164483, 0.391762, 0.307574, 0.481338, 0.601376, 0.484530, 0.136578, 0.124550, 1.015810, 1.011760, 1.151937, 1.006941, 0.442857, 0.140812, 0.549408, 0.818864, 1.002536, 1.443222, 1.105757, 1.458438, 1.020796, 0.718893, 0.982392, 1.237929, 1.139534, 0.499433, 0.101174, 0.393961, 0.399391, -0.022423, 0.012935, 0.027509, 0.284289, 0.383840, 0.396944, 0.420824, 0.237122, 0.287246, 0.218292, 0.389379, 0.492747, 0.414828, 0.338535, 0.161166, 0.528815, 0.745309, 0.556118, 0.154482, -0.323569, 1.729436, -0.175206, -0.386016, 0.253112, 0.280150, 0.419979, -0.218601, 0.166408, 0.029457, -0.038175, -0.008255, -0.052055, -0.183520, -0.002235, -0.257580, -0.172371, -0.216818, -0.209443, 0.039594, 0.030313, 0.332404, 0.271373, -0.041052, -0.031686, -0.238264, 0.203716, 0.024201, -0.009345, -0.225318, -0.188984, -0.134670, -0.280172, -0.277736, 0.014193, -0.131514, -0.056959, 0.069805, -0.107183, -0.223839, -0.040827, -0.004239, -0.128849, -0.024142, -0.153583, -0.023707, -0.056881, -0.207937, -0.406622, -0.252391, -0.234791, 0.034272, 0.007440, -0.073095, -0.047573, -0.234246, -0.286751, -0.114804, -0.094478, -0.209032, -0.688400, 0.840270, -0.364485, -0.420753, 0.011615, 0.272796, 0.353114, -0.210432, 0.109533, 0.225879, 0.148746, 0.025759, -0.051653, -0.203119, -0.060190, -0.222998, -0.162492, -0.339077, -0.250871, -0.062902, -0.082458, -0.147396, -0.272367, -0.232932, -0.045637, -0.384915, -0.110983, -0.214399, -0.215733, -0.483372, -0.217688, -0.591801, 0.077703, -0.099305, -0.263777, -0.507299, -0.739706, -0.483829, -0.334313, -0.397022, -0.343127, -0.168571, 0.087520, 0.132470, 0.083145, -0.177499, 0.152723, 0.524872, 0.429033, -0.029092, -0.041372, 0.283168, 0.492668, 0.231725, -0.071044, 0.112699, 0.283328, 0.118901, 0.040282, 0.005940, -0.294130, -0.002227, 0.306773, 0.186823, 0.178952, -0.128692, -0.266416, 0.009358, -0.209343, -0.271282, -0.209812, -0.129066, -0.230501, -0.216827, -0.229152, -0.237981, 0.261218, 0.362841, 0.158832, -0.170755, -0.247298, -0.237199, -0.199164, -0.219171, -0.009199, -0.063420, -0.093832, -0.195389, -0.013455, -0.281057, 0.164160, 0.730064, 0.604285, 0.634725, 0.614639, 0.699123, 0.586259, 0.457470, 0.381135, 0.453081, 0.509534, 0.634327, 0.693872, 0.602885, 0.521531, 0.562896, 0.640515, 0.507021, 0.186961, 0.306240, 0.681229, 0.605748, 0.595849, 0.732191, 0.646137, 0.496813, 0.488378, 0.531085, 0.461245, 0.459281, -0.211159, 0.772666, -0.474998, 0.037252, 0.098812, -0.026585, -0.360635, 0.054022, -0.342641, -0.427100, -0.318529, -0.189805, -0.400325, -0.329341, -0.282049, -0.307837, -0.029554, 0.081365, 0.037887, -0.318785, -0.340447, -0.358316, -0.446246, -0.418648, -0.264267, -0.390648, -0.409014, -0.404004, -0.310457, -0.438172, 0.579924, 0.382002, 0.126790, 0.202623, -0.094805, -0.451717, -0.588467, -0.505820, -0.070363, 0.109312, 0.113635, 0.169526, 0.070144, -0.093862, -0.280624, -0.240238, -0.087496, 0.079536, -0.003549, 0.140720, 0.346345, 0.462071, 0.475802, 0.353440, 0.505225, 0.439086, 0.224357, 0.354609, 0.445375, 0.725494, 0.097638, -0.003807, -0.411392, 0.180722, 0.103266, 0.219553, 0.179451, -0.059958, -0.094365, -0.133458, -0.095369, -0.092222, -0.104015, 0.024043, -0.096199, -0.179315, -0.319547, -0.263391, -0.325367, -0.247301, -0.049968, 0.032935, -0.143468, -0.393320, -0.257291, -0.085711, -0.326619, -0.194013, -0.252227, -0.015194, 0.572127, 0.314652, 0.469442, 0.707301, 0.989534, 1.150668, 1.150440, 0.902829, 0.660834, 0.583510, 0.501366, 0.708796, 0.790221, 0.824592, 0.769865, 0.362973, 0.438257, 0.303476, 0.479625, 0.610372, 0.551128, 0.373321, 0.246985, 0.241856, 0.422678, 0.292194, 0.313291, 0.336198, 0.439025, 0.432058, -0.340499, -0.534044, -0.306036, -0.046744, 0.148137, 0.278064, 0.335705, 0.071315, -0.208277, -0.292005, -0.184575, -0.294520, -0.120648, 0.042876, -0.216847, -0.305257, -0.480292, -0.434176, -0.474870, -0.344825, -0.311295, -0.434374, -0.512526, -0.631968, -0.341380, -0.331286, -0.580161, -0.507222, -0.568167, -0.525238, 0.510007, -0.690228, 0.406447, 0.405461, 0.669424, 0.603264, 0.174572, 0.041682, 0.074027, -0.226181, -0.624060, -0.548410, -0.511117, -0.405273, -0.342527, -0.078010, 0.130005, 0.259152, 0.470202, 0.190251, -0.173483, 0.250560, 0.211871, -0.115742, -0.352038, 0.067257, 0.110606, -0.070902, -0.240527, -0.238935, -0.211753, -0.002648, -0.117012, -0.526143, -0.182426, 0.012194, 0.011405, -0.092427, -0.169330, 0.027161, -0.211618, -0.037983, -0.393990, 0.035824, 0.189551, 0.257666, 0.198435, 0.238539, 0.246841, -0.030208, 0.048116, 0.550052, 1.085247, 0.289467, 0.070461, 1.191356, 0.836687, 0.451523, 0.492941, 0.413366, -0.437183, 1.223966, 0.622200, 0.714971, 1.328152, 0.666310, 0.796909, 0.766067, 0.538525, 0.543398, 0.367190, 0.454867, 0.506016, 0.245909, 0.159589, -0.145231, 0.402920, 0.059715, 0.375404, 0.433499, 0.180783, -0.296040, -0.135623, 0.180722, 0.030678, -0.223629, -0.009769, 0.204627, 0.020219, -0.039178, -0.181933, -0.052714, -0.065052, -0.323429, 0.435863, 0.349538, -0.195547, 0.015860, -0.185281, 0.052970, -0.305249, -0.169671, -0.480898, 0.080646, 0.263183, 0.324315, 0.128550, 0.549902, 0.683757, 0.096906, 0.298159, 1.283264, 1.461239, 0.416979, 0.171814, 1.613844, 1.405928, 0.949700, 1.047450, 0.811820, -0.947382, -1.049258, -0.451070, -0.349323, -0.688500, -0.910452, -0.959450, -0.866962, -0.657270, -0.593724, -0.420459, -0.606856, -0.696160, -0.872129, -0.977715, -0.706782, -0.832593, -1.022174, -1.083231, -0.955688, -0.854789, -0.986107, -1.003503, -0.821304, -0.610821, -0.770371, -0.739589, -0.896051, -0.874557, -0.765612, 0.810032, -0.241283, 0.270728, -0.140334, -0.155110, -0.156263, -0.198515, -0.147812, -0.079523, -0.550954, -0.179303, -0.251037, -0.294371, -0.286820, -0.537136, -0.279391, -0.339839, -0.328621, -0.227351, -0.102828, -0.391077, -0.555112, -0.762484, -0.559670, -0.328151, -0.564136, -0.464273, -0.556928, -0.553260, -0.603494, -0.823367, -0.855197, -0.969279, -1.189939, -1.071031, -0.793030, -0.549089, -0.282072, -0.152946, -0.237545, -0.192014, -0.261164, -0.171773, -0.396074, -0.246209, -0.285647, -0.696335, -0.554041, -0.574002, -0.491449, -0.325488, -0.224174, -0.133451, -0.368562, -0.530802, -0.502538, -0.146464, -0.265239, -0.211295, -0.241883, 0.666129, -0.182037, 0.323340, 0.142336, -0.064005, -0.058263, -0.083162, -0.168714, 0.078556, -0.490663, -0.261107, -0.356099, -0.326487, -0.352701, -0.636061, -0.484069, -0.212018, -0.182802, -0.079335, -0.064917, -0.328264, -0.558796, -0.726969, -0.630013, -0.418502, -0.710738, -0.636887, -0.557793, -0.677176, -0.666770, -0.186871, -0.329367, 0.324267, -0.341388, -0.518748, -0.582148, -0.779985, -0.494647, -0.299481, -0.458493, -0.379608, -0.154089, 0.033449, 0.078750, 0.099808, -0.229398, -0.023298, 0.382125, 0.353272, 0.083802, 0.003643, 0.112607, 0.445692, 0.198558, -0.086341, 0.063039, 0.268656, 0.088331, 0.086706, -0.042742, -0.561122, -0.297341, 0.142256, 0.104890, 0.292866, -0.105235, -0.308438, 0.329088, 0.312987, -0.255475, -0.268348, -0.171876, -0.155792, -0.195853, 0.320681, 0.008956, -0.023130, -0.042402, 0.060015, -0.316831, -0.327469, -0.408612, -0.222656, -0.134623, -0.013334, -0.101319, -0.242231, -0.230172, -0.053516, -0.271722, 0.104527, -0.214672, -0.508102, -0.675499, -0.512193, -0.274089, -0.005483, 0.409502, 0.156527, 0.068652, 0.237963, 0.358735, 0.652435, 0.830038, 0.266599, -0.149757, -0.450515, -0.180280, 0.179934, -0.149225, -0.443821, -0.069283, -0.255364, -0.100412, 0.026553, -0.038799, -0.183427, -0.265321, -0.381099, -0.220786, -0.226310, 0.843611, -0.206940, -0.280662, 0.002373, -0.099852, -0.538561, 0.198447, 0.351163, -0.269960, -0.380124, -0.385198, -0.193645, -0.144508, 0.321069, 0.252393, -0.059860, -0.208715, -0.059526, -0.370365, -0.400399, -0.463091, -0.304574, -0.249829, -0.117009, -0.216734, -0.338414, -0.268845, -0.186347, -0.298973, 0.182364, 0.574956, 0.900739, 1.468459, 1.202498, 0.381909, 0.448659, 0.659345, 0.803727, 1.323971, 1.292346, 1.204668, 1.331891, 1.191730, 1.104220, 0.645507, 0.558322, 0.783825, 0.911101, 1.166200, 1.215021, 1.144870, 0.988402, 0.884666, 1.573018, 1.631827, 1.150410, 1.003091, 1.177163, 1.681070, 1.631975, 3.786627, 3.941437, 2.933505, 3.206874, 3.112519, 3.280001, 4.132471, 3.261507, 2.981519, 2.387749, 3.834417, 3.693470, 3.786375, 3.798901, 3.682681, 3.550072, 4.465265, 4.374548, 3.753073, 2.825348, 3.243853, 2.201659, 2.188715, 1.991189, 2.391895, 3.284490, 3.251184, 3.467064, 3.086718, -3.790624, -5.136510, -3.746901, -3.044727, -3.859596, -3.916773, -2.896734, -4.788433, -4.575911, -3.805422, -2.176225, -2.370671, -3.558118, -2.072953, -3.034355, -3.818598, -3.998858, -3.447429, -3.174968, -2.977286, -2.670934, -3.446949, -2.183140, -2.138467, -2.280447, -3.704653, -4.569304, -4.658110, -5.342995, -4.084728, 3.070726, 5.217559, 5.492346, 4.021374, 4.979076, 4.427441, 4.855426, 6.602116, 5.215660, 4.149743, 2.994902, 2.996697, 4.080347, 4.368471, 4.291225, 4.529431, 4.071950, 5.045143, 4.457902, 4.163539, 2.898436, 2.939416, 1.686400, 3.401137, 3.150198, 3.148133, 4.198269, 4.145930, 4.490395, 3.501701, 1.619642, 0.566093, 1.322067, 1.799100, 1.729129, 1.686311, 1.702487, 2.017306, 2.088306, 2.136546, 2.105793, 2.190871, 2.295616, 2.159484, 1.839320, 1.580899, 1.447741, 1.671713, 1.883187, 1.948209, 1.658524, 1.467706, 1.521229, 1.490258, 1.462324, 1.572618, 1.400554, 1.285048, 1.270517, 1.027152, 0.737362, 0.933140, 0.689183, 0.503394, 0.597895, 0.420544, 0.545728, 0.456867, 0.681821, 0.733506, 0.060472, 0.769170, 0.943167, 0.735826, 0.611909, 0.682243, 0.710010, 0.704109, 0.996334, 1.183255, 0.969918, 0.508763, 0.828920, 0.936376, 1.504353, 1.364377, 1.335089, 1.509929, 1.615595, 1.528759, -0.107457, -0.521680, -0.433953, 0.099179, -0.233513, -0.602532, -0.194005, -0.570630, -0.533714, -0.369811, -0.178568, 0.091034, 0.149661, -0.134371, -0.425599, -0.454813, -0.928619, -0.681018, -0.626906, -0.745739, -0.330856, -0.322850, -0.438354, -0.664538, -0.635048, -0.362458, -0.667919, -0.654291, -0.639955, -0.841058, 0.322894, 1.799030, 1.279954, 0.656660, 0.411584, 0.646203, 1.024160, 0.366096, 0.112166, 0.533579, 0.238582, 0.752030, 0.812880, 0.330782, 0.523585, 0.381801, 0.296805, 0.780735, 0.482230, 1.034955, 0.410317, 0.124517, 0.593097, 0.757879, 1.047990, 0.996330, 0.933380, 1.130322, 1.151582, 1.032251, 3.447188, 3.489876, 4.254257, 4.606026, 4.462481, 4.420259, 4.405978, 4.935718, 5.348064, 5.649478, 6.024090, 5.830585, 5.769955, 5.843894, 5.715734, 5.320433, 4.832883, 5.125821, 5.732190, 6.111737, 5.934188, 5.444571, 5.376042, 5.643713, 5.355426, 5.513801, 5.667430, 5.182760, 5.429428, 5.345870, 1.086328, 5.090430, 6.270892, 6.360809, 5.406413, 4.771792, 5.743855, 6.178429, 6.558243, 6.803184, 5.968780, 6.509229, 6.364866, 5.720221, 6.740456, 6.593036, 6.732945, 6.602261, 6.347466, 6.236105, 6.317769, 6.348106, 6.116844, 6.319452, 5.908956, 5.850652, 6.752671, 6.373026, 6.407078, 6.462807, 0.981663, 2.759269, 2.314559, 1.436044, 1.758640, 2.302555, 1.058749, 1.230587, 1.631395, 2.229825, 2.293077, 0.690543, -0.265845, 1.015273, 1.387419, 1.186015, 1.290956, 0.068292, 1.447435, 1.997668, 1.226030, 1.170252, 2.016593, 1.884011, 1.714904, 2.562375, 3.578567, 3.221515, 3.891862, 4.149964, 0.539516, 3.806453, 3.213478, 1.942461, 1.390312, 0.367946, 0.985851, 2.096144, 1.564052, 2.093435, 1.130999, 1.117890, 0.561607, -0.082492, 0.157463, 0.302888, 1.586485, 1.290395, 0.863739, 0.731111, 0.749196, 0.687941, 1.955789, 1.697513, 1.302484, 2.188238, 2.045852, 2.360170, 2.564424, 1.817709, 0.512263, -0.516651, 0.564845, 0.493349, 0.653893, 0.714280, 0.334430, 0.096453, 0.104952, -0.121739, -0.656924, -0.504829, -0.423767, -0.295240, -0.335595, -0.046894, 0.205051, 0.289418, 0.527565, 0.220789, 0.002855, 0.191417, 0.239618, 0.005364, -0.267173, 0.045438, 0.058628, -0.021046, -0.211741, -0.173979, -0.233075, -0.246825, -0.048653, -0.039452, -0.093063, -0.101207, -0.205054, -0.189055, -0.069906, 0.236120, 0.124625, 0.006138, 0.205981, 0.232851, 0.280143, 0.578689, 0.437759, 0.255801, 0.457401, 0.378255, 0.069950, 0.601235, 0.906803, 0.272050, 0.166521, 1.033191, 0.615277, 0.369137, 0.487985, 0.436126, 0.434701, 0.209660, 0.387730, 0.035425, -0.210856, 0.147902, 0.208580, 0.221844, 0.200445, 0.507589, 0.273574, 0.318829, 0.658836, 0.448133, 0.527464, 0.497260, 0.551535, 0.973354, 1.406471, 0.990183, 0.741164, 1.037577, 1.044345, 0.740799, 0.702855, 1.181627, 1.207263, 0.971195, 0.892964, 1.075423, -0.215547, -0.360708, -0.334987, -0.274641, 0.349860, -0.117283, -0.458406, -0.157961, -0.178553, 0.349494, -0.080390, -0.006885, 0.356604, 0.334330, 0.454750, 0.807178, 0.832044, 0.612038, 0.912086, 0.866090, 0.501649, 1.445849, 1.403857, 0.497812, 0.361734, 1.734401, 1.237482, 0.960271, 1.132685, 0.991369, -0.439094, 0.335574, -0.410384, -0.429036, -0.770131, -0.835782, -0.885771, -0.717791, -0.532880, -0.590859, -0.541481, -0.650529, -0.625723, -0.689066, -0.854768, -0.777071, -0.845555, -1.100350, -1.086493, -1.031559, -0.960958, -1.033002, -1.065012, -0.924141, -0.683177, -0.829931, -0.770214, -0.865143, -0.952231, -0.834548, -0.042395, -0.188009, -1.043305, -0.558620, -0.317631, -0.282586, -0.361339, -0.338491, -0.454260, -0.420794, -0.041514, -0.235294, -0.236951, -0.491947, -0.289886, -0.348152, -0.343351, -0.384115, -0.226562, -0.209420, -0.345398, -0.659981, -0.681088, -0.498951, -0.332003, -0.510091, -0.521122, -0.552726, -0.585532, -0.585740, -0.700171, -0.382152, -0.193638, 0.048122, 0.190475, 0.266276, 0.212551, 0.081982, -0.120101, -0.313834, -0.435474, -0.218817, -0.012587, 0.273299, 0.040990, -0.145786, -0.334524, -0.076386, 0.042098, 0.159974, 0.124809, -0.018734, -0.028954, 0.081837, 0.250137, 0.346694, 0.104267, 0.172711, 0.038381, 0.052216, 0.246394, -0.837358, -0.805997, -0.359485, -0.195395, -0.182014, -0.247012, -0.345813, -0.361845, -0.372103, 0.103574, -0.183844, -0.214597, -0.551001, -0.394418, -0.368625, -0.437935, -0.545302, -0.427242, -0.182352, -0.293489, -0.502930, -0.676382, -0.519664, -0.311269, -0.550511, -0.520331, -0.525860, -0.650429, -0.635953};
static RBF_CONST rbf_float RBF_WIDTHS[] = {4.728711, 16.487328, 4.484890, 4.248216, 3.269817, 13.655577, 3.178835, 3.926777, 9.909606, 5.206179, 14.188218, 2.587921, 2.801229, 4.451142, 3.564380, 4.881512, 13.536338, 2.844285, 13.070435, 2.959266, 6.896123, 4.019653, 3.829955, 16.487328, 3.201561, 52.051434, 3.943700, 5.488147, 8.574763, 12.818349, 12.857887, 3.114356, 12.217558, 3.458009, 3.874462, 2.832934, 3.458009, 3.193514, 3.367632, 4.135662, 3.229984, 2.840752, 4.865461, 3.874462, 20.892763, 2.981104, 3.191944, 3.864611, 9.108923, 3.316236, 4.330924, 3.573846, 3.570305, 3.092019, 3.211198, 3.563413, 7.995359, 5.045884, 3.801790, 3.663039, 2.915665, 3.169938, 11.634568, 3.678116, 12.788208, 4.508484, 3.220754, 6.627204, 3.979614, 3.464369, 2.587921, 14.188218, 2.981104, 3.806256, 3.578094, 3.776922, 3.122760, 3.236357, 3.348199, 3.678116, 4.097293, 3.013388, 8.929166, 3.057845, 21.204840, 2.649399, 3.546064, 3.143490, 4.853240, 2.844285, 2.645982, 2.995507, 12.199069, 14.651999, 10.804871, 14.512280, 13.926545, 12.005708, 2.649399, 2.666831, 7.476110, 3.914554, 3.963016, 2.935047, 2.984582, 2.832934, 2.840752, 2.893185, 4.043609, 19.901436, 4.241650, 13.070435, 3.592591, 2.645982, 3.348199, 4.392102, 3.774984, 11.537169, 4.897645, 4.097293, 11.465130, 12.818349, 3.092019, 3.574815, 3.236357, 21.939768, 8.126034, 16.076342, 8.126034, 3.546064, 3.546144, 3.663039, 3.468612, 3.942760, 3.763262, 2.941112, 3.570305, 7.223499, 2.801229, 3.790820, 2.984582, 3.721028, 5.406859, 13.985945, 3.559513, 3.721028, 2.709823, 13.303721, 13.510921, 10.160260, 7.438601, 17.028160, 11.561304, 3.169938, 10.804871, 5.948699, 5.519055, 3.743698, 2.709823, 3.403363, 3.148166, 14.913733, 13.536338, 3.618815, 11.561304, 9.108143, 3.108290, 3.254639, 3.210817, 4.214589, 3.108290, 3.470185, 3.598993, 11.334656, 2.858664, 16.076342, 3.776922, 8.378881, 3.413867, 5.634877, 3.148166, 4.018637, 13.547055, 4.213448, 2.935047, 15.880772, 6.227217, 2.666831, 4.082464, 3.344775, 2.945929, 3.114356, 4.333546, 3.482551, 3.060926, 12.217558, 7.995359, 11.802634, 3.857303, 2.959266};
static RBF_CONST rbf_float RBF_WEIGHTS[] = {-5.037305, -7.113726, 1.620301, 2.652190, -3.505197, 11.712187, -1.752147, -2.245183, 2.490680, 0.213657, 2.241455, -1.483685, -0.458208, 3.546292, 1.295707, 0.366390, 1.230715, 0.136653, -0.296590, -3.438193, -0.834330, -1.712876, 0.683658, -0.490442, -3.296743, 3.973367, 0.767518, 7.090965, -1.372221, 1.775314, -4.043901, -3.632971, 1.346261, 2.118066, -4.126111, -0.738931, -0.219384, 6.029340, 10.493980, -3.711919, 1.293880, -6.690810, -5.700540, -2.500954, 0.233611, -5.392003, 4.409179, 1.855039, -2.249788, -9.869128, 1.481626, 0.466768, 0.613604, 2.755631, 5.965509, 1.588421, 1.894696, -5.951199, 1.245895, 2.166930, -0.781871, 0.732533, -0.189549, -0.026535, 0.404586, -0.526363, 0.308771, -0.094404, -0.146605, 0.135072, -0.336768, 0.504423, 15.300653, -5.942256, 0.279044, -4.583579, -4.034006, -0.130733, 1.856980, -1.829654, 0.951711, -2.917056, 0.973888, 0.534640, -3.122979, -11.523494, -1.231488, 0.239183, -2.344889, 41.496243, 4.361613, 0.623892, -13.958438, -5.828038, -7.479482, -1.105063, -1.653246, 1.347301, -0.282256, -0.341820, 1.365487, -0.450576, -0.086506, -0.295445, -0.054169, 0.863432, -0.645575, 0.178148, 2.064466, 3.184122, -1.837006, -4.324065, -0.623450, -4.714244, -2.620431, 2.043408, -6.205591, 0.659466, 11.886019, 0.564679, -6.552285, -0.345954, -0.095074, 0.015534, -2.475603, 1.672313, 8.545338, -1.006197, -0.155108, -0.000896, 0.151757, 0.071116, 1.315866, -12.354501, 33.781496, -4.283221, 0.725394, 1.405620, -3.613498, -3.055632, -0.695512, -19.019493, 4.225346, 2.261385, 0.212051, 4.885099, -0.713097, -1.590504, 1.036903, -3.794739, 18.732265, -1.139170, 0.844872, -12.908567, 1.087569, -6.520413, -1.814238, -3.780794, 0.320619, -0.506899, -1.027441, -1.181174, -2.551354, 0.126656, 11.009677, 0.154887, -0.152426, -0.876192, 4.365589, -1.380364, 0.870503, 1.394166, -2.153730, 0.254897, 0.809472, 0.705286, -4.318881, 3.559629, -1.867766, -2.059511, 0.408995, 0.458037, -6.627062, -0.250401, -1.902479, 6.063594, -0.633804, 1.993969, -1.457209, 0.465336, 4.029919, -2.683960, 0.394412, 3.099065, 1.571991, -0.199561, -3.984600, -5.624206, 3.325199, 0.923630, -0.929693, -0.105769, -4.188647, 5.783802, 2.349847, 1.878305, -0.017985, -5.568852, 9.756341, -12.244427, -1.397695, -1.926995, 0.955445, 0.885665, 5.800085, -0.326104, -0.597680, 6.281428, -0.755973, -1.531836, -1.475523, 1.026517, 0.714056, -2.352188, -0.703699, 0.342541, 0.457032, -1.518978, -9.282453, 5.997246, 0.224778, -2.651715, 15.351133, 2.272135, 2.304148, 0.634579, -1.136109, -2.173472, -12.208897, 0.545834, -1.672013, -2.658928, -0.765590, 0.180071, -0.630450, 1.776647, 0.723018, 4.146839, -1.213093, 0.612363, -0.428303, -0.117049, 1.244732, -5.689784, 1.994973, -3.541039, -1.217921, 0.768908, 0.588118, 5.602997, -1.764179, 0.318675, 3.005121, -1.257352, -2.172466, -0.941479, 2.632622, 2.608527, 2.642918, 5.448298, 3.807123, 1.863269, -0.950745, -3.189135, -9.723451, -1.971144, -1.484692, -7.166258, -1.736483, -0.139936, 0.285543, -1.008179, -0.657362, 13.214439, -2.096319, 0.929504, -0.577853, 0.418101, -1.950773, -4.819471, -2.237749, 1.822858, 7.537713, -2.713760, 4.384867, -0.316012, 0.831282, 0.744743, 2.304769, -5.546125, -7.861862, -3.433530, -0.852162, -1.961994, 4.235195, -0.744651, 0.395871, -0.874314, 7.277945, 4.312531, -2.056561, 1.211640, 2.320486, -1.756051, -0.279924, -5.097476, 1.108937, -2.178304, 1.958998, 5.328260, 0.514453, -1.716333, -0.826348, 0.674903, -0.353255, 3.694871, 5.920024, -1.084871, 2.145660, -2.829961, 1.169958, -2.902090, 1.524830, -3.174211, -4.195916, 0.155498, 0.060397, 0.314525, -0.005765, -0.171995, -0.124444, -0.000197, 0.014989, -0.018245, 0.083356, 0.054551, -0.129563, -0.085102, 1.870875, 3.369204, -0.269962, -0.302381, -1.538867, 0.149621, -1.839159, -2.808876, 0.253582, 0.505132, -0.163409, 0.772290, 0.109064, 2.841748, -2.928233, 0.048856, -1.056553, -0.403790, 0.232365, 1.508736, 0.381354, -0.528427, 0.181249, -0.466160, 2.136282, -0.285873, -10.301924, -4.014255, 1.715288, -3.096203, -3.253355, -1.021370, 6.610517, 14.392655, 2.760753, -6.039491, -0.599606, -3.312531, -1.858753, 0.275494, 6.727281, 4.437978, 3.265560, 1.904286, -3.795263, -3.311065, -1.144395, -2.432750, -6.975922, -3.987721, 3.601248, 0.382812, 5.623249, -5.423312, 6.027567, 2.741828, 4.157906, -9.024744, 4.409605, -1.555969, -0.997381, 7.660588, -2.562062, -3.265346, 0.627428, -1.480308, 1.646691, 1.643440, 1.300753, -4.718559, -0.949901, 0.972226, 0.760005, 2.545079, -9.862734, 0.953953, -6.684537, -2.074065, -8.727554, 3.921828, 9.554562, 24.326411, -4.914095, -10.570252, 4.133218, -1.818798, -8.018281, 4.129579, -0.830975, 6.528765, 16.234476, 6.190767, -6.843005, -6.200543, -4.570005, -8.688657, -4.549414, -2.453822, -0.159448, 4.239986, 2.900130, -3.557217, -0.015197, 1.213367, 1.152818, -0.133603, 1.433085, -0.116847, -1.841903, 2.476721, -7.075556, -0.680417, 1.233665, 6.572811, 8.276426, -7.672935, -3.220850, -1.065215, -0.161994, 3.171890, 3.682567, 4.044851, -0.156026, -7.674124, -1.406279, -4.021873, -9.112004, 5.417724, 3.187377, 7.469412, -0.374116, -1.299095, -5.903562, 6.141613, 5.723003, -1.151220, 1.789452, 1.476031, -6.249059, 0.660678, 0.194962, 1.697734, -6.727028, 2.133219, 1.272095, 3.414861, 7.537393, -2.156895, -2.531583, 5.042480, 6.929458, -2.913696, 2.639552, -13.748430, -5.641629, 0.303579, -1.918013, -9.273513, -1.177851, -0.517596, 3.485424, -2.865145, -5.539067, -0.834582, 7.883208, 5.985213, 2.373638, 2.240337, 5.273674, -14.555176, 4.890750, -1.259385, 3.617142, 7.501229, -0.788799, 2.868329, -15.962052, 2.080133, 4.445745, 2.546635, 3.729241, -1.958666, -1.935100, -0.604359, 0.008842, -1.827118, 0.073426, 0.426824, 0.270928, 1.906591, -0.848561, 0.854279, 2.515343, -0.049301, -0.621137, -2.612509, -1.491032, -4.968591, 0.754758, 8.091829, 2.860254, -1.364789, -0.683960, -2.486931, 2.189761, 0.701065, 8.343328, -5.785713, 12.631605, -12.852571, -0.466943, -3.629888, -1.318200, -1.560815, 4.311041, -2.217907, -3.364333, -4.188025, 2.336083, -1.682142, 4.413255, 2.332777, 3.665112, -0.361658, 7.669590, -3.177763, -5.668328, -2.106041, -0.295597, 0.417691, -1.176062, -2.175516, 0.091953, -5.260000, 10.304523, -1.011007, 2.341754, 0.896946, 0.545314, -4.735101, -3.676961, 0.815676, -0.417950, -12.701852, 16.784872, -9.117040, -2.088770, 2.575411, 4.226987, 2.920261, 2.935371, -2.426976, 2.466428, 5.532934, -0.380377, -0.737447, -1.815760, 2.445811, 0.807087, 0.489612, -2.472922, -0.712983, -3.249307, -2.359623, -0.847519, -3.916810, -1.009012, -5.958001, 4.675934, 1.768131, 0.471023, 1.060968, -6.361125, 6.175402, 6.713188, -2.745346, 0.932414, -1.594349, 2.126095, -4.347100, 0.087187, 2.201215, -3.121122, 1.519688, -3.543459, 3.079363, -0.994012, 3.714749, 1.985393, -0.514771, 1.430318, -0.315554, 0.225195, -5.046956, -2.835901, -5.188590, 5.453175, 6.454589, -0.202134, -1.518868, 5.030890, -4.357938, -4.733577, 3.606575, -0.368625, 9.453703, -0.065133, 0.272197, 0.167816, -3.892723, -4.304075, -0.650532, 2.290099, 4.986498, -5.491897, -3.730934, -6.124465, -8.218568, 0.190055, -1.350709, 10.940404, 2.655404, 3.796580, -0.302405, 2.330356, 4.076752, -0.699113, -0.206598, -0.176051, -0.667756, -2.254877, -1.213535, -1.483763, 0.610014, 0.148092, -0.428018, 2.544225, -1.127049, -3.867852, 4.025921, 0.242226, 2.100084, -2.432773, -2.004740, -2.335445, 4.090383, 1.727139, -2.903525, 1.818658, 1.520802, -2.865070, 5.105744, 8.980657, -15.152685, -1.911802, 0.150866, 5.521535, 0.279671, -6.058036, 2.761120, -2.205089, 10.809000, 0.387183, -2.340684, 2.193492, -22.995720, -5.038200, 2.089252, 0.342085, 9.361501, 2.816010, 4.432187, -3.874128, 3.380829, -11.830261, 3.582568, -2.334110, -7.231774, -12.466982, -2.758469, -2.335340, 23.519890, 6.088210, 5.837411, 5.717150, 4.917114, -12.810121, 14.628993, -8.529897, 4.264983, 5.280868, -8.082199, -0.805095, 2.905511, -2.993171, -4.455612, -0.835337, 1.390115, -0.391626, -0.207705, 0.116837, -0.262054, -0.211614, 0.105877, -0.054863, 0.606019, -0.293382, -0.011409, -0.354627, -2.226529, 0.159405, 0.591784, -2.962070, -3.785871, 3.185628, -4.481129, 9.158117, 1.911127, 4.955586, -6.375316, -0.330293, -1.247558, -0.611417, -0.616684, -0.468497, -0.437956, -2.458706, -1.834031, 9.324024, -1.863010, -0.115327, 0.470137, -1.114447, -0.773466, -0.984335, -3.489144, -1.775003, 2.361417, 3.058509, 7.446028, 0.056069, -0.243630, -3.036362, -1.646297, 2.664300, 1.199190, -4.371892, -1.872662, -4.701363, 1.480179, -13.369314, 2.156733, -2.857843, 9.630062, 4.867332, 5.029530, -1.019749, 1.364535, -0.045870, -3.125706, -0.124456, -5.061371, -0.404753, -1.662512, 1.555407, 3.310040, 2.117485, 3.011293, -2.481368, -0.974647, 0.739078, -0.643634, -1.406161, -7.605140, -0.530572, 1.023796, -0.905675, -0.769106, 12.104001, 1.432579, -2.883096, 6.470009, -1.031348, 2.186962, -5.811461, -5.224065, 7.501800, 3.295323, 2.353672, 0.673663, -3.230568, -4.551805, 3.816016, -7.402135, 8.655806, 0.295342, -0.601982, 5.877983, -4.740547, 0.960483, -6.002682, -4.586442, -1.039220, 5.197464, 9.261605, -0.034500, -1.798876, -0.213750, 0.352794, -1.964400, -3.712108, -1.379056, -0.660987, 0.556843, -0.221363, 0.081094, -1.586081, -2.183208, -1.785785, 5.682779, 2.841209, 4.943495, -1.249157, 5.564481, -0.125692, -6.044270, 0.650856, -6.719286, -2.336772, -1.867781, 0.926939, -3.430796, -15.512216, 10.356615, -2.566863, 1.459532, 6.977581, -1.185715, -6.051416, 12.872262, -4.565439, 5.292020, -1.549696, -0.962151, -2.344947, 11.524089, 0.479121, -1.498520, 2.651932, -0.548885, -5.551459, -3.297590, 1.538769, 27.303811, -1.084100, 1.967682, -2.942617, -19.766524, 1.178721, -1.171101, -9.266558, 2.207408, -1.896678, 1.985677, 3.595757, 8.318689, 2.962504, -3.656422, 0.185254, -12.545521, -4.738423, -1.738030, -5.670377, -9.766717, -2.437149, 26.008586, 9.326013, -8.101621, 3.742898, -9.549255, 0.730832, -3.848191, 0.041957, -2.327422, -6.900030, 1.345091, 10.777907, 5.274814, -0.396404, -3.830022, -1.876909, 2.363296, 0.350941, -0.545646, -2.293757, -1.441400, 1.818959, -0.241856, 7.127900, -1.051028, 3.374648, 1.763196, 0.258094, -2.627575, -3.057054, -3.441260, -5.523162, 0.201546, 4.905157, 5.021096, -2.555340, 1.550899, 0.438009, 4.547243, 0.923254, -1.406208, 0.541729, 5.012399, -5.073936, -0.688272, -6.565886, -4.529209, 3.720079, 3.206253, 1.154759, 1.119758, -4.520239, 3.060838, -2.916244, -5.546723, 9.293003, 1.468415, -2.307776, -3.970178, -2.020084, 5.369188, -1.265689, -3.597877, -1.428546, -1.440588, 8.621446, 3.380841, 0.725534, -0.437332, -1.838231, -0.433941, -0.644576, -1.550978, -9.679883, -4.281104, 0.260104, 7.686510, 12.713057, 1.604097, 2.884609, -1.168686, 3.990667, -4.216827, -8.573817, -1.261501, -0.605215, 4.675865, -0.708809, -0.653536, -2.504475, -0.219929, 0.665754, -1.953625, 0.055619, 0.856203, -0.225119, 0.517951, -3.197989, 3.413926, -2.635364, 9.041639, -18.590302, 2.965486, 1.188816, 2.819481, -6.541816, 3.094735, 2.165924, 6.121649, -3.383593, -3.565923, 1.014705, 3.156777, 4.133703, -3.996939, -3.208486, -3.041682, 5.746960, 2.280774, -0.048493, 0.824267, 7.730168, 1.377702, -1.092354, -1.074729, -8.192447, -0.193242, -2.169438, 5.148130, 5.688932, 12.538972, -6.613836, -13.450531, -1.112860, 23.230364, 3.166571, 2.030373, 4.112091, 2.647338, -4.523009, -22.715912, -3.125781, -2.156135, -0.228531, -1.330025, 8.129048, 0.307703, -4.161442, -13.996965, -4.535995, 1.082022, 1.389574, 0.861121, -1.463318, 1.276109, 4.772065, 6.404616, -0.772454, 2.218017, -0.364605, 3.948670, -5.685603, -2.055935, -13.201037, -1.688022, -0.093740, 19.144370, -0.238469, -1.547031, 26.026821, -2.015424, -0.374746, -11.292526, -11.101063, -0.796952, 4.248329, 0.030501, -2.228268, -4.723195, -0.886942, 3.814876, -2.030672, 0.693735, 0.271472, 7.128800, 1.337318, -1.390749, -1.815078, -0.784021, 1.570859, 1.601332, -4.045434, -2.579524, -2.214090, 1.808871, 0.639951, -0.405646, -0.158412, 3.794141, -3.054987, -1.543118, -0.189517, 1.035535, -0.534422, 0.708316, 0.310473, -0.970507, 0.474835, 0.076844, 0.333029, 0.312293, -0.275215, -0.116253, 0.055336, -0.209835, 0.068360, -0.032467, 0.469094, 0.512457, -0.346132, -2.570712, 0.853013, -1.952254, -0.072073, 0.412674, -3.234313, -0.251930, 6.991311, -0.755855, -1.366011, -1.736187, -0.342884, 0.836702, -0.575537, -0.525786, -0.717333, -1.169046, -0.551344, 0.190636, 5.696771, 0.247812, -0.346548, 0.984428, 0.033381, 0.071406, 0.551739, -0.165779, 0.244030, -1.434623, -0.134690, 0.082084, -0.192399, 0.309283, -1.360653, -0.995369, -8.803983, 26.544599, -3.356991, 2.928507, 8.927116, -8.045374, 4.291716, -9.102600, -6.534956, -4.331367, 2.957287, 5.200574, -0.002872, -0.542494, -3.276455, 1.631147, -6.765451, 4.304095, -4.168039, 2.861786, -1.275752, -0.952522, 1.535318, -2.313720, 2.200939, -0.334703, -3.417067, -1.947305, -1.511434, -2.887969, -3.464806, -0.894756, 1.683402, 11.600328, -0.345460, 1.204583, -8.372504, 3.885970, -0.640867, 0.378675, 0.928199, -0.205935, -0.066005, 0.679946, 0.041540, 2.455263, 4.787202, -3.969271, 1.903531, -0.925355, -0.914757, 7.450241, -8.978301, -1.734863, -7.126784, 5.244694, 3.432881, 1.034709, -6.415225, 5.737306, -1.393795, -15.278023, 23.556871, -7.256151, 0.309924, 1.330922, -1.038693, -3.893249, 1.282509, 3.038005, 3.839185, -2.227826, 0.584631, -0.750927, -0.159654, 5.525440, 13.135231, -3.171296, -6.548400, -8.406978, -4.513349, 3.142056, -1.259637, -21.469774, 10.848321, -3.077951, 5.226541, 7.324050, 3.831036, 1.938465, 2.244446, -8.162404, 3.218104, -0.336171, 5.256900, -1.225176, 10.619558, -3.555846, 0.909968, -2.562901, -15.126029, -2.800447, -0.835614, 5.230764, -0.505281, 4.799758, -4.582484, 4.083421, -1.084741, -2.880376, 0.902083, -4.099664, -4.573875, 2.179786, -0.570436, 5.796729, 6.255317, -1.716430, 0.866571, -1.343212, 5.283433, 1.056401, 0.914545, 0.553566, 4.931792, -0.571812, -1.109301, -8.024250, -2.405595, 0.099377, -4.614575, 4.670069, 1.808102, -0.345146, 0.150833, -1.141053, -0.458064, 1.048608, -1.417106, 0.123040, -0.614294, 0.653760, 0.932198, -9.715132, 1.365417, 2.845005, -1.098833, 2.389885, -3.484007, -5.851698, 0.787462, 6.996742, -1.023391, 5.978632, -0.139796, -1.813088, 1.622381, 1.203058, -0.651239, -3.456574, -0.222662, 6.683311, 0.818542, -3.389858, 0.493225, -1.123396, 0.878852, -3.049400, -0.331124, 5.935852, 3.350296, 8.138122, -17.429125, -14.795409, -3.098204, 24.140213, -4.765680, 0.951934, 5.941668, -2.700983, -7.758855, -2.932885, -4.600454, 3.241535, -7.117503, -1.794245, 0.721068, 12.102087, 0.698535, 4.088568, -1.723680, -1.696615, 2.879545, 0.279521, -3.977141, -3.537980, 4.151566, 0.274428, 2.468474, -4.752934, 4.154515, 1.478541, 0.229912, -0.991211, 1.043606, -1.889281, -0.378249, -8.310148, -1.570603, 0.830470, 12.710440, 2.411873, -3.184698, -1.165278, 1.800090, 1.312870, 10.643050, 3.680258, -1.872453, 0.482994, -1.319558, -0.546642, -1.393429, -5.912747, -6.413036, -0.209341, -0.117053, -0.556111, -0.011504, 1.061256, -4.110349, -0.319666, 2.975264, -1.140699, -1.161089, 3.757135, -0.389400, -0.013038, -0.449394, -3.077528, 0.476779, 9.511504, -0.012259, 2.477592, -0.075476, -2.299772, -0.544572, 5.905273, -4.065750, -7.840758, -1.429921, -3.982676, 2.160990, -0.703023, -1.645128, -4.013421, 13.611000, -1.591425, 4.788300, 1.797771, -3.082032, -5.979467, -1.113766, -0.087996, -0.774307, -1.813855, 1.066504, -2.653287, 1.219532, 0.635090, 1.688667, -0.042042, 0.566678, 1.255748, 0.643949, -0.166326, 0.110403, 0.140343, -0.799678, 0.708496, 0.713038, -1.784538, -0.166608, 0.605190, -0.051453, 0.069013, 1.423979, -2.605554, 1.130910, 3.378889, -2.716846, 5.225326, -1.117621, -2.765895, -3.297780, 0.686546, 0.664325, 0.120082, -2.567070, 3.432386, 5.190210, -3.631124, 1.004930, 2.116619, 2.293989, 2.826955, 3.864724, -2.457437, -6.645638, -5.626691, -1.014270, -6.709464, 3.653670, 2.965525, 3.574362, 3.963652, -4.405104, -4.852438, -2.205765, 1.483586, 0.837499, 2.894408, -1.579726, -1.905957, -0.981489, 0.056763, 0.043506, -2.495411, 0.468418, 0.034381, -1.156299, 0.479292, -0.802937, 7.908027, -0.210541, 0.082014, -0.138778, -0.123231, 0.047719, -0.125070, -0.152089, 0.115020, 0.207300, 0.222998, -0.060907, 0.119978, -0.011046, -0.521331, -1.756768, 1.851508, -2.951356, 9.752078, -0.511892, -1.712465, -1.746639, 0.108389, 0.681423, -3.251736, -0.702093, 0.334184, -0.053659, -0.075756, 0.484103, -0.196700, -0.091463, -0.204665, 0.164370, 0.372940, -0.100882, 0.044608, 2.071757, -0.794000, -8.676079, 3.374655, 1.401705, -1.730751, -1.113925, 2.081316, 6.414800, 3.423934, -1.227988, -5.417789, 4.886179, -0.000981, 1.365316, -3.004450, -3.940148, -3.838888, 6.582206, -0.014197, 1.303764, 3.829486, -2.578301, -4.554550, 0.447827, 13.048302, -6.695828, 0.356376, 6.729365, -14.222968, 10.749092, 1.700784, -1.752462, -2.990625, -2.765667, -4.550646, -0.227223, 4.414070, -3.165838, -1.370950, -0.773957, -4.109133, 2.719441, 2.970530, 2.149659, -8.823822, 7.986406, -1.833347, -1.218106, -3.119631, -2.850388, -1.068338, -2.485873, 3.574846, 3.005130, 0.111531, -1.722610, 0.718062, 5.694470, -0.699301, -0.089269, -4.164452, -1.015809, -0.860281, -0.074986, -1.349789, 3.335324, 12.686399, 0.230787, -8.451548, -0.429554, 0.242520, 21.948063, -6.671740, 2.343039, -0.901296, -17.924687, 0.507339, 0.607721, 1.130544, -1.325106, -1.244258, 2.683970, -0.601814, 1.057277, -3.473445, -2.709942, 5.799420, -4.065560, 10.569469, 0.749121, -1.095106, 2.274377, -1.157942, -2.577657, -5.449291, 0.062095, -0.984320, 0.197270, 6.289265, -4.631575, 1.605149, -1.038577, -2.182416, -4.039583, -1.738291, 2.366025, 4.253969, 3.159545, 5.216540, -4.495406, -4.515781, 3.357233, -3.574810, 7.711274, -3.980604, 2.149161, -9.744210, 8.406596, -3.600960, -3.583124, 6.946911, 1.945591, 0.885055, 2.735998, -5.929333, -0.773833, -0.139192, -2.016109, -7.638589, -0.007522, 7.674805, -1.528818, 0.471389, -6.682649, 4.868570, 0.852790, 1.320262, 23.209942, -3.068035, -1.686168, -11.522351, 3.139399, -9.225108, 3.288730, -9.960782, -8.037688, -0.531577, 3.948301, 26.081313, 8.588650, -5.702851, -3.707026, -9.646623, 3.126992, -7.243251, 0.546652, -2.626650, 0.493265, -1.450876, -0.179118, 2.896012, 6.896610, 2.190474, -2.317672, -4.581417, -1.614541, -0.115723, -0.861549, -3.425276, -0.758902, -1.234795, -0.417471, 1.051395, 1.504013, 1.017603, 0.251859, 0.300760, -2.284791, 4.873750, 5.081869, 5.858504, -4.580229, -0.558228, -5.984231, -10.380126, -1.751610, -0.350845, -2.728905, -5.538949, 14.736430, 6.370965, -12.294226, 13.158802, -2.194776, 9.986974, -5.885554, 4.183061, 0.259684, 2.049392, 4.581245, -2.524755, -5.423242, -6.544118, -1.066254, 2.530557, -9.067255, 8.584143, 1.316260, 2.823714, -0.777182, -5.122173, -1.850636, 7.920015, -4.253118, -1.124995, 0.625454, 1.280540, 0.454989, 0.278077, 0.156781, 0.273861, -0.148511, -0.353879, -0.583379, -0.323157, 0.110318, -1.756287, 1.278547, -1.554955, 0.889711, 6.485202, -2.381943, -0.697980, 2.074387, 0.432378, -1.066342, -1.963504, -1.297385, -2.057786, -2.690670, 1.327298, -0.519711, -4.936677, -0.334783, 2.324595, -0.421220, 0.402392, 2.908528, 0.580853, 2.618943, -1.513636, -0.483125, -5.207200, 1.566224, 4.963853, 1.086817, 5.855543, -4.392206, -0.126837, -0.792859, -4.349862, -2.613473, 4.660251, -1.581136, -3.345258, 8.031719, 0.156904, -4.538357, 0.848176, 0.469856, -0.369150, 0.321387, -0.100907, -0.198589, 0.319924, 0.297819, -1.191455, 0.019192, 0.176123, -0.006265, 0.033743, 0.150584, 0.430739, 0.153863, -0.322782, 0.290380, -0.010939, -29.866684, -3.677120, 9.470156, 35.846578, -21.528931, 6.532472, -4.795199, 1.699855, 1.961724, 8.043000, -0.722179, -3.834915, 0.652027, -0.045470, -0.054139, 0.136789, -0.524525, 0.005898, 0.093920, -0.013617, -0.234286, -0.198517, 0.214275, -0.010579, 8.425432, 2.988431, 2.128967, 0.479023, -5.693235, -5.452968, -0.319762, 0.428978, 1.196330, -0.881007, -5.395202, 2.309353, 0.021814, 2.286612, 2.291177, 2.704486, 0.136808, -3.168202, 1.397809, -0.769040, 1.714360, -5.242628, -3.499358, 2.225955, 3.866278, -3.776458, -1.327529, -0.653815, -5.576677, 1.446430, 1.400702, 2.557960, 2.954192, 0.992074, -0.832765, -1.078820, -1.343264, 2.090216, -0.732187, -5.919128, 1.297703, 0.125667, -2.627488, 3.294045, 1.898657, 2.006093, -3.256339, 2.986173, -3.343006, 4.828905, -2.613839, 0.989971, 1.712953, -3.423978, -4.770623, 4.025853, 0.571764, -0.368233, -0.451098, 2.681649, 1.196205, -0.483561, 3.552654, -1.394519, -3.284911, -1.845608, -0.920646, 3.254493, 0.182117, 2.152441, 1.048546, -3.503607, 1.701144, -3.012857, -0.775069, -2.122796, -3.599844, 4.150274, 0.468286, 0.488683, 0.806695, -0.944280, -2.324481, 5.189704, -1.323431, -2.371286, -0.684784, 2.087345, 3.854132, 6.739661, -2.588864, -2.017809, -0.062432, 0.082219, 0.181810, -3.925721, -1.269158, 0.771193, 0.201000, 0.060103, 1.449232, 4.177201, 2.284726, 3.738946, -4.884619, 0.861620, -4.330829, -3.045451, -0.192379, -0.324733, 0.316541, -0.213612, 1.227956, -0.181590, -0.061813, -0.280042, 0.203421, 0.051064, 0.052455, -0.591771, -0.760981, 1.039013, -0.117961, -0.024434, 0.745885, 0.242635, -0.031265, -0.516671, -0.519971, 0.296783, -0.147602, -0.223920, 4.434961, -1.010251, 9.414091, -8.502757, -2.588200, -5.964715, 6.786706, -3.388115, -4.917397, -3.654033, -4.154642, 14.021346, -7.510063, 1.231060, -2.211286, 9.720145, 3.923024, -1.747777, 6.770496, 1.364517, 0.468376, -6.080310, -2.798051, -3.176113, 15.916097, -0.390367, 2.565220, 0.610076, -11.369686, -6.188521, 0.311986, -0.717622, -1.137588, 1.758287, -0.522755, -0.416249, -2.327795, -6.204935, -5.339739, 1.598990, 5.178159, 13.615046, -0.174886, -1.271936, -4.486743, 0.485228, -0.654458, -0.382472, -4.338563, -0.452145, -3.367461, -4.522212, 6.366544, 5.467235, 1.645787, 7.423672, -5.283950, -8.287888, 7.580422, -2.254006, -4.284671, -2.034226, -0.219245, -3.957717, -7.102204, 2.609566, -0.172907, 3.322797, 4.869607, 2.819452, 3.073065, 0.679907, -6.803226, 3.474867, 6.896695, 3.606269, -4.018002, -1.772686, 2.734162, -2.500663, 5.027966, -1.572434, -2.573751, -2.750106, -2.965523, -3.056224, -2.169336, -2.440941, 8.319041, -0.723670, -2.080030, -0.013076, 2.151146, 2.109030, 0.698346, 0.091610, 6.348596, -3.342069, -1.481815, -0.463590, -13.061092, 6.412882, -0.486062, 0.760058, 0.247763, 6.489071, -0.015248, -1.487644, -0.872249, -3.347564, 0.494232, -1.818163, 9.080621, -2.677857, -0.506546, 1.000915, 0.711274, -0.099551, -0.641519, -1.238487, -7.426821, 4.959260, -10.576724, -1.363059, 4.772927, 2.261747, 2.279182, 1.747594, 1.206955, 4.208103, -0.342508, -2.161918, 1.231441, 2.290090, 2.502185, -1.264484, 7.464678, -1.926153, -2.995709, -0.365836, -0.889062, -1.193453, -4.625303, -0.083146, -1.579892, -1.488176, 6.214058, -4.236389, 0.100408, -5.292220, -6.287278, 2.773473, -0.456496, -0.241996, 3.067959, 7.470131, -2.497540, -3.695748, -0.472641, 1.034097, 1.277572, -0.218144, 1.238998, 11.449968, -0.441076, -2.591131, -1.411167, -3.739931, -1.638789, 2.388109, -6.878957, -1.161578, 5.197437, -1.089695, 2.191336, 5.283825, -1.624808, -5.088696, 1.191959, 1.220303, -2.317164, 4.998871, 5.794736, 0.190131, -5.387027, -2.084698, -3.858666, -0.973130, 0.246644, -0.554747, -2.455404, 6.331006, -0.969089, -0.125939, 1.950121, -3.240467, 0.667463, -1.897886, -3.215341, -0.396697, 0.212676, 5.653026, -0.206151, 1.481036, -1.378498, 12.922576, -3.415626, -1.068031, 1.519965, -3.438829, 0.681231, 0.307645, -2.135678, -0.638086, -0.643439, -2.866554, -0.411642, -4.881526, 1.076190, -6.295276, 12.140806, -0.134036, -4.494315, 2.425207, 2.503876, -3.684955, -0.951215, 2.808190, 0.248500, -2.287011, -2.593393, 0.259735, 9.349938, -0.070442, -1.510420, -3.417699, 1.324211, -0.908108, 0.486694, -0.778568, -0.952229, 4.975109, 0.123201, -0.569322, 1.503872, -4.848647, -1.625419, -2.720911, 0.452474, 1.474416, 1.680746, 0.451656, -3.293614, -9.156687, 3.354285, 1.728937, -0.053656, -2.465463, 5.594573, 3.928611, 3.532539, -3.615896, 0.508171, -0.029867, -0.892868, -4.698347, -0.666689, -1.737356, -3.209355, 16.810046, 1.432179, 0.218455, -0.347013, -2.364328, -3.413285, -1.236025, -1.026553, -10.304472, 5.006328, -0.441220, 4.650686, 4.703304, -18.214807, -3.134216, 2.378413, 2.857799, 1.229686, 12.390795, -5.672900, -2.206322, 23.728355, -1.049137, 2.740407, -5.711159, -8.588792, -0.515224, -6.234548, -9.994134, 9.174568, 4.702804, 0.906158, 1.725661, -12.002820, 2.648048, -6.430314, -9.286565, -3.672851, 8.666482, 0.516293, 17.725986, 3.525634, -4.738736, 0.932692, -6.242684, -0.582783, -1.846445, -3.713405, 7.270485, 0.409195, -1.373513, 3.468353, 2.897591, 1.985286, -3.346266, -18.551990, 1.592866, -3.481255, -0.274402, 21.783321, -1.272663, 0.061066, -0.409009, 0.956883, -2.740812, -1.875446, 3.915757, 1.934445, 3.852086, 0.526084, 2.586334, -0.903057, -3.584592, -0.717917, 0.275314, -3.531603, 1.846694, -0.525263, -1.663115, 0.561724, -1.251386, -0.743807, 0.334590, -3.326685, -2.062941, 0.065879, 0.361594, -2.653201, 8.832309, 0.246736, -0.407608, 1.311328, 9.565872, 0.523546, -0.638410, -2.835534, 1.322962, -0.209056, -0.518084, -2.299660, 0.043424, -0.741488, -5.624685, -0.242591, 0.505848, 0.052518, -0.109553, 0.226192, 0.237802, -0.160901, 0.192926, -0.291070, 0.151530, 0.173746, -0.752151, 2.423784, -0.674013, -2.519884, 0.733604, -0.503987, -7.437150, -2.628407, 0.986146, 2.000125, 1.948000, 4.701319, 0.989217, 3.690643, 0.717313, 3.099105, -20.226405, 20.443003, -5.459610, 0.479638, 1.967841, 2.568044, -5.937094, 4.161516, -5.355571};
static RBF_CONST rbf_float RBF_BIAS[] = {10.128664, 3.495340, 1.540759, 2.307008, -6.415050, 0.837940, -0.966620, 0.431220, -2.866865, -6.807466, 2.651744, -4.026648};

#if RBF_USE_NORMALIZATION
static RBF_CONST rbf_float NORM_IN_MEAN[] = {0.012524, 0.011168, 0.010055, 0.004432, 0.005949, 0.006603, 0.003790, 0.003309, 0.004367, 0.005556, 0.002002, 0.004671, 0.004016, 0.000928, 0.004592, 0.007021, 0.007635, 0.008629, 0.008452, 0.009150, 0.008997, 0.008806, 0.009148, 0.008658, 0.007862, 0.009718, 0.007429, 0.005916, 0.007701, 0.011219, -0.001548, 0.000633, 0.006765, 0.001602, -0.000169, 0.006551, 0.001026, 0.002136, 0.001794, 0.004300, 0.000263, 0.001040, -0.000124, -0.000095, -0.004503, -0.004034, 0.001382, 0.010836, 0.007101, 0.005748, 0.003493, 0.008363, 0.013820, 0.014134, 0.003639, 0.010138, 0.006532, 0.008933, 0.005145, 0.010096, -0.010780, -0.010349, -0.013454, -0.000409, -0.004171, -0.005631, -0.008223, -0.007632, -0.000969, -0.003737, -0.006464, -0.013815, -0.012234, -0.003141, -0.016746, -0.009154, 0.001259, -0.014103, -0.010193, -0.004995, -0.006756, 0.000544, -0.005190, -0.008718, -0.009975, -0.014948, -0.005028, -0.012734, -0.014397, -0.009037, 0.004989, 0.008941, 0.007144, 0.007440, 0.002708, 0.002041, -0.006991, 0.003740, 0.002342, -0.003869, -0.006632, 0.000336, 0.004626, 0.004286, -0.000564, -0.001144, -0.000722, 0.015728, 0.008321, 0.006889, 0.013381, 0.014494, 0.020972, 0.021008, 0.004303, 0.015498, 0.011255, 0.012804, 0.008647, 0.015148};
static RBF_CONST rbf_float NORM_IN_SCALE[] = {0.997338, 0.995202, 0.993008, 0.994557, 0.997468, 0.999854, 0.998349, 1.000235, 1.001992, 0.999279, 0.999906, 0.999074, 0.999159, 0.998852, 0.997974, 0.994508, 0.993709, 0.993968, 0.997303, 1.000558, 0.998086, 0.994645, 0.994647, 0.998962, 1.003583, 0.999004, 0.995026, 0.995603, 0.997072, 0.998984, 1.007682, 1.015553, 1.015839, 1.013344, 1.012521, 1.013557, 1.012583, 1.013301, 1.010982, 1.004945, 1.013300, 1.009507, 1.004639, 1.003466, 1.005021, 0.998558, 1.012246, 1.014717, 1.019581, 1.019733, 1.014228, 1.011177, 1.009326, 1.011706, 1.004440, 1.012002, 1.011833, 1.015081, 1.014339, 1.011649, 1.002443, 1.007082, 1.013958, 1.002171, 1.007335, 1.013750, 1.007755, 1.008978, 1.010783, 1.011220, 1.006845, 1.011117, 1.006592, 1.005554, 1.005010, 1.002849, 1.008369, 1.016702, 1.005056, 1.006811, 1.010217, 1.013220, 1.016792, 1.022904, 1.014390, 1.013852, 1.014976, 1.022773, 1.019057, 1.014189, 1.003253, 1.015721, 1.024795, 1.011496, 1.004809, 1.002934, 1.004258, 1.016177, 1.013370, 1.007935, 1.011621, 1.005717, 1.007669, 1.012225, 1.011813, 1.009335, 1.016833, 1.016397, 1.024124, 1.025141, 1.021932, 1.016820, 1.016858, 1.019304, 1.015818, 1.015055, 1.024281, 1.020812, 1.015767, 1.016519}; // StdDev
static RBF_CONST rbf_float NORM_OUT_MEAN[] = {0.078289, 0.085565, 0.081781, 0.081781, 0.081490, 0.084692, 0.082654, 0.084692, 0.087602, 0.085565, 0.083818, 0.082072};
static RBF_CONST rbf_float NORM_OUT_SCALE[] = {0.268625, 0.279720, 0.274031, 0.274031, 0.273586, 0.278422, 0.275359, 0.278422, 0.282715, 0.279720, 0.277115, 0.274475}; // StdDev
#endif

// ==========================================
// Implementation
// ==========================================

RbfModelRBF::RbfModelRBF() {
    for(int i=0; i<RBF_HIDDEN_DIM; i++) hidden_activations[i] = 0;
}

void RbfModelRBF::predict(const rbf_float* input, rbf_float* output) {
    // 1. Prepare Input (Normalize if needed)
    rbf_float processed_input[RBF_INPUT_DIM];
    #if RBF_USE_NORMALIZATION
        normalizeInput(input, processed_input);
        const rbf_float* in_ptr = processed_input;
    #else
        const rbf_float* in_ptr = input;
    #endif

    // 2. Hidden Layer (RBF)
    for (int i = 0; i < RBF_HIDDEN_DIM; i++) {
        rbf_float dist_sq = euclideanDistanceSq(in_ptr, i);
        rbf_float width = RBF_READ(&RBF_WIDTHS[i]);
        hidden_activations[i] = computeKernel(dist_sq, width);
    }

    // 3. Output Layer (Linear)
    for (int j = 0; j < RBF_OUTPUT_DIM; j++) {
        #if RBF_FIXED_POINT
            int64_t sum = 0;
        #else
            float sum = 0.0f;
        #endif

        for (int i = 0; i < RBF_HIDDEN_DIM; i++) {
            rbf_float weight = RBF_READ(&RBF_WEIGHTS[i * RBF_OUTPUT_DIM + j]);
            #if RBF_FIXED_POINT
                sum += (int64_t)hidden_activations[i] * weight;
            #else
                sum += hidden_activations[i] * weight;
            #endif
        }

        #if RBF_FIXED_POINT
            sum = sum / RBF_SCALE_FACTOR;
            output[j] = (rbf_float)sum + RBF_READ(&RBF_BIAS[j]);
        #else
            output[j] = sum + RBF_READ(&RBF_BIAS[j]);
        #endif
    }
    
    // 4. Denormalize Output
    #if RBF_USE_NORMALIZATION
        denormalizeOutput(output);
    #endif
}

void RbfModelRBF::normalizeInput(const rbf_float* input, rbf_float* norm_input) {
    for(int i=0; i<RBF_INPUT_DIM; i++) {
        rbf_float mean = RBF_READ(&NORM_IN_MEAN[i]);
        rbf_float scale = RBF_READ(&NORM_IN_SCALE[i]);
        #if RBF_FIXED_POINT
             // (Input - Mean) * SCALE_FACTOR / StdDev
             int64_t diff = (int64_t)input[i] - mean;
             norm_input[i] = (rbf_float)((diff * RBF_SCALE_FACTOR) / scale);
        #else
             norm_input[i] = (input[i] - mean) / scale;
        #endif
    }
}

void RbfModelRBF::denormalizeOutput(rbf_float* output) {
    for(int i=0; i<RBF_OUTPUT_DIM; i++) {
        rbf_float mean = RBF_READ(&NORM_OUT_MEAN[i]);
        rbf_float scale = RBF_READ(&NORM_OUT_SCALE[i]);
        #if RBF_FIXED_POINT
             // (Output * StdDev) / SCALE_FACTOR + Mean
             int64_t val = (int64_t)output[i] * scale;
             output[i] = (rbf_float)(val / RBF_SCALE_FACTOR) + mean;
        #else
             output[i] = (output[i] * scale) + mean;
        #endif
    }
}

rbf_float RbfModelRBF::euclideanDistanceSq(const rbf_float* input, int center_idx) {
    #if RBF_FIXED_POINT
        int64_t sum = 0;
    #else
        float sum = 0.0f;
    #endif
    int base_idx = center_idx * RBF_INPUT_DIM;
    for (int k = 0; k < RBF_INPUT_DIM; k++) {
        rbf_float c = RBF_READ(&RBF_CENTERS[base_idx + k]);
        rbf_float diff = input[k] - c;
        #if RBF_FIXED_POINT
            sum += ((int64_t)diff * diff) / RBF_SCALE_FACTOR;
        #else
            sum += diff * diff;
        #endif
    }
    return (rbf_float)sum;
}

rbf_float RbfModelRBF::computeKernel(rbf_float dist_sq, rbf_float width) {
    #if RBF_FIXED_POINT
        if (width == 0) return 0;
        double d = (double)dist_sq / RBF_SCALE_FACTOR;
        double w = (double)width / RBF_SCALE_FACTOR;
        return (rbf_float)(exp(-d / (2.0 * w * w)) * RBF_SCALE_FACTOR);
    #else
        return exp(-dist_sq / (2.0f * width * width));
    #endif
}

void RbfModelRBF::printInfo() {
    Serial.println(F("Model Loaded: RbfModelRBF"));
    Serial.print(F("Normalization: ")); 
    Serial.println(RBF_USE_NORMALIZATION ? F("YES") : F("NO"));
}
