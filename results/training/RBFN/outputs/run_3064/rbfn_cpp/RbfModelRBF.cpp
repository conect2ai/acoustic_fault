#include "RbfModelRBF.h"

// ==========================================
// Flash/PROGMEM Macros
// ==========================================
#if defined(ESP32) || defined(ESP8266)
    #define RBF_CONST const
    #define RBF_READ(x) (*(x)) // Fixed: Dereference pointer
#elif defined(__AVR__)
    #include <avr/pgmspace.h>
    #define RBF_CONST const PROGMEM
    #if RBF_FIXED_POINT
        #define RBF_READ(addr) (rbf_float)pgm_read_dword(addr)
    #else
        #define RBF_READ(addr) (rbf_float)pgm_read_float(addr)
    #endif
#else
    #define RBF_CONST const
    #define RBF_READ(x) (*(x)) // Fixed: Dereference pointer
#endif

// ==========================================
// Model Parameters
// ==========================================
static RBF_CONST rbf_float RBF_CENTERS[] = {-0.568523, 0.774513, 0.009876, 0.006352, 0.824433, 0.983323, 0.734949, 1.297252, 1.296879, 0.663745, -0.206117, -0.123763, -0.013103, 0.222856, 0.264961, 0.360821, 0.560455, 0.332521, 0.317114, 0.224536, -0.370866, -0.848485, -1.007113, -1.240953, -0.964324, -1.350273, -1.503137, -0.837838, -1.715537, -0.558619, -0.208483, -0.489051, -0.429093, -0.709824, -0.215887, -0.934145, -0.310417, -0.404490, -0.357777, 0.667864, 0.251975, 0.020111, -0.277130, -0.019771, 0.376262, 0.732178, -0.303951, -0.548437, -0.166557, 0.270594, -0.401434, -0.021999, -0.175219, -0.848610, 0.023672, -0.677305, -0.731086, -0.462721, -0.117624, -0.612889, 0.307185, -0.302080, -0.648611, -0.324146, 0.394934, 0.432707, -0.143229, 0.042793, -0.256034, -0.667917, -0.761597, -0.730030, 0.042741, 0.706970, 0.516430, -0.206816, 0.470411, 0.471579, 0.227665, 0.028212, 0.225380, 0.070593, 0.127779, -0.047828, 0.403453, 0.610760, 0.058346, -0.259708, -0.285384, -0.182390, 0.083182, -0.217222, -0.063920, -0.579746, -0.477734, -0.573420, -0.004564, 0.313543, -0.042612, 1.022468, 0.337757, -0.182633, 0.252608, -0.288039, 0.748904, 1.048123, 0.074259, -0.692058, -0.225303, 0.043362, -0.221062, -0.451173, 0.124396, -0.485958, 0.216233, -0.603656, -0.595732, -0.611998, -0.106917, -0.371517, 0.137893, 0.286240, 0.607549, 0.958481, -0.921735, -1.367708, -0.844785, 0.185198, -0.373174, -0.545886, 0.472768, 0.357479, 0.254956, 0.347131, 0.374463, 0.599266, -0.021659, -0.422314, 0.552039, 0.850492, 1.230890, 0.723707, 1.596742, 0.921003, 0.910471, 1.425185, 1.275557, 0.854359, 0.691023, 0.325703, 0.000221, 0.718289, 0.236869, -0.221507, 0.231242, -0.039353, -0.369457, -0.018645, 0.811234, 0.303449, -0.417321, -0.237930, 0.255205, 0.188525, -0.170570, -0.066626, 0.201552, -0.181216, -0.074254, -0.314913, 0.645649, -0.349215, -0.064765, 0.189101, 0.477528, 0.134644, 0.056024, 0.428052, -0.138004, 0.276239, -0.346361, 0.971514, -0.083038, 0.084361, 0.080736, -0.194660, -0.085187, 0.328137, -0.666017, 0.127822, -0.110890, -0.195078, 0.164141, -0.228743, 0.031589, -0.347588, -0.277932, -0.069813, -0.242552, 0.067418, 0.267224, -0.009186, -0.048296, 0.124047, -0.370984, -0.223810, 0.261295, 0.303848, -0.005373, 0.067843, 0.361623, 1.435618, 0.422382, -0.243626, 0.394285, -0.155884, -0.187729, 0.043622, 1.394051, 0.344852, -0.356477, -0.317434, 0.203347, 0.537670, 0.015390, -0.067822, 0.655091, 0.015764, 0.355182, -0.174827, 0.569959, -0.363901, 0.038481, 0.206301, 0.073974, -0.027637, 0.313269, 0.117174, -0.343592, 0.268585, -0.213721, -0.808267, 1.253493, -0.569632, 0.363579, 0.909208, -0.422118, 0.970255, 0.049689, 0.602961, 0.265201, 0.245217, 0.104834, -0.137909, -0.106686, 0.261524, -0.082187, 0.452551, 0.027975, -0.369295, -0.989226, -0.825120, -0.755964, -1.017414, 0.051411, -0.832334, -0.052642, -0.266875, -0.750244, -0.965364, -0.159119, 1.101583, 0.491352, -0.344920, -0.786186, 0.003904, -1.420849, 0.455108, -0.180567, 0.789169, 0.362107, -0.455728, -0.517757, -0.203222, -0.327466, -0.424990, -0.239728, 0.476405, 1.163140, -0.464945, -0.204175, -0.010135, 0.762891, 0.568359, 0.041201, 0.706548, -0.085601, 1.455864, 0.109918, -0.536136, 0.066205, 1.102076, 0.487195, -0.717886, -0.723907, 0.041492, 0.510834, 0.572018, 0.322618, -0.182644, 0.222478, -0.101560, -1.067172, -0.905354, -0.501903, 0.192384, 0.721833, -0.360609, -0.307811, -0.620875, 0.026535, -0.440169, 0.191127, 0.231575, -0.279843, 0.068272, -0.857257, -0.243998, -0.724039, 0.186141, 0.065161, 1.098595, 0.100741, -0.189471, -0.194552, 0.008110, -1.857343, -0.434916, -0.423891, 1.436127, 0.665895, -0.541306, 0.057781, 0.304485, -0.285752, -0.678602, -0.096771, 0.389572, 0.000822, 0.059068, -0.665580, 0.607094, 1.068652, 0.518278, 0.165638, 1.089653, 0.253428, 2.573430, 0.462651, 0.722730, -0.320603, -0.237461, 0.808132, -0.024717, 0.271635, 0.604806, 0.478195, -0.810456, -1.224059, -1.273388, -0.763763, -0.584093, 0.445824, -0.486989, 0.331786, 0.155096, 0.136582, 0.499813, 0.437770, 0.844091, 0.421995, 0.145594, 0.619591, 0.010315, -0.399082, -0.789567, -0.954406, 0.103143, -1.015190, -0.957027, -0.304448, -0.511595, 0.091571, -0.023434, -0.368605, -0.353697, 0.308026, -0.626322, -0.836162, 0.174877, -0.460578, 0.031582, -0.789425, -0.252412, 0.485568, -0.688766, 0.347992, 0.838876, 0.144622, 0.129078, 0.160340, 0.310542, 0.239159, -0.004355, 0.041583, -0.120046, 0.612500, -0.020693, 0.636619, 0.157157, -0.001259, -0.081423, -0.210385, 0.343540, 0.115937, 0.132859, -1.210763, -0.555248, 0.281277, 1.021125, 0.097658, -0.203105, -0.454153, -0.132491, -0.257784, 0.013193, -0.103516, -0.506520, -0.576209, -0.192232, -0.015199, 0.391704, 0.332442, 0.139121, 0.783899, -0.578898, -0.018101, -0.766644, -0.173920, -0.190707, -0.482256, -0.563426, 0.080966, 0.197580, -0.600543, -0.195649, 0.357215, -0.363709, -0.648282, 0.477387, -0.417333, -0.064028, -0.832493, -0.190260, -0.084231, -0.463581, -0.040858, 0.868428, -0.288578, -0.446277, -0.468106, 0.226577, -0.100433, -0.265981, -0.045291, -0.310907, 0.360719, 0.056212, 1.364246, -0.539012, 0.789320, 1.079278, 1.590422, 0.249254, -1.102834, -1.121131, -1.386814, -0.736183, 0.229165, 0.320487, 0.951974, 2.287671, -0.624761, 0.992193, -1.263501, -0.105858, -1.435531, -0.463072, -0.136890, -0.366205, -0.711598, -0.835863, -0.689137, -0.260551, 0.232541, 0.062833, -1.367960, -0.650476, 0.025061, 0.058280, 0.065571, 0.549294, 1.272463, 1.594489, 0.598893, 1.015340, 1.363590, 1.182997, 0.708755, 1.399581, 1.505434, 0.876779, 0.748161, 0.554484, 0.776100, 0.945198, 0.553520, 1.196782, 1.482177, 1.387408, 1.033610, 0.848075, 1.037000, 0.555780, 0.674590, 0.731662, 0.619540, 0.149461, 0.312463, 0.176846, 0.208346, 0.051267, -0.651664, -0.466070, -0.279257, -0.319418, 0.090742, 0.706674, 0.375030, -0.059278, -0.271768, 0.189297, -0.099638, 0.000993, 0.041155, 0.431762, -0.375984, -0.262897, -0.163699, 0.171530, 0.180890, 0.020856, 0.364664, -0.029349, 0.031256, 0.401064, 0.247234, 0.150833, 0.195303, 0.301846, 0.017541, 0.055350, 0.859136, 1.270778, 0.861763, 0.859670, 1.317275, 1.407764, 0.378421, 0.883973, 1.125175, 0.524964, 0.306992, 0.717453, 0.385709, 0.686704, 0.081543, 0.618839, 0.980079, 0.730936, 1.013913, 0.796502, 0.813454, 0.391151, 0.589984, 0.620468, 0.608286, 0.274691, 0.335966, 0.363950, -0.520804, -0.014117, -0.458081, 0.172656, 0.928738, 0.848002, 0.548287, 0.480065, 0.435958, 0.536124, 1.061682, 0.176979, -0.591556, 0.790884, 0.753225, 0.113852, 1.201087, 0.995413, 0.021338, 0.151070, 0.050241, 1.003451, -0.476637, -0.114560, 0.409179, -0.702595, 0.095530, -0.413810, 0.657863, 1.025856, 0.197478, 0.138567, -0.063725, -0.206381, 0.184292, 0.203432, -0.371551, 0.074293, -0.235974, -0.425179, -0.334053, -0.063038, 0.106738, -0.147735, -0.145430, 0.711420, -0.015894, -0.340668, -0.258955, -0.147358, -0.294137, -0.018779, -0.053718, -0.213208, -0.269269, -0.081368, -0.111555, 0.254915, 0.472379, 0.121791, -0.045113, -0.395767, 0.186327, 0.271679, 0.151852, 0.092058, 0.120356, 0.022515, -0.016740, -0.147846, -0.213841, -0.227740, -0.125649, 0.162085, -0.162345, 0.237665, 0.350921, -0.044834, -0.095004, 0.214809, -0.193842, 0.107950, -0.018416, -0.281241, -0.280889, -0.283652, 0.103555, 0.206840, 0.107128, -0.185596, 0.609586, 0.475210, -0.122699, -0.084778, 0.352958, 0.555771, 0.025998, 0.434607, -0.041698, -0.307926, -0.086456, -0.297338, 0.507106, -0.195034, -0.213066, 1.516781, 0.050412, -0.227726, -0.196293, -0.127095, -0.305189, 0.003628, -0.127041, -0.339417, -0.266041, 0.221617, -0.165390, -0.015188, 0.314151, -0.107562, -0.108671, 0.217649, -0.053275, 0.059798, -0.603506, 0.660111, 0.311313, 0.580878, 0.445776, 0.737535, 0.122835, 0.352564, 0.573060, 0.017655, 0.811012, 0.435858, 0.889298, 0.262393, 0.091585, 0.054874, -0.472346, -0.007062, -0.458844, -0.358401, -0.287960, -0.444534, -0.362481, -0.815587, -0.579628, -0.633118, -0.290789, 0.161908, -0.191493, -0.272020, -0.370720, -0.478181, -0.014787, -0.061754, 0.161537, -0.196586, 0.096757, 1.090559, 0.568936, -0.667438, 1.062654, 0.069463, 0.212415, 0.242543, 0.776471, 0.024149, -0.103738, 0.412359, -0.669074, -0.010182, -0.049243, 0.156052, -0.042040, -0.141855, 0.075394, 0.085254, 0.265983, -1.211963, 0.060628, -0.273026, 0.100163, -0.521764, -0.271777, 0.233921, 0.256296, -0.258082, -0.844813, -0.414159, -0.095570, 0.515288, 1.010858, 0.103567, 0.661075, 0.615527, 0.844446, 0.317641, 0.187966, 0.203313, -0.172075, 0.681289, 0.117283, -0.191988, 0.091920, -0.042509, -0.172002, 0.079539, -0.077024, 0.573321, -0.048486, -0.043514, -0.327262, -0.043236, -0.132361, 0.235641, 0.425752, 0.414446, 0.287363, 0.746835, 0.197261, -0.590537, 1.545875, 0.399030, -0.053940, 0.932710, 1.003833, 0.297056, 0.113618, 1.282554, -0.678413, -0.121184, 0.181509, 0.095580, -0.042546, 0.039250, 0.016814, 0.231193, 0.222450, -0.741480, 0.521454, 0.470646, 0.402718, 0.718098, 0.502507, 0.312249, 0.700867, -1.374053, 0.450003, -0.331479, 0.098414, 0.830431, 0.659323, 0.449699, -0.082156, 0.483204, 0.401046, -0.024446, 0.772845, -0.233415, -0.144200, -0.893631, -0.139389, -0.012047, -0.605901, 0.189526, -0.191484, -0.374684, -0.002265, 0.256388, 0.018178, 0.073644, 0.701644, 0.026276, 0.371379, 0.422203, 0.467704, -0.124686, -0.165582, -0.309203, 0.604166, -0.218696, 0.304212, -0.265450, 0.036913, -0.273355, -0.269714, 0.319684, 0.944602, -0.537394, 0.570017, 0.142386, 0.777722, -0.178382, 0.199754, 0.169565, -0.239155, 0.013594, 0.283337, -0.078103, -0.002641, 0.172076, 0.297725, 0.452186, -0.075282, 0.067155, 0.204449, 0.271551, 0.146738, 0.064493, -0.042636, -0.724217, -0.007627, 0.227805, 0.075872, 0.397036, 0.292867, 0.117348, -0.651982, -0.499403, -0.022434, -0.496813, -0.371307, -0.004008, 0.397052, -0.079967, -0.155575, 0.167350, -0.136370, -0.210703, 0.025898, -0.156735, 0.730787, -0.024064, 0.442187, 0.481756, 0.319454, -0.193386, -0.195993, -0.217159, -0.090395, -0.246649, -0.143049, -0.327725, 0.021030, -0.312433, -0.307168, -0.246749, 0.680744, -0.748441, 0.400614, 0.242719, 0.293552, 0.065429, 0.361398, -0.135677, -0.296008, -0.242368, -0.307838, -0.288015, -0.542088, -0.418128, 0.458554, 0.213671, 0.035298, -0.086286, -0.768509, 0.876621, 0.570398, -0.480983, -0.269874, -1.037595, -1.111103, -1.264673, -0.703181, -0.020471, -0.698443, 0.004285, -0.260172, -0.160938, -0.415394, 0.671048, 0.162645, 0.859040, 0.846126, 0.419943, 0.501651, 0.008622, 0.094038, -0.109032, -0.020986, -0.097249, 0.555590, 0.482023, 0.368134, 0.052544, -0.012311, 0.072575, 0.030558, -0.232171, -0.359663, -0.347284, -0.284367, -0.522848, -0.372016, -0.359894, -0.172352, -0.364218, -0.488894, -0.162309, 0.159013, 0.168683, 0.047174, 0.489326, -0.307762, -0.283892, 0.064610, -0.349905, 0.005509, 0.001860, -0.103022, -0.189431, -0.124805, 0.175144, 0.217656, 0.163102, 0.025181, -0.212156, -0.136385, -0.019705, -0.065140, 0.024406, -0.104051, -0.044916, -0.205841, -0.121292, 0.137259, -0.080771, 0.162856, 0.153638, -0.085875, 0.262385, 0.307926, 0.029216, -0.028305, -0.192351, 0.269368, -0.221141, 0.448935, 0.314077, -0.017206, 0.073124, 0.260089, 0.324315, 0.016115, -0.038411, -0.246863, -0.111109, 0.333395, 0.020099, -0.137708, -0.429218, -0.194868, -0.367531, 0.013376, -0.369285, 0.102718, 0.026784, -0.313324, -0.152086, 0.142649, 0.052360, 0.250102, 0.644390, -0.127639, -0.285224, 0.145942, -0.204510, 0.524258, -0.536974, -1.649541, -1.018451, -2.224560, -3.412544, -3.119902, -0.940647, -0.192461, -1.795305, 0.320542, 0.035529, 0.277495, -0.469641, 0.420697, 0.054582, -0.884623, 1.346938, -0.166033, -1.958919, 0.719017, -0.736817, -0.791702, -0.554116, -0.551271, 0.313163, 0.221258, -1.065232, -1.252633, -0.414682, -0.580535, -0.105533, 0.569777, -0.290500, -1.359925, 0.782048, -0.067590, 1.032177, -1.556687, -0.389908, 0.987007, -0.788984, 1.381728, -0.157405, -1.053702, -0.325397, 1.167582, 0.331583, -0.641661, -0.564789, -0.151760, 0.674377, 1.232991, 0.017521, 0.817684, 0.737303, 0.478787, 0.618417, 0.192520, -1.507189, -0.025716, 0.720954, 2.272626, 0.057838, 0.042653, 0.048367, -0.523460, -0.192618, 0.203383, -0.203515, -0.663378, -1.333413, -0.948530, 0.258837, 0.362768, 0.436162, -0.081038, -1.399715, -0.089612, 0.434848, 0.081066, 0.316206, 0.578354, 0.393356, 1.024711, -0.240105, -0.693913, -0.749445, -0.608860, -0.279179, -0.662711, -0.235511, 1.634503, -0.517652, -0.604701, 1.264918, 0.479038, 1.187557, -0.925924, -0.233811, 0.598799, -0.953891, 0.468982, -0.418625, -1.094518, -0.932914, -0.848892, -0.125078, -0.531933, -0.417134, -0.532144, 1.370158, 1.233025, -0.024240, 0.956057, 0.010232, 0.213909, 1.440280, -0.106358, -0.854414, 0.097025, 0.365728, 0.405157, 0.798713, -0.889940, -1.376539, -0.621547, 0.450422, -0.164841, -0.348881, 0.088388, 0.232479, 0.055352, 0.593210, 0.763242, 0.018584, 0.487705, -0.217375, 0.371725, 1.588304, 1.222678, 1.033225, 1.710447, 1.122189, 0.870883, 1.280988, 1.407578, 0.449585, 0.928827, 0.482377, 0.038664, 1.248026, 0.238715, 0.024999, 0.265250, 0.048829, -0.225065, 0.163875, 0.129320, 0.109036, -0.053909, 0.191300, -0.081150, -0.519863, -0.155957, -0.100058, 0.078657, -0.045712, -0.153003, 0.446985, -0.632774, -0.147670, -0.081948, 0.130160, 0.040646, -0.393122, 0.053008, 0.469348, -0.154317, 0.323007, 0.569213, -1.611179, 0.085643, 0.432200, 0.226360, 0.269549, 0.469104, 0.413667, 0.499478, -0.916526, -0.719485, 0.214227, 0.169734, 0.644218, 0.422961, -0.265778, 0.832107, 0.637555, -0.010574, 0.191362, 0.098572, 0.207733, -0.212657, -0.232127, -0.257683, -0.044623, -0.052474, -0.838015, -0.032110, -0.636859, 0.409736, 2.072948, 0.469906, -0.228341, 0.211178, 0.419039, -0.108180, 0.519685, 0.420197, 0.117198, 0.253388, 0.236242, -0.008220, -0.540543, 0.030748, 0.050571, 0.329468, 0.336163, -0.107098, 0.481147, -0.379108, -0.262201, 0.072618, -0.083093, -0.042589, -0.459902, 0.237588, 0.584113, 0.199479, 0.433323, 0.385133, -0.989214, 0.752935, 1.206429, 1.192061, 0.674218, 0.851633, 0.317224, 1.109410, -1.054379, 0.107671, -1.141139, -0.926257, 0.495220, 0.043522, -0.372025, -0.046307, 0.014210, -0.361879, 0.268112, 0.365139, -0.060435, -0.217411, -0.627766, 0.327538, -0.036475, -0.241806, -0.196171, -0.196676, -0.554228, -0.122586, 0.065475, 0.092707, 0.138420, -0.419900, -0.001441, -0.315345, -0.159247, 0.152587, 0.323649, -0.063305, -0.228683, -0.061497, 0.171805, 0.092745, -0.148260, 0.348510, 0.758837, 0.265829, 0.155105, 0.072077, -0.102984, -0.092338, -0.613245, 0.137334, -0.106024, 0.289393, 0.005212, 0.123442, 0.387148, -0.262621, -0.284923, 0.285464, 0.641808, -0.075595, -0.234170, 0.030013, 0.106819, 0.042235, -0.259847, 0.056672, 0.304366, 0.141956, -0.041540, -0.124042, -0.215990, -0.432909, 0.479677, 0.528985, 0.104032, -0.034408, 0.114468, -0.071400, 0.243995, -0.267080, -0.161519, -0.364678, 0.115833, 0.336181, 0.403349, -0.385649, -0.468498, -0.188055, 0.170738, -0.209979, -0.218509, -0.361453, -0.097818, -0.136702, 0.309090, -0.034608, -0.031322, -0.346342, -0.053311, -0.298835, -0.194369, 0.193189, 0.035788, 0.120176, -0.276414, -0.434547, -0.125360, -0.138755, -0.404817, -0.022486, -0.017264, 0.123380, -0.180067, -0.087676, 0.235890, -0.328683, 0.267576, 0.277158, 0.197484, 0.038425, 0.701434, 0.528869, 0.764378, 0.837598, 0.220573, -0.045697, 0.345133, 0.444616, 0.114456, 0.352649, 0.484919, 0.633622, 0.278994, 0.137944, -0.321820, -0.420068, -0.502137, -0.888584, -0.522242, -0.617963, -0.741411, -0.782387, -0.646341, -0.492641, -0.203946, -0.170153, 0.321146, 0.298498, 0.094560, -0.281919, -0.048691, 0.448927, -0.098949, 0.124426, 0.353598, 0.284110, -0.264250, -0.049488, 0.698584, 0.036195, -0.299921, 0.168761, 0.211543, 0.314693, -0.311789, -0.299266, 0.163432, 0.212484, -0.511733, -0.148356, -0.076281, 0.393015, -0.252348, 0.441110, 0.097936, 0.674145, -0.631252, 0.093418, 0.016328, -0.204325, -0.310776, -0.124180, -0.072672, 0.004872, -0.279702, 0.067003, 0.109290, -0.324728, -0.092678, 0.529189, 0.152113, -0.166716, -0.501876, 0.299504, 0.271460, 0.285205, 0.367437, -0.314263, 0.037050, 0.382274, -0.209657, 0.138679, 0.402115, 0.203438, -0.074817, 0.165475, 0.708546, 0.224162, 0.126861, 0.077451, 0.145143, 0.661685, 0.141852, 0.225107, 0.335256, 0.460678, -0.036405, -0.000389, 0.806922, -0.037775, -0.247647, 0.001351, 0.227884, 0.757945, 0.045950, -0.193301, 0.067354, 0.086789, -0.640538, 0.142709, -0.099397, 0.574548, -0.090530, 0.202695, 0.050159, -0.022058, -1.047341, -0.592198, 0.521220, 0.254842, 0.146206, -0.180513, 0.041735, -0.447629, -0.633639, 0.343432, 0.130743, -1.156804, 1.035159, 1.582462, 0.273109, 1.095382, 1.077446, 0.373363, 0.169329, 0.383380, 0.780195, 0.299438, 0.232152, 0.068402, 0.006898, 0.305906, -0.455680, 1.316349, 0.394654, 0.022368, -0.217710, -0.318082, -0.066257, -0.065523, -0.325677, 0.033216, 0.654095, 0.216476, 0.208042, -0.309941, -0.214978, 0.705821, 0.327790, -0.405078, 0.746160, 0.135097, -0.692086, 0.339260, -0.085093, -0.085182, 0.043147, -0.567805, -0.241221, 0.426412, 0.037729, 0.574091, -0.125009, 0.247172, -0.050583, 0.013665, -0.184252, -0.230181, 0.032521, 0.295078, 0.196494, 0.232078, -0.056687, -0.047691, -0.249277, -0.175928, -0.129403, 0.547618, -0.161952, -0.321054, -0.077688, 0.026157, 0.313019, 0.243258, 0.298582, 0.013489, 0.034255, -0.329852, 0.235962, 0.331049, -0.309203, -0.148955, 0.001124, 0.066910, 0.128058, -0.031860, -0.363031, -0.074325, 0.028287, 0.150217, -0.371649, 0.133904, 0.348957, 0.014316, 0.121676, -0.321962, -0.191355, 0.536343, 0.495671, -0.317116, 0.483029, -0.027624, -0.708474, -0.023304, 0.020046, -0.058165, -0.069732, -0.329664, -0.431724, 0.808205, 0.112147, 0.522777, -0.168635, 0.411033, -0.181666, 0.413743, 0.093227, -1.602479, -1.713207, -0.771059, -1.679564, -1.842163, 0.650403, -0.308845, -1.006719, -0.809566, -1.477169, 0.812380, -2.130913, -0.589227, 1.172363, -0.494082, -1.909285, 0.593687, -0.946825, -1.765859, -1.268591, 0.049588, -1.625170, -2.430139, 0.067714, -0.277171, -1.141941, -1.861535, -0.498521, -0.449752, -0.615820, -0.514792, -0.398615, -0.203320, -0.215616, -0.169642, -0.016805, 0.116410, 0.052216, 0.466454, -0.342013, -0.085853, 0.349667, -0.082048, -0.355489, -0.244302, -0.771480, -0.128304, 0.104557, -0.022349, -0.091910, -0.365362, 0.128362, 0.281584, -0.377924, -0.320615, -0.108900, -0.654429, -0.256486, 0.007309, -0.109476, 0.137354, -0.150574, -0.125599, -0.048543, -0.089267, 0.076369, -0.004598, 0.037795, 0.357540, 0.118615, -0.199084, 0.270729, 0.136255, 0.111764, -0.145174, -0.323003, 0.096523, -0.359201, -0.235996, 0.083173, -0.050366, 0.301803, -0.122230, 0.064597, 0.143628, -0.167591, 0.015303, -0.018578, -0.401890, -0.719016, -0.333946, -0.588085, -0.057038, -0.511103, -0.414273, -0.105258, -0.210476, -0.006245, 0.035758, -0.579246, -0.234461, 0.188291, -0.403684, 0.019267, -0.305536, -0.370608, -0.368409, 0.187105, -0.104013, -0.288746, -0.064831, -0.028659, -0.052798, -0.450637, -0.217390, 0.034980, -0.371177, -0.237478, -0.863133, 0.494016, -0.642438, -0.419161, -0.808943, 0.401287, 0.497140, -0.132810, -0.148610, 1.115864, 0.619892, -0.398224, 0.765091, 1.036962, 0.132816, 0.985132, 0.883046, 1.265035, 0.252401, -0.112816, -0.172690, 0.436350, 0.323153, 0.012273, -0.223365, -0.577829, -0.167255, -0.446465, 0.003826, 0.013346, -0.296083, -0.466705, -0.102197, -0.162834, -0.236628, -0.026081, 0.692019, -0.096547, -0.218310, -0.154624, -0.252680, 0.103371, -0.138151, -0.350314, 0.024695, -0.381986, -0.353908, -0.265325, -0.252486, -0.560583, -0.210222, -0.329504, 0.279421, 0.473964, 0.436972, 0.114514, 0.365447, 0.224695, 0.065896, 0.465467, 0.080008, 0.031300, -0.016094, 0.050977, -0.184426, -0.158791, -0.152447, -0.287389, -0.014118, 0.356817, 0.068629, -0.306963, -0.023160, -0.122106, 0.064723, 0.198719, 0.161248, 0.254635, -0.205145, -0.083608, -0.047706, -0.164654, 0.018392, 0.335004, 0.250227, 0.381054, 0.218155, 0.089108, -0.295414, -0.251868, -0.337900, -0.471902, 0.117361, -0.094407, -0.235143, 0.069174, 0.935802, -0.032237, -0.106308, -0.024602, -0.160656, 0.012633, -0.197080, -0.356762, 0.177702, -0.159704, -0.607821, -0.060974, -0.191098, -0.506571, -0.339376, -0.411701, -0.012314, 0.288960, 0.268793, -0.090752, 0.227095, 0.220922, 0.135658, 0.542847, 0.903898, 0.131167, -0.417212, -0.876524, -0.420820, 0.063496, -0.654460, 0.343026, 0.523087, -0.025375, 0.237895, -1.550645, 1.641521, -2.255173, 0.326500, 0.955563, -1.904380, -1.339332, -1.508886, -1.385752, -0.676425, -2.261172, -2.163976, -1.439447, -2.700100, -1.607981, -1.063371, -1.167902, -1.355231, -1.291539, -0.533170, -0.945619, -0.286844, -0.309502, -0.381243, -0.486258, -0.243049, -0.471275, -0.379232, -0.564999, -0.776058, -0.240357, -0.651335, -0.372435, -0.388052, -0.295599, -0.520198, -0.465297, -0.378138, -0.182506, -0.207653, -0.145601, -0.097187, -0.278891, -0.132675, 0.092685, -0.091137, -0.671231, -0.637227, -0.401164, 0.158585, 0.194947, 0.138554, 0.270944, -0.002906, -0.101849, 0.229971, 0.121744, -0.340461, -0.423508, -0.215226, 0.146094, -0.066153, 0.187590, 0.333247, 0.094820, 0.225547, 0.294569, 0.117592, -0.520407, -0.433154, -0.012178, -0.603042, -0.273652, 0.298290, -0.142160, 0.328581, 0.283240, 0.095847, -0.368713, -0.598647, -0.765881, -0.228585, -0.232568, -0.400501, -0.312349, -0.202631, -0.203129, -0.265351, -0.427234, -0.652067, -0.169747, -0.629937, -0.315105, -0.322040, -0.204961, -0.027272, -0.378131, -0.379476, -0.227601, -0.508690, -0.534789, -0.334947, 0.031212, -0.057054, 0.168887, 0.237087, -0.215990, -0.333387, -0.111438, 7.348277, -3.138036, -2.792513, -2.961163, -2.988272, -1.447296, -1.410859, -2.015852, -3.107716, -0.751126, -0.812384, -1.650912, 0.019140, -0.464542, -0.124292, -0.014513, -0.210931, -0.547823, -0.418353, 0.391628, 0.176189, 0.320861, -0.177082, 0.019572, -0.060719, 0.173530, -0.240436, -0.303414, -0.711744, -0.764976, 3.240488, 2.139011, 2.715394, 1.909015, 1.377153, 0.974616, 0.836896, 0.621484, 0.277063, 0.465678, 0.180641, -0.109888, 0.613192, 0.016965, -0.310528, -0.282497, -0.678581, -0.802444, -0.840399, -0.587948, -1.307438, -0.955458, -0.574059, -1.153534, -1.376948, -1.097648, -1.602537, -0.667387, -1.148969, -0.842408, -0.195824, 0.232808, -0.437902, 0.055740, 0.559021, 0.554272, -0.236309, 0.266322, -0.303776, 0.146120, 0.189617, -0.632629, -0.602673, 0.359457, -0.042592, 0.071806, 0.597082, 0.286387, 0.053659, 0.052873, 0.168746, 0.038748, 0.125976, 0.556099, 0.175101, -0.210028, 0.667155, 0.546105, 0.115678, 0.142922, 1.891843, 1.067371, 2.281111, 1.307200, 0.641912, 0.844827, 0.790733, 0.406538, 0.353273, 0.725523, 0.339404, -0.053686, 0.795803, 0.433672, -0.210028, 0.029223, -0.003421, -0.017794, -0.262208, -0.152626, -0.667966, -0.361420, 0.170206, -0.476185, -0.737955, -0.267497, -0.554213, -0.191738, -0.519526, -0.669529, -0.819476, 1.283924, -0.361597, -1.330922, 0.274494, -0.215105, 0.209499, 0.941284, 0.603250, 0.570024, 0.060927, 0.724558, 1.014760, -0.931852, -1.880037, -0.581017, -0.780461, -0.830182, 0.641381, 0.143699, -1.728917, -0.681911, -0.603968, 0.774200, -0.329029, 0.025384, -0.076094, 1.187203, -0.384175, 0.077043, -0.365496, -0.733386, -0.287753, -0.266649, -0.221410, -0.411676, -0.293809, -0.159060, -0.235039, -0.210366, -0.081596, 0.045719, -0.140071, -0.015999, -0.185685, 0.129473, -0.634224, 0.075981, -0.258127, -0.400817, -0.238106, 0.042257, -0.420680, 0.094566, -0.316332, 0.085930, -0.189992, -0.106622, -0.203460, -0.335825, 0.059446, 0.071920, -0.004463, -0.076016, -0.044283, -0.143485, 0.083287, 0.403178, -0.022460, 0.060926, 0.176541, 0.074280, -0.211772, -0.229950, 0.013963, 0.003165, 0.016316, -0.025467, 0.170287, 0.253443, -0.118132, -0.292185, 0.346623, 0.019883, -0.154160, -0.113251, 0.098126, -0.066858, -0.116473, -0.080741, -0.449468, -0.618357, -0.063581, -0.211602, 0.099514, -0.273016, -0.044786, -0.175828, -0.230607, -0.224408, -0.347500, -0.167937, -0.183486, -0.231016, -0.262348, -0.025320, -0.393167, -0.036562, -0.361801, -0.210819, -0.038801, 0.173106, -0.244993, 0.177738, -0.010970, 0.128257, -0.178680, 0.023312, -0.124054, -0.212967, 0.851345, 0.073451, -0.096384, -0.687547, -0.460157, 0.143591, -0.330642, 0.077410, 0.730232, 0.263640, -0.072778, -1.553344, 1.753347, -2.559866, 0.719632, 0.819880, -1.882476, -1.406749, -1.611680, -1.095467, -0.702665, -2.552383, -2.290245, -1.221315, -2.220447, -1.947796, -1.286733, -1.179005, -1.383277, -2.145092, -0.541379, -0.891342, -0.003436, -0.470746, -0.606792, -0.514061, -0.403136, 0.097953, -0.243931, -0.802611, 0.298829, -0.350248, -0.089957, -0.083049, -0.074511, -0.592574, -1.027339, -0.644387, -0.252656, -0.414553, -0.899722, -0.125959, -0.838715, -0.615223, 0.115139, 0.343929, -0.493722, -0.343953, -0.401389, -0.175460, -0.008614, -0.128743, -0.154494, 0.025156, -0.070436, -0.023052, -0.048614, 0.158424, -0.006438, -0.255871, -0.268529, -0.304955, 0.062119, 1.000294, 0.387698, -0.346001, 0.028089, 0.221138, -0.258396, -0.764107, 0.363264, 0.893013, -0.114477, -0.511979, 0.421649, 0.282704, -0.040608, -0.415614, -0.238184, -0.045683, -0.555843, -0.707997, -0.125547, 0.016871, -0.336302, 0.069100, -0.586413, -0.070408, -0.429687, -0.763007, 0.678413, -0.383293, -0.564612, 0.184207, 0.440243, -0.700954, -0.454584, -0.544748, 0.030929, -0.373757, -0.418372, -0.114519, -0.986469, -0.631473, 0.739802, 0.237850, -0.046613, -0.099323, -0.016373, -0.243177, -0.570899, 0.923141, 0.103642, -0.434691, 0.829031, -1.235091, -1.541809, -0.314675, 0.004087, 0.151215, 0.729392, -0.794783, 0.282505, -0.309404, -1.494315, 0.685569, -1.335065, -1.146867, -1.318362, -0.074587, -0.513543, 0.767591, -0.163666, 0.686676, -0.293643, -0.449246, -0.415115, 0.432483, -0.868088, -0.387763, -0.448062, -0.527715, -0.298735, -0.331881, -0.111462, -0.290400, -0.379410, -0.139480, -0.137437, -0.349183, -0.015034, 0.106026, -0.105789, 0.124190, -0.012570, -0.161247, -0.057857, -0.213518, 0.205796, -0.272388, -0.001776, -0.368257, -0.295079, -0.412416, -0.208066, -0.057030, -0.265542, -0.318901, -0.339357, -0.208537, 0.062027, -0.058172, 0.136569, 0.004639, 0.145603, 0.042303, -0.050700, -0.041501, -0.018840, 0.041273, -0.015426, 0.065813, 0.015636, -0.144623, -0.120606, 0.006393, -0.084899, 0.046520, -0.114597, -0.083765, 0.090261, -0.046501, -0.012834, -0.034559, -0.027334, 0.071574, -0.017962, -0.036744, 0.035042, -0.092442, -0.472431, -0.586283, -0.083818, -0.160842, 0.003080, -0.221293, -0.341757, -0.287262, -0.146571, -0.201938, -0.200229, -0.020531, -0.146775, 0.155493, -0.102480, -0.056399, 0.097047, -0.113914, 0.207947, -0.476430, 0.270543, -0.213076, -0.189646, -0.214187, -0.093348, -0.131137, -0.106174, -0.113637, -0.096402, -0.221229, 0.130420, 0.370654, 0.505018, 1.022994, -0.957076, -1.349681, -0.668292, 0.103603, -0.434742, -0.078936, 0.069120, 0.394039, -0.377865, 0.910265, 0.929342, -0.198548, 0.476951, -0.542006, 0.104439, 1.343569, 0.791369, 1.198533, 1.417050, 0.949500, 0.748518, 1.150365, 1.583485, 0.407402, 0.836830, 0.148858, 0.124861, 1.454502, -0.334107, -0.207596, -0.553244, -0.058531, 0.123659, -0.105046, -0.168327, -0.249193, -0.064294, -0.294335, -0.140206, -0.364021, 0.419487, 0.534342, 0.652564, -0.013171, -0.527213, -0.254526, -0.422669, 0.021667, -0.250559, 0.009768, 0.255811, 0.005720, 0.736621, 0.621223, -0.094826, -0.104806, 0.261327, 0.043394, 0.081319, 0.157025, -0.102219, -0.011376, 0.099620, -0.368919, -0.190999, -0.347268, -0.067366, 0.091143, 0.216450, 0.340644, 0.187827, -0.434574, -0.286704, -0.369185, 0.049762, 0.538561, -0.216839, 0.313261, -0.284672, -0.119536, -0.025705, -0.294816, -0.405434, 0.252409, 0.257109, 0.107247, 0.437923, 2.257642, -0.186374, -0.262694, -0.688174, -0.203162, 0.207171, 0.255839, 0.079201, -0.110985, 0.071115, -0.691151, 0.014150, -0.399757, 0.695544, 0.641044, 0.639221, 0.227129, -0.560655, 0.075767, -0.535560, -0.174809, -0.059789, -0.261505, 0.252684, -0.002135, 0.669760, 0.739038, 0.112805, -0.450849, 1.313390, -1.213113, -1.964652, -1.826941, -1.224736, -2.364318, -3.114630, -2.344623, -0.827095, -0.001460, -2.967567, 1.636074, -0.408804, -0.824970, 0.109066, 2.260342, -1.668078, -0.794673, 0.015901, -2.082363, -0.790477, 0.386258, -0.385415, -0.750377, -0.774217, -0.790258, 0.952630, -2.005727, -0.585115, -1.010999, -0.514596, -0.508520, -0.077477, 0.153821, 0.804952, 0.104139, -0.056684, 0.671377, -0.583705, 0.031247, 0.558145, -0.318951, -0.701557, 0.388225, -0.712442, -0.508538, 0.189927, -0.184631, -0.341926, -0.457615, 0.178470, -0.307669, 0.054924, -0.094414, -0.286499, 0.081453, -0.087301, 0.102502, -0.599742, -0.236735, -0.101993, 0.224681, 0.483817, 0.098014, -0.208655, 0.687460, 0.102408, -0.475286, -0.356582, -0.471011, -0.292322, 0.037245, 0.112590, 0.843960, 0.300142, -0.572320, -0.048485, 0.017001, -0.380538, -0.472393, 0.816037, 0.328270, 0.201023, -0.051222, -0.131135, 0.158178, -0.233152, -0.088303, 0.178681, -0.137138, -0.578866, -0.427992, -0.266201, 0.529279, 0.538768, -0.296263, -0.014856, 0.240258, -0.173209, -0.407015, 0.452328, -0.202526, -0.860027, 0.073303, -0.317545, -0.030271, 0.409031, -0.300479, -0.298001, -0.154104, 0.165074, -0.566422, -0.006470, -0.466965, 0.541829, -0.268721, 0.247959, -0.018159, 0.359338, -0.183417, 0.115205, 0.528713, -1.852522, -0.408780, -0.037267, -0.075512, -0.242867, -0.447032, -0.199964, 0.493648, -0.652605, -0.766660, 0.564982, -0.014185, 0.052598, 0.211069, 0.291458, -0.480125, 0.803190, -0.083014, 0.179389, 0.538250, 0.349404, 0.132005, 0.040046, 0.459679, 0.308623, 0.036387, -0.237085, -0.625667, 1.386979, 0.568341, 5.237174, 1.456136, 0.649883, 0.411203, 1.257971, 0.910185, 0.615289, 0.360999, 0.210740, 0.243515, -0.664131, 0.442417, 0.344546, 0.572692, 0.338554, 0.173331, 1.095836, -0.564524, 0.665739, 0.678849, 0.218254, -0.165463, -0.146614, 0.095212, -0.200822, 0.061549, 0.023903, 0.298569, 0.162894, 0.711153, 0.724681, -0.422630, -0.374465, -0.514464, -0.077216, -0.168686, 0.159141, -0.324006, -0.538425, 0.081111, -0.217323, 0.029664, -0.388418, -0.138691, 0.095005, -0.292076, -0.148995, -0.174142, -0.122506, -0.373740, -0.039189, -0.126698, -0.076371, 0.172072, 0.022043, -0.321694, 0.116437, 0.347687, 1.510494, 0.534068, 4.385194, 1.722825, 0.603595, 0.736907, 1.148140, 1.042638, 0.738311, 0.371167, 0.505393, 0.148364, -0.447308, 0.336622, 0.500542, 0.474203, 0.183213, 0.050214, 1.282634, -0.223406, 0.949373, 0.523054, 0.337280, 0.211041, -0.092508, -0.172479, -0.156216, 0.375453, -0.381290, 0.323453, 1.213244, 0.463240, -1.357001, -0.629975, -1.136808, -0.050125, -0.086388, -0.328213, -0.879269, 0.529053, 0.336508, -0.185405, 0.241267, 0.970581, 0.722208, 0.525835, 0.663354, 0.410825, 0.178659, 1.260670, 0.419766, 0.930795, 0.265708, 0.512051, 0.696792, 0.415763, 0.623812, -0.306605, 0.389627, -0.093371, 0.742388, 0.393721, -0.063316, 0.065761, -0.515536, -0.426872, -0.423714, 0.088181, -0.152412, -0.205730, 0.419168, -0.172140, 0.286760, -0.076571, 0.065319, -0.380622, -0.115050, -0.144929, 0.084015, 0.058701, 0.008698, 0.127523, -0.040707, 0.041227, -0.392825, 0.085670, 0.622529, 0.015958, 0.229429, 0.004590, 0.191969, -0.167468, -0.021065, -0.162198, -0.026121, 0.284292, 0.260698, -0.497733, -0.436448, -0.037992, -0.085316, 0.065190, -0.363718, -0.107518, 0.706730, 0.468940, 0.270456, 0.114826, -0.181992, 0.345095, 0.126970, 0.216387, -0.180952, -0.150004, -0.054920, -0.304992, -0.285307, 0.404000, -0.115962, 0.099462, 0.863433, 0.219643, -0.048677, 0.053549, -0.450471, -0.085967, -0.308334, 0.280519, -0.074279, -0.308475, 0.232777, -0.367858, 0.429920, 0.008997, 0.166699, -0.091531, -0.230277, -0.250500, -0.018680, 0.002799, -0.165902, 0.222289, 0.019666, 0.025613, -0.430847, 0.011012, 0.558837, -0.129838, 0.259012, -0.053773, 1.318621, -1.207761, -1.982068, -2.253547, -1.504216, -2.593046, -2.977955, -1.902121, -0.755620, -0.233325, -3.404022, 1.361444, -0.777356, -0.973993, 0.128763, 2.035826, -1.649054, 0.058800, 0.160335, -2.023940, -0.328958, 0.153844, -0.098674, -0.447202, -0.811253, -0.473155, 1.362263, -1.317053, -1.030379, -1.034540, -0.485796, -0.136940, 0.207436, -0.157896, -0.052752, -0.489458, -0.032326, -0.119447, -0.500704, -0.197649, 0.371539, 0.023802, 0.199167, 1.353967, 0.266619, -0.190325, -0.177431, -0.221813, -0.029259, 0.169665, -0.606720, -0.669584, -0.716387, 0.143364, 0.531790, 0.240913, -0.039566, -0.228383, -0.069836, -0.461459, 0.138056, 0.560244, 1.085229, 0.544294, -0.246454, -0.031027, -0.277940, -0.513897, -0.231753, 0.370840, 0.271960, 0.038176, 1.251851, 0.867919, 0.353373, -0.169392, -0.758482, -0.679307, -0.065630, 0.095951, -0.070086, -0.670196, 0.377492, 0.003802, 0.768955, 0.140794, -0.224442, -0.120099, -0.438434, -0.107364, -0.490231, -0.339581, 0.505759, 0.209609, 0.012099, -0.086856, 0.372775, -0.211700, -0.449641, -0.397232, -0.092978, -0.101586, 0.580125, 0.860490, 0.475189, -0.037212, -0.185165, -0.037939, -0.006407, -0.022410, -0.570071, -0.616500, -1.025878, -0.016962, 0.446994, 0.323293, -0.143355, -0.212245, 0.039361, -0.832743, 3.631858, -0.666188, -1.473966, -1.179541, -1.597607, -0.393743, -0.584457, -1.053637, -1.934211, -0.352938, -0.596968, -0.899753, -0.026455, 0.060549, -0.047533, -0.099240, 0.150076, -0.431699, 0.004685, 0.272106, 0.134860, 0.526449, -0.026530, 0.321817, 0.361711, 0.385805, 0.068557, -0.036657, 0.074375, -0.578017, 5.981561, 4.124367, 1.763422, 2.076562, 0.946966, 0.880845, 0.991917, 1.022334, 1.678530, 0.633739, 0.369713, 0.240677, -0.122805, -0.074664, -0.349679, 0.205465, -0.657661, 0.009201, 0.057243, -0.404775, -0.478929, -0.375936, -0.293521, -0.291384, -0.738376, -0.800074, 0.174396, -0.423766, -0.082998, -0.714870, 1.082292, -0.481924, 0.966209, 0.297134, 0.471264, -0.396741, -0.350596, -0.094896, 0.056565, -0.374831, -0.937633, -0.366923, 0.453196, 0.080255, 0.039495, 0.158870, -0.391800, 0.126187, -0.177283, -0.462946, -0.345189, -0.172216, -0.160803, -0.259263, -0.089523, -0.016596, 0.359878, 0.242541, -0.186681, 0.100049, 4.062471, 2.479880, 0.924184, 1.560214, 0.380033, 0.775173, 0.891625, 0.575397, 1.071829, 1.041632, 0.271806, 0.258756, -0.215352, -0.223961, -0.296997, 0.363934, -0.285173, 0.168582, -0.098622, -0.532574, -0.390589, -0.201032, 0.044721, -0.207733, -0.137451, -0.667421, 0.336337, -0.123540, 0.218927, -0.462441, 3.615192, -1.027374, -1.942783, -1.280261, -1.575563, -0.698386, -0.876217, -1.518509, -1.588890, -0.462685, -0.550809, -1.458491, 0.088996, -0.229225, 0.050328, -0.121885, 0.024619, -0.544062, 0.202003, 0.474185, -0.173910, 0.429214, -0.191541, -0.239013, 0.021536, 0.043413, -0.128090, -0.512383, -0.196360, -0.843042, 8.589368, 4.412762, 2.734690, 3.691734, 2.367962, 1.185619, 0.955518, 0.621796, 1.113945, -0.045976, -0.504259, 0.485930, -0.517019, 0.018348, -0.585841, -0.048331, -0.110429, 0.052339, -0.059363, -1.157917, -1.006450, -0.688436, -0.412446, -0.675333, -0.346458, -0.790892, -0.158655, -1.164203, -0.645530, -0.304380, -6.870567, 1.610145, 1.290851, 1.974707, 1.494598, 1.090946, 0.953783, 0.925918, 1.020239, 0.776671, 0.835126, 0.418571, 0.470528, 0.854484, 0.334011, 0.523532, 0.096543, 0.461845, 0.299990, 0.156944, 0.313418, 0.184922, 0.447662, 0.178808, 0.206474, -0.232593, 0.146873, -0.071621, -0.190900, 0.123186, 8.626092, 2.862414, 2.696537, 2.950049, 1.908564, 0.806443, 0.665600, 0.495263, 0.903019, 0.211486, -0.097990, 0.812799, 0.124055, 0.477357, -0.091915, -0.026447, 0.049464, 0.625749, 0.054958, -0.421832, -0.422105, -0.136521, -0.100848, 0.084841, -0.015705, -0.462207, 0.022392, -0.704901, -0.242262, 0.299610, -0.715823, 0.629382, 0.426068, -0.134087, 0.596878, 0.863890, 0.242028, 0.044646, -1.219894, -0.957207, -0.740245, -0.832684, 0.092523, -0.537974, -0.023001, 0.472577, 0.083956, -0.281030, 0.523367, 0.015086, 0.265629, -0.251988, 0.482732, 0.117014, -0.793234, -0.966640, -0.834370, -0.457964, -0.517758, -0.882623, -0.439084, -0.783453, -0.620507, -0.427593, -0.563983, -0.556966, -0.491796, -0.362936, -0.253379, -0.294206, -0.060010, -0.239419, -0.482285, -0.164983, 0.061746, 0.210500, 0.458996, 0.628536, 0.354231, 0.880025, 0.232589, -0.022802, 0.062822, -0.130813, -0.375142, 0.015442, 0.091259, -0.501058, -0.214189, 0.258535, 0.147210, -0.054182, -0.111000, 0.095860, -0.070191, 0.082524, 0.358744, 0.057833, 0.236097, 0.063944, -0.273232, 0.114128, 0.211599, -0.014109, -0.165036, -0.272418, 0.270305, 0.492636, -0.051937, -0.151477, -0.140254, -0.102318, 0.205129, 0.393277, -0.081414, -0.297139, 0.125827, -0.080589, -0.564244, -0.279194, -0.443621, -0.549502, -0.527392, -0.424202, -0.374644, -0.532771, -0.479470, -0.303301, -0.080648, -0.277675, 0.076529, -0.261329, -0.346572, -0.237232, 0.340673, 0.111190, 0.117950, 0.222292, -0.007322, 0.302140, 0.021481, -0.211490, 0.071386, 0.066541, -0.167128, -0.141662, 0.113201, -0.298193, -0.177316, 0.140661, -0.054824, -1.252381, -0.615192, 0.619729, 0.347446, -0.001540, -0.355024, -0.355782, -0.533656, -0.795979, -0.164648, 0.164363, -1.207694, 0.958013, 1.675153, -0.203075, 1.124220, 1.013738, 0.591506, 0.242791, 0.679092, 0.751917, 0.040474, 0.701748, -0.135069, 0.305614, 0.293556, -0.098717, 0.959757, 1.007626, -0.093173, -0.246244, -0.135763, 0.062183, -0.173044, 0.234341, 0.140308, 0.541011, -0.082712, -0.147354, 0.018291, 0.305068, 0.315880, 0.029013, 0.174899, 0.074218, 0.148787, -0.098992, 0.191058, -0.156409, -0.126562, 0.052047, 0.538164, 0.527567, -0.064619, 0.480865, 0.121147, -0.126139, 0.176698, 0.233907, 0.138915, 0.018654, -0.223659, 0.275394, 0.073552, 0.395393, 0.157596, -0.026649, -0.056151, -0.071513, -0.199424, -0.059468, 0.063462, -0.165746, -0.087323, -0.317785, 0.038095, 0.212235, -0.361374, -0.251729, -0.248381, -0.112687, 0.035175, 0.171234, -0.087687, -0.069745, 0.279458, -0.143834, -0.095391, 0.019768, -0.407804, -0.397385, -0.367663, -0.261595, -0.290113, 0.120504, 0.113178, 0.196101, -0.136170, -0.083533, -0.052586, 0.344502, 0.010667, -0.160323, 0.082834, -0.295148, 0.089881, -0.006785, 0.120538, -0.029060, -0.017058, -0.115675, 0.593514, 0.280447, 0.048114, 0.405060, 0.129020, -0.231038, -0.045008, -0.196666, -0.184831, -1.076530, -0.373550, 0.785807, 0.961288, 0.396294, -0.079988, -0.210834, -1.209093, -0.085108, -0.572564, -0.283158, -1.050203, -0.052485, -0.087700, -0.484017, 0.263101, -0.310340, -0.387593, 0.543716, 0.202094, 0.730631, 0.729363, 0.818774, 0.680541, 1.186524, 0.633584, 0.849505, 0.731311, 0.945646, 0.093587, -0.321282, 0.198037, -0.648919, -0.669632, 0.231385, -0.347125, 0.139796, -0.589906, -0.736493, 0.199392, 0.887957, 0.688531, 0.089848, -0.285574, -0.164135, 0.179477, -0.178226, -0.516110, -0.462017, -0.048515, -0.588572, -0.089953, 0.523944, -0.296809, 0.323347, 0.337418, 1.568344, -0.776370, 0.015357, -0.617383, 0.183891, 0.428363, -0.253341, 0.822365, 0.788597, 0.336889, 0.377388, -0.439697, -0.545259, -0.149430, 0.758294, -0.315032, 0.301568, -0.015112, 0.586710, -0.767076, -0.301068, -0.237089, 0.307221, 0.391563, 0.875042, 0.255269, -0.524818, 0.278352, 0.416038, -1.494963, 0.774774, 0.782777, -0.278113, -0.058457, -0.489899, -0.095412, -0.140618, -0.882978, 0.389704, 0.201922, -0.594101, -0.351131, -0.603403, -0.219506, 0.588098, 0.828939, 0.396047, 0.702949, 0.109339, -0.081953, 0.488142, -0.244076, -0.246339, 0.405146, -0.086064, 0.193724, -0.227988, -0.775359, 0.660859, 0.603661, 2.238620, -0.583549, 0.413898, -0.092538, -0.962199, -0.071725, 1.350576, 1.053856, 0.733323, 0.200512, -0.264650, -0.490887, -0.765433, -0.525526, -0.665274, -1.915729, 0.580282, -0.252047, -1.523506, -0.013775, -0.516173, -0.550168, -0.383766, 0.428100, 1.233361, 0.620766, 1.423090, 1.411653, 0.775773, 0.921115, 0.656493, 1.418622, 0.999675, -0.137053, -0.343193, -0.442763, -0.307407, -0.537052, -0.519957, -0.091027, 1.141087, 0.180209, -0.014611, -0.131147, 0.287055, 0.749340, -0.629828, -0.243925, -0.122035, -0.600838, 0.521157, -0.618107, -0.186685, -0.254422, 0.144438, -0.615288, 0.282379, -0.165096, -0.254271, 0.440135, 0.946893, -0.526023, 0.623167, -0.035288, -0.145734, -0.024372, 0.179945, -0.221679, 0.059480, 0.163242, 0.119192, -0.126742, -0.584431, -0.151231, 0.327280, 0.168082, 0.160114, -0.290877, -0.087993, 0.225432, 0.124682, 0.760123, 0.400368, -0.043302, -0.247130, 0.448604, 0.100654, -0.237776, -0.177378, -0.228710, -0.154971, 0.188333, -0.026591, -0.352782, -0.515682, -0.182830, -0.119788, -0.204600, -0.445247, -0.012930, 0.946971, -0.117076, 0.066145, -0.028932, 0.088412, 0.473513, -0.372889, 0.015991, -0.165366, -0.404799, 0.417293, -0.128319, -0.054860, -0.084134, 0.496418, -0.569684, 0.223089, 0.025048, -0.390150, -0.160817, 1.023669, -0.519720, 0.280853, -0.477391, 1.131099, 0.463211, -0.167460, 0.076666, 0.605951, 0.333126, 1.116717, 0.946405, 0.326896, 0.021684, 0.385583, 0.068039, -0.157455, -0.029424, -0.002431, 0.179733, 0.101252, -0.005607, -0.271900, -0.620209, -0.737040, -0.496778, -0.511732, -0.921227, -0.372950, -0.877984, -0.558197, -0.895523, -0.515055, -0.155502, -0.394068, -0.668557, -0.379874, -0.386434, -0.521674, -0.281787, 0.071927, 0.251130, 0.369824, -0.513610, -0.007505, 0.026214, -0.055274, -0.379365, -0.564541, -0.429118, 0.859120, 0.254950, 1.210556, 0.090868, 0.677086, -0.221194, -0.379005, -0.027322, -0.255140, -0.253483, 0.522128, -0.813192, 0.631403, -0.092944, -0.164781, 0.021352, 0.415255, 0.030542, -0.310435, -0.497551, -0.112776, 0.456873, 0.734191, 0.618214, 0.114691, 0.363930, -0.220294, -0.299186, -0.237614, -0.274938, -0.991727, -0.859906, 0.419588, 0.623561, 0.367028, 0.364187, -0.025304, -0.230535, 0.040088, 0.040302, -0.097705, 0.035215, -0.371606, -0.033518, -0.419632, -0.911791, -0.241739, -0.324560, -0.326525, 0.162008, 0.440221, 0.404296, 0.981569, -0.413160, 0.041594, 0.051716, 0.141928, -0.196834, -0.486936, -0.176914, 0.565402, -0.366215, 1.206400, -0.036636, 0.331656, -0.089539, -0.451489, -0.074571, -0.453252, -0.227726, 0.551016, -0.315575, 1.378369, -0.846747, 0.463460, 0.043215, -0.608058, 0.253115, 0.511822, 0.097441, -0.160393, -1.080514, -1.043230, -0.787274, -0.574600, 0.295922, -0.373891, 0.094217, 0.771530, 0.398011, 0.325642, 0.982912, 0.396460, 0.708971, 0.306306, 1.052085, 1.178754, 0.078642, -0.293508, -0.603435, 0.994300, -0.127922, -0.067534, -0.272005, -0.673907, -0.318549, -0.503369, 0.000009, -0.016257, -0.147265, -0.401595, -0.277705, -0.166358, -0.106320, 0.026386, -0.294223, 0.017843, -0.173849, -0.093683, -0.043101, -0.171608, -0.184502, 0.192663, 0.199755, 0.171141, -0.243154, -0.023789, -0.156768, -0.392078, -0.409278, -0.291101, -0.105107, -0.254603, -0.018059, -0.096648, 0.000345, -0.119492, -0.171834, -0.029135, 0.173072, 0.236431, 0.173719, -0.111371, -0.275151, -0.173659, -0.015226, 0.060835, 0.202789, 0.064131, 0.149546, -0.229153, -0.193713, 0.076808, 0.163322, 0.102900, -0.247231, -0.088641, -0.004172, -0.097508, -0.205894, 0.138088, -0.086378, -0.037273, -0.319655, -0.554270, -0.038950, -0.272041, 0.150612, -0.028976, -0.022945, -0.161433, -0.333881, -0.286816, -0.076106, -0.079151, -0.274002, -0.101643, -0.152461, -0.197911, -0.387397, -0.351619, -0.259586, -0.034640, -0.032046, 0.170296, -0.198206, -0.002087, -0.119834, -0.472301, -0.426890, -0.129515, 0.027065, 0.034552, -0.330071, 0.005639, -0.571686, -0.345949, -0.040778, -0.134575, -0.180777, -0.079154, -0.279269, 0.956801, 0.119347, -0.365664, 0.082892, -0.693298, -1.126276, -0.955063, -0.103048, -0.522336, -0.571433, 0.105313, -0.179801, -0.530935, -0.252247, 0.710951, 0.401202, 0.821236, 1.006602, 0.859657, 0.549021, -0.038083, 0.084683, -0.191631, 0.360218, -0.250719, 0.417754, 0.517412, -0.072122, -0.383608, -0.446793, 0.134894, 0.210915, 0.102531, -0.352970, 0.087366, -0.133495, -0.019602, -0.178248, -0.081797, -0.347267, 0.224636, -0.101422, 0.528537, -0.030859, -0.560393, -0.194891, 0.277510, 0.261214, 0.175768, -0.499403, 0.066481, -0.185113, -0.115707, 0.466580, 0.310606, 0.302410, 0.143860, 0.080406, -0.082940, 0.025694, 0.377404, 0.067628, 0.191268, -0.119751, -0.098642, -0.316075, -0.272977, 0.040523, -0.019722, -0.171116, 0.179973, 0.107487, -0.357709, 0.507947, 0.472540, -0.072824, 0.094868, -0.067793, 0.050176, 0.189927, 0.633181, 0.472275, 0.284268, 0.744015, -0.117950, -0.073639, 0.035708, -0.419988, -0.452028, -0.316353, 0.109741, 0.437927, 0.224009, -0.337111, 0.199262, -0.057019, -0.169984, 0.139928, -0.043637, -0.072845, 0.528184, 0.079785, 0.781305, -0.090685, -0.189193, -0.069093, 0.095992, 0.215399, 0.179523, -0.600358, -0.027545, -0.437549, -0.024243, -0.638337, 0.027617, 0.450600, 0.744650, 0.603033, 0.351901, 0.667093, 0.571941, 1.051270, 0.329101, -0.273308, 0.870775, 0.804869, -0.018763, 1.215438, 0.652185, -0.295795, 0.329239, 0.288017, 1.075546, -0.504034, -0.164091, 0.396782, -0.445275, 0.350342, -0.457610, 0.569579, 0.346408, 0.018146, 0.189940, -0.040899, 0.120319, -0.024331, 0.361719, -0.013042, -0.333026, 0.141736, 0.929067, 0.466397, 0.409927, 0.308393, -0.077013, -0.114380, 0.627733, 0.485664, -0.247715, -0.309545, -0.370262, -0.140910, 0.143630, -0.319001, 0.093812, 0.695577, -0.393172, 0.432985, 0.159555, 0.168539, 0.402739, -0.347800, -0.034716, -0.321945, -0.328353, 0.053073, -0.202761, 0.157029, 0.336477, 0.486587, 0.392372, -0.166691, 0.134591, 0.177204, -0.217277, -0.152432, -0.073108, -0.046737, -0.244945, 0.047187, -0.432115, 0.392625, 0.281939, 0.271519, -0.285622, -0.382937, 0.290712, 0.203922, 0.231436, -0.071164, 0.181149, 0.468213, 0.523075, -0.063260, 0.525509, 0.401907, 0.810989, 0.117141, -0.120565, 0.228038, 1.204259, 0.541364, 0.375461, 0.269395, -0.103706, -0.238175, 1.338743, 0.907118, -0.168465, -0.118250, -0.030611, 0.306538, 0.128927, -0.119342, 0.270595, 0.769672, -0.542258, 0.981876, -0.044995, -0.106467, 0.223290, 0.394664, -0.792719, 0.751081, 1.106954, 1.186774, 0.701667, 1.088248, 0.442673, 0.942351, -1.097359, -0.251412, -1.267361, -1.164357, 0.283540, 0.008841, -0.497368, -0.356353, -0.048223, -0.559604, 0.156418, 0.407145, 0.012275, 0.011355, -0.745808, 0.378720, 0.182034, -0.323311, -0.101927, -0.249339, -0.597823, -0.115339, 0.117824, 0.032958, 0.129147, 0.107563, -0.070322, -0.589504, -0.534671, 0.002067, 0.101676, -0.336438, -0.194332, 0.316899, 0.159470, 0.160736, 0.211874, 0.380724, 0.183253, -0.074804, -0.288414, 0.038007, -0.547595, 0.159711, -0.273423, 0.116453, -0.453988, -0.722100, -0.047157, 0.004094, -0.062949, 0.320197, 0.037435, -0.242107, -0.374084, 0.000014, 0.069357, 0.189963, 0.033087, -0.286824, -0.083696, 0.039492, 0.040804, -0.118303, -0.427743, 0.023501, 0.243856, -0.024452, -0.176556, -0.284672, 0.012830, 0.430572, 0.172924, -0.196341, -0.004269, -0.013761, -0.119014, 0.240232, 0.059222, -0.029983, -0.156864, -0.387431, -0.510346, -0.055221, -0.011700, -0.063885, -0.156139, -0.398691, -0.450213, -0.435949, -0.256418, -0.386166, -0.090987, -0.110129, 0.062267, -0.183867, 0.139717, -0.044996, -0.200750, -0.080705, -0.338166, -0.085182, -0.567594, 0.046630, 0.088214, -0.006787, -0.252771, -0.575823, -0.038352, -0.086544, -0.189635, -0.707189, 0.935561, -0.270278, -1.158080, 0.098071, -0.392061, 0.039822, 0.385965, 0.664264, 1.218596, 0.413600, 0.247808, 0.850144, -0.282431, -1.788382, -0.925433, -1.230681, -0.442093, 0.131396, -0.342103, -1.394652, -0.259391, -0.863378, 0.553100, -0.149810, 0.281617, -0.176317, 0.805456, -0.175239, 0.218520, -0.435358, -0.522764, -0.244185, -0.287941, -0.528277, -0.475311, -0.383606, -0.762539, -0.672215, 0.273945, -0.073569, -0.296298, 0.098128, -0.061104, 0.444598, 0.220808, 0.413245, 0.331556, 0.165217, 0.146150, -0.195118, -0.404176, -0.313599, -0.494758, -0.533187, 0.155030, -0.426903, -0.589974, -0.334934, -0.280945, -0.060615, -0.027022, 0.115099, 0.281036, 0.127131, -0.093184, -0.017458, -0.240899, 0.046911, -0.141614, -0.297706, 0.198677, 0.015753, -0.151772, -0.223294, 0.098340, 0.292848, -0.036620, -0.107454, -0.117437, 0.076188, 0.155394, -0.108747, 0.141825, -0.204144, 0.217743, -0.042198, -0.216426, 0.198249, 0.034592, -0.534238, -0.505523, -0.247636, -0.080526, -0.277194, -0.323152, -0.292583, -0.539075, -0.645738, 0.010211, -0.366457, -0.110210, 0.052456, -0.133115, 0.323316, 0.148503, 0.440557, 0.307002, 0.012340, 0.364044, 0.112850, -0.278487, -0.236073, -0.315292, -0.330967, 0.170498, -0.306236, -0.482478, -0.309385, 0.116230, 1.371763, -1.000499, -1.597863, -1.375951, -0.581350, -2.314221, -2.495538, -0.747016, -0.007966, 0.041441, -2.396704, 2.910369, -0.308910, -0.139112, 0.426418, 2.189420, -1.535173, -0.231623, 0.840342, -1.200754, -0.101915, 0.282880, 0.239973, -0.028858, -0.571482, -0.551114, 1.463890, -0.743471, -0.665737, -0.089305, -0.519071, -0.238234, -0.435989, 0.451539, -0.031497, -0.226802, 0.090503, -0.052924, -0.457423, -0.287475, 0.596369, -0.215304, -0.168665, 0.364389, -0.218147, 0.008672, -0.072139, 0.064730, 0.173886, 0.160002, -0.548796, -0.630004, -0.127072, 0.509195, -0.181098, -0.092422, 0.166816, 0.392619, -0.105836, 0.224557, 0.148051, 0.429298, -0.025283, -0.022924, -0.303719, -0.280269, -0.108514, -0.056755, -0.012947, -0.100295, -0.101888, 0.188958, 0.197450, 0.021149, -0.006255, -0.100733, 0.214292, 0.597451, 0.183042, -0.112074, -0.134466, 0.028430, -0.009838, 0.098642, -0.216055, -0.087475, 0.336901, -0.579433, -0.063843, 0.044294, -0.603911, -0.352130, -0.475032, 0.283620, 0.024342, 0.015246, 0.568994, 0.051767, -0.402327, -0.100275, 0.121188, -0.185526, 0.205508, 0.245704, -0.114841, 0.194002, -0.166271, 0.077432, 0.100575, 0.095833, -0.339910, -0.600247, -0.159808, 0.404634, 0.217616, 0.116498, 0.008494, 0.557754, -0.323087, 0.522079, 1.148965, 2.812526, 1.257364, -3.865347, -2.934170, 0.103230, -2.054003, -1.971873, 1.343051, 3.684945, 1.064689, 1.485008, -4.220256, 0.924085, 0.297620, -0.999080, -0.881511, -0.552120, 2.023201, 0.449968, -0.289152, -2.766892, 0.000874, -1.089408, -0.095240, -1.422946, 0.007806, 1.585789, 0.937244, 0.696101, 0.507836, 0.498505, 2.003617, 7.492721, 3.188390, 1.329952, 4.658943, 0.164180, 0.302385, 3.248561, 2.033861, -0.231879, 5.583540, 3.644775, -0.025417, 0.354574, 2.919725, 0.287058, 1.160992, 2.020045, 1.956080, 1.660367, 0.963301, 0.571926, 4.333515, 0.260798, -0.821563, -0.194915, 1.307677, -0.817141, -1.910350, -0.697438, -1.455631, 1.383970, 1.879618, 1.311509, 3.250464, -0.790063, 0.407701, 0.626530, -0.044459, -0.387057, -1.361029, -2.859453, -0.537759, 1.604346, 1.568500, -0.538780, 0.000376, 1.182728, -1.482466, -0.831423, -0.772810, -0.493446, 1.808316, 1.772912, 0.029330, 0.098912, 0.982135, -1.153321, 0.606906, 0.177748, 2.103686, 4.849807, 2.856344, -0.023903, 1.406907, 0.241285, 0.417322, 1.990863, 0.867781, -0.299451, 5.305320, -0.819835, 0.535711, -0.064472, 2.133370, 0.148955, 2.001604, 1.408279, 1.746355, 0.926526, -0.312995, 2.037870, 1.168483, 0.843541, -0.560526, 0.123709, 1.624049, -0.727380, 0.196532, 1.161643, 1.114784, 0.283388, -0.498362, 0.005132, -0.006830, -0.181209, 0.649062, 0.082481, -0.502819, 0.942398, -0.143921, -0.093941, -1.118226, -1.051350, 0.032578, 0.212330, 0.395796, 0.536159, -0.507574, -1.109548, 0.203261, -0.028580, 0.480107, 0.801706, -0.368734, 0.076876, 0.572278, -0.391931, -0.032641, 0.062598, 0.139580, 0.348112, 0.108048, 0.440664, 0.386574, -0.222535, 0.041000, 0.174783, 0.086809, -0.111972, 0.025615, -0.429322, 0.174681, 0.465674, 0.043475, -0.139546, 0.058106, 0.012094, 0.272492, 0.249818, 0.147419, 0.169197, -0.111476, -0.065614, 0.523891, 0.580563, 0.593188, 0.448322, 0.172090, 0.088661, -0.042316, -0.159847, 0.134849, -0.225018, -0.077352, -0.034316, -0.219724, -0.294823, -0.118658, -0.146128, 0.226905, 0.090287, -0.006386, 0.184535, 0.007128, -0.022691, -0.130530, -0.162111, -0.211097, 0.252073, 0.135623, 0.045079, 0.197727, -0.104514, -0.064545, 0.218688, 0.240771, -0.058198, -0.218075, -0.317453, -0.009010, -0.029331, 0.170846, -0.086223, 0.166373, -0.170980, -0.309371, 0.033630, -0.111169, -0.143853, 0.164597, -0.334263, -0.078042, 0.185556, -0.098630, -0.282149, -0.180173, -0.067938, 0.227088, -0.159492, 0.088093, 0.293980, -0.285075, -0.070954, 0.050302, 0.565276, 0.243471, 0.361256, 0.207520, 0.294139, 0.484489, 0.818203, -0.885459, -1.479511, -0.757974, 0.311791, -0.110318, -0.215429, 0.090321, 0.478286, 0.205240, 0.318038, 0.509300, 0.494881, -0.188688, -0.362053, 0.320232, 0.915308, 1.521520, 0.782826, 1.671971, 1.090148, 1.059676, 1.095509, 1.493957, 0.662693, 0.522390, 0.311294, 0.043730, 0.757142, -0.141666, -0.496565, 0.121558, -0.469423, -0.018838, -0.219000, 0.961959, -0.038791, -0.559969, 0.634578, 0.011689, 0.395581, 0.155008, -0.287886, 0.403050, -0.197196, -0.284630, -0.095890, 0.281062, -0.421531, -0.143738, -0.143072, -0.070407, -0.081138, 0.030180, 0.075232, 0.414197, 0.146629, 0.374143, -1.467227, -0.271389, 0.201355, 0.113165, -0.135705, -0.194542, 0.231462, 0.832702, 0.031568, -0.312307, 0.616490, 0.255339, -0.245782, 0.272620, 0.166617, 0.426847, 0.148361, 0.148739, -0.156376, 0.282734, -0.140293, 0.347392, 0.049474, 0.114087, 0.370263, 0.149861, -0.473871, -0.199766, -0.095634, 0.323275, 1.420176, 0.216195, -0.364735, -0.197238, -0.410301, 0.499785, -0.040103, 1.509733, -0.075096, -0.495231, 0.436533, 0.080759, 0.240360, 0.530550, -0.171494, 0.658882, 0.018299, -0.321961, 0.138120, 0.470274, -0.170099, -0.334025, 0.072326, -0.436082, -0.459717, 0.220459, 0.301529, 0.364106, 0.228459, -0.669829, 0.936477, -0.462306, -0.980724, -0.228624, -0.203135, 0.016101, 0.734023, 0.791539, 1.190883, 0.211239, 0.207041, 0.866137, -0.569263, -1.325909, -0.820399, -1.107615, -0.656540, -0.027550, -0.515723, -0.834699, -0.442151, -1.011072, 0.208046, -0.266758, 0.310257, -0.130443, 0.714985, -0.200657, 0.293776, -0.400730, -0.511666, -0.266662, -0.155500, -0.146277, -0.419438, 0.158050, 0.293480, -0.203424, -0.049115, -0.321750, 0.374374, 0.021390, 0.075125, 0.020393, 0.077506, 0.015486, -0.449645, 0.371858, 0.200907, 0.203872, 0.072815, -0.465983, -0.083725, -0.397811, 0.113630, -0.083828, -0.112723, -0.337601, 0.025476, 0.075342, -0.091574, 0.142509, 0.250127, -0.156312, 0.084810, -0.037020, -0.226267, -0.349597, 0.314764, 0.482348, -0.192053, 0.106084, -0.004955, -0.157300, -0.068882, -0.127632, -0.081615, -0.006720, -0.443872, 0.342125, 0.311422, -0.028850, -0.319018, 0.050992, -0.206585, -0.197777, 0.092702, 0.192382, -0.009660, -0.503569, -0.561384, 0.045420, -0.114870, 0.011489, -0.432901, 0.202106, 0.211941, -0.351695, 0.068760, -0.249263, 0.187837, -0.052316, 0.147364, -0.068722, 0.019887, -0.006297, -0.536248, 0.001360, 0.398244, 0.257080, 0.158391, -0.146821, 0.179543, -0.390887, 0.056033, -0.068598, 0.153316, -0.238340, -0.120664, -0.446123, -0.272884, -0.431754, -0.121498, 0.179648, 0.180473, 0.128286, -0.020184, -0.416540, 0.766022, 0.631817, -0.000569, -0.194594, -1.104260, -1.052431, -1.470866, -0.476074, -0.033548, -0.186759, 0.358389, -0.140767, -0.506145, -0.571446, 0.266349, 0.208365, 1.080391, 0.834928, 0.692232, 1.027926, -0.133378, 0.127804, -0.029662, -0.195360, 0.005196, 0.603987, 0.680910, 0.188336, 0.024348, 0.541570, 0.303987, 0.644898, 0.017574, 0.019733, -0.311529, 0.405330, 0.240008, -0.196207, 0.217025, -0.163050, 0.677485, 0.365763, 0.623217, -0.224301, 0.022398, 0.116692, -0.031306, -0.040693, 0.208523, 0.361633, 0.009851, 0.059428, 0.427774, -0.021066, -0.294013, -0.358405, 0.040761, -0.136235, 0.059314, 0.427832, -0.211369, -0.435310, -0.537987, 0.164742, 0.056620, 0.302880, 0.286378, 0.096214, -0.034966, -0.132495, -0.364749, 0.016597, -0.052490, -0.216376, 0.304958, -0.157981, 0.023290, 0.367967, -0.131734, 0.108951, -0.100374, 0.560029, 0.540313, -0.193844, 0.207160, 0.161714, 0.531052, -0.159480, -0.189509, 0.566405, 0.099117, 0.862712, 0.161897, 0.176577, -0.093692, 0.607333, 0.188684, 0.043743, -0.141485, -0.241764, 0.869532, 0.678254, 0.792502, -0.128081, 0.231577, 0.350039, 0.105496, -0.042009, 0.664275, -0.112554, 0.197324, -0.373028, -0.131383, 0.657084, -0.213068, 0.420188, 0.726562, 0.600761, -0.096274, -0.895059, -0.968064, -0.441325, -0.399709, 0.367721, -0.293928, 0.158349, -0.152360, -0.188075, -0.017628, 0.573186, 0.400682, 0.209832, -0.214978, 0.381648, -0.248055, -0.359201, -0.537622, -0.558060, -0.052276, -0.660693, -0.123792, -0.188619, -0.384944, 0.390112, 0.195763, 0.036330, 0.132999, 0.351098, 0.513336, 0.223897, 0.341315, -0.205157, 0.544672, -0.381954, 0.205325, 0.454789, -0.345957, 0.005083, 0.640414, -0.134761, 0.709876, 0.717061, -0.393705, 0.222952, -0.478925, -0.268191, -0.063519, -0.691183, 0.546777, -0.253014, 0.317583, 0.234442, 0.235871, -0.122800, -0.057684, -0.017862, -0.082162, -0.684775, -0.830597, -0.825150, -0.349293, 0.042863, 0.520931, 0.566766, -0.125614, -0.175180, 0.203457, -0.171742, 0.167635, 0.389364, -0.055059, -0.286487, -0.004131, 0.304270, 0.409269, 0.493025, 0.409447, 0.019790, -0.147396, -0.570943, 0.604311, -0.317717, -0.540128, 0.054531, 0.242197, 0.197525, 0.225875, 0.146543, 0.561673, 0.101082, 0.001227, -0.431740, 0.403053, -0.330426, -0.134553, 0.319164, -0.135759, -0.103579, 0.180110, -0.555646, 0.469686, 0.245528, -0.586768, -0.062672, -0.199821, -0.610591, -0.141934, -0.848435, 0.563094, -0.539110, 0.307205, -0.056241, -0.176350, 0.462942, 0.264685, 0.325291, 0.423160, 0.441463, 0.144750, 0.914910, -0.248636, 0.578298, 0.254249, 0.218491, 0.201019, 0.338934, 0.166706, 0.158642, 0.353642, 0.942607, 0.791130, 0.546603, -0.144708, -0.502238, -1.250158, -0.330701, -1.002840, -1.181070, -0.766204, -0.700929, -0.125583, -0.113332, -0.026058, -0.011520, 0.288804, 0.035002, 0.243787, -0.134269, 0.394806, 0.318827, 0.724376, 0.087349, -0.235904, -0.261163, -0.137966, 1.169894, 0.227589, -0.371134, 0.298415, 0.032965, 0.652802, 0.057778, 0.393562, 0.113860, 0.463051, -0.083014, 0.773176, 0.396845, -0.461314, 0.186172, -0.258485, -0.072458, 0.194844, -0.024094, 0.188624, 0.255913, 0.201669, 0.176610, -0.012679, -0.214960, -0.041352, 0.107023, 0.188915, -0.273132, -0.414190, 0.080296, 0.108249, -0.048610, -0.242794, 0.105815, 0.253173, -0.163340, 0.021012, -0.109766, 0.120323, -0.366959, -0.243670, -0.032657, -0.078281, 0.271134, 0.049672, -0.124429, -0.168969, -0.088654, 0.226392, -0.101161, 0.015388, -0.232820, 0.219270, 0.089009, 0.829166, 0.054072, -0.385491, -0.162203, -0.050127, 1.092586, 0.201135, -0.213375, 0.152121, -0.177959, 0.316934, -0.100419, 0.312898, 0.104218, 0.501618, -0.023976, 0.550549, -0.255446, -0.474327, 0.037128, -0.064531, 0.347695, 0.739369, 1.401904, 0.824888, 0.269545, -0.156790, -0.069061, 0.512058, 0.087608, 0.132818, -0.627898, 1.515606, -0.115454, -0.093422, -1.161287, -0.987909, -0.583277, -0.358378, -0.095729, -0.148497, -0.436476, -0.703952, -0.388351, -0.681695, 0.414944, 0.307658, -0.888166, -0.238931, -0.218537, -0.314014, -0.141818, 0.450700, 0.648463, 0.466913, 0.132801, 0.239502, 0.091310, -0.178461, -0.139300, -0.229595, 0.643615, 0.181984, 0.114829, -0.087590, 0.347510, 0.040610, 0.687963, 0.828132, 0.850435, 0.835423, 1.097106, 0.731530, 0.267828, 0.298499, -0.233499, 0.142301, 0.002856, -0.259306, 0.012754, -0.328720, -0.026121, -0.093039, 0.119880, -0.129880, -0.105455, 0.049168, 0.040403, -0.137992, -0.047210, 0.184979, 0.207587, 0.099744, -0.163409, -0.156308, -0.146863, 0.009575, 0.076685, 0.053891, -0.060346, -0.065378, -0.181961, -0.239109, 0.016479, 0.054742, -0.004720, 0.189994, 0.081008, 0.082747, -0.081186, -0.066292, -0.322538, -0.192909, 0.246464, 0.071953, 0.108952, -0.023926, -0.188687, -0.147561, -0.233817, -0.241477, 0.145855, -0.157980, 0.104817, 0.028483, -0.145373, -0.188904, 0.015705, 0.391861, 0.236105, 0.495143, 0.542872, 0.324033, 0.135662, 0.296345, -0.071910, 0.224433, 0.026007, -0.033580, 0.034422, -0.379348, 0.365934, -0.175847, 0.529150, 0.636324, -0.047323, 0.052755, 0.705041, 1.381181, 1.727074, -0.527405, -0.076343, -0.317601, -1.261307, 0.053809, 0.343778, -0.295528, -0.317302, -0.537542, 0.775418, 0.167223, 0.277968, -0.039674, -0.247700, -1.237338, 0.183502, 0.285989, -0.598885, 0.589894, -0.377236, -0.391095, -0.104694, 0.218978, 0.370277, 0.057890, 0.466244, -0.150499, 0.507995, 0.424603, 0.279728, 0.318597, -0.165657, 1.095839, 0.645948, 0.140600, 1.139536, 0.304652, 0.669859, 0.358229, 0.226020, 0.900913, 0.571907, 0.591243, 1.900013, 0.371599, -0.852557, 0.453566, 0.042785, -0.893985, -0.216885, 0.785639, 0.283711, 0.175692, -0.420901, -0.567131, -0.142792, 0.199716, -0.324750, -0.412377, -0.352001, 0.092843, -0.554627, -0.679799, 0.189622, 0.736306, 0.208028, -0.600811, -0.297032, -0.353302, 0.258352, -0.509379, 0.068238, 0.923178, -0.589143, -0.558368, -0.085776, 0.761818, 0.544842, -0.312661, -0.413517, -0.201700, -0.135895, -0.139494, -0.138551, 0.164375, -0.185413, -0.317646, 0.231959, -0.029441, 0.389898, 0.007192, -0.277708, 0.408114, 0.445429, -0.436202, 0.180044, 0.364210, 0.569794, 0.153057, 0.056499, 0.412974, 0.364216, 0.618709, 1.153561, -0.214542, -0.498999, 0.738378, 0.015329, -1.046768, -0.495951, 0.682267, 7.281669, -3.392017, -2.733121, -2.697889, -2.992128, -1.276804, -1.069181, -1.832943, -2.663769, -0.490180, -0.975045, -1.614883, -0.342019, -0.167612, 0.040170, -0.074399, -0.129967, -0.291443, -0.679148, 0.336568, -0.010025, 0.149264, -0.281677, -0.043702, 0.089201, 0.484390, 0.048313, 0.070874, -0.442411, -1.022597, 3.600354, 2.730706, 2.751296, 2.176524, 1.733082, 1.544852, 0.593774, 0.630592, 0.648006, -0.168014, -0.363532, -0.669235, -0.881284, -1.165491, -0.601663, -0.720107, -1.058019, -0.677097, -0.792560, -1.166520, -0.597660, -1.380935, -1.423343, -1.364709, -1.291440, -0.939376, -0.853792, -1.259613, -1.115969, -0.977595, 0.004755, -0.261397, 1.067745, 0.861892, -0.780062, -0.443845, -0.496658, -0.135890, 0.524169, -0.022127, 0.194190, 0.092426, -0.065362, -0.455700, -0.294374, -0.399659, -0.351209, -0.340579, 0.219944, -0.357598, -0.028861, 0.146024, -0.035786, 0.105511, 0.159598, -0.319948, -0.209813, -0.153058, -0.027396, 0.013344, 1.792089, 1.132324, 1.835084, 1.364048, 1.099427, 0.983670, 0.226969, 0.571783, 0.626292, -0.000800, -0.218645, -0.367004, -0.315917, -0.428366, -0.375377, -0.504597, -0.460110, -0.199192, -0.275189, -0.638613, -0.238063, -0.365794, -0.694764, -0.865848, -1.098659, -0.431796, -0.828511, -0.535729, -0.594164, -0.453727, -0.045338, -0.882728, -0.148361, 1.071787, 0.778788, 0.531149, 0.147877, -0.144833, -0.500339, -0.702117, -0.532913, -0.501157, -1.890984, 0.516251, -0.013452, -1.201436, 0.154139, -0.334197, -0.407739, -0.570151, 0.420738, 1.150328, 0.720006, 1.174652, 1.381784, 0.908197, 1.093232, 0.299520, 1.520757, 0.964135, -0.193438, -0.354256, -0.428537, -0.175729, -0.548522, -0.357340, -0.249255, 1.110995, 0.420318, -0.383724, -0.150041, 0.154061, 0.727589, -0.260176, 0.026571, 0.260721, 0.232480, -0.645178, -0.024481, -0.062842, -0.169421, -0.122596, -0.245743, 1.044352, 0.322010, 0.197608, 0.180673, -0.399736, 0.562110, -0.011000, 0.114444, -0.196241, -0.171151, -0.237347, -0.295603, 0.325572, 0.138083, -0.035739, 0.243700, 0.330098, 0.282157, -0.072589, -0.192719, -0.259890, -0.151725, -0.164911, 0.017868, -0.042938, -0.021569, 0.166320, 0.101875, 0.188306, -0.113899, -0.046115, 0.362947, -0.138859, 0.048220, 0.358343, -0.393931, -0.261159, -0.411605, -0.405911, -0.097071, 0.139462, -0.156616, -0.143083, 0.002528, 0.819683, 0.096473, -0.347310, -0.054877, 0.246090, 0.245272, -0.147129, 0.287187, 0.122367, -0.065443, -0.316968, 0.034640, -0.158761, -0.000069, 0.013906, -0.048856, 0.662246, 0.669342, 0.137559, -0.035674, -0.387221, 0.110151, -0.343332, 1.189652, -1.048613, -1.968511, -2.027671, -1.659696, -2.750348, -2.911283, -1.855874, -0.605985, -0.606351, -2.156564, 1.750804, -0.637881, -0.948009, 0.114226, 1.769047, -1.728656, 0.126870, -0.086469, -1.912647, 0.045967, -0.000717, -0.184014, -0.176496, -0.366824, -0.288374, 1.041405, -1.210981, -1.314871, -0.632300, -0.447507, -0.266187, -0.061493, 0.641470, 0.192022, 0.286360, 0.141398, 0.323297, -0.291892, -1.247790, 0.445943, 0.197096, -0.753132, 1.157062, 0.411056, -0.627435, 1.211760, -0.155343, 0.609059, 0.470652, 0.713813, -0.448994, -0.220733, -0.075628, 0.053471, -0.148781, -0.047763, 0.759320, 0.243396, -0.435004, 0.018811, -0.366888, -0.276882, 0.115403, 0.018475, -1.477288, -0.478140, -0.370381, -0.074896, 0.192502, 0.509865, -0.306543, -0.415366, -0.169354, 0.989639, 0.470903, -0.910902, -0.416066, 0.855545, 0.774886, 0.803448, -0.269754, 0.237696, -0.838409, -0.020072, -0.142425, 0.823053, 0.232916, -0.777963, 0.278738, -0.543105, -0.283282, 0.002553, 0.146057, -0.260131, 0.727794, 0.209458, -0.863188, -0.333826, -0.524469, -0.195814, 0.494867, -0.265574, 1.118748, 0.709778, -0.392898, 1.465045, -0.236379, 0.532271, 0.256763, 1.113055, 0.017901, 0.434227, 0.164001, 0.351703, -0.304492, -0.272230, 0.886808, 0.623146, -0.357931, -0.953760, 0.713501, -0.559043, -0.386312, -0.635805, 0.375881, 0.444418, 0.091351, -0.171995, 0.981404, 0.592163, -0.290090, 0.859660, 0.998673, 0.107412, 0.887561, 1.192138, 1.096821, 0.138890, -0.080957, -0.066108, 0.282027, 0.357670, -0.072920, -0.154514, -0.640627, -0.344406, -0.520552, 0.030590, -0.142865, -0.289272, -0.584993, -0.354483, -0.315632, -0.267377, -0.676336, -0.546153, 0.128283, -0.231035, -0.155018, -0.170605, 0.463029, -0.182865, 0.139922, -0.473809, -0.253194, -0.658793, -0.076231, -0.647285, -0.134937, 0.138854, 0.108618, -0.044664, 0.356535, -0.172285, -0.034301, -0.017698, -0.342208, -0.139977, -0.626661, 0.038063, 0.095528, -0.184810, -0.301609, -0.024835, 0.141492, 0.326233, 0.317735, -0.031721, -0.480382, -0.137185, 0.335715, 0.002506, -0.001634, -0.104021, 0.109220, 0.264730, -0.374299, 0.080272, 0.121762, 0.125510, -0.378409, -0.012261, 0.207405, -0.693513, 0.117228, 0.311808, 0.128633, 0.044066, 0.189035, -0.334570, -0.530473, -0.353640, -0.342735, -0.230261, -0.613649, -0.383789, 0.319983, -0.155595, -0.006145, 0.074331, 0.551439, -0.077724, -0.072329, -0.382219, -0.361590, -0.597158, -0.203876, -0.551117, -0.118121, -0.047173, 0.027128, 0.115242, 0.124693, -0.147648, -0.158910, -0.293752, -0.426287, 0.224859, -0.255969, 0.118237, -1.065169, 0.851004, 0.453550, 0.421903, 0.836819, 1.144212, -0.650807, -0.442738, -0.883259, 0.255960, 0.328286, 0.559199, 0.130134, 0.962300, 0.372659, -0.155238, 0.267208, 0.030111, -0.279953, 0.053686, -0.333853, 0.175591, -0.865161, 0.131313, -0.430673, -0.020760, 0.834015, 0.212665, 0.580223, -0.225134, -0.265557, -0.076248, 0.014492, -0.093533, -0.296379, 0.478794, 0.678988, 0.009499, -0.425289, 0.349465, 0.089386, -0.340645, -0.056359, -0.504423, -0.111530, -0.128863, 0.077392, -0.324642, -0.029654, 0.258520, -0.016662, 0.192981, -0.220905, 0.074261, -0.092754, 0.087107, 0.278681, -0.669763, -0.181904, -0.004504, 0.029769, -0.076468, -0.127420, -0.196689, 0.020882, 0.142497, 0.022146, -0.154866, -0.203939, 0.084503, 0.154016, 0.202899, 0.139524, -0.047833, 0.213559, 0.224573, -0.038603, -0.054418, -0.137871, -0.366786, -0.261804, -0.235524, -0.062103, 0.008802, 0.119817, 0.086031, -0.145869, -0.022868, 0.344648, -0.448932, -0.642387, -0.308322, 0.026613, -0.072658, -0.364506, 0.307478, 0.036667, -0.198486, -0.560251, -0.017436, -0.154131, -0.223261, -0.229167, -0.324750, -0.059758, -0.236888, 0.069185, -0.292786, -0.257465, 0.043302, -0.077678, -0.144840, -0.091453, 0.027038, -0.076490, 0.009164, -0.022478, -0.476643, -0.122321, -0.715931, 1.163111, 0.370821, -0.213299, 0.289873, 0.601468, 0.530846, 0.487701, 0.255794, 0.623446, 0.048301, -0.414306, 0.355649, 0.020664, -0.230425, 0.073698, 0.153860, -0.517005, -0.637640, -0.385482, -0.708041, -0.527293, -0.095749, -0.461916, -0.712524, -0.855132, -0.716125, -0.357971, -0.537980, -0.165795, -0.182818, -0.663194, -0.057986, -0.168374, -0.208419, -0.085274, -0.747073, -0.331780, -0.525779, 0.122017, -0.561079, -0.388885, 0.211627, -0.521469, -0.109027, 0.210549, 0.000374, -0.306202, 0.042052, 0.578627, 0.548801, 0.525149, 0.218456, -0.416225, 0.440466, 0.165347, -0.469793, -0.136337, -0.347694, 0.639468, 0.458250, 0.198443, 0.098384, -0.428489, -0.174286, 0.220008, 0.111851, -0.224259, -0.203844, -0.120386, 0.346203, -0.212680, -0.224445, -0.000801, -0.071266, -0.174141, -0.347686, -0.136582, 0.166124, 0.654207, 0.339895, -0.370788, 0.042404, -0.197556, -0.094904, -0.498868, 0.027857, -0.061868, -0.184585, -0.032891, -0.168713, -0.592523, 0.023380, 0.028934, 0.010757, -0.305210, -0.500620, -0.450878, -0.532382, 0.028952, -0.486105, -0.608580, 0.150798, -0.651175, -0.234153, 0.511506, -0.008727, -0.333830, -0.115191, 0.635290, 0.420986, 0.406185, 0.309092, -0.504422, 0.020946, -0.157044, -0.317020, 0.061457, -0.201733, 0.439686, -0.032869, -0.895983, -0.138922, 1.156865, 0.948457, 0.567894, 0.148585, -0.322361, -0.686504, -0.613954, -0.544062, -0.551561, -1.909124, 0.622603, -0.201248, -1.324130, 0.035625, -0.441863, -0.407822, -0.338751, 0.405433, 1.265342, 0.593551, 1.090089, 1.446512, 0.879971, 0.884828, 0.574972, 1.570415, 0.926835, -0.174461, -0.346626, -0.388126, -0.315334, 0.109573, -0.251485, -0.129856, 0.274951, -0.066322, -0.321283, -0.351965, -0.242069, 0.697322, 0.224083, 0.205935, 0.339489, -0.258606, 0.073493, -0.666000, -0.683528, -0.352425, -0.724967, -0.102395, 0.193484, -0.005802, -0.067565, 0.132621, 0.229864, 0.416846, -0.124378, 0.027713, -0.072628, -0.009437, -0.321537, 0.141534, 0.036193, 0.232725, 0.421899, 0.113226, -0.332747, -0.294390, -0.265880, 0.010323, -0.192416, -0.049241, 0.009189, 0.307102, 0.300073, -0.411412, 0.103646, 0.279589, -0.036313, -0.431828, -0.137900, -0.240427, -0.121505, 0.281386, -0.192646, -0.041079, 0.417083, -0.428428, -0.460187, -0.283609, -0.150806, 0.321084, -0.295436, -0.033096, -0.016875, -0.233887, -0.325964, -0.387957, -0.427926, 0.188255, 0.291907, 0.334519, 0.136950, -0.207762, 0.081627, -0.288459, -0.539758, -0.064110, -0.627576, 0.185439, -0.015147, 0.298893, 0.120213, -0.028952, 0.484824, 0.446358, -0.630781, 0.953285, 1.238842, 0.600726, -0.532071, -0.648218, -1.353943, -1.190180, 0.990631, 1.642958, 1.111106, -0.494495, 1.544843, -1.764438, 0.479578, -1.357408, 0.753335, -0.564207, 0.090355, -0.371475, -0.770446, -0.688950, -0.787775, -0.293355, -0.670998, 0.443724, -0.185910, -0.748479, -0.189334, -0.103571, -1.013364, 0.056277, 0.116735, 1.308304, 1.459107, 0.664669, 1.736948, 1.489287, 1.019999, 1.907746, 0.949795, 0.933656, 0.637021, 0.832304, 0.803921, 0.372097, 0.617595, 1.625379, 1.194919, 1.645298, 1.569110, 1.372621, 1.227187, 0.718481, 0.673992, 0.788181, 0.015127, 0.170316, 0.568098, -0.008607, 0.226921, -0.137301, -0.420777, 0.064636, 0.634587, 0.718276, -0.235272, 0.218806, -0.567434, -0.620876, -0.441220, 0.367677, -0.074820, 0.587675, 0.202580, -0.379665, 0.011130, 0.168486, 0.202574, 0.119776, 0.159630, -0.129079, 0.101521, -0.228550, 0.359086, 0.298645, 0.280569, -0.161332, -0.329308, -0.092881, 0.219308, 0.007006, -0.026276, 0.876326, 1.175648, 1.044863, 1.334962, 0.983622, 1.297428, 1.342559, 0.885589, 0.600109, 0.481717, 0.784915, 0.483054, 0.149481, 0.392466, 0.922672, 0.842579, 1.248136, 1.002666, 0.931475, 0.788090, 0.517416, 0.115061, 0.829883, 0.152023, 0.332657, 0.036098, 0.513436, 0.215574, -0.015095, -1.158499, -0.366373, 0.925209, 0.632487, 0.416525, -0.040374, -0.157153, -0.543355, -0.805794, -0.360066, 0.231479, -1.611152, 0.335340, 0.615903, -0.789998, 0.382763, -0.080016, 0.251895, -0.215996, 0.465790, 1.014094, 0.293956, 0.979946, 0.907006, 0.663392, 1.314023, -0.249548, 1.404327, 1.189612, -0.059110, -0.286028, -0.322960, -0.225802, -0.187189, -0.124201, -0.284229, 0.541245, -0.228667, -0.131471, 0.012589, -0.649380, 0.687538, -0.071657, -0.076321, -0.104327, 0.302279, -0.505888, -0.233588, 0.015477, -0.658785, 0.467308, 0.014895, -0.226427, 0.425008, 0.324351, 0.414632, 0.832868, 0.546871, 0.445010, 0.044514, 0.137739, -0.183796, -0.022231, 0.047852, -0.010121, -0.028928, -0.170105, 0.195492, 0.336607, 0.102379, -0.130839, 0.146141, 0.263733, 0.081610, -0.091834, -0.213663, -0.310652, -0.257623, -0.384876, 0.090913, 0.238533, 0.221153, -0.232830, 0.146236, 0.234819, -0.342138, -0.584617, 0.041512, -0.064303, -0.328296, -0.451733, -0.154976, -0.205627, 0.100222, -0.358077, -0.113273, 0.293217, -0.389161, -0.296307, 0.000852, -0.416332, 0.124218, -0.096091, 0.098574, -0.526065, 0.269146, -0.090147, 0.108870, 0.236360, -0.347330, 0.243690, -0.183276, -0.318265, 0.014860, 0.339443, 0.463345, 0.326577, 0.399843, 0.476597, 0.885328, 0.138606, -0.115439, -0.698705, -0.544502, 0.100878, -0.446354, 0.028302, 0.497237, 0.092149, 0.134595, -1.535465, 1.641437, -2.484911, 0.780765, 0.939562, -2.100054, -1.181193, -1.550524, -1.089369, -0.738626, -2.592245, -2.106952, -1.476495, -2.571557, -1.828613, -1.156349, -0.979376, -1.361858, -1.647266, -0.511751, -0.800165, -0.101598, -0.202712, -0.803206, -0.225110, -0.252040, -0.367619, -0.055732, 0.445616, -0.381403, -0.036555, -0.258132, 0.376922, -0.285997, -0.230946, -0.065753, 0.410903, -0.460734, -0.189196, -0.209550, 0.277124, -0.264295, -0.078335, 0.108301, -0.431362, -0.428029, -0.098108, -0.518343, -0.665272, -0.095716, 0.112575, 0.257469, 0.016127, 0.117523, -0.037665, -0.106131, 0.406815, -0.039964, 0.165160, 0.449853, -0.295713, 0.202292, -0.192869, -0.344372, -0.183443, -0.181932, -0.350664, 0.275907, 0.220311, 0.028661, 0.278643, 0.163743, 0.190043, 0.096749, 0.088935, -0.238238, -0.320059, 0.369498, 0.281244, -0.484944, -0.707303, 0.020160, -0.191440, -0.644060, -0.053038, -0.250926, -0.427623, -0.257898, 0.596658, -0.304414, -0.062024, -0.559372, 0.149060, -0.033043, -0.198899, 0.023660, 0.424505, -0.429317, -0.146830, 0.144365, 0.224983, -0.092533, -0.169367, 0.228288, -0.298487, -0.278053, -0.171709, -0.346719, -0.192162, -0.061715, -0.354019, 0.051684, 0.025011, 0.140987, 0.557725, 0.403106, -0.111998, -0.641772, -0.880592, -0.218048, -0.346074, 0.295232, -0.045060, 0.453352, 0.495830, 0.342247, 0.299915, 0.041603, 0.229461, 0.178834, 0.102783, 0.582820, 0.295788, 0.253399, -0.089940, -0.174230, 0.590500, -0.223406, 0.034500, -0.182531, -0.409551, -0.243444, -0.209258, -0.093345, -0.126998, -0.214994, 0.367637, 0.141564, 1.037752, 0.196164, 0.079687, -0.170950, 0.032262, 0.396036, -0.082788, 0.012040, -0.929258, 0.903156, 0.936050, 0.265088, -0.378802, 0.341219, 0.428574, -0.128782, 0.095413, -0.284255, 0.294511, 0.262939, -0.244220, -0.121059, 0.086810, 0.476331, 0.237140, -0.028804, 0.201533, -0.050687, -0.588037, -0.026440, 0.492031, 0.047700, -0.402673, -0.063017, -0.590769, -0.872924, 0.290690, 0.316139, -0.273478, -0.174619, -0.531551, -0.560070, -0.270995, -0.375715, 0.322140, -0.102390, -0.203055, -0.197876, 0.377010, 0.027991, -0.111902, -0.346021, -0.617482, -0.301652, -0.075932, -0.146487, -0.205424, -0.121183, 0.629827, 0.319761, 0.959599, -0.183191, -0.115587, -0.207936, -0.041602, 0.123522, -0.195237, 0.368748, -0.923213, 0.414876, 0.856132, 0.098430, -0.205518, 0.562463, 0.691401, -0.223534, 0.022501, -0.557790, 0.259250, 0.193180, -0.307700, 0.210173, 0.298833, 0.958796, 0.726720, 0.588519, -0.050057, 0.165452, 0.152345, 0.150610, 0.126321, -0.378734, 0.826401, -0.312557, 0.197890, -0.398428, -0.513615, -0.051961, 0.337572, 0.065493, 0.067074, -0.494311, -0.403538, -0.440101, -0.703386, -0.040865, 0.192556, -0.509882, -0.777189, 0.234729, -0.097364, -0.157080, 0.056538, 0.042281, -0.274982, -0.172733, -0.436190, -0.091443, 0.331485, -0.601272, 0.389824, 0.330840, -0.019649, 0.686502, -0.460629, -0.086005, -0.098340, 0.221167, 0.359373, 0.370772, 0.232813, 1.171929, -0.294536, -0.144168, -0.637318, 0.490623, -0.374146, 0.755263, 0.067421, -0.224318, -0.311737, -0.140721, 0.184214, -0.368521, -0.355785, -0.158743, 0.048395, 0.660576, 0.902483, 0.109551, -0.888396, -0.667004, 0.079086, 0.727084, 0.079350, 0.339101, -0.291131, -0.254255, -0.258499, 0.420149, 0.321020, -0.888557, -0.271580, 0.002045, 0.334100, 0.283415, -0.166715, 0.099093, -0.418547, -0.059686, -0.315124, -0.306025, -0.295523, -0.202555, -0.109407, -0.320373, -0.496519, -0.105770, 0.479367, -0.241595, 0.483435, -0.010112, 0.104900, 0.541480, -0.047386, 0.007592, -0.447372, -0.220583, -0.119113, 0.342742, -0.006478, 0.545995, -0.359847, -0.066624, -0.474177, 0.386201, -0.431995, 0.133676, 0.125377, -0.441175, -0.401317, 0.067667, 0.477982, 0.468386, 0.978498, -0.928263, -1.373036, -0.719741, 0.029079, -0.486124, 0.126557, -0.096774, 0.501534, -0.311423, 0.882561, 1.064314, -0.492832, 0.859851, -0.465795, 0.005292, 1.569993, 0.805692, 1.095470, 1.535773, 0.993095, 0.588664, 0.948178, 1.538433, 0.483541, 0.879155, 0.360759, 0.173162, 1.428391, -0.137850, 0.055954, 0.023909, -0.052748, -0.013226, -0.226734, -0.104842, -0.311493, 0.021376, 0.174750, -0.106364, 0.268944, -0.062464, 0.659648, 0.174359, 0.165687, 0.381583, 0.423453, -0.037736, 0.014761, 0.304907, -0.042214, 0.148284, -0.101798, 0.204778, 0.403216, 0.035323, 0.029809, -0.604095, 1.461118, 0.130335, -0.128294, -0.253133, -0.576106, -0.350780, -0.348103, -0.289961, -0.091360, 0.479173, 0.082124, 0.258790, -0.032620, -0.438695, 0.570428, -0.292108, -0.109044, -0.008282, -0.681791, -0.140949, -0.365666, -0.128735, -0.225494, 0.037049, 0.057525, 0.719515, 0.147275, 0.253090, 0.344969, 0.634781, 2.166719, -0.151746, -0.007455, 0.171921, 0.199313, -0.001368, -0.003555, -0.137724, -0.175460, 0.153008, 0.009516, 0.112051, 0.122687, 0.150307, 0.678297, 0.443072, 0.033039, 0.274711, 0.651573, -0.062947, 0.008037, 0.331833, 0.007815, 0.156705, 0.251705, 0.057846, 0.116968, 0.216235, 0.051946, 6.360806, -2.643249, -3.484038, -3.648847, -3.844898, -1.791510, -1.819062, -2.039903, -3.561141, -1.865176, -1.431377, -2.716119, 0.227299, -1.131154, -0.967330, -0.403377, 0.435808, -0.865480, -1.559401, -0.147408, -0.509171, 0.276203, -0.047950, -0.451529, 0.021271, 0.324099, -1.039542, -1.575059, -1.274139, 0.211048, 9.201939, 8.971243, 5.938540, 4.184870, 2.850700, 0.953128, 1.242767, 0.399533, -0.026374, -0.458131, 1.105966, -0.184204, 0.549786, -0.265084, 0.900286, -0.969003, -0.742081, -0.711892, -0.442498, 0.389249, -0.588056, -0.718016, 0.318750, 1.902562, 0.818379, -0.441273, -0.760744, 0.293379, -0.749012, -0.747716, 10.336970, -5.968322, -4.882002, -4.649416, -3.784878, -0.750070, -1.084989, 0.074261, -0.522891, -1.109642, -2.688906, -0.781607, -0.806145, -2.102846, -0.452320, -1.003776, -1.278115, 0.312470, 1.868810, -0.800492, -1.273812, -1.166006, -1.650091, 2.788420, -0.746612, -0.921650, 0.291309, -0.244017, -2.032004, 0.295178, 12.293907, 5.396407, 5.073979, 4.045623, 0.839366, -1.159340, 0.828371, 2.844625, 1.680177, -0.656709, 1.163891, -0.294708, -0.511766, 0.464281, 1.730699, -0.460265, -1.780309, -1.721886, 1.095794, 0.193451, -0.851876, -1.403569, 0.294314, -0.051454, 2.543868, 1.055156, -0.101302, 0.528397, 1.564978, 0.479148, 0.803945, -0.720937, -1.946720, -1.014913, -1.592681, -3.428973, -3.021506, -1.099138, -0.252605, -1.003475, -1.049216, 1.163809, -0.461135, -0.812288, 0.194940, 0.549123, -1.055193, 0.126016, 0.079437, -1.022675, 0.567904, -0.475397, 0.407022, -0.699044, -0.683180, 0.156868, 1.033430, -0.598777, -1.462172, -0.274275, -0.490305, -0.216994, -0.350781, 0.142694, -0.013118, -0.714814, -0.661972, -0.281639, 0.281594, 0.152498, 0.390662, 0.455710, -0.243367, 0.644806, 0.623303, -0.062639, -0.393152, 1.446538, 0.282889, 0.496514, -0.950217, 0.389041, -0.281344, 0.450672, 0.526800, -0.597670, -1.216692, -0.484900, -0.519609, -1.124104, -0.185334, -0.763003, -0.133916, 0.641718, -0.220346, 0.898183, 0.530081, -0.368384, -0.090565, -0.632075, -1.956881, 0.131697, -0.050635, -0.209379, 0.909460, 0.021944, 0.936077, 0.094413, 0.030622, 1.125289, 1.330132, 0.594657, 0.138109, -0.492964, -0.906918, -1.249205, -0.090038, 0.031644, -0.418153, 0.381682, -0.506366, -0.567738, -0.282303, 0.002409, -0.437021, -0.127033, -0.967593, -0.046162, 0.161104, 0.245600, 0.928709, 0.874615, -0.426843, -0.178376, 0.455259, -0.146774, -0.951915, 2.014663, 0.098855, -0.308095, -0.174818, -0.787503, -0.112667, 1.287267, -0.037277, -0.700844, -1.178387, -0.517217, -0.324452, -0.617989, 0.857772, 0.181786, -0.062974, -0.791436, -0.517366, 0.216781, -0.244660, 0.039577, 0.446963, 0.052398, 0.135848, -1.584421, 1.504710, -2.610971, 0.893037, 0.906349, -2.012233, -1.384732, -1.830413, -1.306274, -0.861342, -2.403831, -2.267324, -1.551218, -2.244426, -1.540527, -1.189073, -0.875988, -1.240282, -1.643551, -0.526347, -0.751314, -0.433871, -0.446493, 0.062187, -0.292569, -0.076090, 0.515364, 0.358703, 0.586391, 0.065903, -0.005285, -0.352413, -0.586114, -0.191276, 0.003274, -0.239601, -0.077939, -0.222208, 0.027130, -0.378366, 0.147841, 0.089799, 0.152614, -0.198724, -0.620249, -0.305905, 0.144379, -0.191316, -0.027367, 0.354304, 0.589872, -0.280887, -0.484662, 0.151237, 0.109849, -0.630252, -0.770465, -0.274384, 0.390818, 0.482251, 0.229015, -0.357154, -0.296906, -0.067470, -0.166491, 0.033199, 0.096759, -0.263446, 0.600186, -0.115063, -0.278818, -0.264861, -0.899708, -0.063207, 0.131588, -0.290114, 0.198537, 0.133186, 0.291904, -0.539232, -0.618811, -0.337073, -0.131649, 0.126124, -0.769638, -0.124787, 1.337054, 0.271533, 0.547743, -0.235613, -0.321717, -0.044786, -0.009719, 0.043900, -0.123050, -0.405188, -0.154828, -0.173558, -0.129695, -0.431556, 0.013660, 0.493676, 0.499083, 0.060406, -0.098778, 0.280486, 0.098580, -0.193429, 0.045558, 0.258041, -1.062090, 0.848267, 0.509584, 0.435497, 0.575197, 0.935696, -0.397145, -0.068342, -1.051431, 0.246956, 0.276053, 0.373859, 0.448980, 0.747593, 0.496963, -0.159394, 0.447359, 0.275467, -0.212938, 0.196379, -0.344851, 0.138902, -1.093679, 0.111339, -0.346248, -0.439471, 0.532653, -0.013487, 0.544861, -0.116851, 0.211945, -0.140222, 0.057611, -0.351259, -0.066011, -0.514383, -0.001311, -0.399529, -0.092617, 0.176561, 0.101277, -0.226100, -0.223034, 0.306661, -0.889819, -0.120017, 0.212703, 0.546938, 0.061447, -0.438733, -0.204017, 0.208078, -0.487569, 0.189015, 0.113322, -0.237996, 0.008909, 0.097382, -0.078679, -0.116431, -0.033988, -0.368128, 0.133581, 0.197037, 0.059173, 0.059548, 0.216555, 0.419528, 0.134867, -0.791391, -0.019183, 0.506822, -0.104597, 0.063581, 0.484725, 0.277619, -0.110064, -0.512331, -0.449366, -0.171852, 0.532257, 0.109980, -0.618966, -0.366387, 0.171624, -0.030166, 0.038009, 0.084214, 0.635565, -0.399972, -0.431524, -0.587398, -0.174881, -0.645155, 0.283881, -0.750987, -0.404736, -0.668795, -0.104980, -0.212752, 0.399294, -0.259477, -0.263458, 0.230373, -0.853172, -0.144062, -0.273102, 0.290795, -0.131046, -0.163522, -0.328163, -0.044396, -0.182183, 0.006562, -0.321455, -0.229595, -0.320249, 0.136474, -0.277344, 4.003340, -1.979067, -1.796253, -1.137455, -2.162368, -0.510095, -0.269297, -1.006664, -1.642875, 0.164155, 0.224949, -1.140414, 0.337664, 0.192262, 0.327013, 0.641830, 0.184509, -0.230545, 0.818064, 1.068261, 0.426627, 0.900647, 0.292020, 0.384187, 0.548128, 0.825907, 0.013953, 0.544353, 0.157923, -0.711975, 6.554918, 3.912337, 3.962889, 3.317812, 2.392127, 1.564412, 1.175003, 0.641257, 0.910495, -0.151158, -0.301706, 0.121172, 0.011063, 0.422103, -0.577639, -0.586426, -0.587229, -0.720217, -0.895534, -0.710228, -0.859752, -1.183238, -0.842200, -0.868692, -1.014150, -1.423087, -0.797004, -1.247311, -0.914044, -0.937285, -0.069820, -0.267915, 0.191833, -0.119126, 0.074981, 0.127787, -0.119856, -0.093484, -0.494428, -0.428783, -0.025107, -0.029508, 0.309619, -0.197591, 0.220234, -0.371079, -0.203685, -0.304466, -0.271817, 0.065538, 0.164998, 0.206038, 0.043125, -0.121520, -0.203991, -0.211391, -0.018915, -0.300203, 0.287257, 0.204062, 4.840403, 2.034795, 2.950551, 2.446292, 1.973616, 0.885815, 0.899632, 0.917918, 0.540433, -0.229584, -0.345806, 0.337152, 0.357073, 0.365147, -0.347050, -0.036656, -0.056129, -0.206920, -0.539747, -0.537935, -0.146806, -0.119595, -0.204738, -0.429471, -0.255943, -0.926742, -0.170321, -0.893816, -0.789160, -0.320909, -0.357457, 0.127886, 0.206622, 0.585942, 0.647128, 0.686449, 0.639691, 0.066882, 0.778323, 0.100827, 0.230934, 0.309332, -0.475389, 0.508450, 0.547148, 0.246293, 0.897217, 0.515857, 0.595833, -0.145425, -0.211673, -0.104973, -0.521635, -0.624556, -0.037776, -0.325991, -0.232378, -0.265204, 0.247087, 0.599858, 0.102928, 0.293627, -0.198165, -0.190119, -0.254454, -0.075307, 0.251370, -0.460762, 0.386009, -0.126923, -0.541572, -0.566096, 0.034652, -0.432362, -0.344129, 0.026446, -0.052270, -0.339310, -0.312605, -0.300159, -0.087840, -0.307644, 0.089100, 0.438829, 0.509582, 0.173104, -0.176563, 0.181165, 0.125283, 0.408025, 0.433533, -1.112549, -0.273452, 0.353011, 0.249576, 0.493711, 0.446672, 0.264430, 0.666792, 0.091868, 0.216341, 0.147977, -0.325019, 0.020638, 0.073560, -0.574720, 0.011384, -0.219425, -0.015640, -0.323918, -0.270068, 0.021110, 0.045449, 0.059628, 0.768162, 0.181034, 0.352397, -0.186791, -0.096204, -0.045614, 0.471098, 0.851476, -0.122116, -0.204463, -0.233172, 0.380662, 0.259427, -0.346385, 0.642548, -0.184451, -0.561759, -0.396989, -0.033359, -0.314944, -0.269122, 0.411724, 0.231851, 0.082856, 0.127238, -0.136958, 0.020287, -0.390958, -0.132763, 0.301968, 0.220727, 0.016676, -0.151644, -0.099034, 0.137404, 0.521359, -0.887752, 0.701763, -0.755832, -0.758724, -0.984367, 0.132617, 0.410003, -0.078377, 0.152127, 1.381827, 0.907477, -0.170804, 0.946953, 1.275870, 0.219920, 0.880714, 0.871435, 1.441945, -0.019026, 0.023172, 0.133538, 0.458207, 0.511475, 0.039027, -0.001458, -0.379249, -0.252114, -0.699064, 0.051630, -0.105955, -0.277089, -0.764741, -0.258197, -0.341700, -0.578494, -0.498135, -0.421942, -0.607751, -0.393095, -0.361596, -0.290386, -0.125856, 0.329229, -0.095888, -0.353410, -0.225688, 0.382278, 0.151626, 0.125372, -0.291600, -0.335569, -0.746173, 0.118525, 0.525677, 0.534097, -0.014933, 0.249129, -0.019120, 0.130959, -0.451789, -0.199958, 0.008218, 0.396977, 0.289523, -0.387957, 0.054006, -0.106424, -0.093185, -0.036905, -0.122351, 0.151958, 0.336742, 0.156772, 0.454650, 0.071114, 0.038701, 0.459628, 0.136553, 0.345680, -0.006033, -0.349059, 0.045210, 0.217442, -0.021141, -0.456380, -0.506031, -0.851350, -0.058525, 0.605066, 0.182355, -0.327741, -0.640312, -0.282127, -0.334526, -0.413592, -0.309391, -0.140352, -0.267222, -0.308292, -0.277805, -0.313960, -0.038100, 0.180210, 0.074530, -0.350182, -0.300312, 0.460467, 0.018064, 0.076059, -0.100238, -0.391743, -0.513315, 0.260784, 0.447142, 0.969627, 0.049390, -0.104550, -0.177218, 0.381090, -0.318891, 0.133918, 0.543122, 0.355314, 0.693260, -1.106221, -1.592006, -0.733219, 0.501836, -0.167188, -0.192302, -0.010879, 0.344809, 0.005343, 0.669559, 0.829314, -0.020024, 0.170909, -0.556531, -0.091986, 0.738237, 1.157178, 1.094975, 1.762945, 0.985169, 0.862091, 0.998800, 1.265564, 0.453907, 0.755221, 0.158098, 0.154400, 1.808466, 0.032638, 0.024716, 0.531270, 0.207567, 0.209790, 0.195535, 0.211011, 0.431768, 0.353733, 0.495291, -0.095353, 0.570412, 0.138096, 0.207002, 0.493634, 0.024182, -0.104670, -0.107205, 0.443699, 0.346553, 0.421688, 0.155418, 0.588083, 0.561525, 0.235661, 0.421847, 0.292211, 0.050372, 0.734272, -1.673708, -0.155612, -0.328601, -0.224833, 0.284815, 0.421262, 0.111315, 0.645476, -0.198548, -0.336542, 0.249862, -0.077223, 0.204276, 0.378879, -0.022862, 0.818863, 0.464170, 0.205562, 0.121176, -0.042740, 0.230268, -0.356925, 0.073563, 0.527150, -0.152741, -0.151906, -0.405233, -0.426742, 0.318915, 0.482362, 2.535262, 0.576354, -0.038843, 0.150561, 0.346768, 0.114731, -0.004594, 0.331870, 0.461053, 0.299638, 0.588424, -0.288176, 0.770503, 0.186184, 0.021360, 0.794858, 0.276620, 0.108762, -0.024302, 0.547892, 0.336162, 0.647742, 0.212429, 0.502047, 0.861840, 0.384390, 0.329303, 0.369852, 0.073747, 1.267648, 0.765925, -0.873266, -0.276897, -0.561984, -0.092130, -0.655304, -1.183764, -0.911037, -0.447978, -0.520900, -0.998894, 0.278715, -0.231090, 0.316150, 0.310362, -0.063365, -0.465111, -0.310151, 0.032836, -0.174634, -0.192917, -0.412610, -0.678227, -0.007668, 0.000269, -0.252387, -0.444602, -0.556661, -0.575952, 4.082523, 0.566626, 1.737537, 1.469255, 2.286563, 0.610657, -0.323123, 0.731889, -0.017325, 0.017922, 0.567065, 0.609634, 0.416319, 0.354650, 0.330927, 0.251755, 0.487224, 0.093630, -0.313152, -0.345406, 0.382380, 0.660951, 0.577560, -0.110127, -0.678244, 0.116181, 0.333462, -0.298011, 0.048109, -0.080849, -4.795727, 0.131401, 0.965076, 1.144167, 1.336941, 0.781628, 0.672433, 0.822482, 0.686289, 0.528915, 0.599172, 0.638793, 0.608068, 0.195242, -0.509842, 0.295010, 0.345876, 0.702434, 0.581020, -0.070906, -0.586198, -0.111533, 0.050113, 0.474082, 0.105820, -0.076968, 0.432371, 0.052649, -0.207218, -0.406820, 3.895100, 0.397653, 0.966586, 1.425196, 1.489545, 0.614048, -0.131161, 0.781736, -0.346117, -0.512927, 0.686033, 0.699168, 0.693620, 0.110359, -0.015977, 0.160341, 0.340007, 0.275000, 0.559670, -0.269403, 0.001470, 0.496314, 0.584219, -0.133939, -0.298555, 0.249405, 0.231179, -0.646868, 0.154216, -0.393349, 0.903317, 0.108314, 0.049294, -0.629925, -0.778508, 0.192163, -0.599275, -0.079721, 1.013258, -0.170661, 0.608396, -1.702133, 1.600083, -2.100062, 0.437788, 1.215445, -2.116858, -1.273852, -1.564568, -1.344138, -0.344790, -2.608129, -2.260900, -1.317964, -3.041948, -1.494547, -1.605886, -0.686327, -1.392886, -2.190769, -0.540183, -0.794028, -0.081064, -0.482957, -0.573700, 0.392801, -0.305333, -0.282084, -0.406127, -0.342992, 0.375119, -0.026023, -0.454360, -0.061286, -0.421982, -0.129797, -0.076011, -0.224778, -0.775918, 0.039455, -0.119090, -0.413485, -0.628219, -0.254184, -0.091001, -0.061203, -0.272593, -0.397469, 0.062530, -0.051237, -0.065654, -0.245367, -0.337631, 0.025073, -0.190114, 0.260719, 0.227084, 0.285351, 0.214170, -0.114543, -0.102439, -0.015685, 0.114917, 0.055268, -0.199444, 0.449361, -0.456560, -0.278146, -0.014949, -0.080407, 0.140375, -0.186889, 0.190673, 0.597204, 0.098837, -0.121669, -0.491991, 0.298577, 0.051790, -0.100693, -0.593944, -0.607206, -0.102784, -0.468392, -0.207335, 0.483679, -0.075145, -0.213957, -0.262671, -0.309989, 0.625647, 0.275594, -0.244378, 0.182254, -0.224075, -0.135818, -0.029486, -0.248948, -0.718920, 0.018878, -0.285389, -0.152977, -0.149773, -0.329383, -0.277552, 0.042142, 0.110499, -0.071978, 0.229171, -0.191158, 0.252030, 1.199378, 1.122154, 0.314607, -0.858492, 0.013384, -0.143863, -0.395541, 0.726944, 0.093139, -0.247336, 1.229970, -0.201544, 0.061787, -1.180083, -1.240388, -0.221828, 0.246145, 0.072984, 0.523154, -0.277004, -1.089454, 0.029646, -0.064326, 0.559175, 0.752214, -0.400863, 0.108248, 0.317905, -0.291179, -0.058570, -0.007103, -0.170488, -0.296550, -0.287341, 1.187643, -0.111925, -0.654384, -0.068578, -0.403864, 0.071673, 0.181467, -0.084989, -0.753460, -0.061464, -0.016519, 0.120554, 0.290149, -0.063137, 0.435890, 0.646909, 0.023775, -0.061707, -0.061208, 0.214230, 0.243841, -0.245581, -0.183018, 1.220474, 0.620064, -0.033269, -0.027884, -0.052164, 0.022617, -0.027047, 0.545056, 0.196038, -0.148458, -0.267457, -0.289871, 0.047602, 0.040336, -0.062806, -0.143305, 0.226787, 0.129430, -0.113865, -0.307722, 0.096272, 0.229567, 0.199384, 0.074798, -0.271657, -0.178552, -0.243725, 0.164760, 0.011762, -0.041751, -0.062169, 0.077180, -0.252148, -0.326813, -0.310307, -0.322075, -0.374540, 0.600460, -0.379819, -0.475191, -0.129307, -0.198936, -0.043543, -0.110933, -0.138547, -0.406306, -0.236823, -0.542633, -0.012862, 0.106983, -0.187735, 0.253599, 0.234106, -0.060546, -0.321729, -0.385546, -0.032382, -0.121644, -0.394817, -0.221588, 0.639153, 0.656310, -0.167086, -0.581133, -0.661293, 0.043257, -0.192731, 0.001402, 0.273837, -0.276032, -0.726607, 0.554278, 0.235035, 0.015303, 0.232853, -0.702829, -0.973115, -0.470385, -0.066837, -0.211637, -0.044673, 0.293999, -0.490293, -0.503500, 0.111915, 0.399189, 0.396880, 1.035445, 0.653084, 0.956505, 0.575801, -0.280942, 0.475325, 0.986855, 0.819607, 0.149973, 1.493966, 1.378585, 0.367164, 0.266470, -0.191363, 0.136229, -0.000583, 0.344934, 0.033605, 1.070292, -0.161150, 0.154688, 0.511681, 0.543221, 0.052353, 0.100070, -0.474798, -0.146752, 0.148348, 0.271404, 0.540017, 0.660048, -0.045207, -0.155376, 0.578991, 0.319978, 0.573973, 0.640234, 0.088829, -0.028988, -1.203843, -1.040091, -0.229626, -0.778566, -0.323223, 0.363098, -0.269815, -0.589498, 0.108687, 0.392519, -0.160137, 0.272621, -0.030105, -0.130339, 0.339876, 0.632129, 0.382443, -0.166344, -0.606529, -0.587797, 0.539082, 0.807527, 0.005648, -0.426372, -0.697277, -0.330386, 0.714504, 0.859972, 1.456396, 0.563196, 1.178598, 0.867621, 0.007582, 0.049801, -0.283534, -0.106868, 0.494578, 0.321173, -0.044040, 0.932845, -0.232672, -0.046863, 0.350444, 0.727331, 0.195263, 0.641343, -0.229485, -0.033295, 0.063207, 0.003436, 0.459298, 0.524805, 0.007159, -0.319963, 0.540288, 0.085165, 0.207589, -1.082444, 0.948826, 0.465966, 0.308626, 0.661524, 0.923644, -0.690589, -0.450240, -0.998340, 0.091736, 0.021318, 0.473805, 0.219904, 0.949504, 0.439767, -0.100620, 0.478271, 0.040911, -0.086082, -0.001853, -0.273402, 0.051408, -0.727894, 0.012561, -0.324408, -0.225278, 0.399489, -0.180964, 0.183238, -0.242861, -0.128528, -0.076849, -0.246055, -0.115978, -0.094300, 0.031984, 0.049994, 0.149484, 0.103141, -0.149166, 0.093322, 0.199046, 0.051434, -0.110923, -0.508826, -0.151813, -0.072846, 0.062330, 0.311296, 0.267437, -0.228425, -0.080493, -0.306946, 0.369301, -0.335003, -0.417663, 0.040534, -0.003444, -0.237945, 0.023299, 0.031275, 0.392657, 0.217359, 0.156927, -0.193373, -0.586650, -0.474723, -0.079015, 0.495619, 0.221613, -0.281179, -0.511176, -0.381554, 0.294677, 0.026351, -0.164299, 0.054343, 0.333857, 0.359407, 0.384690, 0.251708, -0.014765, -0.256881, 0.124120, 0.163723, -0.057462, 0.136026, 0.068729, -0.308101, -0.471666, -0.607128, -0.226741, -0.379181, -0.322668, -0.385774, -0.231239, -0.345101, -0.138533, 0.031668, -0.176668, 0.083961, 0.422028, 0.187776, -0.021786, -0.529277, -0.395703, -0.073163, -0.238380, 0.094589, -0.027042, -0.129693, -0.302385, -0.373257, 0.124371, -0.319517, -0.293900, -0.015848, 0.151292, -0.109086, -0.998700, 0.701888, -0.758336, -0.493685, -0.681477, 0.320665, 0.508874, -0.397484, -0.086435, 1.452536, 0.881538, -0.239512, 0.870100, 0.976762, -0.127500, 1.018102, 1.227999, 1.061589, -0.162548, -0.065102, -0.221209, 0.455576, 0.379524, -0.001167, -0.166093, -0.384180, -0.108595, -0.573152, -0.045099, -0.295219, -0.313197, -0.668518, -0.411790, -0.292555, -0.544429, -0.252081, -0.359991, -0.300502, -0.202041, -0.063502, 0.121183, 0.042524, -0.006753, -0.394611, -0.441235, -0.167166, 0.033139, -0.086993, 0.180800, -0.325112, -0.134371, 0.273257, 0.180851, 0.300126, -0.203769, -0.250858, -0.066594, -0.257746, -0.599244, 0.001445, 0.054493, -0.230617, 0.017603, -0.423575, 0.076107, 0.006573, -0.056330, -0.012339, 0.240782, 0.575035, 0.146218, 0.012954, -0.211723, 0.203259, -0.038210, -0.141589, -0.491915, -0.551029, -0.156816, -0.023000, 0.284301, 0.395787, 0.281571, -0.091591, 0.065959, 0.168404, -0.242512, 0.217990, 0.233968, -0.123404, -0.394812, -0.641043, -0.287068, -0.300396, -0.335112, -0.078498, -0.341939, -0.384784, -0.059011, 0.231948, 0.098627, 0.200069, 0.015570, -0.402794, -0.385176, -0.140202, 0.223628, 0.252275, 0.179471, -0.326498, -0.249706, 0.206679, 0.254980, -0.101346, -0.273688, -0.173703, -0.219926, -0.357531, -0.564197, -0.049408, 1.417765, 2.199469, -0.123363, -2.369997, -2.502666, 0.536488, -0.971097, 1.307839, 2.347513, 2.389284, -1.823545, 3.864693, -2.665267, 1.120596, -0.979104, -1.312239, -0.826201, -1.306878, 1.176867, -0.306406, -0.153576, -1.369043, 0.016339, -2.039188, 0.978433, -1.186604, -1.486628, 0.452200, -0.515449, 1.954916, 0.566691, 1.579759, 4.356233, 3.060998, 2.722338, 0.503655, 0.955158, 1.847550, 6.413731, 5.033020, 2.723917, 1.457132, 2.521505, 2.444487, 0.035210, -0.854816, 2.742990, 2.492530, -0.223033, 0.541888, 0.569457, 3.096430, 2.770888, 4.140659, 1.424551, -1.064123, 2.995568, 1.578968, 0.439226, -0.721054, 0.602961, 0.508372, 0.006211, -2.521645, -3.057321, -1.334333, -1.144252, -1.005835, 1.735101, 3.498006, -0.925810, -1.005561, -3.138366, -0.271377, -0.955417, 0.218746, -0.487057, 0.648975, 0.251508, -0.836510, 0.953089, 1.936209, 0.720324, -1.699783, 2.260576, -0.264235, 1.680585, 1.754071, 0.314197, -1.810089, 0.358090, 0.774861, 1.570408, 1.445263, 2.361754, 0.598036, 1.833860, 3.034789, 1.868780, 1.957919, 0.771788, 2.200564, -0.591151, 1.373453, -1.073696, 0.270672, 3.136533, 1.388874, 0.037968, -0.514842, 0.507929, 2.485067, 2.068264, 3.163396, 3.034250, -0.045752, 3.027893, 1.746469, 0.849832, 1.242942, -0.266881, 0.358992, -0.286280, -0.555392, 0.008103, -0.081529, -0.362072, -0.045869, -0.026624, 0.582076, 0.304833, -0.367604, -0.090752, -0.539214, -1.097324, -0.415108, -0.397483, -0.075573, -0.753847, -0.242801, -0.021380, -0.384932, -0.326958, 0.635632, 0.476806, 0.528021, 0.121155, 0.537151, 0.022885, -0.147904, 0.054392, -0.048982, -0.094514, 1.330968, 0.758162, 0.923952, 0.255620, -0.531615, 0.393935, 0.124259, 0.124070, 0.309041, 0.055383, 0.321793, -0.562929, -0.137746, 0.125250, -0.114404, -0.444845, 0.069315, 0.113229, -0.109140, -0.329804, 0.252778, -1.130523, 0.686606, 0.722212, 0.764960, -0.256963, 0.584292, 0.132941, 0.026319, -0.192890, -0.515974, -0.394077, 0.366771, 0.404331, 0.571646, 0.620781, 0.717214, 0.718997, 0.010312, -0.156492, -0.262439, -0.412677, -0.717235, -0.096739, 0.245422, 0.442927, 0.317413, 0.207049, 0.233272, -0.120903, -0.150338, -0.402263, 0.914704, 0.420608, 0.311547, 0.547484, 0.018682, 0.116256, 0.300793, -0.150085, 1.976148, 1.123091, 1.206705, -0.018346, -0.523381, -0.308268, 0.146080, -0.328373, 0.310370, 0.939697, -0.225133, -0.189172, -0.465513, 0.314304, 0.243209, -0.652221, 0.494688, 0.075553, -0.068058, -0.735483, 0.389895, -0.907590, 0.495772, 0.883863, 0.550712, 0.279423, 0.662284, 0.723873, 0.213060, -1.501120, -1.511222, -0.361965, -1.452464, -2.173528, 0.202198, 0.194264, -0.899597, -1.256837, -0.588445, 1.308655, -1.984760, -0.359709, 1.337696, -0.631111, -1.290190, 0.162315, -0.551953, -1.531390, -0.859164, 0.197749, -0.851127, -2.425726, 0.263942, 0.001504, -0.141868, -1.735659, -0.329981, 0.231928, -0.323179, 0.177886, 0.438259, 0.016743, 0.440297, -0.023991, -0.289213, -0.678926, -0.274507, 0.030229, 0.261598, -0.684549, 0.140825, -0.525296, -0.776295, -0.888999, -0.123240, -0.174600, -0.505877, -0.236218, -0.576235, 0.407916, -0.353673, -0.124745, -0.191828, -0.506436, 0.268651, -0.130856, -0.289034, -0.221303, 0.290648, -0.308739, 0.302918, -0.041990, -0.077433, 0.339791, -0.421900, 0.263273, 0.001797, 0.083529, -0.019189, -0.210377, -0.003658, -0.399163, -0.089064, -0.137750, -0.227885, -0.076800, 0.893516, 0.460946, -0.134342, -0.303346, -0.353882, 0.314602, -0.112182, -0.530544, -0.437243, 0.208438, 0.103968, 0.537625, -0.223462, 0.296527, 0.635142, -0.114908, 0.460839, -0.263380, -0.229775, -0.210963, -0.644383, -0.509735, 0.196518, -0.792274, -0.005088, -0.072949, -0.704420, -0.201200, -0.129842, -0.415094, -0.300908, -0.480403, -0.273220, 0.499048, -0.799988, -0.491547, -0.032839, -0.314931, 0.610533, 0.380522, -0.217666, -0.485498, 0.545396, -0.081255, 0.012878, 0.291263, 0.966968, 0.622684, 1.178979, 1.284349, 0.433618, -0.068555, 0.254641, 0.459657, -0.040845, 0.213581, 0.485719, 0.672659, 0.513449, 0.368072, 0.048266, -0.263454, -0.280013, -0.907287, -1.013624, -1.037316, -1.265948, -1.298454, -1.232719, -1.379152, -0.747572, -0.127185, -0.072455, -0.413055, -0.517493, 0.022622, -0.229794, -0.062209, -0.409957, -0.141153, -0.113237, -0.045651, -0.321581, -0.184855, -0.002333, 0.181049, -0.555334, -0.038011, -0.308520, 0.107612, -0.048232, -0.387633, 0.046366, 0.053024, 0.082716, -0.201656, -0.121721, 0.090759, -0.484241, -0.314748, -0.104989, 0.067390, 0.397892, -0.199446, -0.206270, -0.020449, -0.050323, -0.042293, 0.234952, 0.064245, 0.013886, 0.014057, 0.005734, 0.189114, 0.053976, -0.049200, -0.016593, -0.082321, 0.025290, -0.135130, -0.148403, 0.101584, 0.066837, -0.195064, -0.258739, 0.069715, -0.149372, -0.147816, 0.210282, -0.133046, -0.103879, 0.237133, 0.244666, -0.100427, -0.386470, 0.160031, -0.135862, 0.089306, -0.118863, -0.153557, -0.065028, 0.025874, -0.168389, -0.022421, 0.019037, 0.351242, -0.497664, -0.068203, -0.110935, 0.114321, -0.042455, -0.338435, 0.191645, 0.129789, 0.028945, -0.028174, 0.052353, 0.130920, -0.251821, -0.004322, -0.107301, 0.033131, 0.455899, 0.512701, 0.853025, -0.888954, -1.470630, -0.780134, 0.104069, -0.561679, 0.214410, -0.033960, 0.250868, -0.180972, 0.655729, 0.828071, -0.145710, 0.753993, -0.347747, 0.071033, 1.703971, 0.580495, 1.180103, 1.686814, 1.204007, 0.730612, 1.007567, 1.448329, 0.561532, 1.011886, 0.739446, 0.098360, 1.536017, -0.331652, -0.199868, 0.115073, -0.315822, -0.288667, -0.397231, -0.059210, -0.001566, 0.089724, -0.129641, -0.126435, 0.318394, 0.054361, 0.658582, 0.342997, -0.033164, 0.265629, 1.027655, -0.303733, 0.132510, -0.357149, 0.624775, -0.035830, 0.028497, 0.294470, 0.502946, 0.421073, 0.470810, 0.658369, -1.341470, 0.130771, 0.298975, 0.421322, 0.150923, 0.491969, 0.154102, 0.397623, 0.668866, -0.037092, -0.300515, -0.669704, -0.214435, 0.297686, -0.866677, 0.366883, 0.348851, -0.142533, 1.067002, 0.040019, 0.288376, 0.222257, -0.192792, -0.095809, -0.121275, -0.351216, -0.030266, -0.513993, -0.591987, 0.509018, 2.323881, -0.330865, -0.167400, 0.193604, -0.151965, -0.182216, 0.188109, 0.073937, -0.186920, 0.240021, -0.015768, 0.081538, 0.618218, 0.004674, 0.645658, 1.019476, 0.234193, 0.438169, 1.527174, -0.195046, 0.310368, -0.265954, 0.359328, -0.339569, 0.315043, 0.272049, 0.452145, 0.372895, 0.614688, -0.844845, 1.249912, 0.603056, -0.291674, 0.699174, 0.944441, 0.411358, 1.025050, 0.192630, -0.041158, -0.332936, -0.444154, 0.219660, -0.252338, -0.208304, 0.063914, -0.412203, -0.936773, -0.445768, -1.191973, -0.806164, -1.098837, -0.230354, -0.368928, -0.971566, -0.765187, -1.017795, -0.323860, -0.518788, 0.092946, -0.329360, -0.877835, -0.521536, -0.408798, -0.493137, -0.398593, -0.163686, -0.092581, -0.306774, -0.231384, -0.479031, -0.261895, -0.253934, -0.148944, -0.089315, -0.175486, 0.091758, 0.083178, 0.106476, -0.075326, -0.151234, 0.085945, -0.047582, 0.282058, 0.102518, 0.161737, 0.175391, -0.054929, 0.161769, 0.116144, -0.152174, -0.023016, 0.008260, 0.045872, 0.060908, -0.068643, -0.040567, -0.202058, 0.052726, 0.079955, -0.118668, -0.089310, -0.164837, 0.118729, 0.177855, 0.067736, -0.235077, -0.024190, -0.067213, -0.013045, -0.002171, 0.073789, -0.163815, -0.042314, 0.084559, -0.013204, 0.000996, 0.118828, 0.124333, 0.037268, -0.374837, -0.777928, -0.392683, -0.312941, -0.436832, -0.261068, -0.212253, -0.089080, -0.161779, -0.202408, -0.340943, -0.268751, -0.135048, -0.164588, -0.119966, -0.354615, -0.299239, -0.228758, 0.007960, -0.099641, -0.205453, -0.225777, -0.266478, 0.119908, -0.057489, -0.064650, 0.005404, -0.137790, 0.070317, 0.034406, -0.453543, -0.165458, -0.664251, -0.467619, -0.086892, 0.120217, 0.115099, -0.068727, -0.821650, 0.621449, 0.630724, -0.039503, 0.126525, -1.313280, -1.232435, -0.999602, -0.084441, 0.152042, 0.118690, 0.750675, 0.253744, -0.325834, -0.176456, 0.269317, 0.144644, 1.164555, 1.097747, 0.850595, 0.847549, -0.134689, 0.120428, -0.056475, 0.027559, 0.148057, 1.012328, 0.630690, 0.494465, 0.184917, 0.230512, 0.275850, 0.515209, 0.205698, -0.590784, 0.486730, 0.471631, 0.363270, -0.525824, -0.144080, -0.167797, -0.121373, -0.247061, -0.219971, -0.046516, -0.331419, -0.768881, 0.174698, 0.057582, 0.635780, -0.091465, -0.234662, 0.217520, -0.193452, -0.227517, 0.043837, -0.139237, -0.016720, 0.075885, -0.117286, -0.100356, 0.174513, 0.271684, 0.253482, -0.245552, 0.409620, 0.179149, -0.399950, 0.142500, 0.273086, 0.217765, 0.072965, -0.205656, 0.062810, -0.045267, -0.206136, 0.008713, -0.193364, 0.057618, -0.001231, -0.343582, 0.197736, 0.576309, 0.213809, 0.044845, 0.293633, 0.803887, 0.429068, 0.317459, 0.016943, 0.204784, 0.107251, 0.672170, 0.549109, -0.342640, 0.147167, 0.292761, 0.424581, -0.413004, -0.128097, 0.143481, 0.023417, 0.143389, -0.012258, -0.016019, -0.345500, -0.516954, 0.216663, 0.191922, 0.804801, -0.075092, -0.155418, -0.127134, -0.102733, -0.300847, -0.500710, 0.630031, 0.087232, -0.468339, -0.138241, -0.630764, 0.566672, 0.271537, -0.625733, -0.261098, -0.462269, -1.027786, -0.823085, -0.812718, -0.650403, -1.357314, 0.116370, -0.758763, 0.061837, -0.869653, 0.235227, 0.264731, 0.114873, 0.224392, 0.301111, -0.559644, -0.274850, -0.035680, -0.093316, -0.157729, -0.014344, 0.226779, 0.261315, 0.149190, -0.177461, -0.036571, -0.015462, 0.261419, 0.041663, -0.115633, -0.170271, -0.005309, -0.131459, 0.411825, 0.268362, 0.127195, -0.031606, 0.062119, 0.240823, 0.480643, 0.337776, -0.198685, -0.031767, 0.128878, 0.374032, 0.093181, -0.015321, -0.091408, 0.274025, -0.150454, 0.032492, 0.142505, -0.219637, -0.331773, 0.018845, 0.107763, 0.214273, 0.056026, -0.148073, -0.170037, 0.063500, 0.038758, 0.129765, 0.063233, 0.304726, -0.110075, -0.179925, -0.090450, -0.020649, -0.195208, -0.220304, -0.150837, 0.093819, 0.103765, 0.072129, 0.062113, -0.288767, 0.364256, 0.445044, -0.063597, 0.277153, 0.097930, 0.230840, -0.204359, -0.279444, 0.098221, 0.081963, 0.574162, 0.114783, 0.064579, -0.122302, -0.023872, -0.167092, 0.814747, 0.725487, 0.533074, 0.164467, 0.245113, 0.444603, 0.532078, 0.689507, -0.049707, 0.298130, 0.340003, 0.287554, 0.059505, -0.119788, 0.166051, 0.961860, 1.090972, 0.390341, 0.028597, 0.116315, 0.013351, -0.367666, 0.112227, 0.056794, -0.349142, 1.001004, 0.244070, 0.028888, -1.203499, -1.102620, -0.319118, -0.123648, -0.059541, 0.322158, -0.280096, -0.771732, 0.155027, 0.213956, 0.417117, 0.670093, -0.725003, -0.502631, 0.469427, -0.048364, -0.127293, -0.017857, -0.134055, 0.380994, -0.323446, -0.432556, 0.510858, -0.860016, -0.189506, -0.213704, 0.129251, 0.182122, 0.352563, 0.140270, 0.417694, -0.173159, 0.650648, 0.050003, 0.591150, 0.062788, 0.296059, 0.330582, 0.204379, -0.744825, -0.467513, -0.565112, -0.167869, 0.225419, 0.175027, -0.004078, -0.217693, -0.412174, 0.039161, -0.094634, 0.024786, 0.361385, 0.364534, -0.005418, 0.138985, -0.258697, -0.352096, 0.873506, 0.213145, -0.071609, 0.000278, -0.440961, 0.330349, 0.034048, -0.116765, -0.371956, 0.219636, -0.095767, -0.419959, 0.024122, 0.058670, -0.254239, 0.009521, 0.282065, 0.065705, 0.065595, -0.333802, -0.352666, -0.709548, 0.037208, -0.526927, -0.400649, -0.026831, -0.708014, -0.477014, -0.218037, 0.345921, 0.158636, 0.111733, 0.545684, 0.141741, -0.132484, 0.034911, -0.054954, 0.487450, -0.018709, 0.038437, -0.063601, -0.263860, -0.631450, -0.602883, -0.556080, -0.106931, 0.104600, -0.026375, -0.177119, -0.048342, -0.931646, -0.164408, 0.999761, 0.877641, 0.600106, 0.163109, -0.181091, -0.471800, -0.599841, -0.528383, -0.457967, -1.918394, 0.545708, -0.129506, -1.189981, 0.157872, -0.421764, -0.520879, -0.562809, 0.456802, 1.225058, 0.661642, 1.294491, 1.448766, 0.865550, 1.066845, 0.335587, 1.480808, 1.046167, -0.114175, -0.341878, -0.275618, -0.096890, -0.121714, 0.250042, 0.345214, 0.252932, 0.225334, -0.109616, -0.512987, 0.268658, 0.888694, 0.241447, 0.158184, 0.202954, -0.240524, -0.110082, -0.472868, -0.248851, -0.451513, -0.253071, -0.132511, -0.235505, -0.210165, -0.086562, 0.009283, -0.288698, 0.144214, 0.569000, 0.134806, 0.178374, -0.211250, -0.101177, 0.150052, -0.153079, -0.536980, -0.047692, -0.146139, -0.036155, 0.135858, 0.098575, -0.124648, 0.117118, 0.149257, 0.247412, -0.089661, 0.008455, 0.099752, -0.288036, -0.127332, 0.054392, 0.404405, 0.033895, -0.052834, 0.155609, -0.027528, 0.062527, 0.068299, -0.000334, -0.424693, -0.332581, -0.120196, 0.171449, -0.029721, 0.451760, 0.397216, 0.087970, 0.088407, -0.261834, -0.457810, 0.279353, 0.509863, 0.084404, 0.138400, 0.184302, -0.311444, 0.100539, -0.013616, -0.052713, -0.363162, -0.201946, -0.247070, -0.128507, -0.283777, 0.025965, 0.004618, -0.355120, -0.061952, 0.529665, 0.903498, -0.711845, -1.629841, -1.158954, -1.375392, -2.537623, -2.445907, -1.820905, -0.080066, -0.407658, -1.615400, 1.441809, -0.513714, -0.571909, 0.318664, 1.022301, -1.001324, -0.029866, 1.098116, -1.513208, 0.726806, -0.414625, 0.122433, -0.603024, -0.433356, 0.074683, 1.162324, -0.764159, -1.041151, 0.247165, -0.433267, -0.210591, -0.335474, 0.324406, -0.379639, -0.495516, 0.255550, 0.269921, -0.081001, 0.345572, 0.141302, -0.115446, -0.429789, 0.626023, -0.629788, -0.490212, -0.220218, -0.045365, -0.252426, 0.146319, 0.010899, -0.191431, 0.400101, -0.000675, 0.045947, -0.762155, 0.590258, 0.144239, -0.108919, -0.044902, 0.003406, -0.099132, -0.033535, -0.148602, 0.048379, -0.120703, -0.213743, 0.460105, 0.212304, 0.267850, 0.487313, -0.247756, 0.092533, 0.064426, -0.262875, -0.571793, -0.265474, -0.417303, -0.245337, 0.425248, -0.067863, -0.042128, -0.274502, -0.135919, -0.393334, -0.087462, -0.337464, -0.116315, 0.144639, 0.163412, -0.519138, -0.303419, -0.029803, 0.027614, -0.142493, -0.551625, 0.217152, 0.297618, -0.257038, 0.154308, -0.064878, 0.035521, -0.132179, 0.481079, -0.576451, -0.437650, -0.494431, 0.294931, 0.089894, 0.043780, 0.287546, -0.243737, 0.916521, -0.175453, 0.311398, -0.463758, 0.772713, -0.076457, -0.249462, 0.051775, 0.253194, -1.134543, 0.983040, 0.207834, 0.092562, 0.688460, 0.960174, -0.883739, -0.882165, -1.247191, -0.190733, -0.297211, 0.402393, -0.329891, 0.982850, 0.139909, -0.067326, 0.782175, 0.219937, 0.249170, -0.063673, -0.133936, 0.122845, -1.041075, -0.458558, -0.961769, -0.845816, -0.258080, -0.919539, -0.596437, -0.173040, -0.271253, 0.561170, 0.262335, 0.057972, 0.269243, 0.633945, 0.170115, -0.212597, -0.018114, 0.003730, -0.146687, -0.466833, 0.004394, -0.446214, -0.251359, -0.179759, -0.126510, 0.353690, -0.280666, -0.134725, 0.376197, 0.412872, 0.035188, -0.210405, 0.094549, -0.219134, 0.335807, -0.168415, -0.283569, 0.165956, 0.099469, -0.002791, 0.058145, 0.106343, 0.051851, 0.251113, 0.181393, 0.084610, -0.105501, -0.248471, -0.164746, 0.363854, 0.651124, -0.009086, -0.257446, -0.207136, -0.226985, 0.003061, -0.170445, 0.093707, -0.142746, 0.126341, 0.115178, 0.098927, 0.224795, -0.138425, 0.032675, -0.153744, -0.135660, -0.475888, -0.506246, 0.070833, -0.002017, 0.177800, 0.156141, 0.169093, 0.051693, -0.159026, 0.198814, -0.016259, -0.011147, -0.195758, -0.032806, -0.364281, -0.170104, -0.064716, -0.314500, 0.217109, -0.503399, -0.117975, 0.290541, 0.357953, 0.108311, -0.433509, -0.206452, -0.178671, 0.010391, 0.028303, -0.361165, 0.638456, -0.481966, -1.803340, -1.100492, -1.744395, -2.840356, -2.766588, -2.374397, -0.031761, -0.531792, -0.677820, 0.339607, -0.346937, -0.563879, 0.364341, 0.269651, -0.499197, 0.182317, 0.543746, -0.995132, 1.307321, -0.637387, 0.459824, -0.618753, -0.662817, 0.469817, 0.950308, -0.694587, -1.376244, 0.463276, -0.432863, -0.071853, -0.111737, 0.454883, -0.468402, 0.209125, 0.261975, 0.157392, -0.261808, -0.103749, 0.621730, -0.211826, 0.042793, -0.088350, 0.478170, -0.341837, 0.362117, -0.218807, -0.198503, -0.215687, -0.312298, -0.187286, -0.258921, 0.124500, 0.260386, -0.116117, 0.111257, 0.460823, 0.499804, 0.279386, -0.020880, 0.012806, -0.417570, -0.096730, -0.008472, -0.199880, 0.041248, 0.329225, 0.185769, -0.433625, -0.463051, -0.093798, 0.045596, 0.167201, 0.247589, 0.597134, 0.165091, 0.227547, -0.003760, 0.164891, 0.018330, 0.071060, -0.179203, -0.131647, -0.470939, 0.266871, 0.158951, 0.149789, 0.425369, -0.020629, -0.525309, -0.528011, -0.079387, 0.457655, -0.311064, 0.178228, 0.441224, 0.051700, -0.385456, 0.004898, 0.146213, -0.163129, 0.242577, -0.083443, 0.291546, -0.008605, 0.100352, 0.240472, -0.213278, -0.179722, -0.101660, 0.044460, -0.292974, 0.267980, 0.013366, -0.045977, 0.138131, 0.269318, 0.164383, 0.304405, 0.053964, -3.224288, 4.323845, -3.130878, 0.790462, 1.050587, -0.522943, 1.780479, -0.300489, 0.319404, 0.672043, -0.602005, 1.811213, -0.499996, 0.655583, 0.146090, -0.566715, 0.575677, -1.500042, 0.163687, -1.406685, -0.811442, 0.521189, -0.561674, 0.283279, -0.571563, -0.754283, 0.527719, -0.797602, 1.074305, -0.127048, 1.822337, 3.657613, 3.872367, 2.775129, 1.719064, 0.914196, 0.625129, 1.029464, 0.463724, 0.364941, 0.955563, 0.413481, 0.569385, 0.737236, 0.601477, -0.306056, 0.041841, 0.921096, 0.491808, 0.541326, 0.193664, 0.645581, -0.025602, 0.566264, 0.319346, 0.035665, -0.104654, 0.526539, 0.347870, 0.248251, -0.025754, 0.348946, 0.192497, -0.169365, -0.015915, -0.116995, -0.043556, -0.110149, -0.229163, -0.411834, 0.079288, -0.077618, 0.067303, -0.256421, 0.205408, -0.064027, 0.169265, 0.062669, 0.276682, -0.106785, 0.202303, 0.718232, -0.004979, 0.576007, 0.105185, 0.316144, -0.270415, -0.018734, -0.493017, -0.143338, 0.308815, 1.579278, 1.347915, 0.845329, 0.793736, 0.516926, 0.842156, 0.675831, 0.516140, 0.535845, 0.886740, 0.070505, 0.076823, 0.010637, 0.183358, -0.538725, -0.455271, 0.460893, 0.489097, 0.230645, 0.134179, -0.056584, -0.215744, 0.232624, -0.030258, 0.125850, -0.283766, 0.133438, 0.321144, -0.493747, -0.171436, -0.455526, 0.286786, 0.834902, 0.855044, 0.632322, 0.515933, 0.696101, 0.470106, 0.891812, 0.421670, -0.486639, 0.782418, 0.799040, 0.086221, 1.127096, 0.989463, 0.106893, 0.097982, 0.055758, 0.838432, -0.551104, -0.183456, 0.230192, -0.727183, 0.218627, -0.844522, 0.585332, 0.770333, 0.094417, 0.128723, -0.120281, -0.293797, -0.306099, 0.464646, 0.000654, -0.114042, 0.034689, 0.135306, -0.160228, -0.463602, 0.257260, 0.094822, -0.316772, -0.341350, 0.043791, -0.069554, -0.318008, -0.328988, -0.062157, -0.193540, 0.150420, -0.068857, 0.145090, 0.613111, 0.047947, 0.154846, 0.543772, -0.003565, -0.165416, 0.573649, 0.119022, -0.309449, -0.201260, -0.245181, -0.352684, -0.393590, -0.608355, 0.168980, 0.522968, 0.012658, -0.143082, 0.011767, -0.008004, 0.046760, -0.142623, 0.242906, 0.311635, -0.005648, -0.078095, -0.031178, 0.252739, 0.251588, 0.048786, 0.205535, -0.034113, -0.296054, -0.348119, -0.016447, 0.528942, 0.425260, 0.054667, -0.127275, -0.251923, 0.879031, 0.415918, 0.322042, 0.331667, 0.241941, -0.096510, -0.216206, 0.389518, 0.263740, -0.374311, 0.074055, 0.232015, -0.131948, -0.053176, -0.164626, -0.166495, -0.377261, -0.038658, -0.113086, -0.138098, 0.541014, 0.001365, 0.046147, 0.375012, -0.053858, 0.631816, -0.577780, -1.554259, -1.193839, -1.638314, -2.668365, -2.606663, -1.982198, -0.309594, -0.523903, -0.791737, 0.609182, -0.273380, -0.722495, 0.490938, 0.204633, -0.602010, 0.064460, 0.775728, -1.440139, 1.367292, -0.654004, 0.154025, -0.794941, -0.524467, 0.067574, 0.645715, -0.722945, -1.349512, 0.569615, -0.490913, -0.116964, -0.620926, 0.564258, -0.053100, -0.297081, 0.239479, -0.200264, -0.145982, 0.234642, 0.747162, 0.141935, 0.345207, 0.414873, -0.354189, -0.038776, 0.537381, 0.468665, -0.818329, -0.225941, -0.192328, -0.237172, -0.559018, -0.159845, 0.196019, -0.558971, 0.143370, -0.312345, -0.314872, -0.101205, -0.002983, -0.081583, 0.298872, -0.038882, -0.230969, -0.334694, -0.506468, -0.372329, -0.049954, 0.038918, 0.042417, 0.443087, 0.222916, -0.210958, -0.555845, 0.015506, -0.340129, 0.179000, 0.408259, 0.305960, 0.145007, -0.436866, -0.164866, 0.776317, 0.399861, 0.304814, -0.027222, 0.173288, 0.110892, -0.376117, -0.584985, -0.387062, -0.456888, 0.011608, 0.194879, -0.455616, 0.150964, -0.404679, -0.167610, -0.119521, 0.316869, 0.105978, 0.989550, -0.202622, -0.456226, -0.149982, 0.375111, 0.948174, -0.402178, -0.273012, -0.043275, 0.377149, -0.157361, 0.092942, 0.074293, -0.124832, 0.079472, -0.349450, -0.808996, -0.335231, -0.293323, -0.545844, -0.286334, -0.192848, 0.173024, 0.079477, 0.131144, -0.130528, -0.719928, 0.823427, 0.502969, -0.212623, -0.153945, -1.047903, -1.193692, -1.075746, -0.720743, -0.344400, -0.504609, 0.084901, -0.166372, -0.168095, -0.475477, 0.554355, 0.265019, 0.752554, 0.435248, 0.438869, 0.441971, -0.128649, 0.317423, 1.321033, 0.120832, 0.222443, 0.324774, 1.195904, 0.233299, -0.292664, -0.247145, -0.382174, 0.046800, 0.381886, 0.089866, -0.463414, -0.283502, 0.696217, -0.432319, -0.352764, 0.115346, -0.117437, 0.076665, 0.525370, 0.043325, 0.377668, -0.244230, -0.125053, -0.283280, -0.095194, 0.310094, -0.258663, 0.363020, 0.191550, -0.515436, -0.402823, -0.077432, 0.274086, -0.025350, -0.162438, -0.121103, -0.167005, 0.517904, 0.864128, -0.241962, -0.588399, -0.309376, -0.093697, 0.294219, 0.251585, -0.229974, -0.108906, 0.040612, -0.223652, 0.220040, 0.080022, 0.032793, -0.034999, -0.145169, 0.376036, 0.302029, -0.240047, 0.626063, 1.016380, 0.140368, 0.339920, -0.072888, 1.057618, -0.135800, -0.251995, -0.080166, -0.174566, 0.351808, 0.367536, 0.192948, -0.190094, -0.245590, 0.300942, -0.169230, 0.136955, 0.330980, -0.145813, 0.553223, 0.893540, -0.011584, -0.005127, -0.019144, -0.198059, 0.169139, -0.038515, 0.281548, -0.088735, -0.249157, 0.173255, 0.478406, 0.564732, 0.560615, 0.504685, 0.580793, -0.415802, 1.145801, -0.346622, -0.247990, 0.397937, -0.539239, 0.597087, 0.548856, 0.269195, 0.829127, 0.488857, 0.540179, -0.276768, 0.155636, -0.372440, -0.485982, -0.737118, -0.113226, -0.222217, -0.368213, 0.332510, 0.196858, 0.750416, 0.023060, 0.375321, -0.210795, -0.146471, 0.021834, -0.459039, -0.228604, -0.002679, 0.146060, 0.241022, 0.119307, -0.123985, -0.188671, -0.137822, -0.371841, -0.108166, -0.147737, -0.371345, -0.207583, -0.230583, 0.440169, 0.521524, 0.243353, 0.169706, 0.479191, 0.240457, -0.185192, 0.297460, 0.105330, 0.729487, -0.312630, 0.793302, 0.185995, -0.353115, -0.161529, -0.129404, -0.157608, -0.163087, -0.619394, -0.027242, 0.010419, -0.030467, 0.496430, 0.314736, 0.121619, 0.008294, -0.175989, 0.336743, -0.010391, -0.130336, -0.096138, -0.163919, 0.112607, -0.153934, -0.226161, -0.101386, -0.215880, -0.118674, 0.134247, -0.092045, 0.373917, 0.850482, -0.325498, -0.177959, 0.070114, -0.426014, 0.211893, 0.035796, 0.575966, 0.291051, -0.020644, 0.198852, -0.092393, -0.053861, -0.205348, 0.080719, 0.003135, -0.275392, -0.069909, -0.341642, 0.068909, 0.161893, -0.077234, -0.117404, 0.138780, -0.063412, -0.246069, 0.091455, -0.315709, 0.578628, 0.187236, 0.306559, 0.476047, 0.876031, -1.003174, -1.444367, -0.695845, 0.003010, -0.270690, -0.464102, 0.251672, 0.374603, 0.096457, 0.396304, 0.438058, 0.503158, 0.151108, -0.348382, 0.500302, 1.226356, 1.191064, 0.876845, 1.525333, 1.049646, 0.850947, 1.027684, 1.314223, 0.581038, 0.765440, 0.230346, 0.042752, 0.769689, -0.062159, 0.094522, 0.066784, -0.369605, -0.187156, -0.324674, 0.636575, 0.234640, -0.233215, 0.068750, -0.081091, 0.059436, -0.247524, -0.184911, -0.080400, 0.538860, -0.236138, 0.103853, 0.080085, 0.054612, 0.069700, 0.052815, 0.194044, -0.037004, 0.102288, -0.094644, 0.316161, -0.286973, -0.219393, 0.353376, 0.163650, -0.075482, -0.065004, 0.202515, 0.053027, 0.037133, -0.195804, 0.034925, 0.156362, -0.037157, -0.291454, -0.386606, -0.359479, -0.100088, -0.621868, -0.554259, -0.095394, 0.346727, -0.071490, 0.048879, 0.586364, 0.125874, 0.109942, 0.357361, 0.184630, 0.202879, 0.078830, -0.148464, 0.301919, 1.272947, 0.122229, 0.061883, -0.091562, -0.357089, -0.027318, -0.282109, 0.891768, 0.234857, -0.112418, 0.123477, -0.164732, 0.151541, -0.037959, -0.453000, -0.083020, 0.739489, -0.311965, 0.200324, 0.065274, 0.197453, 0.054114, -0.266464, -0.088810, -0.593616, -0.079074, 0.386022, 0.158685, -0.259717, 0.755688, -0.512411, -1.974642, -1.277099, -1.644841, -2.999794, -2.988790, -1.303965, -0.171083, -1.490517, -0.230205, 0.598730, -0.371778, -0.712246, 0.255012, 0.810371, -0.826226, 0.334187, -0.034997, -0.674380, 0.726445, -0.660677, 0.496957, -0.809881, -0.662405, 0.291073, 0.933498, 0.145448, -1.320783, -0.095605, -0.529351, -0.132932, -0.076056, 0.305026, -0.351808, -0.486382, -0.404345, -0.051480, -0.207974, -0.652647, 0.020010, 0.612653, 0.115066, -0.540759, -0.203392, -0.925978, -0.150383, 0.143635, -0.112351, 0.198164, -0.244472, 0.113001, 0.332334, -0.112954, 0.465393, -0.070138, 0.063924, 0.019079, -0.106923, -0.196097, -0.054911, 0.212862, 0.133533, -0.250712, 0.113439, -0.131835, 0.240081, 0.401371, -0.136385, 0.080735, -0.066248, -0.268836, -0.609201, 0.002244, 1.096396, 0.653258, -0.370731, 0.004193, -0.351190, 0.616663, -0.180307, -1.054957, -0.400669, 0.103987, -0.266680, -0.386759, 0.810902, 0.888694, 0.177574, -0.073651, -0.568026, -0.502703, -0.286789, 0.253461, -0.583397, -0.186916, -0.498879, -0.761532, -0.129597, -0.869037, -0.252608, 0.177408, 0.036917, -0.534742, -0.193803, -0.277982, -0.272222, 0.563940, 0.439427, 0.361577, -0.289183, 0.305992, 0.539249, -0.184108, -0.094689, 0.363736, 0.059775, -0.448689, -0.120596, -0.062719, 0.159663, -0.608056, 0.416128, 0.603383, 0.344841, 0.565136, 0.660521, -0.529664, 0.124384, -0.899643, -0.023358, 0.030001, -0.317541, 0.345594, 0.704562, 0.054606, 0.389034, 0.218030, -0.027221, -0.223578, 0.022741, -0.121378, 0.309758, -0.215657, 0.169960, 0.054426, 0.109186, 0.173930, 0.109784, 0.513832, -0.077792, -0.173867, -0.068979, -0.183410, -0.049067, -0.368403, -0.387854, -0.084022, 1.119705, -0.477635, -0.051429, -0.423587, -0.219860, -0.008039, 0.162485, 0.127973, -0.509008, 0.175540, 0.264941, -0.178548, -0.062725, 0.076768, -0.770483, 0.380852, -0.414001, -0.031954, -0.145811, 0.143724, 0.295633, -0.097607, 0.007178, -0.601932, -0.761031, -0.057291, 0.633270, 0.745748, 0.441058, 0.346949, 0.756374, -0.007979, 0.551267, 0.019018, -0.179163, 0.081393, 0.118977, -0.481470, -0.429028, 0.227661, -0.127441, 0.241792, -0.010222, 0.117596, 0.259235, 0.035598, 0.015566, -0.427440, -0.538262, -0.049372, 0.129281, -0.310978, -0.179140, -0.200397, -0.148243, -0.303773, -0.511711, -0.632585, -0.357399, -0.458079, 1.284361, -0.662383, -0.009465, -0.055963, -0.277217, 0.285645, -0.172086, 0.010475, -0.568609, -0.188397, 0.085572, -0.734971, -0.161922, 0.090432, -0.489655, 0.544879, -0.169790, 0.268206, -0.472337, 0.100543, -0.093147, -0.366648, -0.413427, 0.498701, -0.793527, -0.679961, -0.636976, 0.124797, 0.299012, -0.119662, 0.153242, 1.317687, 0.680127, -0.268771, 0.389167, 0.874812, 0.250600, 0.875516, 0.917397, 0.771723, -0.677454, 0.147336, 0.151548, 0.532196, 0.154764, 0.264414, 0.471181, -0.233666, 0.284895, -0.319345, 0.075472, 0.336941, -0.161448, -0.481165, -0.096606, -0.120863, 0.287315, 0.257525, -0.171637, -0.213373, 0.061079, 0.564385, -0.276391, 0.615224, -0.192184, -0.115444, 0.631023, 0.064273, 0.226517, 0.515836, 0.202946, -0.272905, 0.214720, -0.247372, -0.136764, 0.110565, 0.056165, 0.863006, 0.196231, 0.017402, -0.076208, 0.406787, 0.177293, -0.036840, -0.114331, 0.213525, 0.387229, 0.502419, 0.137922, 0.024527, -0.061545, -0.143661, -0.253186, -0.732391, -0.197367, 0.065895, -0.700400, -0.759142, 0.284823, 0.466735, -0.624780, -0.010542, 0.183991, -0.263214, 0.361672, 0.043160, -0.115805, 0.041548, 0.139768, -0.046986, 0.303820, 0.531673, -0.074905, -0.313678, 0.044472, 0.045267, 0.126896, 0.339494, -0.088253, -0.066768, 0.418436, 0.521398, -0.254251, 0.298370, -0.409259, -0.098074, 0.749859, 0.081480, 0.264973, 0.336989, 0.063805, -0.461164, 0.168978, -0.147544, -0.190230, -0.019134, -0.121844, 0.717617, 0.344525, -0.049121, -0.259235, 0.299566, -0.833861, 0.737875, -0.715724, -0.619432, -0.687933, 0.180279, 0.475212, -0.329639, 0.015308, 1.347139, 0.739209, 0.039390, 0.832751, 1.066121, 0.187425, 0.846291, 1.019912, 0.719864, -0.153963, 0.309774, 0.101783, 0.700340, 0.300527, 0.105824, 0.081107, -0.303541, 0.001429, -0.632186, 0.003366, -0.239847, -0.289581, -0.618128, -0.423085, -0.436549, -0.214195, -0.276722, -0.391883, -0.288446, -0.246059, -0.366898, -0.357143, -0.556545, -0.512450, 0.306168, 0.433835, 0.141806, -0.093041, -0.268617, -0.020366, -0.112367, -0.242429, -0.060924, -0.029593, -0.110881, 0.211754, 0.052368, -0.117066, -0.073714, -0.040418, -0.176986, -0.031050, -0.065349, 0.032167, 0.111204, 0.089349, -0.241696, -0.121688, -0.025825, 0.111728, 0.112539, -0.110586, -0.124208, 0.062198, 0.011351, -0.261720, 0.000343, 0.275467, 0.345054, 0.465683, -0.059104, -0.180017, 0.068256, -0.147943, -0.095330, 0.134209, 0.002911, -0.135674, -0.048948, -0.002919, -0.119070, -0.350863, -0.582782, -0.388855, -0.460423, -0.105081, -0.077523, -0.327058, -0.200891, -0.374062, -0.435685, -0.167676, -0.354701, -0.675045, 0.466604, 0.515351, 0.178387, -0.025892, -0.352039, -0.170895, -0.125258, -0.158582, -0.094125, 0.083047, -0.394153, 0.163095, 0.152798, -0.188470, -0.150005, -0.027227, -0.241112, 0.425505, -0.920603, 0.643484, 1.310444, 1.223573, 0.152385, 1.066438, 1.693968, 1.055677, -0.389925, -1.478549, -0.167342, -0.572463, -1.215943, 0.262091, -0.766378, 0.342708, -0.716566, 1.168374, -0.425666, 0.808084, 0.088373, 0.291882, 0.835682, 0.326938, 0.901829, -0.295297, 0.461991, 0.000528, 0.255397, 0.090865, -0.211681, -0.141331, -0.291562, 0.181906, -0.168190, -0.077667, 0.190227, -0.198099, 0.175367, -0.076047, -0.080835, 0.170678, 0.282075, 0.593411, 0.553695, -0.064332, -0.047977, -0.022497, -0.280861, -0.220877, -0.154590, -0.275586, -0.120125, 0.024297, 0.217043, 0.091150, -0.365776, 0.038903, 0.088772, -0.025140, 0.064228, 0.049403, 0.234328, -0.034154, -0.159726, -0.150709, 0.077806, 0.085121, 0.067046, -0.000697, -0.026268, -0.009675, -0.036902, 0.298095, 0.147804, 0.098352, 0.100690, -0.170448, -0.180906, -0.091248, -0.300803, 0.050890, 0.093546, -0.141256, -0.050145, -0.177498, 0.055288, -0.130808, 0.045474, -0.289352, -0.485285, -0.080111, -0.167930, -0.178171, -0.238809, -0.120176, 0.034583, -0.090534, 0.137538, 0.375174, 0.128826, -0.028581, -0.012149, 0.047135, 0.155651, -0.229073, -0.155615, -0.053754, -0.254130, -0.093586, -0.007496, -0.084990, 0.065221, 0.167561, 0.105527, 0.029236, -0.257752, -0.011486, 0.050026, -0.423850, -0.271084, -0.402282, 0.219967, 0.412872, 0.831342, 0.544347, 0.346894, 0.620999, 0.336472, 0.800246, 0.410494, -0.315929, 0.702527, 0.808192, 0.235173, 1.273887, 0.924728, 0.042932, -0.092639, -0.085233, 0.637603, -0.513577, -0.410107, 0.015788, -0.710926, 0.052126, -0.711090, 0.531079, 0.470971, -0.046970, 0.222666, 0.052891, -0.001714, 0.136921, -0.239777, -0.367291, 0.099122, 0.117616, 0.175566, -0.045716, -0.138390, 0.594777, -0.383753, -0.457286, 0.499609, -0.792455, 0.144635, -0.109635, -0.347867, -0.640143, 0.556108, 0.414381, 0.545798, -0.130767, -0.503390, 0.342311, -0.152523, 0.456551, 0.525069, 0.217719, 0.060320, 0.048942, -0.062055, -0.160279, -0.472659, -0.293766, -0.146147, 0.002306, 0.077011, -0.118299, -0.172923, -0.301984, -0.064819, 0.115211, 0.165288, -0.041515, -0.393776, -0.083996, 0.250903, -0.163707, 0.049911, 0.057298, -0.154340, 0.156796, -0.183267, -0.181757, -0.036646, -0.395506, 0.275596, 0.276317, 0.619680, 0.232424, 0.072759, 0.114262, -0.181019, -0.443505, 0.127572, 0.419104, 0.176837, 0.279697, -0.321661, 0.684703, -0.307081, 0.017764, 0.770413, -0.679854, 0.325540, 0.173710, -0.163713, -0.462670, 0.419177, 0.117831, 0.770566, -0.215401, -0.387544, 0.296618, -0.289198, 0.240069, 0.329903};
static RBF_CONST rbf_float RBF_WIDTHS[] = {4.552484, 3.458157, 7.286540, 5.157897, 5.851818, 3.551538, 5.187081, 4.418667, 3.810543, 8.386168, 4.337297, 3.383638, 3.898948, 3.812186, 5.136799, 3.697630, 3.916630, 5.331990, 3.449166, 4.109918, 4.824758, 4.255881, 5.311327, 8.601834, 5.152951, 5.311327, 6.670725, 10.351771, 4.120691, 3.812186, 6.072967, 4.026284, 5.061953, 4.120691, 3.810543, 4.404047, 3.383638, 3.389818, 4.812121, 17.327246, 3.475084, 4.103754, 3.389818, 3.995758, 4.761591, 4.515843, 4.191413, 6.261106, 5.331990, 3.599502, 6.463373, 3.471596, 3.459344, 3.874825, 3.464356, 5.851818, 3.944760, 3.763863, 4.792146, 4.817989, 4.255881, 22.145586, 6.929983, 4.305533, 3.816085, 6.670725, 4.278305, 3.549300, 4.346261, 10.061542, 3.763863, 3.475084, 5.535087, 3.459344, 3.471596, 17.451506, 5.484020, 5.136799, 3.898948, 4.443237, 3.874825, 3.995758, 3.902842, 4.054604, 3.464356, 4.599517, 3.875914, 4.149763, 10.648558, 3.551538, 4.149763, 4.052513, 4.278305, 3.458157, 4.717363, 4.672899, 4.170172, 3.528873, 4.956820, 3.725200};
static RBF_CONST rbf_float RBF_WEIGHTS[] = {0.406844, 3.055330, -3.465253, 1.492698, -0.392838, -2.159534, 2.364468, 0.819952, -1.538177, 0.762623, -1.339278, -0.004875, -0.970420, 1.100626, -2.230036, 1.489613, 0.250372, -2.150821, 3.396384, 0.387791, -2.273147, 0.640382, 0.530103, -0.147627, 2.158954, -0.708927, 0.443831, 0.197794, -3.946930, 0.533315, 3.065826, 1.443556, 1.006629, -1.351832, -1.035317, -1.791811, 1.013308, -1.412300, -0.036678, 0.344017, 1.396169, -0.906122, 1.426284, 0.454686, 0.125908, -1.743142, -0.494714, -0.077627, 2.204393, -2.988637, 1.789426, 2.311302, -0.973170, -0.617548, -0.982637, 1.731737, 1.123660, 0.600249, -1.463945, -2.671238, 2.970135, -4.794384, 1.621012, 2.020348, 0.814936, 2.477101, 1.036623, -1.402408, -2.124592, -0.185669, -0.274043, -1.944442, 3.684385, -1.915782, 1.226458, -0.975913, -2.851410, -3.438871, -2.092119, 1.642512, 1.142636, 1.246311, 1.051102, 1.351337, 3.417311, -1.817867, 2.885016, -1.228175, -3.295927, 1.722571, -2.425842, 0.624176, 1.549709, 0.846335, -1.630217, -0.620465, 3.717831, -5.156452, 5.298517, 1.685511, 0.221721, 3.110744, -0.261881, 0.363189, 0.204961, -2.359297, -2.958639, -3.658145, -1.749604, 4.139544, 0.939050, 2.053967, 1.259165, -3.926089, -2.926733, -1.022220, -1.607104, 2.758622, -0.762192, 0.819569, -0.722253, 1.166754, 0.322735, -1.047241, -0.291048, -3.101239, 1.973487, 0.598976, 1.173719, -1.090920, 1.059629, -0.077355, -0.197556, -0.732216, 1.500375, -1.335489, -0.763229, 2.004419, -3.463539, -0.426395, -1.959083, 1.770772, 1.814051, 1.791456, -5.752275, 3.800433, -2.533389, -0.053926, 2.249226, -2.554024, 2.600486, -0.085980, 2.681686, -0.281891, 0.316060, -0.627097, -4.429097, 5.336312, -1.980169, 1.679234, -0.546203, 1.827170, -0.703103, -1.436861, -0.554195, 4.810079, -4.826666, 0.592678, -0.286511, -0.003966, -2.234611, 2.787519, 3.724940, 3.276804, 0.527996, -2.779388, 1.099442, -2.281803, -1.515667, -2.291511, -5.366239, 0.444670, -0.753533, -0.291230, 1.887024, 5.420840, -1.373478, -1.545768, -2.303290, 3.514566, 1.194369, -1.007182, -0.781263, 2.059578, -1.054421, 0.529976, 1.995352, 1.017376, -3.318202, -0.490437, -0.420003, 0.251852, 0.372860, -0.205746, 1.529210, -3.858900, 3.606687, -2.601099, -1.231488, 2.357743, -3.496065, 2.678650, 0.140406, -0.048533, 1.288603, -0.338093, -2.431659, 2.295116, -0.617987, -5.394314, -0.337172, 4.633112, -3.525089, -0.998896, -2.263757, 1.989852, 1.763926, 4.752434, 0.465354, -1.746017, 1.485637, 0.147644, -0.774049, 3.603467, 0.054812, -0.989278, -1.155753, 0.755690, -0.398057, -1.419716, 2.887624, -1.210169, 1.863764, -8.877358, 3.430232, -6.507814, -0.939107, 6.307114, 2.963453, -3.047071, 2.912678, 0.248237, -0.678275, 1.885910, 2.008760, -0.813825, -0.196740, 1.728965, -1.241331, 1.073696, 1.089681, 0.036056, -2.933369, -2.050222, 0.399162, 0.517911, 0.190036, -0.146378, -2.031286, 1.785080, -2.283762, -2.398356, -0.224890, 1.987746, -0.287753, 2.472304, 2.082743, 1.398804, -1.231654, 0.216244, 0.658375, 1.667121, -0.551071, -0.639493, -1.558607, -1.548235, -1.603144, 1.205861, 8.740782, -5.910010, 1.720036, 0.567849, 1.811236, -5.497865, 0.096407, 0.832353, 0.112758, -2.112606, 0.175059, -0.125130, 0.489446, 0.174433, 2.577062, 1.037587, -2.911224, -0.537608, -0.108605, 1.127598, -1.608387, 0.168961, -0.428835, 0.064138, -2.782075, -1.124136, -4.512162, -2.498299, 1.855158, 0.677637, 0.737734, 0.617311, 3.756403, 0.086430, 2.771925, 0.208846, -1.168808, 6.484623, -3.843523, 0.165490, 2.346085, 0.443330, -1.601719, -3.905479, 2.704500, -0.208892, -0.107602, -1.476407, 0.799675, -1.048179, 3.426122, -1.075436, -3.146042, -2.145220, 2.492667, 2.079541, 0.157743, -0.473365, -1.223958, 0.196143, 6.436616, -1.339516, -4.168110, -2.681281, -1.582630, -0.167275, 1.336002, 2.536842, -2.306284, 0.009193, 1.962740, 0.122076, 0.130305, -2.175943, 0.700487, -1.589817, -0.763193, 2.554002, -0.598758, 0.213729, 0.122833, 0.475844, 0.652161, 0.261873, -0.063669, -0.666371, -2.415828, 2.777334, 0.198254, -0.397072, 0.295563, -2.445678, -0.344501, 3.039395, -0.057939, 0.085863, 3.864008, -1.379714, -0.414809, 0.750255, -2.502280, -1.018379, 0.493021, 0.206764, 2.242411, -1.038294, -0.465009, -0.669740, 0.808981, -2.046425, -0.956225, 2.029786, -8.337931, 5.037240, -0.769074, -3.526164, 2.609897, 5.724753, 1.066885, -1.827902, 0.672278, -0.653191, -0.636737, 1.018328, -0.183638, -1.489416, 0.832257, 0.677469, 3.166673, -0.963096, -1.503186, -0.964116, 4.619323, -7.045460, 0.673085, -0.497150, -0.192697, -3.546594, 3.209044, 1.129514, 1.371977, -2.139801, 4.042696, -1.405957, -0.621554, 0.391942, 1.141867, -1.219899, -0.641763, 2.638334, -4.709117, 1.396777, -0.612565, 2.178482, -1.082448, 1.061316, 3.778133, -0.800775, -1.637133, -2.812728, 2.378429, -1.345265, 2.631837, -0.170370, -1.210852, -2.588627, 1.911680, 0.042745, -1.363725, 0.674216, -2.019579, 3.478560, 2.729145, -2.750357, 2.346617, -0.399409, 2.572856, -1.208915, -1.718734, -2.371296, -2.485459, 2.243406, -3.395690, 3.825863, -0.936508, -5.988069, 3.746214, -0.482780, 2.043602, 1.157358, -0.375237, 0.550256, 3.175182, -1.753156, 1.681968, 0.928487, -0.576287, -3.542395, 0.837392, 0.024283, 1.001114, -1.620478, 2.345388, -2.371726, -1.744175, 1.453797, 0.331784, 3.474559, -0.171516, 4.601862, -2.422052, -1.962805, -1.344053, 1.474238, -2.173333, -1.574726, 0.022099, -0.610238, 1.803363, -2.143642, -0.535797, -1.159348, 1.130598, 1.583172, 1.072921, -0.759094, -0.443736, 0.026377, -2.453939, 0.301855, 2.021067, -4.162245, 2.152502, 0.539630, -1.353232, 2.475069, -2.484057, -0.905572, -0.158273, 4.027044, -3.197462, 2.206223, -0.833307, 0.322268, 4.023432, -2.521421, 0.075620, 0.387766, 1.877184, -1.227915, -1.433455, 0.234302, -3.374038, 4.010132, -1.912458, 1.156214, -0.556789, 2.133077, -1.773586, -1.696611, -1.705434, 2.785674, -0.150803, 0.931911, -5.007470, -0.636090, -5.461391, 0.633582, 1.105970, 1.986828, 3.864713, -2.666990, 0.898057, 7.127793, 3.823106, -5.969517, -2.777854, -0.863846, 0.553021, 1.445421, -1.495158, -0.471232, -0.289372, -1.638722, 4.294076, -0.025250, 0.266767, 0.858127, -1.420203, 1.945724, -2.150136, 1.675365, 1.226796, -4.105136, 3.195624, 1.084511, -0.861736, 0.283260, -1.065631, 0.191172, 0.782689, -0.205858, -2.974923, 1.106989, 0.291057, -0.271606, 1.923963, -0.745398, 1.536439, -1.483940, 0.511453, -0.466589, 0.570773, -0.718809, 0.405189, -1.998197, 1.768839, -0.359549, 0.886476, 0.499473, -0.054270, -1.744104, 0.570724, 0.227106, -2.328533, 0.409785, 2.404746, 0.343457, 0.761879, -1.548375, -0.632954, 1.223036, 0.619404, 1.096628, -0.768630, -1.656428, 1.587778, 0.682421, 1.513104, -0.647697, 0.472400, -2.879795, 1.427776, 3.479251, -1.287525, -6.842211, 0.727841, 1.939570, -2.333075, 1.627856, -0.232318, 0.997322, 0.556692, 1.963854, -1.707211, -0.828935, -1.124989, 0.081712, 0.348099, 0.591244, -2.114369, 2.921531, -3.180618, 1.115109, 1.734942, -4.063628, 2.570617, -1.195184, 1.881984, -1.304264, 1.211681, 0.347700, 1.424313, -0.261689, 1.488032, -1.941053, 1.598121, 3.144572, -0.875166, 0.513177, -2.379817, -3.023226, 1.326017, -0.906808, -3.279350, 0.680357, -4.138053, -3.469109, 1.937911, 0.693113, -0.262907, 1.194620, 1.849688, 0.224389, 3.819167, 0.538398, 2.054233, -1.788276, -0.058224, 2.330096, -0.017494, -2.149004, 2.574567, -0.661392, 0.979697, 1.023518, -1.961722, -2.242407, -0.409853, -0.627956, 0.960046, -1.049442, -0.022639, -0.194679, -1.232031, -1.001543, 1.047051, 0.396677, 1.181345, 0.926865, -0.713019, -1.331219, 1.317189, -0.478782, 1.227532, 3.209099, -0.946227, -0.795362, 1.177412, -2.461912, 0.661321, -0.876787, -0.439230, 1.248987, 0.323750, -0.534596, -1.137775, 1.895737, -2.187866, -2.098300, -2.572058, 1.264708, 1.918179, 2.325769, 2.694658, 6.801075, 0.061159, 1.520425, 0.615012, -3.481172, 1.412685, -1.491843, -5.756366, -1.898002, -1.334300, 1.077566, -2.408708, 0.265959, -0.485452, -1.973879, 1.517316, 1.315137, -0.454107, 0.152706, -0.244764, -0.676836, 1.850924, 1.069053, -0.497317, -1.790333, 0.993163, -1.586724, 0.197188, 0.728023, 0.777238, -0.790613, -1.319977, 0.340784, 2.620657, 0.357506, -2.234378, 2.217236, 0.798844, 2.564089, 0.309130, 3.028162, -2.624169, -2.624505, -0.969721, 2.443559, -2.048524, -0.938507, 0.311705, -4.561581, 2.926757, 1.990434, -4.853960, 4.580129, 0.210254, -1.725670, -0.164873, 1.893295, 0.311838, -0.908234, -0.067282, -0.296053, 0.990982, -1.546438, 0.536511, -5.961394, -0.339262, -0.103296, 1.175735, 3.051377, 0.160413, 2.396927, -1.037220, 0.674734, -2.074826, 0.002536, 1.205453, -1.792006, 1.226921, 1.565277, 1.106911, -1.212342, -0.287882, 0.580013, 2.272035, -2.036643, -0.718576, -2.608841, -0.091413, 1.319159, 1.893195, 0.411964, -3.615316, -1.631570, 2.445785, 2.527082, -1.799924, 1.038712, 3.246342, -2.191533, 1.118626, -4.411486, 2.306935, 5.385786, -3.934855, -2.962280, -1.184239, 3.499726, -2.423486, 2.958748, -4.194375, -0.034114, 0.529564, 0.175314, 0.516363, -2.679232, 0.767233, 0.745830, 1.534986, 1.972151, 0.129860, 1.813564, -1.632032, 1.467810, 0.458656, 0.803137, 0.648133, 0.939430, -0.054755, -0.541818, -1.595141, -2.467321, 2.349898, -1.517936, 1.446931, -0.605456, 0.829385, -3.335276, -1.934653, 0.133389, 1.763984, 1.043902, -0.928457, 0.825725, 1.239624, 0.760852, 0.462579, -0.798717, 1.873267, -0.516213, 1.458598, 0.613558, -0.798486, -5.670534, 0.521042, 0.993055, -6.902305, 6.762514, -1.632808, 1.436167, 0.333953, 0.544892, -1.478151, -1.079478, -2.621046, 3.220204, -1.073623, 2.254042, -1.953613, 5.637198, 1.361702, -0.279040, 2.436959, 1.522719, -2.044104, 0.470978, 1.342467, -1.403392, -2.325380, -4.919421, 0.222022, 1.875256, -0.604913, -1.341235, 3.009125, 0.132387, -0.751376, 1.209468, -1.137340, -2.406581, 0.023772, -0.192067, 0.434947, -1.470761, 0.246717, 0.173365, -0.445427, -2.382575, 1.430891, 1.071849, -0.398004, 1.342196, 1.805754, -1.789170, 4.193900, 0.636427, -2.713514, -0.773962, 4.120695, -10.131005, 2.704671, 2.177628, -2.465695, -2.056180, 1.044796, 3.556092, -2.534288, 1.576836, 1.219443, 0.768928, 1.709723, 1.778984, -2.031806, -0.060002, -2.021178, -0.172308, -0.411449, 0.151479, 4.787765, -3.484779, 3.578248, 1.543597, -11.901400, 0.656420, 1.663922, 3.998540, -3.183004, 0.200269, -0.340318, 2.641829, 0.372998, 2.758269, -3.527939, 3.675552, -3.352356, -1.182226, 1.804882, -1.238224, -0.675616, 4.216928, -2.391869, -0.524071, -3.150904, 3.912611, -1.265352, 6.946594, -2.900241, 3.581308, -2.029526, -3.216018, -0.446202, 5.613189, -7.511698, 0.303791, 0.447689, -1.716817, 2.286205, 1.192229, -1.200932, 3.585870, -2.207357, -1.703407, -0.396016, 1.519756, -1.301048, -0.486687, 0.485756, 2.011627, -1.644741, -0.541820, 0.084644, -1.329884, 3.276951, 0.511233, -2.217981, 0.350722, -0.032160, -0.924287, 1.117545, -0.166180, 1.136326, -1.619133, -0.597063, 1.269717, -3.701240, -0.365440, -2.292978, 2.056056, 0.255700, 2.956976, 1.168771, 0.258497, -0.565589, -2.368824, 4.241610, 1.053947, 1.635036, 1.006671, -0.152574, -6.862968, 1.230759, -0.527391, -1.112874, 1.523953, 1.921474, -2.366230, -2.185526, -1.324908, -0.021087, 0.644507, 0.505259, -0.391731, -0.933994, 3.691682, 0.983798, 1.701232, -3.504282, 0.035167, -6.687502, -1.337467, 0.917943, -1.849743, 0.716472, 3.947673, 0.826841, 4.149043, -0.041419, -3.636228, 3.091345, -0.090283, -3.937451, 3.125969, -2.213517, -1.766331, 1.686311, 1.327319, 0.952434, 1.464987, 1.724811, -1.485724, 0.379852, 0.863765, -2.534256, 3.245864, -0.707719, -1.648457, 0.409945, 0.604478, 0.940638, -1.787840, -1.983120, 3.123342, 0.488102, -0.169193, 0.939579, -2.538441, -0.225689, 0.665188, 1.397301, -2.520159, -1.279703, 2.050589, -0.069010, 0.846932, -1.106290, 0.094491, 2.332901, -3.733104, 1.539731, 0.236213, 1.129280, 1.860434, -0.867078, -2.292025, 3.608486, -2.037619, 0.959416, -0.939210, -0.783732, -1.785683, 0.482789, 1.530626, -2.224317, -0.828440, 0.308243, 1.904535, 0.157833, -2.006750, -1.678319, 1.704233, 1.619280, -1.085180, 3.913133, -2.006906, 2.886558, -1.143803, -0.026217, -2.319551, 1.759053, -2.041579, 1.289297, 0.591873, 0.921518, -1.621287, -1.042471, -0.594962, 2.452998, -1.434165, 1.213030, -1.433454, -2.696362, 0.729866, 1.365828, 0.906341, 1.178716, 2.328230, -1.160067, -1.891437, 1.735845, -1.874150, -0.878924, 0.181806, -0.459844, -2.967204, -0.433766, 0.851041, -0.165973, 1.315056, 0.972156, 0.076297, 3.459259, -1.732303, 1.997991, -2.978781, -1.838058, 0.503070, 5.726271, 2.264619, 4.933048, 0.060848, -7.311048, 0.824371, 0.994116, -2.409661, -2.421219, -1.295939, 0.874227, -1.455438, 1.961656, -1.914073, 0.179117, 4.336111, -0.861794, 0.387008, 1.006213, -2.407622, -1.493005, -0.600284};
static RBF_CONST rbf_float RBF_BIAS[] = {2.102807, -23.009592, 7.889239, -7.345418, 0.100702, 10.425588, -3.452522, 7.863259, 1.702627, -0.799868, 2.537553, 2.159225};

#if RBF_USE_NORMALIZATION
static RBF_CONST rbf_float NORM_IN_MEAN[] = {0.007725, -0.007038, 0.007455, 0.011877, 0.001866, -0.003087, 0.004067, 0.002325, 0.003148, -0.006066, 0.004758, 0.000636, 0.004189, -0.007824, 0.003690, -0.004952, -0.002980, -0.015579, -0.010094, 0.002106, 0.004459, 0.006238, -0.002720, -0.000873, 0.007270, 0.009699, 0.006898, 0.001832, 0.005006, -0.007759, 0.005082, 0.013317, -0.002149, -0.000781, 0.011293, 0.011511, 0.005884, -0.005790, -0.009952, -0.009337, 0.005552, 0.014381, 0.010618, 0.015250, 0.005429, 0.003803, 0.008677, -0.012048, -0.007581, -0.018476, -0.000717, 0.010397, 0.001276, -0.002031, -0.007865, -0.015925, -0.004742, -0.004977, 0.008823, 0.009801, -0.012115, 0.003178, 0.000795, 0.004078, -0.008358, -0.003247, 0.002985, -0.001700, 0.003416, -0.003666, -0.008242, 0.004791, 0.002949, 0.003835, 0.013085, 0.002617, -0.000862, -0.003491, 0.012320, 0.005680, -0.008778, -0.010445, 0.013855, -0.000230, -0.028151, -0.007351, -0.002369, 0.003762, -0.006667, 0.005783, 0.009740, 0.013742, 0.000966, 0.002236, 0.001234, 0.012526, 0.005553, 0.000584, 0.001718, -0.007526, 0.010426, 0.019006, 0.001946, -0.000085, -0.001752, 0.006428, 0.012480, -0.011479, -0.004705, -0.011416, 0.002779, 0.019718, 0.009155, -0.006767, -0.002370, -0.006690, -0.004474, -0.008191, 0.013075, 0.004443};
static RBF_CONST rbf_float NORM_IN_SCALE[] = {0.996629, 0.996456, 1.006960, 1.000724, 0.998965, 1.007205, 0.996358, 1.008930, 0.999738, 0.999265, 1.000178, 1.004599, 1.005564, 1.001433, 0.999537, 0.996337, 1.004369, 1.001488, 1.006371, 1.002854, 1.013769, 1.009204, 1.012719, 1.009145, 1.007766, 1.013448, 1.006060, 1.004181, 1.004699, 1.012301, 1.011381, 1.004705, 1.005709, 0.999788, 1.014250, 1.007092, 0.998332, 0.999420, 1.000578, 0.986307, 0.990726, 1.000894, 0.987749, 1.003016, 1.003188, 1.002182, 0.999670, 1.003895, 1.005160, 0.987971, 1.003442, 0.998074, 1.001403, 0.997493, 1.004569, 0.999488, 1.000520, 1.005482, 1.005012, 0.999332, 1.021121, 1.009623, 1.005972, 1.000076, 1.007258, 1.004143, 1.013018, 1.009041, 0.999489, 0.987664, 1.004903, 0.995086, 1.004900, 0.999231, 0.991359, 1.003120, 1.001450, 0.991679, 1.002761, 0.996638, 0.996337, 1.011198, 0.990578, 1.001591, 0.993474, 0.997636, 0.995683, 0.991396, 1.004184, 1.003337, 1.017125, 1.011451, 1.014767, 0.996731, 0.999880, 0.999353, 1.003289, 0.993435, 1.000970, 0.994051, 1.002609, 1.002306, 1.001798, 0.999421, 1.000606, 1.006095, 1.006228, 1.003175, 1.000111, 0.992152, 1.000916, 1.003823, 0.992797, 0.989172, 1.004844, 0.997501, 1.006134, 1.001482, 1.007577, 1.002577}; // StdDev
static RBF_CONST rbf_float NORM_OUT_MEAN[] = {0.078289, 0.085565, 0.081781, 0.081781, 0.081490, 0.084692, 0.082654, 0.084692, 0.087602, 0.085565, 0.083818, 0.082072};
static RBF_CONST rbf_float NORM_OUT_SCALE[] = {0.268625, 0.279720, 0.274031, 0.274031, 0.273586, 0.278422, 0.275359, 0.278422, 0.282715, 0.279720, 0.277115, 0.274475}; // StdDev
#endif

// ==========================================
// Implementation
// ==========================================

RbfModelRBF::RbfModelRBF() {
    for(int i=0; i<RBF_HIDDEN_DIM; i++) hidden_activations[i] = 0;
}

void RbfModelRBF::predict(const rbf_float* input, rbf_float* output) {
    // 1. Prepare Input (Normalize if needed)
    rbf_float processed_input[RBF_INPUT_DIM];
    #if RBF_USE_NORMALIZATION
        normalizeInput(input, processed_input);
        const rbf_float* in_ptr = processed_input;
    #else
        const rbf_float* in_ptr = input;
    #endif

    // 2. Hidden Layer (RBF)
    for (int i = 0; i < RBF_HIDDEN_DIM; i++) {
        rbf_float dist_sq = euclideanDistanceSq(in_ptr, i);
        rbf_float width = RBF_READ(&RBF_WIDTHS[i]);
        hidden_activations[i] = computeKernel(dist_sq, width);
    }

    // 3. Output Layer (Linear)
    for (int j = 0; j < RBF_OUTPUT_DIM; j++) {
        #if RBF_FIXED_POINT
            int64_t sum = 0;
        #else
            float sum = 0.0f;
        #endif

        for (int i = 0; i < RBF_HIDDEN_DIM; i++) {
            rbf_float weight = RBF_READ(&RBF_WEIGHTS[i * RBF_OUTPUT_DIM + j]);
            #if RBF_FIXED_POINT
                sum += (int64_t)hidden_activations[i] * weight;
            #else
                sum += hidden_activations[i] * weight;
            #endif
        }

        #if RBF_FIXED_POINT
            sum = sum / RBF_SCALE_FACTOR;
            output[j] = (rbf_float)sum + RBF_READ(&RBF_BIAS[j]);
        #else
            output[j] = sum + RBF_READ(&RBF_BIAS[j]);
        #endif
    }
    
    // 4. Denormalize Output
    #if RBF_USE_NORMALIZATION
        denormalizeOutput(output);
    #endif
}

void RbfModelRBF::normalizeInput(const rbf_float* input, rbf_float* norm_input) {
    for(int i=0; i<RBF_INPUT_DIM; i++) {
        rbf_float mean = RBF_READ(&NORM_IN_MEAN[i]);
        rbf_float scale = RBF_READ(&NORM_IN_SCALE[i]);
        #if RBF_FIXED_POINT
             // (Input - Mean) * SCALE_FACTOR / StdDev
             int64_t diff = (int64_t)input[i] - mean;
             norm_input[i] = (rbf_float)((diff * RBF_SCALE_FACTOR) / scale);
        #else
             norm_input[i] = (input[i] - mean) / scale;
        #endif
    }
}

void RbfModelRBF::denormalizeOutput(rbf_float* output) {
    for(int i=0; i<RBF_OUTPUT_DIM; i++) {
        rbf_float mean = RBF_READ(&NORM_OUT_MEAN[i]);
        rbf_float scale = RBF_READ(&NORM_OUT_SCALE[i]);
        #if RBF_FIXED_POINT
             // (Output * StdDev) / SCALE_FACTOR + Mean
             int64_t val = (int64_t)output[i] * scale;
             output[i] = (rbf_float)(val / RBF_SCALE_FACTOR) + mean;
        #else
             output[i] = (output[i] * scale) + mean;
        #endif
    }
}

rbf_float RbfModelRBF::euclideanDistanceSq(const rbf_float* input, int center_idx) {
    #if RBF_FIXED_POINT
        int64_t sum = 0;
    #else
        float sum = 0.0f;
    #endif
    int base_idx = center_idx * RBF_INPUT_DIM;
    for (int k = 0; k < RBF_INPUT_DIM; k++) {
        rbf_float c = RBF_READ(&RBF_CENTERS[base_idx + k]);
        rbf_float diff = input[k] - c;
        #if RBF_FIXED_POINT
            sum += ((int64_t)diff * diff) / RBF_SCALE_FACTOR;
        #else
            sum += diff * diff;
        #endif
    }
    return (rbf_float)sum;
}

rbf_float RbfModelRBF::computeKernel(rbf_float dist_sq, rbf_float width) {
    #if RBF_FIXED_POINT
        if (width == 0) return 0;
        double d = (double)dist_sq / RBF_SCALE_FACTOR;
        double w = (double)width / RBF_SCALE_FACTOR;
        return (rbf_float)(exp(-d / (2.0 * w * w)) * RBF_SCALE_FACTOR);
    #else
        return exp(-dist_sq / (2.0f * width * width));
    #endif
}

void RbfModelRBF::printInfo() {
    Serial.println(F("Model Loaded: RbfModelRBF"));
    Serial.print(F("Normalization: ")); 
    Serial.println(RBF_USE_NORMALIZATION ? F("YES") : F("NO"));
}
