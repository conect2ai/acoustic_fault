#include "RbfModelRBF.h"

// ==========================================
// Flash/PROGMEM Macros
// ==========================================
#if defined(ESP32) || defined(ESP8266)
    #define RBF_CONST const
    #define RBF_READ(x) (*(x)) // Fixed: Dereference pointer
#elif defined(__AVR__)
    #include <avr/pgmspace.h>
    #define RBF_CONST const PROGMEM
    #if RBF_FIXED_POINT
        #define RBF_READ(addr) (rbf_float)pgm_read_dword(addr)
    #else
        #define RBF_READ(addr) (rbf_float)pgm_read_float(addr)
    #endif
#else
    #define RBF_CONST const
    #define RBF_READ(x) (*(x)) // Fixed: Dereference pointer
#endif

// ==========================================
// Model Parameters
// ==========================================
static RBF_CONST rbf_float RBF_CENTERS[] = {-0.608310, 0.599256, 0.011243, -0.006814, 0.780345, 0.830459, 0.658975, 0.932580, 1.347194, 0.701066, -0.062893, -0.134038, 0.223294, 0.054114, 0.110552, 0.471940, 0.693551, 0.507733, 0.354130, 0.276591, -0.294815, -0.495865, -0.996997, -1.297475, -0.844035, -1.132945, -1.434019, -0.775746, -1.612999, -0.795915, -0.156133, -0.427068, -0.257183, -0.170953, -0.138773, -0.786417, 0.022907, -0.420414, -0.384409, 0.531449, -0.214239, 0.064893, 0.066752, 0.305223, 0.688420, 0.080306, -0.027363, -0.746749, -0.201407, 0.132404, -0.314977, 0.364252, 0.187870, -1.053109, -0.586449, -0.423403, -0.354007, -0.457713, -0.278288, -0.686384, 0.287915, -0.253714, -0.454555, -0.039652, 0.269866, 0.022202, -0.058790, 0.094729, -0.373313, -0.569570, 0.148696, -0.232120, 0.006894, 0.155208, 0.502850, 0.406793, 0.131664, 0.179555, -0.267323, -0.087596, -0.193221, -0.719647, -0.244229, -0.105335, 0.318895, 0.386931, 0.391779, 0.078914, -0.048707, -0.048299, 0.133430, -0.223808, -0.315292, -0.200051, -0.008648, -0.632325, 0.352689, -0.170643, -0.403961, 1.143996, 0.216636, -0.019342, 0.229585, -0.104888, 0.851824, 0.411835, 0.191446, -0.853024, -0.211735, 0.130421, -0.387933, 0.210529, 0.507210, -0.807557, -0.234745, -0.468787, -0.324897, -0.393575, 0.096737, -0.481370, 0.192916, 0.295363, 0.483937, 0.841389, -0.999668, -1.423582, -0.791921, 0.232676, -0.239140, -0.530197, 0.360842, 0.313347, 0.219773, 0.354590, 0.391428, 0.617230, -0.092839, -0.376549, 0.499189, 0.999551, 1.362639, 0.767029, 1.609750, 1.012962, 0.839643, 1.264976, 1.262151, 0.745253, 0.716170, 0.266533, 0.025502, 0.760940, 0.128806, -0.051705, 0.177867, -0.183705, -0.154716, -0.244842, 0.873059, 0.347792, -0.346517, 0.155102, 0.076437, 0.175676, -0.131755, -0.056245, 0.154323, 0.074024, -0.118845, -0.004705, 0.382331, -0.168118, -0.027962, 0.091557, 0.225909, 0.159546, 0.191341, 0.178970, 0.134788, 0.220070, -0.143273, 0.391903, 0.009729, -0.015080, -0.048532, -0.107824, 0.054569, 0.192219, -0.205346, 0.057977, -0.094728, -0.014743, -0.086500, -0.376056, -0.121917, -0.208421, -0.339782, -0.218728, -0.099597, 0.135372, 0.107206, 0.069944, 0.248245, 0.121807, -0.170414, 0.135659, 0.176651, 0.193520, 0.021984, 0.060990, 0.330476, 1.343736, 0.373998, -0.117293, 0.081526, -0.196401, 0.073049, -0.170532, 1.278482, 0.402595, -0.315269, 0.061499, 0.032292, 0.333948, -0.008674, -0.146407, 0.374809, 0.325773, -0.049607, 0.132628, 0.418047, -0.147568, 0.079737, -0.030484, -0.081664, -0.162701, 0.196492, 0.241686, 0.007963, 0.177035, -0.151341, -0.153511, 0.690129, -0.457364, 0.705327, 0.580089, -0.051268, 0.305994, -0.105085, 0.559492, -0.011652, -0.351328, 0.091620, -0.857740, -0.451402, -0.074084, -0.241680, -0.382943, -0.272102, -0.344151, -0.661992, -0.460693, -0.890473, -0.652427, -0.053695, -0.062264, -0.193521, 0.184607, -0.222299, -0.643585, -0.118853, 0.169884, 0.587088, -0.417599, 0.144097, 0.073872, -0.403286, -0.143690, 0.378853, 1.350056, 0.935711, -0.195398, 0.110207, 0.253236, -0.051875, -0.327721, 0.213529, 0.505975, 0.558510, -0.574744, 0.029067, 0.773259, 0.022262, 0.855546, 0.230900, 1.061936, -0.031041, 1.414174, 0.101805, -0.253273, 0.115914, 0.285471, 0.202344, -0.364514, 0.314094, 0.632464, -0.048144, 0.491870, -0.263251, -0.701903, -0.134285, 0.095710, -0.821179, -0.709373, 0.097458, -0.472416, 0.471614, -0.294017, -0.247811, -0.020503, 0.205877, 0.005559, 0.197116, 0.778813, -0.473915, 0.650232, -0.294615, -0.163423, -0.418180, -0.326461, 0.019132, 0.302651, 0.127418, -0.211876, -0.084200, 0.054828, -0.739058, -0.267813, 0.358446, 1.617303, 1.019967, -0.028400, 0.630843, 0.148181, -0.195189, -0.341692, -0.231434, 0.567886, 0.178750, -0.719772, 0.125702, 1.178557, 0.236498, 0.834697, 0.450521, 1.583242, 0.094326, 1.888603, 0.111634, 0.026563, -0.057334, 0.189292, -0.664106, -0.315775, -0.613243, 0.187819, 0.393232, -0.069210, -0.422327, 0.285052, 0.046223, -0.057490, 0.262467, 0.418776, 0.316641, 0.541758, 0.492726, 0.466294, 0.325028, 0.223909, -0.217418, 0.116255, 0.431785, 0.018517, -0.019880, 0.096873, 0.058370, -0.118475, -0.101195, -0.018657, 0.144764, 0.170003, 0.700359, 0.042243, 0.065347, 0.359792, 0.792744, -0.085951, 0.032167, -0.333711, -0.006318, 0.228857, -0.845728, -0.181277, 0.105909, -0.050762, 0.256130, -0.042741, -0.003579, -0.132295, -0.054551, -0.303730, 0.105795, 0.366679, -0.137266, -0.040501, 0.709339, 0.480213, 0.115457, 0.314419, 0.125353, 0.378449, 0.545214, 0.275715, -0.688746, -1.084709, -0.983834, -0.627246, 0.218125, 0.498914, 0.062915, 0.226900, 0.153530, -0.067809, 0.090819, 0.153925, 0.113330, -0.054422, -0.212091, 0.470640, 0.179763, -0.083196, 0.052102, 0.573917, 0.675484, -0.173431, -0.009315, 0.079842, 0.048576, -0.566252, 0.139756, -0.054740, 0.716237, -0.136814, 0.306096, 0.433789, 0.774673, -0.200298, -0.164508, -0.215041, -0.264039, -0.007854, -0.625747, -0.031932, 0.078458, -0.405991, -0.004774, -0.080325, -0.137341, -0.093023, -0.108653, -0.333091, -0.080794, 0.071059, -0.037690, -0.055989, 0.774504, 0.357431, -0.037098, 0.415897, 0.088574, -1.168470, 1.499373, -1.472909, 0.331930, 0.626532, -0.331393, 0.408297, -0.082745, 0.176525, 0.293670, -0.781485, 0.970503, -0.546018, 0.318911, 0.002463, -0.088523, 0.110841, -0.157135, -0.002744, -0.672558, -0.550353, 0.115977, -0.241926, -0.053776, 0.015179, -0.260361, 0.027183, -0.276602, -0.007639, 0.856427, 1.202592, 4.110242, 2.879752, 1.988388, 1.207764, 0.715226, 0.746434, 0.615466, 0.849294, 0.311468, 0.763928, 0.027725, 0.616669, 0.421733, 0.823402, 0.240661, 0.253700, 0.827703, 0.334135, 0.505385, 0.335799, 0.235235, -0.056837, 0.396023, 0.356626, 0.104107, -0.191251, -0.064543, 0.207868, 0.476009, 0.046831, 0.357895, -0.095033, -0.228045, -0.149018, -0.105311, -0.047365, -0.164731, -0.503045, -0.446195, 0.062128, -0.284897, 0.336413, -0.354020, 0.441369, -0.092404, -0.168832, -0.252196, -0.171072, -0.048790, -0.033351, 0.029915, 0.004401, 0.278658, -0.136516, 0.117175, -0.295494, 0.218948, -0.216092, 0.773598, 0.411288, 2.626107, 1.693337, 0.783147, 0.851971, 0.679353, 0.976043, 0.615139, 0.884548, 0.479524, 0.638312, 0.001236, 0.374310, -0.106012, 0.548130, -0.052658, -0.059604, 0.451744, 0.258169, 0.575153, 0.349960, -0.283677, -0.010322, 0.365752, 0.053575, 0.169606, 0.002061, -0.286877, 0.267976, -0.812131, 0.370014, 0.139411, -0.652521, 0.161109, 0.471739, 0.062103, -0.066021, -0.764078, -0.917545, -0.698428, -0.455384, 0.270989, -0.243603, 0.137853, 0.690305, 0.479218, 0.368801, 0.900057, 0.449307, 0.760268, 0.216718, 1.035822, 1.129576, 0.115683, -0.211034, -0.504313, 1.087173, -0.102925, 0.060411, -0.309834, -0.684345, -0.209576, -0.436715, -0.139010, -0.353613, 0.006182, -0.295667, -0.317373, -0.355747, -0.018803, 0.367441, -0.223255, -0.029501, -0.358594, -0.001023, 0.021834, -0.282321, -0.352850, 0.430223, 0.415507, 0.186104, -0.040877, 0.026179, 0.010090, -0.585191, -0.371154, -0.137004, -0.421930, -0.382699, -0.139417, -0.054707, -0.139945, -0.183446, -0.278617, 0.030681, 0.222876, 0.083069, 0.169251, -0.089931, -0.111557, -0.161294, -0.103559, 0.072163, 0.323928, -0.009074, 0.207068, -0.140844, -0.147182, 0.130478, 0.163891, 0.082875, -0.481936, -0.164799, 0.181551, -0.113963, -0.110350, 0.115878, 0.064334, 0.315157, -0.362797, -0.598338, -0.006939, -0.250908, 0.021674, -0.259870, 0.065358, -0.167256, -0.218708, -0.304514, 0.032516, 0.065886, -0.243541, -0.056561, -0.352379, -0.047794, -0.355930, -0.405665, -0.450816, 0.177419, 0.175045, 0.217172, 0.020458, 0.112085, -0.085342, -0.706191, -0.402256, -0.045732, -0.227877, -0.186132, -0.051458, -0.928109, -0.118136, 1.119279, 0.927139, 0.611519, 0.153410, -0.198010, -0.542857, -0.660588, -0.547547, -0.543296, -1.930939, 0.531907, -0.144618, -1.263777, 0.086628, -0.461151, -0.471114, -0.479073, 0.406075, 1.242559, 0.619319, 1.269677, 1.440953, 0.867316, 1.042266, 0.429092, 1.513387, 0.975447, -0.147108, -0.359510, -0.386835, -0.244416, -0.239765, -0.116746, -0.016173, 0.560964, 0.136330, -0.214358, -0.367133, 0.075192, 0.742610, -0.018002, 0.031603, 0.123276, -0.161406, -0.108827, -0.459691, -0.270237, -0.361604, -0.244598, -0.221762, 0.127583, -0.011171, -0.071170, 0.134564, 0.092886, 0.200516, 0.281865, 0.049975, -0.012490, -0.212892, -0.140857, 0.040235, 0.058388, -0.060689, 0.070026, 0.022277, -0.112825, -0.004415, 0.045583, -0.019979, 0.081457, -0.027104, 0.046406, 0.055564, 0.039991, 0.013306, -0.009095, 0.005232, 0.058741, 0.106973, -0.031956, -0.037919, 0.015866, -0.026432, 0.030540, -0.024158, 0.053914, -0.416819, -0.427537, -0.214542, -0.025686, -0.011758, -0.019512, 0.087864, 0.307534, -0.065042, -0.239841, -0.278934, 0.005796, 0.347301, 0.001522, 0.164304, 0.022800, -0.184481, 0.029146, -0.121692, -0.172896, -0.176565, -0.129618, -0.145352, 0.023403, 0.081144, -0.001115, 0.007219, 0.156308, 0.036304, 0.049162, -0.252962, 0.365636, -0.023660, -0.030233, -0.482256, 0.622066, 0.352496, 0.623957, 0.661817, 0.627532, 0.310459, 0.456019, 0.529647, -0.049741, 0.347178, 0.316087, 0.442700, -0.038195, 0.590946, 0.240406, -0.127207, -0.151051, -0.680797, -0.491026, -0.427604, -0.701575, -0.685960, -0.640621, -0.670852, -0.227640, -0.213250, 0.101443, -0.279413, 0.006731, -0.013774, -0.323034, -0.340891, -0.021177, 0.219060, 0.406973, -0.008059, 0.616296, 0.376992, -0.234504, 0.925145, 0.510243, -0.194407, 0.186497, 0.451699, 0.202108, -0.097968, 0.315765, -0.383624, 0.022998, -0.003832, -0.026046, 0.220472, -0.267699, 0.167652, 0.052927, 0.351114, -1.082522, 0.111917, 0.190472, 0.009898, -0.139556, 0.007278, 0.248373, 0.366189, -0.179170, -0.400674, -0.110672, -0.214103, 0.216643, 0.868208, 0.069925, -0.037419, 0.316292, 0.969531, 0.343389, -0.034146, 0.109843, -0.128142, 0.356681, -0.021371, -0.309471, 0.103978, -0.103555, -0.179819, 0.301120, 0.001789, 0.351046, -0.153902, 0.258727, -0.141455, 0.111953, -0.281926, 0.220610, 0.527308, 0.864654, 0.340622, 0.378252, 0.140990, -0.271972, 1.463377, 0.771117, -0.093822, 0.422257, 0.807276, 0.418610, 0.044432, 0.776073, -0.368277, -0.104241, 0.319793, 0.212696, 0.060940, -0.053959, 0.027729, 0.310214, 0.237359, -1.133935, 1.171344, 0.147148, -0.003377, 0.639440, 1.001015, -0.956378, -0.992112, -1.210287, -0.283664, -0.314646, 0.524514, -0.543500, 0.841661, 0.118137, -0.139815, 0.661031, 0.260096, 0.370044, 0.136041, 0.017492, 0.226965, -0.956580, -0.532733, -1.034496, -0.985662, -0.286255, -1.082899, -0.701574, -0.148432, -0.270939, 0.617779, 0.271312, 0.010740, 0.267765, 0.705846, -0.042742, -0.181346, 0.033522, -0.174814, -0.142605, -0.528659, 0.100717, -0.013791, -0.659524, -0.367602, 0.015137, 0.163190, 0.132645, 0.221492, 0.113560, 0.395067, -0.032166, -0.004198, -0.012259, -0.156882, 0.454795, 0.151613, 0.002312, 0.008688, 0.160248, 0.059682, 0.020570, 0.100930, 0.166025, -0.132376, -0.077785, 0.209699, 0.049603, -0.109832, -0.088583, 0.242610, 0.176640, 0.060117, -0.197804, -0.229497, -0.159485, -0.008943, -0.280307, -0.086409, 0.064692, -0.006526, -0.069656, 0.339443, 0.196968, -0.157966, -0.026867, -0.043782, 0.182368, -0.465750, -0.513773, 0.130924, 0.190538, -0.095796, 0.072070, 0.483377, -0.126267, -0.163483, 0.186339, -0.244384, -0.100218, -0.363604, 0.056714, -0.055235, -0.461549, -0.231132, -0.117526, -0.070829, -0.014660, -0.046933, -0.072334, 0.211347, -0.067337, -0.198955, -0.173700, -0.192841, 0.126830, 0.246843, -0.258614, 0.474842, 0.160996, -1.575635, -1.633657, -0.576913, -1.584219, -1.980465, 0.567659, -0.098719, -1.040262, -0.876743, -1.200359, 0.987449, -2.123584, -0.506035, 1.241230, -0.504173, -1.730275, 0.457524, -0.807307, -1.708243, -1.159152, 0.100157, -1.400686, -2.494280, 0.149706, -0.193762, -0.766988, -1.854641, -0.474011, -0.340853, -0.539380, -0.338309, -0.127370, -0.169599, 0.008493, -0.177316, -0.183990, -0.090184, -0.043742, 0.290908, -0.167908, -0.322914, 0.258383, -0.225597, -0.512606, -0.518486, -0.581185, -0.111604, -0.129414, -0.096050, -0.220414, -0.108335, -0.006735, 0.234217, -0.361107, -0.372433, 0.080700, -0.504703, -0.286942, -0.050942, 0.033273, 0.077029, 0.085547, -0.126173, -0.134234, 0.057565, -0.096135, 0.004018, -0.012110, 0.216986, 0.100245, -0.087553, 0.250728, -0.002589, 0.111611, -0.066255, -0.238603, 0.027859, 0.003715, -0.039472, -0.064764, -0.206583, 0.073510, 0.064866, -0.044538, -0.046648, -0.154433, 0.080978, 0.026954, -0.239014, -0.576268, -0.188337, -0.168899, -0.168804, -0.177071, -0.428768, -0.193954, -0.181479, -0.205140, -0.171151, -0.320942, -0.403878, 0.166696, -0.280965, -0.223689, -0.313034, -0.323701, -0.293826, -0.006376, -0.229802, -0.237911, 0.170195, -0.253251, -0.143786, -0.352202, -0.230565, 0.218538, -0.117424, -0.269246, 0.111798, 0.389915, 0.461832, 0.866724, -0.896226, -1.428337, -0.714314, 0.323145, -0.288223, -0.095516, 0.041984, 0.360509, -0.081801, 0.625230, 0.775946, -0.028656, 0.379241, -0.468721, 0.130328, 1.227687, 1.048308, 1.034715, 1.653168, 1.058005, 0.867114, 1.088309, 1.436139, 0.487791, 0.810408, 0.416119, 0.122520, 1.428254, -0.118954, -0.285441, 0.181989, -0.162508, -0.096266, 0.035994, 0.086177, -0.042902, -0.003959, 0.147109, -0.187016, 0.119480, 0.045814, 0.080146, 0.438916, -0.052999, -0.194146, 0.165041, -0.123543, -0.056108, -0.036600, 0.169335, 0.296554, -0.018542, 0.203838, 0.385840, 0.182238, 0.067443, 0.698996, -1.817209, -0.023946, 0.229198, 0.208207, 0.239220, 0.286673, 0.296741, 0.618766, -0.166877, -0.404915, 0.190078, -0.013846, 0.255717, 0.538738, -0.209151, 0.785408, 0.420509, 0.074016, 0.519697, 0.134587, 0.082555, -0.117155, -0.095017, 0.121082, -0.135140, -0.189739, -0.531243, -0.322174, -0.396930, 0.500427, 2.201868, 0.159521, -0.245026, 0.092464, -0.049143, 0.002355, 0.296617, 0.411806, -0.044335, 0.214840, 0.196321, -0.108273, 0.146758, 0.324997, 0.167132, 0.670360, 0.182395, 0.028840, 0.386586, -0.015522, 0.092991, 0.018332, 0.088161, 0.071431, -0.001079, 0.300349, 0.559820, 0.368555, 0.162992, -0.384456, 0.060988, -0.377925, 0.276293, 0.639197, 0.707648, 0.497675, 0.083600, 0.529966, 0.459772, 0.679776, 0.341649, -0.212261, 0.730177, 0.767905, 0.208691, 1.085063, 0.770093, -0.011739, -0.043930, -0.036005, 0.625184, -0.603679, -0.388073, 0.057324, -0.567278, -0.114229, -0.680038, 0.253494, 0.380048, 0.080217, 0.028597, -0.182056, -0.272073, 0.302847, -0.255078, -0.532216, 0.331301, 0.537652, -0.262994, 0.276674, -0.096507, 0.121925, -0.009829, -0.261817, -0.023275, 0.641037, -0.324197, -0.110661, 0.009702, -0.149637, 0.459398, -0.263444, 0.254792, 0.502352, 0.054468, 0.172935, 0.142519, 0.669293, 0.116936, -0.480197, 0.353670, -0.343901, -0.118154, 0.536810, 0.497524, 0.239321, -0.031465, -0.119044, 0.087191, 0.346924, 0.418706, 0.213212, 0.011737, -0.025063, -0.113961, -0.803062, -0.272363, 0.041641, -0.283877, -0.024236, -0.029851, 0.266716, 0.200355, 0.214549, 0.157631, -0.018938, 0.080962, -0.300593, -0.394875, 0.403749, 0.418578, -0.025738, -0.123918, 0.302151, -0.136851, -0.301630, 0.628911, 1.015853, -0.026610, 0.215542, 0.195622, 0.295308, -0.164267, -0.407319, 0.635599, 0.728051, -0.306046, 0.344101, 0.203832, -0.217424, 0.293554, -0.261607, 0.114129, 0.300823, -0.222275, 0.165983, 0.133069, 0.899066, -0.061474, -0.119650, 0.595271, -0.646665, -0.421826, -0.537785, -0.065197, -0.001127, -0.016431, -0.236120, 0.659300, 0.641626, 0.228468, 0.430748, 0.165668, -0.141455, 0.008977, 0.432356, 0.496677, -0.069130, 0.768991, 0.048145, 0.410895, 0.291520, 0.338283, 0.483038, 0.164028, 0.394756, -0.053013, 0.356195, -0.468621, 0.083231, -0.309600, -0.277506, -0.014992, 0.701731, -0.098316, -0.531289, -0.875060, 0.274358, 0.578665, -0.348011, 0.277245, -0.423229, 0.514315, -0.063588, 0.726091, -0.113865, 0.528615, -0.342741, 0.000840, -0.353577, -0.063650, 0.281423, -0.270197, 0.749405, -0.725783, -0.687178, 0.020273, 0.746081, -0.003340, 0.121584, -0.308945, 0.216109, 0.018441, 0.035617, 0.199296, -0.014807, -0.501155, -0.337622, -0.034073, 0.257278, 0.784277, 0.476385, -0.459057, -0.950645, -0.548255, 0.828631, 0.880051, -0.175579, -0.214560, -0.204419, 0.120852, 0.736789, -0.071304, -0.460082, 0.777153, 0.262329, -0.192541, -0.139538, 0.035216, 0.187896, -0.133958, -0.494100, 0.090309, 0.295496, -0.209373, -0.383992, -0.379226, 0.378439, 0.603221, -0.169176, 0.606711, -0.617864, 0.727157, -0.235282, 0.824059, 0.358694, 0.520721, -0.196899, 0.235498, 0.078520, 0.356640, 0.089876, -0.320178, 0.784399, -0.508922, -0.645511, -0.175460, 0.416033, -0.161166, 0.066634, 0.447461, 0.493740, 1.010647, -0.943951, -1.360281, -0.721510, -0.021317, -0.514539, 0.136924, -0.032868, 0.476329, -0.274057, 0.921912, 1.053839, -0.389276, 0.812554, -0.418655, 0.018942, 1.524214, 0.764276, 1.116711, 1.550415, 0.993163, 0.639406, 1.003119, 1.514497, 0.434882, 0.876950, 0.299895, 0.161349, 1.496410, -0.219286, 0.044325, -0.095992, -0.038963, 0.013828, -0.165222, -0.068881, -0.259851, -0.016964, -0.025813, -0.000369, 0.113228, 0.094228, 0.589025, 0.203889, 0.116192, 0.154698, 0.276264, -0.112059, 0.045745, 0.196584, 0.009321, 0.119462, -0.136321, 0.250538, 0.466638, 0.025322, -0.019871, -0.374761, 1.169488, 0.115928, -0.058114, -0.220297, -0.388948, -0.236293, -0.409468, -0.323607, -0.113147, 0.363634, 0.079800, 0.252078, 0.031635, -0.403446, 0.218427, -0.359369, -0.176864, -0.041930, -0.388224, -0.140653, -0.205579, -0.103805, -0.198343, 0.041314, 0.008636, 0.434284, 0.194558, 0.262322, 0.277158, 0.570939, 2.266581, -0.200261, -0.010779, -0.060807, 0.145482, 0.044969, 0.118916, -0.074492, -0.191075, 0.021907, -0.223851, 0.174809, 0.033005, 0.296316, 0.583629, 0.481831, 0.114819, 0.061711, 0.481057, -0.195557, -0.008165, 0.199863, -0.008491, 0.110140, 0.139275, 0.189772, 0.214142, 0.135556, -0.013674, 0.647848, -0.550366, -1.725726, -1.061042, -1.675586, -2.831463, -2.674484, -2.018069, -0.117260, -0.755518, -0.707321, 0.582762, -0.379096, -0.668186, 0.415805, 0.365360, -0.660277, 0.251301, 0.667766, -1.212252, 1.170388, -0.671743, 0.269091, -0.675780, -0.489606, 0.251215, 0.838962, -0.598736, -1.315916, 0.359044, -0.467956, -0.139656, -0.255254, 0.399688, -0.332328, -0.172585, 0.144448, 0.056686, -0.165808, -0.046455, 0.371904, 0.049766, 0.001561, 0.149824, -0.098191, -0.412602, 0.244267, 0.142530, -0.272029, -0.095460, -0.258030, -0.187111, -0.031712, -0.043536, 0.321990, -0.342822, 0.178270, 0.121470, 0.035936, -0.022878, -0.012890, 0.012607, 0.007763, -0.074221, 0.036082, -0.152932, -0.136014, 0.165957, 0.075191, -0.118348, -0.119901, -0.026690, -0.124375, 0.082322, 0.104687, 0.125931, -0.134186, -0.047572, -0.151857, 0.300983, 0.083518, -0.151097, -0.075006, 0.076778, -0.228412, -0.013312, 0.066215, 0.148928, 0.106058, -0.054988, -0.560287, -0.436754, -0.116764, 0.195662, -0.181815, -0.150055, 0.165322, -0.131690, -0.232570, -0.093431, 0.075139, 0.048763, 0.212697, -0.081879, -0.158082, -0.203682, -0.105710, 0.602648, -0.068724, -0.099464, 0.056291, 0.025254, 0.265639, 0.040561, 0.106207, -0.091245, 0.216374, -0.000849, -0.149475, -0.003241, 0.338767, 0.459203, -0.862060, -0.449605, -0.691088, -0.063666, -0.064814, -0.408227, -0.465777, 0.748919, 0.186484, -0.244668, 0.171576, 0.645439, 0.302917, 0.260393, 0.670305, 0.291912, -0.050208, 0.580357, 0.006949, 0.384859, 0.009599, 0.424393, 0.648548, 0.420866, 0.366598, 0.039369, 0.350283, -0.134503, 0.185590, 0.028377, 0.213928, -0.029681, -0.178882, 0.092513, -0.061784, -0.103046, -0.276914, -0.278522, 0.327974, 0.316557, -0.022828, -0.391255, 0.044404, -0.104206, -0.409776, 0.286148, 0.000320, 0.479054, -0.008504, 0.716739, -0.214296, -0.369443, 0.194201, 0.008739, 0.499849, -0.133992, -0.251351, 0.512005, -0.037857, -0.034915, -0.250865, -0.084496, 0.622599, 0.323398, 0.151021, -0.433587, -0.260164, 0.101953, 0.288364, -0.062955, -0.469330, -0.054830, 0.273798, 0.037750, 0.126777, 0.324801, -0.142743, -0.020567, -0.318549, -0.278513, -0.016749, 0.288931, 0.142676, -0.182131, -0.183599, 0.250091, 0.221174, 0.060346, 0.289152, 0.069517, 0.614167, -0.129545, -0.095344, 0.087332, -0.272557, -0.110821, -0.055431, -0.264261, 0.572936, 0.224570, 0.056547, -0.270080, 0.131211, -0.079952, -0.328470, 0.271050, -0.101154, 0.592913, 0.192321, 0.799893, -0.182477, -0.227162, 0.053179, 0.004127, 0.453624, -0.112511, -0.266482, 0.184898, -0.485550, -0.010937, -0.233509, 0.293631, 0.703513, 0.793043, 0.569468, 0.239986, 0.690914, 0.338882, 0.775448, 0.353254, -0.624660, 0.744113, 0.677322, 0.145561, 1.179304, 0.932744, 0.133070, -0.016344, 0.124092, 0.706423, -0.510823, -0.262010, 0.317574, -0.551771, 0.176212, -0.464541, 0.575381, 0.927286, 0.131021, 0.125575, -0.237142, -0.202248, -0.006068, 0.244012, -0.047889, -0.186957, -0.171671, 0.043515, -0.322174, -0.290876, 0.160747, -0.312977, -0.284626, 0.244975, -0.300752, -0.456446, -0.222119, -0.380556, -0.015214, -0.152452, -0.238688, 0.078553, -0.063459, 0.119209, 0.063914, 0.250816, 0.235737, 0.174774, -0.283564, 0.370445, 0.125494, -0.117640, -0.080118, -0.200624, -0.064061, -0.326163, -0.286534, 0.173394, 0.084323, -0.228940, -0.033001, -0.064790, -0.053504, 0.373261, 0.125994, 0.120470, 0.010492, -0.029804, 0.132301, 0.017212, 0.081372, -0.198784, -0.133255, 0.111324, 0.059906, -0.043770, -0.360935, 0.120992, 0.579861, 0.529929, -0.270301, -0.035384, 0.112045, 0.641748, 0.226251, 0.079383, 0.047242, 0.175564, -0.269418, -0.286498, 0.330799, -0.192526, -0.157452, 0.612593, -0.179438, -0.264633, -0.041988, -0.218867, -0.211556, -0.294856, -0.317971, -0.002300, -0.278076, 0.146312, 0.030840, 0.037650, -0.026188, 0.054653, 0.382176, -0.823394, 0.728750, 0.950294, 1.043492, 0.681724, 0.911743, 0.256139, 1.218084, -1.079150, -0.098973, -1.126881, -0.872899, 0.303819, 0.132983, -0.323522, -0.129519, -0.088926, -0.370450, 0.333808, 0.404593, -0.034774, -0.204423, -0.808749, 0.278153, -0.031903, -0.304587, -0.293921, -0.378004, -0.425303, -0.054306, 0.058609, 0.157623, 0.063969, 0.069794, -0.122300, -0.358945, -0.159814, 0.515946, 0.060508, -0.023758, -0.152185, 0.426222, 0.253830, 0.476100, -0.107547, -0.013084, 0.410608, 0.183374, -0.177026, 0.232672, -0.309748, 0.294092, -0.813002, 0.250735, 0.008610, 0.251237, 0.101728, -0.018806, 0.007360, -0.020003, 0.049218, 0.062093, -0.018676, -0.120615, 0.077308, 0.030358, 0.377362, -0.012650, -0.229683, -0.075810, 0.198015, 0.282792, -0.198739, 0.159795, 0.324190, -0.064474, 0.044744, -0.059627, 0.058837, 0.432116, 0.073321, -0.344217, -0.237168, -0.625517, -0.175804, -0.152786, 0.179234, -0.022450, 0.140126, -0.289802, -0.533071, 0.018409, -0.194846, 0.006141, -0.149273, -0.329653, -0.269906, 0.162231, -0.049084, 0.011288, -0.006121, 0.008087, 0.236980, 0.247785, -0.162684, -0.252721, -0.095772, 0.193717, -0.443195, -0.180063, -0.451384, 0.238742, -0.354950, 0.062426, 0.206239, -0.054386, 0.034672, -0.240724, -0.060737, 0.168269, -0.858637, 0.719456, 0.569635, 0.509680, 0.585504, 0.689640, -0.508864, 0.324547, -1.028046, 0.185668, 0.327497, 0.004521, 0.508388, 0.841720, 0.325022, 0.281348, 0.583815, 0.594827, 0.057726, 0.297712, -0.344506, -0.202444, -0.975705, 0.016522, -0.378002, -0.432456, 0.126509, -0.065714, 0.448701, -0.141067, 0.026036, -0.175225, -0.088146, -0.022673, -0.226512, -0.295788, 0.032159, -0.033858, -0.057747, 0.334837, 0.233137, -0.177892, -0.155644, 0.315983, -0.202796, 0.059599, 0.005511, -0.067783, 0.005160, 0.128530, 0.168083, 0.231150, 0.195160, 0.187664, 0.341592, -0.422188, 0.126722, -0.096998, 0.180314, -0.023132, -0.279772, -0.247665, 0.149864, 0.316481, 0.216557, -0.009272, -0.143701, 0.046171, -0.054230, -0.285835, -0.014245, 0.216179, -0.246576, -0.115806, 0.248991, 0.229059, 0.291522, 0.095796, -0.210346, -0.392697, 0.240526, 0.451223, 0.058552, 0.041167, -0.412941, -0.155821, 0.219494, -0.041268, 0.231380, -0.287315, -0.398469, -0.361996, -0.070245, -0.130800, -0.245021, -0.406976, -0.198403, -0.150590, -0.239608, 0.062026, 0.307518, -0.208613, -0.096680, 0.212421, -0.152659, -0.159018, -0.069551, -0.151107, -0.303114, -0.017125, -0.021627, -0.106167, 0.207427, -0.019400, 0.369541, -0.403272, -0.116054, -0.103076, 0.130423, 0.897445, 0.100509, -0.204080, -0.755023, -0.607357, 0.275587, -0.592091, 0.144355, 0.577513, -0.169128, 0.347104, -1.629825, 1.681138, -2.314392, 0.520716, 1.119254, -2.000755, -1.353700, -1.575654, -1.428117, -0.456257, -2.554734, -2.188229, -1.342739, -2.726799, -1.566025, -1.247733, -0.955795, -1.293597, -1.761476, -0.500554, -0.873628, -0.143577, -0.406925, -0.467841, -0.243485, 0.003993, -0.304252, 0.122885, -0.183503, -0.154831, -0.056171, -0.280625, 0.014604, -0.462341, -0.172701, -0.399119, -0.352442, -0.441976, 0.022006, -0.339147, 0.094439, -0.598353, -0.374867, 0.079751, 0.417776, 0.034745, -0.394844, -0.172505, -0.362369, 0.141047, 0.147663, -0.178349, -0.132563, -0.049873, -0.178848, -0.330541, 0.157456, -0.090067, 0.159059, 0.363840, 0.102762, 0.093410, 0.173489, -0.093644, 0.111981, -0.237991, 0.012653, 0.238974, 0.007543, -0.084055, -0.109710, -0.359536, -0.086557, 0.186791, 0.280812, -0.173502, -0.057654, 0.281152, 0.083074, -0.515676, -0.782382, -0.129837, -0.205143, -0.386645, -0.242332, -0.011548, -0.121006, 0.009461, -0.092669, -0.162014, 0.106001, -0.392329, 0.138002, -0.171791, -0.052840, -0.234192, -0.362601, -0.533984, -0.186607, -0.327984, 0.136953, -0.195473, -0.289385, 0.170399, 0.593195, 0.429333, -0.244774, 0.135654, -0.309745, 7.399549, -3.355230, -2.809793, -2.885543, -3.023040, -1.334095, -1.236853, -1.952317, -2.881675, -0.617745, -0.884568, -1.601089, -0.199368, -0.315002, -0.033910, -0.059008, -0.160202, -0.427406, -0.573290, 0.406646, 0.060088, 0.211083, -0.222286, 0.006700, 0.008200, 0.331007, -0.109049, -0.099492, -0.580580, -0.925678, 3.314092, 2.400743, 2.697243, 2.011895, 1.561005, 1.250129, 0.736168, 0.600890, 0.515056, 0.113957, -0.053030, -0.500522, -0.148158, -0.556035, -0.530768, -0.461735, -0.822440, -0.729979, -0.792788, -0.889217, -0.858347, -1.199759, -1.044926, -1.289388, -1.338491, -1.020981, -1.184664, -0.973813, -1.135004, -0.928563, -0.125761, -0.041908, 0.447912, 0.561259, -0.119706, -0.017263, -0.385213, 0.107136, 0.098399, 0.116013, 0.210055, -0.253622, -0.337611, -0.055754, -0.180325, -0.223618, 0.069872, -0.067446, 0.153821, -0.131045, 0.098468, 0.067619, 0.006466, 0.284345, 0.135843, -0.233104, 0.288990, 0.139698, 0.034131, 0.053219, 1.811001, 1.059947, 1.953543, 1.341991, 0.891186, 0.958770, 0.527481, 0.451280, 0.491868, 0.337848, 0.111716, -0.262657, 0.271348, -0.008645, -0.302219, -0.191700, -0.214780, -0.080461, -0.247864, -0.388893, -0.421490, -0.330068, -0.291883, -0.699177, -0.938585, -0.379796, -0.696039, -0.376950, -0.619707, -0.590964, -0.672173, 1.134485, -0.321072, -1.346603, 0.188451, -0.364711, -0.005563, 0.774026, 0.577860, 0.513668, 0.086878, 0.564493, 0.960452, -0.535788, -1.770130, -0.599121, -1.088674, -0.768145, 0.052097, -0.033018, -1.408224, -0.361191, -0.802145, 0.484609, -0.135084, 0.106237, -0.119800, 0.876563, -0.372195, -0.025430, -0.388021, -0.706878, -0.401551, -0.260575, -0.310001, -0.642828, -0.178002, -0.693640, -0.546588, -0.492497, -0.135063, -0.131244, 0.254751, 0.041511, -0.010361, 0.248298, -0.042598, 0.401653, -0.006066, -0.336137, -0.255120, -0.347547, -0.109458, -0.290049, -0.533250, -0.074385, -0.634188, -0.038473, 0.085549, -0.286303, 0.074740, 0.146940, 0.378750, 0.120818, -0.158780, -0.150785, -0.240098, -0.040103, -0.158449, -0.084045, -0.202686, -0.085939, 0.151790, 0.358516, 0.045323, 0.028598, 0.010880, -0.239571, -0.186265, -0.139969, -0.163284, 0.110821, 0.380439, -0.022230, -0.094639, -0.258326, -0.026412, 0.095673, -0.085761, 0.188303, -0.468253, -0.560539, -0.265608, -0.000097, -0.193656, -0.573489, 0.123236, -0.641603, -0.567772, -0.564207, -0.206115, -0.049168, 0.094283, -0.060764, -0.040938, 0.028899, 0.044366, 0.375847, 0.007955, -0.119768, 0.053561, -0.123238, -0.095013, -0.193043, -0.066443, 0.053735, -0.582054, 0.191509, 0.084187, -0.014038, 0.940725, 1.220495, 1.232390, -0.295503, -1.267096, -1.227303, -1.491880, -0.164357, 0.959553, 0.857332, 0.546681, 2.128776, -1.358556, 0.967249, -1.307902, 0.117563, -1.065215, -0.242338, -0.191837, -0.720721, -0.839425, -1.008653, -0.416122, -0.196779, 0.531729, 0.005084, -1.110294, -0.439656, -0.040984, -0.447512, 0.109775, 0.416362, 1.578858, 1.907755, 0.725895, 1.538460, 1.495292, 1.205949, 1.564305, 1.420243, 1.406591, 0.897112, 1.201198, 0.876968, 0.555413, 0.776228, 1.226345, 1.248398, 1.312840, 1.569847, 1.338745, 1.293046, 1.288528, 0.821854, 0.839527, 0.605246, 0.680559, 0.368348, 0.391661, 0.327205, 0.061902, -0.191857, -0.526097, -0.077880, 0.063531, -0.257078, 0.214680, 0.241603, 0.155930, -0.203037, -0.096905, 0.067402, -0.007472, -0.112366, -0.026276, 0.404236, -0.227058, -0.000383, -0.214098, 0.186572, 0.031634, 0.037093, 0.219946, -0.095807, 0.183802, 0.565487, 0.277146, 0.048610, 0.051839, 0.159850, 0.104796, 0.060425, 0.867098, 1.309354, 1.115065, 1.327650, 1.548320, 1.494063, 0.930809, 0.883970, 1.037304, 0.579923, 0.828982, 0.591392, 0.223848, 0.520252, 0.611780, 0.800406, 0.861671, 0.766700, 1.115238, 1.035724, 0.912948, 0.601456, 0.749721, 0.554416, 0.747696, 0.245812, 0.546715, 0.437785, -0.794654, 0.704743, 0.486434, -0.156367, 0.688913, 0.856848, 0.190249, -0.008870, -1.166681, -0.930575, -0.595375, -0.778431, 0.162597, -0.381353, -0.095293, 0.340616, -0.035074, -0.361173, 0.566355, -0.008456, 0.238260, -0.359812, 0.471883, 0.215688, -0.687252, -1.012022, -0.933446, -0.564253, -0.642725, -0.657811, -0.425690, -0.868183, -0.566475, -0.297620, -0.292522, -0.285590, -0.382936, -0.057220, -0.347492, 0.083082, -0.191960, 0.213304, -0.365648, -0.141930, -0.048697, 0.089348, 0.346197, 0.674194, 0.347626, 0.837572, 0.515756, 0.067061, -0.065289, -0.107688, -0.326966, 0.107894, -0.085109, -0.431055, -0.091871, 0.118680, 0.157081, -0.088032, -0.027616, 0.065535, 0.049572, -0.042983, -0.160696, -0.304303, -0.263133, 0.080515, 0.136779, -0.126624, 0.019726, 0.097358, 0.064655, 0.037029, -0.023801, -0.044906, 0.145792, 0.111486, -0.083664, -0.179522, 0.160619, 0.153413, -0.093852, -0.097208, 0.217104, -0.020940, -0.433229, -0.009589, -0.449247, -0.664313, -0.468630, -0.296736, -0.140821, -0.260489, -0.267052, 0.007360, -0.153067, -0.002457, -0.131585, 0.032922, -0.178270, -0.207619, 0.152372, -0.165778, -0.126411, 0.266318, -0.103656, 0.354450, 0.144144, -0.230734, -0.153431, 0.097284, -0.457750, -0.288578, -0.062220, -0.340548, 0.066301, 0.110533, -0.467164, 0.011790, -0.248302, 0.298451, 0.774714, 0.788402, 0.711082, 0.482893, 0.779887, 0.378252, 0.564818, 0.246761, -0.542539, 0.655295, 0.782586, 0.172691, 1.117677, 0.644630, 0.116496, 0.008253, -0.120229, 0.595498, -0.438687, -0.301549, 0.186696, -0.580820, 0.013461, -0.473918, 0.608010, 0.610951, 0.058448, 0.360153, 0.220525, -0.087222, -0.075221, 0.184693, -0.014898, 0.065964, 0.312066, 0.325891, 0.007202, -0.282642, 0.427805, 0.117204, -0.289106, 0.473002, -0.112006, 0.119240, -0.191719, -0.180804, -0.184473, 0.103109, 0.384997, -0.086356, 0.189014, -0.071578, 0.152304, 0.136575, 0.542379, 0.372660, 0.646261, -1.347009, 0.079797, 0.397645, 0.049911, 0.061749, -0.006409, 0.184609, 0.373682, -0.287313, -0.181053, 0.180536, -0.421731, -0.031501, -0.059500, -0.696023, 0.268611, -0.028207, -0.007040, 0.324133, -0.288065, 0.193502, -0.207902, 0.213265, 0.314519, -0.273042, 0.251831, 0.057889, 0.166986, 0.083002, 0.476625, 0.883590, 0.319676, -0.036321, -0.013905, 0.543337, 0.244400, 0.161938, 0.686096, 0.350800, 0.215743, -0.230033, 0.653590, 0.263775, -0.229569, 0.919735, 0.060828, 0.083969, -0.068220, -0.147121, -0.068606, 0.153100, 0.195976, -0.059173, 0.066007, 0.014120, 0.280135, -0.169696, 0.443617, 0.235956, -0.777576, 1.032348, -0.361614, -1.011141, 0.038449, -0.149594, 0.066412, 0.628398, 0.606196, 1.036070, 0.056221, 0.328561, 0.977285, -0.622131, -1.706331, -1.035196, -0.851328, -0.378707, 0.482528, -0.452890, -1.307250, -0.616785, -0.892089, 0.597116, -0.189730, 0.246124, -0.076383, 0.996604, -0.118681, 0.241018, -0.411339, -0.510318, -0.158493, -0.167484, -0.457118, 0.062780, 0.053208, -0.077484, -0.354533, 0.269742, -0.205717, -0.341045, 0.115323, 0.111566, 0.539816, 0.489542, 0.017947, -0.074810, 0.112628, 0.167139, 0.141105, -0.016203, -0.522537, 0.155904, -0.323935, 0.294568, -0.148631, -0.571366, -0.337224, -0.105011, 0.053370, 0.159029, -0.060299, -0.100267, -0.192719, 0.073427, 0.521631, 0.068772, -0.171206, -0.073918, 0.098801, 0.142745, -0.072724, -0.378690, -0.437997, -0.107025, 0.105749, -0.123658, 0.046563, 0.024428, 0.135290, -0.237737, 0.064107, 0.332928, 0.019436, -0.205179, -0.235398, -0.338238, 0.155763, 0.115469, -0.469786, -0.519025, 0.068286, -0.160572, -0.144171, 0.120182, 0.179752, -0.214618, -0.447858, 0.259017, -0.552785, -0.429021, 0.303130, -0.011631, 0.194212, 0.278164, 0.047860, -0.013614, -0.211447, 0.441356, 0.389192, 0.183216, -0.212419, 0.110199, -0.177016, 0.392491, 0.079044, -0.321187, -0.230361, 0.157895, 0.328416, -0.939017, -0.220540, 0.590669, 0.222539, 0.154328, 0.005528, -0.395112, -0.476493, -0.765323, -0.036556, 0.171259, -0.347160, 0.707935, 1.196146, 0.285550, 0.494527, 0.558289, 0.095085, 0.293693, 0.314704, 0.451402, -0.089202, 0.039272, 0.071921, 0.227470, 0.389613, -0.028205, 0.524765, 0.400398, -0.077491, -0.202529, -0.180616, -0.056332, -0.359822, -0.036475, -0.337146, 0.196514, -0.115430, 0.399952, 1.132472, 0.444968, -0.384327, -0.042487, 0.012992, 0.146215, 0.197234, 0.343207, -0.238187, -0.232135, 0.682202, -0.557884, 0.695383, 0.526125, -0.140691, -0.073956, 0.039845, 0.050456, 0.006949, -0.203645, 0.123342, -0.027084, -0.277969, -0.645068, 0.067669, 0.607956, 0.167014, -0.076123, -0.499657, 0.241408, 0.376727, -0.073516, -0.004854, 0.214075, -0.101690, -0.037792, 0.169191, 0.091360, 0.020480, -0.339966, -0.104225, 0.086094, -0.113866, -0.230500, 0.331500, 0.152112, -0.005064, 0.130273, 0.005525, 0.015701, -0.214003, -0.344027, -0.413913, -0.070646, -0.587012, -0.361017, -0.487011, 0.041726, -0.219729, 0.496798, 0.543615, 0.410344, -0.469439, -0.290288, 0.018134, -0.045800, 0.285643, 0.387970, -0.202500, -0.262428, 0.682463, -0.600665, 0.734998, 0.632080, -0.239977, -0.049636, -0.117906, -0.097738, -0.242256, -0.024921, 0.414924, 0.778306, 1.373172, 0.765401, 0.147144, -0.317627, -0.227437, 0.417686, 0.135898, 0.179849, -0.507942, 1.515671, -0.251614, 0.047528, -1.159378, -0.817837, -0.676890, -0.271825, -0.027060, -0.116804, -0.478714, -0.681105, -0.410592, -0.654753, 0.345012, 0.313187, -0.822215, -0.244155, -0.108674, -0.268445, -0.118407, 0.374611, 0.581321, 0.465279, 0.202308, 0.235267, 0.331347, -0.005185, -0.106430, -0.013706, 0.681239, 0.122752, 0.203368, -0.023801, 0.327226, 0.121942, 0.585898, 0.753477, 0.996902, 0.850170, 1.085675, 0.682633, 0.258477, 0.135162, -0.090008, 0.050703, -0.000995, -0.237268, -0.052728, -0.220746, 0.015452, -0.036629, 0.059621, -0.106367, -0.060233, -0.035900, 0.097497, -0.000739, -0.064963, 0.073323, 0.036858, -0.067553, 0.009022, -0.052695, -0.101830, -0.004351, -0.032560, -0.041254, 0.011207, -0.027974, -0.297733, -0.148470, 0.059240, 0.069410, 0.059198, 0.059692, 0.090052, -0.052057, -0.012582, 0.105660, -0.293947, -0.226140, 0.200181, 0.226536, 0.168250, -0.036890, -0.006303, 0.037434, -0.231732, -0.064123, 0.274047, -0.192685, 0.098694, 0.046352, -0.049332, -0.080538, -0.015489, 0.318173, 0.491969, 0.531229, 0.543408, 0.241449, 0.104485, 0.154062, 0.031167, 0.095411, -0.090298, 0.000440, -0.028784, -0.276642, 2.651414, -0.217059, -1.467598, -0.817831, -1.122367, -0.410411, -0.727669, -1.303265, -1.354035, -0.429711, -0.553338, -1.294885, 0.222297, -0.195107, 0.216195, 0.038110, 0.054903, -0.457970, 0.112636, 0.365703, -0.128331, 0.356805, -0.244206, -0.334422, 0.068304, -0.068220, -0.059030, -0.485539, -0.271760, -0.756747, 7.344311, 2.840245, 2.311708, 2.900601, 2.046100, 0.854618, 0.653410, 0.703602, 0.510064, -0.055591, 0.011660, 0.634968, -0.434795, 0.159868, -0.188199, 0.003297, 0.020885, 0.006808, -0.196191, -0.804205, -0.527176, -0.346637, -0.103055, -0.518247, -0.318450, -0.489223, 0.104276, -0.824448, -0.415959, -0.299600, -6.417687, 1.219149, 1.142970, 1.874449, 1.315851, 1.025016, 0.926544, 0.825741, 0.949275, 0.776480, 0.685588, 0.410395, 0.555750, 0.611815, 0.067115, 0.325469, 0.222921, 0.638776, 0.395800, 0.096382, -0.050659, 0.098931, 0.262963, 0.346835, 0.137783, -0.263717, 0.282533, -0.023610, -0.098360, -0.018439, 7.475041, 1.940191, 2.084260, 2.455263, 1.711413, 0.666047, 0.526242, 0.651931, 0.353353, -0.077267, 0.303419, 0.872158, 0.147522, 0.330431, 0.074493, 0.060512, -0.024867, 0.581959, 0.116551, -0.371685, -0.214437, 0.083326, 0.162817, -0.038515, -0.017804, -0.330728, 0.095939, -0.670007, -0.139172, 0.078956, 0.867933, -4.306603, 4.717991, -2.245493, 1.092604, 0.653754, -1.114871, 1.570826, -4.495703, 0.781348, -1.092909, 1.296547, 1.826304, 0.185285, 0.660922, 1.000769, -1.724594, 1.502952, -3.019372, 1.932153, -1.607917, 0.364511, 2.213095, -1.784164, 1.419648, -2.428983, -1.920048, 2.901196, -5.075456, 5.490023, 0.345444, 2.350083, 2.807697, 1.645817, 1.169564, 0.499884, 2.326711, 2.657993, 4.045272, -0.970299, 0.336465, 1.779138, 0.708090, 0.814761, 0.423272, -0.515969, -0.893913, -0.751567, 2.316511, 0.423845, 1.310731, 0.565810, 1.601544, -0.393170, 0.458535, -0.783656, 0.626740, 0.990542, 3.299644, 2.166984, 0.235511, 0.741049, 0.428142, 0.080236, 0.286393, -0.653886, -0.777020, -1.394683, 1.033712, 0.716263, -1.035365, 0.215576, -0.888663, -0.113696, -0.099355, 0.378262, 0.182986, 0.468792, 0.366674, 1.220912, 0.621435, -0.227859, 2.133604, 1.591985, -0.106613, 0.548361, 0.115039, 0.670729, -0.631216, 1.141808, 0.499797, 1.285833, 2.116987, 1.117378, 0.044727, -0.243269, 0.443798, 1.878033, 3.240790, -0.792440, 0.601212, 2.637850, -0.329301, -0.306611, 0.500010, 0.694042, -1.121711, -1.478937, 1.903516, 0.885832, 0.364856, 0.338977, 3.116029, -0.038796, 0.163474, -1.082249, 0.983278, 1.286386, 3.595088, 1.406405, 0.170679, 1.151698, 1.160362, 0.342789, -0.528726, 0.105683, 0.008409, -0.291456, 0.581832, -0.007832, -0.423222, 1.122702, -0.131874, -0.090811, -1.144944, -1.204853, -0.042483, 0.194742, 0.179094, 0.434978, -0.321224, -1.066762, 0.118032, 0.054946, 0.482134, 0.768087, -0.447327, -0.044565, 0.503044, -0.298580, -0.046595, 0.042502, -0.026892, 0.018068, -0.173860, 0.578283, -0.022632, -0.513961, -0.092649, -0.124776, -0.053461, 0.062120, 0.070711, -0.525040, 0.114691, 0.168089, 0.175497, 0.134582, -0.005729, 0.129695, 0.397470, 0.085166, 0.079402, -0.133707, -0.084447, -0.099896, 0.147959, 0.340369, 0.850200, 0.334290, -0.010540, -0.051253, 0.015335, -0.082106, 0.036049, 0.220577, 0.150207, -0.103007, -0.117377, -0.311428, -0.014588, 0.256663, 0.041167, 0.006827, 0.076308, -0.026955, 0.011585, -0.142304, -0.071970, -0.008121, 0.149333, 0.118895, -0.109398, 0.002731, -0.142742, 0.031964, -0.042677, 0.106147, -0.022315, -0.123292, -0.260523, -0.350041, -0.303920, -0.267480, -0.240596, 0.112466, -0.266554, -0.386352, -0.229933, -0.082156, -0.171905, -0.063149, 0.061469, -0.185319, -0.137045, -0.218606, -0.091935, -0.116756, -0.185795, 0.014196, 0.177904, -0.172905, -0.121761, -0.262196, -0.270145, -0.200373, -0.036913, 0.212126, 0.401958, 0.326010, 0.432388, -0.904706, 0.625472, 1.284436, 1.192391, 0.139946, 1.077021, 1.685675, 1.036511, -0.384986, -1.477266, -0.146638, -0.553021, -1.207256, 0.276712, -0.765730, 0.325447, -0.731118, 1.167529, -0.412935, 0.804411, 0.083463, 0.309371, 0.812222, 0.334520, 0.890918, -0.283426, 0.473638, 0.006569, 0.231900, 0.055031, -0.205758, -0.145868, -0.284300, 0.200193, -0.192871, -0.048107, 0.189422, -0.183130, 0.145543, -0.108808, -0.025771, 0.144724, 0.261333, 0.599786, 0.583473, -0.082773, -0.006869, -0.008522, -0.260228, -0.199131, -0.129814, -0.250624, -0.109080, 0.000995, 0.207168, 0.108837, -0.427530, 0.039789, 0.103093, 0.027943, 0.076375, 0.042451, 0.214616, -0.042948, -0.176346, -0.171015, 0.028304, 0.081457, 0.086172, 0.043598, -0.012498, 0.016606, 0.015376, 0.259129, 0.153950, 0.118439, 0.133886, -0.141419, -0.156768, -0.111781, -0.308560, 0.038571, 0.065904, -0.152670, -0.086740, -0.176522, 0.022239, -0.108666, 0.062124, -0.329918, -0.465949, -0.078582, -0.147336, -0.189098, -0.254689, -0.074640, 0.040599, -0.054195, 0.117030, 0.313204, 0.181791, -0.012101, 0.001761, 0.035648, 0.182542, -0.213981, -0.110779, -0.038949, -0.249363, -0.113292, 0.046151, -0.063200, 0.096500, 0.129757, 0.086504, 0.019014, -0.277991, -0.040415, 0.008869, -0.556803, 0.895731, 0.059782, -0.444666, 0.782141, -1.182308, -1.507646, -0.302059, 0.018968, 0.258564, 0.732937, -0.833720, 0.307012, -0.328857, -1.481838, 0.653680, -1.309598, -1.168818, -1.355505, -0.094411, -0.514238, 0.762549, -0.185281, 0.674615, -0.266264, -0.433870, -0.396621, 0.407196, -0.908893, -0.379409, -0.421866, -0.517905, -0.206363, -0.278170, -0.060153, -0.275321, -0.310452, -0.179509, -0.122154, -0.274076, -0.036016, 0.160079, -0.116551, 0.151084, -0.038595, -0.160044, -0.066746, -0.215317, 0.225247, -0.257692, 0.003327, -0.377353, -0.275610, -0.425780, -0.252457, 0.003800, -0.229338, -0.288886, -0.319065, -0.225478, 0.043324, -0.057331, 0.108520, 0.005862, 0.110210, 0.032018, -0.007760, -0.047515, 0.007718, 0.137204, 0.041638, 0.048336, 0.006120, -0.177059, -0.139923, 0.026109, -0.040928, 0.050161, -0.110929, -0.145052, 0.107095, -0.011323, -0.014928, -0.096468, -0.042673, 0.140274, 0.050959, -0.071222, 0.010172, -0.056041, -0.443543, -0.576011, 0.011719, -0.074806, 0.041823, -0.202479, -0.361561, -0.267963, -0.147493, -0.167233, -0.193668, 0.018581, -0.148543, 0.172617, -0.119587, -0.062099, 0.091918, -0.112597, 0.233540, -0.480099, 0.301515, -0.190708, -0.204580, -0.196642, -0.130261, -0.069254, -0.067047, -0.108186, -0.121098, -0.237319, -0.309131, -0.343603, -0.459912, -0.337547, 0.348328, 0.121626, -0.068249, -0.180060, -0.686894, 0.777947, 0.515784, -0.372817, -0.198920, -0.898807, -1.166806, -1.140920, -0.621282, -0.181102, -0.687232, 0.155321, -0.298918, -0.211967, -0.558810, 0.527957, 0.273575, 0.719465, 0.707274, 0.530585, 0.316655, -0.113881, 0.117660, 0.125079, -0.050616, -0.055973, 0.545904, 0.736827, 0.300188, -0.202810, -0.126852, -0.114887, -0.049894, -0.091617, -0.301228, -0.323420, -0.204743, -0.177467, -0.238971, 0.000891, -0.194306, -0.100937, -0.101522, 0.112928, 0.124061, 0.106973, -0.076531, 0.312785, -0.190637, -0.026632, 0.171585, -0.354942, 0.094730, 0.107040, -0.237535, -0.076587, -0.093405, 0.004029, -0.005241, 0.051398, 0.061213, 0.007424, -0.010941, 0.004482, -0.127948, 0.024899, -0.047403, 0.033243, 0.009327, 0.327499, 0.114946, -0.069922, 0.011906, -0.050534, -0.059418, -0.054071, 0.012426, 0.056177, -0.032803, -0.059181, 0.115121, -0.096999, 0.510051, 0.498980, 0.120427, 0.127592, 0.118932, 0.462424, -0.103990, -0.235835, -0.050716, -0.199281, 0.281521, -0.017774, -0.132384, -0.245399, -0.151351, -0.299025, 0.079484, 0.124925, 0.164930, 0.177743, 0.176257, 0.219520, 0.092872, 0.103513, 0.104526, 0.399599, 0.016919, -0.012701, 0.190440, -0.331673, 0.416060, -0.946864, 0.695219, 1.138504, 1.097021, 0.609883, 0.881326, 0.404467, 0.848762, -1.153603, 0.023017, -1.009983, -0.885148, 0.469704, 0.098093, -0.315017, -0.176409, 0.137907, -0.262168, 0.076528, 0.353507, -0.041632, -0.089403, -0.705282, 0.342717, -0.000922, -0.454315, -0.069967, -0.269145, -0.645955, -0.149693, 0.125860, -0.085641, 0.000698, -0.166612, 0.010826, -0.407129, -0.268915, -0.063471, 0.284394, -0.350530, -0.303728, 0.011713, 0.051159, -0.011352, 0.026788, 0.399165, 0.145571, 0.003913, 0.252855, 0.131076, -0.327555, -0.039032, -0.220394, 0.106534, -0.506830, -0.596160, -0.111645, 0.000406, 0.142247, 0.106828, -0.180308, -0.066360, 0.089280, 0.097597, -0.006904, 0.082640, -0.106527, -0.196213, 0.074580, 0.121257, 0.023658, -0.097218, -0.188037, -0.043032, -0.321205, -0.334094, 0.039594, 0.287419, 0.140833, 0.006619, 0.098438, -0.081643, -0.073552, 0.081365, 0.015618, 0.137672, 0.141537, 0.066299, -0.073328, -0.400100, -0.431580, -0.281286, 0.008796, -0.192617, -0.195897, -0.272302, -0.190990, -0.322448, -0.026480, -0.336893, -0.178359, -0.362114, -0.278169, -0.368219, 0.033996, 0.177624, -0.324749, -0.211285, -0.088408, -0.163266, -0.131812, -0.237721, -0.107391, 0.021015, -0.518005, -0.441238, -0.280117, -0.195353, -0.004120, -0.689108, 0.868552, 0.620328, -0.191304, 0.580623, 0.707147, 0.448088, 0.901210, 0.299364, 0.392076, -0.130319, -0.311235, 0.289949, -0.135985, -0.425340, -0.087387, -0.370483, -0.738775, -0.684405, -0.746547, -1.041984, -0.857207, -0.175478, -0.571044, -0.802861, -0.526809, -0.787321, -0.352744, -0.578629, -0.001073, -0.177132, -0.411516, -0.013923, -0.087472, -0.451380, -0.301686, -0.465904, -0.013948, -0.519192, -0.346272, -0.626986, -0.330589, 0.157031, -0.652816, 0.289851, -0.043681, 0.040255, -0.404694, 0.245099, 0.537091, 0.146806, 0.400528, 0.355957, -0.119256, -0.080625, 0.192808, -0.297256, 0.154482, -0.293676, 0.590593, 0.037262, -0.060935, -0.232108, -0.161976, 0.191493, 0.233204, -0.031713, -0.273469, 0.083559, 0.376732, 0.257101, -0.316527, -0.257194, -0.117174, 0.050264, -0.221705, -0.346441, 0.078157, -0.032639, 0.120531, -0.144742, 0.046872, -0.174463, 0.032533, 0.022351, 0.225368, 0.012260, -0.194780, 0.102809, -0.074380, -0.175085, -0.473110, -0.191248, 0.033438, -0.135969, -0.043327, -0.457130, -0.180496, -0.384592, -0.318918, -0.776532, -0.475983, -0.024449, -0.560657, 0.117664, -0.007231, 0.047525, -0.551021, 0.095909, 0.542361, 0.159647, 0.294110, 0.409158, -0.362084, -0.479288, -0.029971, -0.353319, 0.084588, -0.434385, 0.505218, -0.840477, 1.289294, 0.495623, -0.456189, 0.486569, 0.822867, 0.513154, 1.117506, 0.470104, 0.283522, -0.158747, -0.272146, 0.270495, -0.313310, -0.305937, -0.009679, -0.423616, -0.939918, -0.563180, -1.230172, -1.068988, -1.227334, -0.417475, -0.419091, -0.749301, -0.642867, -0.868389, -0.034892, -0.303653, 0.551059, -0.312784, -0.819304, -0.617439, -0.379588, -0.354750, -0.314543, -0.033447, -0.132686, -0.209277, -0.047632, -0.280624, -0.228882, -0.184663, 0.054990, -0.425197, -0.264402, -0.071539, 0.295018, 0.077635, -0.132252, -0.046397, -0.125492, 0.040619, 0.227760, 0.095981, 0.095987, 0.276719, -0.126934, 0.223742, -0.026236, 0.042096, 0.014897, -0.000084, 0.120657, -0.033950, -0.033173, 0.190398, -0.081849, 0.096850, 0.106338, -0.230257, -0.126039, -0.051223, 0.164228, 0.077655, 0.082094, -0.038479, -0.179356, 0.002055, 0.111964, 0.104873, 0.233188, -0.181130, -0.073138, 0.093913, -0.083452, -0.082317, 0.085166, -0.050466, -0.036342, -0.375787, -0.778053, -0.304052, -0.302844, -0.373189, -0.238496, -0.133971, -0.056292, -0.099876, 0.048285, -0.058490, -0.118676, -0.120606, -0.098959, -0.252782, -0.240359, -0.328208, -0.041969, 0.052470, -0.197992, -0.125009, -0.349180, -0.219419, 0.255782, 0.050823, -0.235548, -0.056647, -0.260524, 0.176676, -0.058712, -0.324851, 0.087127, 0.155708, 0.285198, 0.156498, 0.709215, 0.549151, 0.450742, 0.858865, 0.088840, 0.105484, 0.473849, 0.157863, 0.383088, 0.443141, 0.328468, 0.743216, 0.513036, 0.629089, -0.034876, -0.268758, -0.297513, -0.545361, -0.738086, -0.496669, -0.555600, -0.614952, -0.467528, -0.381453, 0.092663, -0.049540, 0.406276, -0.197027, -0.356176, -0.243940, -0.364601, 0.083515, -0.325883, 0.244656, 0.173456, -0.113469, -0.316174, -0.133421, -0.137004, 0.077752, -0.523226, -0.001723, -0.285673, -0.162349, -0.204093, -0.289575, 0.500742, 0.434368, 0.178575, 0.264046, 0.190952, 0.084373, -0.118536, -0.136319, 0.396767, -0.019172, 0.469932, -0.190963, -0.353670, -0.073692, -0.103460, -0.029910, 0.263999, -0.274668, -0.086592, 0.168801, -0.143235, 0.121976, 0.392592, 0.037764, -0.148922, -0.137643, 0.042181, -0.253137, -0.497099, 0.119582, -0.047422, -0.068319, -0.171561, -0.128644, 0.098629, -0.343822, -0.076133, 0.077043, -0.101693, 0.300298, 0.816103, 0.002142, -0.288715, -0.102077, -0.241150, 0.425059, -0.171578, 0.407905, 0.060801, -0.026391, -0.173458, -0.085608, -0.125368, 0.194848, -0.440165, 0.048946, 0.064722, -0.031542, -0.127328, -0.153349, 0.339598, 0.170332, 0.061182, 0.248623, 0.199501, 0.249214, 0.059851, -0.070024, 0.480166, -0.018752, -1.247126, -0.609967, 0.657178, 0.273018, 0.098218, -0.247266, -0.265642, -0.553663, -0.794505, -0.029593, 0.251417, -1.219592, 0.855466, 1.443111, -0.184395, 0.932166, 0.859135, 0.526104, 0.085364, 0.554760, 0.723990, 0.294393, 0.569929, 0.080262, 0.325832, 0.532214, -0.242645, 1.189741, 0.953124, -0.063074, -0.242522, -0.144682, 0.025584, -0.123262, -0.008019, 0.041284, 0.686375, 0.075248, -0.010278, -0.130821, -0.117824, 0.634216, 0.064286, -0.082103, 0.310163, 0.039415, -0.377692, 0.165982, -0.153662, -0.398739, 0.196928, 0.006898, 0.297145, 0.252197, 0.405235, 0.442605, 0.135186, 0.417734, 0.271562, 0.102058, 0.077519, -0.024281, 0.085229, 0.059662, 0.155416, 0.145592, 0.041670, 0.036853, 0.078086, 0.017534, -0.229306, 0.061735, -0.218003, -0.141180, -0.216874, -0.093893, 0.012091, -0.080022, -0.017635, -0.012303, -0.069248, -0.017349, 0.016205, 0.093684, -0.043970, 0.082962, -0.393167, -0.048882, 0.004874, -0.303345, -0.409026, -0.059891, 0.018143, 0.040824, -0.085402, 0.094694, 0.302028, -0.105290, -0.192194, -0.154208, 0.034800, 0.179036, 0.101227, -0.010752, -0.072145, -0.035720, -0.292429, 0.194801, -0.025939, -0.271192, 0.081792, 0.113989, 0.045913, 0.304563, 0.287439, 0.370613, -0.048358, 0.289346, 0.006887, 0.376512, 1.886263, -1.701198, -2.485665, -0.928226, -0.141098, 0.276071, 1.716922, 2.192334, 0.628273, -1.761454, 0.469612, 0.198519, 1.395597, 0.343455, 0.294825, -0.629591, -2.133188, -1.363873, 1.631447, 2.950196, 1.106402, -0.777664, -1.790700, -1.191964, -1.404120, -1.455724, 0.062315, -0.081729, -0.684756, 0.188621, 0.385304, 1.843752, 2.976657, 1.268619, 0.718455, 1.296239, 0.813303, 0.544576, 0.561899, 2.067666, 0.411183, 0.323943, -0.310089, 1.416792, 0.976932, 0.921788, 1.388836, 0.936154, 0.722886, 1.142255, 1.363887, 0.727233, 1.017903, 0.018279, -0.521439, -0.590066, 0.608570, 0.401229, -0.180335, -0.487584, 0.628655, 1.285896, 0.086628, 1.176948, 0.198593, 0.325161, 0.053308, 0.133338, 0.444914, -0.057658, -0.499617, 0.208917, 0.020765, -1.039170, 0.372840, 0.722019, -0.018057, -0.333446, 0.285758, 0.224381, -0.317516, -0.479559, -0.092617, -0.303022, 0.101024, -0.060345, -0.244558, 0.344260, -0.008620, 0.172881, 0.709589, 1.611665, 2.040049, 1.361458, 0.512716, 1.233274, 0.462972, 0.654481, 1.072965, 1.538228, 0.392268, -0.023210, -0.270218, 1.101162, 1.196370, 1.657801, 1.584357, 1.001113, 0.621245, 1.581889, 0.333965, 0.921831, 0.859120, 0.455386, -0.044307, -0.785962, 0.224286, 0.665570, -0.216298, -0.715958, 1.043231, -0.398672, -1.223433, 0.073135, -0.287506, 0.085949, 0.558467, 0.621922, 1.117107, 0.394217, 0.358371, 0.850280, -0.712175, -1.668194, -0.618524, -1.069637, -0.684319, 0.138994, 0.012461, -1.381705, -0.371361, -0.709383, 0.639143, -0.304830, 0.209959, -0.071139, 0.965076, -0.307879, 0.076679, -0.372964, -0.697329, -0.254793, -0.275657, -0.243426, -0.628169, -0.485792, 0.011858, -0.188528, -0.022583, -0.058624, 0.422691, -0.281562, -0.165270, -0.214161, -0.219888, -0.471582, -0.293311, 0.162295, -0.020871, -0.245105, 0.050182, -0.572987, -0.203407, -0.356082, -0.028699, -0.083036, -0.171419, -0.735863, -0.177830, -0.088465, -0.178564, 0.096611, 0.236974, 0.061152, -0.217475, -0.287147, 0.060428, 0.061232, 0.223877, 0.345163, 0.090576, -0.123123, -0.256148, 0.061137, 0.082256, -0.057121, 0.043803, 0.139230, 0.101642, 0.383158, 0.208113, -0.002620, -0.349848, -0.194711, 0.186339, 0.166972, 0.149985, 0.162821, -0.317953, -0.466879, -0.616959, -0.172253, -0.314297, 0.029001, -0.520458, -0.413429, 0.205976, -0.252852, -0.112990, -0.206501, 0.212469, -0.432858, -0.274861, -0.260161, -0.199500, -0.284746, -0.467588, -0.159774, 0.073887, -0.123526, 0.019407, -0.280651, 0.203433, -0.335234, -0.054922, -0.035565, -0.055062, -0.549356, -0.236029, 4.348160, -1.937162, -1.934782, -1.537064, -2.120580, -0.667150, -0.575480, -1.198851, -2.035966, -0.166851, -0.132166, -1.272277, 0.241844, 0.034027, 0.102178, 0.402401, 0.081473, -0.409070, 0.467958, 0.617922, 0.247627, 0.757933, 0.134598, 0.209945, 0.385359, 0.656915, -0.041889, 0.216299, 0.059430, -0.618777, 6.606844, 4.747169, 3.325993, 2.910524, 2.064331, 1.346018, 0.991696, 0.897020, 1.302374, 0.266514, -0.272745, 0.136474, -0.110576, -0.003747, -0.433659, -0.421579, -0.584901, -0.393709, -0.529302, -0.702438, -0.923072, -0.849259, -0.593755, -0.514784, -0.880335, -1.213972, -0.588625, -0.896458, -0.671447, -0.900471, 0.400960, -0.389093, 0.196165, -0.165107, 0.196952, -0.045658, -0.205371, 0.024740, -0.162524, -0.466246, -0.298800, -0.236736, 0.214754, -0.182564, 0.085404, -0.168326, -0.207121, -0.091507, -0.131710, -0.154922, -0.053805, 0.121265, 0.018278, -0.048530, -0.115227, -0.109576, 0.087351, 0.005656, -0.040278, 0.155805, 4.982090, 2.659456, 2.519660, 2.262991, 1.505040, 0.769610, 0.806587, 0.887742, 0.949585, 0.397049, -0.293534, 0.235922, 0.063479, 0.182966, -0.248398, -0.154117, -0.156621, -0.124253, -0.235352, -0.516917, -0.345363, -0.288513, -0.025983, -0.355523, -0.140245, -0.694596, -0.067534, -0.517518, -0.305308, -0.344075, 0.877714, 0.149375, -0.059986, -0.703369, -0.532356, 0.011608, -0.408551, 0.010749, 0.734266, 0.173072, 0.180440, -1.556001, 1.580348, -2.394770, 0.668361, 0.892048, -2.051731, -1.231367, -1.592587, -1.084397, -0.785050, -2.451432, -2.209402, -1.461463, -2.574087, -1.768684, -1.298544, -0.949944, -1.413318, -1.782899, -0.554007, -0.799556, -0.179072, -0.316056, -0.585849, -0.081605, -0.495868, -0.130101, -0.469090, -0.037160, -0.116843, -0.156674, -0.477647, -0.130196, -0.172696, -0.285288, -0.204198, 0.082309, -0.505092, -0.260713, -0.235197, -0.191244, -0.132067, -0.050832, -0.127561, -0.659682, -0.612111, -0.215648, -0.484755, -0.275837, -0.071729, -0.013313, 0.091423, 0.147322, 0.029979, 0.245693, 0.292048, 0.143426, -0.032365, -0.247100, -0.164977, -0.219273, -0.004178, -0.004256, -0.003726, -0.048242, -0.014619, -0.156410, -0.132848, -0.169374, 0.040715, 0.284923, 0.179579, 0.064258, 0.134610, -0.227072, -0.163990, 0.090447, -0.003643, -0.063182, -0.584903, -0.595343, -0.117283, -0.276174, -0.322103, 0.150006, -0.400526, -0.042094, -0.421944, 0.037490, 0.123622, -0.210601, -0.467298, -0.037028, -0.002381, -0.391147, 0.007947, 0.126475, -0.306592, -0.106603, -0.161202, -0.309491, -0.193862, -0.018420, -0.013180, -0.569399, -0.331416, -0.000769, -0.374749, -0.015052, -0.906642, 0.796147, -0.702674, -0.682277, -0.714470, 0.188611, 0.427126, -0.252677, 0.041579, 1.422774, 0.771242, -0.171321, 0.873441, 1.158002, 0.066864, 0.940386, 1.082999, 1.137860, -0.171568, 0.050747, 0.072511, 0.536692, 0.330455, 0.075117, -0.022109, -0.421788, -0.074183, -0.535191, -0.049540, -0.121340, -0.283652, -0.651958, -0.345429, -0.218171, -0.416177, -0.382595, -0.368920, -0.246947, -0.470432, -0.127568, -0.439417, -0.229399, -0.270230, -0.186786, -0.032207, -0.164400, -0.193130, -0.179390, -0.138819, -0.342728, -0.087051, -0.022002, -0.179837, 0.320573, 0.136423, 0.061278, -0.072035, 0.038405, -0.212507, 0.188475, 0.084776, -0.050155, 0.061846, -0.166703, -0.031155, 0.022549, 0.045894, -0.039078, 0.001244, -0.020988, -0.164035, -0.010324, 0.027468, -0.007938, -0.102600, 0.027747, -0.008518, 0.084652, -0.039517, 0.030586, 0.033084, 0.007518, 0.024174, -0.132493, 0.005229, -0.017281, -0.098203, 0.219267, 0.003421, 0.004102, -0.355807, -0.616345, -0.251197, -0.159469, -0.310543, -0.341122, -0.320663, -0.121626, -0.286795, 0.005703, -0.342548, -0.119676, -0.333534, -0.218718, 0.106893, -0.187190, -0.120361, -0.092733, -0.234903, -0.408740, -0.166619, -0.092545, -0.125706, 0.120650, 0.000444, 0.017500, -0.201255, -0.117154, -0.070134, 0.154751, -0.702338, 0.485526, -0.053178, -0.476165, 0.124576, 0.523396, 0.303784, 0.162287, -0.925324, -0.934997, -0.777814, -0.720406, 0.328565, -0.404665, 0.299575, 0.671950, 0.191119, 0.172846, 0.898384, 0.469096, 0.556837, 0.277139, 1.001952, 0.965754, 0.041550, -0.349147, -0.575832, 0.939818, -0.196116, -0.051707, -0.287849, -0.729798, -0.486984, -0.625489, -0.129767, -0.167406, -0.089572, -0.524393, -0.002066, 0.078524, -0.442018, -0.541790, -0.228184, -0.024107, 0.729608, -0.348440, -0.019773, -0.277268, 0.086792, 0.179051, -0.142651, 0.097096, -0.385297, -0.057879, 0.065594, 0.576668, -0.180203, -0.379680, 0.335545, 0.022132, 0.047274, 0.022332, 0.146279, 0.136267, 0.137701, 0.327075, 0.049899, 0.052928, 0.055212, -0.026465, -0.152408, 0.110110, 0.153124, -0.295646, -0.482974, 0.227976, 0.060632, -0.036648, 0.040683, -0.289434, -0.289657, 0.004429, 0.211098, 0.291504, -0.438905, -0.028333, -0.273214, 0.028961, -0.213948, -0.484745, -0.365152, -0.630579, -0.420864, -0.380155, -0.031163, -0.111921, -0.136373, -0.257644, -0.268027, -0.061128, -0.392312, -0.391447, -0.222173, -0.019319, 0.241566, -0.385838, -0.097316, -0.395882, -0.173448, -0.110501, -0.419199, 0.050909, -0.373461, 0.144436, 0.367725, 0.430924, -0.376083, -0.130235, 0.461497, 0.135069, 1.371578, -1.062901, -1.784919, -1.754269, -1.061261, -2.433937, -2.751427, -1.372966, -0.378044, -0.080048, -2.694759, 2.275952, -0.460301, -0.485125, 0.192299, 2.123376, -1.611789, -0.282796, 0.424206, -1.567558, -0.233797, 0.245319, 0.047815, -0.307134, -0.670923, -0.440054, 1.381364, -1.075209, -0.802507, -0.465659, -0.420628, -0.236061, -0.180101, 0.308686, 0.059611, -0.239272, 0.048775, 0.210801, -0.466399, -0.205002, 0.542994, -0.120199, -0.269821, 0.676423, -0.204029, -0.245082, -0.000345, -0.080236, -0.016585, 0.192867, -0.153219, -0.396534, -0.103585, 0.251559, -0.142938, -0.128545, 0.121887, 0.218553, -0.110324, -0.131966, 0.040218, 0.180177, 0.119215, 0.034397, -0.245463, -0.166003, -0.104631, -0.119142, -0.017759, 0.076117, 0.095172, -0.071429, 0.303628, 0.146090, 0.198640, -0.156480, -0.195912, 0.008060, 0.225466, 0.225735, 0.139291, -0.129866, -0.060028, -0.096018, -0.068551, 0.012633, 0.094833, -0.257560, -0.037695, 0.059349, -0.454347, -0.327417, -0.142144, 0.239117, 0.017104, -0.074496, 0.303436, 0.038479, -0.386893, -0.250896, 0.119991, -0.069201, 0.013770, 0.479397, -0.042001, -0.082027, 0.066613, -0.076181, 0.038050, 0.100585, -0.136204, -0.411362, -0.106882, 0.125515, 0.295014, -0.082927, 0.086860, 0.209669, -0.096984, 0.004165, -0.359822, -0.164543, -0.592971, -0.367282, 0.126850, 0.084687, 0.055484, 0.036814, -0.612286, 0.720957, 0.439289, -0.166311, -0.069715, -1.073235, -1.109740, -1.105493, -0.315272, -0.279119, -0.383663, 0.339504, -0.067428, -0.257508, -0.233574, 0.413354, 0.233594, 0.988433, 0.894904, 0.681978, 0.754408, -0.105212, 0.165128, 0.098347, 0.046719, 0.182197, 0.585884, 0.453397, 0.295123, 0.229997, 0.321094, 0.459463, 0.689055, 0.344131, -0.115466, 0.390945, 0.400127, 0.483868, -0.008293, -0.132506, -0.042842, 0.181372, -0.085223, 0.134087, 0.069862, -0.041977, -0.624278, 0.041242, 0.148255, 0.374985, -0.072086, 0.169475, -0.061348, 0.134131, 0.043734, -0.029817, -0.113610, 0.031977, -0.051220, -0.039425, 0.077742, 0.097474, -0.038304, 0.068841, 0.018002, 0.140220, -0.007878, -0.134856, 0.126982, -0.218570, -0.059144, -0.016765, 0.019985, -0.013531, -0.091593, 0.047373, 0.004716, 0.078941, 0.094487, 0.017439, 0.044075, 0.150180, 0.543555, 0.480766, 0.045245, 0.402650, 0.454954, 0.351580, 0.061287, -0.014606, 0.115648, 0.354207, 0.930435, 0.596831, 0.152557, 0.330502, 0.389512, 0.536658, 0.291320, -0.036369, 0.090442, 0.380698, 0.176597, 0.389561, 0.156096, 0.102858, -0.373957, 0.067506, 0.238276, 0.541718, -0.256139, 0.274192, 0.122024, -1.044114, 0.843924, 0.450535, 0.382990, 0.844512, 1.120794, -0.669859, -0.506285, -0.912453, 0.232161, 0.243629, 0.605430, 0.171842, 0.997620, 0.421335, -0.127793, 0.439463, -0.044979, -0.244388, -0.078647, -0.340319, 0.179865, -0.922140, 0.078654, -0.389550, -0.012701, 0.787074, 0.155633, 0.534392, -0.198599, -0.187316, -0.098438, 0.013144, -0.102591, -0.171998, 0.337278, 0.667875, 0.052691, -0.176961, 0.185099, -0.074478, -0.072996, -0.052742, -0.483398, -0.186941, -0.145956, 0.029041, -0.059286, -0.069834, 0.094652, -0.171506, 0.063238, -0.324346, 0.100106, -0.175050, 0.033551, 0.205280, -0.376868, -0.375593, 0.115487, 0.100395, 0.040770, 0.022751, -0.130222, -0.106937, -0.067288, -0.054034, -0.001881, 0.021784, 0.008362, -0.060245, -0.012737, -0.081920, 0.096800, 0.167778, -0.061771, -0.122660, -0.030888, 0.085339, -0.056809, -0.162142, -0.216854, -0.112889, -0.035597, 0.178018, 0.118736, -0.107810, -0.005415, -0.089748, -0.414640, -0.595824, -0.278603, -0.151899, -0.160554, -0.261292, 0.028492, 0.168823, -0.194698, -0.230626, -0.069393, -0.168130, 0.103867, 0.001814, -0.299954, -0.161567, -0.219776, -0.097805, -0.095621, -0.269939, -0.067869, -0.175884, -0.110333, -0.246711, -0.009600, -0.174376, -0.020487, -0.008448, -0.263292, -0.304192, -0.478169, 0.803048, -0.049807, 0.052564, 0.360118, 0.937058, 0.676533, 1.314242, 1.303260, 0.447718, -0.110345, 0.117667, 0.385465, -0.066767, 0.298465, 0.552426, 0.608566, 0.377668, 0.191054, -0.002975, -0.143252, -0.438329, -1.030083, -1.073774, -1.260084, -1.402100, -1.372047, -1.407373, -1.516066, -1.013158, -0.195519, -0.200791, -0.335764, -0.312625, -0.070189, -0.142848, -0.156408, -0.263554, -0.115349, -0.097310, -0.067052, -0.136531, -0.194962, 0.081338, -0.173735, -0.357593, -0.027398, 0.151074, 0.397771, -0.106063, -0.202256, -0.201998, -0.154301, 0.187471, -0.076548, -0.119676, 0.017981, -0.464155, -0.133903, -0.136906, 0.160731, 0.143333, -0.135448, -0.084116, -0.222013, -0.204645, -0.020260, 0.177432, 0.141124, 0.057569, -0.108198, 0.065288, 0.087446, -0.039152, 0.012332, -0.043859, 0.135990, -0.190027, 0.031813, 0.094204, 0.121648, 0.180988, 0.017793, 0.097976, 0.360588, -0.276448, 0.003098, -0.006844, -0.042348, -0.173195, 0.122089, 0.113594, -0.152255, -0.147332, -0.025448, 0.001123, -0.062226, 0.051510, -0.209063, -0.046787, -0.097754, -0.065514, -0.019760, 0.192801, -0.056105, -0.186953, -0.004644, 0.252129, 0.294050, 0.070788, -0.054314, -0.176833, -0.027313, 0.118146, 0.015607, -0.021690, -0.071691, -0.359505, -0.086113, -0.097896, -0.904432, 0.556390, -0.684109, -0.293973, -0.764480, 0.393324, 0.550392, -0.211190, -0.221634, 1.180289, 0.845899, -0.357376, 0.836215, 1.002208, 0.017373, 0.861150, 1.086930, 1.072099, 0.060336, -0.054961, -0.152277, 0.464387, 0.380802, -0.043230, -0.129690, -0.531140, -0.271897, -0.649792, 0.159799, -0.145641, -0.318036, -0.600083, -0.318377, -0.509301, -0.243830, -0.209010, -0.079363, -0.273600, 0.033446, -0.254210, 0.233858, 0.019157, 0.276249, 0.193681, -0.237415, -0.343401, 0.025997, -0.096762, 0.230307, -0.302248, -0.355556, -0.254870, 0.545148, 0.223257, -0.064109, 0.068001, 0.219519, -0.459414, -0.130903, -0.646378, 0.009149, -0.066147, 0.107137, 0.029167, -0.104854, -0.100067, -0.033038, 0.084894, 0.206742, 0.219187, 0.011998, -0.056918, -0.142016, 0.274162, 0.041009, -0.060330, 0.403405, -0.306602, 0.234371, 0.014512, -0.054112, 0.195589, 0.260839, 0.169089, -0.303452, -0.059520, -0.272631, -0.062937, 0.377392, 0.041145, -0.357945, -0.542791, -0.288105, -0.495676, -0.104825, 0.006062, 0.251546, -0.147626, 0.022421, -0.154872, 0.299000, 0.118382, 0.188253, 0.174539, -0.204492, -0.116696, 0.029476, -0.003532, 0.310798, -0.151110, -0.476721, -0.236297, 0.537037, -0.061692, 0.219698, 0.025260, -0.083650, -0.465647, -0.025789, -0.481133};
static RBF_CONST rbf_float RBF_WIDTHS[] = {4.307198, 4.086917, 6.222364, 4.699992, 8.067509, 3.764367, 4.182676, 4.796072, 3.861284, 6.348768, 4.255335, 3.829812, 5.342021, 4.086917, 4.814158, 4.531036, 3.666157, 3.029279, 3.275819, 3.259710, 7.849226, 3.384189, 7.449436, 4.142286, 3.666157, 3.492557, 4.066957, 3.992232, 9.794323, 16.836432, 3.992232, 4.849531, 4.568951, 3.164676, 3.029279, 3.605599, 3.605599, 3.983938, 4.182676, 10.486203, 3.384189, 7.849226, 3.259710, 2.966298, 3.764367, 4.814158, 3.164676, 3.275819, 3.983938, 2.966298};
static RBF_CONST rbf_float RBF_WEIGHTS[] = {2.269657, -0.739160, 1.905214, -3.968134, 1.063418, 1.358837, -2.029653, -2.601631, 2.982723, -2.522685, -0.300740, 2.630722, -0.799273, -3.617781, -2.366384, -3.960887, -1.150244, 3.260337, -3.764553, 0.892607, 24.653066, -0.873566, -9.203348, -3.714323, 0.378464, -0.064143, -0.576493, -0.507251, 0.820546, -1.413971, 0.370433, -1.305696, -0.407787, 0.290916, 5.435623, -3.018135, 11.778291, 0.503758, -0.548784, -1.402548, 0.108762, -0.914912, 1.235779, -3.180478, -2.890099, -4.252682, -1.220316, 1.256504, -0.759691, -3.467067, 0.296253, -0.866872, 5.535391, 0.011572, -0.178152, -0.622412, -0.404427, 1.565038, 2.628345, -3.704612, -1.155317, -4.359142, 0.908291, -1.512024, 34.036872, 5.442143, -2.928778, -2.632607, -6.692782, -19.575613, 0.505315, -1.329285, 1.752622, -5.600029, 33.911450, -3.831228, -2.355717, 8.205635, -18.822346, 4.561990, -7.783893, -0.115267, -7.382431, -2.171487, 5.512853, 0.282256, -0.130151, -1.424923, -0.419734, 9.356210, -2.314018, -0.031044, -4.696601, 3.272013, -4.143682, -5.163281, -1.685210, 1.440829, -1.069777, 3.893762, -22.089447, -20.838404, 2.925675, -4.813392, 6.471499, 54.338074, -16.394312, -3.025185, -1.103901, -2.402973, -0.736881, 1.292806, -1.347916, -1.147773, -1.382748, 8.404648, -1.105236, -0.817141, -0.641404, 0.962510, -5.077760, -4.731966, -3.843337, 0.395653, -2.381966, -3.966597, -1.115546, -2.282139, 24.274682, -0.881836, 0.022922, -1.061859, -1.241354, 20.770952, -12.476666, 1.156280, -1.242133, -10.231544, 6.679684, 6.119918, -2.274052, 3.722750, -6.070055, -5.266359, 5.892107, 1.762228, 0.573731, -1.815961, -0.362945, -3.722637, -1.455770, -2.553166, -0.762653, 1.161571, 2.463029, -1.018878, -3.998850, -6.088969, -6.531684, 1.323435, 2.553542, -0.598009, -1.510106, 0.328951, 17.893296, 0.552994, 0.404756, -4.841288, -1.291127, -2.623276, -1.225714, -3.648794, 1.866903, -1.456476, 1.375510, 12.961809, -1.058194, -0.465647, -0.536247, -4.002037, 1.560329, 13.498445, -3.498763, -1.852934, -5.445125, -6.528743, 0.794074, -3.770122, -0.541109, 2.186494, 4.497955, -1.074743, -14.275888, 49.395439, -23.906094, -1.856477, 2.132881, -11.549130, -10.802455, 6.988388, 4.764900, -6.457818, -4.905605, 9.316858, 16.082751, 23.579203, -30.278420, -18.356769, 39.792651, -53.560620, 94.568737, 24.561841, 1.930622, -56.721076, -24.795437, -15.484226, -4.865207, -35.667178, 8.477209, 25.188084, -14.636939, -17.762642, 23.443513, 11.081071, 15.265887, -15.843886, 14.815707, -9.188129, -6.200671, 9.250328, 2.406356, -21.016035, -9.178772, -11.628641, 0.013075, 54.372796, -0.318753, -8.514272, -8.623319, -1.290332, -1.584179, 3.884788, 0.032328, -1.605712, -1.079344, -0.785730, 0.514670, -0.695206, -0.948828, 0.705271, 1.255283, 0.215193, -19.598648, 22.291803, 6.419325, 18.151408, -19.056016, -2.474462, 1.252338, -5.788236, -1.867564, 1.610286, 4.056376, -5.761178, -2.065775, -1.359976, -1.352773, 0.276698, -2.548038, -1.594363, 1.096228, -1.465544, -0.124958, -3.295687, 0.179872, 12.331775, -3.633636, -2.193445, -1.666323, -1.049447, 28.545699, -6.175862, 1.092907, -1.715867, 1.810682, -9.888081, 3.967202, -8.834932, -14.128324, 29.852674, -9.505597, 2.386367, 3.374261, 5.996631, -5.104929, 14.089838, -9.694784, -3.290558, -11.460185, -3.195805, 4.129546, -15.415827, 0.628250, 80.460391, -15.020114, -7.395384, -9.716369, -3.040284, 9.373538, 15.460632, -13.498970, -45.765967, -3.041255, 10.184813, 0.822619, -3.490793, -1.953106, -0.708188, 1.445685, -3.373853, -4.349684, 9.108463, -6.832183, 1.993695, 2.330900, 10.462439, 5.822302, -11.932905, -1.036726, -12.313571, -13.995131, 7.859859, -3.349618, -4.785703, -14.386446, 35.600663, -0.731719, -1.073792, 0.491414, -0.853871, -0.092172, 1.899946, 0.004638, -0.404033, -0.328472, 0.258660, 2.173978, -1.378058, -2.245095, -0.446092, -0.046299, -0.542368, 0.186849, 0.697205, -0.458368, -1.174765, 0.481926, 4.532370, 0.605512, -1.729109, -3.708273, -11.937631, -2.246955, -1.883060, -6.913242, 9.718432, -2.064449, -2.247117, -7.002794, -0.685284, -3.483285, 32.729767, -3.268867, -1.469701, -8.845607, -0.263578, -8.375367, -5.242862, 29.088370, -3.204990, -0.342793, 1.829811, -0.023965, 0.039482, 0.655190, -2.802692, -1.879082, 27.337728, -8.561255, 0.603654, 2.199056, -11.857033, -2.510177, -0.313825, 0.039073, -2.593929, -10.557789, -25.034514, -24.811114, -68.535949, -7.466493, 16.865674, 19.140576, 5.876208, 11.159485, -20.285133, 114.395868, -12.105088, 6.649296, -32.755822, -11.342819, 10.034413, -45.738855, 11.799205, 93.677151, 6.621822, 2.282349, -44.824230, 22.242123, -18.019692, 6.961737, 3.384614, 0.899622, -22.937222, 23.497349, -17.847517, 3.276185, 0.096057, 4.336187, -0.806923, 2.182167, -2.809162, 4.173450, 3.403112, 0.552942, -20.177448, 60.027609, -21.328166, -17.126291, -6.924379, 10.537171, -2.666555, 0.422481, -10.515423, 0.655094, -19.609127, 4.278818, 9.161613, -0.702033, 44.748843, -3.832826, -4.473373, -9.559902, -9.569265, -1.148520, -9.627114, -0.969473, -12.368733, 37.994519, 5.630944, -0.257792, -4.668979, -1.227092, -9.271574, -3.759237, -9.186286, 1.702853, -2.857280, 0.254332, 1.140095, 0.163748, 1.070836, -0.651136, 3.131390, -0.496239, -0.102705, 0.192683, -1.602298, -0.902748, -2.222876, -15.555262, 4.428537, 7.491711, 8.827064, -10.685613, 4.050725, 6.441472, 2.909015, 3.054694, -4.189101, -29.225602, 22.176695, 0.166820, 6.964728, -0.929043, 1.644092, -0.874871, -1.420546, -0.484139, -0.486472, -0.512466, -2.561135, -1.972230, 0.446330, -0.679356, 2.128623, 1.591348, -7.272653, -5.610116, -6.432767, 1.985769, 16.972202, -0.087851, -4.606756, -3.631622, 5.528323, 102.464050, -60.479964, 1.766245, -33.156114, -60.573738, -18.494898, 36.276523, 6.863373, -5.104067, 5.145392, 2.407599, 26.060375, -12.569787, 15.525033, -10.025183, -15.414227, 27.874873, 3.777450, -22.752124, 6.631634, -6.466004, 1.074154, -6.297197, 18.283686, -1.279753, -0.394088, -0.662241, -2.446650, -0.471320, 1.712128, -2.687121, 11.478713, -0.922164, 0.084359, -1.612486, -2.965132, -14.082841, -22.154786, -4.612179, -2.278361, 3.466549, -3.139343, -37.157157, 17.578566, -27.908546, -2.733532, 109.976894, -17.087785, -6.758064, -11.312549, -35.948296, -1.265593, -33.706938, 27.041599, -48.296463, -6.604202, -1.677375, 104.591182, 5.955589, 5.739956, -14.114505, -5.761934, 9.914382, -4.716972, -20.862676, 36.743066, -6.037913, -6.821748, 5.337379, -1.946581, 3.505825, 3.944242, 141.641335, -31.556333, -7.561168, -14.099253, -13.680931, -81.786373, 21.033017, 15.506510, 12.174479, -22.468066, -9.153099, -5.470459};
static RBF_CONST rbf_float RBF_BIAS[] = {1.231291, 0.181438, -0.031433, 0.028558, -0.220845, -0.948485, 0.015227, 0.730038, 0.253826, -1.279758, -0.987371, 1.078996};

#if RBF_USE_NORMALIZATION
static RBF_CONST rbf_float NORM_IN_MEAN[] = {0.007725, -0.007038, 0.007455, 0.011877, 0.001866, -0.003087, 0.004067, 0.002325, 0.003148, -0.006066, 0.004758, 0.000636, 0.004189, -0.007824, 0.003690, -0.004952, -0.002980, -0.015579, -0.010094, 0.002106, 0.004459, 0.006238, -0.002720, -0.000873, 0.007270, 0.009699, 0.006898, 0.001832, 0.005006, -0.007759, 0.005082, 0.013317, -0.002149, -0.000781, 0.011293, 0.011511, 0.005884, -0.005790, -0.009952, -0.009337, 0.005552, 0.014381, 0.010618, 0.015250, 0.005429, 0.003803, 0.008677, -0.012048, -0.007581, -0.018476, -0.000717, 0.010397, 0.001276, -0.002031, -0.007865, -0.015925, -0.004742, -0.004977, 0.008823, 0.009801, -0.012115, 0.003178, 0.000795, 0.004078, -0.008358, -0.003247, 0.002985, -0.001700, 0.003416, -0.003666, -0.008242, 0.004791, 0.002949, 0.003835, 0.013085, 0.002617, -0.000862, -0.003491, 0.012320, 0.005680, -0.008778, -0.010445, 0.013855, -0.000230, -0.028151, -0.007351, -0.002369, 0.003762, -0.006667, 0.005783, 0.009740, 0.013742, 0.000966, 0.002236, 0.001234, 0.012526, 0.005553, 0.000584, 0.001718, -0.007526, 0.010426, 0.019006, 0.001946, -0.000085, -0.001752, 0.006428, 0.012480, -0.011479, -0.004705, -0.011416, 0.002779, 0.019718, 0.009155, -0.006767, -0.002370, -0.006690, -0.004474, -0.008191, 0.013075, 0.004443};
static RBF_CONST rbf_float NORM_IN_SCALE[] = {0.996629, 0.996456, 1.006960, 1.000724, 0.998965, 1.007205, 0.996358, 1.008930, 0.999738, 0.999265, 1.000178, 1.004599, 1.005564, 1.001433, 0.999537, 0.996337, 1.004369, 1.001488, 1.006371, 1.002854, 1.013769, 1.009204, 1.012719, 1.009145, 1.007766, 1.013448, 1.006060, 1.004181, 1.004699, 1.012301, 1.011381, 1.004705, 1.005709, 0.999788, 1.014250, 1.007092, 0.998332, 0.999420, 1.000578, 0.986307, 0.990726, 1.000894, 0.987749, 1.003016, 1.003188, 1.002182, 0.999670, 1.003895, 1.005160, 0.987971, 1.003442, 0.998074, 1.001403, 0.997493, 1.004569, 0.999488, 1.000520, 1.005482, 1.005012, 0.999332, 1.021121, 1.009623, 1.005972, 1.000076, 1.007258, 1.004143, 1.013018, 1.009041, 0.999489, 0.987664, 1.004903, 0.995086, 1.004900, 0.999231, 0.991359, 1.003120, 1.001450, 0.991679, 1.002761, 0.996638, 0.996337, 1.011198, 0.990578, 1.001591, 0.993474, 0.997636, 0.995683, 0.991396, 1.004184, 1.003337, 1.017125, 1.011451, 1.014767, 0.996731, 0.999880, 0.999353, 1.003289, 0.993435, 1.000970, 0.994051, 1.002609, 1.002306, 1.001798, 0.999421, 1.000606, 1.006095, 1.006228, 1.003175, 1.000111, 0.992152, 1.000916, 1.003823, 0.992797, 0.989172, 1.004844, 0.997501, 1.006134, 1.001482, 1.007577, 1.002577}; // StdDev
static RBF_CONST rbf_float NORM_OUT_MEAN[] = {0.078289, 0.085565, 0.081781, 0.081781, 0.081490, 0.084692, 0.082654, 0.084692, 0.087602, 0.085565, 0.083818, 0.082072};
static RBF_CONST rbf_float NORM_OUT_SCALE[] = {0.268625, 0.279720, 0.274031, 0.274031, 0.273586, 0.278422, 0.275359, 0.278422, 0.282715, 0.279720, 0.277115, 0.274475}; // StdDev
#endif

// ==========================================
// Implementation
// ==========================================

RbfModelRBF::RbfModelRBF() {
    for(int i=0; i<RBF_HIDDEN_DIM; i++) hidden_activations[i] = 0;
}

void RbfModelRBF::predict(const rbf_float* input, rbf_float* output) {
    // 1. Prepare Input (Normalize if needed)
    rbf_float processed_input[RBF_INPUT_DIM];
    #if RBF_USE_NORMALIZATION
        normalizeInput(input, processed_input);
        const rbf_float* in_ptr = processed_input;
    #else
        const rbf_float* in_ptr = input;
    #endif

    // 2. Hidden Layer (RBF)
    for (int i = 0; i < RBF_HIDDEN_DIM; i++) {
        rbf_float dist_sq = euclideanDistanceSq(in_ptr, i);
        rbf_float width = RBF_READ(&RBF_WIDTHS[i]);
        hidden_activations[i] = computeKernel(dist_sq, width);
    }

    // 3. Output Layer (Linear)
    for (int j = 0; j < RBF_OUTPUT_DIM; j++) {
        #if RBF_FIXED_POINT
            int64_t sum = 0;
        #else
            float sum = 0.0f;
        #endif

        for (int i = 0; i < RBF_HIDDEN_DIM; i++) {
            rbf_float weight = RBF_READ(&RBF_WEIGHTS[i * RBF_OUTPUT_DIM + j]);
            #if RBF_FIXED_POINT
                sum += (int64_t)hidden_activations[i] * weight;
            #else
                sum += hidden_activations[i] * weight;
            #endif
        }

        #if RBF_FIXED_POINT
            sum = sum / RBF_SCALE_FACTOR;
            output[j] = (rbf_float)sum + RBF_READ(&RBF_BIAS[j]);
        #else
            output[j] = sum + RBF_READ(&RBF_BIAS[j]);
        #endif
    }
    
    // 4. Denormalize Output
    #if RBF_USE_NORMALIZATION
        denormalizeOutput(output);
    #endif
}

void RbfModelRBF::normalizeInput(const rbf_float* input, rbf_float* norm_input) {
    for(int i=0; i<RBF_INPUT_DIM; i++) {
        rbf_float mean = RBF_READ(&NORM_IN_MEAN[i]);
        rbf_float scale = RBF_READ(&NORM_IN_SCALE[i]);
        #if RBF_FIXED_POINT
             // (Input - Mean) * SCALE_FACTOR / StdDev
             int64_t diff = (int64_t)input[i] - mean;
             norm_input[i] = (rbf_float)((diff * RBF_SCALE_FACTOR) / scale);
        #else
             norm_input[i] = (input[i] - mean) / scale;
        #endif
    }
}

void RbfModelRBF::denormalizeOutput(rbf_float* output) {
    for(int i=0; i<RBF_OUTPUT_DIM; i++) {
        rbf_float mean = RBF_READ(&NORM_OUT_MEAN[i]);
        rbf_float scale = RBF_READ(&NORM_OUT_SCALE[i]);
        #if RBF_FIXED_POINT
             // (Output * StdDev) / SCALE_FACTOR + Mean
             int64_t val = (int64_t)output[i] * scale;
             output[i] = (rbf_float)(val / RBF_SCALE_FACTOR) + mean;
        #else
             output[i] = (output[i] * scale) + mean;
        #endif
    }
}

rbf_float RbfModelRBF::euclideanDistanceSq(const rbf_float* input, int center_idx) {
    #if RBF_FIXED_POINT
        int64_t sum = 0;
    #else
        float sum = 0.0f;
    #endif
    int base_idx = center_idx * RBF_INPUT_DIM;
    for (int k = 0; k < RBF_INPUT_DIM; k++) {
        rbf_float c = RBF_READ(&RBF_CENTERS[base_idx + k]);
        rbf_float diff = input[k] - c;
        #if RBF_FIXED_POINT
            sum += ((int64_t)diff * diff) / RBF_SCALE_FACTOR;
        #else
            sum += diff * diff;
        #endif
    }
    return (rbf_float)sum;
}

rbf_float RbfModelRBF::computeKernel(rbf_float dist_sq, rbf_float width) {
    #if RBF_FIXED_POINT
        if (width == 0) return 0;
        double d = (double)dist_sq / RBF_SCALE_FACTOR;
        double w = (double)width / RBF_SCALE_FACTOR;
        return (rbf_float)(exp(-d / (2.0 * w * w)) * RBF_SCALE_FACTOR);
    #else
        return exp(-dist_sq / (2.0f * width * width));
    #endif
}

void RbfModelRBF::printInfo() {
    Serial.println(F("Model Loaded: RbfModelRBF"));
    Serial.print(F("Normalization: ")); 
    Serial.println(RBF_USE_NORMALIZATION ? F("YES") : F("NO"));
}
