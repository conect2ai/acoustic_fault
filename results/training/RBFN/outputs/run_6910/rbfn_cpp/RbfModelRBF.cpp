#include "RbfModelRBF.h"

// ==========================================
// Flash/PROGMEM Macros
// ==========================================
#if defined(ESP32) || defined(ESP8266)
    #define RBF_CONST const
    #define RBF_READ(x) (*(x)) // Fixed: Dereference pointer
#elif defined(__AVR__)
    #include <avr/pgmspace.h>
    #define RBF_CONST const PROGMEM
    #if RBF_FIXED_POINT
        #define RBF_READ(addr) (rbf_float)pgm_read_dword(addr)
    #else
        #define RBF_READ(addr) (rbf_float)pgm_read_float(addr)
    #endif
#else
    #define RBF_CONST const
    #define RBF_READ(x) (*(x)) // Fixed: Dereference pointer
#endif

// ==========================================
// Model Parameters
// ==========================================
static RBF_CONST rbf_float RBF_CENTERS[] = {0.169385, 0.137470, -1.144336, -0.522246, -0.980843, -0.913833, -0.725403, -0.630548, -0.537703, -0.621517, -0.617796, -0.649429, -0.666502, -0.657920, -0.599704, -0.635273, -0.681695, -0.866057, -0.857333, -0.679964, -0.699723, -0.622056, -0.572938, -0.580381, -0.534002, -0.589899, -0.620191, -0.860362, -0.909211, -0.833036, -0.475209, -1.493442, -0.321288, 0.648347, -0.011363, -0.174982, -0.198631, -0.325725, -0.230286, -0.366605, -0.250667, -0.253585, -0.268785, -0.380188, -0.087876, -0.050407, 0.112053, -0.111809, -0.159510, -0.087321, -0.121402, -0.207624, -0.427393, -0.336616, -0.240812, -0.083969, -0.046399, -0.186151, -0.284842, -0.211061, -0.094838, -0.161625, 0.427534, 1.401770, 0.136801, -0.642618, -0.329630, 0.005636, 0.197735, 0.667896, 0.518305, 0.223300, 0.124624, 0.290974, 0.463906, 0.357560, 0.584697, 0.408254, 0.436088, 0.714710, 0.182828, 0.557806, 1.008168, 0.841936, 0.667509, 0.820088, 1.091784, 0.587331, 0.376697, 0.506085, 0.129573, -1.027509, -0.177615, 1.766485, 0.506005, 0.021706, -0.287356, -0.359404, -0.573366, -0.708201, -0.538278, -0.505825, -0.189852, -0.291850, 0.015422, -0.061002, 0.351804, -0.007142, 0.042812, 0.198952, 0.077444, 0.148538, -0.032535, -0.221083, -0.013618, 0.107022, 0.020120, 0.076404, -0.144944, -0.027922, 0.776773, 0.292813, 0.501718, 0.823037, 0.891014, 0.922107, 0.803048, 1.002431, 1.111551, 1.063741, 1.057141, 1.182212, 1.156114, 1.032222, 0.981348, 0.915739, 0.743410, 0.738774, 0.916621, 0.963599, 0.932687, 0.907268, 0.832596, 0.711105, 0.638402, 0.823461, 0.670307, 0.620478, 0.576664, 0.419604, 0.413939, 0.244976, 0.164925, 0.169413, -0.080362, -0.238140, 0.090975, -0.255913, -0.144094, -0.031812, -0.063956, 0.024510, -0.297964, -0.028193, -0.001682, -0.057607, -0.271707, -0.216113, -0.076503, -0.214678, -0.294040, -0.242024, -0.343255, -0.447435, -0.298953, -0.303802, -0.332572, -0.350541, -0.305111, -0.242486, -0.717254, -0.624708, -0.498221, -0.486251, -0.448205, -0.330415, -0.513078, -0.609771, -0.484304, -0.648833, -0.486527, -0.287472, -0.089732, -0.389375, -0.482925, -0.293666, -0.220240, -0.251499, -0.275649, -0.009971, -0.256943, -0.462363, -0.293298, -0.194089, -0.241879, -0.403280, -0.331071, -0.163820, -0.001582, -0.053742, 0.522246, 0.363586, 0.408150, 0.074915, -0.351448, -0.323515, 0.026863, -0.539613, -0.368504, -0.029954, -0.095014, -0.174733, -0.221916, -0.167559, -0.031685, 0.017086, -0.274738, -0.153980, -0.181501, -0.122190, -0.381555, -0.321189, -0.243335, -0.353436, -0.399788, -0.330051, -0.466519, -0.352056, -0.422691, -0.311455, 1.659269, 1.709051, 2.444901, 2.672043, 2.503006, 2.508605, 2.384470, 2.704920, 2.986917, 2.985353, 3.019118, 3.120372, 3.119062, 3.122805, 2.986942, 2.752670, 2.456605, 2.558847, 2.736671, 3.001134, 2.784941, 2.478266, 2.509303, 2.679020, 2.474693, 2.711266, 2.524318, 2.267318, 2.309475, 2.337990, 2.831622, 6.171725, 7.484155, 7.627768, 7.397598, 7.311954, 7.624912, 7.063919, 6.682509, 7.294048, 7.901085, 8.207243, 7.940112, 7.578845, 7.313192, 7.360617, 6.991390, 6.828411, 7.246538, 7.446609, 6.828128, 6.679050, 6.519382, 7.244352, 7.579103, 7.069957, 7.273751, 7.324855, 7.050581, 6.880297, -2.157880, -2.119225, -1.722574, -2.186615, -2.149316, -1.908144, -1.922998, -1.916813, -2.167445, -1.861540, -1.340590, -2.091002, -2.235707, -1.695503, -2.091660, -2.178570, -2.455152, -2.288750, -1.858814, -2.195404, -1.667755, -1.996806, -1.744468, -1.887625, -2.146207, -1.972475, -2.084249, -2.050792, -2.125451, -2.409880, 2.426959, 5.310349, 6.476840, 5.469913, 5.379636, 5.529238, 6.085014, 5.832461, 5.458109, 5.661725, 6.108637, 6.935915, 6.401090, 5.969951, 5.642689, 5.808135, 5.438090, 5.065004, 5.785448, 6.222114, 5.822355, 4.740791, 4.137134, 5.390382, 6.413310, 5.288835, 5.688767, 6.163795, 5.564598, 5.115665, -0.652213, -1.388868, -1.510129, -0.972031, -0.776316, -0.652030, -0.638971, -0.443276, -0.599061, -0.848662, -0.698398, -0.625343, -0.819894, -0.785362, -0.853946, -1.157691, -1.320385, -1.259913, -0.964215, -0.805852, -0.954504, -1.148270, -1.198722, -1.198875, -1.187787, -1.152763, -1.311734, -1.147212, -1.176831, -1.262974, 0.414242, 0.065178, -0.186074, -0.322479, -0.487399, -0.207232, -0.391442, -0.202275, -0.544410, -0.489270, -0.126065, -0.148565, -0.316796, -0.298100, -0.323616, -0.257889, -0.314837, -0.490526, -0.304279, -0.244298, -0.374643, -0.576508, -0.638120, -0.368455, -0.344799, -0.465900, -0.654773, -0.482983, -0.476506, -0.555783, -0.641838, -0.670391, -0.128197, 0.345799, 0.256303, 0.307647, 0.556478, 0.256167, -0.067236, 0.267096, 0.406903, -0.156300, 0.256521, 0.182266, 0.211884, 0.286310, 0.184892, 0.380651, 0.603753, 0.441707, 0.476800, 0.490035, 0.105269, -0.047130, 0.031025, 0.287427, 0.022648, 0.047232, 0.140951, 0.385807, 0.509273, 0.311842, -0.285808, -0.253804, -0.627782, -0.062484, -0.229043, -0.263344, -0.529326, -0.416392, -0.010832, -0.256743, -0.262466, -0.239352, -0.166777, -0.064859, -0.312074, -0.537570, -0.267501, -0.227258, -0.425964, -0.569033, -0.650644, -0.396308, -0.364983, -0.467376, -0.675345, -0.529012, -0.549111, -0.549397, 0.402613, 0.316214, 0.042828, 0.364704, 0.014676, -0.372960, -0.503341, -0.477483, -0.048013, 0.134744, 0.196932, 0.190597, 0.046801, -0.071300, -0.312684, -0.283098, -0.052399, 0.107925, -0.005294, 0.150050, 0.415858, 0.531368, 0.441417, 0.342431, 0.563163, 0.537102, 0.337424, 0.418517, 0.523605, 0.835154, 0.396611, 0.057139, -0.281903, 0.101217, -0.074656, -0.430093, -0.224067, -0.356443, -0.227805, -0.203878, -0.072584, -0.103503, -0.199440, -0.267708, -0.386208, -0.270185, -0.459882, -0.411944, -0.474993, -0.373553, -0.009117, 0.087312, -0.363816, -0.488400, -0.362006, -0.208109, -0.364677, -0.292347, -0.289864, -0.114845, 0.555062, 0.467813, 0.423090, 0.043084, 0.054650, 0.047475, 0.007254, 0.279301, 0.168992, 0.058093, -0.241444, -0.248575, 0.133719, 0.537197, 0.542680, 0.341304, 0.094345, 0.003489, 0.026608, 0.003229, 0.019068, 0.102991, 0.001377, 0.002099, 0.144098, 0.290085, 0.209039, 0.225903, 0.146995, 0.136725, 0.043290, -0.527991, -0.250814, -0.312053, -0.103260, -0.316261, -0.123738, -0.340425, -0.048384, -0.082420, -0.043374, -0.205334, -0.286988, -0.335461, -0.440313, -0.297067, -0.412138, -0.397405, -0.517346, -0.483809, -0.471830, -0.602429, -0.630981, -0.610904, -0.451406, -0.418959, -0.591212, -0.499127, -0.555880, -0.566503, 3.757328, 3.626856, 4.565540, 4.914679, 4.753211, 4.662965, 4.693344, 5.080426, 5.373435, 5.803583, 6.136856, 6.037319, 6.063537, 6.155017, 5.879424, 5.361068, 4.924790, 5.220917, 5.820715, 6.255672, 5.862591, 5.487036, 5.553382, 5.858562, 5.601562, 5.708574, 5.725427, 5.428115, 5.547966, 5.437403, 0.707625, 5.419223, 5.820665, 5.631984, 4.853350, 5.176851, 5.573507, 5.664041, 5.744857, 5.573177, 5.833082, 6.161659, 5.973611, 6.214406, 6.419503, 5.916717, 6.532472, 6.598434, 6.258422, 5.963851, 5.678664, 5.849930, 5.768947, 6.413437, 5.791349, 5.943077, 6.467712, 6.362855, 6.550527, 6.430626, 0.677847, 1.414455, 1.363190, 0.726185, 0.669713, 0.988577, 0.855888, 0.947430, 0.881063, 1.090395, 1.777300, 0.773551, 0.421754, 1.162516, 1.174281, 0.587777, 1.168833, 0.640155, 0.746982, 1.543720, 1.714719, 1.336159, 1.572704, 1.209478, 1.476940, 1.721040, 1.931458, 2.113392, 2.500665, 3.022480, 0.247702, 2.751256, 1.675822, 0.523019, 0.242683, 0.215945, 0.545769, 1.569572, 1.413995, 0.651742, 0.809826, 1.146682, 0.777811, 0.423170, 0.633855, -0.153897, 0.578409, 0.672790, 0.311601, 0.655483, 0.442611, 0.485709, 1.076844, 1.283439, 1.276191, 1.503315, 1.527125, 1.660402, 1.900517, 1.300138, 0.333543, 0.221818, 0.035659, 0.412223, 0.016297, -0.270744, -0.398576, -0.396996, -0.025333, 0.139691, 0.201104, 0.160222, 0.078469, -0.046934, -0.222853, -0.158124, 0.039971, 0.183276, 0.059508, 0.178659, 0.409460, 0.586129, 0.497525, 0.405816, 0.539120, 0.594650, 0.415664, 0.431185, 0.548649, 0.786636, 0.487313, 0.203696, -0.169144, -0.015457, -0.063065, -0.180761, -0.353281, -0.349668, -0.269242, -0.144764, -0.123902, -0.109475, -0.198405, -0.324420, -0.380179, -0.321290, -0.246188, -0.344505, -0.326772, -0.201204, -0.122882, 0.124616, -0.157858, -0.219323, -0.335336, -0.175348, -0.090509, -0.163287, -0.192093, -0.062840, -0.433397, -0.066695, 0.223406, 0.340577, 0.564206, 0.563110, 0.376832, 0.246975, 0.233159, 0.453580, 0.393994, 0.256128, 0.177063, -0.302698, -0.288337, -0.357035, -0.101310, -0.095939, 0.064562, 0.286639, 0.157688, -0.007375, 0.160323, 0.147952, 0.061849, -0.143712, -0.009296, -0.157434, -0.254483, -0.218258, 0.418356, -0.418622, -0.097257, -0.206111, -0.124661, -0.088849, -0.233062, -0.262418, -0.286987, -0.391741, -0.123009, -0.413308, -0.463225, -0.503250, -0.548657, -0.447529, -0.092591, -0.420130, -0.226603, -0.250993, -0.475365, -0.443470, -0.463577, -0.403898, -0.445529, -0.413220, -0.415695, -0.474988, -0.576533, -0.535338, 1.002269, 0.802870, 0.706921, 0.210597, -0.293448, -0.326241, -0.234001, -0.021795, 0.096084, 0.179440, -0.028072, -0.029352, 0.072008, 0.128705, 0.251035, 0.386063, 0.426448, 0.560019, 0.435591, 0.442052, 0.447367, 0.604697, 0.680214, 0.570245, 0.520624, 0.412927, 0.564854, 0.535610, 0.530343, 0.874319, 0.090550, 0.272643, -0.235840, -0.233789, -0.285798, -0.191567, -0.182542, 0.132604, -0.076413, 0.085227, -0.203261, -0.244317, -0.150468, -0.120746, -0.088840, -0.112778, 0.140959, 0.228774, -0.148325, 0.032106, -0.230648, -0.051627, -0.231815, -0.198417, -0.117863, -0.295802, -0.078546, -0.046512, -0.058260, 0.209503, -0.198255, 0.227495, -0.349043, -0.269135, -0.095857, -0.052929, -0.217314, -0.619566, -0.834654, -0.804187, -0.605435, -0.483047, -0.377474, -0.239272, -0.120429, -0.010406, -0.129341, -0.188404, -0.245667, -0.235390, -0.246971, -0.148944, -0.126267, -0.231003, -0.278034, -0.085992, -0.103150, -0.206718, -0.400903, -0.413673, -0.256390, -0.728592, -0.101830, -0.122867, -0.299281, -0.283996, -0.277609, 0.139691, 0.095236, 0.299088, -0.039489, -0.135569, -0.159509, -0.300598, -0.228908, -0.275684, -0.176673, -0.131084, -0.220224, -0.192695, -0.390023, -0.353827, -0.539158, -0.506086, -0.335337, -0.491925, -0.459230, -0.447218, -0.445796, -0.397395, 2.811382, 1.907064, 2.839176, 3.265986, 3.017335, 3.037976, 3.209664, 3.533084, 3.680904, 3.754248, 3.981596, 4.083285, 3.966709, 3.860363, 3.666429, 3.319117, 3.124139, 3.510398, 3.960681, 4.387021, 3.939841, 3.473454, 3.690933, 3.950231, 3.827494, 3.876370, 3.761429, 3.490669, 3.619489, 3.439114, 0.667362, 4.198143, 5.256480, 5.412805, 5.043999, 4.664203, 4.599359, 4.640183, 4.812129, 5.341085, 5.611912, 5.493992, 5.304413, 6.132524, 5.918499, 5.810113, 5.872993, 6.050983, 5.819942, 5.405323, 5.805349, 5.626393, 5.312440, 5.806371, 5.964574, 5.977210, 5.974970, 6.325804, 6.205127, 6.133543, -0.988633, -0.688058, -0.793033, -0.650428, -0.400901, -0.548665, -0.853354, -0.953847, -0.498076, -0.694419, -0.957465, -0.710336, -0.655523, -0.338787, -0.150009, -0.542785, -0.255888, -0.089495, -0.573519, -0.747949, -0.852861, -1.155493, -1.644480, -1.528213, -1.154584, -0.342835, -0.481283, -0.553524, -0.583947, -0.117027, 0.230323, 3.643213, 3.860094, 2.448604, 2.660380, 2.534472, 2.403750, 2.235865, 1.801088, 2.591640, 3.173798, 2.756163, 3.160875, 3.269389, 2.840522, 2.874655, 2.685318, 3.000486, 2.722473, 2.389436, 2.962887, 2.590950, 2.428722, 3.113105, 3.638536, 2.913914, 3.112979, 3.515959, 3.604938, 3.259628, 0.411543, -0.617815, -0.987091, -0.621807, -0.857024, -0.834429, -0.765706, -0.571409, -0.532135, -0.674816, -0.485502, -0.240606, -0.165389, -0.227288, -0.258977, -0.591988, -0.532280, -0.216014, -0.292119, -0.642869, -0.619643, -0.478631, -0.182345, -0.384829, -0.661747, -0.390489, -0.523788, -0.525243, -0.532447, -0.519053, -0.399687, 0.400306, 0.432106, 0.360380, -0.209322, -0.014320, -0.261398, -0.141278, 0.017922, -0.046441, 0.058173, -0.019566, -0.157917, -0.207064, 0.044196, -0.050283, 0.092353, 0.140594, 0.082046, -0.196261, -0.184881, 0.184376, 0.449162, 0.149648, 0.007156, 0.492911, 0.130527, 0.014528, 0.090766, 0.021584, -0.857997, -1.582464, -1.343556, -0.591687, -0.321183, -0.498941, -0.559013, -0.693496, -0.853558, -0.927074, -0.830816, -0.605036, -0.617911, -0.697784, -0.874154, -0.811909, -0.755112, -0.868302, -0.755515, -0.663457, -0.962607, -1.302141, -1.333642, -1.304193, -1.040281, -1.455320, -1.216081, -0.961948, -0.961335, -1.035019, 0.046654, 1.363338, 0.809587, 0.452357, -0.091598, -0.010223, -0.139208, -0.044338, 0.261237, 0.210850, 0.238182, -0.003461, 0.014919, 0.007268, 0.243503, 0.267279, 0.336378, 0.580102, 0.476917, -0.027680, 0.140802, 0.880533, 1.130022, 0.749131, 0.463255, 1.169662, 0.786683, 0.471249, 0.709052, 0.580718, -0.586719, 0.115735, -0.047876, -0.408661, -0.135069, 0.034053, 0.015304, -0.161133, -0.217938, -0.068181, 0.004104, 0.082599, 0.174180, 0.198031, 0.103681, 0.022795, -0.139852, -0.056683, 0.031171, -0.022373, -0.116761, -0.257517, -0.155767, -0.161206, -0.006516, 0.199447, 0.078596, -0.081219, 0.124056, -0.123441, 1.370980, -0.677604, 0.214018, -0.232518, -0.207879, -0.047852, -0.173292, -0.350117, -0.545682, -0.287394, -0.199536, -0.332265, -0.183881, -0.174465, 0.046456, 0.011647, -0.130872, -0.074652, -0.019878, -0.122157, -0.214469, -0.300219, 0.119367, 0.236342, -0.182530, -0.020824, 0.403632, 0.160574, 0.074289, 0.241785, 0.581437, 0.125421, 0.386478, 0.569669, 0.347191, 0.554523, 0.788844, 0.871492, 0.602597, 0.454556, 0.601664, 0.633491, 0.689318, 0.645887, 0.583276, 0.886741, 0.778201, 0.692778, 0.663147, 0.460310, 0.865861, 0.757653, 0.634976, 0.766728, 0.610987, 0.704739, 0.876095, 0.873060, 0.854452, 0.884565, 1.198639, -0.070145, 0.440689, -0.049194, -0.259425, -0.128768, -0.013797, -0.232855, -0.312401, -0.134022, -0.033066, -0.185406, 0.064095, 0.030792, 0.286730, 0.371019, 0.180004, 0.271864, 0.342318, 0.011041, 0.113149, -0.069336, 0.534825, 0.613316, -0.186313, 0.174027, 0.991871, 0.618150, 0.512456, 0.761538, 0.356934, -0.537934, -1.001371, -0.577643, -0.764218, -0.760736, -0.693034, -0.472214, -0.486469, -0.623534, -0.448320, -0.171183, -0.132514, -0.236594, -0.200144, -0.477466, -0.442485, -0.276621, -0.390309, -0.609242, -0.527253, -0.452811, -0.225146, -0.373719, -0.597857, -0.351850, -0.511065, -0.494358, -0.526644, -0.571459, -0.649513, 0.041518, 0.178043, 0.163702, -0.413736, -0.128286, -0.201377, -0.122417, -0.104637, -0.262675, -0.105329, -0.171290, -0.192377, -0.315568, -0.259478, -0.227244, -0.076096, -0.139266, -0.060123, -0.212333, -0.262344, -0.154040, 0.174646, 0.040661, -0.074355, 0.418620, 0.065223, -0.001075, 0.070942, -0.112976, -0.526201, -0.516097, -0.082690, 0.158572, 0.151493, 0.066037, -0.017210, 0.124719, 0.059182, 0.153739, 0.141706, 0.148836, -0.130951, -0.093908, -0.076678, -0.327147, -0.185411, -0.179123, -0.107856, -0.186534, -0.030193, -0.196861, -0.518573, -0.324206, -0.445826, -0.460598, -0.371150, -0.493993, -0.407094, -0.387087, -0.065304, 0.426960, 0.271424, 0.304352, -0.357016, -0.153832, -0.319778, -0.111741, -0.072694, -0.100808, -0.138894, -0.140653, -0.163286, -0.255756, -0.311598, -0.097671, 0.034670, 0.079228, 0.071807, -0.089520, -0.221076, 0.276722, 0.747406, 0.370704, 0.095900, 0.780441, 0.410972, 0.297376, 0.500604, 0.173982, -0.792485, -1.211137, -0.975529, -0.646228, -0.749488, -0.794551, -0.809005, -0.674462, -0.644063, -0.733308, -0.485888, -0.585338, -0.711147, -0.744709, -0.858070, -0.907840, -0.997708, -1.050351, -0.936070, -0.803155, -0.858147, -1.000638, -1.041588, -0.918504, -0.738796, -0.868049, -0.945744, -0.980949, -0.997575, -0.998128, 0.483068, -0.061038, 0.057243, -0.049855, -0.191121, -0.200123, -0.318464, -0.148861, -0.109520, -0.329770, -0.118591, -0.160946, -0.272487, -0.288970, -0.390327, -0.260662, -0.379994, -0.390317, -0.310960, -0.240706, -0.343246, -0.563332, -0.638551, -0.465721, -0.329001, -0.587589, -0.494180, -0.444595, -0.543677, -0.612624, -0.750518, -0.916670, -0.774285, -0.717428, -0.905756, -0.816108, -0.577595, -0.589666, -0.576466, -0.644632, -0.547580, -0.254024, -0.116680, -0.270362, -0.346109, -0.606726, -0.484727, -0.308059, -0.436488, -0.452684, -0.281774, -0.268137, -0.307818, -0.334482, -0.500918, -0.410375, -0.224531, -0.319054, -0.205854, -0.250748, 0.473056, 0.019547, 0.173164, 0.187614, -0.153556, -0.286482, -0.393996, -0.104541, -0.155219, -0.371360, -0.131519, -0.167131, -0.206144, -0.422412, -0.471107, -0.264144, -0.333008, -0.417020, -0.324567, -0.292159, -0.333916, -0.625575, -0.607441, -0.554394, -0.381277, -0.690393, -0.603841, -0.436164, -0.638866, -0.691537, -0.709711, -0.787620, -0.929921, -0.775619, -0.764470, -0.662013, -0.662080, -0.645866, -0.675952, -0.671857, -0.466730, -0.615401, -0.757745, -0.752169, -0.838635, -0.919813, -1.075603, -1.172543, -0.958021, -0.845954, -0.959930, -1.120508, -1.111906, -1.008946, -0.901156, -0.982223, -0.995059, -1.021566, -1.043081, -1.065104, 0.015924, -0.002800, -0.101438, -0.257456, -0.206295, -0.182366, -0.169229, -0.112152, -0.262019, -0.311919, 0.085846, -0.094435, -0.273042, -0.219950, -0.360623, -0.269433, -0.322668, -0.373309, -0.321725, -0.318847, -0.387604, -0.500366, -0.640425, -0.404933, -0.352418, -0.515994, -0.518744, -0.449702, -0.478701, -0.554493, -0.300316, 0.168050, 0.535493, 0.459394, 0.223710, -0.031576, -0.045550, 0.510631, 0.913682, 0.591235, 0.182185, 0.072938, -0.123683, -0.157054, 0.036509, 0.210167, 0.330988, 0.447938, 0.591775, 0.454208, 0.393887, 0.392726, 0.568948, 0.671273, 0.662805, 0.598673, 0.546448, 0.517038, 0.343332, 0.386608, -0.056781, -0.161451, -0.122069, -0.027379, -0.225694, -0.267766, -0.270010, -0.141912, -0.108997, -0.268298, 0.193184, -0.192249, -0.257833, -0.269098, -0.492241, -0.382958, -0.481795, -0.381762, -0.234889, -0.414369, -0.433029, -0.438311, -0.608064, -0.426247, -0.362689, -0.552721, -0.539041, -0.512230, -0.531294, -0.651950, 0.372458, 0.668562, 0.553676, 0.891126, 0.842959, 0.452148, 0.482778, 0.629035, 0.796262, 0.880831, 0.698870, 0.908722, 1.088822, 1.005331, 0.940602, 0.761037, 0.620471, 0.581150, 0.615630, 0.792962, 0.648412, 0.521078, 0.482217, 0.625644, 0.827412, 0.741795, 0.367098, 0.313982, 0.316247, 0.585672, 0.544285, 2.105668, 3.593178, 3.661212, 3.616009, 3.981730, 3.523803, 3.595495, 3.489553, 3.544564, 3.506157, 3.885893, 3.918618, 3.955779, 3.553593, 3.319721, 3.731913, 3.720194, 3.862858, 4.339663, 3.855909, 3.129182, 3.003368, 2.787342, 3.005714, 2.904988, 3.016884, 3.322567, 3.168309, 2.927272, -2.044164, -3.075097, -4.161674, -3.808567, -3.693397, -3.726004, -3.509230, -3.687452, -4.002871, -3.777246, -3.155962, -3.957498, -4.258158, -3.801281, -4.002326, -3.775591, -4.236577, -4.069633, -4.070568, -3.951233, -3.967294, -3.538939, -3.590255, -3.655058, -4.131930, -4.235633, -4.491786, -4.745916, -4.161844, -4.082005, 0.969803, 2.584316, 4.485410, 4.293933, 4.171348, 4.272660, 3.536449, 3.898738, 3.403304, 3.112860, 3.329505, 3.323738, 3.843743, 4.163542, 3.782388, 3.222646, 3.814827, 4.041246, 3.993659, 4.992385, 4.516372, 2.994786, 2.448592, 3.291817, 3.708133, 3.180942, 3.240393, 3.769323, 3.642948, 3.134288, 0.510145, 0.170315, -0.495929, -0.002153, -0.196315, -0.265768, -0.042746, 0.151118, 0.099519, 0.070199, 0.074536, 0.045113, -0.042953, -0.132056, -0.067118, -0.108117, -0.129414, -0.236249, -0.209769, -0.138726, -0.041100, 0.050256, 0.100340, 0.114687, 0.029728, 0.122574, 0.026462, -0.209464, -0.289781, -0.274214, -0.780286, -0.183570, -0.249816, 0.088702, -0.469396, -0.308815, -0.401517, -0.327439, -0.325529, -0.240637, -0.379584, -0.473703, -0.220116, -0.191688, -0.191793, -0.098436, 0.149327, -0.202258, -0.320841, -0.317452, -0.231208, -0.131957, -0.068617, -0.127639, -0.395394, 0.003990, -0.045296, -0.181850, -0.254208, 0.089002, -0.086303, 0.088957, -0.302203, -0.223072, 0.114771, 0.287977, 0.078820, -0.000324, -0.010460, -0.072578, -0.075934, 0.131987, 0.241543, 0.174647, 0.401363, 0.167661, 0.107664, 0.191351, -0.045320, 0.006626, -0.159399, -0.191707, -0.216947, -0.245245, -0.106265, -0.176547, -0.282646, -0.104673, -0.156025, 0.008211, 0.660753, 0.148939, -0.167355, -0.003358, -0.475476, -0.220076, -0.351893, -0.285059, -0.526887, -0.285894, -0.276992, -0.466934, -0.179844, -0.095752, -0.071763, 0.094452, 0.407313, -0.360989, -0.240280, -0.257299, 0.055673, 0.353419, 0.446876, 0.087827, -0.317463, 0.390857, 0.148828, 0.087660, -0.004035, 0.613185, 0.536584, -0.504388, 0.432939, 0.438977, 0.697141, 0.612415, 0.244097, 0.117051, 0.167412, -0.100628, -0.513868, -0.413641, -0.399345, -0.372851, -0.344025, -0.067998, 0.184546, 0.256811, 0.410408, 0.216350, -0.037883, 0.212536, 0.173339, -0.014286, -0.212008, -0.025979, 0.016858, -0.012015, -0.158054, -0.126632, -0.329611, -0.170136, 0.114731, -0.364190, -0.268449, -0.124848, -0.085254, -0.143422, 0.052812, 0.265633, -0.197132, -0.111431, -0.152747, 0.033217, 0.146840, 0.194492, 0.177486, 0.341448, 0.142848, 0.040738, -0.099004, 0.504347, 1.010499, 0.340819, 0.092866, 0.751898, 0.531115, 0.388542, 0.473587, 0.465578, 0.211151, 0.854815, 0.662847, 0.351065, 0.321905, 0.549495, 0.601190, 0.445417, 0.839267, 1.030610, 0.696280, 0.662583, 0.588543, 0.474182, 0.324078, 0.438699, 0.715905, 0.480600, 0.635674, 0.622946, 0.539129, 0.384588, 0.427206, 0.314239, 0.305560, 0.257662, 0.269931, 0.442941, 0.412958, 0.383340, -0.187277, 0.057836, 0.219165, -0.082073, 0.155803, 0.153537, -0.343489, -0.049267, -0.027273, 0.301736, -0.164765, -0.209152, -0.145220, 0.104441, 0.178978, 0.307228, 0.325455, 0.651273, 0.392476, 0.267964, 0.285519, 1.097729, 1.415956, 0.665655, 0.429018, 1.249627, 1.055277, 0.907620, 0.996311, 0.915671, 3.967676, 4.757634, 5.876596, 6.492797, 6.162480, 6.080175, 6.281569, 6.936988, 7.090088, 7.375813, 7.845716, 7.775241, 7.581059, 7.703625, 7.511992, 6.884110, 6.322084, 6.758473, 7.449027, 7.508144, 7.035139, 6.659459, 6.720304, 6.980837, 6.949003, 7.203183, 7.252392, 6.989390, 7.086031, 6.885440, -0.490911, 1.368469, 1.969237, 1.925350, 1.932088, 1.727914, 1.928132, 1.948766, 2.075572, 2.373897, 2.162560, 2.234562, 2.746505, 2.445173, 2.632098, 2.737713, 2.782050, 2.493815, 3.152465, 3.111666, 3.011987, 2.575821, 2.549878, 2.860282, 2.917375, 2.774985, 2.799665, 3.118714, 3.147902, 3.070542, 0.181907, -0.814827, -0.760081, -0.793115, -0.725761, -0.308374, -0.635751, -0.678818, -0.630817, -0.801890, -0.786565, -0.944429, -1.628348, -1.343626, -1.100431, -1.133022, -0.953861, -0.960951, -0.616899, -0.435792, -0.742534, -1.002391, -0.677036, -0.048559, -0.598865, -0.794230, -0.650140, -0.772375, -0.903888, -1.046719, -0.236317, 1.014205, 1.200485, 0.700891, 1.009763, 1.059000, 1.224565, 1.247096, 1.160121, 1.329170, 0.885489, 1.889333, 2.514777, 2.115162, 1.798754, 2.069841, 2.560640, 1.917500, 2.093342, 2.134332, 1.901741, 1.452904, 1.445512, 1.866301, 2.217618, 1.640046, 1.510096, 1.889821, 1.741054, 1.734625, 1.305036, 0.335252, 0.803676, 1.197213, 0.795716, 0.764232, 0.796263, 1.198784, 1.298411, 1.267329, 1.414083, 1.743176, 1.660589, 1.726366, 1.685762, 1.403026, 1.221402, 1.314997, 1.508431, 1.379585, 1.164199, 1.120065, 1.333669, 1.261346, 0.969153, 1.501684, 1.320451, 0.997042, 0.833581, 1.014905, 1.144313, 4.622106, 6.763659, 7.108613, 7.709239, 7.811930, 7.155352, 7.271279, 7.358474, 7.071849, 7.130617, 7.023733, 7.367287, 7.281184, 6.988950, 7.556055, 6.989568, 6.048949, 6.334798, 7.008270, 6.920938, 6.202053, 5.563319, 6.241846, 7.031332, 6.380308, 6.328672, 6.731825, 7.076489, 6.732873, -1.841002, -5.727823, -7.121427, -5.293659, -5.330349, -6.151943, -6.035657, -5.943509, -5.279760, -5.456079, -5.882020, -5.411991, -5.830434, -5.934321, -6.320174, -7.189237, -6.976116, -6.171657, -5.085593, -5.917212, -5.613502, -5.970484, -5.735721, -6.363364, -6.956727, -6.543504, -6.472921, -6.148737, -6.331615, -7.161756, 1.295631, 5.573144, 6.895395, 6.960180, 7.637659, 7.073774, 6.405292, 7.059183, 6.649230, 6.682336, 6.186888, 6.337844, 6.416282, 6.397913, 6.901603, 7.995935, 7.247184, 5.722527, 6.055744, 6.552185, 6.474686, 5.264298, 4.512713, 5.606170, 7.031442, 5.880870, 5.411535, 6.069055, 6.245737, 5.926549, 0.479435, -0.595244, 0.489181, 0.483957, 0.723042, 0.723319, 0.393800, 0.305283, 0.247488, -0.031289, -0.408490, -0.332305, -0.286709, -0.228509, -0.167839, 0.030305, 0.263677, 0.287538, 0.437571, 0.254135, 0.056918, 0.260881, 0.226022, 0.144177, 0.026776, 0.069453, 0.032334, 0.001681, -0.134673, -0.019083, -0.224452, -0.020048, 0.240269, -0.411229, -0.033090, -0.076783, 0.081202, 0.121583, 0.207691, 0.258031, 0.116165, 0.282899, 0.064777, 0.319059, 0.531730, 0.404801, 0.136691, 0.276220, 0.335766, 0.230003, 0.076459, 0.858862, 0.922896, 0.626632, 0.396343, 0.533869, 0.385154, 0.451189, 0.606185, 0.718714, -0.446251, -0.277470, -0.164402, -0.159414, 0.063901, -0.238390, -0.373438, -0.996875, -1.049257, -0.902444, -0.840198, -0.946279, -1.049289, -1.058291, -1.392302, -1.254485, -0.813269, -0.967659, -0.803907, -1.125693, -1.150766, -1.540257, -1.733209, -1.450601, -1.351243, -1.484541, -1.465996, -1.410836, -1.576639, -1.853790, -0.065610, 0.012739, 0.152567, -0.493502, 0.016951, -0.085447, 0.133784, 0.380447, 0.588537, 0.546296, 0.331691, 0.497290, 0.234639, 0.580904, 1.060602, 0.790292, 0.288839, 0.737438, 0.717517, 0.534224, 0.625687, 1.709559, 1.743087, 1.369332, 1.001379, 1.132438, 1.059904, 1.068243, 1.324185, 1.388731, -0.868791, -1.177391, -1.156407, -0.893166, -0.651544, -0.557455, -0.616593, -0.538677, -0.669622, -0.816503, -0.622577, -0.612583, -0.724686, -0.683805, -0.675414, -0.872180, -1.064204, -1.055484, -0.874629, -0.741944, -0.826107, -1.060176, -1.114510, -0.997361, -0.918625, -0.976087, -1.004403, -1.007190, -0.983598, -1.073482, -0.160591, -0.038666, 0.429863, 0.286752, -0.031509, 0.086321, 0.052682, 0.268499, 0.125509, -0.221116, -0.075681, -0.242700, -0.278872, -0.201629, -0.238830, -0.161914, -0.330295, -0.320997, -0.244221, -0.119095, -0.321947, -0.550580, -0.625393, -0.360715, -0.184673, -0.405906, -0.457486, -0.486186, -0.435018, -0.568594, -0.055280, -0.511494, -0.515903, -0.463127, -0.198387, 0.328915, 0.550616, 0.709407, 0.736023, 0.314452, 0.085552, -0.086977, 0.080097, 0.170504, 0.152385, -0.206748, -0.375665, -0.491584, -0.216738, 0.108030, 0.232728, 0.054268, -0.165450, -0.050134, -0.050212, -0.199250, -0.009697, -0.138889, -0.103045, -0.072614, -0.472880, 0.048214, 0.003947, 0.411596, 0.048015, 0.212569, 0.330436, 0.222100, 0.040348, -0.241004, -0.063805, -0.440154, -0.376162, -0.371361, -0.351910, -0.359986, -0.398466, -0.279359, -0.104091, -0.141033, -0.297133, -0.404352, -0.601272, -0.441685, -0.200108, -0.444649, -0.517428, -0.547980, -0.437974, -0.601228, 2.273773, 1.392542, 2.121588, 2.604337, 2.448883, 2.490647, 2.416747, 2.778583, 2.874084, 3.165760, 3.271107, 3.263073, 3.221070, 3.031922, 2.947167, 2.450938, 2.280171, 2.559166, 2.871361, 2.980209, 2.628225, 2.283381, 2.220675, 2.327241, 2.284348, 2.497135, 2.439943, 2.136556, 2.112479, 2.043909, 0.484694, 2.172499, 3.325487, 3.315942, 2.909685, 2.521388, 2.530676, 2.638037, 2.918052, 2.879272, 2.448435, 2.876620, 2.940135, 2.865701, 2.977454, 3.336334, 3.303508, 3.362418, 4.198942, 4.232042, 4.472520, 4.197980, 3.501337, 3.988993, 4.192730, 4.008265, 4.518335, 4.836612, 4.435771, 4.453280, 0.719842, 1.606821, 2.687412, 1.980394, 1.566986, 1.145229, 0.551238, 0.782649, 1.315546, 1.571086, 1.163006, 1.515905, 1.407014, 1.307212, 1.616206, 1.609751, 2.045012, 1.706566, 1.865330, 2.205638, 2.608581, 2.573268, 2.464507, 2.450100, 2.317763, 2.818768, 2.637650, 2.012590, 2.104032, 2.272846, 0.460365, 3.080697, 4.088178, 3.061887, 2.591696, 2.362741, 2.687903, 1.860676, 1.583891, 1.880018, 1.771240, 2.557460, 2.351475, 2.696410, 2.736237, 2.826324, 3.316305, 3.636413, 4.196125, 3.646867, 4.041446, 3.607481, 2.471828, 3.033196, 3.714812, 3.224337, 3.564296, 4.152979, 3.712891, 3.554695, 0.987173, 0.826290, 0.724493, 0.322572, -0.203514, -0.272334, -0.189498, 0.079342, 0.207636, 0.265318, 0.023203, 0.009693, 0.127336, 0.204004, 0.321342, 0.395739, 0.458087, 0.624157, 0.451619, 0.438796, 0.454286, 0.643022, 0.758333, 0.617948, 0.537083, 0.432586, 0.563688, 0.569520, 0.579654, 0.865110, -0.005998, 0.248896, -0.268740, -0.179340, -0.204596, 0.114801, -0.081238, 0.080778, -0.012672, -0.054242, -0.260195, 0.044865, 0.020754, 0.034906, 0.003757, -0.000187, 0.031347, 0.267525, -0.097304, -0.037140, -0.177976, 0.014367, -0.236613, -0.191123, 0.020173, -0.227169, -0.011709, 0.036267, -0.084652, 0.178776, 0.222906, 0.408356, 0.538105, 0.551500, 0.655345, 0.757855, 0.662096, 0.608136, 0.711169, 0.679925, 0.534626, 0.602420, 0.559735, 0.452624, 0.409903, 0.546146, 0.644324, 0.599830, 0.495588, 0.434819, 0.581702, 0.433456, 0.211847, 0.366118, 0.520987, 0.540008, 0.522318, 0.435234, 0.395444, 0.347114, -0.611723, -0.700589, 0.002210, -0.081908, -0.152620, 0.001760, -0.165841, 0.141977, -0.017629, -0.113725, -0.306608, 0.075785, -0.076066, -0.081297, -0.138575, -0.185129, -0.280481, -0.079998, -0.240647, -0.093595, -0.282041, -0.384560, -0.506572, -0.469870, -0.209344, -0.475905, -0.399003, -0.362152, -0.482608, -0.449932, 0.942207, 0.764243, 0.626538, 0.340586, -0.225999, -0.350741, -0.299942, -0.038542, 0.103285, 0.173134, -0.113640, -0.038005, 0.094772, 0.201841, 0.341931, 0.317764, 0.348148, 0.582567, 0.421234, 0.360791, 0.292025, 0.531053, 0.717158, 0.592079, 0.540450, 0.378132, 0.420694, 0.500814, 0.564439, 0.810230, 0.012143, 0.377699, -0.522392, -0.328154, -0.360863, -0.167618, -0.322465, -0.210416, -0.287178, -0.094643, -0.323197, -0.252436, -0.145377, -0.070196, -0.215443, -0.056347, 0.030570, 0.362008, -0.124604, -0.082531, -0.320601, -0.139573, -0.170274, -0.272645, -0.023335, -0.345810, -0.247889, -0.035055, -0.070401, 0.206883, 0.195601, -0.268198, 0.036056, 0.068710, -0.181455, -0.224056, 0.100532, 0.123710, -0.038079, -0.316402, -0.255480, -0.053207, -0.109363, 0.062670, -0.024824, 0.060739, 0.193529, 0.384751, 0.188410, 0.022303, 0.224428, 0.353092, 0.266689, 0.219392, 0.353724, 0.203117, 0.018803, 0.009919, 0.288114, 0.345594, -0.676971, -0.695559, -0.197285, -0.135218, -0.231362, -0.254316, -0.429040, -0.332349, -0.371209, -0.106864, -0.528827, -0.449937, -0.353025, -0.073395, -0.432970, -0.255105, -0.309718, -0.004997, -0.300227, -0.255798, -0.455866, -0.399478, -0.473978, -0.510668, -0.234172, -0.591037, -0.486149, -0.433030, -0.441060, -0.350577, 2.226039, 3.854280, 4.577529, 4.946181, 4.689937, 4.687063, 4.708250, 5.231292, 5.534954, 5.765965, 6.091192, 6.042284, 6.156422, 6.031808, 5.567099, 5.173380, 4.959408, 5.062616, 5.599008, 5.886525, 5.250996, 4.947930, 4.989169, 5.385837, 5.376707, 5.604577, 5.381516, 5.151793, 5.208251, 5.228285, 1.837936, 3.182586, 5.863153, 6.700033, 6.463827, 6.168476, 6.358425, 6.739260, 6.503495, 7.118694, 7.496688, 7.109748, 6.640735, 7.438538, 6.857742, 7.247862, 7.289277, 7.872087, 8.393287, 8.732239, 7.967428, 7.929743, 7.974296, 7.747074, 7.396729, 8.097455, 8.281541, 8.253023, 8.045754, 7.748394, -2.877804, -1.306220, -1.445175, -1.630002, -1.971336, -1.201489, -0.929251, -0.976732, -1.174404, -1.528337, -1.107157, -1.320517, -1.083631, -0.989393, -0.864020, -0.528378, -0.612290, -0.756147, -1.351921, -1.783860, -2.184817, -1.397103, -1.149741, -0.936152, -0.595852, -0.764352, -1.575566, -0.757716, -0.610799, -0.810178, 3.240208, 3.505617, 6.697734, 6.917758, 7.159796, 6.552060, 6.241822, 7.710168, 8.048632, 8.458648, 8.273396, 7.819930, 7.392867, 7.403783, 7.286946, 8.061345, 7.946250, 8.977978, 9.589005, 9.423548, 8.597722, 7.830919, 7.697262, 8.527925, 8.517794, 8.032353, 8.149363, 8.923935, 8.732318, 7.924402, 0.899526, 0.316652, 0.563368, 0.993144, 1.103512, 0.935446, 0.889024, 1.109984, 1.239027, 1.265367, 1.254816, 1.255781, 1.234963, 1.169791, 1.187337, 0.971852, 0.896349, 0.918800, 1.057022, 1.046866, 0.867668, 0.790914, 0.827826, 0.824769, 0.762469, 0.809314, 0.681448, 0.611345, 0.587849, 0.476811, 0.649908, 0.337123, 0.218974, -0.117398, -0.114187, 0.000405, 0.039768, 0.026059, 0.127304, 0.023531, -0.029343, -0.082530, -0.016702, -0.088098, 0.028767, -0.028872, -0.103875, -0.105318, -0.155478, -0.033204, -0.149175, -0.303280, -0.263608, -0.250836, -0.179227, -0.166353, -0.306208, -0.260874, -0.251620, -0.337022, 0.345997, 0.647035, 0.642460, 0.439098, 0.463718, 0.341969, 0.127611, 0.582016, 0.696573, 0.384724, 0.352966, 0.510142, 0.611807, 0.708886, 0.672140, 0.154287, 0.046183, 0.367375, 0.550101, 0.303818, 0.267907, 0.333083, 0.373857, 0.236241, 0.441814, 0.272137, 0.339569, 0.485184, 0.543191, 0.344105, 0.467920, 0.464404, 0.266848, -0.135250, -0.140060, -0.095071, -0.068781, 0.032956, 0.294157, 0.180068, -0.146437, -0.136086, 0.093751, -0.014373, 0.012895, 0.075595, -0.155452, -0.105007, -0.112259, -0.131062, -0.072998, -0.278858, -0.190662, -0.271612, -0.149647, -0.083614, -0.330020, -0.355593, -0.213314, -0.326910, -0.647646, -1.479565, -1.659531, -0.942590, -0.782018, -0.689776, -0.708324, -0.544947, -0.607922, -0.827604, -0.651875, -0.555649, -0.732235, -0.676994, -0.727401, -1.175745, -1.344256, -1.217849, -0.856935, -0.711131, -0.869510, -1.019522, -1.114377, -1.079859, -1.065396, -1.103008, -1.252373, -1.116490, -1.173531, -1.250101, -0.926951, -0.060810, 0.274639, 0.123344, -0.430222, -0.194521, -0.369625, -0.108521, -0.230054, -0.426110, -0.329285, -0.205348, -0.228054, -0.123068, -0.358386, -0.237431, -0.247620, -0.271235, -0.336636, -0.223083, -0.404999, -0.615863, -0.711750, -0.463814, -0.322736, -0.542509, -0.589144, -0.395076, -0.464062, -0.600967, 0.037595, 0.050126, -0.118221, 0.078773, 0.027544, 0.035791, -0.032796, -0.105057, -0.121783, -0.274648, -0.187711, -0.191866, -0.217669, -0.109265, 0.119234, 0.011775, -0.171643, -0.076799, -0.245895, -0.238062, -0.300789, -0.113780, 0.019646, -0.027930, -0.040483, -0.124458, 0.068760, 0.065525, 0.045394, 0.004634, -0.671008, -0.133730, 0.080985, 0.260133, -0.454302, -0.144404, -0.417314, -0.201038, -0.167822, -0.454887, -0.315297, -0.146488, -0.278499, -0.101473, -0.308054, -0.274091, -0.320907, -0.432305, -0.360884, -0.217994, -0.408930, -0.568952, -0.670468, -0.530539, -0.365407, -0.608139, -0.638759, -0.413841, -0.566908, -0.611887, -1.124267, -0.598554, -0.279143, -1.022417, -0.812074, -0.469013, -0.107731, -0.623827, -0.915476, -0.495903, -0.274013, -0.221579, -0.293145, -0.345880, -0.418067, -0.362980, -0.532066, -0.483788, -0.325011, -0.288855, -0.415190, -0.402352, -0.638654, -0.576763, -0.452006, -0.308918, -0.331821, -0.459988, -0.437354, -0.426948, 2.167239, -0.146536, 0.051482, -0.193913, 0.032038, -0.317201, -0.147926, -0.257709, -0.352353, 0.015119, -0.070420, -0.043400, 0.047851, -0.114112, -0.146291, 0.011258, -0.157563, -0.091002, -0.154810, -0.215387, -0.403579, -0.224139, -0.180137, -0.104154, -0.014591, 0.170891, 0.166967, 0.004347, 0.100836, 0.297392, -0.610485, -0.297602, -0.149949, -0.192716, -0.029024, -0.028690, 0.068635, 0.014849, -0.036446, -0.274035, -0.385071, -0.530497, -0.549211, -0.297193, -0.177814, -0.080827, -0.162924, -0.093004, -0.030589, -0.240605, -0.102335, -0.191872, -0.263594, -0.195641, -0.417004, -0.439656, -0.293022, -0.286253, -0.403343, -0.276894, 2.138322, -0.193386, 0.251543, 0.247673, -0.055553, -0.309644, -0.179239, -0.255273, -0.318808, 0.416665, 0.462772, 0.404353, 0.333497, -0.081075, -0.100798, -0.054777, 0.083618, 0.257928, -0.176516, -0.226794, -0.235250, 0.059757, 0.137175, 0.140834, 0.293966, 0.577979, 0.658574, 0.490269, 0.622957, 0.867604, 0.374585, -0.546673, 0.393915, 0.377295, 0.571011, 0.632458, 0.338971, 0.190434, 0.146239, -0.182187, -0.520019, -0.439557, -0.457895, -0.402887, -0.329348, -0.086360, 0.163936, 0.163035, 0.299647, 0.192526, 0.036065, 0.074743, 0.092911, -0.044314, -0.151696, -0.014044, 0.011847, -0.023678, -0.112224, -0.068021, -0.153834, -0.036363, 0.190314, -0.367221, -0.189247, -0.192636, -0.254860, -0.243757, -0.119306, -0.030094, -0.273690, -0.267861, -0.195861, -0.079391, -0.022240, 0.001379, -0.041146, 0.026734, -0.032415, -0.103347, -0.231426, 0.426277, 0.807276, 0.269449, -0.094816, 0.171708, 0.163080, 0.234531, 0.348067, 0.249343, -0.315950, -0.337240, -0.185756, -0.143264, 0.278516, 0.265392, -0.069138, -0.418697, -0.336614, -0.416211, -0.454794, -0.327411, -0.490688, -0.513443, -0.693315, -0.712568, -0.850392, -0.746638, -0.741489, -0.753461, -0.674688, -1.261150, -1.392866, -1.088171, -0.745698, -1.016888, -1.290373, -1.083129, -1.480178, -1.218342, 0.043959, 0.067251, -0.051736, -0.218615, 0.170877, -0.181279, -0.375373, -0.022697, 0.025486, 0.228065, -0.179010, -0.069556, -0.196810, -0.060617, 0.165154, 0.244993, 0.275774, 0.372859, 0.199878, 0.111498, 0.132788, 1.251065, 1.470874, 0.877782, 0.220826, 0.649691, 0.744048, 0.885626, 1.083979, 0.912101, 1.652350, 3.547178, 4.985480, 5.728924, 5.303339, 5.366006, 5.449831, 6.233596, 6.423460, 6.533746, 7.159101, 6.889844, 6.442746, 6.262536, 6.658586, 5.931611, 5.381063, 5.530843, 6.405471, 6.526008, 5.806357, 5.334833, 5.512667, 5.776629, 5.948085, 6.177386, 5.937815, 5.470582, 5.683383, 5.718588, 1.459198, 2.856359, 4.836527, 5.422337, 5.901351, 6.328373, 7.389206, 7.747968, 8.045387, 8.374146, 9.266948, 8.780303, 9.054564, 9.998716, 10.046144, 10.269948, 8.877315, 8.768029, 8.952692, 8.722667, 11.080588, 10.320036, 9.096550, 10.060250, 10.384700, 8.755828, 9.282490, 8.907900, 9.528036, 8.922774, -1.500063, 2.386107, 4.026552, 4.118918, 4.005744, 4.478374, 6.083685, 7.350970, 6.571774, 7.782130, 7.717031, 6.172290, 6.919976, 7.316604, 7.008448, 7.612735, 8.046352, 6.978959, 7.351694, 6.707404, 9.609748, 8.018655, 7.538990, 8.862368, 9.065064, 8.577249, 9.835804, 8.492944, 8.695919, 8.194789, 3.087770, 5.510531, 7.121910, 8.793783, 8.447962, 9.303242, 9.295560, 8.648383, 9.622732, 10.388199, 11.753206, 12.041667, 11.147207, 12.076743, 12.658831, 12.769855, 9.671738, 9.466227, 10.125064, 11.003134, 12.375681, 9.797839, 8.645519, 10.997481, 12.297468, 9.727294, 10.584767, 10.322402, 10.278182, 9.281795, -0.198822, -0.324811, 0.382307, -0.250272, -0.409196, -0.569802, -0.785799, -0.552629, -0.353540, -0.443301, -0.355101, -0.179293, 0.012011, 0.102019, 0.099014, -0.173750, 0.040333, 0.442043, 0.384753, -0.021145, -0.022299, 0.210610, 0.464163, 0.267713, -0.059738, 0.063183, 0.245567, 0.163174, 0.089672, -0.029642, -0.425034, -0.337702, 0.173344, 0.018754, 0.055461, -0.142962, -0.371116, 0.073143, -0.016599, -0.239937, -0.193373, -0.252003, -0.274152, -0.274909, -0.296071, -0.195534, 0.103084, 0.275621, 0.207619, -0.241058, -0.258899, -0.328299, -0.165971, -0.120082, -0.088617, -0.101178, -0.238176, -0.211661, -0.030569, -0.344923, -0.103734, -0.364789, -0.320497, -0.296234, -0.396998, -0.283365, -0.277658, -0.209764, -0.150427, -0.103051, -0.118513, -0.304232, -0.331289, -0.104788, 0.073586, -0.097487, -0.000644, 0.016299, 0.081185, -0.055968, -0.098910, -0.098490, -0.196300, -0.190223, -0.193439, -0.222584, -0.170961, -0.155699, -0.147468, -0.140048, -0.181339, 0.785329, -0.284575, -0.309462, -0.113364, -0.070376, -0.368842, 0.009623, -0.025146, -0.355492, -0.237471, -0.284480, -0.306560, -0.314801, -0.314051, -0.308616, -0.089261, 0.037588, 0.083207, -0.240778, -0.294346, -0.489323, -0.397656, -0.293124, -0.310838, -0.357540, -0.399361, -0.366410, -0.288998, -0.463048, -1.123136, -0.444100, -0.198941, -1.010939, -0.657029, -0.342238, -0.003467, -0.399432, -0.656778, -0.389877, -0.210947, -0.157292, -0.284096, -0.360547, -0.374354, -0.316669, -0.471390, -0.433519, -0.251147, -0.294330, -0.433359, -0.462987, -0.651348, -0.564835, -0.481508, -0.323715, -0.386561, -0.470048, -0.480659, -0.456225, 2.262338, -0.241268, 0.239138, -0.354895, -0.214089, -0.455500, -0.086681, -0.245391, -0.120258, -0.172844, -0.211666, -0.263718, -0.090273, 0.085195, 0.135321, -0.117106, -0.387206, -0.319570, -0.116368, -0.185863, -0.296401, -0.127192, 0.103879, 0.010319, -0.169210, 0.188265, 0.430993, 0.156354, 0.207030, 0.366506, 0.603580, 0.156537, 0.163686, -0.386812, -0.459974, -0.235613, -0.046117, -0.116365, -0.176032, 0.080426, 0.230215, -0.160698, -0.061631, 0.026200, 0.085841, -0.018781, -0.322852, -0.434639, -0.065900, -0.196597, -0.035876, 0.352757, 0.329752, 0.061982, -0.076507, -0.176937, 0.024676, -0.028248, 0.056481, -0.020790, 1.793762, -0.267287, 0.326659, -0.226877, -0.330614, -0.389813, 0.173760, -0.159111, -0.039224, -0.202539, -0.067272, -0.053494, 0.120908, 0.323930, 0.534407, 0.042584, -0.187473, 0.043732, 0.058884, -0.099194, 0.021847, 0.339252, 0.612543, 0.473178, 0.093534, 0.635728, 1.093744, 0.758186, 0.865248, 0.995766, -0.787754, -1.456294, -1.481639, -0.903678, -0.799542, -0.669855, -0.673755, -0.538268, -0.632006, -0.855243, -0.623732, -0.639530, -0.786583, -0.719374, -0.749400, -1.034042, -1.225099, -1.179913, -0.857532, -0.686521, -0.857010, -1.023839, -1.087522, -0.985917, -0.941845, -1.042053, -1.222779, -1.114480, -1.105480, -1.249333, 0.049998, 0.168761, 0.052671, -0.077104, -0.499837, -0.099752, -0.374471, -0.104045, -0.157116, -0.244707, -0.124012, -0.242021, -0.303095, -0.147189, -0.115798, -0.248953, -0.339795, -0.254446, -0.208550, -0.279308, -0.587423, -0.695633, -0.693615, -0.407690, -0.362338, -0.484354, -0.577783, -0.507745, -0.572850, -0.672338, 0.843917, 0.734456, 0.397893, -0.449820, -0.361469, -0.244945, -0.006292, 0.151025, -0.094831, 0.108594, 0.465390, 0.242665, 0.107057, 0.098233, -0.006716, 0.181539, 0.136824, 0.142479, 0.224530, 0.182568, -0.089624, 0.061602, -0.017758, 0.171855, -0.114167, -0.089763, 0.198557, 0.089430, -0.048630, 0.003122, 0.273856, 0.181538, -0.046573, 0.231799, -0.371107, -0.114549, -0.309678, -0.112246, -0.163744, -0.184919, -0.004381, -0.083046, -0.336183, -0.117824, -0.075814, -0.285474, -0.519120, -0.272428, -0.277103, -0.368826, -0.577615, -0.681035, -0.649793, -0.424040, -0.419476, -0.577516, -0.647541, -0.621299, -0.659642, -0.700514, -1.133121, -0.741341, -0.385295, -0.957035, -0.697747, -0.506921, -0.110919, -0.441205, -0.808965, -0.400209, -0.175562, -0.182369, -0.360274, -0.382162, -0.415552, -0.378656, -0.557236, -0.488793, -0.284210, -0.229393, -0.407027, -0.390668, -0.584955, -0.552724, -0.440883, -0.351981, -0.387504, -0.499738, -0.483186, -0.464552, 2.658388, 0.239545, 0.140827, -0.155157, -0.011833, -0.326209, -0.023737, -0.230974, -0.314776, 0.077406, -0.035159, -0.152104, 0.095116, 0.016511, -0.055707, -0.128059, -0.164288, -0.008478, -0.069345, -0.035733, -0.097441, -0.085016, 0.060618, 0.054814, 0.051151, 0.233985, 0.263772, 0.134531, 0.199257, 0.311331, 0.543842, 0.348578, 0.361830, 0.744507, 0.702042, 0.626358, 0.684105, 0.502808, 0.471351, 0.614728, 0.795412, 0.686076, 1.009978, 0.950336, 0.756176, 0.465896, 0.535033, 0.704407, 0.785032, 0.653832, 0.967397, 0.771665, 0.892780, 0.874280, 0.827870, 0.886877, 0.778791, 0.723726, 0.749903, 0.641258, 2.378190, 0.373802, 0.732767, 0.069990, -0.269775, -0.293055, 0.121912, -0.115634, -0.297294, 0.417425, 0.233283, 0.200408, 0.488224, 0.117388, 0.203372, -0.032082, 0.058853, 0.484270, -0.057397, -0.054190, 0.084707, 0.307841, 0.548401, 0.383477, 0.403306, 0.727577, 0.883494, 0.549129, 0.795672, 0.904797, 0.960964, 0.817688, 0.664309, 0.382730, 0.022931, -0.102275, -0.086221, 0.074063, 0.216675, 0.388053, 0.188680, 0.148820, 0.229077, 0.260858, 0.330279, 0.396903, 0.452265, 0.570675, 0.440931, 0.394440, 0.408453, 0.574420, 0.702727, 0.549302, 0.514239, 0.433333, 0.522167, 0.603641, 0.577090, 0.752667, -0.130983, 0.668914, -0.076435, 0.155619, 0.182753, 0.367582, 0.200826, 0.222103, 0.075357, 0.216092, 0.026554, 0.153418, 0.129342, 0.247838, 0.166993, 0.052093, 0.112033, 0.252694, -0.083977, 0.014971, -0.162394, 0.091456, -0.077686, -0.243651, -0.002711, -0.084194, 0.061024, 0.043633, 0.001286, 0.148946, -0.007830, -0.410202, -0.758957, -0.602340, -0.781349, -0.810512, -0.590023, -0.554807, -0.629786, -0.492254, -0.471915, -0.660152, -0.474581, -0.422889, -0.570586, -0.934477, -0.918906, -1.197123, -0.869375, -0.667312, -0.506482, -0.611555, -0.505790, -0.557119, -0.701982, -0.741298, -0.684565, -0.656415, -0.724797, -0.619046, -0.708336, -0.356644, 0.065845, 0.142587, 0.065624, 0.424374, 0.165477, 0.138078, 0.129389, 0.046015, -0.208366, 0.141426, 0.190540, 0.294055, 0.066991, 0.008100, 0.047539, -0.033241, -0.083506, -0.045312, -0.292250, -0.255681, -0.353432, -0.433273, -0.233968, -0.335847, -0.156261, -0.282350, -0.396840, -0.384212, -0.628370, -0.782461, -0.855457, -0.671116, -0.760473, -0.776413, -0.780516, -0.684828, -0.602704, -0.665227, -0.483463, -0.571187, -0.691561, -0.747444, -0.872825, -0.852270, -0.971260, -1.084561, -1.001908, -0.927231, -0.962042, -1.082802, -1.104887, -1.006415, -0.831414, -0.946558, -0.944858, -0.981338, -1.013701, -0.980274, 0.225290, 0.024215, -0.032343, -0.008464, -0.054247, -0.132865, -0.133755, -0.035208, -0.032993, -0.277195, 0.003301, -0.154962, -0.211966, -0.155568, -0.240221, -0.218766, -0.292873, -0.308497, -0.228913, -0.060779, -0.211845, -0.582863, -0.489217, -0.348015, -0.199254, -0.440899, -0.414898, -0.392151, -0.420863, -0.462874, 1.085678, 0.985178, 1.096973, 0.985355, 0.913693, 0.809923, 0.748990, 0.737142, 0.699298, 0.674227, 0.758015, 0.790757, 0.800072, 0.745009, 0.612721, 0.652937, 0.759186, 0.660335, 0.698145, 0.941932, 0.766849, 0.695506, 0.726578, 0.783720, 0.891111, 0.742257, 0.653155, 0.739227, 0.816554, 0.766921, 0.178378, -0.151158, 0.068283, 0.214306, -0.083768, -0.151367, 0.029288, 0.002611, 0.083022, -0.252680, -0.012497, -0.136867, -0.224587, -0.162670, -0.263163, -0.357428, -0.278588, -0.334610, -0.337779, 0.025366, -0.321112, -0.578459, -0.510034, -0.427845, -0.281822, -0.503477, -0.524017, -0.552738, -0.541435, -0.463014, -1.578896, -0.599312, 0.225670, 1.222854, 1.841585, 1.735193, 1.553967, 1.578017, 1.475744, 1.103450, 0.923940, 1.277447, 1.206659, 1.469020, 1.705666, 2.075966, 2.328769, 1.506097, 0.774476, 1.002996, 1.736854, 1.307873, 0.842854, 1.045641, 0.852151, 0.974634, 1.387582, 1.969447, 1.606619, 0.938584, -0.080720, -0.410814, 0.029442, -0.132915, -0.053687, -0.228092, -0.394394, -0.371933, -0.218873, -0.194158, -0.426340, -0.348071, -0.335032, -0.248114, -0.322306, -0.454762, -0.161030, -0.498927, -0.415673, -0.390039, 0.718841, -0.149413, -0.665361, -0.226144, -0.426454, -0.504187, -0.433659, -0.271955, -0.524698, -0.517289, 1.012218, 0.687569, 0.436202, 0.426503, 0.432741, 0.526155, 0.336137, 0.074091, 0.237003, 0.310283, -0.034606, -0.194950, 0.112658, 0.254725, 0.115650, -0.014475, -0.022691, 0.236520, 0.323448, 0.257222, 0.439815, 0.237880, 0.109465, 0.165870, 0.245023, 0.327509, 0.044640, 0.056095, 0.039363, 0.250009, 0.638971, -0.056668, 0.117369, -0.149588, 0.250238, 0.046283, -0.548728, -0.490893, -0.165058, -0.116623, -0.192657, -0.183114, -0.259427, 0.001814, -0.315275, -0.441453, -0.212882, -0.520001, -0.567573, -0.204241, 0.277799, -0.428736, -0.797002, -0.346747, -0.363067, -0.505234, -0.516630, -0.397527, -0.597750, -0.612426, 0.405158, 0.173871, -0.643180, -0.265310, -0.546396, -0.679180, -0.475062, -0.325361, -0.355381, -0.376998, -0.390835, -0.298313, -0.400378, -0.420441, -0.322660, -0.408835, -0.456391, -0.506098, -0.601624, -0.569736, -0.400479, -0.315785, -0.192129, -0.302228, -0.413474, -0.410656, -0.437141, -0.417348, -0.463187, -0.392758, -0.617911, -0.478735, -0.086975, 0.080859, -0.268319, -0.073428, -0.064843, -0.143529, -0.316237, -0.211797, -0.262945, -0.105490, -0.071736, -0.095899, -0.174003, -0.130082, 0.123292, -0.001478, -0.053431, 0.060649, 0.020197, -0.001467, 0.150270, 0.145718, -0.022262, 0.046589, 0.018251, -0.029466, 0.079091, 0.341901, -0.811609, -0.240474, -0.545710, -0.531256, -0.153370, -0.263287, -0.574261, -0.600437, -0.517982, -0.483671, -0.449813, -0.543430, -0.668849, -0.692894, -0.749116, -0.928399, -0.922015, -0.960280, -0.977337, -1.122592, -1.117083, -1.217269, -1.265824, -1.316323, -0.943393, -1.071613, -1.191705, -0.964700, -1.227448, -1.473630, 0.227206, -0.477952, 0.104461, 0.083976, -0.202882, -0.105507, 0.123951, 0.072220, -0.235906, -0.182438, -0.231433, 0.145240, 0.257631, 0.113208, -0.078344, 0.125461, 0.624664, 0.329799, 0.202450, 0.484253, 0.498037, 0.636462, 0.734108, 0.670138, 0.302934, 0.373293, 0.372593, 0.325048, 0.623783, 1.028867, 1.681888, 1.982926, 2.534631, 2.587493, 2.454107, 2.399049, 2.642519, 2.833709, 2.533104, 2.712277, 2.922018, 2.724458, 2.725853, 2.721384, 2.818805, 2.519324, 2.086209, 2.290324, 2.459817, 2.394238, 2.212521, 2.290088, 2.387277, 2.238270, 1.955235, 2.086823, 2.246324, 1.992591, 1.927562, 1.912471, 0.788886, 2.255407, 3.312268, 4.186428, 5.212052, 4.697289, 4.087419, 4.075209, 4.925439, 4.450198, 4.393764, 5.962915, 5.711421, 5.526774, 5.674965, 5.271260, 4.933189, 5.466626, 5.304313, 4.329943, 5.099492, 4.984076, 4.138822, 4.673114, 5.674081, 5.323195, 4.999981, 4.982168, 5.146167, 5.339876, 3.333539, 3.131357, 2.730717, 3.344563, 4.303324, 3.075822, 2.645515, 2.563842, 2.837338, 3.664466, 3.090404, 3.341974, 3.490948, 3.905018, 4.030650, 4.103004, 4.135030, 4.416417, 3.739052, 3.605480, 4.317893, 3.714727, 3.481721, 4.679427, 5.636411, 5.209698, 5.051729, 5.445260, 5.585647, 4.837066, 0.807587, 1.143234, 1.689545, 1.965822, 2.076109, 1.462318, 1.019965, 1.566821, 2.804610, 2.176100, 1.976564, 3.276980, 3.379852, 3.489331, 3.449322, 3.812611, 3.582654, 3.133353, 3.433997, 2.535702, 3.290507, 2.685527, 1.916759, 3.027211, 4.442644, 3.684864, 3.466928, 4.443244, 4.251730, 4.188128, 4.075431, 4.789131, 5.978047, 6.586472, 6.257521, 6.167282, 6.326792, 7.043994, 7.251770, 7.524195, 7.915778, 7.999747, 7.701364, 7.681405, 7.502010, 7.023330, 6.426219, 6.780288, 7.364687, 7.569932, 7.100163, 6.755145, 6.777131, 7.009485, 7.023938, 7.338360, 7.338395, 7.044856, 7.174554, 6.925128, -0.416425, 1.099362, 1.526206, 1.502322, 1.561059, 1.807618, 1.698298, 1.711067, 1.366013, 1.552325, 1.810810, 1.823785, 1.915892, 1.958983, 1.732273, 2.273143, 2.234895, 2.353844, 2.490107, 2.272922, 2.394655, 2.163642, 2.108853, 2.645210, 2.636073, 2.352750, 2.266628, 2.563564, 2.383325, 2.335806, -0.184753, 0.789660, 1.009137, 0.500784, 0.296502, 0.347579, 0.479371, 0.392104, 0.070832, -0.244323, -0.214195, -0.033055, 0.529708, 0.660115, 0.408178, 0.457910, 0.331253, 0.833246, 0.578816, 0.178996, 0.239411, 0.369203, 0.585878, 0.537306, 0.445782, 0.642460, 0.521554, 0.399486, 0.332428, 0.236961, -0.005024, 0.879846, 1.244868, 0.797569, 1.033676, 0.851144, 0.833707, 0.713702, 0.323630, 0.646883, 0.729911, 0.796007, 0.813712, 0.723648, 0.622260, 1.087452, 0.977576, 1.182080, 1.246686, 1.230478, 1.325730, 0.906389, 0.758255, 1.347762, 1.526771, 0.908264, 0.873007, 1.185631, 1.171059, 1.143543, 0.406532, -0.645797, 0.458876, 0.360733, 0.551187, 0.592809, 0.299421, 0.172273, 0.202805, -0.141076, -0.566290, -0.493161, -0.437758, -0.322464, -0.312793, -0.119606, 0.142804, 0.238235, 0.461993, 0.183476, -0.116752, 0.169810, 0.168447, -0.100790, -0.309481, 0.040894, 0.049023, -0.058401, -0.196831, -0.135850, 0.248360, -0.130351, -0.100634, -0.482674, -0.167444, -0.170902, -0.097574, -0.257839, -0.295999, -0.205456, -0.408315, -0.214592, -0.224080, -0.008113, 0.183720, 0.220224, 0.048995, 0.237415, 0.192354, -0.008506, -0.153218, 0.580522, 0.832023, 0.369355, 0.047888, 0.804889, 0.652942, 0.374031, 0.530022, 0.480083, 0.799417, -0.245074, -0.099908, 0.263938, -0.318753, -0.367902, 0.090369, 0.366754, 0.219656, 0.426448, 0.447234, 0.252469, 0.422671, 0.746850, 0.857468, 0.843537, 0.696655, 1.012149, 1.189560, 1.137156, 1.027546, 1.651509, 1.800812, 1.231963, 1.051274, 1.701249, 1.588508, 1.460477, 1.541919, 1.532072, 0.068206, -0.344829, -0.336528, -0.429991, 0.338433, -0.052551, -0.037596, -0.095574, -0.181324, -0.022977, -0.457479, -0.270310, 0.011031, 0.351977, 0.595530, 0.562982, 0.314528, 0.660725, 0.725135, 0.445693, 0.395688, 1.492211, 1.474112, 0.836024, 0.496774, 1.549525, 1.400332, 1.171885, 1.363395, 1.198529, 1.397342, 2.883399, 3.876390, 4.566290, 4.455337, 4.285871, 4.469667, 4.970766, 4.982248, 5.180485, 5.202457, 5.279863, 5.242338, 5.406716, 5.059790, 4.759207, 4.452744, 4.426365, 4.768429, 5.080145, 4.681249, 4.302490, 4.218554, 4.556766, 4.599362, 4.711612, 4.668750, 4.486914, 4.699044, 4.644851, 3.181700, 3.833915, 5.797790, 6.534248, 6.210186, 6.429805, 6.635081, 6.727612, 7.284977, 7.950253, 7.892115, 8.238596, 7.558779, 7.847066, 7.974081, 7.496270, 7.075326, 8.621954, 9.474502, 8.584656, 8.457132, 8.698236, 8.824508, 9.063141, 8.545958, 8.572924, 8.537233, 8.432730, 8.410225, 7.767307, 0.351624, -1.655761, -2.829370, -2.795581, -3.236789, -3.649151, -4.241164, -3.977285, -3.310028, -4.250994, -3.980793, -3.241636, -2.930646, -4.084733, -3.758240, -2.844704, -3.218837, -4.115032, -4.718446, -3.840946, -4.555088, -4.449932, -4.668425, -4.771279, -4.442306, -4.737932, -4.968353, -4.711185, -5.099992, -4.761225, 5.663656, 4.139808, 4.571064, 4.162340, 3.992521, 4.074438, 4.008503, 3.640355, 4.912679, 5.166187, 4.547625, 5.277167, 5.546805, 5.320739, 5.415612, 5.246708, 4.620886, 6.430686, 6.528822, 6.369545, 5.906408, 6.119462, 5.297103, 6.070154, 6.495468, 5.705664, 5.779947, 5.998786, 5.733298, 4.688502, 0.953397, 1.117754, 0.942039, 0.483770, 0.527938, 0.659376, 0.780369, 0.351888, -0.004361, 0.331899, 0.447425, -0.141679, -0.155494, -0.200905, 0.060872, 0.119178, 0.002017, -0.002329, -0.067123, 0.023249, -0.030134, 0.270721, 0.287179, 0.048899, 0.017911, -0.095846, 0.246593, 0.327430, 0.189594, -0.059380, -0.266463, 1.110816, -0.511163, -0.725355, 0.107574, -0.136200, 0.188421, -0.063326, -0.025579, -0.010095, 0.070702, -0.150130, -0.049003, -0.136197, 0.049530, -0.106846, -0.190649, -0.210167, -0.248816, 0.022517, 0.029446, 0.390964, 0.385276, -0.066233, -0.007496, -0.191373, 0.199085, -0.040885, -0.107508, -0.202366, -0.015321, -0.216355, -0.430576, -0.497745, -0.452377, -0.536435, -0.517232, -0.469532, -0.511901, -0.351346, -0.213845, -0.365944, -0.524115, -0.538558, -0.516218, -0.440366, -0.412560, -0.368557, -0.369251, -0.355414, -0.402641, -0.213203, -0.178747, -0.299219, -0.431071, -0.373544, -0.286623, -0.261220, -0.278998, -0.188684, -0.806192, 0.320311, -0.486686, -0.719820, -0.158630, -0.278678, 0.001152, -0.208493, -0.097583, -0.151399, 0.022950, -0.116521, -0.029610, -0.240205, -0.052786, -0.151600, -0.177001, -0.350113, -0.293506, -0.043433, -0.033661, -0.107510, -0.285434, -0.366845, -0.181138, -0.383179, -0.189690, -0.308031, -0.357150, -0.494299, 0.340387, 0.200165, -0.900088, -0.452946, -0.731716, -0.704584, -0.460528, -0.369007, -0.391443, -0.382763, -0.312495, -0.328044, -0.363793, -0.462019, -0.307635, -0.389930, -0.516670, -0.592582, -0.619524, -0.652292, -0.526677, -0.514181, -0.438717, -0.498343, -0.562304, -0.543987, -0.535820, -0.595592, -0.614631, -0.588709, -0.408012, -0.741097, -0.074258, 0.180858, -0.099043, 0.128467, 0.159297, 0.032733, -0.033840, -0.084896, -0.147523, -0.011078, -0.158792, -0.272075, -0.315319, -0.162904, 0.121921, -0.030347, 0.005893, 0.005201, -0.018406, -0.187738, 0.027564, 0.003188, -0.144467, 0.097203, 0.020956, -0.094253, -0.056341, 0.163471, 0.691477, 0.214826, 0.742523, 0.752441, 0.753222, 1.088244, 1.052389, 0.907071, 0.841519, 0.803253, 0.623753, 0.685960, 0.700361, 0.605019, 0.637537, 0.963657, 0.948044, 0.996742, 0.831602, 1.053450, 0.965295, 0.860748, 0.939996, 0.942055, 0.956016, 1.006156, 1.069022, 1.032585, 1.186142, 1.467335, -0.057202, -0.505624, -0.068841, 0.331151, 0.126785, 0.277268, 0.241465, 0.119457, -0.112732, 0.006723, -0.162833, -0.038827, -0.225433, -0.179075, -0.349940, -0.058054, 0.361227, 0.080601, 0.212450, 0.258724, 0.318270, 0.187755, 0.457420, 0.321593, 0.008017, 0.345356, 0.318577, 0.137335, 0.211832, 0.581688, -1.246131, -0.492302, 0.331567, 1.204668, 1.861722, 1.769801, 1.511744, 1.503048, 1.413434, 1.143683, 1.066265, 1.292235, 1.159368, 1.442006, 1.720770, 2.109119, 2.347908, 1.463246, 0.863010, 1.031720, 1.723487, 1.329314, 0.918775, 1.121582, 0.892796, 0.953254, 1.452888, 2.047821, 1.642342, 0.937699, -0.163058, -0.293400, -0.050382, -0.298579, -0.028162, -0.254041, -0.027123, -0.176405, -0.128103, -0.115005, -0.395119, -0.345801, -0.302913, -0.355535, -0.369686, -0.347200, -0.060442, -0.346761, -0.480783, -0.373881, 0.755202, -0.007237, -0.645262, -0.256583, -0.352574, -0.549328, -0.449980, -0.270952, -0.453538, -0.567080, -0.770206, -0.775167, -0.570559, -0.090583, -0.061858, -0.028072, 0.057594, -0.173175, -0.149880, 0.020561, -0.050605, -0.111582, -0.110625, -0.090372, -0.155562, -0.258535, -0.165693, -0.420926, -0.205687, -0.303649, -0.304818, -0.143871, -0.210585, -0.196168, -0.172651, -0.174992, -0.155097, -0.220339, -0.287506, -0.165711, 0.174121, 0.077230, 0.018745, -0.293919, 0.118343, -0.390136, -0.005353, -0.261426, -0.219757, -0.093421, -0.395220, -0.136840, -0.116496, -0.273474, -0.429249, -0.124765, 0.019702, -0.299063, -0.441756, -0.439943, 0.397043, -0.294786, -0.630362, -0.479872, -0.407875, -0.539019, -0.471974, -0.301217, -0.523417, -0.528748, -2.300164, -1.161916, -0.116215, 0.851791, 1.305153, 1.337718, 1.343500, 1.087469, 0.604862, 0.368462, 0.131049, 0.370777, 0.415465, 0.646907, 0.959115, 1.069257, 1.313877, 1.025921, 0.697244, 0.439392, 0.948962, 0.768662, 0.339767, 0.466127, 0.460745, 0.181886, 0.450729, 0.664966, 0.312222, 0.671042, -0.702565, -0.506134, 0.095167, 0.059516, -0.127830, -0.186723, -0.264194, -0.455772, -0.288734, -0.106535, -0.208130, -0.243520, 0.052307, -0.205513, -0.167982, -0.484294, -0.350888, -0.463275, -0.489759, -0.440335, 0.444439, -0.207457, -0.527717, -0.393743, -0.170825, -0.434441, -0.428425, -0.267858, -0.531797, -0.419597, 0.070698, 0.535531, 0.496190, 0.382164, 0.268151, 0.463237, 0.356639, 0.158861, 0.052661, 0.088936, 0.105359, 0.050205, 0.254230, 0.230592, 0.138794, 0.223996, 0.059766, -0.145944, -0.014177, -0.114562, -0.428641, -0.130856, 0.089621, -0.013288, 0.010842, 0.049368, 0.178681, 0.049883, 0.250121, 0.156148, -0.530486, -0.008080, -0.075273, 0.043892, -0.044125, -0.055760, -0.285142, -0.295445, -0.160267, -0.139498, -0.255803, -0.314487, -0.067764, -0.325116, -0.189978, -0.568532, -0.434101, -0.279322, -0.537587, -0.604684, 0.160021, -0.207304, -0.721337, -0.512377, -0.369787, -0.564163, -0.564564, -0.318398, -0.602830, -0.504277, -1.209404, -0.204959, -0.350935, -0.770050, -0.232961, 0.293649, 0.236133, -0.161159, -0.379380, -0.452695, -0.453323, -0.566109, -0.478023, -0.339954, -0.321766, -0.124281, -0.316030, -0.642955, -0.684122, -0.469853, -0.659065, -1.130449, -1.054822, -0.734954, -0.622944, -0.766036, -0.780477, -0.664525, -0.145247, -0.539121, 0.039308, -0.490693, -0.348728, -0.455240, -0.382280, -0.096223, -0.209289, -0.414919, -0.126479, -0.262523, -0.238607, -0.259821, -0.317905, -0.245518, -0.383586, -0.320035, -0.409415, -0.581002, -0.329083, -0.216310, -0.250976, -0.625173, -0.673408, -0.417701, -0.369474, -0.521012, -0.501068, -0.487589, -0.490949, -0.663550, 0.008641, -0.066976, -0.098545, -0.141883, -0.111823, 0.045771, -0.044508, -0.313721, -0.379009, -0.313412, -0.334568, -0.231976, -0.187488, -0.187824, -0.207578, -0.129511, -0.101951, -0.112050, -0.198814, -0.217940, -0.048081, 0.042025, -0.202009, -0.241290, -0.196803, -0.095471, -0.131151, -0.099989, -0.005287, -0.120797, -0.498288, -0.090910, -0.342587, -0.481221, -0.349584, -0.095506, -0.292486, -0.323745, 0.055326, -0.196059, -0.106806, -0.285650, -0.345940, -0.204973, -0.227920, -0.242085, -0.326786, -0.543355, -0.348208, -0.313791, -0.238716, -0.592716, -0.687759, -0.442401, -0.416902, -0.511509, -0.496538, -0.582379, -0.545501, -0.701258, -0.436796, -0.128814, -0.684676, -0.615203, -0.599183, -0.462692, -0.530468, -0.513902, -0.430615, -0.438477, -0.510632, -0.655683, -0.678896, -0.700367, -0.720484, -0.657052, -0.804428, -1.028220, -0.988336, -0.923418, -0.892020, -1.005288, -1.020841, -0.930002, -0.778611, -0.899755, -0.839809, -0.880721, -0.895518, -0.895557, -0.111068, -0.258814, -0.530689, -0.307183, -0.106614, 0.358725, 0.148876, -0.074997, 0.017229, -0.024161, 0.149479, 0.164176, 0.142166, 0.057734, 0.022517, -0.184819, -0.139850, -0.184393, -0.097706, -0.012877, -0.151527, -0.458658, -0.454057, -0.279839, -0.189375, -0.293241, -0.376683, -0.363324, -0.398117, -0.457201, -0.613139, -0.165856, -0.222795, -0.450623, -0.565697, -0.912894, -0.720704, -0.581489, -0.377761, -0.567396, -1.025077, -0.996589, -0.785942, -0.787216, -0.680814, -0.525182, -0.443397, -0.287426, -0.426737, -0.514175, -0.569556, -0.651256, -0.705887, -0.708198, -0.667898, -0.578666, -0.568867, -0.548768, -0.403617, -0.485161, -0.059782, -0.429275, -0.442010, -0.162971, 0.071213, 0.551930, 0.304301, 0.048770, 0.068533, 0.039552, 0.337785, 0.370471, 0.209214, 0.152803, 0.053997, -0.186767, -0.084573, -0.146320, -0.118857, 0.111854, 0.037429, -0.348083, -0.359900, -0.210013, -0.079051, -0.272953, -0.422301, -0.368882, -0.480800, -0.468759, -0.291323, -0.196297, -0.801603, -0.701480, -0.776713, -0.668054, -0.522202, -0.495274, -0.433325, -0.410083, -0.333484, -0.490222, -0.512813, -0.551662, -0.569351, -0.618589, -0.688784, -0.768404, -0.756507, -0.706791, -0.671724, -0.765447, -0.753975, -0.757355, -0.632747, -0.725932, -0.700419, -0.778790, -0.743817, -0.781285, -0.266667, -0.501540, -0.170897, 0.032800, 0.214312, 0.046321, 0.034007, -0.242678, -0.171369, 0.083201, 0.027391, -0.192798, -0.032198, -0.135557, 0.011481, -0.122014, -0.301561, -0.282110, -0.125880, -0.164800, -0.236827, -0.488406, -0.268413, -0.209313, -0.121847, -0.346361, -0.340640, -0.250101, -0.256423, -0.368012, 0.339101, 0.531971, 0.782604, 0.591833, 0.516599, 0.484901, 0.343966, 0.303779, 0.475723, 0.451649, 0.573913, 0.556743, 0.270387, 0.359560, 0.341498, 0.361812, 0.316925, 0.309734, 0.250476, 0.076458, 0.161496, 0.211783, 0.105117, 0.198203, 0.308684, 0.242509, 0.233222, 0.169090, 0.283144, 0.146886, -0.281802, -0.583620, 0.044664, 0.177417, 0.320152, -0.005200, -0.044192, -0.240502, -0.189478, -0.056913, -0.040385, -0.254765, -0.018759, -0.194773, 0.017045, -0.095482, -0.148268, -0.270427, -0.081008, -0.032873, -0.082702, -0.336448, -0.257237, -0.138142, -0.019718, -0.287083, -0.319903, -0.189738, -0.199501, -0.258733, 1.085641, 1.456584, 2.244979, 2.285737, 2.023556, 1.861401, 1.641771, 1.795676, 1.971964, 1.977862, 2.216431, 2.204369, 2.129561, 2.188738, 2.052295, 1.930678, 1.757071, 1.610906, 1.665009, 1.756054, 1.592837, 1.311109, 1.343464, 1.583312, 1.591815, 1.580199, 1.471737, 1.492183, 1.429942, 1.244627, 1.399431, 2.123313, 3.275896, 3.512374, 3.177691, 3.121460, 2.983352, 3.069166, 3.299853, 3.561660, 2.706596, 2.746077, 3.018538, 2.524726, 2.964244, 3.167555, 3.097172, 2.793777, 3.672169, 4.159006, 3.701369, 2.916125, 2.832081, 3.413292, 4.015575, 3.504965, 3.350286, 3.484022, 3.894196, 3.611909, -0.227509, 1.048475, 0.864971, 0.846893, 0.658874, 0.228013, 0.060873, 0.379178, 0.553333, 0.021585, 0.247066, 0.558111, 1.049252, 0.373304, 0.404172, 0.559333, 0.363633, 0.012323, 0.326255, 0.808560, 0.714367, 0.594111, 0.503386, 0.417167, 0.408863, 0.093899, 0.347750, 0.449417, 0.612626, 0.436424, 1.414157, 2.315415, 2.908833, 2.595475, 2.228968, 2.331165, 2.284120, 2.907935, 2.951667, 3.376408, 2.643138, 2.055837, 2.022881, 1.860105, 2.264772, 2.428835, 2.267884, 2.192351, 3.450064, 3.773245, 3.037419, 2.535178, 1.849519, 2.497555, 3.904495, 3.002506, 2.921792, 3.245115, 3.503191, 3.309895, -1.044332, -0.146552, 0.007112, -0.809290, -0.482317, -0.168229, -0.059804, -0.212452, -0.333161, -0.138446, -0.005293, 0.086842, 0.106452, 0.150804, -0.036099, -0.217983, -0.349324, -0.247901, 0.008763, 0.000732, -0.163755, -0.329274, -0.462088, -0.305143, -0.011555, 0.169309, -0.001539, -0.117352, 0.064002, -0.138543, 1.916337, -0.644068, -0.470575, -0.478707, -0.335054, -0.365102, -0.053703, -0.260629, -0.493158, -0.030957, 0.007657, -0.035194, -0.266283, -0.400777, -0.378995, -0.220457, -0.625115, -0.479350, -0.075606, -0.039194, -0.180203, -0.238571, -0.085761, -0.086701, -0.090149, 0.151592, 0.283235, 0.243324, 0.199925, 0.140660, 0.612993, 0.255914, 0.335607, 0.316246, 0.329836, 0.187242, 0.045535, 0.028279, 0.136274, 0.331302, -0.023768, 0.264436, 0.274859, 0.320834, 0.251960, -0.284346, -0.157723, 0.133284, 0.174958, 0.169778, -0.317162, -0.091070, -0.052449, 0.046175, -0.136735, 0.208945, 0.325582, 0.156640, 0.219432, 0.072211, 1.545058, -0.458010, -0.330409, -0.145919, -0.183153, -0.202908, -0.032220, -0.353783, -0.571169, 0.253792, 0.374961, 0.227982, -0.041001, -0.062271, -0.295794, -0.191240, -0.682817, -0.487837, 0.010848, 0.013728, -0.071827, 0.033030, 0.193991, 0.145570, 0.203176, 0.432073, 0.771504, 0.668153, 0.548423, 0.492544, 2.306075, 2.865098, 3.565378, 4.073230, 3.572574, 3.526951, 3.578902, 3.866888, 3.912574, 4.009461, 4.172468, 4.250475, 4.171951, 4.279250, 4.154536, 3.750032, 3.358291, 3.476560, 3.833692, 4.201728, 3.695681, 3.361830, 3.369440, 3.541913, 3.385731, 3.599876, 3.406638, 3.202219, 3.163590, 3.181609, 2.270538, 5.418699, 7.702573, 8.159493, 8.542269, 8.918297, 8.485518, 8.576425, 9.672402, 9.505629, 8.971777, 7.986260, 8.254930, 8.491246, 9.097572, 8.831426, 8.476899, 8.858293, 8.923585, 9.306145, 8.838779, 8.208570, 7.816493, 9.009478, 9.212416, 8.382278, 8.757051, 8.671520, 8.517469, 8.113801, -1.662449, -3.687046, -5.575484, -5.559071, -5.097793, -4.878430, -4.927450, -5.189834, -5.696000, -5.843049, -5.489083, -6.045592, -6.141836, -6.175982, -6.558456, -6.567199, -5.848050, -5.996238, -6.237951, -6.918013, -6.531952, -5.926789, -6.026813, -6.925877, -6.990836, -6.639759, -7.363351, -7.360596, -7.700224, -7.027402, 2.410498, 3.717748, 6.596602, 5.486434, 7.055527, 7.616362, 6.778759, 7.219349, 8.402937, 8.615301, 7.861275, 7.359847, 7.796119, 8.437551, 8.416126, 8.561999, 8.030196, 8.398860, 8.677848, 10.014011, 9.259555, 7.463835, 6.331532, 8.581865, 9.726580, 7.739101, 8.241629, 8.853539, 8.116709, 7.651242, 0.480945, -0.476393, 0.556380, 0.406033, 0.732939, 0.737631, 0.347966, 0.264519, 0.278506, -0.052698, -0.455865, -0.370396, -0.403164, -0.358512, -0.271068, 0.101683, 0.351760, 0.347562, 0.395244, 0.313666, 0.058985, 0.116169, 0.091137, 0.073261, 0.093609, 0.032136, 0.041307, 0.037443, -0.069194, -0.053135, -0.221043, -0.265995, 0.229945, -0.345963, -0.021317, 0.022804, -0.153170, -0.168362, -0.325322, -0.015276, -0.234955, -0.203641, -0.112286, -0.033144, 0.194723, 0.140702, -0.000593, 0.047106, 0.073966, -0.119495, -0.010978, 0.512104, 0.745655, 0.385314, 0.179797, 0.268372, 0.201429, 0.173333, 0.255957, 0.399556, 0.482116, -0.532712, -0.499253, -0.366814, -0.624743, -0.488498, -0.466578, -0.350170, -0.123509, -0.142418, -0.389099, -0.326880, -0.594575, -0.296874, 0.340657, 0.452015, 0.339699, 0.211178, -0.039184, -0.031487, 0.279521, 0.767534, 0.888262, 0.523026, 0.340979, 0.643769, 0.547195, 0.583068, 0.573789, 0.795835, -0.042063, 0.066158, 0.176648, -0.191356, 0.372710, 0.160993, -0.130199, -0.153147, -0.209131, 0.118711, -0.246036, -0.262277, -0.253039, -0.027343, 0.432038, 0.348030, 0.140353, 0.446931, 0.254641, 0.054987, 0.404880, 1.181937, 1.297062, 0.895990, 0.607116, 0.714633, 0.607476, 0.571983, 0.653709, 0.868280, 1.656137, 0.503970, 1.233931, 1.664041, 1.697084, 1.644782, 1.650363, 1.960811, 1.975280, 2.047939, 2.058286, 2.102925, 2.192429, 2.004971, 1.767482, 1.503035, 1.380847, 1.647004, 1.825134, 1.812562, 1.566299, 1.372598, 1.443395, 1.395929, 1.367221, 1.504524, 1.315411, 1.170396, 1.177958, 0.929567, 0.769762, 0.929149, 0.794193, 0.522833, 0.411599, 0.414045, 1.048363, 1.044357, 1.082044, 0.877970, 0.455550, 0.941601, 1.023554, 0.993325, 0.866395, 0.933759, 1.022094, 1.108117, 1.360292, 1.505051, 1.259893, 0.834967, 0.911257, 1.140656, 1.701984, 1.618255, 1.587230, 1.488473, 1.474339, 1.395225, -0.178454, -0.563166, -0.565429, 0.065118, -0.150942, -0.685153, -0.478244, -0.606471, -0.412897, -0.446361, -0.407639, -0.013592, -0.041824, -0.333639, -0.468934, -0.623910, -0.836637, -0.831086, -0.547547, -0.735848, -0.578456, -0.495219, -0.452776, -0.700671, -0.692349, -0.739674, -0.830247, -0.886261, -0.876575, -0.816194, 0.137407, 1.674868, 1.494946, 0.805102, 0.233038, 0.708020, 1.496650, 1.113723, 0.822438, 0.848968, 0.584977, 1.151427, 0.868101, 0.720315, 0.912467, 0.974272, 0.990326, 1.255763, 1.365052, 1.664473, 0.955253, 0.476855, 0.714510, 1.003387, 1.390198, 1.387430, 1.258888, 1.275755, 1.251285, 1.077466, 1.082454, 1.296590, 0.981372, 0.793342, 1.233769, 1.522319, 1.409277, 0.857911, 0.325517, 0.433473, 0.542896, 0.181979, 0.296402, 0.165915, 0.229337, 0.322607, 0.310189, 0.239961, -0.038367, 0.057103, 0.170283, 0.428817, 0.452402, 0.406958, 0.310457, 0.080851, 0.390955, 0.635340, 0.532686, 0.113484, -0.185928, 1.343476, -0.174033, 0.260538, 1.484565, 1.847275, 1.841718, 1.163132, 0.817680, 0.025711, 0.078131, 0.039112, 0.419372, 0.286231, 0.315279, -0.272419, -0.179977, -0.134361, -0.168457, -0.061221, -0.194701, 0.134721, 0.127723, -0.130537, -0.266296, -0.258523, 0.088901, 0.199372, 0.046240, -0.074546, -0.045776, -0.349614, 0.186060, 0.137854, 0.945859, 1.724337, 2.246906, 2.098554, 1.320452, 0.741381, 0.753404, 0.883966, 0.525527, 0.682064, 0.642669, 0.637220, 0.580864, 0.526545, 0.307184, 0.108185, 0.082069, -0.077931, -0.054658, 0.366805, 0.627369, 0.410053, 0.690556, 0.602464, 0.475906, 0.532827, -0.453581, 0.397410, -0.524156, 0.119886, 1.256667, 1.929437, 1.766178, 0.751576, 0.552326, -0.166648, 0.075297, 0.408242, 0.471461, 0.014840, 0.126218, -0.143994, -0.167168, -0.076680, -0.347139, -0.196809, -0.250577, -0.185674, -0.266363, -0.512279, -0.302519, -0.335279, -0.222587, -0.275853, -0.074184, -0.435731, 0.510407, 0.049668, -0.441973, -0.152916, -0.359911, -0.592282, -0.408618, -0.315343, -0.363626, -0.400487, -0.375587, -0.329449, -0.315406, -0.290222, -0.276450, -0.412252, -0.378527, -0.309371, -0.490071, -0.505118, -0.407211, -0.213447, -0.034673, -0.247040, -0.482192, -0.477776, -0.430849, -0.368353, -0.450007, -0.309545, -0.789965, -0.072577, -0.073564, 0.289718, -0.314212, -0.234136, -0.219094, 0.038739, -0.033259, -0.176669, -0.021887, 0.081862, 0.123539, -0.020686, 0.066746, 0.211367, 0.291903, 0.161304, -0.112934, -0.084018, 0.198848, 0.227208, 0.393486, 0.172688, 0.002851, -0.009976, 0.141311, 0.045820, 0.065536, 0.450257, 0.552704, 0.522047, 0.747252, 0.585213, 0.397845, 0.462546, 0.589336, 0.744308, 0.645470, 0.668537, 0.647227, 0.778528, 1.012068, 1.183224, 1.203152, 1.478891, 1.342900, 1.140753, 0.955723, 0.998512, 1.514437, 1.399682, 1.464904, 1.393600, 1.129178, 1.078655, 1.238600, 1.127448, 1.145572, 1.597111, 0.000074, -0.197870, -0.186739, -0.012858, -0.388197, -0.212128, -0.062988, 0.253357, 0.131495, -0.183096, 0.178160, 0.251239, 0.371597, 0.531722, 0.483008, 0.789388, 0.920394, 0.636856, 0.242998, 0.311347, 1.033211, 0.943284, 1.032422, 0.751773, 0.374835, 0.346825, 0.653597, 0.622265, 0.727383, 1.211375, -1.078318, -0.262733, -0.072802, -0.872315, -0.590588, -0.379362, -0.137940, -0.422025, -0.737965, -0.450253, -0.260390, -0.060961, -0.102799, -0.145192, -0.087726, -0.228813, -0.446570, -0.258822, -0.109858, -0.240101, -0.330561, -0.361739, -0.522709, -0.446591, -0.359360, -0.162300, -0.244590, -0.356568, -0.361415, -0.375302, 2.059772, -0.543839, -0.029629, -0.184857, 0.075690, -0.197539, 0.071188, -0.115406, -0.170443, 0.262863, 0.054097, -0.043472, -0.056229, -0.038588, 0.004825, -0.018182, -0.192125, -0.131376, 0.039669, 0.031732, 0.031946, 0.016179, 0.252803, 0.202600, 0.054529, 0.284755, 0.389401, 0.178408, 0.221804, 0.329933, -0.300783, -0.550314, -0.822059, -0.981281, -0.769451, -0.622322, -0.514391, -0.585086, -0.592659, -0.691799, -0.690783, -0.751417, -0.575630, -0.523599, -0.509291, -0.743442, -0.786529, -0.830712, -1.027893, -1.019970, -1.113143, -1.188071, -1.220225, -1.029527, -0.890253, -1.013637, -1.144839, -0.916512, -0.969843, -0.979831, 1.626997, -0.421125, -0.025872, 0.188111, 0.028314, 0.033696, 0.428459, 0.152318, -0.011739, 0.493617, 0.261712, 0.294079, 0.276892, 0.178949, 0.445399, 0.103674, -0.099486, 0.210980, 0.289552, 0.142964, 0.259222, 0.536320, 0.832262, 0.598225, 0.484329, 0.860017, 1.129466, 0.806983, 0.848637, 1.005714, -0.078934, 0.302146, -0.346322, -0.175723, -0.212555, -0.326502, -0.445147, -0.371069, -0.173977, -0.041141, 0.145594, -0.154394, -0.326434, -0.368040, -0.507965, -0.412140, -0.457381, -0.602560, -0.621411, -0.558848, -0.472852, -0.408790, -0.156962, -0.038866, 1.359062, 2.080956, 2.217424, 2.116609, 2.439879, 2.501802, 0.128921, 0.043294, -0.278107, -0.271217, -0.258393, 0.004345, -0.101982, -0.046759, -0.060642, -0.080791, 0.432535, -0.038106, -0.333519, -0.168057, -0.175186, -0.222406, 0.097233, -0.311466, -0.039962, -0.299247, -0.335618, -0.231554, -0.026106, 0.241413, 1.374839, 3.057511, 2.938185, 3.117391, 3.679255, 3.940728, 0.183739, -0.674958, 0.466458, 0.366048, 0.142048, 0.462933, 0.157706, 0.156520, -0.231347, -0.021816, 0.115066, 0.123856, -0.189195, 0.137557, -0.106589, 0.222852, 0.592201, 0.521094, -0.014595, 0.683150, 0.466554, 0.633542, 0.607990, -0.218491, 1.535646, 2.455018, 2.488965, 2.330387, 2.814921, 2.606888, 0.304406, -0.322846, -0.216531, -0.488269, -0.131175, 0.078281, -0.097536, -0.200726, -0.196407, -0.139910, 0.999786, 0.558996, -0.669392, -0.586548, -0.285364, -0.189862, 0.200675, -0.095461, -0.074287, -0.557200, -0.589591, -0.476074, 0.042237, -0.056621, 0.881104, 1.267085, 1.606082, 2.256760, 1.943756, 2.021482, 0.372648, 0.048479, -0.021064, 0.085587, -0.074393, -0.442182, -0.608952, -0.528661, -0.192297, -0.065403, 0.032267, 0.090463, 0.029540, -0.075591, -0.267454, -0.302762, -0.082003, 0.131804, 0.018020, 0.039641, 0.179622, 0.351932, 0.418839, 0.296653, 0.330232, 0.357741, 0.226441, 0.260445, 0.275687, 0.498611, -0.055376, -0.030133, -0.142412, 0.373930, 0.212560, 0.111372, 0.063682, -0.100564, -0.031939, -0.112583, 0.097834, 0.020636, -0.091687, -0.073823, -0.207874, -0.142698, -0.178588, -0.086234, -0.164628, -0.085581, 0.053511, 0.028381, -0.223899, -0.389452, -0.216362, 0.046111, -0.172489, -0.130850, -0.173334, -0.105423, 0.702366, 0.654770, 0.779630, 0.876344, 0.895746, 0.906390, 0.952221, 0.953806, 0.766210, 0.584222, 0.582485, 0.905305, 0.836606, 0.769153, 0.747317, 0.499542, 0.646704, 0.713808, 0.719042, 0.711525, 0.565432, 0.462352, 0.451551, 0.474221, 0.625761, 0.571645, 0.518826, 0.590882, 0.454142, 0.488758, -0.332312, -0.152104, -0.251361, 0.057425, 0.150217, 0.142342, 0.155091, 0.000961, -0.046015, -0.264087, 0.002814, -0.175267, -0.147495, -0.099455, -0.277735, -0.243450, -0.214658, -0.230272, -0.257830, -0.216651, -0.306155, -0.437809, -0.516322, -0.594058, -0.325864, -0.236051, -0.433910, -0.384698, -0.466526, -0.503840, 1.225828, 0.844764, 1.076247, 1.423737, 1.418074, 1.214571, 1.292427, 1.718181, 1.920722, 1.913843, 2.047721, 1.877068, 1.730377, 1.786165, 1.481037, 1.287264, 1.245491, 1.322330, 1.461337, 1.527751, 1.423376, 1.253571, 1.219757, 1.119957, 0.947598, 1.074474, 1.112117, 0.803042, 0.669264, 0.861516, -0.363630, -0.094945, 1.584831, 1.967183, 3.793190, 3.927403, 2.702274, 3.546647, 3.368626, 2.700115, 2.713077, 2.927013, 2.691490, 2.341555, 2.037983, 1.660577, 1.950204, 1.674099, 2.006949, 2.381566, 1.995487, 1.306650, 0.831168, 0.953906, 1.044276, 0.524038, 0.380361, 0.827808, 0.854594, 1.054337, 0.024207, 1.232222, 1.491366, 1.830996, 2.109124, 2.256564, 1.464566, 1.188784, 1.218448, 1.317021, 0.988407, 1.596134, 1.388869, 0.779978, 0.586910, 1.068071, 0.675978, 0.445259, 0.817982, 1.805127, 1.305702, 0.538597, 1.314551, 0.767264, 0.435844, 0.431164, -0.114798, 0.641159, 0.202304, -0.107018, -0.144404, 0.199128, 0.987576, 1.355647, 1.955682, 1.866611, 1.582418, 2.756921, 2.850405, 1.697863, 1.658220, 2.099914, 1.800852, 1.722389, 2.493773, 1.460073, 1.655743, 1.733930, 1.688655, 1.872836, 1.769727, 1.052926, 0.494794, 0.672451, 1.059470, 0.272284, 0.398625, 0.996650, 1.116434, 0.963850, 1.143546, 1.599063, 1.088289, 1.554212, 2.137527, 2.400519, 3.016035, 2.379939, 1.768728, 1.590781, 1.261824, 0.990692, 1.592651, 1.538143, 1.004910, 0.857918, 0.698974, 0.575186, 0.152507, 0.249931, 0.362265, 0.661658, 1.117845, 0.777652, 0.563309, 0.455269, 1.242328, 1.791062, 1.279903, 0.412594, -0.362022, 1.638901, -0.254095, 1.385919, 2.349294, 2.618806, 3.156255, 2.259267, 0.882892, 0.645023, 0.672741, 0.934855, 2.244568, 2.399017, 1.228142, 0.878692, 1.520957, 0.702042, -0.326627, -0.210142, -0.088227, 0.455742, 0.437545, 0.263783, -0.029247, -0.255636, 0.376785, 0.929188, 0.278312, -0.150584, -0.238836, -0.329511, -0.493955, -2.210532, -1.994260, -1.671245, -1.533750, -1.014020, -1.295688, -0.498746, 0.120112, 0.020381, -0.488568, -1.122158, -0.521486, -1.022533, -1.481894, -1.432530, -0.527804, -0.256849, -0.704322, -1.338446, -0.941085, -1.226658, -1.192361, -0.924038, -1.223253, -2.030402, -1.090983, -0.322809, -0.271179, 1.127225, -0.725773, 2.153359, 3.294693, 3.420786, 4.061182, 2.976376, 0.694129, 0.365550, 0.670753, 1.033152, 2.222855, 2.921954, 0.734163, 0.390106, 1.651782, 0.722612, -0.362406, -0.189766, 0.151626, 0.214439, -0.061112, 0.278542, -0.126419, -0.412790, 0.089949, 0.798545, 0.077914, -0.417526, -0.684186, -0.192981, -0.425122, -0.350301, -0.746629, -0.841466, -0.933527, -0.841888, -0.575221, -0.580402, -0.446639, -0.601995, -0.591912, -0.676365, -0.887362, -0.684826, -0.759928, -1.037103, -1.034182, -0.981082, -0.991912, -1.039013, -1.066470, -0.884425, -0.650601, -0.819467, -0.720949, -0.858547, -0.922343, -0.807781, 0.465131, -0.120899, -0.734173, -0.631018, -0.365697, -0.459472, -0.299705, -0.281949, -0.389953, -0.396398, -0.119204, -0.333812, -0.246297, -0.437041, -0.395979, -0.487295, -0.473028, -0.457694, -0.332680, -0.375564, -0.486687, -0.701735, -0.677786, -0.492140, -0.330408, -0.547319, -0.528634, -0.532890, -0.638464, -0.652073, -0.693891, -0.169612, -0.174194, -0.014916, 0.020896, 0.139234, 0.114373, 0.075488, -0.020477, -0.019393, 0.276848, 0.374297, 0.427533, 0.399623, 0.184525, 0.127967, 0.091537, -0.082878, -0.139192, 0.005933, 0.084312, -0.044073, 0.214050, 0.193657, 0.143280, 0.115451, -0.049416, -0.123116, -0.190943, -0.008993, 0.625151, -0.602407, -0.401359, -0.487852, -0.305920, -0.436535, -0.195604, -0.312755, -0.410051, -0.443710, -0.050917, -0.242102, -0.204461, -0.515671, -0.487741, -0.400038, -0.359750, -0.531922, -0.376179, -0.281697, -0.367224, -0.582711, -0.735183, -0.567199, -0.381060, -0.522108, -0.554821, -0.550518, -0.656257, -0.680274, 0.535073, 0.094034, -0.364009, -0.164736, -0.425214, -0.669214, -0.487664, -0.374594, -0.427947, -0.439502, -0.478767, -0.398022, -0.357037, -0.357554, -0.366012, -0.513259, -0.478759, -0.435814, -0.567829, -0.578674, -0.416010, -0.207775, -0.074297, -0.190482, -0.396134, -0.436384, -0.340497, -0.214589, -0.248026, -0.089992, -0.939927, -0.083841, -0.284204, 0.431477, -0.058176, -0.101740, -0.190493, 0.047605, 0.057150, 0.023124, -0.036511, -0.002691, -0.094907, 0.014443, -0.230949, -0.042078, 0.175650, 0.090012, -0.103157, -0.050364, 0.129086, 0.162955, 0.320116, 0.260278, 0.059174, -0.105785, 0.116034, 0.179947, 0.190324, 0.837336, -0.330699, 0.361240, 0.366307, 0.358920, 0.396010, 0.366177, 0.203827, 0.021364, -0.184936, -0.063916, 0.065898, -0.198727, -0.341007, -0.306235, -0.222671, -0.212921, -0.327788, -0.115871, -0.248288, -0.179661, -0.098945, -0.304702, -0.367546, -0.277097, -0.208143, -0.228308, -0.396932, -0.344554, -0.531991, -0.667900, -0.327661, -0.425957, -0.344589, 0.299409, 0.377077, 0.145804, -0.041728, 0.215510, 0.162025, 0.152322, -0.095228, 0.131547, 0.137461, 0.180964, -0.144583, 0.138301, 0.546182, 0.523585, -0.062578, 0.064186, 0.454757, 0.691525, 0.815552, 0.623175, 0.237582, 0.015207, 0.479471, 0.417731, 0.654751, 1.459668, 0.494837, -0.421407, 0.561919, 0.441179, 0.758563, 0.835565, 0.538617, 0.425638, 0.400068, 0.207277, -0.176415, -0.217132, -0.207691, -0.206634, -0.138972, 0.222190, 0.379625, 0.330078, 0.400406, 0.345781, 0.181261, 0.178662, 0.163026, 0.129297, 0.072816, 0.053255, 0.037701, 0.137433, 0.014661, 0.041251, -0.282795, -0.174808, 0.505814, -0.253303, -0.034146, 0.042144, -0.112995, -0.234848, -0.006446, 0.144296, -0.118401, -0.119787, -0.221128, -0.102247, 0.262159, 0.175205, -0.007497, 0.006537, -0.165064, -0.008730, 0.023517, 0.333050, 0.457916, 0.261168, -0.062761, -0.169444, -0.189595, 0.003060, 0.146738, 0.258981, -0.530387, 0.469824, 0.329679, 0.074551, 0.401730, 0.344988, 0.306234, 0.148171, -0.003797, 0.012285, 0.211252, 0.160244, 0.054871, -0.006081, -0.202364, -0.026247, -0.100124, -0.023772, 0.042806, -0.012189, -0.093816, -0.376022, -0.480524, -0.459624, -0.163709, -0.152061, -0.124695, -0.278765, -0.339455, -0.406355, -0.144062, 0.417394, 0.486541, -0.186933, 0.230545, -0.146857, -0.161039, -0.225934, -0.054652, 0.184786, -0.127643, -0.075619, -0.241128, 0.077903, 0.539192, 0.554782, 0.174565, 0.303376, -0.033793, 0.028933, 0.383364, 0.817186, 0.823907, 0.640145, 0.208531, -0.062303, 0.095960, 0.385840, 0.370706, 0.671995, 0.068684, 1.819461, 0.186604, 0.734184, 0.865199, 0.768502, 1.041404, 1.056439, 1.149734, 0.959915, 0.705416, 0.871780, 1.149848, 0.841222, 0.675072, 1.050228, 0.856955, 0.314491, 0.363086, 0.610538, 1.063037, 0.744665, 0.054948, 0.811795, 1.342645, 1.130261, 0.484350, 0.216839, 0.648255, 1.006359, -1.591565, -1.603736, -0.453971, -0.238287, -0.321282, -0.555467, -0.275594, -0.440718, -0.208639, -0.143145, -0.373056, -0.275385, -0.043898, -0.112842, -0.238329, -0.238242, -0.375598, -0.445778, -0.141421, -0.391186, -0.218642, -0.435641, -0.650382, -0.074445, -0.281494, -0.358150, -0.489279, -0.511369, -0.511853, -0.540950, -0.154064, -0.281799, -0.191743, -0.361031, -0.445663, -0.260548, -0.040527, -0.019962, 0.045557, 0.005753, -0.184480, -0.369870, -0.146670, -0.385610, -0.402383, -0.212788, -0.197369, -0.143572, -0.440082, -0.266361, -0.432411, -0.575959, -0.454476, -0.227020, -0.336751, -0.360204, -0.278416, -0.379095, -0.166333, -0.143624, -0.895156, -1.236933, -0.329606, -0.283533, -0.291970, -0.445464, -0.066365, -0.291582, -0.135223, -0.338243, -0.665535, -0.462223, -0.033058, -0.130568, -0.220769, -0.228757, -0.171766, -0.320608, -0.131754, -0.469606, -0.394910, -0.441796, -0.593837, -0.204981, -0.257130, -0.351513, -0.529223, -0.530559, -0.559276, -0.528901, 0.548244, -0.449318, 0.566413, 0.491056, 0.771722, 0.988550, 0.678857, 0.543947, 0.583624, 0.322381, -0.102487, -0.081806, -0.115075, -0.190884, -0.058878, 0.277884, 0.493549, 0.483067, 0.535020, 0.414681, 0.300299, 0.245841, 0.188980, 0.182283, 0.167947, 0.161113, 0.100318, 0.189501, 0.084097, 0.127388, -0.066038, -0.003393, 0.683744, -0.136828, -0.074549, 0.077702, 0.026593, 0.225665, 0.172381, 0.130703, -0.083902, 0.223553, -0.026631, 0.084372, 0.269493, 0.111560, -0.135360, -0.115240, -0.121203, -0.205250, -0.283963, 0.382915, 0.489373, 0.305069, 0.009528, -0.135934, -0.136151, 0.089884, 0.151544, 0.303887, 0.515071, -0.452737, -0.061599, 0.182900, 0.099200, 0.007915, 0.107962, 0.507135, 0.774691, 0.707361, 0.653682, 0.702622, 0.712809, 0.785655, 0.799532, 0.482168, 0.714233, 0.793466, 0.754783, 0.514012, 0.510455, 1.075171, 1.176114, 1.083147, 0.911883, 0.857907, 1.050096, 1.157448, 1.151287, 1.421822, 0.105718, 0.499348, 0.663654, -0.088444, -0.055346, -0.071320, -0.048409, 0.257467, 0.139024, 0.228968, -0.050625, 0.401430, 0.106895, 0.330662, 0.687444, 0.179619, -0.090372, 0.051226, -0.015801, -0.054851, 0.053613, 1.011080, 0.894641, 0.739117, 0.220980, 0.172661, 0.313872, 0.490158, 0.572560, 0.854320, 0.775049, 1.462199, 1.815002, 1.876424, 1.515850, 1.331057, 1.277212, 1.440673, 1.414224, 1.384631, 1.290613, 1.284352, 1.308613, 1.350518, 1.425250, 1.344540, 1.072523, 0.971834, 1.018799, 1.082286, 1.024741, 0.979417, 0.877251, 0.765526, 0.792782, 0.696547, 0.777019, 0.464223, 0.577019, 0.712339, 0.186283, 0.789577, 1.801718, 2.029662, 2.454207, 2.560630, 2.718556, 2.895103, 2.182579, 1.794324, 1.971288, 2.235278, 2.582884, 2.076846, 1.720915, 1.346579, 1.303986, 1.816293, 2.390668, 2.641469, 2.542964, 2.542604, 2.250080, 2.168734, 2.148616, 1.670922, 1.468709, 1.593409, 1.901193, 1.908226, -1.206874, -1.658544, -2.678104, -3.201142, -3.000976, -3.020751, -2.998947, -3.276874, -3.152377, -2.617330, -2.602903, -2.476877, -2.679595, -2.847551, -2.481969, -2.021061, -2.073467, -2.579489, -3.013188, -2.710830, -2.790870, -3.109013, -2.753703, -2.872751, -3.154187, -2.745682, -2.432256, -2.161668, -2.663451, -2.949262, 1.594401, 1.128837, 1.227805, 1.134522, 1.347299, 1.291105, 1.133468, 1.355568, 0.760508, 1.033470, 1.128063, 0.666737, 1.345161, 1.232358, 0.490324, 0.567192, 0.572349, 1.407980, 1.729776, 1.826555, 1.995686, 1.758691, 1.255573, 1.456564, 1.218409, 1.385669, 1.057864, 1.342238, 1.624833, 1.602957, -0.886921, 0.237269, 0.118178, -0.483557, -0.247419, 0.003656, 0.070525, -0.108966, -0.312017, -0.096398, 0.015622, 0.148546, 0.325181, 0.353526, 0.225795, 0.115419, -0.125831, 0.026299, 0.132681, 0.062060, -0.016832, -0.357399, -0.261926, -0.133504, 0.054251, 0.178505, 0.034828, -0.012082, 0.259140, -0.062790, 1.500500, -1.113037, 0.032822, -0.522349, -0.413677, -0.174948, -0.101266, -0.171968, -0.210295, -0.079569, -0.081424, -0.178777, -0.035343, -0.171330, -0.036771, -0.008199, -0.383909, -0.293581, -0.200858, -0.053609, -0.123490, -0.362885, 0.011150, 0.089198, -0.218206, -0.225557, 0.244615, 0.035802, -0.006893, 0.000005, -0.618154, -0.284320, -0.287165, -0.300482, -0.206636, -0.200242, -0.142807, 0.024862, -0.164785, -0.206509, -0.200626, -0.189789, -0.123781, -0.228379, -0.301282, -0.287327, -0.034516, 0.087368, -0.081281, -0.223151, -0.183003, -0.092107, -0.302489, -0.307358, -0.380060, -0.315600, -0.223417, -0.088563, -0.058732, -0.259627, 1.407122, -0.361391, 0.276785, -0.373402, -0.485218, -0.309930, 0.217427, 0.005042, -0.319182, 0.004874, 0.185735, 0.193427, 0.377340, 0.067389, 0.195283, 0.037312, -0.201222, -0.280584, -0.025992, 0.122673, 0.090537, -0.019958, 0.531145, 0.396076, -0.106792, 0.035478, 0.894943, 0.557046, 0.320092, 0.469546, -0.915713, -0.557595, -0.443776, -0.315832, -0.200629, -0.191416, -0.236856, -0.251673, -0.382650, -0.349057, -0.347476, -0.155535, -0.036708, 0.307255, 0.297125, 0.266271, 0.013948, -0.420626, -0.417960, 0.046834, -0.138458, -0.635695, -0.769904, -0.488917, -0.463304, -0.440846, -0.458871, -0.730694, -0.711788, -0.564570, 0.135528, -0.178259, 0.236981, 0.190668, -0.069180, 0.384163, -0.312310, -0.239104, -0.202891, -0.021865, 0.128632, 0.828593, 2.005491, 3.410764, 2.436772, 2.423036, 3.557944, 1.750285, 1.040160, 3.003267, 2.380857, 0.412454, 0.734641, 1.354221, 0.943078, 0.990540, 0.265811, -0.046745, -0.090463, 0.100383, 0.506930, 1.067108, 0.773847, 0.194524, -0.052502, -0.147916, 0.089880, 0.102564, 0.050360, -0.113601, -0.702978, -0.600870, -0.921873, -1.819069, -1.217641, -0.942644, -1.184016, -1.183226, -1.388302, -1.578614, -1.336016, -0.467277, -0.467643, -0.315679, -0.567389, -0.817467, -0.344511, -0.073639, 0.359768, 0.168183, -0.320920, 0.160785, 0.458493, 0.346306, -0.163404, -0.046062, -0.553110, -0.046116, -0.069676, -0.306712, 0.176014, 1.056561, 2.743706, 4.237696, 2.407219, 2.319913, 4.106381, 2.185529, 1.004333, 3.410049, 2.696043, 0.582461, 0.758341, 1.287297, 1.013342, 0.969813, 0.166680, -0.044698, -0.053929, 0.192220, 0.025184, 1.712839, 0.390197, 0.767323, 0.886517, 0.735807, 0.975206, 1.150339, 1.251930, 1.011338, 0.762587, 0.976622, 1.289744, 0.855790, 0.719754, 1.079994, 0.892106, 0.357106, 0.362139, 0.595357, 1.091491, 0.744635, 0.150288, 0.692976, 1.233608, 1.180862, 0.596235, 0.309949, 0.576439, 0.919032, -1.497174, -1.488544, -0.545053, -0.168997, -0.333259, -0.625539, -0.318565, -0.702098, -0.082714, 0.003190, -0.173241, -0.132426, 0.100451, 0.097089, -0.152964, -0.000739, -0.257094, -0.474961, -0.191161, -0.357254, -0.215835, -0.504848, -0.710110, -0.359095, -0.413077, -0.439906, -0.623701, -0.541893, -0.371884, -0.531285, 0.215644, 0.328667, 0.302359, 0.595769, 0.561644, 0.820855, 0.719314, 0.612119, 0.406893, 0.757808, 0.806670, 0.681675, 0.980837, 0.783074, 0.386216, 0.329575, 0.361747, 0.581574, 0.702219, 0.533061, 0.318360, 0.247543, 0.296524, -0.171864, 0.056877, 0.077025, 0.191173, 0.407485, 0.592781, 0.423557, -0.863483, -1.168776, -0.314819, 0.060809, -0.162740, -0.334452, -0.325274, -0.619575, -0.148515, -0.143897, -0.165533, -0.041127, 0.281968, -0.004741, -0.174586, 0.146972, -0.180674, -0.360571, -0.106456, -0.300392, -0.402432, -0.624909, -0.631854, -0.564047, -0.536348, -0.403001, -0.703210, -0.748150, -0.528785, -0.529413, 1.115195, 1.447473, 0.970124, 0.492482, 0.625140, 0.744565, 0.760446, 0.271337, -0.007293, 0.349862, 0.372631, -0.022250, -0.077063, -0.123484, 0.173161, 0.251579, 0.245459, 0.173959, 0.035244, 0.198963, 0.173285, 0.294925, 0.392662, 0.149197, 0.161578, 0.078556, 0.451355, 0.565257, 0.379974, 0.050052, -0.201954, 1.823437, -0.232688, -0.437683, 0.019563, -0.120797, 0.078612, -0.205065, 0.022462, 0.012554, -0.057532, -0.068087, -0.106704, -0.278003, -0.036245, -0.211378, -0.270945, -0.273134, -0.267008, -0.063744, -0.102652, 0.286873, 0.175833, -0.212876, -0.079980, -0.198034, 0.150551, 0.020356, -0.087775, -0.228487, -0.164826, 0.366844, 0.300281, 0.241781, 0.252782, 0.197792, 0.311908, 0.336652, 0.309445, 0.339103, 0.324235, 0.309827, 0.315406, 0.322031, 0.167151, 0.151953, 0.235865, 0.219247, 0.220126, 0.267224, 0.283219, 0.299289, 0.254431, 0.290599, 0.330402, 0.388153, 0.235501, 0.242809, 0.379937, 0.194607, -0.487804, 1.005244, -0.534706, -0.587916, -0.195177, -0.256451, -0.050128, -0.239652, 0.028785, 0.080529, 0.010627, 0.095891, 0.006559, -0.159446, -0.027009, -0.158532, -0.322465, -0.356730, -0.270982, -0.078488, -0.178883, -0.218727, -0.381394, -0.464936, -0.214243, -0.329242, -0.300010, -0.294056, -0.300839, -0.492897, -0.348576, 0.339560, -0.660047, -0.791135, -0.815346, -0.738367, -0.623031, -0.575869, -0.577218, -0.547412, -0.514028, -0.732003, -0.767084, -0.779702, -0.871698, -0.757284, -0.887416, -1.157501, -1.176993, -1.083344, -1.055709, -1.160248, -1.136080, -1.033599, -0.879660, -0.928779, -0.871922, -0.982897, -1.011785, -0.947473, -0.601034, -0.428454, -0.804096, -0.336656, -0.287922, -0.344737, -0.330410, -0.210902, -0.204206, -0.412291, -0.237401, -0.419547, -0.272979, -0.327847, -0.245948, -0.276558, -0.295820, -0.324767, -0.234512, -0.261034, -0.376236, -0.577729, -0.611167, -0.402917, -0.291921, -0.500758, -0.533106, -0.539624, -0.493701, -0.539944, -0.399668, -0.408811, -0.266008, -0.398118, -0.455590, -0.150190, -0.127241, -0.188594, -0.172449, -0.239914, -0.403778, -0.395726, -0.185126, -0.116579, -0.093982, -0.108092, -0.318327, -0.233513, -0.217233, -0.295327, -0.386995, -0.409802, -0.254418, -0.200102, -0.261467, -0.198748, -0.110673, -0.203961, -0.205134, -0.266495, -0.576101, -0.772250, -0.611578, -0.095148, -0.140759, -0.284764, -0.323047, -0.081773, -0.148389, -0.485505, -0.223054, -0.466120, -0.372764, -0.354579, -0.302347, -0.255359, -0.312717, -0.443789, -0.237892, -0.282770, -0.223034, -0.487338, -0.532738, -0.331814, -0.343743, -0.528018, -0.566310, -0.490646, -0.569383, -0.513730, 2.423027, 2.380657, 2.876993, 3.212532, 2.921315, 2.749555, 2.803946, 2.982756, 2.980434, 3.328060, 3.283324, 3.322011, 3.336290, 3.440889, 3.357978, 2.884701, 2.531773, 2.637091, 2.984982, 3.269366, 2.932697, 2.678360, 2.746882, 2.614926, 2.677189, 2.775764, 2.516471, 2.111193, 2.344449, 2.475552, 2.904677, 6.912574, 9.526620, 8.732975, 8.918058, 8.842205, 8.727154, 8.691282, 8.527538, 8.142828, 8.590753, 8.692855, 8.957491, 8.080562, 7.494583, 8.153288, 8.436485, 7.859940, 8.661308, 8.872196, 8.883200, 7.842916, 7.384201, 8.135366, 8.370284, 8.158920, 7.952888, 7.970739, 7.539951, 6.858473, -1.515810, -3.138102, -4.437707, -4.621579, -4.864348, -4.320320, -4.431526, -4.672632, -4.437219, -4.475072, -4.761756, -4.688154, -4.036356, -3.758102, -3.267513, -3.738114, -3.251777, -3.112489, -4.147465, -4.020648, -4.444523, -4.508073, -4.066719, -3.549558, -4.538022, -4.840677, -5.126159, -5.143474, -5.276686, -4.629604, 4.665306, 7.576952, 10.407156, 8.690693, 8.761837, 9.125856, 9.302380, 9.521160, 9.773685, 9.015078, 8.365137, 9.177647, 9.684818, 8.862790, 7.584403, 8.472878, 9.418295, 8.987730, 9.429618, 9.606860, 9.694498, 7.371590, 6.522288, 7.998809, 8.989644, 8.469398, 8.214573, 8.919891, 7.867693, 6.782964, 0.320202, 0.133278, -0.018787, 0.207445, -0.070189, -0.420727, -0.533228, -0.533975, -0.214188, -0.054979, 0.037244, 0.110105, -0.009623, -0.147258, -0.387368, -0.311309, -0.082614, 0.057304, -0.042506, 0.087724, 0.298773, 0.420772, 0.388587, 0.265101, 0.395918, 0.406904, 0.216942, 0.286310, 0.339691, 0.605738, 0.197510, 0.000931, -0.198697, 0.233450, 0.167574, 0.036287, 0.129389, -0.030710, 0.016905, -0.015619, 0.234141, 0.061591, 0.018615, -0.054287, -0.101716, -0.172213, -0.296388, -0.338817, -0.176291, -0.139402, 0.059175, 0.010374, -0.305686, -0.369509, -0.215637, -0.005862, -0.251337, -0.213210, -0.235537, -0.059331, -0.691147, -0.592200, -0.630707, -0.486711, -0.665764, -0.995046, -1.127420, -0.895122, -0.757748, -0.783010, -0.642606, -0.728126, -0.824110, -0.593147, -0.618106, -0.546458, -0.438909, -0.442714, -0.600761, -0.646835, -0.431437, -0.472629, -0.339618, -0.370031, -0.597276, -0.581474, -0.559816, -0.591928, -0.434958, -0.454492, -0.129607, -0.376607, -0.082878, -0.093229, -0.012394, 0.035685, 0.280578, 0.098386, 0.087728, 0.010873, 0.175147, -0.082628, -0.144547, -0.081137, -0.028744, -0.166494, -0.348679, -0.370558, -0.271242, -0.177783, -0.181718, -0.441013, -0.553144, -0.569581, -0.269910, -0.230618, -0.481359, -0.447684, -0.478694, -0.420865, -0.677737, -0.320659, -0.507580, -0.441734, -0.754440, -0.706967, -0.766289, -0.699043, -0.533254, -0.626638, -0.457923, -0.616541, -0.661612, -0.720495, -0.912021, -0.851600, -0.914366, -1.027117, -0.974659, -0.873029, -0.922166, -1.098887, -1.106254, -0.940071, -0.756806, -0.877343, -0.861763, -0.932945, -1.026274, -0.906435, 0.449722, -0.365318, -0.677740, -0.554516, -0.231065, -0.132180, -0.259816, -0.160792, -0.235484, -0.240496, -0.264023, -0.311509, -0.120026, -0.181673, -0.272188, -0.282812, -0.342330, -0.433298, -0.320406, -0.070774, -0.431167, -0.721421, -0.663882, -0.495585, -0.282189, -0.510153, -0.521220, -0.464755, -0.581441, -0.639569, 0.907989, 0.653371, 0.412498, 0.259978, 0.315596, 0.015081, 0.078768, -0.018656, -0.312372, -0.079086, -0.246286, -0.396350, -0.248318, -0.092594, -0.428067, -0.373236, -0.506647, -0.179715, 0.302343, 0.350682, 0.203056, 0.096180, -0.033674, -0.123260, -0.110309, -0.000840, -0.176980, -0.009568, 0.164272, 0.113386, 0.664969, -0.652183, -0.557766, -0.307365, -0.180172, -0.081842, -0.049545, -0.047142, 0.038571, -0.163745, -0.335098, -0.180327, 0.059285, -0.197682, -0.358066, -0.231920, -0.371044, -0.493220, -0.472326, 0.184363, -0.350821, -0.642719, -0.667635, -0.498737, -0.235474, -0.587391, -0.560897, -0.506569, -0.585816, -0.606256, -0.205467, -0.362882, 0.371379, -0.206537, -0.363364, -0.522208, -0.746058, -0.509713, -0.347573, -0.413015, -0.323261, -0.164037, 0.018378, 0.117083, 0.100696, -0.161440, 0.107840, 0.478809, 0.382119, -0.025571, -0.043133, 0.225665, 0.502622, 0.280501, -0.048335, 0.113886, 0.270061, 0.153917, 0.088091, -0.013232, -0.346961, -0.288551, 0.089860, -0.072979, 0.042063, -0.200668, -0.305061, 0.036995, -0.152267, -0.255216, -0.225171, -0.194979, -0.237666, -0.246720, -0.100391, -0.184368, 0.022506, 0.184082, 0.135755, -0.223211, -0.230403, -0.337052, -0.227268, -0.159558, -0.040320, -0.081575, -0.162388, -0.213023, -0.073502, -0.321865, 0.065358, 0.368548, 0.281056, 0.244814, 0.273441, 0.350837, 0.387478, 0.345437, 0.338803, 0.408936, 0.478340, 0.570161, 0.528312, 0.472431, 0.397238, 0.368950, 0.236890, 0.231087, 0.171202, 0.273006, 0.276182, 0.265117, 0.277836, 0.441152, 0.466826, 0.283471, 0.203804, 0.236726, 0.222629, 0.241608, -0.221442, 0.657750, -0.440167, -0.299267, -0.133371, -0.075861, -0.351526, 0.018871, -0.173171, -0.300587, -0.358472, -0.183742, -0.336347, -0.272942, -0.089402, -0.203451, -0.192631, -0.085326, -0.090153, -0.292118, -0.259182, -0.475575, -0.423674, -0.362690, -0.238673, -0.404140, -0.377434, -0.419387, -0.320441, -0.450597, -0.993275, -0.277159, -0.125229, -1.066009, -0.688543, -0.396093, -0.126561, -0.467129, -0.732067, -0.436778, -0.288274, -0.218299, -0.182997, -0.294063, -0.306028, -0.282552, -0.434834, -0.332004, -0.175879, -0.203512, -0.271253, -0.251775, -0.440330, -0.300565, -0.256118, -0.099585, -0.139556, -0.202409, -0.252860, -0.272564, 2.117522, -0.511205, 0.125009, 0.194082, 0.105160, -0.211438, 0.264666, 0.148865, -0.046353, 0.213522, 0.129792, 0.349565, 0.311363, 0.105487, -0.073455, 0.046806, -0.376556, -0.222505, 0.044559, 0.045364, -0.051374, 0.224131, 0.325173, 0.434199, 0.268489, 0.366095, 0.636845, 0.538832, 0.474595, 0.583877, 0.026998, 0.436327, 0.573674, 0.800785, 0.822813, 0.522636, 0.570647, 0.714454, 0.709524, 0.636909, 0.811331, 0.925737, 0.607889, 0.491257, 0.414611, 0.539407, 0.364950, 0.454169, 0.527136, 0.518982, 0.350977, 0.459991, 0.499707, 0.678022, 0.646347, 0.615398, 0.520783, 0.239469, 0.256571, 0.259833, 1.733303, -0.388651, -0.011547, 0.548296, -0.066767, -0.147284, 0.696553, 0.240991, 0.191876, 0.471632, 0.407766, 0.872129, 0.705378, 0.475908, 0.244803, 0.307804, -0.202796, -0.222329, 0.109202, 0.014422, 0.163215, 0.703549, 0.729605, 0.878565, 0.730485, 0.778972, 1.071402, 0.927964, 0.862820, 1.104552, 2.816673, 2.442171, 3.225478, 3.437145, 3.135844, 3.031209, 2.932886, 3.437970, 3.738809, 3.901822, 3.985358, 4.176028, 4.120257, 4.014013, 3.604290, 3.456909, 3.233798, 3.519650, 3.994353, 4.353147, 3.849883, 3.505605, 3.514757, 3.733281, 3.723851, 3.730595, 3.769907, 3.579390, 3.655431, 3.493665, 0.436194, 3.133618, 4.497782, 5.304927, 5.075227, 4.554264, 4.637960, 4.365458, 4.480056, 5.103788, 5.275721, 5.046229, 5.139199, 4.830439, 5.191004, 5.499779, 5.671664, 5.838140, 5.825746, 5.382543, 5.508441, 5.698984, 5.131783, 6.228337, 6.410169, 5.624159, 5.862572, 6.269675, 6.276918, 6.275986, 0.697742, 1.248388, 1.859410, 1.829750, 1.109158, 0.876299, 1.312952, 1.126204, 0.970076, 1.156615, 0.504985, 0.627008, 0.337153, -0.197900, 0.430741, 0.573875, 0.281602, 0.315711, 0.536122, 0.415023, 0.722615, 0.947672, 1.193403, 0.943977, 1.667225, 1.305057, 1.174381, 1.321931, 1.076381, 1.596660, -0.338027, 2.355077, 3.348950, 3.621656, 3.771056, 2.489368, 2.377005, 2.268300, 2.293033, 3.160956, 3.407436, 2.955893, 3.184868, 3.474898, 3.355098, 3.553707, 3.603737, 3.279695, 4.223521, 3.978983, 4.103305, 3.803746, 3.006145, 4.302152, 5.023946, 3.850235, 3.965050, 4.303555, 4.328235, 4.229154, -0.962680, -0.171332, -0.013752, -1.043394, -0.675196, -0.464987, -0.203552, -0.573202, -0.909208, -0.271617, -0.216564, -0.282878, -0.120989, -0.102662, -0.219646, -0.270222, -0.367438, -0.105387, 0.474306, 0.570749, 0.379067, 0.582881, 0.777516, 0.609315, 0.814338, 0.875343, 0.686398, 0.522026, 0.883272, 0.552872, 1.311905, -0.553074, -0.561306, 0.406390, 0.163965, -0.336460, 0.651532, -0.039837, -0.055470, -0.062066, 0.375233, 0.065905, -0.065077, -0.301869, 0.075241, 0.931172, 0.194740, 0.624120, 0.890810, 1.407836, 1.601801, 1.353219, 1.617602, 1.841259, 2.058334, 1.698040, 1.688757, 1.674761, 2.768088, 2.093802, -0.292472, 0.020829, -0.321565, -1.260240, -0.056859, -0.613158, -0.253005, -0.867373, -1.028371, -1.970342, -1.144927, -0.829776, -1.067150, -1.943612, -1.382977, -1.882205, -2.580598, -1.790057, -2.279082, -3.528894, -3.644083, -3.211253, -3.258309, -3.861280, -4.619346, -3.349799, -3.442536, -3.548983, -4.838950, -4.626010, 1.556108, -0.559821, -0.673998, 0.139933, -0.851747, -0.785495, 0.349746, -1.032465, -0.606697, 0.261506, 0.222766, 0.814453, 0.589222, 0.277595, 0.325787, 0.423564, -0.187350, -0.027390, -0.011906, -0.463842, -0.254334, 0.571094, 0.975374, 0.485469, 0.507565, 1.176917, 1.173872, 0.999626, 0.981915, 0.992460, 0.465402, -0.611482, -1.018603, -0.729116, -1.013034, -1.005676, -0.785923, -0.585895, -0.565794, -0.674970, -0.480929, -0.143774, -0.158907, -0.284748, -0.248980, -0.575745, -0.496467, -0.227892, -0.331026, -0.613806, -0.605648, -0.487436, -0.217621, -0.412303, -0.693488, -0.372088, -0.546093, -0.550005, -0.562929, -0.581537, -0.576098, 0.025442, 0.235809, 0.393336, -0.252040, -0.106560, -0.221946, -0.147383, -0.051754, -0.335453, -0.181661, -0.027117, -0.035479, -0.251384, 0.077097, -0.133209, 0.060302, 0.056206, 0.025074, -0.290581, -0.322715, 0.081310, 0.678286, 0.268794, -0.018692, 0.569276, 0.081865, 0.056973, 0.142018, 0.021656, 0.272982, 0.705074, 0.936083, 0.505516, 0.261537, 0.227046, 0.093840, 0.272379, 0.327344, 0.366289, 0.405333, 0.295542, 0.339684, 0.680129, 0.616026, 0.598620, 0.516183, 0.802855, 1.044758, 0.467972, 0.526302, 1.070666, 1.382842, 1.118787, 0.981032, 1.530130, 1.203407, 1.140210, 1.252455, 0.954402, -0.172391, 0.706815, 0.382433, 0.534309, -0.006895, -0.155795, -0.192994, -0.053690, 0.160010, -0.184866, -0.002597, 0.005761, -0.151300, -0.091554, 0.380701, 0.106942, 0.204883, 0.538596, 0.491582, -0.095381, -0.067344, 0.725671, 1.370363, 0.825035, 0.306118, 1.147140, 0.618446, 0.498880, 0.805193, 0.498947, -1.039660, -0.394131, -0.538862, -0.967278, -0.729570, -0.462689, -0.316767, -0.517299, -0.664525, -0.449668, -0.329033, -0.699523, -0.788052, -0.671514, -0.706006, -0.589534, -0.806748, -1.091820, -1.069721, -0.945780, -1.012295, -1.279507, -1.291307, -1.118248, -0.982749, -1.061766, -0.987151, -1.098301, -0.941882, -0.982254, 0.281131, -0.286011, -0.353634, -0.555232, -0.283603, -0.364304, -0.346468, -0.421240, -0.455349, -0.432168, -0.088035, -0.330068, -0.304164, -0.232929, -0.448169, -0.164507, -0.389093, -0.433381, -0.418000, -0.200016, -0.517141, -0.699457, -0.594653, -0.416851, -0.403975, -0.559812, -0.469537, -0.534701, -0.559776, -0.612289, 1.188595, 0.319426, -0.096226, 0.180220, 0.147136, 0.201945, 0.182121, 0.123063, 0.340623, 0.235425, 0.367048, 0.663768, 0.489977, 0.302517, 0.213713, 0.293279, 0.368060, 0.068468, 0.155609, 0.295971, 0.205790, 0.245148, 0.292656, 0.311330, 0.270072, 0.093268, 0.061675, 0.149482, 0.067200, 0.241150, -0.056464, 0.015730, -0.232019, -0.756856, -0.478576, -0.395651, -0.364556, -0.366034, -0.465413, -0.429925, 0.136459, -0.335816, -0.143547, -0.102867, -0.345524, -0.000605, -0.315594, -0.550244, -0.416327, -0.138611, -0.576872, -0.690520, -0.648787, -0.404792, -0.381865, -0.554783, -0.494754, -0.609771, -0.517570, -0.535129, -1.926359, -0.249022, -0.105845, 0.419315, 0.633938, 0.614993, 0.929158, 1.065174, 0.871291, 0.635654, 0.431387, 0.515337, 0.301738, 0.540440, 0.740674, 1.217568, 1.392497, 0.344622, 0.322969, 0.558993, 0.324600, -0.148154, -0.282116, 0.138086, 0.492547, 0.318948, 0.301711, 0.058398, 0.114138, 0.428455, -0.749349, -0.605669, -0.239052, -0.292277, -0.158450, -0.336788, -0.147833, -0.020487, -0.242916, -0.136939, -0.201221, -0.126033, -0.354197, -0.169679, -0.322242, -0.277557, -0.121032, -0.464129, -0.228627, -0.190479, -0.202335, -0.529869, -0.623279, -0.451576, -0.339162, -0.537993, -0.447859, -0.443401, -0.574204, -0.636879, -0.139242, 0.025807, -0.033984, -0.037759, 0.339816, 0.280927, 0.045151, -0.000480, 0.126719, 0.149292, -0.021458, -0.072252, 0.169109, 0.064846, -0.119093, -0.063277, 0.240530, 0.302222, 0.228544, 0.251236, 0.143194, 0.079330, 0.077174, 0.428540, 0.147136, 0.076821, 0.101216, 0.207378, 0.158766, 0.051324, -0.334159, -0.517982, -0.128400, -0.246066, -0.188733, -0.311730, -0.083975, -0.401327, -0.434950, -0.089085, -0.276913, -0.219009, -0.484078, -0.412332, -0.346167, -0.129855, 0.080969, -0.329349, -0.118309, -0.080559, -0.372166, -0.396010, -0.645839, -0.491958, -0.336181, -0.603996, -0.562757, -0.512258, -0.520639, -0.649719, 0.483100, -0.652136, 0.487465, 0.492134, 0.695010, 0.674137, 0.342395, 0.177154, 0.200445, -0.178147, -0.650977, -0.562939, -0.460500, -0.300522, -0.346015, -0.127831, 0.154871, 0.268137, 0.508329, 0.289081, -0.109661, 0.233819, 0.213603, -0.113196, -0.322133, 0.095043, 0.118744, -0.020068, -0.218355, -0.172329, -0.079348, -0.139000, -0.239945, -0.357152, 0.088440, -0.091522, -0.134187, -0.257109, -0.206420, -0.132239, -0.148042, -0.058621, -0.191046, -0.028790, 0.052378, 0.080757, -0.035457, 0.244440, 0.203374, -0.044640, -0.086137, 0.523219, 0.874836, 0.313904, 0.112490, 0.963650, 0.670160, 0.450857, 0.502622, 0.424430, -0.647359, 0.135683, 0.225122, -0.017785, 0.095851, 0.049811, 0.038756, -0.052662, -0.120226, -0.211845, -0.155303, -0.151273, -0.198319, -0.252252, -0.169642, -0.315451, -0.321592, -0.470237, -0.531759, -0.356326, -0.412994, -0.511085, -0.497306, -0.431655, -0.516790, -0.587073, -0.713598, -0.461175, -0.382677, -0.421980, 0.068010, -0.378175, -0.364716, -0.065969, 0.594724, -0.033699, -0.131574, -0.351018, -0.114754, 0.085114, -0.031598, 0.076905, -0.089451, 0.015041, 0.337229, 0.069485, -0.022565, 0.597147, 0.695490, 0.234272, 0.292023, 1.141412, 1.289270, 0.683661, 0.473550, 1.521015, 1.281362, 0.954791, 0.982861, 0.894014, 1.095542, 1.090383, 0.896358, 1.041075, 1.175786, 1.007872, 0.857809, 0.543825, 0.270418, 0.507520, 0.454414, 0.210424, 0.251186, 0.244833, 0.462102, 0.540941, 0.593104, 0.697554, 0.565089, 0.650345, 0.560598, 0.614518, 0.785239, 0.940001, 0.701136, 0.363836, 0.717781, 0.987832, 0.928369, 0.486640, -0.223259, 1.338327, -0.313343, 0.461117, 1.167952, 0.695208, 0.444842, 0.217480, 0.252336, 0.199859, 0.071144, 0.137174, -0.052282, -0.212858, 0.008741, -0.009727, 0.122439, -0.061866, -0.053683, -0.035111, -0.088009, 0.232443, 0.117810, 0.171223, 0.104431, -0.183967, 0.113414, 0.096459, 0.149375, -0.034864, -0.114226, 0.243396, 0.038165, 0.323740, 0.607592, 0.147591, -0.153436, -0.095782, -0.078742, 0.072290, -0.013274, 0.046689, 0.079574, -0.248887, -0.315542, -0.184161, -0.029957, -0.332104, -0.242789, -0.003757, 0.092494, 0.068778, -0.357754, -0.370637, -0.104567, -0.134928, -0.259958, -0.228943, -0.108353, -0.199839, -0.447127, 0.618930, -0.382697, 0.796882, 1.373647, 0.952170, 0.539134, 0.233863, 0.245679, 0.343846, 0.270629, 0.132884, -0.024866, -0.265688, 0.016984, -0.257983, 0.006355, -0.064554, -0.104688, -0.066778, -0.248633, -0.185694, -0.280494, 0.208714, 0.075058, -0.340793, -0.195740, -0.077090, 0.056259, -0.305389, 0.133429, 1.897949, 0.126469, 0.734683, 0.833392, 0.742136, 0.977085, 1.016266, 1.268238, 1.072308, 0.667377, 0.838370, 1.252702, 0.942168, 0.738734, 1.143369, 0.931951, 0.392616, 0.390017, 0.594012, 1.125217, 0.770577, 0.063035, 0.879529, 1.413490, 1.154421, 0.510956, 0.230067, 0.615419, 0.980679, -1.621323, -1.861821, -0.346270, -0.182311, -0.267118, -0.470881, -0.172982, -0.496402, -0.056258, 0.048633, -0.221818, -0.400830, -0.048992, -0.274553, -0.507447, -0.344250, -0.488676, -0.401763, -0.196523, -0.426099, -0.191184, -0.462515, -0.696259, -0.098419, -0.273581, -0.404859, -0.549203, -0.467605, -0.496037, -0.520611, 0.069431, 0.188528, 0.287302, 0.101624, 0.120079, -0.035019, -0.104905, 0.058874, 0.256538, 0.288462, 0.168663, 0.001888, -0.244916, -0.146819, 0.194243, 0.110760, 0.137011, 0.204448, 0.131102, 0.226284, 0.313715, 0.315763, 0.352076, 0.591040, 0.465342, 0.390557, 0.121507, 0.032517, 0.083682, 0.106421, -0.913358, -1.361389, -0.261401, -0.013192, 0.094191, -0.223384, -0.029734, -0.421979, -0.149060, -0.069340, -0.370687, -0.371934, -0.178066, -0.415406, -0.650769, -0.388904, -0.540135, -0.342988, -0.126795, -0.351435, -0.227248, -0.488023, -0.720703, -0.119231, -0.156948, -0.324807, -0.589165, -0.423985, -0.556546, -0.487271, -0.013375, 1.578771, 0.401388, 0.810819, 0.967443, 0.730590, 0.967191, 0.986594, 1.134990, 1.010212, 0.688221, 0.926542, 1.078054, 0.848925, 0.751004, 1.082284, 0.929260, 0.383426, 0.309242, 0.638521, 0.959274, 0.694748, 0.079496, 0.688616, 1.186138, 1.177563, 0.552991, 0.268260, 0.564798, 0.861427, -1.239478, -0.743190, -0.406803, -0.212377, -0.274418, -0.769363, -0.277833, -0.439678, -0.193725, -0.124648, -0.118066, -0.167133, 0.173864, -0.232884, -0.393534, -0.370282, -0.198378, -0.337652, -0.259773, -0.513749, -0.345157, -0.547626, -0.705872, -0.452583, -0.480584, -0.488020, -0.470541, -0.570876, -0.585862, -0.548058, 0.368961, 0.050389, -0.032901, 0.032598, 0.158457, 0.088786, -0.375166, -0.307049, -0.777335, -0.631179, -0.121836, 0.148020, 0.318941, 0.068551, 0.160078, 0.109698, -0.140655, 0.047505, 0.015433, 0.092953, -0.172923, -0.218029, -0.012938, -0.005876, 0.041356, 0.009514, 0.035863, 0.051068, -0.371475, -0.411366, -0.301052, -0.407222, -0.284277, -0.211948, -0.229248, -0.708962, -0.208701, -0.274894, -0.079711, -0.174433, -0.163023, -0.256366, 0.075849, -0.219537, -0.523541, -0.285856, -0.001530, -0.138163, -0.249340, -0.510401, -0.524737, -0.637578, -0.638792, -0.508795, -0.458251, -0.531654, -0.513767, -0.546636, -0.533693, -0.564381, 3.263613, 3.576282, 4.631035, 5.153685, 5.005274, 4.872375, 4.969620, 5.413037, 5.633713, 5.794265, 6.091894, 6.178330, 5.968856, 6.131150, 5.805181, 5.333733, 4.903569, 5.370451, 5.932454, 6.056974, 5.625782, 5.075652, 5.137314, 5.466216, 5.496107, 5.640171, 5.557793, 5.400330, 5.466494, 5.271631, 0.630188, 3.917461, 4.865726, 4.834305, 4.584261, 4.781139, 4.628686, 5.061310, 4.850121, 4.723131, 4.966805, 4.820992, 4.930876, 5.264765, 5.436214, 5.274911, 5.301270, 5.635977, 5.894802, 5.783631, 5.796542, 5.473624, 5.021534, 5.528015, 5.863877, 5.433076, 5.640922, 6.106452, 5.862393, 5.824403, 0.045820, -0.639499, -0.264651, -0.475369, -0.521681, -1.004323, -0.599637, -0.583937, -0.491736, -0.511818, -0.436755, -0.809812, -0.598102, -0.537980, -0.567545, -0.482348, -0.841207, -0.813521, -1.046783, -0.871628, -0.875121, -0.709931, -0.867139, -0.639119, -0.439090, -0.724084, -1.051294, -1.494825, -1.565082, -1.036993, 0.060835, 2.050323, 1.849077, 0.914622, 1.203622, 1.385615, 1.104147, 1.732683, 1.733376, 1.751371, 1.086279, 1.441130, 1.974618, 1.630158, 2.060205, 2.493029, 2.233399, 2.341573, 2.142572, 1.877541, 2.076391, 1.452917, 1.478956, 1.774093, 2.321773, 1.901376, 2.211868, 2.331829, 2.250036, 2.275367, 0.655439, 0.482521, 0.188698, 0.174691, -0.115525, -0.305700, -0.328063, -0.368244, -0.183924, 0.040400, -0.022841, 0.013373, 0.032089, 0.055483, 0.099814, 0.059693, 0.115464, 0.290324, 0.218270, 0.152702, 0.220301, 0.402536, 0.555787, 0.450402, 0.415486, 0.258351, 0.195552, 0.417817, 0.450147, 0.608952, 0.098998, 0.295532, -0.689260, -0.016478, -0.371142, -0.190979, -0.241478, -0.282066, -0.061802, 0.117302, -0.074675, -0.116397, -0.209645, -0.022940, -0.033437, -0.136651, 0.087345, 0.124961, -0.024467, -0.056770, -0.092938, -0.009235, -0.086623, -0.355510, -0.266131, -0.136909, -0.213805, 0.024882, -0.079663, 0.014575, -0.383232, -0.301432, -0.209562, 0.260262, -0.110722, -0.423701, -0.445649, 0.053380, 0.776227, 1.110831, 1.181501, 0.966289, 0.414885, 0.186016, -0.061533, 0.297274, 0.370337, 0.307237, 0.327399, 0.227094, 0.088124, -0.110119, -0.028609, 0.080830, 0.076484, 0.158522, 0.126520, 0.074133, -0.013920, -0.081406, -0.408475, -0.424226, -0.768495, -0.208800, -0.583664, -0.224392, -0.093979, -0.183895, -0.079063, 0.316619, 0.003492, 0.107441, -0.096636, -0.109682, -0.063697, 0.001090, 0.102413, -0.122314, -0.198732, -0.117312, -0.281450, -0.477492, -0.473547, -0.623311, -0.558967, -0.462584, -0.436560, -0.364831, -0.434902, -0.434673, 0.733497, 0.770743, 0.834591, 0.324560, 0.441188, 0.468955, 0.679637, 0.299069, -0.105343, 0.274449, 0.493103, -0.185217, -0.240291, -0.265397, -0.034566, -0.008438, -0.238475, -0.320150, -0.308195, -0.207966, -0.218815, 0.189492, 0.252081, -0.006259, -0.133242, -0.301991, -0.017594, -0.012333, -0.047117, -0.273463, -0.206321, 0.401404, -0.785296, -0.637840, -0.126434, -0.152715, -0.119413, -0.223746, -0.166253, 0.057433, 0.099988, -0.181851, -0.030639, -0.011923, -0.068636, -0.141925, -0.144586, -0.135750, -0.083073, -0.037604, -0.006653, 0.582036, 0.642036, 0.105325, 0.079181, -0.178932, 0.113029, -0.149373, 0.016786, -0.187831, 0.056215, 0.230252, 0.356529, 0.500137, 0.529104, 0.468678, 0.191145, -0.001602, 0.302371, 0.292035, 0.407347, 0.571157, 0.475214, 0.337597, 0.368171, 0.473275, 0.431573, 0.355463, 0.373677, 0.322717, 0.213935, 0.273218, 0.241890, 0.302292, 0.384153, 0.339305, 0.433333, 0.209065, 0.297779, 0.311287, -0.802644, -0.089172, -0.720957, -0.643279, -0.156647, -0.416102, -0.156969, -0.245054, -0.339257, -0.068999, 0.168345, -0.258271, -0.040408, -0.084970, -0.217030, -0.293559, -0.177062, -0.218036, -0.133584, -0.113196, -0.154547, -0.006402, -0.090335, -0.208867, -0.240433, -0.355258, -0.217343, -0.422356, -0.271961, -0.440166, -1.107567, -0.348794, -0.248174, -0.947411, -0.557455, -0.323138, -0.079001, -0.285262, -0.612961, -0.396973, -0.125772, -0.129561, -0.012013, 0.078192, -0.054888, 0.013879, -0.069803, -0.051438, 0.192591, 0.229536, 0.119533, -0.052382, -0.255846, -0.086554, 0.198287, 0.277420, 0.232797, 0.082616, 0.081003, -0.043628, 1.522950, -0.441326, -0.008005, 0.098433, 0.184820, -0.140829, -0.038938, -0.150880, -0.097976, -0.138801, -0.181871, 0.212390, 0.007965, 0.215502, 0.009503, 0.679586, 0.920903, 0.512812, 0.847391, 1.531403, 1.652696, 1.361610, 1.624834, 1.482682, 1.960330, 1.762485, 1.440933, 1.586489, 1.547669, 1.109012, 0.794742, -0.168634, 0.285247, 0.456733, 0.396991, 0.482231, 0.332297, 0.076064, -0.103229, 0.334708, 0.239628, 0.748966, 0.810774, 0.443373, 0.846734, 0.916975, 0.570413, 0.488124, 0.633109, 1.014031, 1.212687, 1.435912, 1.015769, 1.169256, 1.534351, 1.249326, 0.918773, 1.107321, 1.129875, 0.785855, 0.813383, -0.532315, 0.111991, 0.234527, -0.030896, 0.277314, 0.297859, 0.040569, 0.025114, 0.006356, 0.218797, 0.514188, 0.190865, 0.160685, 0.030256, 0.465342, 0.991882, 0.586512, 1.044472, 1.347931, 1.728751, 1.279156, 1.575880, 1.605291, 2.248828, 1.928269, 1.426988, 1.855790, 1.902964, 1.336270, -0.151233, -0.424972, -0.098899, -0.049249, -0.197418, -0.023505, 0.011177, 0.177194, 0.265192, 0.484001, 0.436705, 0.526977, 0.580230, 0.649825, 0.421570, 0.261689, 0.349833, 0.336458, 0.426553, 0.681621, 0.547698, 0.252995, 0.161671, -0.011558, 0.060382, 0.105793, 0.004033, -0.157655, -0.268102, -0.168685, 0.468453, 0.468041, 0.834485, 0.786103, 0.904997, 0.704641, 0.779809, 0.940041, 1.232370, 0.910216, 0.638127, 1.337196, 1.071552, 1.552245, 1.400830, 2.292977, 2.299536, 1.335505, 1.622542, 2.583504, 1.825658, 1.064862, 1.119071, 0.985108, 0.514276, 0.721304, 0.515146, 0.573171, 0.374668, 0.265744, -0.321572, 0.202540, 0.777845, 1.341674, 1.493915, 1.249349, 1.256337, 1.411815, 1.055304, 1.308006, 0.986675, 0.717275, 0.650679, 0.991560, 1.428868, 2.201227, 1.474407, 1.399687, 1.767589, 1.886096, 1.030455, 1.017073, 1.356941, 1.341865, 0.759767, 0.682910, 1.313358, 1.369962, 1.142566, 1.111604, 0.617962, 0.922404, 1.061550, 1.230306, 1.096716, 0.470110, 0.342155, 0.698152, 1.142971, 1.078236, 0.319208, 0.831561, 0.824772, 0.997611, 0.649571, 1.799065, 2.216345, 1.496002, 1.262020, 2.413894, 1.686247, 0.944449, 0.834530, 0.567262, 0.491685, 0.832459, 0.484180, 0.632287, 0.338496, 0.237378, -0.762017, -0.628739, -0.858661, -0.919283, -0.764219, -0.529746, -0.442241, -0.507697, -0.584487, -0.509417, -0.460177, -0.634456, -0.713305, -0.675347, -0.721802, -0.718126, -0.903550, -1.023484, -0.859453, -0.771333, -0.883054, -1.120695, -1.100580, -1.015972, -0.922033, -0.985129, -0.964189, -0.973988, -0.894955, -0.947938, -0.119221, -0.058318, 0.095207, -0.033993, -0.078281, -0.111473, -0.017964, -0.129262, -0.204230, -0.303679, -0.126098, -0.163596, -0.287025, 0.013414, -0.169821, -0.131021, -0.142244, -0.399751, -0.183270, -0.123465, -0.140676, -0.524011, -0.600018, -0.316296, -0.227794, -0.363276, -0.413273, -0.366539, -0.356515, -0.516661, -0.513505, -0.807260, -0.769884, -0.643698, -0.594602, -0.457124, -0.746396, -0.861485, -0.786569, -0.845567, -0.825432, -0.666380, -0.678811, -0.646077, -0.478121, -0.485766, -0.870158, -1.002352, -0.814441, -0.972001, -1.065112, -0.915531, -0.706759, -0.816136, -0.903718, -0.787686, -0.614388, -0.757075, -0.844717, -0.726446, -0.294436, 0.039980, 0.103309, 0.071248, -0.172267, -0.079658, 0.020181, -0.172378, -0.301369, -0.277003, 0.007038, -0.216925, -0.191643, 0.093093, -0.259009, -0.154561, -0.171361, -0.485766, -0.327959, -0.156430, -0.216055, -0.478033, -0.602333, -0.363691, -0.242492, -0.437831, -0.491596, -0.443097, -0.438010, -0.539939, 0.447880, 0.161887, -0.477165, -0.040691, -0.263296, -0.112877, 0.098574, 0.245695, 0.362458, 0.306952, 0.045315, 0.091995, 0.086986, -0.015115, 0.036127, -0.131447, -0.243509, -0.249815, -0.247227, -0.209425, -0.262738, -0.254670, -0.178179, -0.243916, -0.341793, -0.342590, -0.345627, -0.387247, -0.464266, -0.427886, -0.679264, -0.395149, -0.047044, -0.110324, -0.302091, 0.093646, 0.139261, 0.139908, 0.238312, 0.293131, -0.153317, 0.317490, 0.317583, -0.131768, -0.211781, -0.148493, -0.056770, -0.178686, -0.204328, -0.162572, -0.126994, -0.212720, -0.073910, -0.124500, -0.324821, -0.037565, -0.131851, -0.024541, -0.109415, 0.006725, 1.154197, 0.530424, 0.054840, 0.116105, 0.028488, -0.077218, 0.322115, 0.720940, 0.820774, 0.781224, 0.449000, 0.641317, 0.543925, 0.188472, 0.370779, 0.439986, 0.388983, 0.441990, 0.249859, 0.569276, 0.747571, 0.622796, 0.412426, 0.423580, 0.174973, 0.478060, 0.451222, 0.738574, 0.750762, 0.649478, 0.425914, -0.093688, 0.130150, -0.281125, -0.260229, 0.061973, 0.242248, 0.373795, 0.364345, 0.574904, 0.073850, 0.501541, 0.659074, 0.086196, -0.058937, -0.130218, 0.274948, 0.059772, -0.200405, -0.051299, 0.062892, 0.054149, 0.268513, 0.014338, -0.124854, 0.153121, 0.001300, 0.339501, 0.221699, 0.391366, 0.481278, -0.308369, -0.749984, -0.526233, -0.681540, -0.757068, -0.696498, -0.453050, -0.414369, -0.541764, -0.392189, -0.223258, -0.178359, -0.238080, -0.229266, -0.538587, -0.497878, -0.307252, -0.375983, -0.586190, -0.519863, -0.379597, -0.175998, -0.340745, -0.595510, -0.420580, -0.478407, -0.463196, -0.488116, -0.431337, -0.672832, 0.265426, 0.310207, 0.266501, -0.161738, 0.048233, -0.010747, 0.021075, -0.050762, -0.158779, -0.075129, -0.100860, -0.209668, -0.219114, -0.109955, 0.016601, 0.235319, 0.113251, -0.025251, -0.088836, -0.004587, 0.157784, 0.527409, 0.245534, 0.051160, 0.258387, 0.033637, 0.007339, 0.076455, 0.210606, 0.537434, 0.536380, -0.024144, -0.354909, -0.669918, -0.538893, -0.303551, -0.126480, -0.101085, -0.047613, -0.000349, 0.023558, 0.139420, 0.227700, 0.124742, 0.040771, 0.315172, 0.325666, 0.111966, 0.385165, 0.345593, 0.335761, 0.741077, 0.584057, 0.472566, 0.569482, 0.590494, 0.433104, 0.508197, 0.618355, -0.230963, 0.665453, 0.320875, 0.386990, 0.177104, 0.136699, -0.026062, 0.119639, 0.048685, -0.015959, 0.025038, 0.025760, -0.060252, 0.018477, -0.107808, 0.075703, 0.468532, 0.390752, 0.145256, 0.069441, 0.204268, 0.631090, 1.116666, 0.683511, 0.357397, 0.602621, 0.370063, 0.301055, 0.445382, 0.637187, -1.127492, -0.227640, -0.402760, -0.787066, -0.302124, 0.174637, 0.155111, -0.195743, -0.399133, -0.432251, -0.399243, -0.554003, -0.561609, -0.428634, -0.373095, -0.211364, -0.392944, -0.724196, -0.748480, -0.532176, -0.712172, -1.168128, -1.104804, -0.768778, -0.667496, -0.807589, -0.825853, -0.703806, -0.259216, -0.632904, -0.288039, -0.343126, -0.399189, -0.357782, -0.315700, -0.015074, -0.165590, -0.363989, -0.191741, -0.322665, -0.333060, -0.174741, -0.413559, -0.321881, -0.306689, -0.220212, -0.174114, -0.508220, -0.256363, -0.094698, -0.270012, -0.499868, -0.580682, -0.321335, -0.294879, -0.501727, -0.460490, -0.459993, -0.376146, -0.652835, -0.172591, 0.558221, 0.620825, 0.487346, 0.482905, 0.658774, 0.621112, 0.618049, 0.461830, 0.366111, 0.440669, 0.482963, 0.355830, 0.435325, 0.453792, 0.449335, 0.401679, 0.385587, 0.508721, 0.675035, 0.682548, 0.442508, 0.549484, 0.533723, 0.467720, 0.388329, 0.569015, 0.725864, 0.383600, 0.371866, -0.824395, 0.173334, -0.327014, -0.460109, -0.375747, -0.002102, -0.105786, -0.329749, -0.002261, -0.219632, -0.252663, -0.188323, -0.418174, -0.246136, -0.308381, -0.192027, -0.247502, -0.577680, -0.166546, -0.027071, -0.221102, -0.464502, -0.638239, -0.480085, -0.395329, -0.558305, -0.506926, -0.397620, -0.474988, -0.653120, 0.186833, -0.183243, 0.070976, -0.107748, -0.187166, -0.489524, -0.704741, -0.555572, -0.311976, -0.267058, -0.134872, -0.015091, -0.024487, -0.031953, -0.140453, -0.222465, -0.010408, 0.208882, 0.145523, 0.019197, 0.138758, 0.307889, 0.439037, 0.332942, 0.209231, 0.214486, 0.160774, 0.178348, 0.161837, 0.208847, -0.344442, -0.507707, -0.344320, -0.030458, -0.264976, -0.147913, -0.120521, 0.013801, -0.166434, -0.179107, -0.149768, -0.045271, -0.121816, -0.080517, -0.107145, -0.178431, -0.132185, 0.018576, -0.040973, -0.216368, -0.085056, -0.118469, -0.147518, -0.189284, -0.247926, -0.108753, -0.235229, -0.170378, -0.201990, -0.268278, -0.146525, -0.073608, -0.199319, -0.230775, -0.173820, -0.399817, -0.511156, -0.578980, -0.622584, -0.743227, -0.504844, -0.348473, -0.246696, -0.716167, -0.776687, -0.547293, -0.424493, -0.647696, -0.744641, -0.557279, -0.721368, -0.557839, -0.372493, -0.325102, -0.387552, -0.394167, -0.411274, -0.470672, -0.361211, -0.329538, -0.602134, -0.132540, -0.418398, -0.451695, -0.407298, -0.048231, -0.067830, -0.120186, -0.298497, -0.207144, -0.227756, -0.192733, -0.372488, -0.093870, -0.100278, -0.275842, -0.384642, -0.107476, -0.062789, -0.323989, -0.163367, -0.513032, -0.425600, -0.427832, -0.358240, -0.326722, -0.384533, -0.356969, -0.441686, -0.466105, 1.159397, 1.482134, 1.104533, 1.144919, 1.654931, 2.075372, 2.163607, 2.159632, 1.407451, 0.824345, 0.919487, 0.508281, 0.723756, 0.796812, 0.958300, 1.130504, 1.079079, 1.082118, 0.674817, 0.547164, 0.571172, 0.825050, 1.017152, 0.880169, 0.469362, 0.265440, 0.936301, 1.528961, 1.240400, 0.258122, -0.491873, 1.786708, -0.365695, 0.199353, 0.950382, 1.257281, 1.588552, 2.713818, 2.176566, 0.323607, 0.007148, 0.369575, 0.426146, 0.936847, 1.024218, 1.055956, 0.685912, 0.396250, 0.085037, 0.170463, 0.087707, 0.315954, 0.106877, 0.218707, -0.023558, -0.261986, 0.161455, 0.373048, 0.261228, -0.240425, -0.031824, -0.338036, 0.124228, -0.128931, -0.239157, -0.295634, 0.048806, 0.416533, 0.454608, 0.518002, 0.027136, 0.163481, 0.251504, 0.053941, 0.335410, 0.596199, 0.580127, 0.386460, 0.405175, 0.457344, 0.285050, 0.282694, 0.163020, 0.270332, 0.142042, -0.258616, -0.030705, 0.462517, 0.420209, 0.162126, -0.659464, 0.643597, -0.628128, 0.784845, 1.784918, 1.966920, 1.870987, 3.166404, 2.382494, 0.255344, 0.310978, 0.660706, 0.437577, 0.803196, 0.627627, 0.687115, 0.774635, 0.383509, 0.189575, 0.156505, 0.314148, 0.060438, -0.249102, 0.060431, -0.096422, -0.406507, 0.034206, 0.196527, 0.077956, -0.431315, -2.331252, -1.192490, -0.102486, 0.787147, 1.304047, 1.381622, 1.347446, 1.046731, 0.704336, 0.478762, 0.159135, 0.377036, 0.460643, 0.722612, 0.984854, 1.101271, 1.425288, 1.118312, 0.787856, 0.439620, 0.887662, 0.776176, 0.401842, 0.458075, 0.479761, 0.201526, 0.436704, 0.702178, 0.373191, 0.702515, -0.794686, -0.335340, -0.033711, -0.172277, -0.247537, -0.239015, -0.348152, -0.396591, -0.352063, -0.392559, -0.081267, 0.063802, -0.037431, -0.118852, -0.090172, -0.440720, -0.373442, -0.167744, -0.281144, -0.371791, 0.470693, -0.074704, -0.536400, -0.418885, -0.046782, -0.405930, -0.513612, -0.372790, -0.555968, -0.451138, -0.174757, -0.528538, -0.487103, -0.217049, -0.298042, -0.655697, -0.325762, -0.220248, 0.211645, 0.062766, -0.374747, -0.350069, -0.321249, -0.390334, -0.381655, 0.105003, 0.128852, 0.114480, 0.056587, -0.210431, 0.169324, 0.126802, -0.108550, -0.195384, -0.016831, -0.136661, -0.210521, -0.101552, 0.007188, -0.311399, -0.515421, 0.022591, -0.131951, -0.053855, -0.172737, 0.047634, -0.375511, -0.287430, -0.327543, -0.358283, -0.169231, -0.009754, -0.059622, -0.285196, 0.062272, -0.279681, -0.352218, 0.013564, -0.278803, -0.414531, 0.125989, 0.049172, -0.711365, -0.548781, -0.360886, -0.505401, -0.502035, -0.420844, -0.553943, -0.551395, 3.451391, 3.820978, 4.816291, 5.347534, 4.849709, 5.006228, 5.139127, 5.601122, 5.634669, 6.074879, 6.242809, 6.010721, 6.076398, 6.212915, 5.840426, 5.198357, 4.991253, 5.427261, 5.787693, 6.048208, 5.627197, 5.315385, 5.216614, 5.334770, 5.255203, 5.422811, 5.518939, 5.522549, 5.765001, 5.450472, -0.072166, 3.943889, 5.009687, 4.084819, 4.370114, 3.623295, 3.543396, 3.899390, 4.090218, 5.332092, 5.512327, 5.395321, 6.874728, 5.539775, 4.814162, 5.136738, 4.903348, 5.449799, 5.492641, 5.208989, 5.830717, 6.524841, 5.965222, 6.775668, 6.802362, 6.042156, 6.876073, 6.535851, 6.625149, 6.671756, -1.131969, -4.358902, -3.731606, -1.956535, -3.277599, -3.024497, -4.155395, -3.572725, -4.022905, -3.741107, -2.994979, -4.659313, -5.227172, -2.605498, -3.227516, -4.512344, -4.848868, -4.622924, -5.231193, -4.134708, -4.956503, -5.222092, -4.104934, -4.862618, -4.760288, -5.303665, -6.125093, -6.196517, -6.035272, -6.046359, 0.325963, 4.240018, 5.621937, 3.138039, 3.319407, 2.585354, 1.424107, 1.636229, 2.000769, 2.797171, 3.267827, 3.612954, 4.499428, 2.777206, 3.009655, 2.662838, 3.311096, 3.736614, 4.361479, 3.124089, 4.792629, 5.017882, 4.676394, 5.660293, 5.680531, 4.989480, 5.744223, 5.519407, 5.100046, 5.118147, 0.624614, 0.502426, 0.296642, 0.426744, 0.104245, -0.284638, -0.336235, -0.197966, 0.192261, 0.380258, 0.399083, 0.364979, 0.267662, 0.204444, 0.089526, 0.162751, 0.290786, 0.418871, 0.314497, 0.440665, 0.577456, 0.676281, 0.664391, 0.613744, 0.651164, 0.553447, 0.483898, 0.611998, 0.692153, 0.912728, 0.146291, -0.104193, -0.360131, 0.199417, -0.028025, -0.320518, -0.288280, -0.069155, -0.128563, -0.131048, -0.229779, -0.237785, 0.056705, -0.067201, -0.148997, -0.262399, -0.178797, -0.168283, -0.365372, -0.222734, -0.038183, -0.059401, -0.372098, -0.342101, -0.355742, -0.295823, -0.328369, -0.221310, -0.254603, -0.247939, -0.126477, -0.455731, -0.907951, -0.831526, -0.655501, -0.665534, -0.502251, -0.416008, -0.298086, 0.060580, 0.220195, -0.167265, -0.667382, -0.758409, -0.275511, 0.162532, 0.110817, -0.177642, -0.351691, -0.137614, 0.203239, 0.219218, -0.111349, -0.354685, -0.117339, -0.135122, -0.213119, -0.426464, -0.289273, -0.078707, -0.336779, -0.635712, -0.035274, 0.272541, 0.056540, -0.205716, -0.181056, -0.094782, -0.105539, -0.327640, -0.357058, -0.269511, -0.013680, -0.189107, -0.372368, -0.365736, -0.317746, -0.330461, -0.549105, -0.279690, -0.374502, -0.569887, -0.536338, -0.389179, -0.431968, -0.380730, -0.531331, -0.409309, -0.527633, -0.579566};
static RBF_CONST rbf_float RBF_WIDTHS[] = {7.926742, 8.756255, 37.216618, 5.793707, 5.353994, 27.788858, 5.353994, 5.587618, 21.938118, 7.634472, 7.603057, 7.083918, 5.744668, 5.793707, 34.738747, 7.221498, 8.654243, 17.282103, 40.465538, 7.683982, 5.758614, 21.718042, 5.991484, 5.587618, 42.076691, 9.508658, 5.134273, 5.972579, 6.670103, 97.227455, 5.810000, 5.972579, 5.134273, 6.602191, 6.742338, 6.547368, 7.084291, 7.634472, 31.779125, 17.282103, 9.034487, 37.216618, 7.689144, 7.304529, 7.084291, 5.825127, 6.438565, 5.664799, 6.316514, 21.718042, 6.469939, 30.706554, 8.610502, 20.887379, 12.527686, 7.304529, 8.549578, 21.484280, 5.991484, 23.205868, 19.873857, 5.892203, 7.083918, 7.814724, 5.828110, 8.610502, 28.723595, 6.469939, 24.763563, 6.611989, 6.003535, 6.003964, 30.706554, 5.141970, 6.043415, 5.871365, 6.602191, 21.938118, 22.928387, 7.144199, 5.892203, 6.752862, 6.670103, 9.166041, 5.874601, 5.828110, 24.869253, 6.740301, 6.003535, 13.555014, 18.085606, 5.664799, 8.409125, 7.144199, 6.400959, 5.141970, 14.480142, 5.825127, 37.858143, 5.945129};
static RBF_CONST rbf_float RBF_WEIGHTS[] = {2.145386, -2.342892, 4.205303, 3.299022, -8.188800, 3.098900, -2.632432, -1.832913, -0.511763, -0.723551, -1.596278, 5.190960, -3.516731, 1.584173, 7.843492, 2.614090, 0.426944, 9.165042, -5.962093, -4.921863, 0.269965, -0.630041, -6.663407, -0.270282, 6.480061, -8.412464, 7.819100, -1.473381, 3.625074, 0.892052, -2.233103, -1.453921, 4.059176, -3.684609, -1.906473, -3.408493, 13.956173, -1.110129, 2.962075, -2.562526, -11.688877, -0.161007, -2.029299, -0.283287, -0.567340, 6.142886, -2.369655, -2.072203, 0.965857, -1.287285, -4.604696, 0.767508, -5.809295, 0.705831, -7.448189, -1.156028, 0.716966, 15.960977, -1.968133, 2.899521, -4.583756, -0.627360, -0.285770, 2.257783, 3.115518, 3.332117, 2.026712, 1.476338, -0.005959, -1.015168, -2.221967, -3.575638, 1.027527, -0.451926, -2.487305, 1.687767, -2.429789, 4.920530, -1.935591, -2.072019, 1.056208, 6.444492, -1.803711, -4.107051, -0.555020, 1.446513, -0.536510, 0.790748, -0.089816, -1.471015, 12.532963, 2.571754, -0.873027, -9.092622, -5.758017, 1.193863, 2.719102, 7.590055, 1.382206, -1.375998, -7.115875, -3.406569, -1.347964, -2.185900, -0.621008, -0.535340, 2.910167, 1.962649, 1.891845, 15.315455, -2.501157, -3.087850, 0.489724, -4.560765, 0.127710, -0.030747, -7.151766, 0.681874, -2.136697, 0.990414, 2.588006, 1.187353, -6.139392, -5.885886, 8.625868, -6.237971, -0.755901, 2.361781, -3.818388, 0.141211, 2.079262, 6.045112, -6.583955, 5.671724, -0.894928, -0.596910, 2.591923, -7.927642, 3.228846, 1.998025, 2.207743, -0.239849, -0.326156, 0.644773, -0.670960, -4.943990, -3.155376, -3.506460, 8.263751, 3.545500, 0.911454, 1.456128, 0.416470, -1.280356, -3.567244, 2.598661, -3.371816, -2.926708, 0.711174, 4.770507, 1.036423, 4.318055, 4.140967, 0.508669, -0.960177, -5.547422, 0.149925, -2.782664, -4.413924, -6.937723, -1.542563, -4.015262, 8.067065, 3.660141, -2.715609, -2.524130, 2.644290, 7.128518, 1.215187, -0.745242, -1.474089, -8.694682, -3.602514, 1.324875, 6.326214, 15.728601, 8.323938, 0.604278, -1.011769, -11.363670, -0.505951, -5.512992, 0.484988, -4.265486, 2.434587, -2.905239, 1.441776, -7.646374, -2.873276, 1.291639, 3.058394, 2.412450, 1.842623, 4.764673, 1.019895, 0.165762, -0.079567, 0.596885, 1.135039, 0.991869, -0.490485, -2.452416, -0.310094, -0.481687, -0.739900, 0.715996, -1.258494, 12.514352, 3.651315, 1.790290, 1.423445, -2.441178, -1.151554, -4.928250, -2.963082, -4.108110, -2.961152, 0.485494, -3.686873, -2.969517, 2.826016, 0.316599, 4.631606, 0.762942, 0.635858, -0.356437, 6.518754, -4.494774, -1.135946, -3.156755, 1.251437, 1.301576, -2.299487, 2.951118, 1.023524, -1.987949, 0.971890, -1.320541, -1.031178, -1.759848, -1.400655, 2.428789, 2.822868, 10.302883, 0.780006, 2.439461, -5.921721, -10.148979, 1.837564, -4.122625, 3.068751, -1.271701, 3.755526, -3.597361, -1.213086, -0.757584, -5.864756, 5.790147, 0.352904, 0.005776, 19.950247, -2.925407, 0.017852, -3.523276, -1.465731, -10.318823, 2.485255, -0.212601, -5.035388, -0.665071, -1.151659, 1.280478, 13.833490, -2.421008, -1.583993, -8.380271, 4.175507, -2.141280, -4.289205, -1.253798, -1.902220, 0.499622, 1.217153, 2.232798, -2.514371, 3.754086, -2.518486, 3.081777, 1.700130, -0.150902, -3.304136, 16.508615, -2.201970, 4.218292, -0.508474, -0.945095, 0.696293, -8.313801, -7.776712, 4.453478, 0.691171, -3.629320, 15.644317, -1.603556, -0.070183, -14.961615, -6.826766, -8.553682, -2.715798, -0.454791, 0.867608, 2.765078, 9.460772, 6.734660, -1.576720, -0.366124, 1.368559, 0.884457, -4.567959, -5.703218, -2.452789, -0.019842, 3.779730, -0.940572, 2.006486, 7.525651, 2.203970, 1.334849, -0.524363, -1.683617, -2.027888, -3.297339, -1.442270, 0.020878, 0.370334, -1.174466, 3.116638, 3.147711, -13.814217, 3.202390, -1.032519, 4.143036, 11.336174, 5.037202, 6.806073, -6.677621, 3.386899, -2.514648, -6.216782, -3.962011, -4.202952, -8.778194, 13.174311, -0.191844, 7.655795, 1.145978, -3.423141, -0.047186, 2.020835, -6.176178, 0.880493, -1.889849, -1.268315, -0.005775, -1.185410, -6.443631, 3.342783, 3.538077, 2.887983, 2.512499, -5.876029, -0.904773, 3.829907, -0.395211, 5.640488, -1.414587, -1.560997, 2.139220, -8.468671, 6.385215, 0.475369, 0.181972, -2.362115, -1.071553, -0.876869, 1.057141, -3.929454, -5.621222, 0.112965, 5.734688, -6.623073, 4.182604, -3.043339, -0.638540, 1.729549, 4.887532, 4.474335, -1.483883, 0.505531, -0.571570, -0.300062, -2.161601, 4.883723, -3.379666, 5.254667, -1.142841, -0.232754, -4.241800, 2.473899, -0.941637, 6.735479, -4.661552, 2.918788, -14.605507, 18.806882, -13.099644, 1.291775, 1.948548, 4.716366, -4.637681, 0.043155, 0.920823, -1.349850, -2.508796, 2.077177, 0.527452, -1.294215, 2.615874, -0.576323, 3.715575, -0.400308, -2.201432, -2.694912, 2.099773, 3.158022, -4.440367, -0.485928, -3.189395, -6.821129, 13.536170, -0.380605, -1.558557, -2.188614, 0.456204, -5.340628, 7.316304, -5.767698, 1.083283, -0.697854, 2.051206, 0.424801, 3.132781, -1.486098, -0.647460, -6.042720, -0.717371, -2.671869, 11.388820, -1.646743, 3.147208, 1.679987, 1.117226, 2.435376, -1.195417, -0.896566, 0.111439, -2.342660, -1.428429, -0.370643, -0.573940, 0.786721, -2.275971, 2.565539, -1.829864, -3.738741, 4.121557, 1.529555, -1.110613, 6.356295, -3.602753, -0.287442, -2.632377, 3.226951, -6.451608, -4.717134, 2.053375, 4.585064, -3.362548, -3.075467, 11.279372, -1.576261, 1.431295, -0.553014, -2.716087, 1.893422, -4.867317, -0.286730, -2.229908, -4.573051, -3.137966, -0.907692, 2.907973, -6.295021, 5.436152, 1.163894, 11.090882, -3.026946, 1.130308, -1.579732, -2.380530, -8.239110, 18.284016, -3.671716, -4.076110, -0.087507, -1.940869, 1.088649, 4.217111, 1.556546, -2.849298, -1.389378, 3.310961, -1.231583, -3.081787, -0.444807, 2.153839, 1.614894, 2.792732, 1.104963, -3.548044, -1.466440, 0.619840, -0.865554, -2.838642, 3.132407, 1.901996, 3.120745, 0.195320, 0.432649, -3.019816, -0.699070, -0.541151, -1.387216, 4.199462, -0.347469, 22.277167, -14.891380, 4.106147, 1.224706, -4.876258, -1.651665, -1.240918, -5.402612, -2.000122, -1.415578, 2.331496, 0.477061, -2.333901, 6.221162, -0.667244, 0.867741, -1.181686, 1.563510, -2.349415, -1.932108, -1.598284, -1.894110, 0.406235, -4.644448, 1.951877, 3.591883, 7.754621, 0.961350, 0.445357, -0.188972, -2.701878, -3.180317, -2.575576, -2.833836, -1.089461, 5.317514, 3.337571, 4.916944, 2.854931, -8.118329, 2.026274, -1.517518, -1.132838, -8.034778, 4.364320, 5.391096, 3.513713, -0.535075, -1.810752, 0.313964, -1.059431, 5.547982, -2.508973, 1.952726, -7.355846, -0.122473, -3.165392, -4.404058, -1.534938, -1.897218, 0.923555, 2.401377, 10.556151, -0.591501, -5.772902, -0.602565, 0.349699, -1.005796, 1.474072, 1.541733, -1.869949, 1.824666, -8.886912, 8.808544, -5.770655, -6.330321, 2.498506, 6.326313, 4.490585, -1.472168, -1.268790, 3.100593, -2.302226, -6.297817, -7.765448, -10.077522, 6.428210, 2.181750, 11.070035, 4.254864, 4.791269, 0.010997, -5.818073, -0.413925, 2.664856, 2.967929, -0.760278, -1.268675, -4.567591, 1.427962, 4.591870, -0.067244, 0.772685, -4.530019, -0.851973, 0.720308, -1.877715, 1.022744, -0.189580, 0.864426, 1.853356, 1.755704, 1.334198, -2.803969, 0.771646, -1.500084, -1.863287, 0.371660, -4.229631, 0.298278, 1.338079, -4.696145, -3.455485, 0.063929, 1.701812, -0.784787, 4.278540, 10.060354, -5.000383, -2.783223, -3.032293, 1.406089, -3.439343, 11.811020, -0.196444, -0.429632, 0.739277, -1.389028, 2.662193, -2.395913, -2.911674, -3.896751, -1.551709, 0.044143, 0.427002, 1.011258, -6.901766, -9.899231, 2.871325, 1.713034, 14.562343, 2.432596, -1.124871, 5.191650, -9.337481, -4.963331, -5.262153, -4.513005, 6.741550, 3.262718, -3.272906, 4.193300, 6.155101, 4.943504, -3.232472, -3.167027, 3.928344, 3.709955, 1.026942, 5.374474, -3.729968, 0.807086, -3.147985, -1.281247, -5.995651, -1.289918, 3.909252, -8.541231, 8.009655, -3.998917, -13.174511, 24.119947, -2.578731, 2.435934, 2.116195, 0.189112, -6.738645, -2.731861, 0.756458, -3.612810, -3.361512, -0.737808, 6.093015, 0.700843, 14.272139, -5.402945, 2.661031, -8.385554, 4.258048, -1.934779, -4.588625, 1.048118, 3.584385, -0.747047, -5.400912, 0.090212, -8.289260, 0.619444, -2.431655, 10.066474, 2.590370, 0.514981, -1.905407, -0.458024, 2.229985, -1.849731, 0.697616, -0.350818, 0.281802, 1.588704, 4.680128, -1.893356, -3.268556, -2.128362, 0.478541, -4.417624, -6.633849, -2.854751, 10.278410, -1.518254, 5.605447, 1.563880, -1.214736, 7.623982, -1.617765, -2.527329, -4.489533, -2.961151, 0.787035, -3.659829, 7.251207, -6.757608, -0.104130, 10.076470, 1.999520, -6.018091, -2.533601, 1.488306, 0.492716, 1.803360, -1.719434, 0.847940, 0.768232, -1.876542, -0.005270, -5.442458, -2.207838, -4.104442, 2.989966, 6.504455, 2.562730, 4.081882, -2.296998, -0.142944, 2.655664, -4.462347, -3.957696, -2.743334, 1.993001, 2.560861, 3.441769, 0.197539, -1.314358, -0.500061, -1.705974, 3.176256, -0.999096, -0.972307, -2.816350, -4.062831, 3.446378, -1.515734, -0.191615, 1.369907, 4.833760, -1.089893, -1.966824, 0.469813, -1.756940, 3.017344, 7.205684, -9.459254, -0.798659, 0.502344, -7.401480, 1.151008, 10.202526, -3.384085, -1.784792, 3.289518, -5.226669, -0.378390, -5.273764, -3.491689, 0.549780, 2.286632, 6.810831, 10.088815, -3.745234, 3.686268, 2.416072, -1.685523, -0.137652, -7.186481, -7.382777, 6.149764, 1.069555, -1.949879, 1.661583, 2.240303, 1.201162, 4.546636, -0.546198, -2.375285, -1.556200, -7.781002, 2.616264, -3.557652, 3.684629, -0.420743, 9.710287, -0.754594, -3.735184, -3.531757, 4.278963, -1.062846, -6.232084, 11.024128, -3.917690, -1.216376, 2.581259, 1.754460, 0.000150, -3.932513, 0.129453, 7.418395, 1.980490, 23.805630, -5.590866, -11.183888, 2.581087, -7.645239, 0.618584, -1.341451, -9.088837, -3.597073, 2.383843, 2.078959, -1.213570, 2.992937, -2.807212, 0.118329, -4.596981, 1.918888, 1.949536, -0.829037, -2.136671, 3.181627, -0.521620, 1.785018, -2.805465, -3.170491, -2.546439, 3.310519, 2.786259, 3.281080, 1.618259, -0.056089, -1.713489, 1.640041, -4.091337, -0.847923, 4.175577, 2.287732, 1.886363, 6.658908, -0.767679, -3.234300, -5.897212, 0.536821, -5.081618, -0.718155, 1.126095, -2.894995, 15.581790, -3.179862, 1.898300, 2.182213, -9.267944, 2.086059, -0.022222, -6.054152, -0.311822, -3.299218, 3.273718, -13.825645, 0.832522, 1.898986, 17.761888, -8.678865, 4.829444, 0.135682, -1.719658, -0.763345, 4.133036, -4.053340, -0.919795, 4.109297, -3.266852, -2.251480, -6.394797, 3.252830, -6.872431, 0.252335, 5.787388, 1.021847, 2.305362, 1.307248, 0.823289, 0.618666, -1.126975, -2.654184, 8.773085, -1.996688, 0.414876, 0.975326, -2.475462, 6.840821, 3.767431, -8.224186, -5.046322, 1.085545, -4.663356, -2.410563, -0.561972, -0.250300, -0.527517, 5.922397, 0.996711, -3.063337, -2.987695, 6.845772, -0.221670, -0.065939, -0.655742, 3.470504, -1.587304, 2.130701, 0.066269, -0.934471, 2.247795, -0.639478, -4.489259, 1.427608, -0.888632, 1.012452, -0.974892, -2.150906, 1.102403, -0.280536, -1.599135, -4.707187, -1.351543, 5.571488, 6.405866, 2.084303, -5.326850, 3.331660, -0.271040, 0.258550, -1.290384, -0.078271, -3.411146, -2.331712, -3.544109, 0.084053, 4.048044, 0.621758, 2.678532, 0.230765, -0.540217, -4.682293, -0.118444, 1.225648, -3.858916, 4.070087, 2.516285, 1.230848, 3.121254, -0.801185, -2.465080, 5.944014, 4.641223, 1.396255, -7.407924, -0.440308, -6.079152, -3.962784, -1.277132, -5.286534, -0.965835, 0.950876, 12.800719, -0.058480, 1.235896, -0.844833, 9.267179, -2.700884, -2.498820, 0.783844, -2.572867, -5.124494, -2.225312, 1.305210, 3.667801, -3.994918, 3.941524, 2.672543, -2.046435, 8.170503, 0.073422, 3.737581, 1.173340, -5.934238, -5.016267, 1.741532, -4.424293, -1.502291, -3.381183, 1.400199, 9.435546, 0.711933, 0.297444, 2.423930, 0.108899, 2.577612, -4.058569, -2.547412, -5.402657, 8.467513, 2.502938, 5.858954, -5.377291, -3.886494, 5.871929, -2.393399, -2.214306, 0.496660, -2.746368, -3.287166, -3.147847, 0.314622, 2.412367, -5.088834, 2.148803, -2.760517, -4.144682, 1.610453, 2.196258, 1.714151, 5.204572, 2.011706, -5.819429, -7.500469, -1.919175, -6.926281, 17.199004, -3.417689, -2.343664, 3.757158, -2.029552, 0.866353, 4.373960, 4.861799, -7.144648, -2.416579, 0.205286, 3.959665, -0.028456, 0.273990, -3.280817, -4.935777, -2.610844, -0.575703, 1.757456, 4.483994, 3.160796, 0.571433, -1.684659, -2.800754, 2.505889, -2.485751, 1.288438, -6.033016, -2.512598, 0.785853, -0.304402, 0.036335, 10.687999, -1.405268, 4.055599, -2.079884, -2.879090, 0.782526, 3.674926, 0.026572, 3.350602, -6.139579, -1.587096, 0.758836, 1.435151, -8.200558, 5.899854, 1.364863, -0.541013, -1.786972, 1.254798, 4.629752, -0.029174, 0.996838, -4.015242, -1.444164, 1.607215, -2.992276, 5.641769, -1.656054, 2.154746, 2.977335, -5.846249, -4.450179, -6.412597, 3.760830, 6.231683, -0.104874, 0.494370};
static RBF_CONST rbf_float RBF_BIAS[] = {16.846999, -2.004441, 0.543030, -5.534834, -14.642649, -6.649173, -5.537367, 4.220735, 1.741810, 1.905056, 6.770182, 2.581451};

#if RBF_USE_NORMALIZATION
static RBF_CONST rbf_float NORM_IN_MEAN[] = {0.012524, 0.011168, 0.010055, 0.004432, 0.005949, 0.006603, 0.003790, 0.003309, 0.004367, 0.005556, 0.002002, 0.004671, 0.004016, 0.000928, 0.004592, 0.007021, 0.007635, 0.008629, 0.008452, 0.009150, 0.008997, 0.008806, 0.009148, 0.008658, 0.007862, 0.009718, 0.007429, 0.005916, 0.007701, 0.011219, -0.001548, 0.000633, 0.006765, 0.001602, -0.000169, 0.006551, 0.001026, 0.002136, 0.001794, 0.004300, 0.000263, 0.001040, -0.000124, -0.000095, -0.004503, -0.004034, 0.001382, 0.010836, 0.007101, 0.005748, 0.003493, 0.008363, 0.013820, 0.014134, 0.003639, 0.010138, 0.006532, 0.008933, 0.005145, 0.010096, -0.010780, -0.010349, -0.013454, -0.000409, -0.004171, -0.005631, -0.008223, -0.007632, -0.000969, -0.003737, -0.006464, -0.013815, -0.012234, -0.003141, -0.016746, -0.009154, 0.001259, -0.014103, -0.010193, -0.004995, -0.006756, 0.000544, -0.005190, -0.008718, -0.009975, -0.014948, -0.005028, -0.012734, -0.014397, -0.009037, 0.004989, 0.008941, 0.007144, 0.007440, 0.002708, 0.002041, -0.006991, 0.003740, 0.002342, -0.003869, -0.006632, 0.000336, 0.004626, 0.004286, -0.000564, -0.001144, -0.000722, 0.015728, 0.008321, 0.006889, 0.013381, 0.014494, 0.020972, 0.021008, 0.004303, 0.015498, 0.011255, 0.012804, 0.008647, 0.015148};
static RBF_CONST rbf_float NORM_IN_SCALE[] = {0.997338, 0.995202, 0.993008, 0.994557, 0.997468, 0.999854, 0.998349, 1.000235, 1.001992, 0.999279, 0.999906, 0.999074, 0.999159, 0.998852, 0.997974, 0.994508, 0.993709, 0.993968, 0.997303, 1.000558, 0.998086, 0.994645, 0.994647, 0.998962, 1.003583, 0.999004, 0.995026, 0.995603, 0.997072, 0.998984, 1.007682, 1.015553, 1.015839, 1.013344, 1.012521, 1.013557, 1.012583, 1.013301, 1.010982, 1.004945, 1.013300, 1.009507, 1.004639, 1.003466, 1.005021, 0.998558, 1.012246, 1.014717, 1.019581, 1.019733, 1.014228, 1.011177, 1.009326, 1.011706, 1.004440, 1.012002, 1.011833, 1.015081, 1.014339, 1.011649, 1.002443, 1.007082, 1.013958, 1.002171, 1.007335, 1.013750, 1.007755, 1.008978, 1.010783, 1.011220, 1.006845, 1.011117, 1.006592, 1.005554, 1.005010, 1.002849, 1.008369, 1.016702, 1.005056, 1.006811, 1.010217, 1.013220, 1.016792, 1.022904, 1.014390, 1.013852, 1.014976, 1.022773, 1.019057, 1.014189, 1.003253, 1.015721, 1.024795, 1.011496, 1.004809, 1.002934, 1.004258, 1.016177, 1.013370, 1.007935, 1.011621, 1.005717, 1.007669, 1.012225, 1.011813, 1.009335, 1.016833, 1.016397, 1.024124, 1.025141, 1.021932, 1.016820, 1.016858, 1.019304, 1.015818, 1.015055, 1.024281, 1.020812, 1.015767, 1.016519}; // StdDev
static RBF_CONST rbf_float NORM_OUT_MEAN[] = {0.078289, 0.085565, 0.081781, 0.081781, 0.081490, 0.084692, 0.082654, 0.084692, 0.087602, 0.085565, 0.083818, 0.082072};
static RBF_CONST rbf_float NORM_OUT_SCALE[] = {0.268625, 0.279720, 0.274031, 0.274031, 0.273586, 0.278422, 0.275359, 0.278422, 0.282715, 0.279720, 0.277115, 0.274475}; // StdDev
#endif

// ==========================================
// Implementation
// ==========================================

RbfModelRBF::RbfModelRBF() {
    for(int i=0; i<RBF_HIDDEN_DIM; i++) hidden_activations[i] = 0;
}

void RbfModelRBF::predict(const rbf_float* input, rbf_float* output) {
    // 1. Prepare Input (Normalize if needed)
    rbf_float processed_input[RBF_INPUT_DIM];
    #if RBF_USE_NORMALIZATION
        normalizeInput(input, processed_input);
        const rbf_float* in_ptr = processed_input;
    #else
        const rbf_float* in_ptr = input;
    #endif

    // 2. Hidden Layer (RBF)
    for (int i = 0; i < RBF_HIDDEN_DIM; i++) {
        rbf_float dist_sq = euclideanDistanceSq(in_ptr, i);
        rbf_float width = RBF_READ(&RBF_WIDTHS[i]);
        hidden_activations[i] = computeKernel(dist_sq, width);
    }

    // 3. Output Layer (Linear)
    for (int j = 0; j < RBF_OUTPUT_DIM; j++) {
        #if RBF_FIXED_POINT
            int64_t sum = 0;
        #else
            float sum = 0.0f;
        #endif

        for (int i = 0; i < RBF_HIDDEN_DIM; i++) {
            rbf_float weight = RBF_READ(&RBF_WEIGHTS[i * RBF_OUTPUT_DIM + j]);
            #if RBF_FIXED_POINT
                sum += (int64_t)hidden_activations[i] * weight;
            #else
                sum += hidden_activations[i] * weight;
            #endif
        }

        #if RBF_FIXED_POINT
            sum = sum / RBF_SCALE_FACTOR;
            output[j] = (rbf_float)sum + RBF_READ(&RBF_BIAS[j]);
        #else
            output[j] = sum + RBF_READ(&RBF_BIAS[j]);
        #endif
    }
    
    // 4. Denormalize Output
    #if RBF_USE_NORMALIZATION
        denormalizeOutput(output);
    #endif
}

void RbfModelRBF::normalizeInput(const rbf_float* input, rbf_float* norm_input) {
    for(int i=0; i<RBF_INPUT_DIM; i++) {
        rbf_float mean = RBF_READ(&NORM_IN_MEAN[i]);
        rbf_float scale = RBF_READ(&NORM_IN_SCALE[i]);
        #if RBF_FIXED_POINT
             // (Input - Mean) * SCALE_FACTOR / StdDev
             int64_t diff = (int64_t)input[i] - mean;
             norm_input[i] = (rbf_float)((diff * RBF_SCALE_FACTOR) / scale);
        #else
             norm_input[i] = (input[i] - mean) / scale;
        #endif
    }
}

void RbfModelRBF::denormalizeOutput(rbf_float* output) {
    for(int i=0; i<RBF_OUTPUT_DIM; i++) {
        rbf_float mean = RBF_READ(&NORM_OUT_MEAN[i]);
        rbf_float scale = RBF_READ(&NORM_OUT_SCALE[i]);
        #if RBF_FIXED_POINT
             // (Output * StdDev) / SCALE_FACTOR + Mean
             int64_t val = (int64_t)output[i] * scale;
             output[i] = (rbf_float)(val / RBF_SCALE_FACTOR) + mean;
        #else
             output[i] = (output[i] * scale) + mean;
        #endif
    }
}

rbf_float RbfModelRBF::euclideanDistanceSq(const rbf_float* input, int center_idx) {
    #if RBF_FIXED_POINT
        int64_t sum = 0;
    #else
        float sum = 0.0f;
    #endif
    int base_idx = center_idx * RBF_INPUT_DIM;
    for (int k = 0; k < RBF_INPUT_DIM; k++) {
        rbf_float c = RBF_READ(&RBF_CENTERS[base_idx + k]);
        rbf_float diff = input[k] - c;
        #if RBF_FIXED_POINT
            sum += ((int64_t)diff * diff) / RBF_SCALE_FACTOR;
        #else
            sum += diff * diff;
        #endif
    }
    return (rbf_float)sum;
}

rbf_float RbfModelRBF::computeKernel(rbf_float dist_sq, rbf_float width) {
    #if RBF_FIXED_POINT
        if (width == 0) return 0;
        double d = (double)dist_sq / RBF_SCALE_FACTOR;
        double w = (double)width / RBF_SCALE_FACTOR;
        return (rbf_float)(exp(-d / (2.0 * w * w)) * RBF_SCALE_FACTOR);
    #else
        return exp(-dist_sq / (2.0f * width * width));
    #endif
}

void RbfModelRBF::printInfo() {
    Serial.println(F("Model Loaded: RbfModelRBF"));
    Serial.print(F("Normalization: ")); 
    Serial.println(RBF_USE_NORMALIZATION ? F("YES") : F("NO"));
}
