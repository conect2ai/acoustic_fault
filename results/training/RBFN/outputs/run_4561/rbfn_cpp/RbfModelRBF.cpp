#include "RbfModelRBF.h"

// ==========================================
// Flash/PROGMEM Macros
// ==========================================
#if defined(ESP32) || defined(ESP8266)
    #define RBF_CONST const
    #define RBF_READ(x) (*(x)) // Fixed: Dereference pointer
#elif defined(__AVR__)
    #include <avr/pgmspace.h>
    #define RBF_CONST const PROGMEM
    #if RBF_FIXED_POINT
        #define RBF_READ(addr) (rbf_float)pgm_read_dword(addr)
    #else
        #define RBF_READ(addr) (rbf_float)pgm_read_float(addr)
    #endif
#else
    #define RBF_CONST const
    #define RBF_READ(x) (*(x)) // Fixed: Dereference pointer
#endif

// ==========================================
// Model Parameters
// ==========================================
static RBF_CONST rbf_float RBF_CENTERS[] = {0.465258, 0.415639, -1.100813, -0.574858, -1.057059, -1.013783, -0.735095, -0.666788, -0.556115, -0.532049, -0.507359, -0.577169, -0.724716, -0.666108, -0.618695, -0.539557, -0.558389, -0.834364, -0.934861, -0.794558, -0.684130, -0.617359, -0.553072, -0.663934, -0.597041, -0.662501, -0.719018, -0.893042, -0.832416, -0.765757, -0.824969, -1.566776, -0.368572, 0.659182, -0.170472, -0.240764, -0.115980, -0.034960, -0.502639, -0.459815, -0.435620, -0.555571, -0.304345, -0.570760, -0.034842, 0.053292, 0.427059, -0.202945, 0.005257, -0.343623, -0.272523, -0.139627, -0.394019, -0.315170, -0.346733, -0.104825, -0.369250, -0.146439, -0.236666, -0.043169, -0.044349, -0.939042, 0.103402, 1.062785, -0.098433, -1.163458, -0.867010, -0.158196, -0.356750, 0.176596, 0.373810, 0.373185, -0.029763, 0.120020, 0.360786, -0.099849, 0.236667, 0.218742, 0.150874, 0.467435, 0.176604, 0.636200, 0.746869, 0.112856, 0.303235, 0.836511, 0.525611, 0.013598, 0.218757, 0.533597, -0.265156, -0.664661, -0.013356, 1.795504, 0.608640, 0.524639, -0.354689, -0.043377, -0.457256, -0.723364, -0.543057, -0.447733, -0.079486, -0.417875, -0.161600, -0.148866, 0.861773, -0.177485, 0.218531, 0.092347, -0.138569, 0.362772, 0.092421, -0.139978, 0.008209, 0.293752, -0.124294, 0.077338, -0.075545, 0.278277, 1.976751, 2.169689, 2.872693, 3.128378, 2.917095, 2.867896, 2.800472, 3.227204, 3.449266, 3.486412, 3.577259, 3.650051, 3.681416, 3.665601, 3.446158, 3.205246, 2.916910, 2.970165, 3.189116, 3.470779, 3.201329, 2.909032, 2.931683, 3.129605, 2.948416, 3.222427, 3.063337, 2.744563, 2.712786, 2.760320, 2.433949, 5.577594, 6.984929, 7.002302, 6.990615, 7.062012, 7.311174, 6.833116, 6.405777, 6.896592, 7.494226, 7.792155, 7.631866, 7.344145, 6.904576, 6.990127, 6.420420, 6.767826, 7.095286, 7.458868, 6.818380, 6.692398, 6.353651, 6.956912, 7.164104, 6.970718, 7.217307, 7.278831, 7.033431, 6.705774, -2.087164, -1.882899, -1.660192, -2.011248, -2.079192, -1.861019, -1.732693, -1.763745, -1.956814, -1.873955, -1.308172, -1.893610, -1.914462, -1.397171, -1.490671, -1.505174, -1.686889, -1.696306, -1.500973, -1.767183, -1.477867, -1.608755, -1.184550, -1.396527, -1.459228, -1.411084, -1.675800, -1.701068, -1.757800, -1.940268, 2.225870, 4.629735, 6.003514, 5.110258, 4.999931, 5.276783, 5.695718, 5.734405, 5.439325, 5.651975, 5.915172, 6.575848, 6.041639, 5.818443, 5.746871, 5.803289, 5.208198, 5.533644, 6.095796, 6.531127, 5.955612, 4.935512, 4.236587, 5.389606, 6.389771, 5.580530, 5.789960, 6.190253, 5.734641, 5.288034, -0.868463, -0.547441, -0.816174, -0.931614, -0.587702, -0.146339, -0.077190, -0.189796, -0.017138, 0.145111, -0.027770, -0.331048, -0.497047, -0.461041, -0.513840, -0.317487, -0.562939, -0.774821, -0.658494, -0.542223, -0.655170, -0.852519, -1.034225, -0.815297, -0.747676, -0.881507, -0.859337, -0.806639, -0.565604, -0.763741, 0.521831, -0.053205, -0.203314, -0.158351, -0.099337, 0.221657, -0.069604, -0.450224, 0.035096, 0.494311, 0.147237, -0.291169, -0.282473, -0.174137, 0.145375, -0.151875, -0.052260, -0.294468, -0.317744, -0.247827, -0.472198, -0.756725, -0.593685, -0.488638, -0.346292, -0.450486, -0.525221, -0.492559, -0.548027, -0.657016, 2.208984, 0.802566, 0.014820, -0.581745, -0.380647, 0.065992, 0.421563, -0.003211, -0.299701, 0.062590, 0.512460, -0.095087, -0.054424, 0.399181, 0.436049, 0.554973, 0.623477, -0.024210, -0.221802, -0.003327, -0.132648, 0.014841, -0.292688, 0.395502, 0.216340, 0.130737, 0.043665, 0.458474, 0.440509, 0.509529, 0.798674, 0.137722, -0.083968, 0.059636, -0.195527, 0.220317, -0.265180, -0.273118, 0.023138, 0.735277, 0.340873, -0.464950, -0.455375, -0.199805, 0.002769, -0.085056, -0.222271, -0.244268, -0.400355, -0.094184, -0.418216, -0.761062, -0.677069, -0.315747, -0.402446, -0.402873, -0.653349, -0.567149, -0.522030, -0.526587, -0.134475, -0.065309, 0.701782, -0.031781, -0.068956, -0.156288, -0.454383, -0.276720, -0.121790, -0.072711, -0.070033, 0.068270, 0.178637, 0.326122, 0.409837, 0.131111, 0.257328, 0.570412, 0.491797, 0.111387, 0.160003, 0.473736, 0.591263, 0.397935, 0.185858, 0.068533, 0.245384, 0.346438, 0.135052, 0.052867, -0.759658, -0.768425, -0.224758, -0.044742, -0.157079, 0.240650, 0.304428, 0.137522, -0.402205, 0.099475, -0.084598, -0.063812, -0.039722, 0.171650, 0.115826, -0.029963, 0.004920, 0.436509, 0.061661, -0.132620, -0.118133, -0.276246, -0.270956, -0.352612, -0.171453, -0.227549, -0.401842, -0.471643, -0.251322, -0.207113, 0.192323, 0.262121, 0.655497, -0.416144, -0.498945, -0.688100, -0.960644, -1.048109, -0.694904, -0.867421, -0.592374, -0.272448, -0.614415, -1.066189, -0.797634, -1.354909, -0.910791, -1.285088, -0.628166, -0.514474, -1.001550, -0.821569, 0.121239, -0.049217, -0.239300, 0.266144, -0.317602, -0.433974, -0.511034, -0.432879, -0.647379, -0.218373, -0.596052, -0.198569, -0.273342, 0.983005, 0.281097, -0.055791, -0.507289, -0.268620, -0.338902, -0.266409, -0.253710, 0.475723, 0.294561, 0.455850, -0.071339, 0.508198, -0.014429, -0.275545, -0.006380, -0.391559, -0.572610, -0.746356, -0.457279, -0.407737, -0.451790, -0.780696, -0.412144, -0.450086, 0.922890, 0.852720, 0.465790, 0.315882, -0.043384, -0.085148, -0.070538, -0.024289, 0.047848, 0.229395, -0.010572, 0.001541, 0.026663, 0.033128, 0.232763, 0.239937, 0.251775, 0.462628, 0.263620, 0.253640, 0.247829, 0.490159, 0.677091, 0.508431, 0.463121, 0.258270, 0.294065, 0.504631, 0.531537, 0.594149, 0.108737, 0.848589, -0.337742, -0.045604, -0.296228, 0.009863, 0.053004, -0.286872, -0.207506, -0.020374, -0.366092, -0.153595, -0.247480, -0.215524, -0.019138, -0.087416, -0.202045, 0.231963, -0.071712, -0.172927, -0.305211, -0.113612, -0.035322, -0.210451, -0.121781, -0.245946, -0.239027, 0.207039, -0.041188, 0.030372, -0.169484, 0.050645, 0.276364, 0.528245, 0.454434, 0.376516, 0.488486, 0.518359, 0.805572, 0.830490, 0.376918, 0.159065, 0.192411, -0.102276, -0.861268, -0.342632, 0.343537, 0.818407, 0.461456, 0.076157, -0.059499, -0.200100, -0.303274, -0.042724, 0.357205, 0.284658, 0.300352, 0.317916, 0.239046, 0.032442, -0.370867, -0.118249, -0.473000, -0.221464, -0.541313, -0.101425, 0.081051, -0.259918, -0.033164, 0.077703, -0.488508, -0.045846, -0.306631, -0.281803, -0.031361, -0.189866, -0.328557, -0.092647, -0.330365, -0.239004, -0.493553, -0.472932, -0.486361, -0.388881, -0.455510, -0.568896, -0.511980, -0.235502, -0.445955, -0.322680, 4.586664, 4.419111, 5.333059, 5.657330, 5.460634, 5.251698, 5.385772, 5.807860, 6.147583, 6.645715, 6.926517, 6.958478, 6.950287, 6.937250, 6.706729, 6.104996, 5.468481, 5.811250, 6.590447, 6.815598, 6.254845, 5.943252, 6.060153, 6.398942, 6.054059, 6.005226, 5.907003, 5.870138, 5.995277, 5.797606, 0.523519, 5.185309, 4.164761, 4.112724, 3.569475, 3.854783, 4.146909, 4.534910, 4.237078, 4.121192, 4.711665, 5.081495, 4.946797, 5.488910, 5.010783, 4.045799, 4.747989, 5.519250, 5.196205, 4.702197, 4.465806, 4.650689, 4.527887, 5.823036, 4.777797, 5.091187, 5.432549, 5.488094, 5.935142, 5.419916, 0.321164, 1.706356, 2.502012, 1.459338, 0.132975, 0.933153, 1.626146, 2.055881, 0.805145, 0.318815, 1.824706, 1.502676, 1.928207, 2.138997, 1.960833, 0.740310, 0.836007, 0.857224, -0.427681, 1.135995, 2.628382, 1.890018, 1.862683, 0.963567, 1.098124, 0.689435, 1.030847, 2.021621, 2.208552, 3.166358, 0.926948, 3.001023, 0.908572, 0.292550, -0.460259, -0.908843, -0.579225, 1.049288, -0.088624, -0.220882, 0.718013, 0.169299, 0.227634, 0.885967, 0.067253, -0.403266, -0.574766, -0.179789, -0.482680, 0.241249, 0.738692, 0.664968, 0.672054, 0.951327, 0.543825, 0.418662, 0.081176, 0.680475, 1.530535, 0.730960, -0.765018, -1.049327, -1.240459, -1.046685, -0.661042, -0.435720, -0.332476, -0.408522, -0.593039, -0.620615, -0.491166, -0.685468, -0.808364, -0.668034, -0.681462, -0.845009, -1.048764, -1.094339, -0.832350, -0.664233, -0.827523, -1.091304, -1.045131, -0.997045, -0.939671, -0.997708, -1.065577, -1.057240, -1.041480, -1.157000, -0.328585, 0.203471, 0.358368, 0.267387, 0.296953, 0.066105, -0.374635, -0.302544, -0.119433, -0.053162, 0.075711, -0.181418, -0.088289, -0.079205, -0.292362, -0.211098, -0.478809, -0.263924, -0.062885, -0.077999, -0.329811, -0.347870, -0.632297, -0.412858, -0.221663, -0.307723, -0.369790, -0.341560, -0.374623, -0.527896, -0.234653, 0.265504, 0.248109, -0.364380, -0.441525, -0.482904, -0.410810, -0.198557, 0.239267, 0.395626, 0.289791, 0.135482, 0.027109, -0.058608, 0.155096, 0.207690, 0.239777, -0.025347, -0.277408, -0.008859, 0.149055, 0.312989, 0.162509, 0.402113, 0.099821, 0.068514, 0.243647, -0.019156, 0.057200, -0.016019, -0.629885, 0.388607, 0.245824, 0.538598, 0.476146, 0.122277, -0.524036, -0.440926, -0.106992, -0.176410, 0.378397, -0.149992, 0.038358, -0.124645, -0.323575, -0.254128, -0.583492, -0.152955, -0.037068, -0.058850, -0.393961, -0.282889, -0.649672, -0.557838, -0.354727, -0.473342, -0.498908, -0.378689, -0.455056, -0.617225, 0.423935, 0.065748, -0.666708, -0.269453, -0.592226, -0.736951, -0.540211, -0.374080, -0.415728, -0.488618, -0.497176, -0.355926, -0.428042, -0.423461, -0.338625, -0.487523, -0.498794, -0.453072, -0.585823, -0.641322, -0.464669, -0.344523, -0.185434, -0.373525, -0.602567, -0.578004, -0.541813, -0.503540, -0.556627, -0.431415, -0.642756, -0.329477, -0.050996, 0.052991, -0.275686, -0.101139, -0.256031, -0.237685, -0.329395, -0.115849, -0.119950, -0.111113, -0.017897, -0.009636, -0.090820, 0.011889, 0.243801, 0.099016, 0.011844, 0.006586, 0.006471, 0.065652, 0.317710, 0.154983, -0.024653, 0.072732, 0.008516, -0.137493, 0.040787, 0.318319, -0.796128, -0.653679, -0.684974, -0.209806, 0.054516, -0.054697, -0.442988, -0.558353, -0.475552, -0.662424, -0.675161, -0.742935, -0.856212, -0.850837, -0.793749, -1.042162, -1.179471, -1.138224, -1.102193, -1.155655, -1.099277, -1.306715, -1.323858, -1.354929, -1.015917, -1.222904, -1.178925, -0.974102, -1.208865, -1.427849, 0.010425, -0.240105, 0.115653, -0.023332, -0.199583, -0.218302, -0.127644, -0.030748, -0.182680, 0.002617, -0.056898, 0.065971, 0.360643, 0.332399, 0.156257, 0.497359, 0.867930, 0.585914, 0.330109, 0.449032, 0.547652, 0.803422, 0.999552, 0.775332, 0.477978, 0.578657, 0.494000, 0.364348, 0.717541, 1.128366, 3.866478, 4.786003, 5.852462, 6.656595, 6.344991, 6.287756, 6.478681, 7.081460, 7.207613, 7.521490, 8.045801, 7.856135, 7.504549, 7.833999, 7.653847, 7.003561, 6.392141, 6.784414, 7.576442, 7.583862, 7.103399, 6.697510, 6.728571, 7.041965, 7.048744, 7.248058, 7.280330, 7.120012, 7.241928, 7.111198, -0.803028, 0.397192, 1.347934, 1.535641, 1.510122, 1.327437, 1.677944, 1.851480, 1.739471, 1.843756, 1.590290, 1.476669, 2.547388, 2.692541, 2.639338, 2.656358, 2.739812, 2.175411, 2.501957, 2.739388, 2.505728, 2.301699, 2.101145, 2.252638, 2.503809, 2.162786, 2.204453, 2.349831, 2.410987, 2.465501, 0.229542, -1.174617, -0.689069, -1.072074, -0.785452, -0.899507, -1.268371, -1.109811, -0.698963, -1.052055, -0.830458, -1.185148, -2.383101, -1.773884, -1.333350, -1.583921, -2.281469, -2.201225, -1.140831, -1.337178, -1.686274, -1.968476, -1.880168, -1.194283, -1.051810, -0.702113, -0.571948, -0.892839, -1.257132, -1.317906, -0.165542, 0.496311, 1.019506, 1.152235, 1.363660, 1.550416, 2.286846, 2.019762, 0.985987, 1.534564, 0.870161, 1.447734, 2.952330, 2.597831, 2.633983, 2.541374, 2.854276, 2.390338, 2.297412, 2.595715, 2.258524, 1.626031, 1.961262, 1.773085, 2.085382, 1.443187, 1.491718, 1.622303, 1.293120, 1.417473, 0.316158, 0.160682, 0.044589, 0.015023, -0.009892, -0.039252, 0.219915, 0.219989, -0.078327, -0.152189, 0.234865, 0.213579, 0.136657, 0.099314, 0.097899, 0.127195, 0.288773, 0.352989, 0.086837, 0.027166, 0.181908, 0.246611, 0.138526, 0.195292, 0.303608, 0.314978, 0.244048, 0.266672, 0.274257, 0.011510, 0.743626, 0.952158, 0.612356, 0.434633, 0.480902, 0.827892, 1.043794, 1.112591, 1.584068, 0.164149, 0.499286, 0.947693, 0.523658, 0.764074, 0.746612, 1.957180, 1.534044, 0.734771, 0.456673, 1.016450, 0.839656, 0.696708, 0.873206, 1.621050, 1.151318, 1.009208, 1.028416, 1.565682, 1.047223, 0.424655, 0.413094, 1.439027, 2.070115, 2.172037, 1.463888, 1.197492, 1.783357, 2.401979, 2.342095, 1.949590, 1.454512, 1.573160, 1.616476, 1.468690, 2.295882, 3.508581, 3.579774, 2.226138, 2.019399, 2.486265, 2.293797, 2.201541, 2.353877, 2.407001, 2.045908, 2.438765, 2.252624, 2.676134, 1.916781, 1.737136, 0.379275, 0.403310, 0.786648, 0.231989, 0.556300, 1.340062, 1.556991, 1.695256, 1.889698, 0.477123, 0.392749, 0.979999, 0.548652, -0.011650, 0.074034, 2.004102, 2.149775, 0.966645, 0.854231, 0.946142, 1.055565, 0.775029, 0.607092, 1.431700, 1.557429, 1.300085, 1.037375, 1.271208, 1.079255, 0.309016, 2.394287, 2.978554, 3.316818, 3.807756, 3.407514, 3.108927, 3.207965, 3.573869, 3.572306, 3.806292, 3.883936, 3.916672, 3.874112, 3.969971, 3.899873, 3.381339, 3.013651, 3.090939, 3.377214, 3.786631, 3.487814, 3.232430, 3.319641, 3.207148, 3.111908, 3.294241, 3.152789, 2.823207, 2.976885, 3.002148, 2.569271, 6.024604, 8.985350, 8.692096, 8.444326, 8.940116, 8.618813, 8.630180, 8.581141, 8.309994, 8.930557, 8.802738, 8.169692, 7.581227, 7.381133, 7.958728, 7.744076, 7.463266, 8.588359, 8.782052, 8.499479, 7.269122, 6.672069, 8.002430, 8.407863, 7.887441, 7.806979, 7.455490, 6.987330, 6.520734, -1.104971, -3.000921, -4.849102, -4.905840, -4.884778, -4.205521, -4.068942, -4.257926, -4.410911, -4.536240, -4.947091, -5.034934, -4.599733, -4.400895, -4.286124, -4.708021, -4.248874, -4.114133, -5.389194, -5.899638, -5.488048, -4.512375, -4.150859, -5.014603, -5.691284, -5.518565, -5.561302, -5.348508, -5.403034, -4.448439, 3.386016, 5.748456, 9.122348, 8.125155, 8.079491, 8.861629, 8.678850, 9.195804, 9.221548, 8.282984, 8.205509, 9.176939, 8.544458, 7.708051, 7.022470, 8.119214, 8.505336, 8.159324, 9.375571, 9.598629, 9.513918, 7.245845, 6.151538, 8.074205, 9.442804, 8.390448, 8.190852, 8.463489, 7.523395, 6.524347, -0.167959, -0.730457, -0.187894, -0.095396, -0.263482, -0.542858, -0.724593, -0.456339, -0.304382, -0.415734, -0.370112, -0.162119, -0.025034, 0.082905, 0.034938, -0.168745, 0.152787, 0.485698, 0.377223, -0.023322, 0.019525, 0.308684, 0.462955, 0.271464, -0.034212, 0.130158, 0.264198, 0.144633, 0.126021, 0.050147, -0.325362, 0.094102, 0.299720, 0.349463, 0.042259, -0.023076, -0.155265, 0.233283, 0.046852, -0.269927, -0.220652, -0.167273, -0.201956, -0.222857, -0.332252, -0.262548, 0.105350, 0.239550, 0.026238, -0.262574, -0.271421, -0.320013, -0.214317, -0.045421, -0.119144, 0.038611, -0.123621, -0.119019, -0.010641, -0.346934, -0.272818, -0.452882, -0.297163, -0.322299, -0.390584, -0.416653, -0.605978, -0.591977, -0.472125, -0.335927, -0.237222, -0.385750, -0.330539, -0.088237, 0.020626, -0.091299, -0.050525, 0.014227, 0.018640, -0.078119, -0.193886, -0.241238, -0.238833, -0.375501, -0.467811, -0.424404, -0.402429, -0.563837, -0.523744, -0.396762, -0.180856, 0.927361, -0.285637, 0.032870, -0.116510, -0.000369, -0.039482, 0.111514, -0.023198, -0.317779, -0.333389, -0.235748, -0.229158, -0.204743, -0.394177, -0.339013, -0.114336, -0.016544, -0.099705, -0.267324, -0.239065, -0.381789, -0.406654, -0.249328, -0.249269, -0.192354, -0.225592, -0.264838, -0.213993, -0.428631, 0.931828, 0.811958, 0.598267, 0.394819, -0.208959, -0.348197, -0.270627, -0.096729, -0.001179, 0.131366, -0.194059, -0.035496, 0.107742, 0.229108, 0.328137, 0.271747, 0.279160, 0.584513, 0.432799, 0.274577, 0.216056, 0.520470, 0.776601, 0.640223, 0.634251, 0.406041, 0.316748, 0.549900, 0.626563, 0.838743, -0.056129, 0.408362, -0.613306, -0.401659, -0.369469, -0.345346, -0.322716, -0.292245, -0.330399, -0.069333, -0.309154, -0.334780, -0.098664, 0.267631, -0.171537, -0.275664, 0.081328, 0.236324, -0.141331, -0.107525, -0.346869, -0.120270, -0.034188, -0.203595, -0.027327, -0.365402, -0.392659, -0.043096, -0.039870, 0.208692, -0.233270, -0.323182, 0.176837, -0.209908, -0.591196, -0.776560, -0.218118, 0.055445, -0.180575, -0.222334, -0.288562, 0.047981, -0.109243, -0.021588, 0.016355, 0.067012, 0.218361, 0.233623, 0.086026, -0.131054, -0.010204, 0.493733, 0.461370, 0.183847, 0.123598, 0.222296, -0.067638, 0.077876, 0.429928, 0.317901, -0.733187, -0.660921, -0.489251, -0.213037, -0.347525, -0.397948, -0.312018, -0.441899, -0.496231, -0.071871, -0.376392, -0.465949, -0.154689, 0.177244, -0.483599, -0.504916, -0.284321, -0.163570, -0.275081, -0.186996, -0.410531, -0.375651, -0.438956, -0.494231, -0.238414, -0.533360, -0.519940, -0.429544, -0.400369, -0.356487, 0.517850, -0.464814, 0.517090, 0.423722, 0.667078, 0.665145, 0.343587, 0.203790, 0.213956, -0.022617, -0.470107, -0.329938, -0.250007, -0.300206, -0.276411, 0.028073, 0.299954, 0.304004, 0.441863, 0.306995, 0.042728, 0.149159, 0.134526, -0.030881, -0.133629, 0.009495, 0.009537, 0.012896, -0.102845, -0.062336, -0.031982, -0.175070, 0.173483, -0.104899, 0.139252, 0.002462, -0.111765, 0.094828, 0.316163, 0.364917, -0.096505, -0.131601, -0.134214, 0.064390, 0.316317, 0.196093, -0.048471, 0.153782, 0.136893, 0.292998, 0.041320, 0.538941, 0.924158, 0.421468, 0.137346, 0.525085, 0.402261, 0.425409, 0.495829, 0.636079, 0.884774, 0.367270, 0.314863, 0.473366, 0.263513, 0.498495, 0.598229, 0.655489, 1.013590, 1.332682, 0.992281, 1.116685, 1.073757, 0.775795, 0.653423, 0.577714, 0.699709, 0.819052, 1.071711, 0.881491, 0.842539, 0.755000, 1.288859, 1.215180, 0.799594, 0.572555, 0.838035, 1.082648, 0.975229, 1.174212, 0.064689, 0.068051, 0.133222, 0.040718, 0.305634, 0.079679, -0.190632, 0.172024, 0.226166, 0.427922, 0.027294, -0.055292, -0.023712, 0.306785, 0.215369, 0.229326, 0.031639, 0.248790, 0.359075, 0.548735, 0.533114, 1.288341, 1.416013, 0.720325, 0.516052, 1.036569, 0.928827, 0.978350, 0.972578, 1.172983, -1.186664, -0.542373, -0.208688, -1.072409, -0.757060, -0.392943, -0.108538, -0.573227, -0.833790, -0.418127, -0.164249, -0.109791, -0.242822, -0.293158, -0.399153, -0.371574, -0.501329, -0.452708, -0.222271, -0.253646, -0.379036, -0.420383, -0.670819, -0.600406, -0.415271, -0.267335, -0.357697, -0.464359, -0.417672, -0.443602, 2.465562, -0.177433, -0.040962, -0.402061, -0.224906, -0.499119, -0.063312, -0.164147, -0.230761, -0.002483, -0.253542, -0.286121, -0.183870, -0.159381, -0.012713, -0.037652, -0.434636, -0.348542, -0.117738, -0.125884, -0.389919, -0.197879, -0.023294, -0.133987, -0.116011, 0.128572, 0.333439, 0.105719, 0.258993, 0.314973, 0.660815, 0.154348, 0.136489, -0.163282, -0.188708, -0.033212, -0.137617, -0.201424, -0.198696, 0.056479, 0.012322, -0.063557, -0.133535, 0.121024, 0.204632, 0.063100, -0.021945, -0.031540, 0.064220, -0.078290, -0.130682, 0.176124, 0.266458, -0.049931, -0.172330, -0.022564, 0.263247, 0.101722, 0.112247, 0.022361, 1.900477, -0.259230, 0.035962, -0.330163, -0.340441, -0.468001, 0.099998, -0.051270, -0.054723, 0.414920, 0.137449, -0.110861, -0.016135, 0.035951, 0.258832, 0.046634, -0.275091, -0.117989, -0.050643, -0.147543, -0.165338, 0.216202, 0.307034, 0.163090, 0.093352, 0.550560, 0.910427, 0.618323, 0.845855, 0.884082, 1.217415, 0.890286, 0.877497, 1.304685, 1.503523, 1.306812, 1.104016, 0.958969, 0.775065, 0.885741, 0.829779, 0.654806, 0.695961, 0.615009, 0.724420, 0.758984, 0.807194, 0.886953, 0.876216, 0.961690, 0.662149, 0.656063, 0.811509, 0.964593, 0.732707, 0.588147, 0.736555, 0.878397, 0.901708, 0.388996, 0.024934, 1.355811, 0.147941, 0.178484, 0.822729, 0.515719, 0.371247, -0.028217, 0.463726, 0.102094, -0.013322, -0.115608, -0.122074, -0.075296, 0.061549, 0.131860, 0.072867, -0.004365, -0.051886, 0.191840, 0.049803, 0.095770, 0.146261, 0.162899, 0.263962, 0.106588, 0.043733, 0.137643, 0.320546, -0.016274, 0.007371, 0.308697, 0.508939, 0.617168, 0.554213, 0.639593, 0.365116, 0.287550, 0.493842, 0.530082, 0.272420, 0.220203, 0.378833, 0.453893, 0.701359, 0.266167, 0.465728, 0.448512, 0.649341, 0.807052, 0.724218, 0.737672, 0.829265, 0.321074, 0.659068, 0.871567, 0.767734, 1.084400, 1.286411, 0.625735, -0.218028, 1.014238, -0.192364, 0.382802, 0.997450, 0.310823, 0.168771, -0.127817, 0.357566, 0.080374, -0.071060, -0.133176, -0.056609, 0.035273, 0.054821, -0.118199, -0.215913, 0.008537, 0.076063, 0.418658, 0.264301, -0.151182, -0.189436, 0.143674, 0.339440, 0.224124, -0.005650, 0.243196, 0.572209, -0.108794, 0.983104, 1.554526, 1.975088, 1.861149, 1.460146, 1.300784, 1.210118, 1.388985, 1.358519, 1.406719, 1.416269, 1.330571, 1.387277, 1.343244, 1.392198, 1.143237, 0.903138, 1.076653, 1.204893, 1.092343, 0.992486, 1.035482, 1.007395, 0.846508, 0.842686, 0.697441, 0.646618, 0.388963, 0.497234, 0.617563, -0.101893, 0.537748, 1.390424, 2.156754, 2.664073, 2.900281, 2.903074, 3.168193, 2.564903, 1.908301, 2.109990, 2.202016, 2.465398, 1.937279, 1.630703, 1.586224, 1.241957, 1.461712, 1.941421, 2.449445, 2.455143, 2.364316, 2.016727, 2.068417, 2.008275, 1.460729, 1.382336, 1.494292, 1.778903, 1.949120, -1.457761, -1.740256, -2.656780, -3.525444, -3.289201, -3.271350, -3.215353, -3.274120, -3.373775, -2.641193, -2.890740, -2.871774, -2.904308, -2.692684, -2.304499, -2.009890, -1.925578, -2.513357, -3.144933, -2.887099, -3.093911, -3.485735, -2.839576, -2.906356, -3.189048, -2.629759, -2.583606, -1.987396, -2.539202, -3.096224, 0.896875, 0.637248, 0.465814, 0.723133, 1.100907, 1.330845, 0.995244, 1.059847, 0.556881, 0.793567, 1.086242, 0.542666, 1.042563, 0.871907, 0.312446, 0.731715, 0.217747, 0.959402, 0.961207, 1.091988, 1.575652, 1.378669, 0.950433, 1.210198, 0.719140, 0.939904, 0.715900, 1.048249, 1.356492, 1.538375, -0.667383, -1.513060, -1.657302, -0.929865, -0.724606, -0.634856, -0.684814, -0.476325, -0.569550, -0.852627, -0.646889, -0.494459, -0.723366, -0.725823, -0.789478, -1.167884, -1.361173, -1.284992, -0.925549, -0.718034, -0.934154, -1.084686, -1.151451, -1.101203, -1.122588, -1.115504, -1.261425, -1.106507, -1.140566, -1.280856, -0.733915, -0.195063, 0.269563, 0.332850, -0.414158, -0.032714, -0.274881, -0.061795, -0.405439, -0.436717, -0.146451, -0.291462, -0.377196, -0.295985, -0.274377, -0.280600, -0.211120, -0.364759, -0.324525, -0.351839, -0.425909, -0.579113, -0.650493, -0.376194, -0.272124, -0.435079, -0.521889, -0.355492, -0.416165, -0.560875, -0.070654, -0.179612, 0.126256, 0.285932, 0.298551, 0.361362, 0.481477, 0.497162, 0.450815, 0.335733, 0.197941, 0.159665, 0.434098, 0.483499, 0.458469, 0.347672, 0.308339, 0.400254, 0.490994, 0.447519, 0.300764, 0.398997, 0.328134, 0.566783, 0.350197, 0.269388, 0.510511, 0.505928, 0.394699, 0.477140, -0.505025, -0.222416, 0.056767, 0.765911, -0.307371, -0.086620, -0.378183, -0.144397, -0.328996, -0.350078, -0.139605, -0.317447, -0.475821, -0.429480, -0.269737, -0.303205, -0.276618, -0.418334, -0.323916, -0.332763, -0.456382, -0.509825, -0.689046, -0.397991, -0.305610, -0.462542, -0.588986, -0.474118, -0.518184, -0.578740, 2.182130, 1.290762, 1.658519, 2.074897, 1.960632, 1.984132, 1.820305, 2.207238, 2.289842, 2.517399, 2.677484, 2.526346, 2.413981, 2.179368, 2.272816, 1.838561, 1.628129, 1.765884, 2.147118, 2.292360, 1.940993, 1.633630, 1.599242, 1.723378, 1.667136, 1.895041, 1.725511, 1.477500, 1.471277, 1.344211, 0.004462, 1.848404, 3.180196, 3.026876, 2.094870, 1.459965, 1.239104, 1.472390, 1.488676, 1.896254, 1.692033, 2.194872, 2.095764, 1.933805, 2.161025, 2.609831, 2.500682, 2.455879, 3.930178, 4.181702, 4.380860, 3.870660, 2.971459, 3.011163, 3.608708, 3.661471, 4.180507, 4.264460, 3.599626, 3.715547, 0.398409, 2.392501, 2.894503, 2.033597, 1.874303, 1.512576, 0.838626, 1.001319, 1.092792, 1.626661, 0.899772, 1.266269, 0.892101, 1.031821, 1.786035, 2.394629, 2.529607, 2.127872, 2.037594, 2.530879, 3.186221, 2.798640, 2.463407, 2.446377, 2.659719, 3.510623, 3.555897, 3.170524, 3.083786, 3.331458, -0.502617, 3.263837, 3.918794, 2.867890, 2.419626, 1.683215, 2.009084, 1.297845, 0.586959, 1.325804, 1.748775, 2.609032, 2.500592, 3.014275, 2.886219, 3.009053, 3.480590, 3.549207, 5.148604, 4.848804, 5.506158, 4.959425, 3.266528, 3.101908, 3.990765, 3.836513, 4.309662, 5.057388, 4.121965, 3.969774, -0.777289, -0.612207, -0.536532, -0.382788, -0.755851, -0.933451, -0.993044, -0.834868, -0.605721, -0.638150, -0.453363, -0.631909, -0.679000, -0.735883, -0.893318, -0.772038, -0.843093, -1.018191, -1.009720, -0.932373, -0.928024, -1.020581, -1.060453, -0.863514, -0.642911, -0.780534, -0.774313, -0.904509, -0.944623, -0.820577, 0.789139, -0.177021, -0.426092, -0.450338, -0.276434, -0.399688, -0.363208, -0.277574, -0.341314, -0.479885, -0.118138, -0.212203, -0.107987, -0.322124, -0.384606, -0.339375, -0.510784, -0.457192, -0.278619, -0.280918, -0.444448, -0.668934, -0.641573, -0.491308, -0.339868, -0.575233, -0.522161, -0.495282, -0.603507, -0.598784, -0.465015, -0.331070, -0.290973, -0.138839, -0.236022, -0.211874, -0.191918, -0.040952, -0.213520, -0.266025, -0.099803, -0.046857, 0.021848, 0.088587, 0.055805, -0.120670, -0.307121, -0.133681, 0.075219, 0.020199, -0.081139, -0.156485, 0.056839, 0.022203, -0.128058, -0.045084, 0.048922, -0.038920, -0.066908, 0.068609, 0.920317, -0.454818, -0.195535, -0.241353, -0.319805, -0.448118, -0.280059, -0.217122, -0.311028, -0.547789, -0.161460, -0.222062, -0.021189, -0.399265, -0.498804, -0.247321, -0.424209, -0.509568, -0.354549, -0.192111, -0.357585, -0.624453, -0.676045, -0.530073, -0.396502, -0.626437, -0.543849, -0.521749, -0.653108, -0.620900, -1.211980, 0.362786, 0.328542, 0.600248, 0.809146, 0.798863, 1.060718, 0.981660, 0.539876, 0.563321, 0.427840, 0.426189, 0.589787, 0.681424, 0.829068, 1.109023, 1.043087, 0.361146, 0.224699, 0.604668, 1.072808, 0.630164, 0.200751, 0.353540, 0.561180, 0.581770, 0.362412, 0.451261, 0.312313, 0.780260, -0.480936, -0.374908, -0.920510, 0.026089, 0.282579, 0.885290, -0.060576, -0.378684, 0.242174, 0.093512, -0.737612, -1.021049, 0.126986, 0.125196, -0.387085, -0.474067, -0.454642, -0.619415, -0.414005, -0.159466, 0.193859, 0.447497, -0.600402, -0.161246, -0.180881, -0.597440, -0.144719, -0.419685, -0.501776, -0.538660, 0.899218, 1.525793, -0.876409, -1.461847, -0.645516, 0.709030, 0.704702, -0.050730, -0.207871, 1.155183, 0.142262, 0.383940, 1.210180, 0.859251, 0.116117, 0.418279, 0.929458, 1.031235, -0.425369, -0.720862, -0.137077, -0.419484, -0.507436, -0.630485, -0.555827, -0.064209, -0.293563, -0.517820, -0.033001, 0.828534, -0.171861, 0.149968, -0.825258, -0.476922, -0.025955, 0.787271, -0.177883, -0.220365, 0.403407, -0.096795, -0.495829, -1.647600, -0.125979, -0.378118, -0.084908, -0.530354, -0.909564, 0.078326, -0.438203, -0.020052, 0.133103, 0.210288, -0.583463, -0.281160, 0.416977, -0.740957, -0.402420, -0.252013, -0.221512, -0.664700, -2.162806, -1.120941, -0.064733, 0.843228, 1.275117, 1.361793, 1.344042, 1.074853, 0.677764, 0.475912, 0.173099, 0.410710, 0.477916, 0.744111, 1.043095, 1.097793, 1.296813, 0.979260, 0.700908, 0.382112, 0.926734, 0.719095, 0.304854, 0.447335, 0.517912, 0.235563, 0.451164, 0.642001, 0.361091, 0.730174, -0.770879, -0.145119, 0.168189, -0.123081, -0.126739, -0.229343, -0.365154, -0.528567, -0.294789, -0.249201, 0.070442, 0.105420, 0.068964, -0.130816, 0.024535, -0.519262, -0.347473, -0.357923, -0.536593, -0.449948, 0.456523, 0.058087, -0.498946, -0.323744, -0.113383, -0.420553, -0.473319, -0.306983, -0.570223, -0.473115, -0.544299, -0.722647, -0.048083, 0.293283, 0.135636, 0.068219, 0.240536, -0.241400, -0.508316, -0.392805, -0.454119, -0.338328, -0.381870, 0.024760, 0.441277, 0.760261, 0.491000, -0.034357, -0.015199, 0.143782, 0.005921, -0.088932, -0.215176, -0.169613, 0.255677, 0.126544, -0.124073, -0.377541, 0.030536, 0.116014, -0.296312, 0.158761, 0.167874, 0.037234, -0.108904, -0.190008, -0.473612, -0.331031, -0.282265, -0.256252, 0.093364, -0.119690, -0.086236, -0.272816, 0.202382, -0.262344, -0.491129, -0.160977, -0.596263, -0.424674, 0.043558, 0.205678, -0.612400, -0.331979, -0.392265, -0.486169, -0.478705, -0.396434, -0.681709, -0.642702, 0.401406, -0.485812, 0.495009, 0.454108, 0.795529, 0.746127, 0.320385, 0.153924, 0.259545, -0.102479, -0.583108, -0.519458, -0.381018, -0.154146, -0.264013, -0.098491, 0.181028, 0.262791, 0.471447, 0.313996, -0.094336, 0.193821, 0.214279, -0.142966, -0.347703, 0.083928, 0.137741, 0.000661, -0.184087, -0.115842, 0.284972, -0.179149, -0.360150, -0.474665, -0.281767, -0.295120, -0.088626, -0.125037, -0.214952, -0.194390, -0.211842, -0.080939, -0.150274, -0.032442, 0.264047, 0.107034, -0.076451, 0.269294, 0.553307, 0.180824, -0.083376, 0.538428, 0.860129, 0.229608, 0.157847, 1.248444, 0.759959, 0.376529, 0.408267, 0.575971, -0.198571, -0.425546, -0.344210, 0.296883, 0.240786, -0.378994, -0.379773, -0.596947, -0.144487, -0.200707, -0.459328, -0.457237, -0.282636, -0.163618, -0.151164, -0.173504, -0.091581, -0.331576, -0.596229, -0.526151, -0.039319, 0.514253, 0.536955, 0.239710, 0.250373, 0.544264, 0.355975, 0.080614, 0.316756, 0.347605, 0.198280, -0.495614, -0.584982, -0.215251, 0.175526, -0.374624, 0.153659, -0.208102, -0.215939, -0.045170, -0.210327, -0.121318, -0.059801, 0.162311, 0.694965, 0.019689, -0.088774, 0.600237, 0.957972, 0.717600, 0.331852, 0.978078, 1.325720, 0.582888, 0.581441, 1.776214, 1.445957, 0.864937, 0.748035, 1.012680, 1.365787, 3.058315, 4.013541, 4.645609, 4.504156, 4.414416, 4.537219, 5.042683, 5.183146, 5.377714, 5.491137, 5.552577, 5.561350, 5.666310, 5.345062, 4.998218, 4.696887, 4.725084, 5.123994, 5.395631, 4.956243, 4.626206, 4.604052, 4.969819, 4.970660, 5.112827, 5.014084, 4.853216, 5.084155, 5.059751, 2.837193, 3.234151, 5.530978, 6.492005, 6.156164, 6.174658, 6.471712, 6.463168, 6.876801, 7.613408, 7.815003, 7.813756, 7.219387, 7.563424, 7.630643, 7.404689, 7.189544, 8.385444, 9.279016, 8.551382, 8.214363, 8.444865, 8.707514, 8.841498, 8.343965, 8.387315, 8.382414, 8.340253, 8.264858, 7.718675, -0.264849, -1.413371, -2.374870, -2.610340, -2.952210, -3.004591, -3.454151, -3.143072, -2.491877, -3.257728, -3.174999, -2.629505, -2.524880, -3.305713, -3.050330, -2.328235, -2.764694, -3.424182, -3.896540, -3.486291, -4.069263, -3.808339, -3.924551, -3.771295, -3.657707, -3.789561, -4.196675, -3.638033, -3.800670, -3.614244, 5.305797, 4.002869, 5.344572, 5.178562, 5.266245, 5.053616, 4.933598, 4.794653, 5.905499, 6.303853, 5.803343, 6.160181, 6.442109, 6.385408, 6.316086, 6.384086, 5.874061, 7.307022, 7.618916, 7.394246, 6.844378, 6.844204, 6.351168, 7.212223, 7.406082, 6.533402, 6.673381, 7.130596, 6.859797, 5.782257, -0.527811, -0.569664, -0.991668, -0.953526, -0.832764, -0.658976, -0.513398, -0.612796, -0.736727, -0.675866, -0.540193, -0.688221, -0.800047, -0.833775, -0.793902, -0.741330, -0.980808, -1.188606, -1.081088, -0.988537, -1.033891, -1.217241, -1.214547, -1.157748, -1.061249, -1.072124, -1.012616, -1.105145, -1.134224, -1.072141, -0.072183, 0.184284, 0.080304, 0.057206, 0.095726, -0.245352, -0.297637, -0.064646, -0.031974, -0.287411, 0.037824, -0.064935, -0.201448, -0.124295, -0.306735, -0.042641, -0.124936, -0.115332, -0.141215, -0.000953, -0.170022, -0.530347, -0.468317, -0.311096, -0.209953, -0.428233, -0.377546, -0.352962, -0.348021, -0.387772, 0.964118, 1.255625, 1.441044, 1.107776, 0.944399, 0.751337, 0.856551, 0.872022, 0.662632, 0.683354, 0.962879, 0.858045, 0.887081, 0.876787, 0.643925, 0.654899, 0.914808, 0.952821, 0.810085, 0.942709, 0.836814, 0.775346, 0.899294, 0.762028, 1.159339, 0.908189, 0.762590, 0.886443, 0.967256, 1.043118, -0.250153, 0.036405, 0.303417, 0.036670, 0.014100, -0.494640, -0.350302, -0.179835, -0.130401, -0.350841, 0.123711, 0.034928, -0.243261, 0.022741, -0.537782, -0.258796, -0.039683, 0.014334, -0.188452, 0.137721, -0.172588, -0.416773, -0.411256, -0.282155, -0.167345, -0.370422, -0.439203, -0.445054, -0.429442, -0.375478, 1.652350, 3.547178, 4.985480, 5.728924, 5.303339, 5.366006, 5.449831, 6.233596, 6.423460, 6.533746, 7.159101, 6.889844, 6.442746, 6.262536, 6.658586, 5.931611, 5.381063, 5.530843, 6.405471, 6.526008, 5.806357, 5.334833, 5.512667, 5.776629, 5.948085, 6.177386, 5.937815, 5.470582, 5.683383, 5.718588, 1.459198, 2.856359, 4.836527, 5.422337, 5.901351, 6.328373, 7.389206, 7.747968, 8.045387, 8.374146, 9.266948, 8.780303, 9.054564, 9.998716, 10.046144, 10.269948, 8.877315, 8.768029, 8.952692, 8.722667, 11.080588, 10.320036, 9.096550, 10.060250, 10.384700, 8.755828, 9.282490, 8.907900, 9.528036, 8.922774, -1.500063, 2.386107, 4.026552, 4.118918, 4.005744, 4.478374, 6.083685, 7.350970, 6.571774, 7.782130, 7.717031, 6.172290, 6.919976, 7.316604, 7.008448, 7.612735, 8.046352, 6.978959, 7.351694, 6.707404, 9.609748, 8.018655, 7.538990, 8.862368, 9.065064, 8.577249, 9.835804, 8.492944, 8.695919, 8.194789, 3.087770, 5.510531, 7.121910, 8.793783, 8.447962, 9.303242, 9.295560, 8.648383, 9.622732, 10.388199, 11.753206, 12.041667, 11.147207, 12.076743, 12.658831, 12.769855, 9.671738, 9.466227, 10.125064, 11.003134, 12.375681, 9.797839, 8.645519, 10.997481, 12.297468, 9.727294, 10.584767, 10.322402, 10.278182, 9.281795, -1.900497, -0.324071, -0.097519, 0.496777, 0.706615, 0.704097, 1.077577, 1.116358, 0.857037, 0.590564, 0.420891, 0.588709, 0.394950, 0.583159, 0.777760, 1.301084, 1.455755, 0.487547, 0.356789, 0.497395, 0.362893, -0.013117, -0.109705, 0.243056, 0.495715, 0.275922, 0.348834, 0.182711, 0.136149, 0.454579, -0.915149, -0.641505, -0.292837, -0.247703, -0.089778, -0.272442, -0.253443, -0.126349, -0.261066, -0.055950, -0.292099, -0.163321, -0.356062, 0.056444, -0.211664, -0.299196, -0.204375, -0.575286, -0.215151, -0.192717, -0.248115, -0.522197, -0.613955, -0.481628, -0.361449, -0.572769, -0.448454, -0.436675, -0.590616, -0.587112, -0.176920, 0.000900, 0.032060, 0.211203, 0.665470, 0.534660, 0.409722, 0.208847, 0.334150, 0.578051, 0.221264, -0.192071, -0.028740, -0.082725, -0.292105, -0.118976, 0.289613, 0.510416, 0.571914, 0.455577, 0.398108, 0.166994, 0.131514, 0.524305, 0.404822, 0.194542, 0.214542, 0.299053, 0.101977, -0.006042, -0.447585, -0.554131, -0.179034, -0.145689, -0.093631, -0.277358, -0.150471, -0.196979, -0.290227, 0.020985, -0.390943, -0.219660, -0.440874, -0.259053, -0.321192, -0.109839, -0.028272, -0.474384, -0.170491, -0.097478, -0.375679, -0.391493, -0.613755, -0.490597, -0.306081, -0.690155, -0.496555, -0.453855, -0.467380, -0.586953, -0.257528, -0.274381, 0.459405, -0.300270, -0.373388, -0.572843, -0.845881, -0.562422, -0.400194, -0.426404, -0.345219, -0.145895, 0.034668, 0.117090, -0.005745, -0.230082, 0.107565, 0.344735, 0.330933, -0.130735, -0.057375, 0.302300, 0.461985, 0.230832, -0.056113, 0.174081, 0.306538, 0.163665, 0.100264, -0.046520, -0.344477, -0.546323, -0.077650, -0.168946, 0.209776, 0.077662, -0.126502, -0.141762, -0.806048, -0.788000, -0.604927, -0.171126, 0.068587, -0.091639, 0.126467, -0.372937, 0.319063, 0.768423, 0.441968, -0.341686, -0.209426, 0.202092, 0.011192, -0.450638, -0.113673, -0.276875, 0.004155, -0.216442, 0.082667, -0.509170, 0.168823, 0.395545, 0.374633, 0.098217, 0.591779, 0.807694, 0.916979, 0.150674, -0.290206, 0.039360, 0.522092, 1.765788, 1.229539, 1.151001, 0.398230, -0.052220, -0.183716, -0.458277, -1.189982, 0.028018, 0.248473, 0.755402, 0.661741, 0.607154, 0.628198, 0.097242, 0.270119, 0.397873, 0.439124, 0.087875, -0.180707, 0.564554, -0.514086, -0.132103, 0.702652, 0.287862, -0.518977, -0.372575, -1.162064, -0.824698, -0.580338, 0.430833, 0.144216, -0.357108, -0.037153, -0.622840, 0.094988, -0.008405, -0.046438, -0.500989, -0.326346, -0.031058, -0.096880, -0.499595, -0.166620, -0.399915, -0.428507, -0.537866, -0.231120, -0.534039, 3.756910, 4.503659, 5.956521, 6.614326, 6.245368, 6.070571, 6.147137, 7.016757, 7.228383, 7.500106, 7.947828, 8.062309, 7.774872, 7.685116, 7.619179, 7.221846, 6.568905, 6.856681, 7.357783, 7.611401, 7.135983, 6.885416, 6.827768, 7.012482, 7.027193, 7.410449, 7.383574, 7.000255, 7.250885, 7.032023, -0.136988, 0.770391, 1.231534, 1.734084, 1.835053, 1.658142, 1.879223, 1.784743, 1.362287, 1.815174, 2.158447, 2.311236, 2.407422, 2.233427, 2.223046, 2.557323, 2.234798, 2.407395, 2.703544, 2.472199, 2.738801, 2.858387, 2.678265, 3.286570, 3.297400, 3.106028, 2.692449, 3.012003, 2.923668, 2.865433, -0.701922, 0.158039, -0.192953, 0.458203, 0.856215, 0.173347, 0.775582, 0.901003, 0.145034, -0.207191, 0.369284, 1.121656, 1.561371, 1.726568, 1.409520, 0.866255, 0.899284, 1.571038, 1.062567, 1.180840, 0.963709, 0.616362, 0.881644, 1.241914, 0.714086, 1.220545, 1.230272, 1.138134, 0.913214, 1.083660, 0.455719, 0.501920, 0.637505, 0.911823, 1.755710, 1.130691, 1.410119, 1.018086, 0.442891, 1.586560, 1.387432, 0.954294, 1.497021, 0.829840, 1.238801, 1.721261, 0.910544, 1.302202, 1.870338, 1.991649, 2.060901, 1.212974, 1.173248, 2.182616, 2.118314, 1.602180, 1.306086, 1.658045, 1.504564, 1.304201, 2.365347, 2.142821, 3.079959, 3.346206, 3.171094, 3.068873, 3.056233, 3.419627, 3.587020, 3.643747, 3.848168, 3.922049, 3.784072, 3.715085, 3.505747, 3.181600, 2.943679, 3.211324, 3.544220, 3.677039, 3.194171, 2.827240, 2.877030, 3.079402, 3.023228, 3.069788, 3.041858, 2.860073, 2.842243, 2.645785, 0.294889, 1.992909, 2.864676, 4.037500, 3.528616, 3.482619, 3.247070, 3.260665, 3.582856, 3.843851, 3.707170, 4.104119, 4.174091, 4.478601, 4.194349, 4.534572, 4.359643, 4.331925, 4.596985, 4.727662, 5.151349, 5.147263, 4.427851, 4.954401, 5.426408, 4.756557, 4.893369, 5.433531, 5.222180, 5.263057, -0.693259, -0.420507, 0.222410, 0.103194, 0.578757, -0.276958, -0.475058, -0.694635, -0.896165, -0.791987, -0.760640, -0.379596, -0.812975, -0.906442, -0.169662, -0.388578, -1.236953, -1.101623, -1.046406, -0.802452, -0.602535, -1.238260, -0.910565, -1.142381, -0.965496, -0.705632, -0.523932, -0.486417, -0.998985, -1.025090, 0.305483, 2.033329, 2.997928, 2.638782, 2.510968, 2.283696, 1.941298, 2.298508, 2.280866, 2.466831, 2.610322, 2.704150, 2.854116, 3.014929, 3.085503, 3.377438, 3.003392, 2.076241, 2.835251, 3.021811, 3.406727, 3.280974, 2.539865, 3.194003, 4.062691, 2.931112, 3.361681, 4.089956, 3.735620, 3.566130, 2.664408, 1.380911, 2.274191, 2.737971, 2.475670, 2.345043, 2.499490, 3.006267, 3.242290, 3.211401, 3.361927, 3.546023, 3.372934, 3.311331, 3.213661, 2.805824, 2.613637, 3.009086, 3.534021, 4.354833, 4.017923, 3.381033, 3.585160, 4.056127, 4.017574, 3.923003, 3.668933, 3.321634, 3.609709, 3.357747, 0.639645, 4.696593, 6.007059, 6.123532, 5.888656, 5.168344, 5.466221, 5.831671, 6.372064, 6.322577, 6.140077, 6.196510, 6.145229, 6.844884, 6.888237, 6.396337, 6.205670, 6.386549, 6.250912, 5.253483, 5.287374, 5.061604, 4.938144, 5.990973, 6.161627, 6.165809, 6.098857, 6.574535, 6.998386, 6.824701, -1.242824, -0.070265, -0.837620, -0.425019, -0.634245, -0.559378, -0.809575, -0.506689, -0.571878, -0.975204, -1.194444, -0.787704, 0.303430, 0.428265, 0.361705, 0.528527, 0.960775, 1.153230, -0.198460, -1.116673, -1.540949, -1.468685, -2.334562, -1.396994, -0.487836, 0.006037, -0.936939, -1.437716, -1.463904, -0.489453, 0.078094, 4.468057, 4.675652, 2.365671, 2.711124, 2.530321, 2.587450, 2.911677, 2.755346, 2.825243, 3.274435, 2.928003, 4.175859, 4.221819, 3.763055, 3.606859, 2.954394, 4.077901, 3.523583, 2.947838, 3.060030, 2.241099, 2.293453, 3.238331, 3.891346, 3.269679, 3.373641, 3.897666, 4.637228, 4.032645, 0.550618, 0.332134, 0.057458, 0.185600, -0.037355, -0.467968, -0.606480, -0.526820, -0.123921, 0.059311, 0.118989, 0.166226, 0.055040, -0.109050, -0.311813, -0.231157, -0.027669, 0.120633, 0.006780, 0.123085, 0.328959, 0.452225, 0.434063, 0.313377, 0.419409, 0.424931, 0.262132, 0.363670, 0.402467, 0.732487, 0.098437, 0.004048, -0.296327, 0.454755, 0.261758, 0.061532, 0.064832, -0.091568, -0.036368, -0.100259, 0.246570, 0.158404, -0.023814, 0.095582, -0.075475, -0.069035, -0.103893, -0.102678, -0.150239, 0.044811, 0.219446, 0.173540, -0.284489, -0.413829, -0.223386, -0.005986, -0.235084, -0.155585, -0.273815, -0.062633, 0.709071, 0.791100, 0.961525, 0.988865, 1.016915, 0.787006, 0.935888, 0.870593, 0.763012, 0.813594, 0.766700, 1.003052, 0.853647, 0.751875, 0.755726, 0.707581, 0.812491, 0.741018, 0.815623, 0.616837, 0.594806, 0.519710, 0.513977, 0.556322, 0.725142, 0.650720, 0.506725, 0.549887, 0.361807, 0.385861, -0.342193, -0.452788, -0.160159, 0.033983, 0.177257, -0.070750, 0.014368, 0.060380, -0.045814, -0.164316, 0.270738, -0.005181, -0.176443, 0.021887, -0.168798, -0.141739, -0.100180, -0.211092, -0.262454, -0.147410, -0.103333, -0.402604, -0.539313, -0.641452, -0.360213, -0.283218, -0.496026, -0.479472, -0.582389, -0.565480, 0.346163, 0.934233, 0.600015, 1.058949, 0.930004, 0.555928, 0.646329, 0.797622, 0.956862, 1.047640, 0.854851, 1.073947, 1.124656, 1.106051, 1.114246, 0.983489, 0.751813, 0.487199, 0.387306, 0.717365, 0.699949, 0.551325, 0.449339, 0.589982, 0.840461, 0.712245, 0.534243, 0.329960, 0.362328, 0.719429, 0.639880, 1.998389, 3.587621, 3.344141, 3.394974, 3.676655, 3.308210, 3.316739, 2.880671, 2.895711, 3.066478, 3.516402, 3.549625, 3.715774, 3.258010, 2.804563, 3.489617, 3.859807, 4.194913, 4.381110, 3.884270, 3.212697, 3.109563, 2.721859, 2.972463, 2.777353, 2.873254, 3.044860, 3.054271, 2.672398, -1.727288, -2.552741, -3.601120, -3.465338, -3.347323, -3.590676, -3.314198, -3.348697, -3.354430, -3.150422, -2.579316, -3.187888, -3.761764, -3.649523, -3.558564, -3.169355, -3.840394, -3.771768, -3.650174, -3.386847, -3.228547, -3.049460, -3.264919, -3.215709, -3.637070, -3.852115, -3.785183, -4.067249, -3.842089, -3.444974, 1.767381, 2.471848, 4.310630, 4.199220, 3.872319, 3.941101, 3.340090, 3.536983, 2.840743, 2.432642, 2.782078, 2.505841, 3.482677, 4.131696, 3.224715, 2.499719, 3.711653, 4.148584, 4.275697, 5.279215, 4.541658, 3.137899, 2.595784, 3.041548, 3.369097, 2.869967, 2.976930, 3.406854, 3.322284, 2.631313, 1.022189, 0.816608, 0.670911, 0.286671, -0.113524, -0.161792, -0.054146, 0.152021, 0.302797, 0.419527, 0.128921, 0.108699, 0.133401, 0.220138, 0.388672, 0.489916, 0.518436, 0.710688, 0.476179, 0.433407, 0.532482, 0.660405, 0.710800, 0.632268, 0.537559, 0.425857, 0.594536, 0.578997, 0.609746, 0.849145, -0.117765, 0.351088, -0.337874, 0.328865, 0.357656, 0.600819, 0.199036, 0.395121, 0.086065, -0.079034, -0.381466, -0.091372, -0.071739, 0.012511, -0.067994, -0.012365, 0.216067, 0.257172, -0.195277, 0.044440, -0.083350, 0.001716, -0.216176, -0.269481, -0.045265, -0.139011, 0.142990, 0.014636, 0.015256, 0.145496, 0.218892, 0.491793, 0.267953, 0.420144, 0.448487, 0.179299, -0.109728, -0.245804, 0.010424, -0.037620, -0.080682, -0.020380, -0.044427, 0.048396, 0.059281, -0.089686, -0.603373, -0.921603, -0.526148, -0.256808, -0.012907, -0.093708, -0.354460, -0.368319, -0.335558, -0.265599, -0.020691, -0.029642, -0.144697, -0.208536, -0.725221, -0.448782, -0.148834, 0.815418, 0.508937, 0.802522, 0.654237, 0.598314, 0.164615, 0.043020, -0.293673, -0.158419, -0.058501, 0.023074, -0.227144, -0.238368, -0.241103, -0.068055, -0.168679, -0.043844, -0.182916, -0.403928, -0.522649, -0.487524, -0.149029, -0.345589, -0.247186, -0.377531, -0.371990, -0.324051, 0.487670, -0.417753, -0.796924, -0.686628, -0.800154, -0.633135, -0.680516, -0.543122, -0.369745, -0.553765, -0.384599, -0.162679, -0.048172, -0.278448, -0.226905, -0.489455, -0.485903, -0.246791, -0.361278, -0.645843, -0.628947, -0.488483, -0.231539, -0.394917, -0.620572, -0.444104, -0.569863, -0.511155, -0.497897, -0.494049, -0.749417, 0.260588, 0.629913, 0.462212, 0.160961, 0.595851, 0.611195, 0.267725, 0.120277, 0.123253, 0.165492, 0.018414, 0.180929, 0.119046, -0.043404, -0.026916, 0.178065, 0.153692, 0.136120, 0.122326, 0.168717, 0.354362, 0.582273, 0.260430, 0.085772, 0.360305, -0.087013, 0.007309, 0.137602, 0.089345, 0.560266, 0.381026, -0.343169, -0.528778, -0.770180, -0.924827, -0.613967, -0.374323, -0.075946, 0.200214, 0.104279, -0.002390, 0.068380, 0.532030, 0.147066, -0.059518, 0.026123, 0.280882, 0.280813, 0.516012, 0.427022, 0.409500, 0.747812, 0.677371, 0.670853, 0.768654, 0.395251, 0.274461, 0.478813, 0.495462, -0.362052, 0.731191, 0.531103, 0.594087, 0.545092, 0.638947, 0.444100, 0.116814, 0.036567, 0.142418, 0.248972, -0.002081, 0.591506, 0.622125, -0.058461, -0.047653, 0.330691, 0.431824, 0.360841, 0.336283, 0.152283, 0.749264, 1.058015, 0.645101, 0.402055, 0.738830, 0.139683, 0.162175, 0.499355, 0.495463, -0.144501, -0.068383, 0.397656, -0.222066, -0.362494, -0.487117, -0.661379, -0.510541, -0.316391, -0.374713, -0.190884, -0.085661, 0.028804, 0.052578, 0.049051, -0.198319, -0.042974, 0.309481, 0.293896, 0.017570, -0.014762, 0.128348, 0.383700, 0.250983, 0.037220, 0.061274, 0.194814, 0.139172, 0.121235, -0.004957, -0.381349, -0.366244, -0.039768, -0.169803, 0.081148, -0.269903, -0.378817, -0.096777, -0.236958, -0.111205, -0.035868, -0.356458, -0.464795, -0.249219, -0.190418, -0.100197, -0.020534, 0.020052, -0.006600, -0.173277, -0.214097, -0.175627, -0.201007, -0.091228, -0.100681, -0.158582, -0.256717, -0.198568, -0.118547, -0.251763, -0.230384, -0.681007, -0.544066, -0.250045, -0.288826, -0.388107, -0.425337, -0.224595, 0.209202, 0.503055, 0.776211, 0.543443, -0.031171, -0.079351, 0.288853, 0.452073, 0.376596, 0.145515, 0.211286, 0.223451, 0.196438, 0.235393, 0.177128, 0.205979, 0.154179, 0.098349, -0.074599, 0.101737, -0.043466, -0.027385, -0.289060, 0.533779, -0.352803, -0.433237, -0.093053, -0.112974, -0.442867, -0.139969, -0.260069, -0.178523, 0.042584, -0.224162, -0.452573, -0.297513, -0.249042, -0.180355, -0.090866, -0.110785, -0.150914, -0.171634, -0.341219, -0.451193, -0.272487, -0.255684, -0.298327, -0.384832, -0.360132, -0.313316, -0.318114, -0.391191, 0.938104, 0.863514, 0.719921, 0.578745, 0.237409, 0.074352, 0.091619, 0.253563, 0.252462, 0.309482, 0.204532, 0.290521, 0.342923, 0.301927, 0.372510, 0.428513, 0.441280, 0.559668, 0.492575, 0.430909, 0.375021, 0.604662, 0.849281, 0.734197, 0.626939, 0.377424, 0.450103, 0.645816, 0.690478, 0.764048, -0.141071, 0.705190, -0.273696, 0.033706, 0.231630, 0.423912, 0.412254, 0.548725, 0.490882, 0.533259, 0.099914, 0.062876, 0.468215, 0.435436, 0.423654, 0.435825, 0.453725, 0.217216, -0.028299, 0.170113, -0.090353, 0.194307, 0.210149, 0.243444, 0.258222, -0.087608, -0.072644, 0.022879, 0.150707, 0.273803, -0.022446, -0.003758, -0.247385, 0.121628, 0.029969, -0.248601, -0.152714, -0.532775, -0.357319, -0.042637, -0.171232, -0.117848, -0.212632, -0.186984, -0.588259, -0.510720, -0.201648, -0.446651, -0.660430, -0.594065, -0.561128, -0.599900, -0.644089, -0.387204, -0.311165, -0.310297, -0.501923, -0.657841, -0.680057, -0.773591, -0.828772, -0.098528, -0.245393, 0.216609, 0.086554, 0.424660, 0.538228, 0.746367, 0.567261, 0.294864, -0.175980, 0.222386, 0.610720, 0.549978, 0.453328, 0.365286, 0.301651, 0.135886, 0.039015, 0.110856, -0.220790, 0.013863, -0.153542, -0.033463, -0.080539, -0.202251, -0.163478, -0.145324, -0.174051, -0.198281, -0.621984, -0.206958, -0.620681, -0.672863, -0.699998, -0.572503, -0.542972, -0.519558, -0.503286, -0.492704, -0.306964, -0.469043, -0.654530, -0.688684, -0.793829, -0.780027, -0.787052, -1.009923, -0.991259, -0.914679, -0.938162, -1.097977, -1.075131, -0.984660, -0.803530, -0.878962, -0.864990, -0.870018, -0.819722, -0.887778, 0.083309, -0.119253, -0.386039, -0.389355, -0.174038, -0.044173, -0.287877, -0.162370, -0.039106, -0.145069, -0.187740, -0.290054, -0.404780, -0.253195, -0.176276, -0.023719, -0.264556, -0.429290, -0.207527, -0.174110, -0.281466, -0.527438, -0.398556, -0.323802, -0.138705, -0.421995, -0.357962, -0.483578, -0.435606, -0.564879, 1.138299, 0.777167, 0.607107, 0.583202, 0.963960, 0.966812, 0.552118, 0.528559, 0.432568, -0.091583, 0.122408, 0.425912, 0.385167, 0.785858, 1.021662, 0.988689, 0.632834, 0.262503, 0.509162, 0.755602, 0.577229, 0.601109, 0.692841, 0.816673, 0.767094, 0.761435, 0.684846, 0.618098, 0.477416, 0.479603, 0.116571, -0.311156, -0.360151, -0.344477, -0.376054, -0.029437, -0.118193, -0.269280, 0.270103, -0.107940, -0.269302, -0.390771, -0.356509, -0.401669, -0.055976, 0.112133, -0.125669, -0.598829, -0.355040, -0.247944, -0.366228, -0.554215, -0.478038, -0.474231, -0.286745, -0.505020, -0.464224, -0.570492, -0.527551, -0.560651, -2.367034, -1.192611, -0.139285, 0.808076, 1.318164, 1.362805, 1.342416, 1.074956, 0.676653, 0.414626, 0.140734, 0.389744, 0.436058, 0.675631, 0.962247, 1.109100, 1.413063, 1.114866, 0.765874, 0.470696, 0.903424, 0.771129, 0.381425, 0.469894, 0.482932, 0.212509, 0.452697, 0.690095, 0.351275, 0.671423, -0.776141, -0.496817, 0.013481, -0.107469, -0.226888, -0.250324, -0.282171, -0.415365, -0.375236, -0.254595, -0.231512, -0.180021, -0.028897, -0.174288, -0.167382, -0.457716, -0.408016, -0.339759, -0.365948, -0.387590, 0.441594, -0.226268, -0.554781, -0.438276, -0.106845, -0.406776, -0.473433, -0.327968, -0.532563, -0.424108, 0.113524, 0.244702, 0.095055, 0.068689, -0.013147, -0.084262, 0.021560, 0.182975, 0.434495, 0.240582, -0.041936, -0.123106, 0.113495, -0.054249, -0.302829, -0.065982, -0.039265, 0.031241, 0.036448, -0.290705, -0.182558, 0.076060, 0.083606, -0.118642, -0.181693, -0.138797, 0.013316, 0.128717, 0.251048, -0.121973, -0.620481, -0.001919, -0.151144, -0.083133, -0.103094, 0.028204, -0.316358, -0.362071, -0.285680, -0.248159, -0.328958, -0.152310, -0.057035, -0.308925, -0.164247, -0.506561, -0.384848, -0.193357, -0.447910, -0.573943, 0.191352, -0.197396, -0.761594, -0.604469, -0.385572, -0.523860, -0.559045, -0.376114, -0.567115, -0.491081, -1.979386, -0.339573, -0.038073, 0.644045, 0.884620, 0.801529, 0.945553, 1.020024, 0.842128, 0.681250, 0.423466, 0.481871, 0.283526, 0.578161, 0.874550, 1.201044, 1.451016, 0.436145, 0.411257, 0.536450, 0.472913, 0.041825, -0.186401, 0.204617, 0.532105, 0.381650, 0.339148, 0.191569, 0.203079, 0.525241, -0.789742, -0.818933, -0.241963, -0.155219, -0.226524, -0.350490, -0.161208, -0.127976, -0.316444, -0.210977, -0.123404, 0.117711, -0.196664, -0.373524, -0.512831, -0.306685, 0.093395, -0.142067, -0.108503, -0.275623, 0.118242, -0.382452, -0.616798, -0.500947, -0.311438, -0.486619, -0.459221, -0.427450, -0.512114, -0.630661, 0.045399, 0.066421, -0.283750, -0.276131, -0.420505, -0.465835, -0.594903, -0.289397, -0.235537, -0.454159, -0.343395, 0.168914, 0.271910, 0.027544, 0.112986, 0.115138, -0.391466, -0.615112, -0.357205, -0.309659, -0.450336, -0.307123, -0.101302, 0.009478, -0.218673, -0.173756, -0.166396, -0.043247, -0.057231, -0.062770, -0.313267, -0.672052, -0.155728, -0.205803, -0.308659, -0.249314, 0.054338, -0.365975, -0.467172, -0.384732, -0.325338, -0.093058, -0.398822, -0.467143, -0.507398, -0.286435, 0.279675, 0.177320, 0.217437, -0.207113, -0.176820, -0.393552, -0.732422, -0.559262, -0.371475, -0.522550, -0.597767, -0.554514, -0.485153, -0.657261, 0.226743, 0.257715, 0.345160, -0.001246, -0.082908, -0.147712, -0.136853, -0.118304, -0.018791, 0.103529, 0.204468, -0.004766, -0.081673, -0.075317, -0.084687, -0.017444, -0.023271, 0.050047, 0.054226, 0.028279, 0.088226, 0.189661, 0.218325, 0.118854, 0.078732, 0.153927, 0.126277, 0.104401, 0.197998, 0.207921, 0.125701, -0.215746, 0.122649, -0.326712, -0.284682, -0.129180, 0.108904, -0.158870, -0.316912, -0.045635, 0.037281, 0.073918, -0.074279, 0.183003, -0.012413, -0.231935, -0.083545, -0.324217, -0.117529, -0.161599, -0.017037, -0.157737, -0.228870, -0.245443, -0.136749, -0.190663, -0.151921, -0.087016, -0.159442, -0.170237, 0.183064, -0.531367, -0.496816, -0.291369, 0.040549, 0.537273, 0.658752, 0.711031, 0.032446, -0.079790, -0.395712, -0.654172, -0.703941, -0.989759, -0.950602, -0.784915, -0.516286, 0.012486, 0.041243, -0.160348, -0.308104, -0.185387, -0.022732, -0.061815, -0.008401, 0.095335, -0.101810, -0.480916, -0.379148, -0.078691, -0.052605, -0.150605, 0.301686, -0.448489, -0.380088, -0.188233, 0.149129, -0.038570, -0.278489, -0.106515, 0.101229, 0.102912, 0.127601, 0.310747, 0.226147, -0.171082, -0.077379, -0.327425, -0.170551, -0.222012, -0.075500, -0.415167, -0.464643, -0.214289, -0.166880, -0.305970, -0.241451, -0.159324, -0.242837, -0.356549, -0.198514, -0.099328, 0.626445, -0.391452, -0.505030, -0.616647, -0.880503, -0.669780, -0.473357, -0.448704, -0.318916, -0.211110, 0.002973, 0.129811, 0.110621, -0.216156, -0.008355, 0.431238, 0.387159, -0.017714, -0.046913, 0.143081, 0.500458, 0.257564, -0.091057, 0.045933, 0.245013, 0.169274, 0.065283, -0.012535, -0.263415, -0.710751, -0.084604, 0.044020, 0.276508, -0.017894, -0.253131, 0.064626, -0.123232, -0.202312, -0.341054, -0.337472, -0.301001, -0.238064, -0.192087, -0.163499, -0.043643, 0.134472, 0.128045, -0.298754, -0.189764, -0.477886, -0.253002, -0.185441, -0.046022, -0.189985, -0.195298, -0.224018, -0.062012, -0.302583, -0.044381, 0.108753, 0.277651, 0.469492, 0.580493, 0.851286, 0.566181, 0.222315, 0.414571, 0.334951, 0.346581, 0.200240, 0.421364, 0.807361, 0.577327, 0.376764, 0.558868, 0.394079, 0.141298, -0.039004, -0.066043, -0.118562, 0.250029, 0.390958, 0.227394, 0.099447, 0.091295, -0.136777, -0.134887, -0.066321, -0.157641, 0.367261, -0.426524, -0.043480, 0.259527, 0.286667, -0.176163, 0.121621, -0.102878, -0.256153, -0.419472, -0.432247, -0.488596, -0.352931, -0.073002, -0.292120, -0.319661, -0.283928, -0.171132, -0.401948, -0.295723, -0.655700, -0.490680, -0.389587, -0.343808, -0.479805, -0.404174, -0.454053, -0.361378, -0.452715, 0.392977, -0.403082, 0.624879, 0.534948, 0.956539, 0.968779, 0.578123, 0.682566, 0.578871, 0.182990, -0.072666, -0.090404, -0.132827, 0.086874, 0.115842, 0.451895, 0.709687, 0.378606, 0.381012, 0.322256, 0.324612, 0.305910, 0.108930, 0.496019, 0.649155, 0.116815, 0.059691, 0.053360, -0.044135, 0.143778, -0.435192, 0.011195, 0.594514, -0.344546, -0.028012, -0.141270, -0.292186, 0.363785, 0.297734, 0.192420, -0.229045, 0.239886, 0.255097, 0.678464, 0.864166, 0.573556, 0.696078, 0.687113, 0.153568, 0.574378, 0.189477, 0.753496, 0.518252, 1.049687, 0.819926, 0.215694, -0.104958, 0.152273, 0.098542, 0.494936, -0.495396, 0.169943, 0.505380, 0.015030, 0.089965, -0.091506, -0.289693, -0.677311, -0.863198, -0.833608, -1.274062, -0.614334, -0.516234, -0.925006, -1.768685, -1.341978, -0.746656, -0.775680, -0.428216, -1.060421, -0.914841, -1.337351, -1.412111, -1.193987, -1.021685, -0.935919, -0.790983, -0.887820, -0.894249, -1.257862, -0.213813, 0.406850, 0.551682, -0.530930, -0.043239, -0.072214, -0.478259, 0.115493, 0.506750, 0.418732, -0.114285, 0.357413, 0.238722, 0.694327, 1.355951, 1.025421, 1.096418, 1.251048, 0.457189, 0.803466, 0.750361, 1.456511, 1.130438, 1.838459, 1.522841, 0.670080, 0.230747, 0.317054, 0.309468, 0.981431, 0.491766, -0.184993, -0.751569, -0.439375, -0.650381, -0.745661, -0.609980, -0.390998, -0.425810, -0.511078, -0.421324, -0.272916, -0.267802, -0.326128, -0.305216, -0.543841, -0.505495, -0.393218, -0.454231, -0.586102, -0.537963, -0.375858, -0.196277, -0.351632, -0.612179, -0.475533, -0.496117, -0.489059, -0.545302, -0.482370, -0.678796, 0.079304, 0.012016, 0.039555, -0.399837, -0.264243, -0.333565, -0.098476, -0.096093, -0.249051, -0.197828, -0.021958, -0.367994, -0.391765, -0.166998, -0.145333, 0.208228, 0.149164, -0.024799, -0.280024, -0.098404, -0.050823, 0.347228, 0.151967, -0.086106, 0.130155, 0.026626, -0.010260, 0.032667, 0.171879, 0.753025, 0.829558, 0.408763, -0.160747, -0.453863, -0.068109, 0.110681, 0.235169, 0.282038, 0.019705, 0.101019, 0.328099, 0.209760, 0.072262, 0.034458, 0.235982, 0.609140, 0.488138, 0.209903, 0.464202, 0.457189, 0.403260, 0.648947, 0.645259, 0.571348, 0.602282, 0.620169, 0.517577, 0.519721, 0.614008, -0.080459, 0.413102, 0.007021, 0.069014, -0.191921, -0.200014, -0.302133, 0.110320, 0.027489, -0.052001, -0.151184, 0.029757, -0.282233, -0.315070, -0.103796, 0.088125, 0.649961, 0.539719, 0.133472, -0.158230, 0.214470, 0.469891, 0.965633, 0.634738, 0.209013, 0.407433, 0.352609, 0.372969, 0.468580, 0.592153, 1.763115, 1.554388, 2.060801, 2.646087, 2.031332, 2.155653, 2.207031, 2.404928, 2.477823, 2.699484, 2.962832, 2.943170, 2.787304, 2.694971, 2.493963, 2.386865, 2.258842, 2.432126, 2.885199, 2.882197, 2.183414, 1.981091, 2.116572, 2.429225, 2.628077, 2.663158, 2.029175, 1.812354, 1.692202, 1.802013, 2.891921, 7.185389, 9.498261, 10.177688, 10.833721, 10.734095, 10.849492, 10.889028, 11.634687, 11.834881, 9.769278, 9.326378, 10.748430, 11.039107, 11.771504, 11.164368, 11.411944, 10.733838, 10.573971, 11.382502, 11.298091, 10.064754, 10.086751, 11.170147, 10.762632, 9.829151, 10.311579, 10.894805, 9.868690, 9.189087, -0.863666, -3.807676, -5.400042, -5.093090, -4.303706, -4.592308, -4.741914, -6.088056, -6.481115, -6.092166, -5.422561, -5.781548, -6.138991, -7.772601, -7.665044, -7.192428, -7.419830, -5.645465, -5.376562, -6.266908, -5.881071, -6.076075, -6.587203, -7.189497, -6.928466, -6.136586, -7.429506, -7.547112, -8.727883, -8.000203, 2.468981, 4.455432, 6.358686, 4.492334, 5.637950, 6.819142, 5.896942, 5.614898, 6.348356, 7.749906, 5.889536, 5.466966, 7.485247, 8.539250, 8.057117, 8.623453, 8.283811, 7.382369, 7.171910, 9.673097, 9.475513, 5.767555, 5.290718, 7.238869, 7.891654, 6.452588, 6.585951, 7.603937, 5.688953, 5.371523, 0.118334, 1.872595, 0.268512, 0.759982, 0.855784, 0.772529, 1.039121, 1.081269, 1.315622, 1.113346, 0.735093, 0.902435, 1.233629, 0.866609, 0.742610, 1.179742, 0.893323, 0.372133, 0.361059, 0.597495, 1.175780, 0.813657, 0.101531, 0.990809, 1.462755, 1.161440, 0.542813, 0.239546, 0.616368, 0.973773, -1.473488, -1.520363, -0.432268, 0.044216, -0.303865, -0.616857, -0.363309, -0.678158, 0.008002, 0.070617, -0.348119, -0.322399, -0.005280, -0.335159, -0.413912, -0.297801, -0.505779, -0.320993, -0.228637, -0.405122, -0.159329, -0.580065, -0.770287, 0.040261, -0.127154, -0.320700, -0.608972, -0.604231, -0.517197, -0.541699, 0.235520, 0.364160, 0.405314, 0.474407, 0.500054, 0.220490, 0.147189, 0.340542, 0.725471, 0.821213, 0.326805, -0.000517, 0.008368, 0.236228, 0.340849, 0.313993, 0.369061, 0.200617, 0.514350, 0.423583, 0.562457, 0.422966, 0.244601, 0.697231, 0.625833, 0.331733, 0.264258, 0.282679, 0.292873, 0.263332, -0.818463, -1.199704, -0.384059, 0.259187, 0.127269, -0.551756, -0.147547, -0.578393, -0.002658, -0.146371, -0.506742, -0.387262, 0.076175, -0.538396, -0.583574, -0.337013, -0.467158, -0.320741, -0.235664, -0.376510, -0.253247, -0.635850, -0.775920, -0.127994, -0.168269, -0.200924, -0.591644, -0.542068, -0.612171, -0.527053, -0.706563, 0.182917, -0.424855, -0.797538, -0.644314, -0.445016, -0.268436, -0.283730, -0.364692, -0.264407, -0.214654, -0.579173, -0.580148, -0.523484, -0.609658, -0.581290, -0.745265, -1.034037, -1.010495, -0.810267, -0.832452, -1.087454, -1.107901, -0.977373, -0.821931, -0.925660, -0.811635, -0.872535, -0.773322, -0.836885, -0.203654, -0.420195, -0.855347, -0.671805, -0.429956, -0.486264, -0.360622, -0.166413, -0.104876, -0.100847, -0.121677, -0.664284, -0.472060, -0.390592, -0.344666, -0.218258, -0.246626, -0.531620, -0.337210, -0.205654, -0.387412, -0.673515, -0.698526, -0.516987, -0.367866, -0.605193, -0.553779, -0.583688, -0.593960, -0.683134, -0.171681, 0.209401, 0.301545, 0.338040, 0.108205, 0.050460, 0.002967, -0.048618, 0.023493, 0.115088, 0.145376, -0.191942, -0.192653, -0.133436, -0.081266, 0.154604, 0.195091, 0.181644, 0.215002, 0.083010, 0.186454, 0.208472, -0.016771, -0.038826, -0.026406, 0.085042, 0.092971, 0.044817, -0.024551, -0.113793, -0.226165, -0.496909, -0.713828, -0.658860, -0.598415, -0.590098, -0.373085, -0.039763, 0.021095, -0.124341, -0.101288, -0.668386, -0.267869, -0.217448, -0.365762, -0.466717, -0.307252, -0.468448, -0.389976, -0.180988, -0.305255, -0.489350, -0.673153, -0.512911, -0.309239, -0.598930, -0.529831, -0.573723, -0.587411, -0.673036, 0.303529, -0.592631, 0.334670, 0.211213, 0.431176, 0.453475, 0.225583, 0.063678, 0.058788, -0.280644, -0.554101, -0.489767, -0.436444, -0.298398, -0.351444, -0.218827, 0.029319, 0.119081, 0.353524, 0.125548, -0.198571, 0.099266, 0.080153, -0.224231, -0.386468, -0.021199, -0.013589, -0.132148, -0.262728, -0.212351, 0.324787, -0.270210, -0.247383, -0.461792, -0.052915, -0.218710, -0.167702, -0.242614, -0.238463, -0.155426, -0.480981, -0.161927, -0.246169, -0.033465, 0.272939, 0.294317, 0.178004, 0.302727, 0.231578, 0.125821, -0.008169, 0.709920, 0.908919, 0.443858, 0.121764, 0.872008, 0.760290, 0.386677, 0.523684, 0.500860, 0.824342, -0.270326, -0.038384, 0.216459, -0.668662, -0.295548, 0.290790, 0.568209, 0.457939, 0.470142, 0.409244, 0.197460, 0.457849, 0.816196, 0.951688, 0.921837, 0.907629, 1.195584, 1.498808, 1.363637, 1.164272, 1.841884, 1.937204, 1.245209, 1.197437, 1.787074, 1.653082, 1.569219, 1.768102, 1.642225, 0.183837, -0.436321, -0.342057, -0.349623, 0.369608, -0.169559, -0.047036, -0.018211, -0.071814, 0.031621, -0.422465, -0.219890, -0.043780, 0.332144, 0.791535, 0.736882, 0.535715, 0.982605, 0.977111, 0.665881, 0.565456, 1.614413, 1.608002, 0.945338, 0.732917, 1.697793, 1.573810, 1.222030, 1.481126, 1.270792, 0.715352, 0.558627, 0.647387, 0.896944, 0.903715, 1.077558, 1.110577, 1.450007, 1.683493, 1.530792, 1.359003, 1.397673, 1.386618, 1.387585, 1.383752, 0.965102, 0.686015, 0.661457, 0.445286, 0.513294, 0.471935, 0.594423, 0.490764, 0.308342, 0.076327, 0.172565, 0.550719, 0.517308, 0.192685, 0.209313, 0.029837, 0.194543, -0.231262, -0.039673, 0.508725, 1.415699, 0.627291, 1.125535, 1.742221, 1.291113, 0.904438, 2.100592, 2.381285, 2.149915, 2.055396, 1.176155, 0.248639, 0.155610, 0.091633, 0.387437, 0.188498, 0.147163, -0.143539, -0.329078, -0.012678, -0.231899, -0.078109, -0.010843, -0.179312, 0.073834, 0.099417, 0.453782, 0.844772, 0.647904, 0.690273, 1.036973, 0.595033, 0.157795, 0.527001, 0.856165, 0.614093, 0.897179, 0.998218, 0.462399, 0.791632, 0.795067, 0.586736, 0.013061, 0.101079, 0.415189, -0.197385, 0.238570, -0.134501, -0.072621, -0.345979, -0.429218, -0.089797, 0.401842, 0.251896, 0.268301, 0.198847, -0.102105, 0.083554, -0.078997, 0.112437, 0.460345, 0.591744, 1.109758, 1.784822, 0.913937, 0.626133, 1.815606, 1.867071, 1.925929, 1.917666, 0.904837, 0.192799, 0.327543, 0.402802, 0.265859, 0.174164, 0.037205, -0.080984, -0.362471, -0.055482, -0.021031, 0.013669, 0.021909, -0.021708, 0.028054, -0.235268, 0.247873, -0.687478, -0.662091, -0.782498, -0.757141, -0.731241, -0.581649, -0.503096, -0.484755, -0.498679, -0.663795, -0.696574, -0.714176, -0.822691, -0.722925, -0.831586, -1.086697, -1.061718, -0.988736, -0.973554, -1.043282, -1.047741, -0.967395, -0.819772, -0.921056, -0.847194, -0.921379, -0.986735, -0.922570, -0.514437, -0.501574, -0.784486, -0.283741, -0.274233, -0.022701, -0.012071, -0.050049, 0.014849, -0.280580, -0.192178, -0.242067, -0.195292, -0.241000, -0.231511, -0.289622, -0.247886, -0.294512, -0.196775, -0.094897, -0.301839, -0.485991, -0.518121, -0.370958, -0.201809, -0.372429, -0.428392, -0.395569, -0.409600, -0.437267, -0.590485, -0.115087, -0.140444, -0.488992, -0.538002, -0.586918, -0.760026, -0.641017, -0.344653, -0.221839, -0.563344, -0.643983, -0.480899, -0.553152, -0.352834, -0.264516, -0.340905, -0.385580, -0.477319, -0.700737, -0.433233, -0.553405, -0.536011, -0.663607, -0.604977, -0.550342, -0.493025, -0.478542, -0.492005, -0.575569, -0.297039, -0.732451, -0.599527, -0.142768, -0.156687, 0.082288, 0.182889, 0.136171, 0.019801, -0.291141, -0.179135, -0.171657, -0.259587, -0.246360, -0.314038, -0.235650, -0.225332, -0.389228, -0.185940, -0.040262, -0.271067, -0.349463, -0.425847, -0.270417, -0.141767, -0.371430, -0.489840, -0.388861, -0.433729, -0.320811, -0.631781, -0.226984, -0.257094, -0.775800, -0.548664, -0.387846, -0.239148, -0.474736, -0.665557, -0.468487, -0.328118, -0.113439, -0.170549, -0.215028, -0.250049, -0.332479, -0.339504, -0.232210, -0.174628, -0.244687, -0.327307, -0.290895, -0.394011, -0.464024, -0.423564, -0.131368, -0.313283, -0.440794, -0.369205, -0.410206, 1.717403, -0.561355, -0.038898, -0.370435, -0.319204, 0.010028, 0.251824, 0.215787, 0.106733, -0.140808, 0.019470, 0.094319, -0.430678, 0.038027, 0.327665, 0.107675, 0.052994, -0.365699, -0.247162, -0.329844, -0.174082, 0.109835, 0.295891, 0.224915, 0.062021, 0.135930, 0.162934, -0.021033, 0.038311, 0.061705, -1.545155, -0.032964, 0.099783, 0.293113, 0.902290, 0.572484, -0.152240, -0.608010, -0.832911, -0.364831, -0.430801, -0.361306, -0.294334, -0.465784, -0.417688, -0.195100, -0.224034, -0.628340, -0.888954, -0.733802, -0.281172, -0.651071, -0.911906, -1.161084, -0.971263, -0.599804, -1.040364, -0.565408, -0.229099, -0.551133, 2.440451, -0.469265, 0.053722, -0.601123, -0.013074, 0.276123, 0.850373, 0.990813, 0.558436, -0.143088, 0.450106, 0.470136, -0.147553, 0.515637, 0.816131, 0.026403, 0.473910, 0.155933, 0.198012, -0.119905, 0.256158, 0.868823, 1.104674, 0.823828, 0.562478, 0.639239, 0.857326, 0.585119, 0.401851, 0.587079, -0.887325, -0.373283, -0.266633, -0.733271, -0.348113, -0.228251, -0.023545, -0.165150, -0.385114, -0.214422, -0.125535, -0.169538, -0.178793, -0.080698, -0.135341, -0.133329, -0.340478, -0.413075, -0.074251, 0.002687, -0.267197, -0.376281, -0.451159, -0.395872, -0.306717, -0.142828, -0.191818, -0.321359, -0.277371, -0.346123, 1.967030, -0.310091, 0.467625, -0.049409, -0.318495, -0.440116, -0.122373, -0.479411, -0.564295, -0.180000, -0.065844, 0.017774, 0.374420, 0.099946, 0.101620, -0.029325, -0.295817, -0.117091, -0.090411, -0.213817, -0.246175, -0.138704, 0.016328, 0.248856, -0.005366, 0.226592, 0.498846, 0.285505, 0.235656, 0.467976, 0.427485, 0.077789, 0.521585, 0.084150, 0.064011, 0.316832, 0.283263, 0.146065, 0.278752, 0.530719, 0.755335, 0.439588, 0.787223, 0.239658, -0.245207, 0.060061, 0.047533, 0.102213, 0.297215, 0.051032, 0.359721, 0.681148, 0.491733, 0.303973, 0.513959, 0.183587, 0.570190, 0.347626, 0.473364, 0.586266, 1.497585, 0.126149, 0.623317, 0.545447, -0.251801, -0.484828, 0.316805, -0.281519, -0.527693, -0.035637, 0.236939, 0.162165, 0.666800, 0.375716, 0.490632, 0.173000, -0.169205, 0.172563, -0.031362, -0.276191, 0.112421, 0.256239, 0.578759, 0.617089, 0.249813, 0.571730, 1.080176, 0.688194, 0.669012, 1.036687, 0.387954, 0.068273, -1.033775, -0.511542, -0.868277, -0.730863, -0.539720, -0.385740, -0.395063, -0.509339, -0.402754, -0.370418, -0.392367, -0.462428, -0.308825, -0.408560, -0.518361, -0.613905, -0.695828, -0.700646, -0.571835, -0.559402, -0.442622, -0.425829, -0.497091, -0.520100, -0.513813, -0.661084, -0.692464, -0.634253, -0.372060, -0.911157, -0.106507, 0.413270, -0.046272, 0.132817, -0.107799, -0.039048, 0.032080, -0.105151, 0.006696, -0.008264, -0.117017, -0.101328, -0.246458, -0.134681, 0.035766, -0.042140, -0.148781, -0.110608, 0.013657, -0.191198, 0.138198, -0.075897, -0.188738, 0.002668, 0.071685, -0.283010, -0.246630, 0.028644, 0.073906, -0.129359, 0.653446, 0.793922, 0.782475, 1.096529, 0.918144, 0.254679, 0.367940, 0.998020, 0.836693, 0.898832, 0.528938, 0.659998, 0.840381, 1.043171, 0.947598, 0.810523, 0.827525, 0.843820, 1.247575, 1.313135, 1.525893, 1.350948, 0.970915, 1.259556, 1.348475, 0.815538, 0.907238, 1.523413, -0.073066, -0.818772, 0.135256, 0.840980, 0.408408, 0.503452, -0.021253, -0.225446, -0.270759, -0.226334, -0.206917, -0.031758, -0.193885, -0.040983, -0.185062, 0.184198, 0.278394, 0.110744, 0.172718, 0.216143, 0.624453, 0.311324, 0.624417, 0.193570, 0.020799, 0.177987, 0.283327, -0.051877, -0.035218, 0.546959, -1.213278, -0.461848, 0.314684, 1.199438, 1.848641, 1.756275, 1.473943, 1.472142, 1.425010, 1.162688, 1.028794, 1.263066, 1.174297, 1.465416, 1.761606, 2.182750, 2.391674, 1.482912, 0.893722, 1.064908, 1.725096, 1.334018, 0.929477, 1.126141, 0.909705, 0.991675, 1.462867, 1.987362, 1.596091, 0.935893, -0.165542, -0.356806, -0.004977, -0.263299, -0.024561, -0.253774, -0.073569, -0.158823, -0.225269, -0.121962, -0.439100, -0.290346, -0.355171, -0.415980, -0.402051, -0.582146, -0.095142, -0.383117, -0.485662, -0.398233, 0.751797, -0.051606, -0.631313, -0.270684, -0.347762, -0.510411, -0.416931, -0.306602, -0.454315, -0.529443, -0.476414, -0.810753, -0.559255, 0.043695, -0.200388, -0.142119, 0.140387, -0.103865, -0.077353, 0.023262, 0.149565, 0.122719, -0.052891, -0.266465, -0.177362, -0.055727, 0.002546, -0.255313, -0.094776, -0.143488, -0.096464, -0.162657, -0.210161, -0.122590, -0.415696, -0.163574, -0.221424, -0.193672, -0.186958, -0.153441, 0.196340, -0.021025, 0.051743, -0.333749, 0.157701, -0.292108, 0.069865, -0.275366, -0.309980, -0.093014, -0.360878, -0.174745, -0.191496, -0.241697, -0.465307, -0.566218, -0.116398, -0.428898, -0.408421, -0.454740, 0.330700, -0.404592, -0.689303, -0.443234, -0.420920, -0.523204, -0.473037, -0.374466, -0.520591, -0.517864, -0.923683, -0.628094, -0.685127, -0.747775, -0.726408, -0.509299, -0.659785, -0.731364, -0.710248, -0.788575, -0.688370, -0.692956, -0.696637, -0.714248, -0.781484, -0.635730, -0.813783, -0.982876, -0.897981, -0.853237, -0.906711, -1.102125, -1.145451, -0.909597, -0.804035, -0.971381, -0.912454, -0.956129, -0.890680, -0.911345, 0.197033, -0.144441, -0.238357, -0.306363, -0.270426, -0.068044, 0.164327, 0.033210, -0.008446, -0.118228, -0.207107, -0.186901, -0.227704, -0.431997, -0.514951, -0.432372, -0.428475, -0.327324, -0.306810, -0.265949, -0.340479, -0.552374, -0.682209, -0.450505, -0.343343, -0.493566, -0.460386, -0.532200, -0.515029, -0.646043, -0.628526, -0.388613, -0.187116, -0.024542, 0.139813, 0.417873, 0.676307, 0.486573, 0.561357, 0.685714, 0.723930, 0.214743, 0.188383, -0.066490, -0.442162, -0.247345, -0.070411, -0.328175, -0.322555, -0.271931, -0.194878, -0.096152, -0.338182, -0.255295, -0.097725, 0.028542, -0.032724, -0.227834, -0.183489, -0.106262, -0.091152, -0.038384, -0.282054, -0.168656, -0.141571, 0.063491, 0.405485, 0.067714, 0.009337, -0.294678, -0.255780, -0.409762, -0.375180, -0.615726, -0.534880, -0.425033, -0.550384, -0.426965, -0.138188, -0.195240, -0.252308, -0.489192, -0.665390, -0.534912, -0.265964, -0.551347, -0.537485, -0.499317, -0.561104, -0.662150, 0.491192, -0.457639, 0.568328, 0.457703, 0.698136, 0.757508, 0.418958, 0.242845, 0.220244, -0.052180, -0.448373, -0.370755, -0.338477, -0.322003, -0.277922, 0.167535, 0.445534, 0.406127, 0.394424, 0.285942, 0.205885, 0.141765, 0.170322, 0.178981, 0.102504, 0.102894, 0.034492, 0.104635, 0.024607, 0.027948, -0.265215, -0.276747, 0.490782, -0.636254, -0.260449, -0.255805, -0.273432, -0.259432, -0.183162, -0.310477, -0.412145, -0.352286, -0.236140, -0.211977, 0.251816, 0.225769, 0.050137, 0.020346, -0.365668, -0.019295, -0.111127, 0.151706, 0.474001, 0.276345, -0.125806, -0.305625, -0.418861, -0.104159, -0.045456, 0.217132, -0.484017, 0.333133, 0.415943, -0.136604, 0.154570, -0.008828, -0.111391, 0.162932, 0.271727, 0.126394, -0.077356, -0.349399, -0.544336, -0.409789, -0.590690, -0.236549, -0.294515, -0.269025, -0.620617, -0.692079, -0.338993, -0.593024, -1.051044, -0.872640, -0.476193, -0.431717, -0.280130, -0.303178, -0.736122, -0.779980, -0.079631, 0.531827, 0.549499, -0.594794, -0.058967, -0.334349, -0.210056, -0.098253, -0.294609, -0.241719, -0.444569, -0.235061, -0.076136, 0.196981, 0.698517, 0.474295, 0.152200, 0.310959, -0.075980, 0.144431, 0.245257, 0.613063, 0.958165, 0.917975, 0.149480, -0.233333, -0.111329, 0.233955, 0.247584, 0.809844, 1.555342, 0.725552, 1.258997, 1.593151, 1.763468, 1.950969, 2.029118, 2.133076, 1.931023, 1.861337, 1.883247, 1.772263, 1.878197, 1.768802, 1.640048, 1.429904, 1.441195, 1.801457, 1.890041, 1.672760, 1.494866, 1.437460, 1.696156, 1.615994, 1.315366, 1.386758, 1.336131, 1.460833, 1.454333, 0.980821, 0.310089, 1.151811, 0.705680, 0.720758, 0.696055, 0.944823, 1.313275, 1.498791, 1.440716, 1.005070, 0.683911, 0.934273, 1.297497, 1.018562, 1.134636, 1.219860, 1.316497, 1.390105, 1.274443, 1.196739, 1.090137, 0.967557, 1.047229, 1.149905, 1.428156, 1.306402, 1.247593, 1.324264, 1.419843, 1.148943, 0.143392, -0.358269, -0.220489, 0.074883, -0.040104, -0.340363, -0.502093, -0.326963, 0.115358, -0.039441, -0.258105, 0.139464, -0.074257, -0.192927, -0.010533, -0.209584, -0.255373, -0.144544, 0.226293, -0.138695, -0.052161, 0.015205, 0.428109, 0.021214, -0.172385, -0.326007, -0.281979, -0.220203, -0.134586, -0.070285, -0.038941, 1.284339, 0.908290, 1.036200, 0.699140, 1.472105, 1.747828, 1.627527, 1.433173, 1.092123, 0.622132, 0.867114, 1.107242, 0.997842, 1.295618, 1.367659, 1.192102, 1.407692, 1.592076, 1.317554, 0.877385, 0.655003, 0.840771, 0.995337, 1.450350, 1.136898, 1.075344, 1.155797, 1.187664, 0.773293, -0.000529, -0.519736, -0.822730, -0.609296, -0.738903, -0.644672, -0.590239, -0.539421, -0.578728, -0.530235, -0.333617, -0.103004, -0.119169, -0.190781, -0.156323, -0.347929, -0.475218, -0.286912, -0.279075, -0.500064, -0.524944, -0.484796, -0.282981, -0.380910, -0.462999, -0.325125, -0.419969, -0.447912, -0.450562, -0.469698, 0.144251, -0.077096, 0.367200, 0.440454, 0.292532, 0.081944, 0.182192, 0.041893, 0.000454, -0.090899, -0.172044, -0.062191, -0.132677, -0.090568, 0.027309, -0.202527, 0.035290, 0.072625, 0.006051, -0.013971, 0.017375, 0.057125, 0.320406, 0.241356, 0.003213, 0.408028, 0.202484, 0.066268, 0.092897, 0.053296, -0.789463, -1.146636, -1.567216, -1.460958, -1.140096, -1.147234, -1.216941, -1.311831, -1.172011, -0.980920, -0.728230, -0.975131, -0.849017, -0.323290, -0.765438, -0.821257, -0.904847, -0.759361, -1.089098, -1.106997, -1.258576, -1.317060, -1.515145, -1.565663, -1.144782, -1.650800, -1.510943, -1.233641, -1.293125, -1.389360, 0.535460, 0.727688, 0.750517, 0.815457, 0.434145, 0.113183, 0.347388, 0.298703, 0.014940, 0.020206, -0.153405, 0.089922, 0.177275, -0.006442, 0.004851, -0.118548, 0.157030, 0.269896, 0.313279, -0.037049, 0.074043, 0.576061, 0.843202, 0.527823, 0.290523, 0.793824, 0.711879, 0.362017, 0.508661, 0.513554, 0.446387, -0.478058, 0.504167, 0.416886, 0.709854, 0.732411, 0.329062, 0.168961, 0.224765, 0.047140, -0.306071, -0.263439, -0.364707, -0.398455, -0.260659, 0.119943, 0.335087, 0.289347, 0.316560, 0.295270, 0.119109, 0.149166, 0.097490, 0.082136, 0.080625, 0.024939, 0.005884, 0.095085, -0.024617, -0.003918, -0.201357, -0.249037, 0.408630, -0.350482, -0.336560, -0.209577, -0.086704, -0.123727, -0.192766, -0.175852, -0.245156, -0.103306, -0.122883, -0.117430, 0.081333, 0.118735, 0.099842, 0.325144, 0.037229, -0.331569, -0.181448, 0.554860, 0.720577, 0.431491, 0.008279, -0.045909, -0.110342, 0.087414, 0.214439, 0.305663, 0.031004, 0.325894, 0.542616, 0.181871, 0.115591, 0.299928, 0.468959, 0.499419, 0.699112, 0.702133, 0.518351, 0.668595, 0.549681, 0.368938, 0.322121, 0.406157, 0.633913, 0.391109, 0.222841, 0.209481, 0.212068, 0.383264, 0.518099, 0.392534, 0.434359, 0.580173, 0.296422, 0.359896, 0.438729, 0.626877, -0.070996, 0.201928, 0.540597, -0.092947, -0.221207, -0.184784, -0.119912, 0.125070, 0.006493, -0.087130, -0.148676, -0.197371, -0.035782, -0.058503, 0.187992, 0.305824, 0.380018, 0.576526, 0.092524, -0.203206, 0.141620, 1.074488, 1.127917, 0.885949, 0.370409, 0.299295, 0.202323, 0.423227, 0.592483, 0.771331, 0.486898, -0.612443, -0.989300, -0.624668, -0.826514, -0.810860, -0.740011, -0.567278, -0.575593, -0.734720, -0.478411, -0.172235, -0.130711, -0.197040, -0.176015, -0.586727, -0.490281, -0.187868, -0.239931, -0.607275, -0.578776, -0.436754, -0.148741, -0.359612, -0.626987, -0.337108, -0.506298, -0.517628, -0.530169, -0.551053, -0.709299, 0.266719, 0.531802, 0.287939, -0.327533, 0.014295, -0.252519, -0.049914, 0.106182, -0.076319, -0.071068, -0.180634, -0.199741, -0.292096, -0.167487, -0.156823, -0.036363, 0.094701, 0.016709, -0.176821, -0.182085, 0.089926, 0.377856, 0.133680, 0.056789, 0.533824, 0.101244, 0.029809, 0.119621, -0.021554, -0.571039, -0.994521, -0.654467, -0.332242, -0.438283, -0.471512, -0.324224, -0.485816, -0.783813, -0.587492, -0.585889, -0.197927, -0.100044, -0.507574, -0.837020, -0.573197, -0.588175, -0.829206, -0.594419, -0.532938, -0.773779, -0.833688, -1.026437, -0.802329, -0.670598, -1.031106, -0.758862, -0.604226, -0.562201, -0.640516, -0.175473, 1.099600, 0.839095, 0.425958, -0.328063, -0.002184, -0.260223, 0.039773, 0.429965, 0.236762, 0.023879, -0.216413, -0.127813, -0.157609, -0.045201, 0.009906, 0.279769, 0.553957, 0.327006, 0.026281, 0.052924, 0.639055, 1.067431, 0.641552, 0.360601, 1.095397, 0.708780, 0.468613, 0.727395, 0.461080, 0.537602, -0.026601, -0.306278, -0.038121, -0.144921, -0.598309, -0.724020, -0.740295, -0.372979, -0.227450, -0.053019, 0.077052, -0.098804, -0.287684, -0.465704, -0.384371, -0.172962, -0.017354, -0.108134, 0.042967, 0.257708, 0.389351, 0.385026, 0.317351, 0.382012, 0.297860, 0.100523, 0.226163, 0.277298, 0.469454, -0.261049, -0.552740, -0.595461, 0.406454, 0.014924, -0.172946, -0.029868, -0.180551, -0.010536, -0.216123, 0.002106, 0.039452, -0.026080, -0.068757, -0.070213, -0.114243, -0.139075, -0.201978, -0.143703, -0.208092, 0.030442, 0.033296, -0.202465, -0.362730, -0.354933, -0.072335, -0.238765, -0.174741, -0.262070, -0.097251, -0.333655, -0.184209, -0.088382, 0.211749, -0.018838, -0.616551, -0.550338, -0.443914, -0.502558, -0.524614, -0.407961, -0.359600, -0.373553, -0.657717, -0.736727, -0.583113, -0.510155, -0.749918, -0.684145, -0.561245, -0.433203, -0.398759, -0.368778, -0.199648, -0.327242, -0.447314, -0.589057, -0.389655, -0.367756, -0.530711, -0.663051, -0.848037, -0.466476, -0.081091, -0.272516, -0.165112, 0.011525, -0.205419, -0.041340, -0.130603, -0.065369, -0.183665, -0.323827, -0.099300, -0.090484, -0.253342, -0.134420, -0.202894, -0.203376, -0.297149, -0.417345, -0.631502, -0.431137, -0.491740, -0.358810, -0.247780, -0.417839, -0.362698, -0.533950, -0.458571, -1.196774, -0.224626, -0.327690, -0.760038, -0.322683, 0.155904, 0.104925, -0.288192, -0.475298, -0.558058, -0.561976, -0.656193, -0.567449, -0.400555, -0.370919, -0.215625, -0.384990, -0.703079, -0.725870, -0.596368, -0.762298, -1.179296, -1.124611, -0.779989, -0.670638, -0.812672, -0.823565, -0.712516, -0.267671, -0.626375, -0.088142, -0.367962, -0.425823, -0.415383, -0.313976, -0.153630, -0.282632, -0.349384, -0.242436, -0.395051, -0.325486, -0.142844, -0.405896, -0.328447, -0.378167, -0.299963, -0.279999, -0.527442, -0.304790, -0.140280, -0.255458, -0.583306, -0.619871, -0.310608, -0.364473, -0.544184, -0.512725, -0.507389, -0.408607, -0.627992, -0.203571, 0.491323, 0.499646, 0.335813, 0.250521, 0.377230, 0.485390, 0.448836, 0.199304, 0.436923, 0.577323, 0.534603, 0.350559, 0.362837, 0.268056, 0.184119, 0.242602, 0.251368, 0.361516, 0.530657, 0.632522, 0.359943, 0.474792, 0.420864, 0.464479, 0.445612, 0.464403, 0.533312, 0.346314, 0.397085, -0.692494, 0.100781, -0.351913, -0.493677, -0.300577, -0.161100, -0.318292, -0.339943, -0.194009, -0.336661, -0.235606, -0.116151, -0.385874, -0.197354, -0.327237, -0.303451, -0.358452, -0.573508, -0.253073, -0.109158, -0.258327, -0.523396, -0.631808, -0.372984, -0.449233, -0.576104, -0.541812, -0.485426, -0.502400, -0.631013, 3.397889, 3.549592, 4.438359, 4.845782, 4.610807, 4.448889, 4.488988, 4.879114, 5.103302, 5.337511, 5.590627, 5.580308, 5.460842, 5.702977, 5.399039, 4.851102, 4.616404, 4.980108, 5.494929, 5.907016, 5.549479, 5.013275, 5.024436, 5.355084, 5.306503, 5.486309, 5.446691, 5.189224, 5.270364, 5.203032, 0.962553, 4.963833, 5.959716, 5.710863, 5.147831, 5.750492, 5.900321, 5.746426, 5.924988, 5.775259, 5.925680, 5.816182, 5.701476, 5.973895, 6.344875, 6.123913, 6.558921, 6.682131, 6.427922, 6.259998, 6.142890, 5.935658, 5.710708, 6.230943, 6.165350, 6.044987, 6.398564, 6.500707, 6.465827, 6.518178, 0.714953, -0.098842, -0.012113, 0.001183, 0.231166, 0.124393, 0.016600, 0.337600, 0.657228, 0.693238, 1.256895, 0.388464, -0.182180, 0.603167, 0.583901, 0.628096, 0.687464, 0.060573, 0.554744, 0.766110, 0.581495, 0.334358, 0.663306, 0.736491, 0.994071, 0.972673, 0.948838, 0.575934, 0.851235, 1.374538, -0.008358, 1.785561, 2.031471, 0.676129, 0.511104, 0.920809, 1.088800, 1.297099, 1.645742, 1.169853, 0.961817, 1.665532, 1.532032, 0.938559, 1.513230, 1.221233, 1.637078, 1.695308, 1.214811, 1.111810, 1.132165, 0.791711, 1.274241, 1.374065, 1.662095, 1.842580, 2.033376, 1.978172, 1.915258, 1.569443, 0.489209, -0.338452, 0.484022, 0.378633, 0.643079, 0.696108, 0.359195, 0.263781, 0.209927, -0.103680, -0.501481, -0.438090, -0.438605, -0.412947, -0.240704, 0.117457, 0.348587, 0.277838, 0.229738, 0.182269, 0.149846, 0.115383, 0.046199, 0.036721, 0.020949, -0.044541, -0.030611, 0.089366, -0.015316, 0.000455, -0.345334, -0.142638, 0.620526, -0.345188, -0.000150, 0.066883, -0.230410, -0.154682, -0.319543, -0.159426, -0.219363, -0.083947, -0.227439, -0.117906, 0.216438, 0.320316, -0.007948, -0.136294, -0.135766, -0.248239, -0.052723, 0.577216, 0.603179, 0.400035, 0.054451, -0.201674, -0.093138, -0.033176, 0.039513, 0.371094, 0.399203, -1.182156, -1.045923, -0.552609, -0.677116, -0.716888, -0.486842, -0.118106, -0.081353, 0.025742, -0.070985, -0.280189, -0.411422, 0.135759, 0.768679, 0.845590, 0.558502, 0.443620, 0.234746, 0.113773, 0.499032, 0.968547, 1.053891, 0.944033, 0.524557, 0.609468, 0.942215, 1.006982, 0.735036, 1.015288, -0.120581, 0.557763, 0.752505, -0.258790, 0.361936, 0.140276, -0.216606, -0.133738, -0.211288, 0.001927, -0.173491, -0.078676, -0.358541, -0.067469, 0.593412, 0.691295, 0.242122, 0.223951, 0.143972, -0.158618, 0.490482, 1.365612, 1.233560, 1.097080, 0.360436, 0.161963, 0.314000, 0.349232, 0.435828, 0.973288, 0.074307, -0.235464, 0.942962, 1.098408, 1.303445, 0.933246, 0.727832, 0.804491, 0.834039, 0.462235, 0.008085, 0.273350, 0.814786, 0.876008, 0.689238, 1.037492, 1.093353, 1.022314, 1.416041, 1.420042, 0.896072, 0.603918, 0.521064, 0.619910, 0.527920, 0.840717, 0.462896, 0.685368, 0.665753, 0.422661, 0.861013, 2.333285, 3.474675, 3.106652, 2.719913, 2.727396, 3.058447, 3.196523, 3.697694, 4.582682, 3.614878, 4.215777, 4.897794, 3.835135, 3.559675, 2.963790, 2.763584, 2.536551, 2.527378, 3.202331, 2.752445, 2.838180, 2.652515, 2.897418, 2.876232, 3.149863, 2.532349, 3.378412, 2.960544, 3.019022, -1.787710, -3.943476, -5.566169, -3.620078, -3.578444, -2.694993, -3.108484, -4.981661, -5.508992, -5.655998, -4.334789, -4.745340, -4.262712, -4.225805, -5.410653, -5.096924, -4.645939, -4.333342, -4.588173, -4.827684, -5.272441, -4.049520, -4.036887, -4.935071, -5.489041, -5.126970, -5.359874, -6.252090, -4.759222, -5.546570, 0.396619, 3.657534, 5.149666, 3.253644, 3.828011, 2.789942, 2.668165, 4.347224, 4.387821, 5.394174, 4.032485, 5.252506, 4.360878, 2.833394, 3.990200, 3.523740, 2.506624, 2.665602, 3.393857, 3.330673, 3.549391, 2.563211, 1.740172, 3.693375, 4.910666, 4.723608, 3.743037, 4.330537, 4.301515, 4.376161, 0.072380, -0.032318, 0.025022, 0.666608, 0.343396, 0.065625, 0.042418, 0.153915, 0.477266, 0.457480, 0.452209, 0.466292, 0.369608, 0.292102, 0.060053, 0.015442, 0.253124, 0.281909, 0.299778, 0.416352, 0.591753, 0.633632, 0.485901, 0.445530, 0.691878, 0.777682, 0.508683, 0.587133, 0.649055, 0.920036, 1.829104, 1.104831, 0.338266, -0.039866, 0.014313, -0.060410, 0.044432, -0.206382, -0.400780, -0.155545, 0.059343, 0.113606, 0.041803, -0.212888, -0.294296, -0.109585, -0.193574, -0.453225, -0.480627, -0.178260, 0.182849, 0.159533, -0.416453, -0.467445, -0.310949, 0.012260, -0.360945, -0.342704, -0.373214, -0.262769, 2.123785, 1.548027, 0.782038, 0.170620, 0.267993, 0.485681, 0.208436, 0.271924, 0.559860, 0.439005, 0.753981, 1.103792, 0.386699, 0.108626, 0.410722, 0.342238, 0.228583, 0.081469, 0.146601, -0.076626, -0.227903, 0.109619, 0.153836, 0.297474, 0.204628, 0.189215, 0.289043, 0.319797, 0.490040, 0.360120, 1.762337, 0.489471, 0.366108, -0.290054, 0.191034, 0.187391, 0.169937, -0.120005, -0.263436, -0.090396, 0.273055, 0.097929, -0.142849, -0.333785, -0.272493, -0.028440, -0.167539, -0.714544, -0.472236, -0.377064, -0.196115, -0.411534, -0.621180, -0.688058, -0.355218, -0.501700, -0.660292, -0.696349, -0.452731, -0.497375, 0.897812, 0.992494, 0.845088, 0.338861, 0.407617, 0.522162, 0.611445, 0.159749, -0.092714, 0.273304, 0.363417, -0.259952, -0.288712, -0.344075, -0.069969, 0.018643, -0.042597, -0.095417, -0.197543, -0.117600, -0.109623, 0.206778, 0.235074, -0.056304, -0.098317, -0.175720, 0.162936, 0.215946, 0.100983, -0.122471, -0.224018, 1.081326, -0.522981, -0.732554, -0.050815, -0.255418, -0.041486, -0.253281, -0.020988, 0.105321, -0.002538, -0.252824, -0.142379, -0.167786, 0.012000, -0.208406, -0.302910, -0.191828, -0.262100, -0.048357, 0.002118, 0.472468, 0.430972, -0.034016, 0.022354, -0.229437, 0.197553, -0.118920, -0.099861, -0.181046, 0.018397, 0.040738, -0.068760, -0.151323, -0.107678, -0.142961, -0.077234, -0.164991, -0.269707, -0.372669, -0.217898, -0.231759, -0.375640, -0.218710, -0.151481, 0.035902, -0.000600, -0.171156, -0.067059, -0.046043, -0.037856, 0.074728, -0.013716, -0.082762, -0.304824, -0.164486, -0.138754, -0.047636, -0.079607, -0.117936, -0.797327, 0.316731, -0.633911, -0.766179, -0.206368, -0.461268, -0.143694, -0.309137, -0.070715, -0.031956, -0.086902, -0.283122, -0.129398, -0.129475, -0.105614, -0.290456, -0.347933, -0.363252, -0.322818, -0.079867, -0.098518, -0.091011, -0.222251, -0.351810, -0.132182, -0.437923, -0.256900, -0.323208, -0.344973, -0.511859, 1.021213, 0.952596, 0.925323, 0.753269, 1.091377, 1.472768, 1.811672, 1.968741, 1.196007, 0.785567, 0.695658, 0.304051, 0.339255, 0.484278, 0.662130, 0.931510, 0.805109, 0.675482, 0.456055, 0.417709, 0.396678, 0.577411, 0.648680, 0.496251, 0.334340, 0.104413, 0.515431, 0.933177, 0.815662, 0.150249, -0.303572, 1.051080, 0.054268, -0.280038, 0.431251, 0.936204, 1.828906, 3.420285, 1.954854, 0.373524, 0.137089, 0.260725, 0.013765, 0.220398, 0.638311, 0.807292, 0.178148, 0.109038, -0.112600, -0.219443, 0.008298, 0.225178, 0.052518, -0.075241, -0.111695, -0.367624, -0.086853, 0.051808, 0.126166, -0.150247, -0.121914, -0.418871, 0.173613, 0.035403, 0.003628, 0.412542, 1.127180, 1.154526, 0.000933, 0.201988, 0.224010, 0.283934, 0.016363, -0.073443, 0.334709, 0.358569, 0.259218, 0.238600, 0.150779, 0.292736, 0.304957, 0.101444, 0.106414, 0.212052, 0.204774, 0.016244, 0.188971, 0.368444, 0.372567, 0.504358, -0.549516, 0.380307, -0.156598, -0.303828, 0.292987, 1.223569, 1.726775, 2.967830, 2.066923, 0.165766, 0.368878, 0.675497, 0.019706, 0.052131, 0.422606, 0.332954, 0.269619, 0.112951, -0.457487, -0.353442, 0.081363, -0.023235, -0.163271, -0.132193, -0.247704, -0.479990, -0.241911, -0.126155, -0.106502, -0.308669, -1.176934, -0.352980, -0.157789, -1.008472, -0.672158, -0.482946, -0.247267, -0.631728, -0.954796, -0.635036, -0.414519, -0.251757, -0.277133, -0.285501, -0.231744, -0.371896, -0.564470, -0.399609, -0.241169, -0.324194, -0.400523, -0.390118, -0.646388, -0.507657, -0.420723, -0.223508, -0.296384, -0.421952, -0.425890, -0.420380, 2.377834, -0.454964, -0.106901, -0.164545, -0.055171, -0.268609, -0.039028, -0.133537, -0.182210, 0.357262, 0.107868, -0.114040, -0.089694, 0.058202, -0.048496, -0.000978, -0.236636, -0.165459, 0.175931, 0.107838, -0.016365, 0.134890, 0.330476, 0.196644, 0.166487, 0.295068, 0.444476, 0.321675, 0.283448, 0.426224, -0.339828, -0.774090, -0.922186, -1.141166, -0.824718, -0.462589, -0.385063, -0.474627, -0.440059, -0.649768, -0.585791, -0.718383, -0.632470, -0.707943, -0.667165, -0.713509, -0.619047, -0.740561, -1.069033, -1.054323, -1.202929, -1.171459, -1.222882, -1.146267, -1.018524, -1.201275, -1.361296, -1.245530, -1.177773, -1.059098, 1.839123, -0.582594, -0.190090, 0.184852, -0.044867, -0.023266, 0.342584, 0.082261, -0.034896, 0.703338, 0.393374, 0.464566, 0.311607, 0.139146, 0.367038, 0.137464, -0.267941, 0.154207, 0.459481, 0.294275, 0.198525, 0.538065, 0.814541, 0.448913, 0.481299, 0.773507, 1.011813, 0.900657, 0.924492, 1.008118, 0.646830, 0.279376, 0.006375, 0.271433, -0.047261, -0.210624, -0.259645, -0.281693, -0.015073, 0.031654, -0.034906, 0.048346, 0.055606, 0.035998, 0.028282, 0.059196, 0.109730, 0.257920, 0.198792, 0.169875, 0.229692, 0.470122, 0.551135, 0.421688, 0.400937, 0.349772, 0.312086, 0.390366, 0.386443, 0.625923, 0.183161, 0.359211, -0.578911, -0.136358, -0.439848, -0.078518, -0.531002, -0.420285, -0.289181, -0.251703, -0.139939, -0.225329, -0.340497, -0.424647, -0.482194, -0.322545, 0.109772, 0.209373, -0.130638, -0.246141, -0.121010, 0.005821, 0.016809, -0.295508, -0.260942, -0.198718, -0.256867, 0.057189, -0.123898, 0.053654, -0.528439, 0.021958, 0.028415, 0.491865, 0.376573, 0.110262, 0.197008, 0.545621, 0.605392, 0.576494, 0.649567, 0.271130, 0.143578, 0.195366, 0.298732, 0.293296, 0.680965, 0.554158, 0.435108, 1.016876, 0.813919, 0.202380, 0.345865, 0.216446, 0.103522, 0.213773, 0.307518, 0.250059, 0.012532, -0.057756, -0.024556, -0.343586, -0.526372, -0.097947, -0.288609, 0.020878, -0.626654, -0.544917, -0.425497, -0.298699, 0.017826, -0.325093, -0.478065, -0.489634, -0.640743, -0.340527, 0.133942, 0.170284, -0.252679, -0.250629, -0.309432, -0.472653, -0.303481, -0.520593, -0.500094, -0.471462, -0.295829, -0.348478, -0.407793, -0.395318, -0.159809, -0.080072, 0.722333, -0.307003, -0.453644, -0.525812, -0.809061, -0.582729, -0.356556, -0.425605, -0.331997, -0.202147, 0.000989, 0.120858, 0.113678, -0.137406, 0.018466, 0.385418, 0.327603, -0.028373, -0.019221, 0.180482, 0.463983, 0.310022, -0.031020, 0.086003, 0.248054, 0.173239, 0.087650, -0.054297, -0.458033, -0.608702, 0.044319, -0.202943, -0.041390, -0.143800, -0.471855, 0.060980, -0.032011, -0.220977, -0.221492, -0.199852, -0.194838, -0.273111, -0.156589, -0.205467, -0.039216, 0.322178, 0.337695, -0.244755, -0.237876, -0.405316, -0.171140, -0.085775, -0.082259, -0.151384, -0.301275, -0.245963, -0.007517, -0.332686, -0.047546, -0.160189, -0.293780, -0.313897, -0.374438, -0.293624, -0.268534, -0.194062, -0.166281, -0.275663, -0.273459, -0.340604, -0.343403, -0.342535, -0.334350, -0.414785, -0.219932, -0.390801, -0.419583, -0.431156, -0.399751, -0.180786, -0.409244, -0.357616, -0.233281, -0.182027, -0.165569, -0.160999, -0.067697, -0.057279, -0.168320, 0.602098, -0.295699, -0.644646, -0.215866, -0.028425, -0.445082, 0.004149, -0.125083, -0.341371, -0.225463, -0.213157, -0.285880, -0.385541, -0.163461, -0.353448, -0.221216, 0.131784, 0.287061, -0.243613, -0.189424, -0.515286, -0.475541, -0.341594, -0.343143, -0.415096, -0.470234, -0.442921, -0.318302, -0.486976, 1.737745, 1.357725, 2.155549, 2.226340, 2.143996, 2.261648, 2.067314, 2.005922, 2.275588, 2.500613, 2.456238, 2.488531, 2.449442, 2.521938, 2.372918, 2.026825, 1.797482, 1.933503, 2.289710, 2.703535, 2.247573, 1.724416, 1.664881, 1.707822, 1.751969, 1.806419, 1.493789, 1.300810, 1.530165, 1.555613, 3.601683, 7.648947, 9.369097, 9.674153, 9.682509, 8.708548, 8.714645, 9.169518, 9.129262, 9.410845, 9.166351, 9.012297, 9.164173, 9.434023, 9.312615, 9.397364, 10.305891, 9.073574, 9.212234, 8.941145, 8.799200, 8.824932, 8.838339, 8.887220, 9.063530, 8.697474, 8.726074, 8.951294, 8.855911, 8.702040, -3.328556, -3.469107, -3.148439, -3.662805, -3.894759, -3.143423, -3.507949, -3.762154, -4.110547, -3.698315, -2.926630, -3.678349, -3.285029, -2.666127, -3.148893, -3.399660, -3.236747, -3.098892, -3.352899, -3.222461, -3.235300, -3.789103, -3.800235, -2.585896, -3.160793, -3.222138, -3.917065, -4.228426, -4.550951, -4.623213, 4.598493, 7.671319, 9.206695, 8.031245, 8.852020, 8.023679, 8.434401, 8.929476, 9.215975, 8.870338, 8.396126, 8.353216, 8.866545, 8.035915, 6.764575, 7.898622, 8.979155, 7.637459, 7.852986, 7.640311, 7.683687, 6.728658, 6.010339, 6.995950, 7.351118, 6.449083, 7.214753, 8.490961, 7.661620, 6.825768, 0.112307, 1.840464, 0.255568, 0.748893, 0.876536, 0.717133, 0.940854, 1.013058, 1.192632, 0.993138, 0.662695, 0.894456, 1.194447, 0.828618, 0.644566, 1.041867, 0.870387, 0.347542, 0.326372, 0.616578, 1.097927, 0.777158, 0.060807, 0.700413, 1.281332, 1.212792, 0.509670, 0.220603, 0.606409, 0.986024, -1.472836, -1.417543, -0.361890, -0.396481, -0.354690, -0.597202, -0.165731, -0.315368, -0.105237, 0.039776, -0.098362, -0.169804, 0.049138, -0.083647, -0.283249, -0.270760, -0.360670, -0.481730, -0.137370, -0.491260, -0.230691, -0.486817, -0.676075, -0.315964, -0.412082, -0.395996, -0.531222, -0.516041, -0.464866, -0.525246, 0.008087, -0.020611, 0.084695, 0.127982, 0.435099, 0.619624, 0.415814, 0.272530, -0.231346, -0.157910, 0.314848, 0.394112, 0.465085, 0.209871, 0.148290, -0.017223, -0.068284, 0.262807, -0.056699, 0.093391, -0.013791, -0.041255, 0.031824, 0.030064, 0.128342, 0.189535, 0.064339, -0.148561, -0.026119, -0.047521, -0.673486, -0.949352, -0.177564, -0.312863, -0.312520, -0.370244, -0.086223, -0.245440, -0.110005, -0.034660, -0.186578, -0.235601, -0.157612, -0.154792, -0.390888, -0.180671, -0.256905, -0.316491, -0.043443, -0.486374, -0.447704, -0.464833, -0.610622, -0.476448, -0.341506, -0.428575, -0.653248, -0.558475, -0.428091, -0.490731, 0.092608, -0.098770, -1.019538, -0.607601, -0.874565, -0.866917, -0.683091, -0.604567, -0.469147, -0.524224, -0.447685, -0.459500, -0.453488, -0.534078, -0.502961, -0.611684, -0.700581, -0.693220, -0.699740, -0.740764, -0.672489, -0.667154, -0.551895, -0.619208, -0.575960, -0.609335, -0.675261, -0.703645, -0.743364, -0.719111, -0.552374, -0.801784, -0.301230, 0.018188, -0.058434, -0.081445, -0.078480, -0.291994, -0.168029, -0.202809, -0.245520, -0.123711, -0.068176, -0.292090, -0.053799, -0.154790, -0.169679, -0.115860, -0.136085, -0.240696, -0.163008, -0.425334, -0.199228, -0.155840, -0.150551, -0.205007, -0.245977, -0.162982, -0.164031, -0.205055, 0.431022, 0.486989, 0.633966, 0.570446, 0.385543, 0.494322, 0.482461, 0.387159, 0.376709, 0.414050, 0.242936, 0.336818, 0.379926, 0.485816, 0.433827, 0.332045, 0.201792, 0.256898, 0.379206, 0.103016, 0.271718, 0.223972, 0.090828, 0.059450, 0.233454, 0.292648, 0.105519, -0.044413, 0.204615, 0.161728, -0.258776, -0.758286, 0.131724, 0.262825, 0.057966, -0.217963, -0.232179, -0.360350, -0.393250, -0.268797, -0.298928, -0.061310, 0.019616, -0.317843, -0.054939, -0.125055, -0.059172, -0.069388, -0.060432, -0.089649, 0.041395, -0.238944, -0.036108, -0.052686, -0.068377, -0.129177, -0.160772, -0.048618, 0.008729, 0.005294, 0.539000, 0.280650, -0.522127, -0.100343, -0.381395, -0.634229, -0.394827, -0.258659, -0.323559, -0.342600, -0.382237, -0.410923, -0.357915, -0.348408, -0.311920, -0.405696, -0.466850, -0.460656, -0.590351, -0.588421, -0.473696, -0.326124, -0.203712, -0.369035, -0.493075, -0.506591, -0.403044, -0.385121, -0.461001, -0.313959, -0.743486, -0.260493, -0.115778, 0.184265, -0.289475, -0.053831, -0.029246, 0.069311, 0.055757, 0.098302, 0.040786, 0.076626, 0.140765, -0.101177, -0.202340, -0.077187, 0.136172, -0.048443, -0.100793, -0.104210, 0.048402, -0.014079, 0.120856, 0.171335, -0.005337, 0.113597, 0.202585, 0.087356, 0.184633, 0.566283, 1.177943, 0.633141, 0.534053, 0.213864, 0.270206, 0.379256, 0.561157, 0.785111, 0.780706, 0.832730, 0.769380, 0.789308, 1.130568, 1.181686, 0.953623, 1.044616, 1.010741, 0.964453, 0.786317, 0.940860, 1.072123, 1.144577, 0.818606, 0.958178, 0.836224, 0.699661, 0.988298, 1.200745, 1.336785, 1.664557, 0.128932, -0.358503, -0.106471, 0.124209, -0.169159, -0.028727, 0.101842, 0.272217, 0.011826, 0.080781, 0.211766, 0.187253, 0.279097, 0.313744, 0.042360, 0.259434, 0.454357, 0.126135, 0.088700, 0.161806, 0.439962, 0.559265, 0.595068, 0.556223, 0.177713, 0.190549, 0.531384, 0.479609, 0.564201, 1.090289, 0.399208, -0.579404, -0.964163, -0.729471, -0.960486, -0.951582, -0.745195, -0.552804, -0.559501, -0.661190, -0.454182, -0.155504, -0.161713, -0.285203, -0.268453, -0.561379, -0.507193, -0.263591, -0.332110, -0.588475, -0.572963, -0.486379, -0.242564, -0.426173, -0.673797, -0.365236, -0.520864, -0.525743, -0.529718, -0.545798, -0.519047, 0.049608, 0.305663, 0.402659, -0.241118, -0.079850, -0.213819, -0.246733, -0.104242, -0.354697, -0.167001, -0.064934, -0.063213, -0.210622, 0.156320, -0.022175, 0.104591, 0.009854, 0.007920, -0.157511, -0.234267, 0.180263, 0.715033, 0.297734, 0.084534, 0.597107, 0.175354, 0.162671, 0.190409, 0.109002, 0.280770, 0.752810, 0.906253, 0.523028, 0.272823, 0.124896, -0.003513, 0.123615, 0.227735, 0.290804, 0.336005, 0.280399, 0.330456, 0.664219, 0.764442, 0.724097, 0.623755, 0.745449, 0.961757, 0.547397, 0.582801, 1.126497, 1.530050, 1.166594, 0.957319, 1.516303, 1.333427, 1.266431, 1.349134, 1.076979, -0.239135, 0.686215, 0.387084, 0.467103, -0.074308, -0.065729, -0.157821, -0.136134, 0.081276, -0.240267, 0.048008, -0.054608, -0.091938, -0.025371, 0.423160, 0.164623, 0.208494, 0.383810, 0.494799, 0.138427, 0.096480, 0.747545, 1.409261, 0.836162, 0.441581, 1.159018, 0.721161, 0.599463, 0.832385, 0.567887, 0.913521, 1.070565, 0.914584, 0.420388, 0.542207, 0.566268, 0.713485, 0.277546, -0.092449, 0.281884, 0.409008, -0.177772, -0.223830, -0.274314, -0.008250, 0.048568, -0.066503, -0.126386, -0.190283, -0.030508, -0.060800, 0.219694, 0.287541, 0.025095, -0.041241, -0.158877, 0.205450, 0.245681, 0.145933, -0.123279, -0.236631, 0.992336, -0.559624, -0.568912, -0.094179, -0.165041, -0.044395, -0.208627, -0.045143, 0.178134, 0.169023, -0.094868, 0.020835, -0.085795, -0.056996, -0.165379, -0.163109, -0.210446, -0.142280, -0.025470, -0.038350, 0.448220, 0.451151, -0.030599, -0.003616, -0.126222, 0.208068, -0.088645, -0.016364, -0.223435, -0.094005, 0.273216, 0.360090, 0.529709, 0.460777, 0.479804, 0.394341, 0.380360, 0.609926, 0.528493, 0.598901, 0.749165, 0.665543, 0.496949, 0.518744, 0.541349, 0.483554, 0.501150, 0.531335, 0.500641, 0.399606, 0.386803, 0.326788, 0.448379, 0.578824, 0.457627, 0.512830, 0.381938, 0.503684, 0.473878, -0.684594, 0.372263, -0.621784, -0.723525, -0.168737, -0.501172, -0.201406, -0.237995, -0.192752, 0.118891, 0.289484, -0.112832, 0.042874, -0.133112, -0.118001, -0.218750, -0.215226, -0.269742, -0.129570, -0.107750, -0.133433, -0.152636, -0.202862, -0.322007, -0.248931, -0.325651, -0.206484, -0.416162, -0.306955, -0.471706, -1.090644, -0.463292, -0.191902, -0.946462, -0.705943, -0.437862, -0.088719, -0.435045, -0.721259, -0.424177, -0.234466, -0.133321, -0.219382, -0.321393, -0.275344, -0.273623, -0.513099, -0.412959, -0.264141, -0.318156, -0.412112, -0.450757, -0.635818, -0.555998, -0.420597, -0.302893, -0.364837, -0.463022, -0.472187, -0.445674, 2.003139, -0.272205, 0.003702, -0.204421, -0.043932, -0.279305, -0.096150, -0.350109, -0.336332, 0.189083, 0.080762, 0.103528, 0.067087, -0.009822, -0.075644, 0.000264, -0.121061, -0.035092, -0.096174, -0.164674, -0.236678, -0.277216, -0.029294, -0.001820, -0.022803, 0.247636, 0.277514, 0.048933, 0.115859, 0.263639, -0.614821, -0.402087, -0.234583, -0.384133, -0.244023, -0.413146, -0.277558, -0.281160, -0.142171, -0.268676, -0.343214, -0.704341, -0.487972, -0.344334, -0.476766, -0.567852, -0.835593, -0.661423, -0.359809, -0.557362, -0.532604, -0.473341, -0.524992, -0.231992, -0.423359, -0.417890, -0.339189, -0.509085, -0.623291, -0.452353, 1.825163, -0.335822, 0.160695, 0.324844, -0.267648, -0.194752, 0.086465, -0.348539, -0.399586, 0.230942, 0.337811, 0.416376, 0.378920, 0.351956, 0.369736, 0.132707, 0.175821, 0.434728, 0.013700, -0.015071, 0.078105, 0.136379, 0.358380, 0.416772, 0.477915, 0.823548, 0.930968, 0.566728, 0.738685, 0.931850, -1.194687, -0.627135, -0.363960, -1.085923, -0.765057, -0.504537, -0.109889, -0.517037, -0.929376, -0.503732, -0.195748, -0.154711, -0.329300, -0.370126, -0.453888, -0.438090, -0.582488, -0.458169, -0.270196, -0.228333, -0.393869, -0.353394, -0.564788, -0.526558, -0.430190, -0.291191, -0.338641, -0.470318, -0.429993, -0.422676, 2.692808, 0.128180, 0.413142, -0.179867, 0.030691, -0.254307, 0.165631, -0.035074, -0.366827, -0.058857, -0.065639, 0.045203, 0.230942, 0.102512, -0.045285, 0.069177, 0.009102, -0.012187, -0.000328, -0.079189, -0.250463, 0.053720, 0.210577, 0.191581, 0.171031, 0.320470, 0.339824, 0.228582, 0.227568, 0.364167, 1.079087, 0.283364, 0.209737, 0.427424, 0.542952, 0.331978, 0.253689, 0.161246, 0.163047, 0.354406, 0.736901, 0.858325, 1.108908, 1.016574, 0.999539, 0.924589, 0.799517, 0.892919, 0.658718, 0.172330, 0.482645, 0.654067, 0.985487, 0.882532, 0.748035, 0.886654, 0.951773, 0.798717, 0.669894, 0.694875, 2.503021, 0.227754, 0.677906, -0.008665, -0.266766, -0.207053, 0.387433, 0.184673, -0.401985, 0.095041, 0.143224, 0.512267, 0.632790, 0.334077, 0.236109, 0.071462, 0.371097, 0.459545, 0.210871, -0.132351, -0.156486, 0.582185, 0.777612, 0.727598, 0.654228, 0.867363, 0.930395, 0.665866, 0.845388, 0.979265, 0.538105, -0.533926, 0.497810, 0.445373, 0.624360, 0.610634, 0.326109, 0.283098, 0.366132, 0.062410, -0.375046, -0.317140, -0.342340, -0.260076, -0.225214, -0.014457, 0.199237, 0.311368, 0.484444, 0.296636, -0.022034, 0.172849, 0.200656, 0.136288, 0.017872, 0.087876, 0.112127, -0.056019, -0.192667, -0.114230, -0.018623, -0.120114, 0.019228, -0.370809, -0.281499, -0.069073, -0.095816, -0.323625, -0.355017, -0.057169, -0.176246, -0.307711, 0.027161, 0.108468, 0.055415, 0.052724, -0.008548, 0.066444, 0.115542, -0.103637, -0.122748, 0.292688, 0.808690, 0.213588, 0.077708, 0.716481, 0.471265, 0.350347, 0.468251, 0.451947, 0.665578, -0.032822, 0.010403, -0.171613, -0.438275, -0.642290, -0.529296, -0.138213, -0.036373, -0.146990, -0.000580, -0.031323, -0.190277, 0.019768, 0.155303, 0.299844, 0.532862, 0.693898, 0.343791, 0.392625, 0.524900, 0.924085, 1.042487, 0.539904, 0.553777, 1.091445, 0.803998, 0.798329, 0.971874, 0.985936, 0.038594, -0.273197, -0.251906, -0.338912, 0.190757, 0.220824, -0.221788, -0.380978, -0.325117, 0.127232, -0.350205, -0.263168, 0.067793, 0.205699, 0.175088, 0.215333, 0.194863, 0.408741, 0.157001, 0.047128, 0.192001, 0.878654, 1.250989, 0.622155, 0.433858, 1.279995, 0.977217, 0.884669, 1.045541, 0.920639, 1.059319, 1.086748, 0.829781, 0.948402, 1.141599, 0.874028, 0.696022, 0.315097, 0.166726, 0.482114, 0.480806, 0.078273, 0.214658, 0.138957, 0.257281, 0.326464, 0.360656, 0.368206, 0.354080, 0.517176, 0.245086, 0.319381, 0.464963, 0.371068, 0.242654, 0.113393, 0.387318, 0.693451, 0.611363, 0.161027, -0.523168, 1.403944, -0.003157, -0.015753, 0.476547, 0.617344, 0.148816, -0.017199, 0.262979, 0.282515, 0.407975, 0.278085, -0.099495, -0.071922, 0.062728, -0.142850, 0.001851, 0.003389, 0.062155, 0.138271, 0.114369, 0.413408, 0.337431, 0.123439, 0.016766, -0.187059, 0.174660, 0.133273, 0.014002, 0.010745, -0.303185, -0.943919, -1.337229, -0.841049, -0.628014, -1.356398, -1.042497, -0.353040, -0.731081, 0.123881, 0.378150, -0.370414, -0.755665, -0.927720, -1.109153, -0.761306, -0.816971, -1.174783, -1.097684, -0.455905, -0.124715, -0.889653, -1.257653, -1.136633, -0.957282, -1.177842, -0.922771, -1.131326, -0.634884, -0.827915, -0.577758, 0.539165, 0.180823, 0.141101, 0.625730, 0.705182, 0.243589, -0.035568, 0.143793, 0.312087, 0.731766, 0.429203, -0.126503, -0.063759, 0.024407, -0.350855, 0.048033, 0.109436, -0.163719, 0.075231, -0.085352, 0.075166, 0.086194, 0.236250, -0.179582, -0.444578, -0.096426, -0.019482, -0.109227, -0.197461, 1.043301, 0.807698, 0.854365, 0.172338, -0.280106, -0.264742, -0.119300, 0.094512, 0.113419, 0.139944, -0.024902, -0.149326, -0.065476, 0.033646, 0.260535, 0.498094, 0.570381, 0.554976, 0.347599, 0.450901, 0.559936, 0.663854, 0.565931, 0.449976, 0.363592, 0.422146, 0.768336, 0.544345, 0.446496, 0.784215, 0.184200, 0.170646, 0.163182, -0.406819, -0.465285, -0.346258, -0.226384, 0.050120, -0.011170, -0.056280, -0.058538, -0.184382, -0.158766, -0.347797, -0.066597, 0.037526, 0.229345, 0.336574, -0.173439, 0.021685, -0.191996, -0.013339, -0.393249, -0.291793, -0.198234, -0.216929, 0.353395, -0.057959, -0.010091, 0.288298, -0.022481, 0.322917, -0.901896, -0.697793, -0.403985, -0.140350, -0.087364, -0.071762, -0.305195, -0.638420, -0.269647, -0.237438, -0.090827, 0.007685, -0.177441, -0.231117, -0.262481, -0.024986, 0.015934, -0.220902, -0.420801, -0.183853, 0.015425, -0.223262, -0.063395, -0.066786, -0.155795, -0.246662, -0.364144, -0.199482, -0.169386, -0.762817, 0.533588, -0.236688, -0.381414, -0.352650, -0.462395, 0.007693, 0.104128, 0.089188, -0.223184, -0.160941, -0.308996, -0.506123, -0.206975, -0.110969, -0.054547, -0.054286, -0.204690, -0.163378, -0.505324, -0.442702, -0.653003, -0.506279, -0.409135, -0.524796, -0.246507, -0.395772, -0.450278, -0.433511, -0.087365, -0.015239, -0.727813, -0.716204, -0.511815, -0.501401, -0.581133, -0.447763, -0.412966, -0.350272, -0.314658, -0.517263, -0.510601, -0.567292, -0.775192, -0.759599, -0.827215, -1.003394, -1.062191, -0.828716, -0.655410, -0.321898, -0.172491, 0.525778, 1.791901, 1.946998, 1.285637, 1.419988, 1.528515, 1.604442, -0.122843, 0.379307, -0.283060, 0.307552, 0.241875, -0.243446, -0.309157, 0.047681, -0.338993, -0.186345, -0.101378, -0.282532, -0.145083, 0.024562, -0.366690, -0.226185, -0.304093, -0.362352, -0.155912, -0.142375, -0.239245, 0.108487, 0.020907, 0.841809, 1.127187, 0.475948, 1.357183, 2.670741, 2.052330, 2.102630, 0.185243, 0.484320, 0.374658, 0.304290, 0.233995, 0.045661, -0.037981, 0.137330, -0.066742, 0.274010, 0.066691, 0.050577, -0.327121, -0.094806, 0.236985, 0.189775, 0.071414, -0.034007, 0.072631, 0.187153, -0.096701, 0.038808, -0.070837, 0.112726, -0.595456, -1.005346, -1.083903, -0.672198, -1.066597, -1.406108, -0.219171, -0.372440, -0.216406, 0.303395, 0.445996, 0.237429, -0.166383, -0.042222, -0.091947, -0.230694, -0.151695, -0.113349, 0.004079, 0.135859, -0.375817, -0.244589, -0.568251, -0.353453, -0.109631, -0.202935, -0.471687, -0.216163, -0.552658, 0.334403, 0.624046, -0.016304, 0.667213, 1.694921, 0.782766, 0.485592, -0.760585, -0.737740, -0.675114, -0.665796, -0.683999, -0.640127, -0.697615, -0.698309, -0.644421, -0.594972, -0.459960, -0.685372, -0.731418, -0.807849, -0.840951, -0.700484, -0.881902, -1.073253, -1.018646, -0.935056, -0.917071, -1.028013, -1.062785, -0.896105, -0.732093, -0.863984, -0.819110, -0.940099, -0.894010, -0.864077, 0.589998, 0.096540, 0.044331, -0.223948, -0.042278, -0.071408, 0.031270, -0.094377, -0.130680, -0.117073, 0.209087, 0.109913, -0.074973, -0.041874, -0.076306, -0.139911, -0.205134, -0.243150, -0.091930, -0.098365, -0.067911, -0.373649, -0.539136, -0.333796, -0.143051, -0.333988, -0.378872, -0.383273, -0.384622, -0.509848, -1.130187, -0.896910, -0.874931, -0.815487, -0.686330, -0.863340, -0.508542, -0.630784, -0.676270, -0.957816, -1.257401, -1.026999, -0.642785, -0.548735, -0.709096, -0.755549, -0.734156, -0.667064, -0.601227, -0.643671, -0.881735, -0.844571, -0.740623, -0.839733, -0.794054, -0.674730, -0.589419, -0.652175, -0.567030, -0.524040, 0.454274, 0.129040, 0.200281, -0.040212, 0.032488, 0.062771, 0.080357, -0.241334, -0.193727, -0.125889, 0.501046, 0.266204, 0.046016, 0.237661, -0.078734, -0.200356, -0.273023, -0.252363, -0.112605, -0.070310, 0.018247, -0.384376, -0.531449, -0.294477, -0.135307, -0.350223, -0.413226, -0.422815, -0.520632, -0.550527, 3.451391, 3.820978, 4.816291, 5.347534, 4.849709, 5.006228, 5.139127, 5.601122, 5.634669, 6.074879, 6.242809, 6.010721, 6.076398, 6.212915, 5.840426, 5.198357, 4.991253, 5.427261, 5.787693, 6.048208, 5.627197, 5.315385, 5.216614, 5.334770, 5.255203, 5.422811, 5.518939, 5.522549, 5.765001, 5.450472, -0.072166, 3.943889, 5.009687, 4.084819, 4.370114, 3.623295, 3.543396, 3.899390, 4.090218, 5.332092, 5.512327, 5.395321, 6.874728, 5.539775, 4.814162, 5.136738, 4.903348, 5.449799, 5.492641, 5.208989, 5.830717, 6.524841, 5.965222, 6.775668, 6.802362, 6.042156, 6.876073, 6.535851, 6.625149, 6.671756, -1.131969, -4.358902, -3.731606, -1.956535, -3.277599, -3.024497, -4.155395, -3.572725, -4.022905, -3.741107, -2.994979, -4.659313, -5.227172, -2.605498, -3.227516, -4.512344, -4.848868, -4.622924, -5.231193, -4.134708, -4.956503, -5.222092, -4.104934, -4.862618, -4.760288, -5.303665, -6.125093, -6.196517, -6.035272, -6.046359, 0.325963, 4.240018, 5.621937, 3.138039, 3.319407, 2.585354, 1.424107, 1.636229, 2.000769, 2.797171, 3.267827, 3.612954, 4.499428, 2.777206, 3.009655, 2.662838, 3.311096, 3.736614, 4.361479, 3.124089, 4.792629, 5.017882, 4.676394, 5.660293, 5.680531, 4.989480, 5.744223, 5.519407, 5.100046, 5.118147, -1.272756, -0.268463, -0.436330, -0.865225, -0.336039, 0.071225, 0.003715, -0.321456, -0.590966, -0.618315, -0.627296, -0.743681, -0.664015, -0.505150, -0.426397, -0.293805, -0.554037, -0.812661, -0.903542, -0.701959, -0.839377, -1.291378, -1.290098, -0.991048, -0.852470, -0.951743, -0.891183, -0.824160, -0.402478, -0.730304, 0.160053, -0.400125, -0.400450, -0.509714, -0.067339, 0.234219, -0.121998, -0.539251, -0.382752, -0.119756, -0.052546, -0.244055, -0.362177, -0.157106, -0.238792, -0.206405, -0.532697, -0.554164, -0.368861, -0.214348, -0.408867, -0.688907, -0.770453, -0.380175, -0.273354, -0.498597, -0.471739, -0.492229, -0.522630, -0.696017, 0.385600, 0.002717, 0.185080, 0.125685, -0.291887, -0.328611, -0.363431, -0.200453, 0.105548, -0.066571, 0.085167, 0.105866, -0.153285, -0.183180, 0.084711, 0.352179, 0.122342, 0.023787, 0.013093, -0.004470, 0.045679, -0.000335, -0.120379, -0.152161, -0.261658, -0.303996, -0.218707, 0.120050, 0.099087, -0.035529, -0.381087, -0.037022, -0.424959, -0.519072, 0.045307, 0.425645, 0.107474, -0.325455, -0.369201, -0.249513, -0.035113, -0.331193, -0.445743, -0.141606, -0.048300, -0.048564, -0.397593, -0.512855, -0.364376, -0.241504, -0.389097, -0.663823, -0.785764, -0.394565, -0.288033, -0.440354, -0.405368, -0.527671, -0.569360, -0.658041, 0.517162, -0.645765, 0.486273, 0.469352, 0.665681, 0.668998, 0.335688, 0.181143, 0.153162, -0.190670, -0.637037, -0.506543, -0.473565, -0.379728, -0.381330, -0.128792, 0.151666, 0.287702, 0.496194, 0.233161, -0.109030, 0.238861, 0.205163, -0.108146, -0.296113, 0.067088, 0.081465, -0.010597, -0.188199, -0.180926, -0.323552, -0.103178, -0.112271, -0.351779, -0.041675, 0.028635, 0.001318, -0.326983, -0.361841, -0.006910, -0.253482, -0.112996, -0.202778, 0.104310, 0.126733, 0.206208, 0.101015, 0.219624, 0.213234, -0.030580, -0.066976, 0.633192, 0.979045, 0.408870, 0.124004, 0.902880, 0.679976, 0.499858, 0.557523, 0.345215, -0.398802, 0.571989, 0.456475, 0.543377, 0.875329, 0.601893, 0.477052, 0.474041, 0.269593, 0.154409, 0.112935, 0.191747, 0.089172, 0.022855, 0.011180, -0.155467, -0.181396, -0.468118, -0.339882, -0.307503, -0.364684, -0.654225, -0.560283, -0.259962, -0.301909, -0.643888, -0.573932, -0.334421, -0.462217, -0.475557, -0.191015, -0.053263, -0.121943, -0.219108, 0.507701, 0.196781, -0.126727, -0.424963, -0.381866, 0.177846, -0.229156, -0.241545, -0.235749, 0.160459, 0.304577, 0.319109, 0.126943, 0.570694, 0.580581, 0.238605, 0.319019, 1.407869, 1.425480, 0.668278, 0.449754, 1.437167, 1.284177, 1.096899, 1.168796, 0.830529, 0.256218, 0.282022, 0.020168, 0.322269, 0.037594, -0.391808, -0.533875, -0.492037, -0.157097, 0.008905, 0.098928, 0.161776, -0.033512, -0.142952, -0.483601, -0.377602, -0.110593, -0.006931, -0.084858, 0.111079, 0.353446, 0.426043, 0.349704, 0.222178, 0.487533, 0.484380, 0.214584, 0.268670, 0.387492, 0.733510, 0.405574, 0.135353, -0.177950, 0.112661, -0.078470, -0.185786, 0.090977, -0.139693, -0.136716, -0.103605, 0.062362, -0.063339, 0.046891, -0.066900, -0.233302, -0.203479, -0.469014, -0.450763, -0.216366, -0.070806, 0.159124, 0.164577, -0.296098, -0.514937, -0.348064, -0.114356, -0.247454, -0.289415, -0.333738, -0.139020, -0.714971, -0.481636, -0.783192, -0.725426, -0.816494, -0.837049, -1.196733, -0.877789, -0.569388, -0.494987, -0.337689, -0.652381, -0.936495, -0.838199, -0.805721, -0.597284, -0.325340, -0.154181, -0.504757, -0.696724, -0.430253, -0.534119, -0.483905, -0.317227, -0.405805, -0.464544, -0.430716, -0.309180, -0.004844, -0.051539, 0.089096, -0.357968, 0.052189, -0.011823, 0.019534, -0.199091, 0.415570, -0.114605, -0.155675, -0.174349, 0.132262, -0.029106, -0.208457, -0.122330, -0.147286, -0.307997, -0.580232, -0.576994, -0.294991, -0.104416, -0.094861, -0.373668, -0.615104, -0.711582, -0.447103, -0.378262, -0.572100, -0.544977, -0.628586, -0.426717, 0.983103, 0.215281, 0.521076, 0.865558, 0.936353, 0.940439, 0.826154, 1.071066, 1.186915, 1.151539, 1.156176, 1.287963, 1.267110, 1.154055, 1.055919, 0.818560, 0.679250, 0.786205, 1.039658, 1.034912, 0.896854, 0.889613, 0.891355, 0.747252, 0.658657, 0.837821, 0.722759, 0.610979, 0.526221, 0.358269, 0.465224, 0.221467, 0.214355, 0.077559, -0.104544, -0.189436, 0.178844, -0.325960, -0.149588, -0.038888, -0.037443, -0.090182, -0.289003, -0.201411, -0.141753, -0.196931, -0.330023, -0.128755, -0.110251, -0.176551, -0.294360, -0.335952, -0.274636, -0.379921, -0.275585, -0.273498, -0.343692, -0.330187, -0.299473, -0.336923, -0.104404, 0.056002, 0.015164, 0.113098, 0.036172, -0.114051, -0.223097, -0.058948, 0.047628, -0.363333, -0.358544, 0.095441, 0.247260, 0.105986, -0.068716, -0.103532, -0.133752, -0.076234, -0.056566, 0.062511, -0.022984, -0.003618, -0.082205, -0.031450, 0.102290, -0.043317, -0.097593, 0.015433, 0.260443, 0.154332, 0.467104, 0.437695, 0.408403, 0.000660, -0.169190, -0.191890, 0.158954, -0.388911, -0.131045, 0.015154, -0.006937, -0.306783, -0.086139, -0.214320, -0.089323, -0.003820, -0.321223, -0.142887, -0.103045, -0.203544, -0.367357, -0.356281, -0.147050, -0.325214, -0.261109, -0.253089, -0.445383, -0.274994, -0.296995, -0.270509, -0.699617, -1.140502, -1.431219, -0.962914, -0.803636, -0.693430, -0.686257, -0.584593, -0.697796, -0.780208, -0.604177, -0.652381, -0.795985, -0.727030, -0.786913, -1.114112, -1.301290, -1.216580, -0.914870, -0.766426, -0.910850, -1.100984, -1.180037, -1.117744, -1.068942, -1.117457, -1.213566, -1.162199, -1.206870, -1.251989, -0.671552, 0.029541, 0.002632, -0.073545, -0.463060, -0.256513, -0.266008, -0.125504, -0.316429, -0.517360, -0.337131, -0.215893, -0.140832, -0.088593, -0.284780, -0.242357, -0.178698, -0.374103, -0.361076, -0.269162, -0.478900, -0.670572, -0.705870, -0.500711, -0.385670, -0.569598, -0.605281, -0.513498, -0.531846, -0.635862, -0.238951, -0.178177, 0.003599, 0.211553, 0.141832, 0.327904, 0.373608, 0.247311, 0.388286, 0.117788, -0.120795, -0.308490, -0.608511, -0.374175, -0.045210, -0.060336, -0.112506, 0.069636, -0.018039, 0.079890, 0.052675, 0.020004, 0.123381, 0.090455, 0.248724, 0.164896, 0.067916, 0.020332, 0.009972, 0.029002, -0.546204, 0.030891, -0.086566, -0.086926, -0.525055, -0.167033, -0.205908, -0.097476, -0.218256, -0.415786, -0.259782, -0.205543, -0.106432, 0.064906, -0.197327, -0.287615, -0.181500, -0.504143, -0.394385, -0.343551, -0.582314, -0.578089, -0.677750, -0.583730, -0.389027, -0.606341, -0.655398, -0.578387, -0.635478, -0.645092, 0.445443, 0.291714, 0.011765, 0.304558, -0.040175, -0.428855, -0.555256, -0.592973, -0.132428, 0.069482, 0.142756, 0.133652, -0.022400, -0.183160, -0.431415, -0.379779, -0.138807, 0.026063, -0.086969, 0.061186, 0.357449, 0.425140, 0.344767, 0.251255, 0.474566, 0.421998, 0.190593, 0.270329, 0.387204, 0.703042, 0.250420, -0.112032, -0.295608, 0.112026, -0.065110, -0.470297, -0.281069, -0.383121, -0.280593, -0.202821, 0.076101, -0.001756, -0.119965, -0.138087, -0.329436, -0.228807, -0.415252, -0.444597, -0.453693, -0.318376, 0.075689, 0.147026, -0.353329, -0.554406, -0.402458, -0.172147, -0.340000, -0.319893, -0.282988, -0.183037, 0.124969, 0.020368, 0.267666, 0.004897, -0.031978, -0.015779, -0.116296, 0.192797, 0.099483, -0.059210, -0.477696, -0.417046, 0.290085, 0.493326, 0.409893, 0.042311, 0.126561, 0.026577, -0.027103, 0.067285, 0.115565, 0.023010, -0.094417, -0.135212, 0.200916, 0.261931, 0.245470, 0.168657, -0.049854, -0.004959, -0.144345, -0.690761, -0.243703, -0.156723, -0.055782, -0.465356, -0.206706, -0.269744, -0.162922, -0.209840, 0.062928, -0.021798, -0.210583, -0.166771, -0.404113, -0.359022, -0.325761, -0.488045, -0.544518, -0.444196, -0.365934, -0.494263, -0.566849, -0.625548, -0.497177, -0.390144, -0.551498, -0.460667, -0.540829, -0.508841, -0.746643, -1.546191, -1.522292, -0.978526, -0.858104, -0.726227, -0.680655, -0.517897, -0.635099, -0.810159, -0.554225, -0.636194, -0.853070, -0.798311, -0.828235, -1.152979, -1.296123, -1.220202, -0.927707, -0.793706, -0.941075, -1.117225, -1.164345, -1.137850, -1.103410, -1.145637, -1.285958, -1.211981, -1.222978, -1.306512, 0.303043, 0.074377, 0.099510, -0.132679, -0.491384, -0.227655, -0.443128, -0.096024, -0.106185, -0.413552, -0.045187, -0.260395, -0.313245, -0.161809, -0.159212, -0.158341, -0.311924, -0.434212, -0.425294, -0.223323, -0.535829, -0.683176, -0.635605, -0.336542, -0.327415, -0.545469, -0.632156, -0.490989, -0.531677, -0.605509, 0.860703, 0.361553, 0.043006, -0.089758, -0.143228, -0.142800, -0.117491, -0.014483, -0.270415, -0.042067, 0.197071, 0.201358, 0.263758, 0.168194, -0.092619, 0.012954, -0.020936, 0.141069, 0.278542, 0.249575, 0.182024, 0.219127, 0.010684, 0.031557, 0.050447, -0.007339, 0.063054, 0.179300, 0.122026, 0.015354, 0.408623, 0.172209, -0.122789, -0.036829, -0.530856, -0.196268, -0.364871, -0.074083, -0.026408, -0.269000, 0.134697, -0.139179, -0.402046, -0.215389, -0.166166, -0.112829, -0.465473, -0.526940, -0.453085, -0.231931, -0.536211, -0.739742, -0.600027, -0.313306, -0.357028, -0.568167, -0.697068, -0.574857, -0.609773, -0.668450, -0.782934, -0.735019, -0.341107, -0.227277, -0.197040, -0.040040, -0.064691, 0.053644, 0.014348, 0.306682, 0.235117, 0.113329, 0.133324, 0.374118, 0.316927, 0.241730, 0.012507, -0.189031, -0.036671, 0.350577, 0.237705, -0.246192, -0.308412, -0.396090, -0.454984, -0.638325, -0.466848, -0.512958, -0.585983, -0.602035, 0.561064, 0.304715, 0.602307, 0.141495, 0.251631, 0.846022, 0.097472, 0.588422, 0.868402, 0.817531, 0.945757, 1.565559, 1.945866, 2.230119, 1.618064, 2.403706, 2.593346, 1.655031, 1.912038, 3.260513, 2.576989, 1.444833, 1.189677, 0.991242, 0.789233, 0.522736, 0.216930, 0.297683, 0.227137, 0.044873, 0.050784, -0.337641, 0.056633, 0.163359, 0.491325, 0.766920, 0.836057, 0.996178, 0.613295, 0.634146, 0.636121, 0.801360, 0.882396, 0.803393, 0.979129, 1.229235, 0.922387, 0.327707, 0.661778, 1.189664, 0.486362, 0.788182, 1.047010, 0.785129, 0.294365, -0.028092, 0.385655, 0.552004, 0.559690, 0.850696, 0.623713, 1.106085, 0.652984, 0.526132, 0.047938, 0.435356, -0.198363, 0.274629, 0.331662, 0.269547, 0.731541, 1.514617, 2.254539, 2.382898, 1.243495, 1.928734, 2.333584, 1.590497, 1.658548, 2.972170, 2.608837, 1.349188, 0.845786, 0.658679, 0.597870, 0.469603, 0.100581, 0.333718, 0.294984, -0.029117, 2.673991, 3.379266, 4.366727, 4.839632, 4.378551, 4.384531, 4.471253, 4.673944, 4.677826, 4.729311, 4.744547, 4.916728, 4.904242, 5.076326, 4.965342, 4.492877, 3.930695, 4.140821, 4.493054, 4.789470, 4.330629, 4.034548, 3.998331, 4.202650, 3.966637, 4.196897, 4.089837, 3.873427, 3.880834, 3.925775, 2.125661, 5.175258, 7.094382, 7.011101, 7.383492, 7.827828, 7.302991, 7.227221, 8.825351, 8.441849, 8.308287, 7.217603, 7.618040, 7.564304, 7.950377, 7.769498, 7.216638, 8.086987, 7.958137, 8.584790, 8.058537, 7.467847, 7.112690, 8.267172, 8.696350, 8.039652, 8.342997, 8.076901, 8.256441, 7.923198, -2.213588, -3.879015, -5.812055, -5.611194, -5.250801, -5.296891, -5.473480, -5.311265, -5.867942, -6.202073, -5.887856, -6.518031, -6.477655, -6.235407, -6.811269, -6.842813, -5.469737, -6.426049, -6.282161, -6.518984, -6.771368, -6.639460, -6.816611, -7.497319, -7.631585, -7.948554, -8.302259, -8.009258, -8.058431, -7.835602, 2.634315, 4.030641, 7.019542, 5.426869, 7.218780, 7.509666, 6.665208, 7.065370, 8.906931, 9.212926, 8.689642, 8.129576, 8.600819, 9.370270, 9.347662, 8.621921, 8.127905, 9.315729, 9.211187, 10.825846, 9.737343, 8.241398, 7.205713, 9.646292, 10.995920, 8.570210, 9.180056, 9.680303, 9.346315, 9.054413, 3.347674, 3.912573, 5.053290, 5.667356, 5.573291, 5.538017, 5.580781, 6.094044, 6.284859, 6.555157, 6.967435, 7.010349, 6.897377, 6.831989, 6.517082, 6.033933, 5.421262, 5.897109, 6.506613, 6.545644, 6.127470, 5.680564, 5.753578, 6.003349, 6.059360, 6.234069, 6.170454, 5.906206, 6.061143, 5.766990, 0.053371, 2.813643, 3.582815, 3.400916, 3.525176, 3.154854, 2.893083, 3.689770, 3.663325, 3.346380, 3.225935, 3.435410, 3.715586, 3.352394, 3.921200, 3.753869, 3.928668, 4.273037, 4.378649, 4.432979, 4.732899, 4.348299, 4.117836, 4.241262, 4.565666, 4.361094, 4.622095, 5.123648, 4.862222, 4.819212, 0.121051, 0.183993, -0.063837, -0.370870, -0.026225, -0.301558, -0.604130, -1.025922, -0.825493, -0.377550, -0.897318, -1.213358, -0.752882, -0.987953, -0.748459, -0.652098, -0.470113, -0.358986, -0.612186, -0.947417, -1.730254, -1.052592, -0.769565, -0.075897, -0.145512, -0.690070, -0.722695, -1.245866, -1.976719, -1.927869, 0.050252, 2.502453, 1.836825, 0.672207, 1.375153, 1.377086, 0.733129, 2.075498, 2.372251, 1.323451, 0.783756, 1.525855, 2.170842, 1.528294, 1.328094, 1.558050, 2.265190, 2.465721, 2.137926, 1.833676, 2.262194, 1.523135, 0.991699, 1.599435, 2.536584, 1.954081, 1.958798, 2.687370, 2.451859, 2.920202, -1.095877, -0.871050, -0.133154, -0.480605, -0.532778, -0.681228, -0.259875, -0.394828, -0.554106, -0.305916, -0.258825, 0.040086, 0.348937, 0.552658, 0.423978, 0.292104, -0.029350, -0.274043, -0.131675, 0.126613, -0.173727, -0.405240, -0.441111, -0.170207, -0.121642, -0.144142, -0.155926, -0.562945, -0.587731, -0.529023, 2.846916, 0.409075, -0.071070, 0.263382, -0.293249, 0.418722, 0.336855, 0.076160, -0.179178, 0.068241, 0.127399, 0.536151, 3.866609, 6.493129, 3.864973, 3.998803, 5.412641, 2.410796, 1.132861, 3.827272, 4.304527, 1.403913, 0.966853, 0.852464, 0.573663, 1.229948, 0.566343, -0.211200, -0.085930, 0.079787, -0.586079, 0.626566, 0.004694, -1.030576, -1.712281, -1.479924, -1.746221, -1.401731, -0.644518, -0.995685, -2.353167, -2.622002, -3.346524, -3.337821, -2.534939, -1.922421, -1.285762, -0.809395, -2.335545, -3.048928, -2.829159, -1.716441, -1.519810, -1.137310, -1.774031, -0.914878, -0.329022, -0.483721, -0.120899, -0.608348, 1.153866, 0.617054, 0.891056, -0.381428, -0.082435, -0.287910, 0.674047, 0.186531, -0.790359, -1.111322, -0.301311, -0.071579, 4.293384, 6.199081, 2.808952, 3.097527, 5.325829, 3.333624, 0.433424, 3.734892, 3.741245, 1.192518, 1.142426, 0.760260, 0.839417, 1.443749, 0.735385, 0.120243, 0.687597, 0.229814, -0.933971, -0.400120, -0.084510, -1.066615, -0.928622, -0.604387, -0.188421, -0.486229, -0.886904, 0.000233, -0.002602, -0.066157, -0.041907, 0.103373, -0.036999, -0.077352, -0.113354, 0.130201, 0.787336, 0.483019, 0.636134, 0.838558, 0.841996, 0.917179, 1.349295, 1.242771, 1.121356, 0.852605, 1.269343, 0.860759, 1.038270, -0.870439, -1.251671, 0.012103, 0.314700, 0.206561, 1.078913, -0.287156, 0.286222, -0.495348, -0.113188, -0.132922, -0.024702, -0.287204, 0.640013, 1.371679, 0.590076, 1.232024, 1.652109, 2.581023, 3.453166, 2.263712, 1.849650, 2.278407, 2.797384, 2.140911, 2.169041, 1.964146, 3.065510, 2.426902, -0.471631, 0.163607, 0.249442, -1.113891, 0.302220, -0.442473, -0.420392, -1.163896, -1.785993, -1.442374, -0.260122, -0.320238, -0.489950, -1.445677, -2.070511, -2.513170, -3.341074, -2.546106, -3.493745, -4.996892, -5.088943, -3.936579, -3.785517, -4.434294, -4.895509, -3.431959, -4.360613, -3.496804, -4.490111, -4.891522, 1.650627, -0.722842, -0.436911, 0.388676, -0.630370, -0.507527, 0.279457, -0.974868, 0.107353, -0.746734, -0.921420, 0.429095, -0.107107, -0.264809, 0.825570, 0.572223, -0.277992, -0.055223, -0.179613, -0.283626, 0.064013, 0.288394, 0.765560, 0.604239, -0.099073, 1.121299, 0.930874, -0.202276, 0.660563, 0.574180, 3.686949, 3.293407, 4.376549, 4.859012, 4.612810, 4.792010, 5.066377, 5.335093, 5.457416, 5.615047, 5.942646, 6.096816, 5.972850, 5.785943, 5.413231, 4.984958, 4.688672, 5.089184, 5.574755, 5.860387, 5.485633, 5.048126, 5.310893, 5.538567, 5.399389, 5.473703, 5.476891, 5.368954, 5.379228, 5.276545, 0.898774, 5.241537, 6.274994, 6.187325, 5.632493, 6.031508, 5.795864, 5.645380, 5.600751, 6.312405, 6.862749, 6.261928, 6.746883, 7.280579, 6.802136, 6.929853, 6.861088, 6.635855, 6.876475, 6.376741, 6.557039, 6.563417, 6.446280, 6.960980, 6.808170, 6.568307, 6.762756, 6.776053, 6.537199, 6.658878, -0.563385, -0.304960, 0.466422, -0.261439, -0.520482, -0.785558, -0.714499, -0.752414, -0.474352, -1.037962, -1.673306, -1.564641, -1.645519, -1.217688, -1.141953, -1.567222, -0.847895, -0.940103, -1.879750, -0.969339, -0.930737, -1.254116, -2.073329, -2.259315, -1.914364, -2.139073, -2.438643, -1.756071, -1.715010, -1.236133, 0.245170, 3.673789, 2.753973, 1.554227, 1.962978, 2.437773, 2.461473, 1.872186, 1.330028, 3.653847, 2.430587, 1.824157, 2.630089, 2.840679, 2.595339, 3.654907, 2.846830, 2.706813, 2.895580, 2.671428, 2.463775, 2.641266, 2.785494, 3.612118, 3.328946, 2.819993, 3.030940, 2.558683, 3.118791, 2.816244, -1.173364, -0.163131, -0.311701, -0.694038, -0.221451, 0.263603, 0.137375, -0.254661, -0.453215, -0.496879, -0.454737, -0.566595, -0.487954, -0.377623, -0.382593, -0.174265, -0.343688, -0.671081, -0.698097, -0.453155, -0.651002, -1.155269, -1.035048, -0.726995, -0.594464, -0.763137, -0.774466, -0.657605, -0.202513, -0.563494, -0.039828, -0.492356, -0.396208, -0.517843, -0.351005, -0.336074, -0.417375, -0.441012, -0.166554, -0.232484, -0.257785, -0.203736, -0.264230, -0.138435, -0.411422, -0.276615, -0.207250, -0.399941, -0.212111, -0.191694, -0.286195, -0.652652, -0.630376, -0.415300, -0.364971, -0.506189, -0.421303, -0.418667, -0.448792, -0.577533, 0.065907, -0.153702, -0.302088, -0.211704, -0.076708, -0.152644, -0.269581, -0.530219, -0.651821, -0.924139, -1.000937, -0.437043, -0.230892, -0.235665, -0.269968, -0.317514, -0.515303, -0.416722, -0.363301, -0.433450, -0.363170, -0.253734, -0.497587, -0.404612, -0.259021, -0.249030, -0.331596, -0.453319, -0.246759, -0.211614, -0.610588, -0.143999, -0.319547, -0.601242, -0.384664, -0.306814, -0.572252, -0.461266, 0.011896, -0.063017, -0.108301, -0.230493, -0.227487, -0.059698, -0.321120, -0.248751, -0.156698, -0.319543, -0.262291, -0.273043, -0.278297, -0.668905, -0.640440, -0.476686, -0.370262, -0.547655, -0.455284, -0.561309, -0.524926, -0.662844, 0.104415, 1.875250, 0.189471, 0.761880, 0.883893, 0.760531, 1.026805, 1.051589, 1.183933, 1.009950, 0.695984, 0.859831, 1.215620, 0.931083, 0.723267, 1.069578, 0.871580, 0.349691, 0.366790, 0.605272, 1.059819, 0.751381, 0.048656, 0.827723, 1.373284, 1.177863, 0.512534, 0.246790, 0.650710, 1.004364, -1.630057, -1.639548, -0.409499, -0.121170, -0.250500, -0.592792, -0.274898, -0.551968, -0.179888, -0.173605, -0.324929, -0.367317, 0.014790, -0.133134, -0.327889, -0.246821, -0.344480, -0.385115, -0.244947, -0.426427, -0.281725, -0.462766, -0.678515, -0.140348, -0.355504, -0.454116, -0.494830, -0.478093, -0.555855, -0.535281, 0.003712, -0.176163, -0.069354, -0.335731, -0.563877, -0.565249, -0.535813, -0.375186, -0.097430, -0.166917, -0.328942, -0.486564, -0.352913, -0.434700, -0.266819, -0.084030, -0.075931, -0.062069, -0.222367, -0.080396, -0.295482, -0.376925, -0.149498, -0.092011, -0.180282, -0.269961, -0.167242, -0.115541, -0.202760, -0.249953, -0.865287, -1.194194, -0.310847, -0.099776, -0.065572, -0.419689, -0.174724, -0.428248, -0.165032, -0.345348, -0.572743, -0.455211, 0.008663, -0.104940, -0.326080, -0.292508, -0.208290, -0.313241, -0.225978, -0.460630, -0.393977, -0.497307, -0.623689, -0.168014, -0.326731, -0.420690, -0.497422, -0.466180, -0.663479, -0.552857, 1.146142, 1.539438, 1.165965, 1.649001, 2.310916, 1.989828, 1.835731, 1.506148, 0.844339, 0.882449, 0.879342, 0.337553, 0.653367, 0.573589, 0.536012, 0.664523, 0.534038, 0.597692, 0.358280, 0.465134, 0.401708, 0.467463, 0.789518, 0.844841, 0.566204, 0.342261, 0.834708, 1.408769, 1.191365, 0.334241, -0.444111, 1.909966, -0.588337, 1.259944, 2.595673, 1.135532, 1.221380, 1.113012, 0.715787, 0.543610, 0.469610, 0.327555, 0.288933, 0.540232, 0.101930, -0.234922, -0.007722, -0.134493, -0.155583, 0.155731, -0.106039, -0.072006, -0.133695, 0.158275, -0.100985, -0.219207, 0.239429, 0.424010, 0.189165, -0.242389, -0.584779, -0.552061, -0.179062, -0.327562, -0.117299, -0.467911, -0.519598, -0.142799, 0.126509, 0.040726, 0.091389, 0.196055, 0.227446, -0.045633, -0.162146, -0.160289, 0.130381, 0.091911, 0.314347, 0.211885, -0.110791, -0.561049, -0.324346, -0.545560, 0.135484, -0.211137, -0.587565, -0.335201, -0.339106, -0.321120, -0.437619, 1.002963, -0.849141, 2.273207, 3.828583, 2.169080, 1.438955, 2.132502, 0.879474, 0.123854, 0.280464, 0.529023, 0.368542, 0.541842, 0.000146, -0.466347, 0.083453, 0.224897, 0.179787, 0.312257, 0.100689, 0.008232, -0.466967, -0.038368, -0.256024, -0.389776, 0.101195, 0.106165, 0.074008, -0.479428, 1.092597, 1.317458, 0.993661, 0.555435, 0.771470, 1.213594, 1.292013, 0.566118, 0.090590, 0.423013, 0.537737, 0.118082, 0.063002, -0.047558, 0.329653, 0.407349, 0.288679, 0.291084, 0.103568, 0.217816, 0.211475, 0.382113, 0.479554, 0.437514, 0.303489, 0.031801, 0.437621, 0.618694, 0.449615, 0.067411, -0.434644, 1.630563, -0.392796, -0.677400, 0.189965, 0.497090, 1.069149, 0.485775, 0.004656, -0.254749, -0.316396, -0.280663, 0.017977, -0.368802, -0.134734, -0.170873, -0.008120, -0.147163, -0.244046, -0.119527, -0.168889, 0.303528, 0.168700, -0.168397, -0.042171, -0.286209, 0.039288, -0.044852, 0.019540, -0.272772, -0.084558, -0.292520, -0.059188, -0.083788, -0.184568, -0.771947, -1.096954, -1.032918, -0.715537, -0.194136, 0.011917, -0.392423, -0.217047, -0.151483, -0.362286, -0.424562, -0.329386, -0.086276, -0.133984, 0.016162, -0.349695, -0.310467, -0.009804, 0.039533, -0.046869, -0.024854, -0.041357, -0.015517, 0.018662, 0.024754, -0.724945, 0.721115, -0.651439, -0.776636, -0.179306, 0.419065, 1.038188, 0.355636, 0.006661, -0.542055, -0.394553, -0.397645, -0.139737, -0.305245, -0.222699, -0.224945, 0.059741, -0.252800, -0.309247, -0.221828, -0.264390, -0.045551, -0.346434, -0.332443, -0.075653, -0.397882, -0.205146, -0.284422, -0.220125, -0.509342, 0.513950, -0.116814, -0.467432, -0.233206, -0.500973, -0.659429, -0.510624, -0.349673, -0.391325, -0.422564, -0.422901, -0.302485, -0.245563, -0.222599, -0.217177, -0.502392, -0.454996, -0.312877, -0.445608, -0.528496, -0.400337, -0.219664, -0.066635, -0.242907, -0.561250, -0.513468, -0.467878, -0.359877, -0.440196, -0.317638, -1.093748, 0.040765, 0.024546, 0.513956, -0.059346, 0.193692, -0.007347, 0.127057, 0.249116, 0.140794, -0.025198, 0.157699, -0.119772, -0.184417, -0.182322, 0.026914, 0.278486, 0.277124, 0.103935, 0.199496, 0.247116, 0.295901, 0.356167, 0.171731, 0.084513, 0.114476, 0.151527, 0.106974, 0.111113, 0.569737, -0.326267, 0.459523, 0.619222, 0.626750, 0.858252, 0.769014, 0.563307, 0.247975, 0.325332, 0.597365, 0.240784, 0.021375, 0.221843, 0.129224, 0.135920, -0.236669, -0.292548, 0.004878, 0.044497, -0.090947, -0.125032, -0.398968, -0.325446, -0.262046, 0.012565, 0.039104, -0.037846, -0.187450, -0.315993, -0.468426, -0.395275, -0.019363, 0.146001, 0.395954, 0.349125, 0.396627, 0.189318, 0.153843, 0.275335, 0.191292, 0.139274, 0.236799, -0.038218, -0.008012, -0.108734, 0.003478, 0.428583, 0.609590, 0.286367, 0.432780, 0.605081, 0.885589, 0.885161, 0.569361, 0.416022, 0.325201, 0.594554, 0.450648, 0.569994, 1.252880, -0.804572, -0.865539, -0.536360, -0.433305, -0.743133, -0.849163, -0.928692, -0.786228, -0.504148, -0.559942, -0.386674, -0.500088, -0.611731, -0.734775, -0.925393, -0.756420, -0.842940, -1.005471, -0.950358, -0.881305, -0.912900, -0.994794, -1.008501, -0.906367, -0.684614, -0.836686, -0.831794, -0.880926, -0.898602, -0.841934, 0.652451, -0.249159, -0.176662, -0.225150, -0.196873, -0.112477, 0.014646, -0.103934, -0.225492, -0.278174, 0.061668, -0.158359, -0.194870, -0.134187, -0.271789, -0.346240, -0.411852, -0.405322, -0.318934, -0.109128, -0.333357, -0.589753, -0.581119, -0.467312, -0.294890, -0.495765, -0.476513, -0.422704, -0.522399, -0.571725, 0.718102, 0.532872, 0.691284, 0.788190, 0.665813, 0.563489, 0.455896, 0.626641, 1.009192, 0.878302, 0.663401, 0.737207, 0.751308, 0.401801, 0.361449, 0.438118, 0.607035, 0.643492, 0.674360, 0.837378, 0.769137, 0.640942, 0.572191, 0.564925, 0.460190, 0.377950, 0.318023, 0.411751, 0.466177, 0.423515, 0.491253, -0.320325, -0.109923, -0.026167, -0.134508, 0.003602, 0.273605, 0.099566, 0.023103, -0.172298, 0.104934, -0.224399, -0.174133, -0.187106, -0.267565, -0.337485, -0.418154, -0.447903, -0.271983, 0.063790, -0.289889, -0.599433, -0.606328, -0.507357, -0.317714, -0.563190, -0.552320, -0.552316, -0.592049, -0.570047, 1.016405, 0.743637, 0.855981, 0.146373, -0.341451, -0.318994, -0.181380, 0.133274, 0.260194, 0.237199, 0.039078, -0.125848, -0.047068, 0.060131, 0.294172, 0.557179, 0.613576, 0.619165, 0.411553, 0.491501, 0.574062, 0.717352, 0.595888, 0.461434, 0.335685, 0.422211, 0.791119, 0.529855, 0.446069, 0.814938, 0.101540, 0.131731, 0.220729, -0.266543, -0.189908, 0.118203, -0.132757, -0.226449, -0.181822, -0.227105, -0.293510, -0.257122, -0.111926, -0.251626, -0.147173, -0.049773, 0.073606, 0.338191, -0.324067, 0.013430, -0.062028, 0.005501, -0.267578, -0.194206, -0.151457, -0.170266, 0.204393, -0.068554, -0.063518, 0.318215, 0.493973, 0.500778, 0.688387, 0.789820, 0.674389, 0.371348, 0.111759, 0.381932, 0.518075, 0.301660, 0.406638, 0.451206, 0.102167, 0.133112, 0.293786, 0.227800, 0.325975, 0.539461, 0.453440, 0.068705, 0.349356, 0.132640, -0.037757, 0.324149, 0.416316, 0.215443, 0.313079, 0.025944, 0.194632, 0.200242, -0.322194, -0.811775, 0.632858, 0.094606, -0.067945, 0.018648, -0.192631, -0.238011, -0.294015, -0.204004, -0.414254, -0.223359, -0.232489, -0.372402, -0.238352, -0.360529, -0.211059, -0.038199, -0.419998, -0.198205, -0.297662, -0.294127, -0.429194, -0.397805, -0.344575, -0.509224, -0.313443, -0.428722, -0.469684, -0.397668, -0.235606, -0.458896, 0.238217, -0.177742, -0.342054, -0.491646, -0.677667, -0.465939, -0.332685, -0.453365, -0.396824, -0.183211, 0.010511, 0.055073, 0.104807, -0.132665, 0.080452, 0.463238, 0.367546, 0.030863, 0.032441, 0.247280, 0.470937, 0.261063, -0.004363, 0.129912, 0.276918, 0.153631, 0.150540, 0.026442, -0.328672, 0.012613, 0.314792, 0.041515, 0.015951, -0.447296, -0.301818, 0.019514, -0.092946, -0.360109, 0.091439, 0.116728, -0.048567, -0.074238, -0.026790, 0.077259, 0.119304, 0.195708, 0.195221, -0.271592, -0.213709, -0.354736, -0.244526, -0.163939, 0.015984, -0.047988, -0.134162, -0.236752, -0.102867, -0.291059, 0.327218, 0.411911, 0.176346, 0.100917, 0.013156, 0.057258, 0.352103, 0.241349, 0.116213, 0.131183, 0.104517, 0.542285, 0.756893, 0.400900, 0.266912, 0.424165, 0.272836, 0.374887, 0.425190, 0.322167, 0.322816, 0.256793, 0.089288, 0.415187, 0.770456, 0.360920, 0.281389, 0.464895, 0.444396, 0.402616, -0.309746, 1.005873, -0.241780, -0.265973, -0.247513, -0.471589, -0.471870, 0.134119, -0.031250, -0.298013, 0.002886, 0.142776, -0.187724, -0.077184, -0.023080, 0.207064, 0.044329, -0.019294, -0.094306, -0.357255, -0.279935, -0.517163, -0.457570, -0.308722, -0.092369, -0.250641, -0.361026, -0.433540, -0.289813, -0.348557, -0.160260, -0.556906, -0.027631, -0.029571, -0.190967, -0.478474, -0.617334, -0.413379, -0.262439, -0.301053, -0.253474, -0.093069, 0.081160, 0.130781, 0.028585, -0.175330, 0.169173, 0.444100, 0.332894, -0.030841, -0.011983, 0.294092, 0.499822, 0.312415, 0.008345, 0.204961, 0.260772, 0.124985, 0.081706, 0.067002, -0.384012, -0.062296, -0.051704, -0.121230, -0.138046, 0.038803, -0.158694, 0.052559, -0.092080, -0.119096, -0.249846, -0.272887, -0.243918, -0.317496, -0.283471, -0.295353, 0.008152, 0.018605, -0.079778, -0.061652, -0.220212, -0.204030, -0.162407, -0.190020, -0.233240, 0.030593, -0.128107, -0.219601, -0.107329, -0.358787, 0.064804, 0.643570, 0.469790, 0.337399, 0.369927, 0.472020, 0.444605, 0.531060, 0.545108, 0.620707, 0.726593, 0.607450, 0.438062, 0.338008, 0.334291, 0.030026, -0.118317, 0.245762, 0.465693, 0.719858, 0.525298, 0.402984, 0.316747, 0.450185, 0.271128, 0.287968, 0.240796, 0.287349, 0.200393, 0.259839, -0.329612, 0.556280, -0.525558, -0.377175, -0.369016, 0.090323, -0.150339, -0.009803, -0.044293, -0.156890, -0.500234, -0.372457, -0.262839, -0.325670, -0.300357, -0.389607, -0.290830, -0.172396, -0.043507, -0.039928, -0.264698, -0.329212, -0.420850, -0.351492, -0.418671, -0.364544, -0.411111, -0.374703, -0.348096, -0.551595, -0.646089, -0.826837, -1.171391, -0.978916, -0.827305, -0.705605, -0.506266, -0.469691, -0.633397, -0.676775, -0.578401, -0.702480, -0.808049, -0.713749, -0.801961, -0.998495, -1.128102, -1.184337, -0.992653, -0.885505, -0.968303, -1.141543, -1.157252, -1.120021, -1.018356, -1.075004, -1.123608, -1.139205, -1.174992, -1.174140, -0.395620, 0.056099, 0.048704, -0.259640, -0.348041, -0.160093, -0.232973, -0.241672, -0.245381, -0.588557, -0.246271, -0.242107, -0.222992, -0.126358, -0.298492, -0.223284, -0.179384, -0.274254, -0.304034, -0.209379, -0.402792, -0.717989, -0.681978, -0.439727, -0.345843, -0.538561, -0.598144, -0.464195, -0.546378, -0.659518, 0.363612, 0.329552, -0.285564, -0.535208, -0.288508, -0.023843, 0.023991, -0.177053, -0.420145, -0.359194, -0.323111, -0.009313, 0.079880, -0.162707, -0.461567, -0.765028, -0.693461, -0.513468, -0.440226, -0.606997, -0.575638, -0.360086, 0.000436, -0.194020, -0.311242, -0.318839, -0.095374, -0.113486, -0.250016, -0.236687, -0.458312, -0.224234, -0.075909, -0.101982, -0.371359, -0.217222, -0.404971, -0.221032, -0.152795, -0.603019, -0.354104, -0.268417, -0.190008, 0.061301, -0.219909, -0.242346, -0.150967, -0.374241, -0.360302, -0.176750, -0.400172, -0.704771, -0.697964, -0.561902, -0.476564, -0.617558, -0.668344, -0.483702, -0.565592, -0.647493, 0.438989, -0.634179, 0.527448, 0.552192, 0.745277, 0.748137, 0.365035, 0.194781, 0.137090, -0.164059, -0.570265, -0.509141, -0.490317, -0.406474, -0.255254, -0.054045, 0.208734, 0.247574, 0.336199, 0.232502, 0.062489, 0.243713, 0.203953, 0.099712, -0.035533, 0.059388, 0.056846, 0.089567, -0.046028, -0.002093, -0.218143, -0.197946, 0.297764, -0.260283, -0.004098, -0.202358, -0.036045, -0.020930, 0.102979, 0.088693, 0.158312, 0.312224, -0.003244, 0.135170, 0.363840, 0.202191, 0.030988, -0.153153, 0.144381, 0.040300, -0.221299, 0.734008, 0.939449, 0.416181, 0.108899, 0.079129, 0.060784, 0.287678, 0.415594, 0.545175, -0.169708, 0.119024, 0.230916, -0.169793, -0.212769, -0.447828, -0.538609, -1.120595, -0.920256, -0.562595, -0.728595, -1.095295, -1.182591, -0.823469, -1.058894, -0.913772, -0.421175, -0.309570, -0.510150, -0.759800, -0.989675, -1.335047, -1.288278, -1.141721, -0.879041, -0.796552, -0.925857, -1.152486, -1.369788, -1.508980, 0.000054, 0.038125, 0.085948, -0.228990, 0.037682, -0.411135, -0.095427, 0.355144, 0.527382, 0.121926, 0.287000, 0.651702, -0.102627, 0.170956, 0.967181, 0.757955, 0.198362, 0.209862, 0.341985, 0.190540, 0.261941, 1.740777, 1.770572, 1.189913, 0.586930, 0.547246, 0.687971, 1.066075, 1.310848, 1.312583, 1.305036, 0.335252, 0.803676, 1.197213, 0.795716, 0.764232, 0.796263, 1.198784, 1.298411, 1.267329, 1.414083, 1.743176, 1.660589, 1.726366, 1.685762, 1.403025, 1.221402, 1.314997, 1.508431, 1.379585, 1.164199, 1.120065, 1.333669, 1.261346, 0.969153, 1.501684, 1.320451, 0.997042, 0.833581, 1.014905, 1.144313, 4.622106, 6.763659, 7.108613, 7.709239, 7.811931, 7.155352, 7.271279, 7.358474, 7.071849, 7.130618, 7.023733, 7.367287, 7.281184, 6.988950, 7.556055, 6.989568, 6.048949, 6.334798, 7.008270, 6.920938, 6.202053, 5.563319, 6.241846, 7.031332, 6.380307, 6.328672, 6.731826, 7.076489, 6.732873, -1.841002, -5.727824, -7.121427, -5.293659, -5.330349, -6.151943, -6.035656, -5.943508, -5.279760, -5.456079, -5.882020, -5.411991, -5.830434, -5.934321, -6.320174, -7.189237, -6.976115, -6.171657, -5.085593, -5.917213, -5.613502, -5.970484, -5.735721, -6.363364, -6.956728, -6.543504, -6.472920, -6.148737, -6.331615, -7.161756, 1.295631, 5.573144, 6.895394, 6.960181, 7.637659, 7.073774, 6.405292, 7.059183, 6.649230, 6.682336, 6.186888, 6.337844, 6.416282, 6.397913, 6.901602, 7.995935, 7.247184, 5.722527, 6.055745, 6.552185, 6.474686, 5.264298, 4.512714, 5.606170, 7.031442, 5.880870, 5.411535, 6.069056, 6.245736, 5.926549, 0.710496, 0.440885, 0.516672, 0.848292, 0.891696, 0.643760, 0.487018, 0.583369, 0.713594, 0.802903, 0.849906, 0.887375, 0.885142, 0.827057, 0.785958, 0.784641, 0.814676, 0.835872, 0.762376, 0.771662, 0.859132, 0.872122, 0.837107, 0.731555, 0.674405, 0.618925, 0.635727, 0.753596, 0.676697, 0.691016, 0.554034, 0.417239, -0.059318, 0.644281, 0.524099, -0.096569, -0.016336, -0.151857, -0.163664, 0.209222, 0.039200, 0.065025, -0.117315, 0.080918, 0.022832, 0.080616, -0.018624, -0.191767, -0.287308, -0.340880, -0.198021, -0.066782, -0.280125, -0.423981, -0.178583, -0.280856, -0.242120, -0.292602, -0.250813, -0.245486, -1.487765, -1.232726, -1.162683, -1.445869, -1.032253, -0.881297, -0.880687, -0.691573, -0.690716, -0.569556, -0.345322, -0.499113, -0.621261, -0.895798, -0.831052, -0.909598, -0.890387, -0.994917, -0.650320, -0.430750, -0.603292, -0.409300, -0.232985, -0.468480, -0.859344, -0.714437, -0.531360, -0.543149, -0.675531, -0.354554, 0.136692, -0.028728, 0.270214, 0.430393, 0.009324, -0.224091, -0.127574, -0.438895, -0.201352, 0.138868, -0.022886, 0.086289, -0.036519, 0.022156, 0.059794, 0.202543, 0.092074, -0.146704, -0.343723, -0.313706, -0.274713, -0.409973, -0.332037, -0.432900, -0.283341, -0.366167, -0.419861, -0.564767, -0.480121, -0.543262, 1.540536, 1.965131, 2.718460, 2.939316, 2.570121, 2.523452, 2.313575, 2.424646, 2.629478, 2.657422, 2.747817, 2.771555, 2.659518, 2.648490, 2.583015, 2.399872, 2.246707, 2.105273, 2.276708, 2.273391, 2.163729, 1.902810, 1.842561, 1.918075, 1.912174, 2.059044, 1.906351, 1.883007, 1.860954, 1.659687, 1.458587, 2.412288, 3.520141, 3.459373, 3.201086, 2.870312, 3.098631, 3.306825, 3.331034, 3.395296, 2.562073, 2.220519, 2.510628, 2.278835, 2.744374, 2.868156, 2.883535, 3.092131, 3.669475, 3.685049, 3.529497, 3.133024, 2.906521, 3.433320, 3.814759, 3.575131, 3.364264, 3.591408, 3.889003, 3.778086, 0.170873, 0.583546, 1.270240, 1.414582, 0.553050, 0.491310, 0.320713, 0.527417, 1.216051, 0.438590, 0.236338, 1.000249, 1.630455, 0.999285, 0.874387, 0.752128, 0.974937, 0.447142, 0.625524, 1.106081, 1.338117, 1.591289, 1.112567, 0.885872, 0.916143, 0.434696, 0.554691, 0.148824, 0.746241, 0.733756, 2.258227, 2.501706, 3.257982, 2.833342, 2.161563, 2.191039, 2.853747, 3.046548, 2.504264, 2.804310, 1.950123, 1.622578, 1.573532, 1.676035, 2.065490, 1.823392, 2.183370, 2.680303, 3.298395, 2.806772, 2.436606, 2.381531, 1.615213, 2.321845, 3.599376, 2.946269, 2.522917, 2.901256, 3.124069, 2.924141, 0.495724, 0.649205, 0.441478, 0.846598, 0.832722, 0.351284, 0.328416, 0.557963, 0.896471, 0.968354, 0.963573, 0.905041, 0.982746, 0.918854, 0.790002, 0.739040, 0.789628, 0.708944, 0.809783, 0.912338, 0.970048, 0.884857, 0.826116, 0.883253, 0.899116, 0.891363, 0.698408, 0.692309, 0.738179, 0.761451, 0.429271, -0.098983, -0.349118, -0.231554, -0.291895, -0.354784, -0.485378, -0.185909, -0.166754, -0.065817, -0.076009, -0.111277, -0.203214, -0.153185, -0.126334, -0.108865, -0.153889, -0.288088, -0.336729, -0.192478, -0.241491, -0.233654, -0.402151, -0.401976, -0.225390, -0.247727, -0.368865, -0.305615, -0.409719, -0.434009, 0.746390, 0.858597, 0.603449, 0.341588, 0.449009, 0.615906, 0.589704, 0.603764, 0.675489, 1.048673, 0.781186, 0.430583, 0.483938, 0.485970, 0.473689, 0.243403, 0.283786, 0.643822, 0.848308, 0.681125, 0.479220, 0.125629, 0.228475, 0.291969, 0.503694, 0.350395, 0.420304, 0.449271, 0.368344, 0.407759, 0.191225, -0.243199, -0.289439, -0.291730, -0.251799, -0.231707, -0.455425, -0.218598, -0.082205, 0.098830, -0.176656, -0.254374, -0.244346, -0.247450, -0.194593, -0.116729, -0.243976, -0.312049, -0.353698, -0.167068, -0.247775, -0.452342, -0.450787, -0.530727, -0.189314, -0.149516, -0.464005, -0.540703, -0.485914, -0.579016, 0.534920, 0.351328, 0.108558, 0.252072, -0.073543, -0.435346, -0.596680, -0.553894, -0.195012, 0.030911, 0.144435, 0.199623, 0.014867, -0.040248, -0.215564, -0.238681, -0.052718, 0.157665, 0.031259, 0.174083, 0.356285, 0.471233, 0.480695, 0.392270, 0.505604, 0.420467, 0.263073, 0.362185, 0.430768, 0.660548, 0.201522, -0.100377, -0.405391, 0.119312, -0.102515, -0.142903, -0.023493, -0.241245, 0.007526, -0.104420, -0.227909, -0.343233, -0.215766, -0.258276, -0.323467, -0.280132, -0.413912, -0.292404, -0.377854, -0.293396, -0.102219, -0.020986, -0.190416, -0.398830, -0.275065, -0.194698, -0.279798, -0.265054, -0.278980, -0.038961, 0.358096, 0.773801, 0.374726, 0.140586, 0.545174, 0.814019, 0.776120, 0.578533, 0.379214, 0.346102, 0.368653, 0.553406, 0.388265, 0.405092, 0.478199, 0.468519, 0.105532, -0.218310, -0.361163, -0.053068, 0.126245, 0.209212, 0.206330, 0.185103, 0.193675, 0.142041, 0.170404, 0.271047, 0.280062, 0.330207, 0.002266, -0.426196, -0.372361, -0.311311, -0.246322, 0.037864, 0.233072, -0.308111, 0.044439, -0.159624, -0.359251, -0.599838, -0.287384, -0.305589, -0.480916, -0.131932, -0.463174, -0.375756, -0.464706, -0.399453, -0.461332, -0.564021, -0.439573, -0.576160, -0.350149, -0.356102, -0.627765, -0.521757, -0.556057, -0.456596, -0.987831, -0.364734, -0.154836, -0.986159, -0.698132, -0.437918, -0.129946, -0.534943, -0.791885, -0.368511, -0.188246, -0.158257, -0.178416, -0.305989, -0.295778, -0.276830, -0.450455, -0.326100, -0.185727, -0.213285, -0.351575, -0.347813, -0.502384, -0.415066, -0.375804, -0.237640, -0.261370, -0.340802, -0.360718, -0.377290, 2.183023, -0.421035, -0.020837, 0.058802, 0.073786, -0.170185, 0.156418, -0.050591, -0.100900, 0.328644, 0.138070, 0.024728, 0.007659, 0.027254, -0.075828, -0.042912, -0.299735, -0.025162, 0.028756, 0.086444, 0.049746, 0.070615, 0.221508, 0.164774, 0.051746, 0.310324, 0.418575, 0.222611, 0.274044, 0.426618, -0.162261, 0.474844, 0.614318, 1.086909, 1.017273, 0.882014, 1.021661, 1.090006, 0.984257, 0.907364, 0.855162, 0.771319, 0.724409, 0.693443, 0.623746, 0.480701, 0.362865, 0.535766, 0.815946, 1.018914, 0.943450, 0.741057, 0.716481, 0.811803, 0.757014, 0.810582, 0.686166, 0.558036, 0.573443, 0.450146, 1.834633, -0.225763, 0.177180, 0.314221, -0.189438, -0.125159, 0.316802, -0.042353, 0.092178, 0.689345, 0.456336, 0.459977, 0.362559, 0.203884, 0.182195, 0.237277, -0.062263, 0.208411, 0.133602, 0.125416, 0.384696, 0.455164, 0.675491, 0.607706, 0.452092, 0.818020, 0.974808, 0.688298, 0.862493, 1.057382, 0.434410, -0.660877, 0.384857, 0.384033, 0.622082, 0.643674, 0.347623, 0.201671, 0.192773, -0.103347, -0.500903, -0.370731, -0.289467, -0.263703, -0.301969, -0.176529, 0.061039, 0.203287, 0.474557, 0.262908, -0.065479, 0.224902, 0.264842, -0.148756, -0.366367, 0.087812, 0.110411, -0.025597, -0.193544, -0.089778, -0.081239, 0.098834, 0.026964, -0.382222, -0.104638, -0.218245, -0.019777, -0.092612, -0.025006, 0.119565, -0.154127, -0.175753, -0.298659, 0.010526, 0.012081, 0.225974, -0.083407, 0.273951, 0.249716, 0.016640, -0.127550, 0.662153, 1.034371, 0.317084, 0.049907, 0.859348, 0.781196, 0.513737, 0.701265, 0.507271, -0.338717, -0.759547, -0.755950, -0.359543, 0.417638, 0.007007, -0.124069, -0.639528, -0.719302, -0.839885, -0.548875, -0.621830, -0.891471, -1.101506, -1.146790, -1.147992, -1.027233, -1.205488, -1.221724, -1.232985, -1.087928, -1.693873, -1.952923, -1.235924, -1.529048, -2.086983, -2.258104, -1.796720, -2.124296, -1.892948, -0.105102, -0.055813, -0.183352, -0.358244, 0.109734, -0.105920, 0.135173, 0.045795, 0.020824, 0.417138, -0.031010, -0.024109, 0.057408, 0.281405, 0.365350, 0.350164, 0.319598, 0.922740, 1.002945, 0.433839, 0.301373, 1.653620, 1.992320, 0.850332, 0.623922, 1.746660, 1.778707, 1.380524, 1.499605, 1.213781, 0.042658, -0.459357, -0.111852, -0.176323, -0.182270, -0.168231, -0.292672, -0.252411, -0.166728, -0.194369, -0.196993, -0.031489, 0.068338, 0.140651, 0.124272, -0.020853, 0.139822, 0.281056, 0.283742, 0.062702, 0.040748, 0.240096, 0.390890, 0.271485, 0.007137, 0.163014, 0.150775, 0.027872, -0.050028, -0.063306, 0.016719, 0.093892, 0.543766, 0.386081, 0.144869, 0.091158, -0.031626, 0.156960, 0.022888, -0.290976, -0.053197, 0.002437, -0.131453, -0.238040, -0.096345, -0.160481, 0.166668, 0.364850, 0.062889, -0.223634, -0.250817, -0.101098, -0.068652, -0.095054, -0.139239, 0.270723, 0.070102, -0.024391, 0.068237, -0.171912, 1.098773, 0.666905, 0.951083, 1.187135, 0.973956, 0.436439, 0.618665, 1.308600, 0.918850, 0.691209, 0.655181, 0.687097, 0.678550, 0.910309, 0.957222, 1.166843, 1.361858, 1.410577, 1.068662, 0.821034, 0.702029, 0.822774, 0.748630, 0.830644, 0.762934, 1.145517, 0.993336, 1.103301, 1.052862, 1.058649, 0.438315, 0.544358, -0.026917, 0.035166, 0.056209, 0.096868, 0.152091, 0.228559, 0.032487, -0.351914, -0.188692, -0.019718, -0.010487, -0.079059, 0.110022, 0.042210, 0.301485, 0.428964, 0.131967, -0.313611, -0.223540, -0.122971, -0.124819, -0.189994, -0.289230, 0.146764, 0.080910, -0.127412, -0.056349, -0.127066, -0.088458, 0.226472, -0.276835, -0.063149, -0.130288, -0.232637, -0.402088, -0.359761, -0.093956, 0.055393, 0.283257, 0.028284, -0.175276, -0.317045, -0.508749, -0.372045, -0.372179, -0.477981, -0.544337, -0.473109, -0.369884, -0.286163, -0.032678, -0.016112, 1.582692, 2.379801, 2.492249, 2.377708, 2.710968, 2.731152, 0.206802, 0.017580, -0.252013, -0.250016, -0.283958, 0.059948, -0.052693, -0.063105, -0.299888, -0.236873, 0.470221, -0.134884, -0.434708, -0.079383, -0.177732, -0.291804, 0.035937, -0.335713, -0.102445, -0.331487, -0.382671, -0.152115, 0.136865, 0.144995, 1.646632, 3.267759, 2.970749, 3.307067, 3.720662, 3.849495, -0.087329, -0.595685, 0.435748, 0.597628, 0.237728, 0.349952, 0.134390, 0.011903, -0.587685, -0.268807, -0.029034, 0.011836, -0.444790, -0.103229, -0.354803, 0.178113, 0.377619, 0.375622, -0.197764, 0.425950, 0.526921, 0.614360, 0.438226, -0.364082, 1.679125, 2.451846, 2.600658, 2.211492, 2.616789, 2.398575, 0.337918, -0.396709, -0.205032, -0.526984, -0.045391, 0.223189, 0.084904, -0.132016, -0.059040, -0.175508, 1.214207, 0.624505, -0.844070, -0.526642, -0.046479, -0.298637, 0.088590, -0.003133, -0.173279, -0.649932, -0.613445, -0.517513, 0.148571, -0.128134, 1.143554, 1.596098, 1.828585, 2.728082, 2.293295, 2.206123, -0.863131, -0.202199, -0.590870, -0.774991, -0.395594, 0.536266, 0.652100, -0.045854, -0.084939, 0.162236, 0.007934, -0.260448, -0.291873, -0.347618, -0.405708, -0.259958, -0.397725, -0.684354, -0.587561, -0.379638, -0.449312, -0.798103, -0.743864, -0.614152, -0.542184, -0.738236, -0.611609, -0.619544, -0.525223, -0.711712, 0.023270, -0.082317, -0.146183, -0.138932, -0.079656, 1.639530, 1.455788, -0.294386, 0.110927, 0.051603, -0.466508, -0.257765, 0.256440, -0.063490, 0.256060, -0.180579, -0.557592, -0.447157, -0.141989, 0.245916, 0.173532, -0.339049, -0.325771, -0.157406, -0.236249, -0.400905, -0.505932, -0.384590, -0.471538, -0.654104, 0.309215, 0.059440, -0.285845, -0.428514, -0.088228, 0.299104, -0.040181, -0.234538, -0.309913, -0.507213, -0.056508, -0.313811, -0.640124, -0.506620, -0.684610, -0.273809, -0.571253, -0.496903, -0.154353, 0.115076, -0.343940, -0.416011, -0.222784, -0.093458, -0.511204, -0.539827, -0.381066, -0.678880, -0.386915, -0.092126, -0.102809, -0.112345, -0.139089, -0.149800, 0.109811, 1.721073, 1.553527, 0.000875, 0.131319, -0.238565, -0.193385, 0.042559, 0.478597, 0.034944, 0.310827, -0.079771, -0.302481, -0.207317, -0.265673, 0.167187, 0.374595, -0.192612, -0.318938, -0.388488, -0.254706, -0.302248, -0.596673, -0.280957, -0.434953, -0.648487, 0.918041, 0.733639, 0.576913, 0.193571, -0.182552, -0.265024, -0.282456, -0.018173, 0.173091, 0.263501, 0.123662, 0.099214, 0.166064, 0.198840, 0.292224, 0.230115, 0.388229, 0.525755, 0.372676, 0.280815, 0.393439, 0.560899, 0.635375, 0.549462, 0.450235, 0.393924, 0.477243, 0.484477, 0.444657, 0.775498, -0.228792, 0.486204, 0.030940, 0.045691, 0.067577, 0.411711, 0.306817, 0.262382, -0.071731, 0.102727, -0.250444, 0.092457, -0.073983, -0.051829, -0.084791, -0.186835, -0.062423, 0.145592, 0.045295, 0.025811, -0.181277, -0.077300, -0.184711, -0.270216, -0.099040, -0.144619, 0.016646, -0.036744, -0.093841, 0.166788, -0.224955, -0.982734, -1.277410, -0.986293, -1.053088, -1.209923, -0.980669, -0.510838, -0.884974, -1.093171, -1.036073, -1.115429, -0.729017, -0.362364, -0.584662, -0.931273, -0.868484, -1.218454, -1.184772, -1.008515, -0.687731, -0.560869, -0.419042, -0.780874, -0.821640, -1.120393, -0.891028, -0.770395, -0.868456, -0.874884, -0.653833, -0.465791, 0.141231, -0.260261, -0.149917, 0.541478, 0.171252, 0.108064, -0.174225, 0.003158, -0.601255, -0.012284, -0.051298, -0.148571, -0.244477, -0.240789, -0.142392, -0.141995, 0.025385, 0.031607, -0.286527, -0.389649, -0.475076, -0.380891, -0.232241, -0.373671, -0.186096, -0.262902, -0.357725, -0.388696, 1.058149, 1.461776, 1.042266, 1.232806, 1.736897, 2.126703, 3.268138, 2.671610, 1.688088, 1.454763, 1.326665, 1.414178, 1.846337, 2.064400, 1.043097, 0.363116, 0.292202, 0.413503, 0.130869, 0.026025, 0.192934, 0.532287, 0.997768, 0.739029, 0.541614, 0.392323, 1.067091, 1.457647, 1.026527, 0.303684, 0.034753, 1.851646, -0.244879, 1.022812, 1.598251, 2.028513, 3.761186, 3.114712, 0.400013, 0.165695, 0.397167, 1.730284, 2.895461, 3.621598, 2.237705, 0.494948, 0.972240, 0.356644, -0.008683, -0.078267, 0.245776, 0.440385, 0.510702, 0.307170, -0.057464, -0.078920, 0.488196, 0.767162, 0.107220, -0.254730, -0.243631, -0.327898, -0.771420, -2.417002, -2.538109, -2.422830, -1.768197, -1.273485, -1.866666, -1.356592, -0.590364, -0.379845, -0.664522, -0.840411, -0.638116, -1.073609, -0.489101, -0.333476, -0.557469, 0.485271, -0.504541, -0.479033, -0.169375, -0.924281, -2.003575, -1.066669, -1.015085, -1.763308, -0.639957, 0.189700, -0.242562, 1.518049, -0.879711, 1.971773, 3.252093, 2.630131, 4.849722, 4.325277, 1.466059, 0.535149, 0.128546, 1.752844, 3.267080, 4.691628, 1.822467, 0.906074, 0.822393, -0.195286, -0.363036, -0.121217, 0.462282, -0.317995, -0.127876, 0.200695, 0.003133, -0.051544, -0.114867, 0.959902, 0.244518, -0.394948, 2.772461, 1.873859, 2.752228, 3.132039, 2.911594, 2.895956, 2.863102, 3.272884, 3.452586, 3.718715, 3.916376, 4.019425, 4.004583, 3.895836, 3.553066, 3.394639, 3.167137, 3.571647, 3.997992, 4.340840, 3.824873, 3.451478, 3.513575, 3.683299, 3.590500, 3.748827, 3.808058, 3.570134, 3.605439, 3.404850, 0.679192, 3.883951, 5.086759, 5.259014, 5.076501, 4.556499, 4.611821, 4.325338, 4.385164, 5.084064, 5.248706, 5.172137, 4.960163, 4.943168, 5.245403, 5.488969, 5.832517, 6.015974, 6.018601, 5.643140, 5.668081, 5.724261, 5.274654, 6.375218, 6.397472, 5.831600, 6.216150, 6.573029, 6.461187, 6.263290, 0.699795, 1.145721, 1.364122, 1.064187, 0.719079, 0.536844, 0.540060, 0.609258, 1.192863, 1.585232, 0.925252, 0.627065, 0.517914, 0.414461, 0.657065, 0.594216, 0.755322, 0.619986, 0.938389, 0.841089, 0.997971, 1.307644, 1.372431, 1.231388, 1.587333, 1.796282, 1.813305, 1.968970, 1.939644, 2.362094, -0.285924, 2.862553, 3.533736, 3.155972, 3.582211, 2.685707, 2.237387, 1.788035, 1.804947, 2.655771, 3.123063, 2.870313, 2.792112, 2.837521, 2.601568, 2.934355, 3.106997, 3.181941, 3.523811, 3.257015, 3.513831, 3.082444, 2.676061, 3.882402, 4.519233, 3.338460, 3.568617, 3.704470, 3.726189, 3.574619, -2.155524, -0.630086, 0.191495, 1.271457, 1.876855, 1.809775, 1.600491, 1.639408, 1.422108, 1.042113, 1.005681, 1.373837, 1.154791, 1.411521, 1.643475, 1.886474, 2.231397, 1.475857, 0.747588, 1.027495, 1.744740, 1.261921, 0.816612, 1.087938, 0.868651, 0.889303, 1.399640, 2.085804, 1.691659, 0.894272, -0.593640, -0.505738, 0.064738, -0.055884, 0.045897, -0.312650, -0.337391, -0.004505, 0.188851, 0.006272, -0.128118, -0.456208, -0.115816, -0.249954, -0.386136, -0.071268, 0.119186, -0.375942, -0.503733, -0.327550, 0.644896, -0.076117, -0.654018, -0.247710, -0.513665, -0.562786, -0.488038, -0.224101, -0.497059, -0.555686, 0.142725, 0.300190, 0.635799, 0.263127, 0.250408, 0.318856, 0.156312, -0.225312, -0.036448, 0.196775, -0.603211, -0.702158, 0.016577, 0.301144, -0.218994, -0.625519, -0.101999, 0.227260, 0.166109, -0.134488, -0.088742, 0.026846, -0.106822, -0.259487, 0.226458, 0.173288, 0.091131, 0.038216, -0.295504, 0.082259, -0.081835, -0.216483, 0.221392, 0.045855, 0.276785, -0.208465, -0.491952, -0.099923, 0.081382, 0.051300, 0.094398, -0.109367, -0.042594, -0.250676, -0.438890, 0.172961, 0.046805, -0.273821, -0.657094, -0.177117, 0.344948, -0.258357, -0.718932, -0.292086, -0.333911, -0.539602, -0.487306, -0.362741, -0.581020, -0.553823, 0.481368, -0.433781, 0.521999, 0.471948, 0.786917, 0.845926, 0.549292, 0.535346, 0.513444, 0.283220, -0.105165, -0.094950, -0.166564, -0.218766, -0.207785, 0.142784, 0.361202, 0.340298, 0.488070, 0.333936, 0.159704, 0.200071, 0.186657, 0.158970, 0.069488, 0.085356, 0.058822, 0.119044, -0.000355, -0.004634, -0.128507, -0.140637, 0.434956, -0.140234, 0.174925, 0.072115, -0.186761, -0.172280, 0.133607, 0.320073, 0.051558, 0.119937, -0.166323, -0.154823, 0.264038, 0.098955, -0.113415, -0.163148, -0.113873, -0.023453, -0.079371, 0.161217, 0.563409, 0.195637, -0.112739, 0.059942, -0.044547, 0.056742, 0.311503, 0.307040, -0.469570, 0.518685, 0.292798, -0.053585, 0.210943, 0.466495, 0.231310, -0.116649, -0.049337, 0.297064, 0.438847, 0.274541, 0.252255, 0.077686, -0.059309, 0.176272, 0.054857, 0.078320, 0.468372, 0.599657, 0.210124, -0.140764, -0.433683, -0.484443, -0.149348, -0.248198, -0.154631, -0.315185, -0.306752, -0.436991, 0.094585, 0.310636, 0.265341, -0.011959, 0.518784, -0.155299, -0.413705, -0.295098, 0.257702, 0.606011, 0.083804, 0.197840, -0.228078, -0.031943, 0.609174, 0.401536, 0.043539, 0.087035, -0.008501, 0.043800, 0.311453, 0.747145, 0.951122, 0.562762, 0.185226, 0.316191, 0.290319, 0.477887, 0.618803, 0.711693, -0.891963, -0.011691, -0.047279, -0.607474, -0.390909, -0.152286, 0.053985, -0.190933, -0.444244, -0.243685, -0.141961, -0.002537, 0.081325, 0.072465, 0.048705, -0.050492, -0.258142, -0.171905, 0.005103, 0.008795, -0.113552, -0.313938, -0.259685, -0.158174, -0.089307, 0.098157, 0.043635, -0.012505, 0.109845, -0.121857, 1.821959, -0.682091, 0.056888, -0.286755, -0.358704, -0.238196, -0.247790, -0.202707, -0.256001, 0.010678, 0.052794, 0.067721, 0.282525, -0.093370, 0.036757, -0.071568, -0.293840, -0.282678, -0.121414, -0.064089, -0.158362, -0.124528, 0.150347, 0.186961, -0.248586, -0.060051, 0.381524, 0.048799, -0.003213, 0.268474, -0.905109, -0.329017, -0.233533, -0.004060, 0.067725, -0.255624, 0.134508, 0.323568, 0.063122, -0.009342, -0.287338, -0.472724, -0.610028, -0.320563, -0.166933, -0.046250, 0.038343, 0.243632, 0.158073, -0.498845, -0.266905, -0.163371, -0.340469, -0.637900, -0.555532, -0.372335, -0.543548, -0.185824, -0.177377, -0.198581, 1.847782, -0.264270, 0.364954, -0.148682, -0.596159, -0.497495, -0.255907, -0.174000, -0.204129, 0.226934, 0.427085, 0.549552, 0.802703, -0.097896, 0.036784, -0.082001, -0.201267, -0.231275, 0.026648, 0.245119, 0.222063, 0.208288, 0.708472, 0.460396, -0.058797, 0.186567, 0.969284, 0.571575, 0.236983, 0.868786, 0.930824, 1.596760, 1.780761, 1.343851, 1.366769, 1.300243, 1.616519, 1.541743, 0.839189, 1.189816, 1.402649, 0.709552, 1.092301, 1.056246, 1.452901, 1.401710, 0.796409, 1.115696, 1.039965, 0.627282, 0.749840, 1.509005, 1.253834, 0.776512, 0.422994, 0.475928, 0.840375, 0.659138, 0.522200, 0.498457, 1.017680, 1.336799, 1.920337, 4.182936, 5.322368, 4.999669, 3.829620, 5.097088, 6.321349, 4.897043, 5.111381, 7.759049, 6.772018, 5.943865, 5.495717, 4.942505, 4.971449, 5.886248, 5.934160, 4.112142, 5.128646, 4.232469, 3.336005, 4.006065, 6.018604, 5.830712, 4.472160, 4.586661, 4.747110, 4.462206, 4.605083, 3.214455, 2.800483, 4.482666, 4.749032, 3.906105, 3.273691, 3.859636, 4.175592, 5.302110, 4.783742, 4.687567, 5.132027, 4.788462, 4.850633, 5.013764, 4.933056, 4.731033, 4.334004, 4.250690, 5.857607, 5.025588, 4.132030, 5.504879, 6.777788, 6.405113, 6.300520, 7.068489, 7.149630, 5.706163, 1.592301, 0.263192, 0.550045, 2.266872, 2.386007, 2.194664, 0.972727, 2.165479, 3.393273, 2.589417, 2.032522, 3.747278, 3.358046, 2.597088, 1.760627, 3.476576, 3.348488, 3.247576, 3.781000, 2.472950, 3.407652, 1.861878, 1.222508, 1.807504, 4.081100, 3.267564, 2.931182, 4.233442, 3.677367, 3.221248, 4.209520, 4.677636, 5.798199, 6.254053, 5.914883, 5.790851, 6.008718, 6.625558, 6.754884, 7.050854, 7.424222, 7.439914, 7.375529, 7.434680, 7.243433, 6.787379, 6.252800, 6.615228, 7.253664, 7.407177, 6.983413, 6.606681, 6.615327, 6.783742, 6.779367, 7.098569, 7.095843, 6.801867, 6.880756, 6.654773, -0.301346, 2.282588, 2.676635, 2.341414, 2.463744, 2.504990, 2.369964, 2.292050, 2.364499, 2.931482, 3.100206, 3.149547, 3.241102, 2.853863, 2.878760, 3.339177, 3.188561, 3.289022, 3.870856, 3.521281, 3.277127, 2.636208, 2.693728, 3.229848, 3.437553, 3.141922, 3.002285, 3.304453, 3.365506, 3.254561, -0.211776, 0.292168, -0.282093, -0.270337, 0.138236, 1.184669, 0.725630, 0.177146, -0.059816, -0.132433, -0.371457, -0.420832, -0.547942, -0.994429, -0.559708, 0.232718, 0.711695, 0.314293, 0.109031, 0.400257, 1.175889, 1.280313, 1.282269, 1.446916, 1.020408, 0.910558, 0.822638, 0.371259, 0.475758, 0.613697, -0.445621, 1.550181, 1.749034, 0.897437, 0.478088, 0.327100, 0.019700, 0.338591, 0.749402, 0.947742, 1.079297, 1.984766, 1.707638, 1.619830, 1.513587, 1.153735, 1.570333, 0.883004, 1.357634, 1.415642, 1.369886, 0.925756, 0.599578, 1.289118, 1.587533, 0.949650, 0.842239, 1.032030, 1.294797, 1.418099, 0.027038, 0.031619, 0.188887, 0.274076, 0.027732, -0.247235, 0.021546, 0.280204, 0.352230, 0.406452, 0.761345, 0.611175, 0.503380, 0.538521, 0.189929, 0.128177, 0.058675, -0.118063, -0.127799, 0.176587, 0.065130, -0.133540, 0.001367, 0.323201, 0.308726, 0.055841, 0.176183, -0.173218, -0.304456, -0.152906, 0.310417, 0.623470, 3.175161, 3.181160, 4.932145, 5.456406, 3.914817, 5.122649, 5.320405, 4.314404, 3.288324, 4.131051, 4.668227, 3.870229, 3.778090, 3.480520, 3.318129, 2.916275, 3.956939, 4.586714, 3.649587, 2.163201, 2.025464, 2.273842, 2.518165, 2.144130, 2.149786, 2.023641, 2.209110, 1.867551, -0.724654, 2.125059, 2.077320, 1.823564, 1.913770, 1.308191, 0.980442, 1.058506, 0.784111, 0.031230, 1.064333, 1.245829, 1.713251, 0.668110, 0.279848, -0.101601, -0.314962, 0.907593, 2.004320, 2.312849, 1.321041, 0.598507, 1.138003, 1.203676, 0.735461, 1.098737, -0.114634, 1.149266, 0.676111, -0.078203, 0.276338, 1.071146, 2.000142, 2.349625, 3.339176, 3.550004, 2.783592, 4.604115, 5.078061, 4.450362, 3.678505, 3.242076, 3.230360, 2.915355, 3.435963, 2.737394, 3.140003, 2.832343, 3.579561, 3.925766, 3.380267, 2.256583, 1.347580, 1.997546, 2.637879, 2.049483, 2.530877, 2.536473, 2.606546, 3.062945, 4.146722, 4.945885, 6.038427, 6.621540, 6.299550, 6.231557, 6.451997, 7.153948, 7.392365, 7.643379, 8.032355, 8.102681, 7.779032, 7.816870, 7.582529, 7.002810, 6.428743, 6.871539, 7.499478, 7.635445, 7.136260, 6.764548, 6.869180, 7.155190, 7.122269, 7.381951, 7.427658, 7.160963, 7.231870, 6.963863, -0.587767, 1.034077, 1.470750, 1.328272, 1.261541, 1.512345, 1.417465, 1.490174, 1.237057, 1.274605, 1.441305, 1.420903, 1.453757, 1.575604, 1.388453, 1.884880, 1.999991, 1.968361, 2.248614, 2.079206, 2.171997, 1.836966, 1.843589, 2.310039, 2.154680, 1.926044, 2.016034, 2.380969, 2.146106, 2.061940, 0.146818, 0.559442, 1.185525, 0.268723, -0.409928, -0.076826, 0.028333, -0.035489, -0.186684, -0.532681, -0.601123, -0.608508, -0.125904, 0.090869, -0.329880, -0.331559, -0.471842, 0.181950, 0.145212, -0.314248, -0.435787, -0.310321, 0.007376, -0.111731, -0.319819, -0.314049, -0.391937, -0.377282, -0.221078, -0.579696, -0.216632, 0.929889, 1.335893, 0.646164, 0.860171, 0.868800, 0.822499, 0.774675, 0.411427, 0.387179, 0.448117, 0.773102, 0.608096, 0.645984, 0.279886, 1.132006, 1.342279, 1.365306, 1.268443, 1.151141, 1.109849, 0.937544, 0.864597, 1.266182, 1.556758, 0.939097, 1.011465, 1.419800, 1.284620, 1.169849, 0.482626, -0.498534, 0.231192, 0.303108, 0.403045, 0.370342, 0.218370, 0.134461, 0.189406, -0.022661, -0.370716, -0.363858, -0.367995, -0.331530, -0.294859, -0.074985, 0.107459, 0.128633, 0.301745, 0.205563, -0.059170, 0.064707, 0.089573, -0.026796, -0.162252, -0.056259, -0.051080, -0.119765, -0.192584, -0.138504, -0.379132, -0.072415, -0.028734, -0.073753, 0.023438, -0.105126, -0.172507, -0.114992, 0.103303, 0.197994, -0.117860, -0.090866, -0.106280, -0.052291, -0.149691, -0.157135, -0.003830, 0.159688, -0.043449, -0.055385, -0.082509, 0.151032, 0.463423, 0.215223, 0.020639, 0.219810, 0.180694, 0.129877, 0.258602, 0.353106, -0.615919, 0.028290, -0.067944, -0.724082, -0.557398, 0.143865, -0.062738, -0.494456, -0.760721, -0.738283, -0.676961, -0.343497, -0.390578, -0.480718, -0.159337, -0.444066, -0.773847, -0.587144, -0.276224, -0.147162, -0.348199, -0.615733, -0.694161, -0.814285, -0.584715, -0.488206, -0.813796, -0.699619, -0.726921, -0.727651, 0.113696, -0.297943, -0.249566, 0.228718, 0.500039, 0.042689, -0.197597, 0.117539, 0.215537, 0.432323, -0.038645, 0.131393, -0.095949, -0.071149, -0.083800, -0.121836, 0.254227, 0.532509, 0.144733, 0.079920, 0.362129, 0.800149, 0.992627, 0.815326, 0.214738, 0.524292, 0.678204, 0.665469, 0.862126, 0.975140, 1.074756, 1.436182, 1.065291, 0.615433, 0.639330, 0.713947, 0.732673, 0.314876, -0.031242, 0.307025, 0.389753, 0.036809, 0.082281, 0.098346, 0.369516, 0.384900, 0.227139, 0.250088, 0.214085, 0.338655, 0.225680, 0.350646, 0.412045, 0.238246, 0.217539, 0.131899, 0.443049, 0.578356, 0.428409, 0.168283, -0.253220, 1.204556, -0.382526, -0.270280, 0.360221, 0.013067, -0.129939, -0.296387, -0.045477, -0.006531, 0.124690, 0.227565, 0.207919, -0.017465, 0.167400, -0.096483, -0.167652, -0.149790, -0.151136, 0.106445, 0.004425, 0.257209, 0.186729, -0.052962, -0.125539, -0.200078, 0.136768, 0.031702, -0.226872, -0.183027, -0.100275, 0.248329, 0.197554, 0.158031, 0.316612, 0.406731, 0.398026, -0.018180, -0.269897, -0.160137, -0.039956, 0.181709, 0.324696, 0.108017, -0.180894, -0.326215, -0.419517, -0.240745, -0.123531, -0.280189, 0.109668, 0.475486, 0.158365, 0.041774, 0.110868, -0.002272, -0.103221, -0.124971, 0.024747, -0.167740, -0.745348, 0.581566, -0.375205, -0.273430, 0.195887, -0.037753, -0.209040, -0.420541, -0.000167, 0.313681, 0.275654, 0.526245, 0.413281, -0.014375, 0.136376, 0.158612, -0.109991, -0.270316, -0.054020, 0.057352, -0.025802, -0.168450, -0.319807, -0.241304, -0.264330, -0.233467, -0.156537, -0.348240, -0.430027, -0.420123, 0.373285, -0.734383, -1.027696, -0.697700, -0.896594, -0.879128, -0.888116, -0.754900, -0.704685, -0.714581, -0.491069, -0.245330, -0.162453, -0.337450, -0.292655, -0.678767, -0.555288, -0.253844, -0.403984, -0.692881, -0.676937, -0.543901, -0.206864, -0.463087, -0.717050, -0.375468, -0.572300, -0.579551, -0.553810, -0.582288, -0.315009, 0.673809, 0.140055, 0.170130, -0.438426, -0.342285, -0.239373, -0.270066, -0.408450, -0.233850, -0.033488, 0.006631, -0.378342, -0.293251, -0.285177, 0.064495, -0.119392, -0.094198, 0.212459, -0.202498, -0.237512, 0.086500, 0.549443, 0.344792, -0.133394, 0.504414, 0.104496, -0.066530, -0.054170, -0.228508, -0.820257, -1.405507, -0.494813, 0.230061, 0.371498, 0.122441, -0.137068, 0.400010, 0.270180, 0.411460, 0.431534, 0.183156, -0.173249, -0.018221, -0.026164, -0.615165, -0.163710, -0.210053, -0.423674, -0.082619, -0.309383, -0.942379, -1.157152, -1.091516, -0.778965, -0.827999, -1.005987, -0.859541, -0.871092, -0.663831, 0.031495, 1.564234, 0.391986, 0.117944, -0.173938, -0.172273, -0.000145, -0.425094, -0.549471, -0.286026, -0.019282, -0.169830, -0.564541, -0.300485, -0.264521, 0.439678, -0.067457, 0.220682, 0.473090, -0.104166, -0.124633, 0.708120, 1.193133, 0.972421, 0.197732, 1.188752, 0.697374, 0.379643, 0.617775, 0.155282, -0.972829, 0.036468, 0.069856, -0.677247, -0.391399, -0.027813, 0.177691, 0.052339, -0.078276, -0.044267, 0.017116, 0.210048, 0.306810, 0.230578, 0.093249, -0.026387, -0.226378, -0.023436, 0.073168, -0.052388, -0.146406, -0.401428, -0.426689, -0.280409, -0.079732, 0.063909, -0.081064, -0.206227, -0.014679, -0.220288, 1.690049, -0.916299, -0.016859, -0.334943, -0.002478, -0.075114, 0.088170, 0.325411, 0.117813, -0.235334, -0.315968, -0.313850, -0.184411, -0.256571, -0.181160, -0.040437, -0.366141, -0.381070, -0.221143, -0.010294, -0.104364, -0.383290, -0.082641, 0.008547, -0.156527, -0.004824, 0.271873, 0.072411, 0.081939, 0.057583, 0.118774, -0.137974, -0.356726, -1.057374, -1.024606, -0.399922, -0.254964, -0.128042, -0.305555, -0.532583, -0.471827, -0.298391, -0.005966, -0.120535, -0.101081, -0.507546, -0.498621, -0.485380, -0.266556, -0.202331, -0.237641, -0.196753, -0.346481, -0.044328, -0.108051, -0.317088, -0.292458, -0.175704, -0.226103, -0.349532, 1.273270, -0.457478, 0.052530, 0.038306, 0.203073, -0.001177, 0.343927, 0.294287, -0.066790, -0.116000, -0.150811, -0.023444, -0.018652, 0.015566, 0.117921, -0.038642, -0.153313, -0.356912, -0.140088, -0.071920, -0.170534, -0.138532, 0.256317, 0.326636, -0.082019, 0.363757, 0.882798, 0.492172, 0.501948, 0.488945, 0.425925, 0.026872, -0.003038, 0.200363, -0.169812, -0.393894, -0.466206, -0.456872, -0.274500, -0.066711, -0.103107, -0.099728, -0.026453, -0.023640, -0.231794, -0.274506, -0.011064, 0.124641, 0.017990, 0.021652, 0.133020, 0.266042, 0.418444, 0.257848, 0.192845, 0.304639, 0.207744, 0.204744, 0.122096, 0.245911, -0.350109, 0.162898, 0.140075, 0.106837, 0.098509, 0.323199, 0.375575, 0.137090, 0.351262, 0.192279, 0.610913, 0.468998, -0.023315, 0.205700, 0.112795, -0.202010, -0.186208, 0.053902, 0.065306, -0.005848, 0.072648, 0.134471, -0.139570, -0.092126, -0.077308, 0.155863, -0.116391, 0.055595, -0.170849, 0.017610, -0.611822, -0.891271, -1.253855, -1.142363, -0.734372, -0.913850, -0.840762, -1.292140, -1.611545, -1.444677, -1.259604, -1.600781, -1.010820, -1.250416, -0.922898, -0.841069, -0.711151, -0.697800, -0.953549, -0.936525, -0.730468, -0.862386, -0.359340, -0.232593, -0.734553, -0.696641, -0.881124, -1.072567, -0.731809, -0.478316, -0.500950, -0.070121, 0.316667, -0.144390, 0.016633, 0.049729, 0.515449, 0.799842, 0.666493, 0.225160, 0.578171, 0.259164, -0.231369, 0.147964, 0.020359, -0.066369, -0.357931, 0.006783, 0.037990, -0.090539, 0.023561, -0.207988, -0.332631, -0.435774, -0.180916, 0.016578, -0.243300, -0.199390, -0.260890, -0.203347, -1.187008, -0.558555, 0.302054, 1.211531, 1.856945, 1.718755, 1.565389, 1.573145, 1.505179, 1.147032, 0.941637, 1.266004, 1.229926, 1.481392, 1.696004, 2.104257, 2.337272, 1.507813, 0.757833, 0.950408, 1.777944, 1.358372, 0.856941, 1.028534, 0.806766, 1.000148, 1.402619, 1.979500, 1.620905, 0.959991, 0.387615, -0.188608, -0.103516, -0.252123, -0.149698, -0.201273, -0.303727, -0.618818, -0.327096, -0.321085, -0.605854, -0.349907, -0.402057, -0.237840, -0.289622, -0.374333, -0.291887, -0.546185, -0.379584, -0.417195, 0.802022, -0.142800, -0.711702, -0.183006, -0.365694, -0.541993, -0.434693, -0.250192, -0.513640, -0.535306, 1.214234, 0.898212, 0.245947, 0.413411, 0.737970, 0.816483, 0.328538, 0.141367, 0.234418, 0.373748, 0.235849, -0.045296, 0.058819, 0.375280, 0.393230, 0.203068, -0.094701, 0.038506, 0.259628, 0.333947, 0.520003, 0.443239, 0.358871, 0.376173, 0.540744, 0.398040, 0.031152, -0.016609, 0.111693, 0.272711, 1.179442, 0.186079, -0.099269, -0.289784, 0.188829, 0.021138, -0.563329, -0.706094, -0.208810, -0.257564, -0.527413, -0.148771, -0.279883, 0.012608, -0.269400, -0.241099, -0.208534, -0.584855, -0.560268, -0.235629, 0.342063, -0.412884, -0.784070, -0.451171, -0.326426, -0.533385, -0.505253, -0.307455, -0.596611, -0.650449, -0.701611, -1.363622, -1.398078, -0.916253, -0.739136, -0.605864, -0.621537, -0.506242, -0.632366, -0.823185, -0.619811, -0.646457, -0.789831, -0.695276, -0.736108, -1.059247, -1.216018, -1.103866, -0.881684, -0.737846, -0.874907, -1.080536, -1.118026, -1.058350, -0.991286, -1.026505, -1.157139, -1.053324, -1.033093, -1.145278, -0.412825, 0.113268, 0.208943, 0.249609, -0.172411, -0.120145, -0.289374, 0.002666, -0.241736, -0.268855, -0.045097, -0.082080, -0.365593, -0.092038, -0.316264, -0.247521, -0.330263, -0.376996, -0.263179, -0.228877, -0.303566, -0.567056, -0.662901, -0.345485, -0.301304, -0.495002, -0.554933, -0.447795, -0.435230, -0.595414, -0.379484, -0.907871, -0.773629, -0.562419, -0.689098, -0.499053, -0.420329, -0.484515, -0.627694, -0.873902, -0.635386, -0.471616, -0.480639, -0.481676, -0.248839, -0.295805, -0.381478, -0.621270, -0.742004, -0.517544, -0.642246, -0.518606, -0.416647, -0.441785, -0.750247, -0.654072, -0.398729, -0.351854, -0.424831, -0.476631, -0.402207, 0.070548, 0.034117, 0.505085, -0.163960, -0.091150, -0.193382, -0.055943, -0.306948, -0.229395, 0.078378, -0.067850, -0.341433, -0.329697, -0.402214, -0.280459, -0.352969, -0.568862, -0.377720, -0.326478, -0.297197, -0.557371, -0.610866, -0.424882, -0.304829, -0.586839, -0.593835, -0.453870, -0.520644, -0.750107, 0.340745, 0.128077, -0.840306, -0.375448, -0.605941, -0.524342, -0.362398, -0.289285, -0.259447, -0.283677, -0.091930, -0.088730, -0.199475, -0.247148, -0.195961, -0.330184, -0.426194, -0.405951, -0.449640, -0.465834, -0.356895, -0.411797, -0.367763, -0.353839, -0.348780, -0.312191, -0.448045, -0.585948, -0.680068, -0.640326, -0.847919, -0.420122, -0.096952, 0.454240, 0.264171, 0.152680, 0.408834, 0.267781, -0.067126, -0.150662, -0.374301, 0.161368, -0.296719, -0.310235, -0.259222, -0.139396, 0.266201, -0.129893, -0.170547, 0.111327, -0.037736, -0.277601, -0.033120, -0.072824, -0.352410, 0.058839, 0.005276, -0.031875, -0.207100, -0.020543, 0.189468, -0.355125, 0.916121, 1.490312, 1.478168, 1.741004, 1.860554, 1.661501, 1.222310, 1.022398, 0.558910, 0.517614, 0.681181, 0.575093, 0.507003, 1.156736, 1.038413, 1.209573, 0.825048, 1.283025, 1.098471, 0.921237, 1.247329, 1.294561, 1.136211, 1.233298, 1.389346, 1.323907, 1.184495, 1.547978, -0.183706, 0.036634, 0.050702, 0.671154, 0.453068, 0.191809, 0.550978, 0.545661, 0.429881, 0.134058, -0.471979, 0.169533, -0.284073, -0.124344, -0.366981, -0.065503, 0.673696, 0.046424, -0.072916, 0.521492, 0.424449, 0.099584, 0.399641, 0.075338, -0.247671, 0.584156, 0.378005, 0.395874, 0.117901, 0.492102, -1.172973, -0.145171, -0.165781, -1.004021, -0.721209, -0.295777, -0.171346, -0.527724, -0.780835, -0.482199, -0.283773, -0.225050, -0.080055, -0.158680, -0.153848, -0.045875, -0.136692, -0.091041, 0.103300, 0.204991, 0.263551, 0.137067, -0.101261, 0.085984, 0.379953, 0.411742, 0.331105, 0.323954, 0.302710, 0.102801, 1.506706, -0.868808, -0.447910, -0.366850, -0.040445, -0.469314, 0.011029, -0.133849, -0.497213, -0.301083, -0.329576, 0.235857, 0.115265, 0.006082, -0.240349, 0.220172, 0.495519, 0.318298, 0.838511, 1.600807, 1.702376, 1.537359, 1.795525, 1.496790, 2.459606, 1.834512, 1.260236, 1.512763, 1.575618, 0.935870, 0.230450, 0.036015, 0.491960, 0.166781, 0.361856, 0.457924, 0.404057, -0.295360, -0.594967, 0.224999, 0.509560, 1.455193, 0.449785, -0.078436, -0.274724, 0.268887, -0.082030, 0.061933, 0.346856, 0.302937, -0.026260, -0.242072, -0.107854, 0.036563, 0.297847, 0.229337, 0.096473, -0.286859, -0.164513, -0.249492, 1.097086, -0.774688, -0.479475, -0.000796, -0.114988, 0.099886, 0.357505, -0.226545, -0.613488, -0.398618, -0.043416, 0.884429, 0.688976, 0.034022, -0.364130, -0.548539, 0.585708, 0.099185, 0.728858, 1.119844, 1.286941, 0.994727, 1.224075, 1.159248, 2.002341, 1.315374, 0.664534, 1.255470, 1.372699, 0.806632, 0.771788, 0.665983, 0.478048, 0.405418, -0.116583, -0.339227, -0.323058, -0.119128, 0.202172, 0.358708, 0.159866, 0.148753, 0.244459, 0.253203, 0.207789, 0.196662, 0.315808, 0.503862, 0.353706, 0.408359, 0.399567, 0.581569, 0.707387, 0.624730, 0.626717, 0.487841, 0.430522, 0.570897, 0.649797, 0.933862, 0.065423, 0.236032, -0.404268, -0.257200, -0.204820, -0.142185, -0.398533, -0.031450, -0.068454, 0.018179, -0.438623, -0.263255, -0.114059, -0.167847, -0.121842, -0.112417, -0.184692, -0.008162, -0.272943, -0.165216, -0.316648, -0.109435, -0.295971, -0.319188, -0.084468, -0.354096, -0.362895, -0.142789, -0.220470, -0.073202, 0.439100, -0.504193, -0.605402, -0.115387, -0.232589, -0.309724, -0.203386, -0.211305, 0.126784, 0.294649, 0.165302, -0.304510, -0.527018, -0.597389, -0.317227, 0.172141, 0.155661, 0.040278, -0.089175, 0.131887, 0.255423, 0.118408, -0.069667, -0.206958, -0.110526, -0.202873, -0.187009, -0.474154, -0.342913, 0.044076, -0.522614, -0.727196, -0.156349, -0.174625, -0.189958, -0.113388, -0.437295, -0.076794, 0.111992, -0.115869, -0.471091, -0.297729, -0.146232, -0.183486, -0.355783, -0.267315, -0.440605, -0.269463, -0.390003, -0.235852, -0.454423, -0.423131, -0.559698, -0.455959, -0.252832, -0.547638, -0.606474, -0.368125, -0.553540, -0.482191, 0.845174, 0.971948, 0.945057, 0.555940, 0.574145, 0.638593, 0.731880, 0.405863, 0.080906, 0.387447, 0.557785, -0.062852, -0.065992, -0.089340, 0.095333, 0.075797, -0.149464, -0.119033, -0.104978, -0.060536, -0.101262, 0.286128, 0.271758, -0.001878, -0.032727, -0.175509, 0.111620, 0.114183, -0.009496, -0.182760, -0.152648, 0.811554, -0.642620, -0.700122, -0.025239, -0.258104, -0.075925, -0.252198, -0.137244, -0.166088, 0.111542, -0.033971, -0.058348, -0.003174, 0.001923, -0.102685, -0.245849, -0.289366, -0.151189, 0.119967, 0.075804, 0.461007, 0.621072, -0.036926, 0.022710, -0.202268, 0.186617, 0.026815, -0.101382, -0.146862, 0.134717, -0.123717, -0.792482, -0.846807, -0.577651, -0.591204, -0.748498, -0.621225, -0.513050, -0.213625, -0.418619, -0.675628, -0.788890, -0.713161, -0.712675, -0.534250, -0.354696, -0.623665, -1.061929, -1.073194, -0.899283, -0.549645, -0.340628, -0.551749, -0.662698, -0.452986, -0.315907, -0.453931, -0.546880, -0.390815, -0.790352, 0.193456, -0.496391, -0.589784, -0.201739, -0.429938, -0.449165, -0.426759, -0.310862, -0.218236, 0.172901, 0.034024, -0.011146, -0.257563, -0.030646, -0.232523, -0.369660, -0.513698, -0.227808, 0.049787, -0.003942, -0.096875, -0.257148, -0.419965, -0.206325, -0.430826, -0.201769, -0.288129, -0.386925, -0.439107, 0.953148, 0.837002, 0.707999, 0.369656, -0.141755, -0.214483, -0.202597, 0.081165, 0.214216, 0.290161, -0.005112, 0.035317, 0.189784, 0.293334, 0.354393, 0.329439, 0.385757, 0.621763, 0.481574, 0.406478, 0.340821, 0.586231, 0.853648, 0.717235, 0.627746, 0.409004, 0.426860, 0.543119, 0.578330, 0.832930, -0.074106, 0.329393, -0.507540, -0.188667, -0.255889, -0.095060, -0.195799, 0.150053, 0.023505, 0.016848, -0.364927, 0.128697, -0.009407, 0.021431, 0.029871, -0.016159, -0.157648, 0.124731, -0.075971, -0.052650, -0.219913, -0.008866, -0.213291, -0.192855, 0.034723, -0.339903, -0.199888, 0.035276, -0.096381, 0.157973, 0.044745, 0.084919, 0.353971, 0.239942, 0.345013, 0.638619, 0.683799, 0.536096, 0.455018, 0.520485, 0.489465, 0.667159, 0.684827, 0.661815, 0.494769, 0.663902, 0.593649, 0.510024, 0.559114, 0.642417, 0.687991, 0.619514, 0.467500, 0.409481, 0.426910, 0.640120, 0.740870, 0.669073, 0.497692, 0.537908, -0.779422, -0.670022, -0.308152, -0.126367, -0.163429, -0.204210, -0.262291, 0.202978, -0.002266, -0.049580, -0.365980, 0.103142, -0.118247, -0.097210, -0.091654, -0.097978, -0.385844, -0.113701, -0.217930, -0.044563, -0.336570, -0.387907, -0.555236, -0.501474, -0.192097, -0.558721, -0.507133, -0.354080, -0.450539, -0.438677, 0.376303, 0.219253, -0.562467, -0.109677, -0.300033, -0.305938, -0.069847, 0.164332, 0.173988, 0.147290, 0.185076, 0.107191, -0.047485, -0.109703, 0.000114, -0.085047, -0.172223, -0.341640, -0.280836, -0.210438, -0.171984, -0.165993, -0.088048, -0.052393, -0.123515, -0.073555, -0.170117, -0.358201, -0.429674, -0.400065, -0.769950, -0.403628, -0.216881, 0.005297, -0.417671, -0.256644, -0.343460, -0.376530, -0.105746, -0.116117, -0.363740, -0.247434, -0.092909, -0.162824, -0.128178, -0.091775, -0.059809, -0.287035, -0.358814, -0.227881, -0.242733, -0.205569, -0.117919, -0.215717, -0.349302, 0.009114, -0.069204, -0.167062, -0.261261, -0.041211, 0.626387, 0.564941, -0.322740, -0.249152, -0.028373, 0.047944, -0.157431, -0.214574, 0.270597, 0.209880, 0.254350, 0.526109, 0.365205, -0.055484, 0.415744, 0.143947, -0.080736, -0.002356, -0.077073, -0.036342, -0.137111, -0.256508, -0.177740, -0.086262, -0.099520, -0.295359, -0.232781, -0.163082, -0.079413, -0.128300, 0.357855, -0.194516, -0.018805, -0.062777, -0.406596, -0.233092, -0.327252, -0.295950, -0.157069, -0.126388, -0.186904, -0.361328, -0.047262, 0.057166, 0.063395, 0.088515, 0.183660, -0.276908, -0.300492, -0.163450, -0.012412, 0.194761, 0.333333, -0.077142, -0.464938, 0.248229, 0.096214, 0.063590, -0.074223, 0.323186, 1.046258, 1.149714, 0.884918, 0.648586, 0.771156, 0.929778, 0.953088, 0.522446, 0.153621, 0.334827, 0.379219, 0.094755, 0.167164, 0.117618, 0.308825, 0.334406, 0.270867, 0.133441, -0.048466, 0.140337, 0.186630, 0.409180, 0.385354, 0.227149, 0.237774, 0.106392, 0.398492, 0.480893, 0.359916, 0.129906, -0.320732, 0.919642, -0.246450, 0.307784, 1.002585, 1.273461, 1.201591, 0.339512, 0.622878, 0.252604, 0.081082, 0.121049, 0.396207, 0.282311, 0.048950, -0.187603, -0.098060, -0.057007, 0.056761, -0.097629, -0.258490, 0.229800, 0.129233, -0.064073, -0.158314, -0.078077, 0.286612, 0.104687, 0.079810, -0.027697, -0.094522, 0.023026, 0.342839, 0.311163, 0.760331, 1.475500, 1.776507, 1.532090, 1.780359, 1.293331, 1.192935, 1.332665, 1.211278, 1.070295, 1.117789, 0.888108, 0.611454, 0.671311, 0.190444, 0.170177, 0.335229, 0.268831, 0.192976, 0.509253, 0.710661, 0.864573, 0.680269, 0.552087, 0.809013, 0.676844, -0.654381, 0.054484, -0.364394, 0.006383, 0.818069, 1.327106, 1.170609, 0.038852, 0.354143, -0.050556, 0.228329, 0.466664, 0.561051, 0.052823, -0.118636, -0.278819, -0.275699, 0.024499, -0.132377, -0.303533, -0.353017, -0.209745, -0.290372, -0.477911, -0.198076, -0.159145, -0.053044, -0.215878, -0.088393, -0.389859, 1.215772, 1.748864, 1.207896, 1.262588, 1.298882, 2.652775, 3.194477, 2.065194, 2.831760, 1.893695, 1.037794, 0.505704, 1.102766, 1.168216, 1.671986, 2.361287, 2.031829, 1.140348, 0.279388, 0.709228, 0.785199, 1.278204, 1.491624, 0.671287, 0.426312, 0.375848, 1.444183, 2.570953, 1.590098, 0.428503, -1.131979, 1.308229, -0.678760, 1.385377, 1.201425, 3.100153, 3.676015, 1.325314, 3.500203, 0.966025, -0.321375, -0.287403, 0.570606, 0.561986, 0.484032, 2.470743, 3.410867, 1.957988, -0.438854, -0.219437, -0.583454, 0.628999, 0.646919, 0.132800, 0.013472, -0.696560, 0.071473, 1.094538, -0.040190, -0.497157, 1.235215, 0.043392, -0.151948, -1.417319, -1.762798, -0.896123, -1.211038, -1.358361, -2.528753, -1.736549, -0.476371, -0.449429, -1.621880, -1.986614, -1.237950, -2.119100, -4.287399, -3.262480, 0.063043, -1.324983, -0.597676, -2.552546, -1.767824, -0.811559, -0.869817, -1.001324, -1.748898, -2.970311, -1.156441, 0.327761, -0.988822, -0.157114, -1.044580, 1.830227, 0.999089, 4.076105, 5.243339, 0.719891, 0.159404, -0.589121, 0.420518, 0.078631, -0.272806, 0.625362, -0.263937, 0.579695, 3.542375, 2.458314, -0.429607, 0.090179, -0.397029, 0.700562, 0.048312, 0.417635, -0.101248, -1.201965, -0.575394, 0.690662, -0.091023, -1.024027, -0.899668, 0.115566, 0.089415, -0.575760, -0.273162, 0.020686, 0.016153, -0.137749, -0.254284, -0.096327, -0.028178, 0.061360, 0.193966, 0.263531, 0.113520, -0.005868, -0.229275, -0.082966, 0.059269, 0.023646, -0.117424, -0.337211, -0.282705, -0.220066, -0.031256, 0.117055, -0.018007, -0.086603, 0.154200, -0.129983, 1.397218, -0.894377, -0.024354, -0.497536, -0.163123, -0.096243, -0.174705, -0.479100, -0.509146, -0.279447, -0.100987, -0.208375, -0.153012, -0.260580, -0.105959, -0.084794, -0.417012, -0.324110, -0.084133, -0.137157, -0.233722, -0.360529, -0.016561, 0.127025, -0.183762, -0.153939, 0.229614, 0.124334, 0.081208, 0.080973, 0.053679, 0.095570, 0.226037, 0.516723, 0.488956, 0.399067, 0.519856, 0.546726, 0.226415, 0.002173, 0.346089, 0.562786, 0.418676, 0.341096, 0.471318, 0.288745, 0.359404, 0.346087, 0.334861, 0.395511, 0.558248, 0.382872, 0.138163, 0.437430, 0.208316, 0.223720, 0.367748, 0.421436, 0.411301, 0.191068, 1.371920, -0.249281, 0.153090, -0.248750, -0.167768, -0.076700, -0.066129, -0.465970, -0.536679, -0.242629, 0.131421, 0.066941, 0.104388, -0.070542, -0.081832, 0.029053, -0.382783, -0.274896, 0.063265, -0.068612, -0.031111, 0.009119, 0.462399, 0.481078, -0.036996, 0.011832, 0.778445, 0.677762, 0.526331, 0.495199, 0.505563, -0.054319, -0.743993, -0.320020, -0.549078, -0.678780, -0.466688, -0.218436, -0.282426, -0.394288, -0.361582, -0.186368, -0.206521, -0.317197, -0.295521, -0.413340, -0.350695, -0.351674, -0.468450, -0.534808, -0.380839, -0.246991, -0.136019, -0.275850, -0.459354, -0.358833, -0.414284, -0.428411, -0.484442, -0.414456, -0.667449, -0.153707, -0.111071, 0.261458, -0.388689, -0.297586, -0.244834, -0.054059, -0.239858, -0.413912, -0.089605, -0.291299, -0.118165, -0.098359, -0.190776, -0.233210, 0.163414, -0.065476, -0.249633, -0.181268, -0.193046, -0.092509, 0.121033, 0.038867, -0.272002, 0.073113, -0.073526, -0.138056, -0.092320, 0.158888, -0.656431, -0.395318, -0.154590, 0.163562, 0.150115, 0.011072, 0.023056, 0.166953, -0.123548, -0.424737, -0.385780, -0.341580, -0.398678, -0.396560, -0.221714, -0.198687, -0.058993, 0.217884, 0.012036, 0.048797, 0.047211, 0.153167, 0.061664, 0.072973, -0.137986, 0.049773, -0.210680, -0.044874, -0.020171, -0.083427, 0.159619, -0.003485, -0.118606, 0.371397, -0.299978, -0.318837, -0.386283, 0.158187, -0.171231, -0.247848, -0.143433, 0.005997, 0.141906, -0.008276, -0.145387, -0.085243, 0.263568, 0.072765, -0.198599, -0.099079, -0.007095, 0.351565, 0.675109, 0.317306, -0.029758, 0.445536, 0.143805, 0.134075, 0.318673, 0.633002, 0.644922, 0.457481, 0.323310, 0.397182, 0.014239, -0.264972, -0.316366, -0.225462, 0.013737, 0.214314, 0.203245, 0.194729, 0.184842, 0.091966, 0.004980, 0.094825, 0.184042, 0.354071, 0.289581, 0.346302, 0.450914, 0.588796, 0.644405, 0.528408, 0.612496, 0.486557, 0.436157, 0.559577, 0.622315, 0.845868, 0.319604, 0.197351, -0.547364, -0.057847, -0.117980, -0.295650, -0.273704, -0.055805, -0.208129, 0.017461, -0.100277, -0.189225, -0.170419, -0.157212, -0.188638, -0.282959, -0.084733, -0.176727, -0.165335, -0.175560, -0.120334, 0.006630, -0.275004, -0.306065, -0.215326, -0.207884, -0.350334, -0.126113, -0.226015, -0.058456, -0.570096, -0.064521, -0.211472, -0.226861, -0.292270, -0.338892, -0.423119, -0.766900, -1.080345, -1.048126, -0.812987, -0.398671, -0.387598, -0.248425, -0.177152, -0.043406, -0.165013, -0.177926, -0.199466, -0.152480, -0.202658, -0.302250, -0.275459, -0.337975, -0.315500, -0.339950, -0.275361, -0.375406, -0.289798, -0.351123, 0.056236, -0.473926, -0.425438, -0.196548, -0.248416, -0.315967, -0.329244, -0.083680, -0.166136, 0.133240, -0.061838, -0.261780, -0.232875, -0.355786, -0.256311, -0.358586, -0.181889, -0.308704, -0.350927, -0.361797, -0.385689, -0.465271, -0.563313, -0.533161, -0.361875, -0.400034, -0.543705, -0.402710, -0.523517, -0.502501, 2.432952, 2.369092, 3.288502, 3.831134, 3.541445, 3.497855, 3.668518, 4.125676, 4.227019, 4.234738, 4.441387, 4.739365, 4.359405, 4.386521, 4.184709, 3.636939, 3.376010, 3.464951, 3.879670, 4.161193, 3.675202, 3.071170, 3.520720, 3.700028, 3.487475, 3.697719, 3.652274, 3.326045, 3.332924, 3.326484, 0.560093, 3.174015, 4.704199, 4.189919, 5.101737, 4.394908, 4.345218, 3.053330, 3.529528, 4.003354, 3.676148, 4.166781, 4.650825, 5.109684, 5.854213, 5.600014, 4.894928, 5.047005, 4.674465, 4.547744, 5.070337, 5.735682, 4.941639, 5.340163, 5.329557, 4.815679, 5.527802, 5.377676, 5.545223, 6.217546, 2.061995, 3.048259, 2.660952, 2.206460, 3.857615, 2.245538, 2.017339, 1.268049, 1.499084, 2.026822, 1.397066, 1.996380, 1.849869, 3.021575, 3.210668, 3.192244, 3.337004, 4.101801, 3.144100, 2.960270, 2.778178, 2.403865, 2.831412, 3.853976, 4.495033, 4.014283, 3.802939, 3.822031, 4.021664, 3.967969, 0.022874, 2.023276, 2.829045, 1.664773, 1.766210, 0.729972, 1.067202, 0.968163, 2.215946, 1.762783, 1.920607, 2.806682, 3.401658, 4.381573, 5.138017, 4.148645, 3.816821, 3.019130, 3.086993, 2.598455, 3.173362, 3.509176, 2.611010, 4.246919, 4.804187, 4.102164, 4.002674, 4.653045, 4.826092, 5.155009, -1.195694, -0.477544, -0.503904, -1.404914, 0.128034, 0.283236, 0.467207, 1.591456, 1.145935, 0.389078, -0.162729, -0.515290, 0.015625, 0.504401, 0.343681, 0.149439, 0.572224, 0.608940, 0.284092, 0.520923, 1.058445, 0.387169, 0.018879, 0.133541, 0.705364, 0.506986, 0.431950, 0.819457, 0.647750, 0.174935, 0.362982, -0.010309, 0.228825, -0.114963, -0.475817, -0.328026, -0.400502, -0.319585, 0.762377, 0.617159, 0.215659, 1.094661, 0.113311, 0.766489, -0.723009, 1.166607, 2.053744, 1.852144, 1.390475, 2.084716, 3.651196, 2.909562, 2.485677, 3.161576, 3.306485, 3.121723, 3.301979, 3.780989, 3.103078, 2.748270, 1.168104, -0.675707, -1.311155, -0.069443, 0.010756, -0.499841, -1.590327, -0.139488, -0.634941, -0.492860, -0.573721, 0.093299, 0.283715, -0.235189, -0.206732, -0.122728, 0.731922, -0.473622, -0.407860, -0.976372, 1.438398, 1.402712, 0.800610, 1.122037, 1.739703, 1.015548, 1.102957, 1.054779, 1.084622, 1.191226, -0.719644, -0.124789, -0.139645, 0.337273, -0.306006, 0.262401, -0.018219, 0.290770, 1.525820, 1.580180, 1.418617, 1.352638, 0.624198, 1.162885, -1.060876, 1.587269, 2.440360, 1.545915, 1.189176, 0.788827, 4.877897, 3.323111, 2.760750, 3.296917, 4.624209, 3.991396, 3.651592, 4.473869, 3.500751, 3.188051, 0.005204, -0.269386, 0.350197, 0.090325, 0.178676, 0.163429, 0.095197, -0.065496, -0.174107, -0.205787, -0.303069, -0.047162, 0.306934, 0.274950, 0.154823, 0.313244, 0.150330, 0.174130, 0.417670, 0.477045, 0.232382, -0.006235, -0.060871, 0.068997, -0.019160, 0.038370, 0.011781, -0.120463, -0.132236, -0.202304, 0.580420, -0.650937, 0.586018, 0.172211, 0.676536, 0.267866, 0.703893, 0.282413, 0.585528, 0.783616, 1.122415, 2.082994, 2.054640, 2.519502, 2.523011, 1.606704, 1.663831, 1.044539, 0.989036, 1.758775, 2.028453, 1.704906, 1.693834, 1.711612, 1.436078, 1.537270, 1.386119, 1.946700, 2.075501, 1.572554, -1.287134, 0.392276, -0.787961, -0.751958, 0.175899, -0.490330, -0.530894, -0.449197, -0.064750, -1.100497, -0.536897, -1.703760, -2.254939, -1.827968, -1.593454, -1.753299, -1.094115, -1.735434, -2.048421, -2.274204, -1.735171, -1.396469, -1.527040, -2.131232, -1.960169, -1.937063, -2.334264, -1.825445, -1.843341, -2.297833, 1.108513, -0.520834, 1.266571, 0.491612, 0.855682, 0.374349, 0.217204, 0.100583, 1.020645, 1.342938, 1.196173, 2.563581, 2.131573, 2.304131, 2.381196, 2.058996, 0.463740, 0.476479, 0.493420, 1.360954, 2.071755, 0.882603, 1.561408, 1.354565, 0.899219, 1.210076, 1.745566, 2.171186, 2.069318, 1.313831};
static RBF_CONST rbf_float RBF_WIDTHS[] = {4.364526, 16.384377, 3.946359, 4.037015, 3.090056, 13.195536, 3.159617, 3.724669, 9.509692, 10.477574, 14.188218, 2.458554, 2.721463, 3.728899, 3.372545, 5.084839, 13.817203, 2.666196, 13.070435, 3.062372, 5.770232, 2.782469, 3.666830, 16.384377, 3.195521, 52.051434, 3.385231, 4.073603, 7.918364, 12.818349, 12.857887, 3.260598, 11.842709, 3.396858, 3.674348, 2.951307, 3.396858, 2.703772, 2.782469, 3.364778, 3.653890, 2.648912, 4.294221, 3.538393, 21.325453, 2.854569, 2.809833, 4.226449, 7.696274, 3.291657, 4.194005, 3.205034, 3.518274, 3.283558, 3.079037, 3.651710, 9.605794, 3.969555, 3.597561, 3.575393, 2.978147, 3.028480, 13.195536, 3.595757, 11.842709, 4.613025, 2.988994, 7.095459, 3.451647, 3.123696, 2.458554, 14.188218, 2.854569, 3.711242, 3.527865, 3.538393, 3.558625, 3.297542, 3.418877, 3.595757, 4.509936, 2.981353, 8.075870, 3.022383, 21.204840, 2.809833, 3.946092, 2.978147, 4.088948, 2.666196, 2.777096, 2.733619, 10.346084, 14.651999, 11.314033, 14.512280, 14.075952, 13.707889, 3.083677, 2.942407, 7.612438, 3.740748, 3.803139, 2.703772, 2.964043, 2.525661, 2.525661, 2.763827, 3.998259, 19.901436, 4.387065, 13.070435, 3.816976, 2.777096, 3.418877, 4.410584, 3.730283, 10.775550, 4.801905, 3.676077, 11.769330, 12.818349, 3.283558, 3.597561, 3.297542, 21.939768, 7.918364, 15.880266, 8.380239, 3.899830, 2.988994, 3.575393, 3.637838, 3.676077, 3.706738, 2.813423, 3.518274, 7.419004, 2.721463, 3.083824, 2.964043, 3.357747, 5.109049, 14.117798, 3.205034, 3.357747, 2.989806, 13.303721, 13.510921, 10.239225};
static RBF_CONST rbf_float RBF_WEIGHTS[] = {-1.221081, -2.464135, -0.588080, 1.314619, -1.919908, 6.728200, -1.338091, -0.979610, -0.249881, 1.243657, 0.090484, -0.695644, -1.230742, 0.740056, 3.526491, 0.125421, -0.578958, -0.008890, 0.350575, -1.827648, -0.962651, -0.114142, 0.116222, -0.116829, 0.022091, 1.129960, 0.651295, 2.434285, 5.888067, -2.715981, -0.937667, -3.583946, -0.280966, -3.457757, -0.098548, 1.121175, -0.082844, 0.918800, 9.328184, -1.696401, -1.101177, -1.452903, -0.555804, -0.503917, -0.542284, -4.189826, 0.557818, -0.569280, -0.111670, -1.453870, -0.039545, 0.191220, -0.599975, 2.916890, 5.671478, 1.603136, 1.839040, -5.943243, 0.008253, -4.082996, -1.043724, 1.793984, -0.335153, 0.132131, 0.744794, -0.259306, 0.296505, -1.026156, -0.261501, 0.190806, -0.168477, -0.094989, -0.430605, -3.700888, -2.148126, 2.878500, 2.750138, -1.122950, 1.968500, 1.006170, 0.250010, -1.026006, 1.416096, -1.775392, -0.430614, -5.963694, -0.280541, 0.506450, -2.633888, 18.461695, 0.047225, 0.387161, -7.588438, 0.222189, -4.240066, 1.602292, -1.128870, 1.468492, -0.225266, 0.208658, 1.189775, -0.473931, -0.110542, -0.779575, -0.627262, 0.318138, -0.088898, 0.232975, -1.218165, 1.835750, -0.435571, -2.584551, 0.120778, 0.343973, 0.199949, -1.675898, -0.265122, 0.405628, 2.634872, 0.566192, -4.136147, 0.232484, -0.729849, -0.023512, -0.031162, -0.036804, 5.401715, -1.069250, 0.168798, -0.075476, 0.062834, 0.136737, -1.277546, -11.926248, 20.915817, 1.214124, 0.827049, 2.275878, -5.070515, -0.817154, -1.683859, -12.507021, 2.426735, 6.123458, -0.545869, 0.001468, -5.007856, 1.452827, 1.182986, 0.867639, 12.859279, 0.598525, -0.270711, -8.575170, 0.396193, -2.867209, 2.216391, -2.189165, -0.359459, 0.184236, 0.815421, -5.367685, -0.435156, 0.025042, 7.932935, -0.759449, 0.226470, -2.345746, -1.854122, 0.400028, 1.907959, 0.266356, -6.599226, 2.530589, -0.016269, 0.483230, 2.119494, 1.560665, -2.797494, 1.823953, 1.096086, -1.626886, -1.677998, 0.471034, -2.606686, 1.790923, 1.539437, 1.826283, -1.013745, -1.891825, 0.689994, 1.450415, -2.241817, 0.758341, 0.709624, -0.146888, 0.361636, 1.845548, 1.293675, -0.664716, -0.430211, 0.496908, -1.462300, -0.583651, 15.350691, -0.486010, 1.501931, -7.990520, -5.199618, -4.815531, -0.498327, -0.372486, -2.168638, 0.490262, 4.292321, 0.295694, -0.359475, 5.268822, -1.180114, -0.924583, 0.038959, -0.845693, 1.072879, -1.131719, -0.342104, 0.685550, -0.431613, -1.936231, -9.245801, 1.822890, -1.069210, -12.479502, 27.755635, -1.151750, -0.201265, -0.318331, -0.910679, -2.444637, -2.982396, 1.185648, -1.786133, -1.520883, 0.824467, -0.473603, -1.558867, -0.347679, 0.622084, 4.299801, 0.003581, 0.968997, 0.444713, -1.571700, -0.990850, -2.571292, -1.385344, -1.181878, 0.069053, -0.185801, 0.663217, 9.190982, -2.266321, 0.059430, 0.197263, -1.641000, 0.347902, -3.178702, -0.155283, 0.733493, 2.475013, 1.132043, 1.142212, 0.667626, -1.559970, 1.941294, -3.856089, 0.404837, 0.394668, -3.783256, -2.583324, 0.022116, 3.492793, 0.162768, -1.032636, 5.525263, -0.810195, -0.145048, -0.336238, -0.867183, -0.370427, -2.732809, -0.801798, 6.237801, 2.194475, -3.915059, -0.512965, -0.264466, 2.387606, 0.452254, -1.293048, -1.327464, -4.917234, -1.849842, -0.309330, 0.081719, 2.566389, -0.825120, -0.024339, -1.092847, 3.374746, 1.203931, 0.214687, 1.417011, -0.518508, -0.122551, -1.314540, -1.596713, 1.330553, -0.501785, 0.653234, 7.038198, 0.050109, -3.634729, 0.677244, -2.104286, -0.681897, 0.415518, 5.591555, -1.671477, 0.768385, -1.995153, 0.769896, -0.946671, 0.365515, -0.412060, -0.836795, -1.335685, -0.716340, 1.412605, -0.142682, 0.021318, 0.698544, 0.022026, 0.050070, -0.799434, -0.664229, 0.210456, 0.001266, -0.106869, 2.701509, 3.360289, -0.516494, -0.710802, -0.251055, -0.506823, -1.150125, -1.273121, 0.143254, -0.143342, -0.832588, -0.794392, -0.506215, 0.943084, -1.621983, 0.121077, -1.155152, 0.040856, 0.116072, 1.113601, 0.712526, -0.040277, 0.331410, -0.130763, -0.968979, -0.388046, -7.969836, 0.510975, -0.667450, -4.914379, -3.821821, 2.157458, 2.005769, 17.459014, 1.638029, -5.425853, 0.614108, -1.983086, -0.931254, -0.096571, 2.477630, -0.735214, 2.097430, 1.707267, -3.451110, 0.851731, -0.346040, -0.077622, -0.977103, -1.410358, 0.307259, 0.500183, -0.124771, -1.809733, 7.426100, 0.045949, 1.091455, -1.762914, 1.171669, -4.459613, 0.184512, 5.205543, -0.135109, -3.035409, -0.141994, -2.973544, 0.988559, 2.203294, 0.063250, -0.081095, -0.885448, -1.477631, 2.154930, -1.276073, 10.413014, 1.056383, -2.168408, -5.180995, -3.315927, -0.307443, 0.111821, 5.806733, -1.222921, -6.002231, 3.476266, 1.994445, -3.566351, 1.778595, 0.887521, -2.367527, 7.262003, 2.605526, -4.798466, -0.958272, -1.981247, -4.141927, -8.096129, -4.387438, -0.259468, -4.078041, 8.555163, 0.274482, 1.753861, 4.054073, -0.291967, 1.668331, 2.661386, -2.038887, 0.209710, 3.229117, -2.484570, 0.617751, -0.317118, 3.336178, 1.739071, -6.761088, -1.712914, -0.696780, -0.658107, 3.552192, 0.883871, -0.176278, -1.451032, -2.398575, 0.688319, -1.881055, -2.631822, 7.064659, 0.269806, -0.104857, -0.860072, 0.551352, -1.885564, -0.549473, 4.802623, -2.391472, -1.543746, 0.246725, -0.304647, -0.846932, -1.644220, 2.672324, -1.113002, 2.545216, -0.879193, 3.082014, 7.080933, -1.712085, -1.047680, 1.811296, -0.942040, -0.742491, 0.000601, -7.388284, -2.357472, 3.173572, 0.496868, -1.673136, -1.576120, -1.401982, 2.463499, 0.160530, -2.386639, -0.442646, 3.332836, 1.589638, -1.226880, 0.602868, -1.425267, -0.939674, -1.842199, -1.465172, 1.427040, 2.271986, 0.172513, -0.601500, -2.342704, 2.187652, 1.542052, 0.991239, 2.433396, -1.516965, -0.796204, 0.105705, 1.367642, -1.563630, 0.023282, -1.075819, 0.143853, 0.333621, 0.037269, 0.618840, -0.900650, -1.139442, 1.207665, -0.607073, -0.633617, -0.976125, -0.081481, 7.108243, -0.195711, -2.565366, -0.087544, -1.159582, -1.970702, 1.520434, 3.197576, -2.688143, 4.439722, -3.908885, -1.017372, 0.178626, 0.229819, -0.070440, 3.846992, -3.799127, -0.957701, -2.538059, -0.479994, -1.669846, -1.082329, 1.512642, 0.234999, 0.139333, 5.528910, 0.091666, -0.992987, 0.051779, -1.557479, -1.342833, -0.904935, -0.760138, -0.512220, 2.103301, 2.056607, 2.347723, 0.574479, -1.107511, 0.776800, -1.759866, -1.633202, 0.331037, 1.209327, -6.429224, 8.379463, -4.599133, 0.579612, -0.070896, 2.264230, 0.041662, 0.202745, -0.303498, 0.804231, 2.692096, 0.103968, -2.896998, 0.858105, 1.661943, -0.231587, -0.193596, -2.120387, -0.262072, 0.288969, -0.695202, -1.280815, -1.268639, 1.558276, -0.412768, 4.195785, -0.676379, 0.619071, -0.248197, -3.863144, -0.098502, 1.755791, -0.155825, -1.055886, -2.818222, 0.652938, -3.742795, 1.667294, 3.980591, 0.445367, 0.058447, 0.211016, -2.049107, 0.350403, 2.301643, 0.106427, -3.791815, 0.885591, -0.275072, 0.917202, 0.610759, -0.052119, 5.153973, 0.919360, 0.028931, -0.205493, -4.327971, -0.806819, -3.041530, -1.294422, 4.922730, -1.792939, 2.370863, 1.179608, 0.080816, 0.380455, -0.921172, -0.490276, -0.574482, -0.913861, -2.260224, 0.056522, 0.167818, 0.730174, -2.180851, -2.270424, -0.897422, 5.971008, 0.373069, 1.231618, -0.127638, 2.138093, 5.417447, -0.001002, -1.503207, -1.013557, -0.538106, 0.279747, 0.448891, -0.100993, -0.098135, -1.187920, -3.888219, -0.859296, 5.472087, -0.298719, -0.396331, -1.224933, 2.885930, -0.819990, -0.732517, 0.534423, -0.909503, -1.266188, -2.527748, 0.576039, -0.081663, -4.716460, 2.003142, 0.999076, -1.180670, -2.059714, -0.060104, 2.626899, 3.686713, -1.419412, -0.472347, 0.582172, 12.176504, 0.887128, -2.063595, 0.774601, -15.141256, -0.411225, 0.271824, -1.705695, 0.119376, 0.420149, 4.130386, 0.761612, 2.010930, -7.957617, -0.483824, -0.910180, -5.275866, -5.814842, 1.824516, 0.103527, 9.821132, 3.057010, 2.672974, -0.025047, 1.284345, -3.052129, 18.150250, -10.878895, 0.457400, 0.490739, -3.716963, 0.029116, 0.920166, -1.240704, -2.415388, -0.582831, 0.920843, 0.187853, -0.102072, 0.708075, 0.051375, -0.564364, -0.120438, -0.709203, 0.460875, 0.127120, -0.390749, -1.044263, -3.728311, -0.261230, -1.123903, -0.045225, 1.452609, 1.166392, -0.865734, 4.180145, -0.671968, 2.691020, -1.853664, -0.473374, -0.897405, -0.712922, 0.158243, -0.772724, -0.342406, -1.554926, -1.882150, 5.537612, 0.208991, 0.131747, 0.468469, 0.007064, -0.646292, -1.933131, -1.874666, -1.541816, 2.143640, 1.098651, 1.932152, 1.648742, 3.527288, -1.750940, -2.771556, 1.991913, 2.232842, 0.391271, -7.349827, -0.295298, -0.855858, -1.179369, 4.897382, -3.767585, 5.045139, 1.666342, -2.843036, 0.112837, -1.209298, 1.244221, 0.924522, -0.868748, -1.155922, -0.063515, -0.626026, 0.878636, -0.135192, -0.701597, 1.635077, -1.531386, -5.273215, -0.556045, -0.307159, 2.034645, -4.201588, 0.542455, 0.342850, -3.597736, 1.254923, 9.550319, 1.861165, 0.433720, 0.457712, -3.253041, -0.530029, -2.555928, -1.398321, 3.333808, -0.026316, 0.293881, 5.054846, -0.685888, -1.227411, 2.373377, 1.789004, 0.609239, -2.814323, 2.482060, 3.663652, -2.492067, 2.046143, -0.508593, -3.520126, -2.279684, -1.297441, 5.765455, -0.015475, -0.676007, 0.011273, -0.542928, -0.375762, -2.620858, -1.079925, -0.598391, 0.205581, -0.042750, 0.133941, 1.106649, -2.625392, -0.552804, 0.248908, -0.445876, -0.086404, -2.638458, 5.539598, 1.416570, -2.044736, 0.521605, -0.446236, 5.359515, 3.514726, 1.167264, -5.394776, -3.466067, -7.377391, -0.173116, -0.198234, 5.842374, -0.190536, -2.692837, 3.601729, -1.346158, -4.125651, -0.355565, 0.735512, -2.067183, 18.192574, 0.080264, 0.915915, -7.028189, 0.158714, -3.157642, -1.995237, -0.104099, 16.928910, -1.670148, 2.322103, -1.421508, -12.029489, 0.526300, -0.294507, -3.472692, 0.312857, -2.602349, 1.474193, -0.743560, -0.216975, -0.212888, -1.148728, 0.679036, -3.514979, -1.324215, -0.745866, -2.855462, -5.244793, -0.008316, 15.576627, 2.035533, -0.813620, -1.530220, -0.529715, -2.790555, -4.005853, 1.021477, 0.917513, 4.902181, -0.515953, 2.507557, -1.272092, 0.582365, -4.223804, -3.560569, -2.114504, -0.184939, 0.285054, -0.379540, -0.280552, 0.693779, 1.389409, 8.381615, -0.631815, 1.829548, 2.421827, 2.067022, 0.021191, 0.060084, -3.077455, -2.247266, -0.637888, 1.049173, 0.302165, -1.811482, 0.060183, 0.341562, -0.641242, 0.562662, -0.353145, -1.409709, 2.180580, -0.371777, -0.751610, -2.153394, -2.690955, 1.421059, 3.964328, 1.147358, -0.950578, -3.636637, 2.036458, -1.263450, -2.177652, 10.649108, 0.511950, -0.355625, -6.055799, -0.546450, 0.798573, -0.562810, -1.597501, 0.309641, -0.319883, 4.899253, -0.081717, 1.468053, -0.460358, -1.467465, 0.630675, -1.834867, -0.895922, -6.697124, -4.273582, -0.168611, 3.936913, 7.776686, 0.728063, 1.202654, 1.449403, 2.376157, -1.996854, -5.043338, 0.659996, -1.859066, 2.540616, -0.360160, -0.036567, -0.859196, -0.391381, 0.320621, -1.737455, 0.004409, 0.638947, 0.353147, 1.308334, -12.761017, 1.813841, 0.974887, 6.520335, -7.394313, 3.937296, 1.956896, 4.535708, -2.238238, 0.235746, -0.584225, 2.624808, -0.535087, -0.399797, -0.307397, -0.407107, -2.385499, -0.564543, 0.516836, 0.226370, 4.365629, -0.822636, -0.474246, 0.667257, 1.922612, 0.067583, -3.643414, -0.348649, -1.679906, 1.611081, -6.192971, 0.387252, 2.724240, 13.435664, -3.940692, -4.624438, -0.468400, 11.705411, 1.298461, -0.176340, 1.282782, 2.140005, -2.687525, -7.747935, -1.174444, -2.232485, 1.068370, -3.078659, 0.943442, 1.546369, 1.313551, -4.527465, 0.468134, 0.046404, -1.289681, -0.644019, -1.211155, -0.681423, 1.316196, 2.755992, 0.873492, 0.616573, -0.862655, -0.027888, -2.292955, -2.701236, -8.558141, 0.472116, 0.383736, 12.445273, 0.577616, -1.123245, 24.145149, -3.496058, 1.423792, -1.271320, -29.703461, 5.491328, -0.528033, 1.166974, 0.747277, 5.500105, -4.247457, 1.076439, 1.129185, -0.139943, 0.795246, 2.074381, 0.638955, -0.630422, -1.083956, -0.780251, -0.708634, 1.458703, -2.972733, 0.298693, -0.705783, 1.081650, 0.415398, 0.096370, -0.125983, 2.642268, -2.300168, -1.456570, -0.246068, 0.285077, -0.011143, 0.282064, 0.085089, -1.521460, 0.197488, -0.045437, 0.346398, 0.597492, 0.111274, 0.400476, 0.228384, -0.111619, 0.143272, -0.419912, -0.196928, -1.456497, -0.511109, 0.402787, 1.450893, -1.950880, 0.721385, 0.004672, -2.175080, 0.098092, 3.160676, 0.538833, -0.805932, -1.400130, -0.398393, 1.841518, 1.686859, -1.354824, -1.517576, -1.968137, -0.932777, 1.650946, 1.937746, 1.308564, -0.304842, 0.189073, 0.310804, 0.355274, 0.398837, -0.312768, 0.402334, -1.303481, -0.238888, 0.006112, -0.069883, 0.589362, 0.691743, -0.589638, -3.407928, 15.259158, -7.816179, -0.353049, 2.085845, -3.902213, 0.202544, -0.235503, -0.998893, -0.853511, 0.134197, -0.291091, -0.541246, 0.628380, -0.148330, -0.312958, -1.181170, 3.605311, -0.421170, -0.554073, -0.002534, -0.927519, -0.388908, -1.090670, 0.190806, 0.039857, -0.053169, -1.270024, -1.693309, -0.845307, -0.080298, 0.610073, 0.080955, 4.538601, -0.351984, -1.564110, -2.358488, -0.574838, -0.249594, 1.138366, -3.830832, -1.074750, 1.410227, 1.172166, 0.468812, 5.774044, 0.048643, -2.158864, 1.174210, 0.231967, 0.947501, 5.829961, -1.634424, 0.371840, -5.423077, 0.586065, 0.784140, -0.650187, -5.424657, 3.262429, -1.376289, -9.989991, 16.564083, 0.599924, 1.094015, 0.365215, -0.567000, -3.937133, -1.786029, 1.144762, -0.472326, -2.149370, -2.195408, 1.352101, 0.636162, 0.236830, 8.130568, -0.091010, -3.471606, -3.623359, -1.203372, 3.039255, -0.317021, -6.733444, 1.523557, 1.219319, -0.465864, -0.448658, -0.391655, 2.507965, 1.201172, 1.023934, -0.118664, 1.041366, -0.181194, -0.169015, 9.737222, -5.316088, 5.096773, 2.000503, -6.606748, -0.707421, -1.089718, -8.487845, 3.713778, 2.194647, -9.159864, 2.072321, -0.662900, 0.472033, 1.806638, 1.045261, -1.403877, 2.589212, -0.532089, 1.068475, 2.610754, -0.212541, 0.215723, -0.076495, -0.016997, 3.015402, -2.091285, -3.111785, 3.692873, 1.074740, 1.359616, -2.360205, -0.439791, -1.231741, -3.266318, 1.070918, 1.892871, 0.101084, 0.715598, 0.285416, -0.415451, -0.590637, -0.342701, 0.275947, -0.072564, 0.272742, -0.089846, -1.848986, -1.806810, 0.958805, 0.550973, -1.166918, -1.067935, 1.945878, -0.411805, 4.982387, -1.361527, -0.727900, -1.710322, -3.768835, 1.422632, 1.055721, -1.263796, -2.254269, -0.410483, 3.003856, -0.654167, -0.376289, 1.487644, 3.506861, 0.350931, -1.167740, 1.902629, 2.268830, 1.356111, -1.643089, -4.584475, -7.235935, -0.702830, 8.695721, -1.042973, 1.851165, 0.813560, 0.059198, -2.929964, 1.993792, -1.676108, 2.551338, -9.570638, -1.618021, 1.237815, 5.566838, -0.986209, 4.451018, -1.095799, 0.229238, 1.097434, 0.316821, -1.654546, -4.854545, 0.039375, 0.944020, -1.753854, -0.768746, 7.091787, 0.433246, -0.358319, -1.187524, 0.213523, -1.018627, 1.430448, -2.715789, -0.968809, -0.612079, 6.301971, 0.951016, -1.265439, -0.896202, 0.497663, 0.364654, 13.191124, 1.509061, -0.934682, -1.139831, -2.469801, -0.245556, -1.312202, -7.707561, -1.168500, -0.334182, -1.030615, -0.486292, -0.987719, -1.392114, 3.397860, -0.447598, -0.325458, -0.961498, 0.723841, 2.278916, 0.022332, -0.841359, 3.261962, 0.151178, -2.703040, 5.987968, 0.027546, -1.118606, -1.821194, -0.965554, 0.141461, 2.029534, -1.096103, -3.819772, -0.576145, -1.342969, -0.946163, -0.248602, -0.463006, 0.751882, 6.942831, -1.147966, 1.233354, -0.339464, -0.103257, -3.796754, 0.363623, -0.439456, 0.098262, 1.194600, 0.638536, -0.847469, -2.827768, -2.499011, -0.742593, 0.379354, 0.408965, 4.361608, 0.265684, 0.216027, -0.829250, -0.114202, 0.691759, 0.219488, 0.872705, 0.043988, 0.087781, -0.376727, -0.281790, -0.792541, 0.997498, -0.028948, 0.197837, 0.827821, -1.198873, -0.189797, -0.532883, -0.791983, -0.723977, 1.047742, 0.485251, -0.057221, -1.559245, 1.833973, 2.535590, -0.104591, 1.549957, -2.215396, 1.303028, -0.222464, 2.540264, -1.684154, -2.101394, -1.927898, 0.783952, -2.914593, 3.018563, 0.564275, 1.281464, -0.531956, -1.231738, -1.088537, -3.203235, -0.557540, 2.011635, 2.064799, -1.618354, -1.690081, -0.186657, 0.714543, 0.589465, -2.308402, 0.316589, -0.767866, -1.277258, 0.805480, -0.557176, 6.051822, 0.647579, -0.400642, -0.059865, -0.023940, -0.673097, -0.099333, -0.064976, 0.626882, 0.111193, -0.153560, -0.030102, 0.131513, 0.227273, -1.923056, -0.555579, -0.997445, 3.532601, 4.475140, -0.458612, -2.108453, 0.040389, 1.058343, -0.059922, -3.233584, -1.323301, 1.017103, -0.056975, 0.049748, 0.944346, -0.253670, -0.150966, -1.003509, -0.024053, 0.426249, 0.055730, 0.285313, 1.824733, -0.302483, -1.018629, -1.280511, 0.619899, 1.416772, -3.348682, -0.987689, 2.722232, 2.169179, -0.633462, -1.250873, -0.489851, -2.661385, 1.733637, 3.241716, 2.026820, 1.523323, -11.716603, -1.167781, 1.064342, 1.653881, 1.200816, 3.603628, -1.592810, 6.935885, -1.203908, 1.320223, -0.588881, -4.373678, 1.315941, 0.152635, 0.618668, 0.806554, -1.357090, -2.166215, 0.170869, 0.876758, -0.804483, -0.693027, -0.722584, -1.182507, -0.656372, 0.423020, -2.087910, -3.207851, 7.584846, 0.345423, -0.881448, -0.442015, 3.031757, -0.623240, -0.118069, -0.473689, -1.227133, 0.776385, -0.930931, 1.319548, 0.875184, -1.319263, -0.523354, -2.019877, -0.667724, 0.120480, 1.427496, -1.406264, -0.610288, 7.364481, -0.382306, -3.223408, -0.414085, 0.359373, 21.296753, -1.949173, 1.024817, -7.098675, -12.743850, -1.673460, -0.274426, -1.987931, -0.342686, 0.021986, 2.985119, 1.216255, 0.574066, 1.331864, -3.692486, 1.036963, -0.774874, 2.582724, -0.170698, 0.499754, 0.402443, 1.750914, -0.616584, -3.027498, -0.858546, -0.166680, 0.740861, 1.448527, -3.104639, -0.130359, 0.870182, -0.497438, -1.106091, -2.189774, 4.139798, 0.873992, -1.928892, 5.106760, -0.028649, -0.329398, 3.141819, -1.411309, -7.806238, -4.888181, 3.185822, -0.847803, 2.924143, 2.760986, -0.681764, 2.241407, -0.338771, 0.979514, 1.391295, -3.219076, 1.209098, -2.168633, -1.034456, -8.941735, -0.651146, 11.444236, 1.297791, 1.700431, -2.193472, -1.031992, 0.715251, 1.333474, 15.613646, -0.180224, -1.194687, -9.748568, 1.185917, -7.361432, 1.085809, -2.133953, -4.190132, -1.229672, -0.141483, 15.246949, 1.542603, -2.446534, -3.926736, -2.726253, -0.338427, -0.703283, -0.095430, 2.180207, -0.489245, -0.264863, 0.891430, -0.500518, 0.744862, -1.427209, -0.339276, -0.552805, -0.705309, 0.568983, -2.794817, -1.936455, -1.219228, -1.223133, 0.941817, 0.216688, 3.433556, 1.823210, 0.876557, -1.038100, -1.079130, 1.939089, 2.248407, 0.287628, -6.003989, 0.619166, 0.808204, -1.956353, 0.222764, 1.086296, -1.847458, -1.531917, 5.935631, 0.207383, -2.723219, -1.820532, -2.654762, 3.089189, -2.544373, 6.839220, 3.046709, 3.215002, 1.781530, -4.770467, -1.675814, -1.913868, -0.871453, -2.045314, -0.402973, 0.729803, -1.078573, 2.465752, 5.854624, -3.734119, 0.410306, 0.031789, -2.088414, 0.752673, 0.893895, 1.296231, 0.835230, -0.117464, -0.465046, 1.586212, -0.656202, -0.682526, -0.324301, -0.471065, 0.302524, -2.198609, -0.837316, -1.397613, 0.612332, 4.459962, -0.740607, 0.800131, -1.369153, 0.747124, 1.759487, -1.680172, -1.371667, -0.993200, 0.917652, 3.311163, 0.084982, -3.555572, -4.044758, 0.468296, -0.323731, 0.469708, 3.591539, -1.280285, 1.352555, -1.162790};
static RBF_CONST rbf_float RBF_BIAS[] = {3.885497, 1.571716, 0.105992, -0.527496, -2.832504, 0.553653, -0.345957, 1.851562, -0.693973, -1.417329, -0.378844, -1.711310};

#if RBF_USE_NORMALIZATION
static RBF_CONST rbf_float NORM_IN_MEAN[] = {0.012524, 0.011168, 0.010055, 0.004432, 0.005949, 0.006603, 0.003790, 0.003309, 0.004367, 0.005556, 0.002002, 0.004671, 0.004016, 0.000928, 0.004592, 0.007021, 0.007635, 0.008629, 0.008452, 0.009150, 0.008997, 0.008806, 0.009148, 0.008658, 0.007862, 0.009718, 0.007429, 0.005916, 0.007701, 0.011219, -0.001548, 0.000633, 0.006765, 0.001602, -0.000169, 0.006551, 0.001026, 0.002136, 0.001794, 0.004300, 0.000263, 0.001040, -0.000124, -0.000095, -0.004503, -0.004034, 0.001382, 0.010836, 0.007101, 0.005748, 0.003493, 0.008363, 0.013820, 0.014134, 0.003639, 0.010138, 0.006532, 0.008933, 0.005145, 0.010096, -0.010780, -0.010349, -0.013454, -0.000409, -0.004171, -0.005631, -0.008223, -0.007632, -0.000969, -0.003737, -0.006464, -0.013815, -0.012234, -0.003141, -0.016746, -0.009154, 0.001259, -0.014103, -0.010193, -0.004995, -0.006756, 0.000544, -0.005190, -0.008718, -0.009975, -0.014948, -0.005028, -0.012734, -0.014397, -0.009037, 0.004989, 0.008941, 0.007144, 0.007440, 0.002708, 0.002041, -0.006991, 0.003740, 0.002342, -0.003869, -0.006632, 0.000336, 0.004626, 0.004286, -0.000564, -0.001144, -0.000722, 0.015728, 0.008321, 0.006889, 0.013381, 0.014494, 0.020972, 0.021008, 0.004303, 0.015498, 0.011255, 0.012804, 0.008647, 0.015148};
static RBF_CONST rbf_float NORM_IN_SCALE[] = {0.997338, 0.995202, 0.993008, 0.994557, 0.997468, 0.999854, 0.998349, 1.000235, 1.001992, 0.999279, 0.999906, 0.999074, 0.999159, 0.998852, 0.997974, 0.994508, 0.993709, 0.993968, 0.997303, 1.000558, 0.998086, 0.994645, 0.994647, 0.998962, 1.003583, 0.999004, 0.995026, 0.995603, 0.997072, 0.998984, 1.007682, 1.015553, 1.015839, 1.013344, 1.012521, 1.013557, 1.012583, 1.013301, 1.010982, 1.004945, 1.013300, 1.009507, 1.004639, 1.003466, 1.005021, 0.998558, 1.012246, 1.014717, 1.019581, 1.019733, 1.014228, 1.011177, 1.009326, 1.011706, 1.004440, 1.012002, 1.011833, 1.015081, 1.014339, 1.011649, 1.002443, 1.007082, 1.013958, 1.002171, 1.007335, 1.013750, 1.007755, 1.008978, 1.010783, 1.011220, 1.006845, 1.011117, 1.006592, 1.005554, 1.005010, 1.002849, 1.008369, 1.016702, 1.005056, 1.006811, 1.010217, 1.013220, 1.016792, 1.022904, 1.014390, 1.013852, 1.014976, 1.022773, 1.019057, 1.014189, 1.003253, 1.015721, 1.024795, 1.011496, 1.004809, 1.002934, 1.004258, 1.016177, 1.013370, 1.007935, 1.011621, 1.005717, 1.007669, 1.012225, 1.011813, 1.009335, 1.016833, 1.016397, 1.024124, 1.025141, 1.021932, 1.016820, 1.016858, 1.019304, 1.015818, 1.015055, 1.024281, 1.020812, 1.015767, 1.016519}; // StdDev
static RBF_CONST rbf_float NORM_OUT_MEAN[] = {0.078289, 0.085565, 0.081781, 0.081781, 0.081490, 0.084692, 0.082654, 0.084692, 0.087602, 0.085565, 0.083818, 0.082072};
static RBF_CONST rbf_float NORM_OUT_SCALE[] = {0.268625, 0.279720, 0.274031, 0.274031, 0.273586, 0.278422, 0.275359, 0.278422, 0.282715, 0.279720, 0.277115, 0.274475}; // StdDev
#endif

// ==========================================
// Implementation
// ==========================================

RbfModelRBF::RbfModelRBF() {
    for(int i=0; i<RBF_HIDDEN_DIM; i++) hidden_activations[i] = 0;
}

void RbfModelRBF::predict(const rbf_float* input, rbf_float* output) {
    // 1. Prepare Input (Normalize if needed)
    rbf_float processed_input[RBF_INPUT_DIM];
    #if RBF_USE_NORMALIZATION
        normalizeInput(input, processed_input);
        const rbf_float* in_ptr = processed_input;
    #else
        const rbf_float* in_ptr = input;
    #endif

    // 2. Hidden Layer (RBF)
    for (int i = 0; i < RBF_HIDDEN_DIM; i++) {
        rbf_float dist_sq = euclideanDistanceSq(in_ptr, i);
        rbf_float width = RBF_READ(&RBF_WIDTHS[i]);
        hidden_activations[i] = computeKernel(dist_sq, width);
    }

    // 3. Output Layer (Linear)
    for (int j = 0; j < RBF_OUTPUT_DIM; j++) {
        #if RBF_FIXED_POINT
            int64_t sum = 0;
        #else
            float sum = 0.0f;
        #endif

        for (int i = 0; i < RBF_HIDDEN_DIM; i++) {
            rbf_float weight = RBF_READ(&RBF_WEIGHTS[i * RBF_OUTPUT_DIM + j]);
            #if RBF_FIXED_POINT
                sum += (int64_t)hidden_activations[i] * weight;
            #else
                sum += hidden_activations[i] * weight;
            #endif
        }

        #if RBF_FIXED_POINT
            sum = sum / RBF_SCALE_FACTOR;
            output[j] = (rbf_float)sum + RBF_READ(&RBF_BIAS[j]);
        #else
            output[j] = sum + RBF_READ(&RBF_BIAS[j]);
        #endif
    }
    
    // 4. Denormalize Output
    #if RBF_USE_NORMALIZATION
        denormalizeOutput(output);
    #endif
}

void RbfModelRBF::normalizeInput(const rbf_float* input, rbf_float* norm_input) {
    for(int i=0; i<RBF_INPUT_DIM; i++) {
        rbf_float mean = RBF_READ(&NORM_IN_MEAN[i]);
        rbf_float scale = RBF_READ(&NORM_IN_SCALE[i]);
        #if RBF_FIXED_POINT
             // (Input - Mean) * SCALE_FACTOR / StdDev
             int64_t diff = (int64_t)input[i] - mean;
             norm_input[i] = (rbf_float)((diff * RBF_SCALE_FACTOR) / scale);
        #else
             norm_input[i] = (input[i] - mean) / scale;
        #endif
    }
}

void RbfModelRBF::denormalizeOutput(rbf_float* output) {
    for(int i=0; i<RBF_OUTPUT_DIM; i++) {
        rbf_float mean = RBF_READ(&NORM_OUT_MEAN[i]);
        rbf_float scale = RBF_READ(&NORM_OUT_SCALE[i]);
        #if RBF_FIXED_POINT
             // (Output * StdDev) / SCALE_FACTOR + Mean
             int64_t val = (int64_t)output[i] * scale;
             output[i] = (rbf_float)(val / RBF_SCALE_FACTOR) + mean;
        #else
             output[i] = (output[i] * scale) + mean;
        #endif
    }
}

rbf_float RbfModelRBF::euclideanDistanceSq(const rbf_float* input, int center_idx) {
    #if RBF_FIXED_POINT
        int64_t sum = 0;
    #else
        float sum = 0.0f;
    #endif
    int base_idx = center_idx * RBF_INPUT_DIM;
    for (int k = 0; k < RBF_INPUT_DIM; k++) {
        rbf_float c = RBF_READ(&RBF_CENTERS[base_idx + k]);
        rbf_float diff = input[k] - c;
        #if RBF_FIXED_POINT
            sum += ((int64_t)diff * diff) / RBF_SCALE_FACTOR;
        #else
            sum += diff * diff;
        #endif
    }
    return (rbf_float)sum;
}

rbf_float RbfModelRBF::computeKernel(rbf_float dist_sq, rbf_float width) {
    #if RBF_FIXED_POINT
        if (width == 0) return 0;
        double d = (double)dist_sq / RBF_SCALE_FACTOR;
        double w = (double)width / RBF_SCALE_FACTOR;
        return (rbf_float)(exp(-d / (2.0 * w * w)) * RBF_SCALE_FACTOR);
    #else
        return exp(-dist_sq / (2.0f * width * width));
    #endif
}

void RbfModelRBF::printInfo() {
    Serial.println(F("Model Loaded: RbfModelRBF"));
    Serial.print(F("Normalization: ")); 
    Serial.println(RBF_USE_NORMALIZATION ? F("YES") : F("NO"));
}
