#include "RbfModelRBF.h"

// ==========================================
// Flash/PROGMEM Macros
// ==========================================
#if defined(ESP32) || defined(ESP8266)
    #define RBF_CONST const
    #define RBF_READ(x) (*(x)) // Fixed: Dereference pointer
#elif defined(__AVR__)
    #include <avr/pgmspace.h>
    #define RBF_CONST const PROGMEM
    #if RBF_FIXED_POINT
        #define RBF_READ(addr) (rbf_float)pgm_read_dword(addr)
    #else
        #define RBF_READ(addr) (rbf_float)pgm_read_float(addr)
    #endif
#else
    #define RBF_CONST const
    #define RBF_READ(x) (*(x)) // Fixed: Dereference pointer
#endif

// ==========================================
// Model Parameters
// ==========================================
static RBF_CONST rbf_float RBF_CENTERS[] = {-0.434746, 0.712214, -0.129079, 0.018171, 0.665007, 1.181797, 0.983034, 1.255276, 1.146487, 0.466816, 0.092213, -0.099156, -0.151304, 0.603627, 0.230035, 0.411967, 0.469695, 0.502784, 0.780698, 0.142251, -0.865099, -0.748744, -0.466700, -1.219704, -0.544464, -1.322264, -1.596706, -0.427749, -1.587135, -0.243795, -0.161985, -0.206117, -0.304588, -0.772741, -0.254931, -0.993102, -0.300750, -0.874775, 0.313916, 0.646258, -0.378236, 0.125728, 0.139923, -0.087887, 0.618151, 0.781163, -0.749410, -0.856795, -0.486340, -0.046666, -0.389327, 0.521334, 0.284832, -1.489799, 0.469137, -0.109955, -0.217676, -0.486089, -0.593730, -0.575028, 0.360906, -0.996229, -0.676779, -0.420564, 0.488058, 0.879977, 0.267551, -0.552657, -0.043575, -0.559983, -0.509671, -0.698466, -0.219747, 0.523737, 1.123391, -0.178828, 0.179605, 0.864921, 0.243625, 0.903481, 0.204711, 0.372009, -0.037622, 0.064296, 0.099770, 0.825165, -0.323504, -0.446937, -0.032194, -0.117407, 0.067765, 0.004435, 0.393414, -0.559790, -0.379908, -0.531582, 0.119185, 0.246240, 0.960434, 0.895745, 0.136170, 0.505170, 0.700983, -0.159269, 1.663016, 1.446088, -0.237472, -0.781419, -0.351857, -0.094124, -0.347583, 0.359350, 0.236287, -1.371436, 0.880215, 0.152390, 0.033397, -0.644116, -0.306980, -0.285005, 0.132699, 0.216263, 0.442714, 0.967192, -0.807130, -1.400890, -0.808444, 0.047684, -0.373813, -0.405667, 0.430987, 0.346294, 0.010989, 0.505772, 0.364451, 0.387464, 0.317853, -0.383535, 0.362184, 1.302361, 1.199592, 0.980448, 1.162420, 0.973033, 0.855756, 0.934632, 1.457231, 0.715347, 0.646611, 0.544119, 0.077129, 0.863410, 0.136257, -0.363264, 0.013784, 0.101747, -0.252204, -0.242331, 1.181940, 0.971405, -0.453921, -0.123582, -0.126691, 0.138282, -0.270065, -0.033719, 0.566192, -0.172037, -0.319156, -0.090619, 0.870757, -0.524083, 0.013712, 0.321721, 0.559436, -0.087331, -0.065128, 0.520619, 0.215522, 0.141630, -0.297834, 1.413172, 0.392581, -0.032571, -0.379753, -0.241910, 0.117587, 0.034751, -0.312787, -0.049793, -0.411091, -0.079691, 0.428698, -0.529921, -0.212154, -0.121403, -0.151626, 0.078206, -0.738559, -0.005282, 0.267453, -0.454838, -0.344936, 0.271642, -0.841968, -0.155437, 0.121117, 0.634740, 0.722201, 0.307420, 0.362855, 1.541092, 0.154997, -0.324396, -0.170339, -0.158532, -0.222527, -0.076205, 1.728059, 0.529756, -0.125395, -0.144321, 0.076391, 0.124529, -0.050554, -0.156968, 0.738905, -0.518254, -0.075378, 0.027567, 0.710642, -0.262061, 0.186233, 0.388326, 0.297321, -0.183022, -0.297568, 0.080809, -0.159086, -0.221029, -0.057173, -0.925315, -0.187971, 0.791428, 0.776892, 0.464576, 0.558480, 0.240611, -0.376493, -0.428249, 0.616751, 0.025053, -1.526800, 0.893401, 0.569013, -0.273526, 0.528999, 0.579882, -0.845534, -0.151037, -0.136001, 0.554578, 0.886405, 0.576778, 0.332209, 0.513864, 0.117031, -0.050210, 1.045756, -0.133111, -0.034995, 0.161759, -0.668269, 0.062068, 0.731554, -1.522070, -0.844105, 0.437246, 0.499236, -0.054557, -1.218447, -1.087326, 1.199059, -0.454104, 0.022878, 0.093484, -0.903372, -0.314000, 0.242832, -0.668390, 0.636280, -0.005508, -0.707882, -1.102599, -0.830930, 0.028409, 1.664315, -0.235043, -0.232299, -1.716969, -0.218346, 0.157657, -0.032263, 0.426576, 1.060194, -0.016843, -0.725060, -0.163881, -0.070736, 0.681914, -0.245079, -0.248047, 0.351433, -0.303804, -0.328822, -0.309985, -0.346031, -0.707252, -0.724854, 0.984307, 1.242287, 0.104545, -1.201065, -0.066558, -0.631825, -0.507499, -0.327864, -0.075338, -1.031018, 0.009873, -0.032242, -0.207750, -0.934513, 0.071429, 0.286648, -0.979535, -0.233925, -0.440479, 0.052341, -1.018162, -0.477227, -0.255561, 0.144385, -0.273408, 0.239832, 0.009124, 0.121153, -0.260328, 0.509434, -0.498411, 0.516395, -0.793951, 0.748994, -0.746769, -0.588097, -0.005700, 1.037172, -0.536433, 0.586268, -1.271521, 0.381784, 0.940547, 1.087682, 0.500805, 0.023923, -0.216693, -0.193114, 0.144377, -0.040306, -0.050535, -0.629629, 1.347628, 0.066778, 0.163921, -0.833856, -0.782352, -0.449411, -0.285059, 0.199145, -0.008878, -0.502020, -0.716437, -0.331537, -0.522041, 0.536297, 0.384172, -0.750054, -0.290466, 0.033585, -0.004317, 0.088947, 0.448707, 1.042377, 0.815899, 0.512686, 0.129015, 0.511750, 0.028308, -0.049766, 1.062338, 0.903482, 0.102194, 0.706349, 0.044601, 0.087423, 0.588226, 0.353415, 0.435200, 0.709923, 0.228165, 0.796864, 0.326249, 0.377660, -0.041327, -0.297318, 0.769953, -0.168108, 0.145348, 0.045486, -0.338079, -0.243986, -0.172493, -0.518300, -0.718805, -0.099904, 0.216477, 0.791376, 0.275001, 0.570230, -0.156989, -0.373054, 0.084161, 0.362929, -0.085413, -0.380710, -0.068123, 0.171914, 0.571833, 0.030632, -0.105362, -0.216550, -0.066706, 0.191787, -0.271499, 0.072661, 0.009338, 0.035405, 0.167639, -0.316625, 0.122317, -0.166791, -0.122993, 0.471815, 0.748355, 0.471371, -0.231307, 0.571206, 0.236170, -0.171909, 0.740630, 0.296446, 0.272260, 0.389832, 0.145592, -0.346554, 0.184658, -0.302607, -0.018772, 0.172882, -0.271812, 0.434644, -0.081205, 0.095907, -0.034859, -0.083657, 0.480895, 0.013915, 0.045182, -0.161728, -0.468061, 0.077423, -1.035711, 1.010367, 0.541392, 0.477526, 0.878425, 1.100352, -0.658890, -0.486422, -1.043171, 0.400889, 0.131493, 0.665745, 0.159614, 1.075476, 0.552888, 0.017788, 0.383146, -0.104038, -0.635111, 0.059724, -0.245479, 0.087276, -0.866962, 0.183081, -0.053469, 0.057879, 0.728474, -0.032497, 0.646711, -0.221310, -0.214774, -0.049312, -0.141848, -0.033468, 0.118655, -0.125797, 0.624751, 0.919788, 0.037969, 0.412950, 0.108898, 0.462299, -0.440545, -0.045794, -0.175783, -0.088365, 0.040755, 0.272981, 0.481166, 0.112328, 0.079132, -0.166511, -0.588855, -0.267111, -0.205117, -0.399136, 0.470129, -0.134756, 0.044045, -0.081165, -0.042445, 0.168398, 0.331276, 0.008683, 0.186933, -0.363875, -0.248807, 0.156386, 0.445317, 0.131359, -0.392996, -0.484544, -0.365972, 0.299538, 0.060195, -0.439750, 0.126689, 0.245489, 0.449117, 0.105487, 0.332881, 0.111544, -0.222290, -0.015057, -0.002790, -0.283841, -0.036176, 0.136576, -0.167869, -0.492508, -0.542963, 0.016375, -0.329311, -0.286209, -0.084707, -0.528763, -0.031107, 0.702024, -0.310980, 0.148032, 0.321014, 0.775827, -0.184119, 0.204891, -0.273513, -0.272379, 0.007983, -0.397000, 0.088426, -0.039931, 0.071439, -0.447971, -0.500305, -0.446846, -0.172383, -0.264294, 0.456059, -0.139272, 0.124319, 0.911607, 0.265368, -0.247083, -0.922322, -0.769790, 0.176419, -0.341513, -0.002986, 0.359513, 0.133316, 0.153853, -1.490842, 1.631087, -2.481941, 0.692219, 1.060814, -1.879472, -1.239227, -1.611903, -1.070301, -0.955910, -2.437775, -2.130860, -1.511919, -2.753040, -1.635946, -1.094274, -0.790390, -1.671113, -1.533054, -0.519366, -1.074307, -0.020957, -0.495052, -0.171336, -0.433802, -0.007448, -0.230297, 0.029069, -0.106685, -0.823123, -0.037063, -0.529595, 0.388395, -0.060658, -0.273896, 0.398802, -0.099556, -0.091912, -0.636168, -0.395229, 0.102954, 0.031228, -0.128773, 0.369646, -0.030028, -0.470942, -0.150069, 0.601810, -0.499351, 0.088196, 0.157090, -0.143625, -0.280602, -0.018812, 0.175528, -0.042344, 0.208120, 0.394633, 0.146845, 0.338752, 0.315963, 0.185651, 0.795600, -0.280640, 0.226718, -1.217188, -0.876596, 0.918203, 0.776093, 0.773360, -0.868369, -0.954735, 0.194794, -0.017139, 0.575888, 0.133458, 0.560226, -0.409538, 0.046367, -0.601054, -0.962872, -0.152255, -0.380580, 0.053626, -0.419163, -0.386369, 0.210355, 0.052171, 0.480840, -0.306127, 0.084745, -0.548552, 0.484537, -0.067138, 0.090355, 0.501606, -0.071099, -0.137257, -0.564267, -0.022752, 0.065809, 0.187485, 0.176615, 0.849962, 0.377779, 0.357526, -0.019174, 1.349169, -0.577742, -0.104818, -0.269395, 0.304476, -0.381090, 0.081179, 0.062035, 0.323021, -0.056925, -0.781152, 0.164121, 0.732768, -0.122886, 0.541997, -0.494786, -0.170709, -0.390236, -0.673638, -0.041022, -0.204363, -0.330163, -0.280520, -0.358134, -0.221718, -0.021878, -0.231233, 0.160759, 0.349769, 0.483800, 0.168335, 0.564645, -0.372651, -0.331122, -0.118569, 0.386145, -0.123799, -0.291742, 0.305024, 0.444663, -1.493184, -0.790215, -0.862334, 0.285298, 0.230352, 0.585370, -0.776643, -0.976382, -1.225883, 0.117279, -0.088031, -0.560426, -0.451153, -0.562467, 0.128816, -0.407625, -1.613999, 0.685982, 0.194453, 1.522505, -0.217646, -0.295617, 0.302569, 0.306740, 0.128627, 0.295424, -0.939112, -0.220404, -0.107534, 0.386336, 0.548356, 0.387599, 0.313634, -0.074391, -0.179667, 1.319002, 0.075709, -0.284669, -0.121014, -0.093870, -0.269303, -1.248361, 1.036602, 0.385523, -0.110515, -0.474361, -0.759985, 0.059844, -0.172027, -1.074229, -1.097038, 0.374286, -0.397613, -0.245922, -0.008016, 0.951384, -0.101423, 0.093129, 0.108086, -0.178662, -1.345940, -0.664114, -0.946823, 0.984892, -0.422964, 0.575116, -0.250852, -0.715988, -0.350891, 0.184390, -0.740739, -0.413758, -0.175446, -0.621282, 0.282107, -0.836208, -0.772461, 0.120086, -0.128505, 2.394043, 0.619152, -0.516046, 0.445880, 0.132423, -1.620787, -1.657465, -0.596503, -1.593186, -1.971551, 0.619684, -0.204515, -1.064155, -0.863208, -1.263324, 1.080966, -2.134053, -0.550195, 1.240194, -0.575083, -1.757970, 0.477737, -0.884832, -1.766499, -1.178101, 0.168054, -1.422297, -2.501138, 0.193107, -0.214893, -0.900308, -1.845689, -0.441083, -0.466334, -0.591126, -0.427339, -0.111686, -0.158638, 0.034642, -0.026534, -0.134572, -0.090012, -0.011549, 0.334399, -0.228798, -0.287214, 0.278512, -0.160249, -0.485656, -0.545678, -0.524876, -0.099241, -0.204706, -0.137560, -0.179338, -0.168603, -0.046228, 0.121576, -0.418292, -0.358630, 0.103982, -0.518549, -0.209884, 0.071669, 0.017625, 0.045026, 0.063692, -0.120280, -0.188056, -0.059779, -0.106511, 0.041572, -0.018448, 0.233175, 0.042630, -0.183567, 0.310650, 0.024202, 0.117372, -0.089842, -0.232181, 0.027198, 0.080811, -0.137290, -0.000715, -0.232588, 0.142148, 0.145960, -0.186312, 0.006701, -0.187901, -0.052941, 0.073363, -0.376799, -0.637879, -0.253137, -0.214957, -0.117820, -0.187880, -0.360296, -0.116363, -0.231247, -0.127163, -0.065171, -0.461426, -0.427766, 0.107352, -0.213025, -0.211730, -0.320545, -0.223856, -0.301002, -0.102237, -0.260056, -0.233608, 0.103277, -0.190417, -0.200190, -0.508763, -0.214774, 0.189507, -0.146337, -0.219049, -0.982765, 0.876241, -0.714522, -0.501129, -0.555858, 0.214164, 0.588527, -0.140297, 0.026426, 1.357458, 0.840559, -0.180018, 0.958679, 0.894924, -0.096018, 0.846089, 1.158953, 0.929435, -0.041788, -0.016329, 0.078191, 0.454653, 0.301622, -0.166554, -0.057281, -0.505450, -0.158421, -0.790902, -0.100042, 0.118353, -0.258732, -0.680810, -0.386052, -0.410247, -0.200331, -0.477742, -0.429026, -0.343242, -0.402936, -0.253424, 0.394936, 0.253133, -0.018207, 0.172691, -0.182770, -0.014032, -0.281557, 0.060120, -0.218411, -0.398992, -0.001193, -0.622504, 0.055011, 0.360459, 0.009286, -0.471449, -0.109923, -0.119346, -0.222182, -0.425815, -0.030820, 0.131852, 0.010533, -0.084216, -0.009119, 0.083641, 0.026123, 0.117707, 0.160291, -0.209140, -0.120723, -0.174719, -0.058089, 0.138282, -0.183175, 0.127274, 0.333417, -0.103276, 0.375448, 0.046537, -0.346194, -0.256239, -0.127243, 0.309721, -0.318550, 0.017480, -0.058222, 0.274327, 0.360727, -0.108758, -0.346135, -0.611284, -0.222214, -0.353807, -0.044128, -0.389605, -0.461549, -0.210530, -0.272492, -0.303690, 0.275916, 0.332492, -0.107108, 0.018437, -0.115479, -0.109717, -0.079827, 0.052523, -0.205435, -0.328844, -0.382341, -0.665492, 0.080678, 0.143547, 0.268536, -0.274694, -0.419350, -0.321164, 0.188505, -0.248500, 1.984588, 2.867548, 0.939967, 0.820024, 0.114552, 0.082079, -1.072207, -2.896362, -2.963217, -2.182693, -1.781857, -2.280564, -0.886825, -0.541371, -0.356300, -0.890756, -0.095652, -0.455554, -1.367921, 0.309205, -0.635166, 0.670066, -0.490418, -0.121267, -0.420590, -0.689112, -0.354578, -1.512798, -1.164985, -0.777192, 3.450668, 2.235632, 0.765388, 1.727145, 4.000607, 2.806629, 0.964439, 1.324361, -0.477835, -0.612028, 1.016794, 0.951614, 0.355510, 0.459203, 0.210618, 0.157520, -0.689183, -0.742897, -1.461332, 0.007962, -0.631609, 0.482965, -0.397486, -0.024286, -1.502444, -0.393306, 0.564757, -0.298676, -0.491366, -0.197238, -1.567152, 0.399407, 1.100721, 0.649939, 3.262582, 0.668027, -0.957730, 0.184848, 0.223262, 0.486124, -0.932995, 0.679040, -0.008650, -0.233894, 0.114139, 1.171889, 0.227205, -1.161659, -1.087743, -0.946725, -0.164496, -0.344670, -0.633789, 0.106532, 0.136754, -0.858907, -0.737337, -1.023381, -0.533640, 0.442714, 2.820168, 1.317234, -0.612794, 0.978179, 2.464171, 1.787672, 0.772387, 0.170713, -0.168831, 0.224252, 1.271040, 0.810803, -0.020719, -0.256528, -0.375926, -0.457725, -0.636369, 0.150339, -0.940895, -0.188209, 0.077329, 0.300408, 0.230616, 1.241361, 0.178738, -0.310980, 0.415112, -0.253833, -0.225938, -0.662976, 0.633787, -0.522665, -1.856524, -1.055763, -1.852400, -2.942295, -2.803812, -2.073277, -0.039930, -0.884921, -0.495627, 0.305011, -0.349089, -0.521777, 0.439286, 0.194552, -0.638170, 0.510569, 0.427600, -1.051957, 1.135465, -0.629075, 0.233315, -0.671639, -0.604942, 0.437984, 0.915863, -0.606600, -1.266106, 0.299213, -0.461891, -0.163636, -0.268796, 0.318418, -0.508139, -0.090774, 0.105761, 0.317066, -0.166323, -0.228264, 0.363051, -0.313280, 0.018794, -0.304108, 0.245928, -0.637091, 0.391906, -0.184486, -0.189224, -0.210414, -0.357989, 0.174920, -0.137755, 0.034137, 0.633244, -0.231287, 0.248140, 0.369116, 0.193555, 0.140096, 0.029212, 0.130391, -0.041797, -0.151721, -0.115511, -0.346676, 0.042904, 0.408244, 0.235637, -0.279151, -0.337903, -0.056776, -0.061962, 0.200796, 0.298711, 0.531221, -0.055972, 0.084309, -0.044229, 0.228316, 0.019222, -0.117070, -0.193499, -0.158793, -0.397215, -0.083046, 0.244702, 0.091506, 0.111128, -0.014029, -0.555863, -0.491224, -0.150550, 0.303511, -0.352313, 0.002271, 0.195111, -0.012902, -0.219135, -0.095240, 0.077687, -0.288479, 0.134631, -0.318491, 0.261515, -0.335672, 0.052883, 0.264317, -0.101967, -0.192495, 0.030031, 0.351150, 0.031483, 0.194958, 0.413849, -0.063296, 0.346553, 0.167770, 0.020096, 0.178782, -0.060108, -0.909765, -0.114743, 1.096028, 0.961324, 0.629672, 0.141015, -0.198329, -0.476770, -0.625618, -0.654558, -0.581073, -1.881978, 0.548889, -0.179005, -1.160648, 0.040053, -0.615399, -0.721908, -0.523506, 0.603999, 1.231275, 0.771892, 1.325808, 1.429581, 0.911654, 0.901130, 0.487816, 1.436043, 0.920413, -0.135296, -0.293377, -0.344906, -0.236820, -0.183882, 0.037028, 0.141570, 0.358204, 0.289226, -0.278301, -0.313948, 0.513359, 0.759392, 0.049567, 0.147601, 0.058034, -0.469690, 0.174324, -0.721194, -0.365096, -0.318546, -0.235435, -0.161993, -0.029090, -0.267828, -0.209616, 0.172746, -0.061432, 0.263921, 0.447609, 0.030920, 0.087846, 0.019714, -0.103697, 0.142485, -0.060037, 0.009456, -0.137002, -0.264948, -0.224773, -0.003647, 0.166527, -0.257464, 0.112206, 0.205560, 0.331382, 0.037166, 0.251470, 0.135030, -0.262186, -0.316054, -0.099965, 0.339646, 0.200714, -0.239995, -0.079928, -0.059894, 0.119889, 0.241520, 0.086628, -0.431327, -0.320594, -0.269294, 0.091246, -0.150701, 0.100675, 0.201669, 0.059357, -0.029193, -0.382399, -0.424093, 0.296956, 0.482277, -0.068777, 0.291528, 0.003045, -0.374846, 0.323088, -0.305453, -0.249552, -0.176693, -0.239472, -0.178862, -0.040603, -0.187604, -0.170891, 0.014077, 0.020443, 0.163321, 0.331603, 2.473839, -0.078541, -1.546839, -1.190121, -1.107926, -0.173301, -0.505104, -0.739420, -1.323615, -0.067490, -0.124522, -0.742047, 0.256255, 0.191827, 0.109060, 0.128038, 0.351091, 0.003410, 0.576421, 0.502597, 0.365615, 0.381033, 0.310116, 0.681730, 0.666443, 0.841418, 0.045952, 0.073692, 0.286876, -0.268268, 4.809829, 3.423402, 1.798970, 1.745265, 0.496527, -0.155784, 0.939801, -0.091722, 1.322525, 0.090941, -0.072014, 0.272577, -0.265146, 0.155265, 0.150060, 0.368129, -0.827438, -0.143388, 0.047103, -0.300763, -0.406221, 0.419050, -0.095319, -0.174916, -0.972026, -1.086470, 0.264562, 0.092776, -0.197103, -0.395385, 2.855702, -1.113953, 0.225826, 0.218691, -0.113391, -0.248861, -0.165401, -0.078745, -0.476550, -0.622523, -0.697804, -0.331236, 0.069682, -0.429734, 0.066048, 0.101644, -0.194084, 0.031221, -0.282414, -0.498870, -0.308768, 0.148541, -0.890232, -0.427550, -0.125215, 0.138134, 0.208064, 0.154322, 0.089079, -0.177214, 4.330400, 2.359430, 1.367544, 1.605791, 0.378847, -0.069603, 0.816762, -0.404459, 1.227533, 0.642045, -0.287851, 0.183011, -0.138995, -0.005111, 0.206515, 0.679915, -0.483149, 0.028451, -0.089557, -0.554693, -0.306028, 0.567649, -0.052531, -0.140264, -0.401815, -0.700341, 0.424592, -0.061153, -0.183681, -0.036637, 0.386681, 0.624225, 1.252195, 0.827347, 0.274194, -0.135578, 0.046554, 0.557850, 0.223586, 0.048339, -0.661330, 1.465877, -0.298760, -0.016818, -1.212282, -0.736922, -0.680063, -0.246200, 0.042850, -0.253025, -0.599110, -0.617447, -0.529355, -0.749724, 0.442249, 0.620392, -0.869258, -0.121259, -0.483288, -0.322434, -0.087431, 0.529063, 0.372704, 0.373152, 0.237534, 0.536325, 0.230046, -0.118657, -0.066214, -0.468024, 0.551174, -0.231328, -0.181534, -0.352985, 0.388037, -0.400335, 0.912894, 0.759018, 0.462131, 0.973438, 1.236239, 1.317411, 0.247259, 0.170991, -0.071362, -0.030900, -0.041987, -0.659699, -0.392256, -0.489293, 0.205904, 0.002676, 0.403114, 0.049263, -0.323365, -0.243894, -0.124599, -0.188434, -0.366916, -0.003931, 0.228338, -0.221464, 0.307230, -0.076012, -0.216055, -0.404257, -0.379965, 0.189124, 0.405890, 0.267581, -0.344206, 0.007503, -0.389165, 0.123595, 0.195866, 0.515719, -0.285761, -0.216237, 0.198722, 0.008038, -0.257178, -0.185828, -0.034076, -0.103331, 0.140169, -0.096140, -0.174074, 0.072754, -0.177189, -0.197705, -0.166252, -0.450158, -0.036450, 0.090072, -0.300199, -0.370933, 0.272979, 0.423949, 0.014229, 0.709032, 0.709466, 0.843587, -0.085796, 0.517756, 0.020853, -0.019688, -0.178990, -0.402960, -0.232672, -0.462604, -0.259936, -0.438811, -0.610504, -0.067619, 0.105700, 0.183799, 0.100333, 0.019534, -0.655006, 0.658641, 0.587822, -0.250685, -0.395422, -0.991531, -0.940605, -1.021881, -0.129741, -0.516111, -0.707941, 0.198205, -0.241393, 0.162162, -0.195568, 0.434301, 0.263154, 1.070158, 0.609269, 0.127503, 1.072474, 0.041612, 0.228788, 0.382486, 0.895070, 0.408608, -0.430835, -0.233969, 0.620745, 0.455365, 0.610620, 0.850222, 1.012981, 1.021428, -0.282800, 0.594524, 0.818868, 0.637000, 0.034157, -0.432866, 0.451840, 0.212494, -0.406570, 0.179096, 0.255823, 0.037037, -0.156112, -0.274952, 0.514737, 0.025062, -0.360903, 0.241127, -1.179499, 1.158164, 0.275132, -0.081584, -0.311628, -0.195154, -0.533368, -0.261254, 0.740857, 0.778633, -0.064301, -0.229162, 0.079913, -0.657255, -0.275533, 0.357625, 0.038536, -0.114407, -0.345545, -0.792068, 0.293385, -0.157141, -0.030637, -0.292157, -0.452523, 0.147798, 0.745641, 0.153496, -0.297093, 0.552365, 0.689523, 0.673057, 0.556404, 0.707087, -0.185312, 0.045480, 0.602745, 0.322718, 0.555089, 0.607539, 1.536739, 1.237288, -0.129189, 0.224045, 0.850938, 0.902724, 0.913083, -0.124612, 0.872724, 0.665192, -0.221759, 0.503550, 0.283883, 0.252072, -0.038759, -0.166486, 0.576915, 0.279812, -0.541009, 0.123539, 7.573179, -3.520919, -2.998120, -2.738148, -3.311286, -1.364107, -1.344757, -2.265100, -2.584293, -1.111523, -1.367061, -1.689917, -0.108861, -0.649743, 0.134367, 0.093143, -0.036086, -0.742622, -0.676015, 0.476501, 0.198162, 0.067910, -0.269469, 0.266284, 0.314383, 0.572789, -0.629337, -0.366717, -1.043046, -1.043736, 3.007034, 2.509247, 2.001375, 1.901606, 0.242871, 2.169059, 2.157239, -0.425258, -0.186157, 0.565076, 1.521837, -0.670157, 1.150134, -0.285465, -0.018723, 0.261276, -1.049627, -0.664831, -0.782834, -0.480541, -0.652821, -0.672198, -1.336451, -1.449535, -1.764426, -0.843486, -1.336008, -0.124394, -1.058074, -0.592098, 0.237777, -0.096236, -2.153625, -0.702462, 0.456245, 0.095788, 0.281038, -0.159122, -0.122468, -0.170517, 1.553320, -1.045945, -2.227368, 0.017817, 0.650745, 0.586698, 0.361893, 1.259755, 1.150926, 0.168069, -0.420825, 0.390331, -0.398784, -0.200626, -0.223852, 0.543885, 0.821184, 1.132843, 0.375166, -0.051118, 1.691601, 0.934416, 1.429215, 0.845207, 0.139896, 0.629952, 1.988479, -0.407422, -0.585243, 0.978749, 1.765663, -0.624723, 1.934043, 0.660084, -0.032678, 0.222998, -0.275805, 0.080674, -0.165842, 0.365868, -0.753939, -0.132641, -0.843738, -0.587197, -1.037485, 0.389569, -0.281227, -0.659999, -0.934962, -0.428082, -0.726126, 1.110944, -0.249281, -1.379150, 0.135149, -0.294412, 0.080790, 0.538494, 0.673333, 0.811869, 0.230466, 0.646739, 1.002837, -0.578140, -1.946816, -0.577857, -1.140051, -0.729126, 0.276381, 0.216658, -1.587731, -0.522664, -0.691314, 0.584935, -0.271760, 0.244097, -0.227000, 0.882937, -0.252149, -0.033531, -0.406092, -0.736653, -0.432258, -0.496748, -0.351186, -0.665412, -0.000697, -0.296764, -0.176910, -0.142254, -0.063575, -0.171955, 0.095343, -0.010591, 0.111856, 0.141685, -0.355376, 0.321488, -0.148487, -0.045760, -0.330162, -0.182599, -0.340012, -0.171232, -0.540604, -0.021101, -0.128502, -0.012774, -0.130471, -0.251464, 0.084981, -0.068000, 0.052785, 0.093232, 0.065897, -0.156948, -0.029747, 0.168562, -0.102534, -0.181742, -0.138782, 0.081846, -0.017678, -0.104031, -0.153261, 0.060119, 0.265222, 0.161779, 0.097820, -0.102570, -0.016102, -0.061680, 0.003258, -0.024442, -0.005744, 0.028174, 0.186935, -0.103899, -0.028166, 0.178906, -0.508656, -0.627365, -0.244463, -0.256789, 0.028663, -0.541764, 0.199049, -0.202171, -0.376275, -0.170725, -0.273270, -0.345616, 0.117217, -0.198233, -0.044216, -0.072607, -0.262926, 0.281712, -0.182564, 0.158626, -0.103342, -0.150832, -0.128141, -0.156453, -0.230381, 0.119578, -0.067799, 0.094052, -0.044226, -0.072821, -0.581643, -0.170594, -0.394345, 0.310885, 0.807591, 0.810074, 0.644411, 0.369989, 0.556826, 0.462510, 1.273690, 0.430923, -0.494903, 0.760801, 0.561774, 0.162677, 1.166413, 0.989430, 0.306412, 0.074372, 0.175283, 0.777740, -0.838590, -0.319042, 0.432542, -0.686103, 0.158442, -0.558333, 0.644184, 0.864403, 0.048080, 0.149801, 0.028629, -0.120731, 0.107222, -0.208283, -0.401502, 0.029778, 0.543102, 0.282852, 0.036680, -0.160815, 0.214112, -0.185467, -0.508927, -0.542047, 0.067815, -0.688249, -0.306713, -0.096681, -0.119347, 0.278152, -0.375527, 0.027321, 0.104852, -0.166021, -0.228357, 0.073290, 0.692479, 0.315500, 0.029015, -0.304894, 0.363403, 0.237950, -0.107172, 0.267991, 0.002681, 0.323735, 0.307104, 0.115255, -0.078548, -0.388923, -0.481142, 0.061063, 0.264081, 0.149464, -0.133501, -0.358778, -0.222765, -0.384597, -0.359409, 0.022012, 0.420142, 0.351958, -0.123562, 0.042689, 0.378831, -0.295376, -0.089177, -0.049140, 0.500490, 0.572497, 0.214424, 0.031683, 0.051883, -0.024372, -0.161566, 0.472221, 1.068033, 0.450598, 0.231143, 0.309575, 0.497911, -0.008340, -0.521470, 0.249013, 0.387022, -0.583521, 0.227799, 0.015311, -0.089159, -0.053548, -0.532412, -0.244278, 0.177369, -0.196630, -0.296168, -0.293120, 0.439149, 0.163709, 0.087133, 0.364656, 0.556801, 1.114858, -0.846098, -1.345483, -0.778320, 0.044351, -0.530268, 0.069533, 0.083655, 0.414607, -0.438684, 0.938034, 1.029245, -0.344857, 0.569974, -0.483873, 0.083212, 1.384549, 0.736985, 1.253739, 1.412525, 0.898611, 0.746338, 1.043209, 1.606833, 0.517537, 0.893939, 0.236855, 0.160933, 1.495844, -0.409120, -0.133686, -0.270814, -0.007319, -0.032372, -0.285172, -0.420264, -0.114389, -0.083294, -0.250456, -0.254443, -0.416082, 0.581091, 0.559775, 0.834736, 0.041722, -0.373970, -0.198068, -0.411251, -0.087013, -0.182875, 0.199655, 0.604375, -0.088598, 0.806933, 0.650356, -0.075319, -0.354640, 0.198805, -0.145423, 0.048592, 0.033054, -0.033176, -0.074313, 0.171758, -0.214198, -0.187917, -0.373610, -0.086924, 0.159727, -0.048064, 0.216749, 0.070249, -0.366489, -0.358494, 0.064459, 0.082296, 0.602415, -0.114411, 0.328163, -0.326688, 0.073884, 0.057114, -0.235446, -0.237835, -0.098971, 0.415639, 0.227657, 0.483658, 2.242449, -0.133014, -0.025119, -0.323908, -0.037794, 0.011922, 0.158996, -0.245031, -0.034201, 0.037304, -0.414556, -0.117652, -0.308486, 0.897148, 0.679449, 0.976609, 0.180301, -0.422217, 0.011100, -0.464106, -0.380893, 0.034664, -0.005756, 0.402395, 0.132782, 0.666095, 0.808172, 0.202432, -0.453697, 0.217022, -0.991930, 0.743291, 0.682143, 0.364784, 0.614679, 0.866880, -0.329797, -0.080278, -0.964485, 0.045891, -0.179271, -0.014528, -0.182924, 0.534128, 0.036783, -0.018857, 0.391836, 0.331952, 0.160826, 0.274639, -0.153962, -0.097213, -0.716071, 0.043392, -0.387454, -0.723857, -0.285374, -0.448553, -0.250571, -0.067574, -0.057313, 0.152763, -0.130277, 0.028124, 0.469492, 0.195033, 0.412041, 0.146215, 0.887909, 0.001812, -0.596210, -0.565996, 0.245111, 0.835655, 0.162763, 0.205263, -0.158899, -0.282472, 0.303824, 0.239066, -0.278700, -0.342919, 0.569840, 0.066786, 0.122598, -0.128857, 0.388392, -0.097224, -0.092645, -0.167463, 0.205188, -0.151692, 0.228884, 0.669582, -0.193532, 0.075025, -0.378894, -0.505966, -0.280404, 0.148362, 0.106609, -0.436955, -0.855766, -0.885886, 0.483888, 0.743191, -0.024822, -0.182942, -0.007402, 0.156678, 0.181569, -0.106085, 0.197837, -0.004508, -0.502885, 0.011841, 0.216145, 0.149764, 0.215447, -0.268938, -0.390614, -0.114489, -0.181290, -0.137474, 0.050936, 0.071995, 0.723473, 0.106784, 0.740920, -0.282975, -0.369199, -0.250265, 0.134519, 0.705720, -0.023176, 0.209674, -0.256313, -0.448795, 0.490277, -0.244781, -0.502137, -0.246152, 0.278164, 0.053976, 0.035494, -0.410656, 0.513109, -0.089851, -0.122306, -0.568589, 0.373954, -0.396147, -0.064518, -0.856285, 0.568643, 0.537605, -0.323147, 0.076616, 1.087260, 0.491357, -0.159094, 0.670280, 0.787144, 0.006227, 0.940145, 0.862079, 0.869880, -0.581502, 0.470159, -0.271262, 0.171587, 0.079494, -0.014925, -0.381462, -0.277157, -0.000297, -1.180370, -0.041285, -0.588388, -0.334921, -0.514555, -0.072092, -0.290917, -0.351933, -0.080204, -0.201449, -0.239187, -0.537986, -0.014342, 0.091734, -0.372685, -0.028685, -0.305744, -0.411417, -0.073123, 0.629752, 0.158700, 0.687134, -0.431998, -0.083880, 0.288179, 0.577231, -0.189191, -0.448792, 0.227869, 0.341046, 0.347248, -0.140931, -0.434562, -0.031963, -0.483885, 0.176896, -0.015399, 0.155322, 0.165805, -0.217213, -0.003703, 0.246849, 0.539144, 0.314255, 0.559258, -0.170959, 0.004035, 0.130746, 0.100563, -0.581704, -0.878725, -0.299956, -0.239457, 0.593277, 0.690110, 0.676012, -0.051683, 0.355116, 0.147116, -0.117183, 0.434044, 0.277579, 0.051778, -0.383631, -0.395576, -0.092245, -0.235751, -0.286203, 0.166396, -0.266636, -0.162817, -0.260965, 0.328542, 0.189435, -0.053940, 0.151313, -0.017149, -0.530490, 0.031832, 0.703621, -0.056322, 0.682578, -0.045004, 0.007334, 0.522206, 0.668331, -0.722678, -0.376362, 0.553379, 0.180231, 0.039098, -0.393145, -0.302935, 0.006660, -0.940710, 0.136236, 0.207289, 0.627927, 0.614397, 0.603173, -0.579333, -0.414727, -0.702351, 0.277865, 0.477035, 0.443494, 0.537688, 1.195761, 0.634183, 0.661386, 0.604642, 0.309526, -0.453083, -0.242194, -0.017938, 0.437320, -0.236725, 0.247095, -0.167110, 0.235202, 1.119230, 0.100128, 0.983208, -0.136460, 0.211950, 1.466717, -0.007337, 0.557549, 0.948735, 0.577251, 0.106635, 0.381770, 0.508566, -0.871696, 0.055389, -1.080118, -0.417108, -0.048611, 1.676415, 0.746006, -0.339417, -1.192558, -0.556957, -0.707802, 1.067903, -0.220753, 0.612659, 0.418343, -0.294337, 1.578629, -0.736830, -1.040651, -0.578126, -0.300116, 0.542125, -0.330635, -0.333907, -0.601471, -0.642260, 0.307618, -0.597339, -0.402638, 0.537832, 0.301342, 0.444299, 0.036485, 0.620995, 0.671191, 0.401213, 0.114562, 0.214302, -0.158832, -0.059969, 0.182453, 0.450380, -0.817849, -1.351292, 0.126719, -0.256882, 1.199835, 0.658854, -0.227588, -0.170503, -0.042084, -0.052223, 1.031465, -0.330243, 0.071769, 0.852661, -0.113130, 0.372676, 0.518262, 0.369671, -0.182692, 0.005344, -0.696459, -0.005276, 0.655975, 1.149496, 0.333290, -0.073281, -1.114583, -0.365150, -0.463158, 0.380497, -0.346897, 0.742732, 0.464103, -0.351980, 1.933615, -0.622825, -0.915603, -1.149925, -0.270160, 0.336965, -0.506493, -0.297648, -0.072097, 0.272695, 0.263157, 0.241594, 0.330950, 0.700836, 0.594841, -0.003880, 0.089149, 0.883080, 0.659962, 0.458158, 0.848329, 0.594465, -0.002931, 0.652700, 0.390594, 0.458288, -0.075631, -0.099224, -0.175138, -0.171792, -0.267228, -0.825002, 0.374327, -0.018828, -0.138443, -0.319108, 0.037247, -0.249171, -0.357385, -0.329366, 0.066737, 0.408653, -0.250488, 0.060483, -0.203249, 0.166651, -0.256161, 0.688544, 0.334352, 0.003170, 0.339876, 0.494905, 0.312198, -0.458144, 0.086134, -0.018451, -0.567388, -0.228685, 0.610251, 0.118431, -0.110911, -0.146630, 0.329943, -0.413028, 0.118261, -0.082676, 0.045962, -0.152823, 0.001866, -0.226512, -0.341245, -0.245399, -0.398100, -0.314456, -0.032311, -0.021755, 0.269952, -0.285915, -0.494740, 0.326453, 0.844926, 1.021808, 0.759839, -0.511807, -0.958900, 0.140996, -0.374392, -0.144614, 0.473981, 0.047119, 0.230972, 0.152273, 0.104578, -0.376007, -0.050963, -0.330460, 0.009739, -0.564953, 0.007436, -0.149302, -0.006665, 0.320572, -0.165292, 0.124265, -0.100445, 0.093162, -0.451471, 0.644322, 0.336479, 0.002005, 0.153031, 0.647926, 0.341139, -0.689107, 0.081376, -0.042465, -0.241461, -0.171641, 0.601799, 0.214100, 0.026832, -0.132094, 0.179035, -0.548338, -0.286873, 0.136118, 0.493465, 0.273286, 0.054830, 0.831087, 0.287904, 0.642877, 0.343987, 0.306812, 0.123254, 0.331750, 0.237910, 0.009377, 0.586579, 0.469410, 0.750387, 0.147948, 0.604209, -0.256401, -0.459694, -0.498198, -0.661181, -0.536693, -0.794693, -0.791886, -0.904290, -0.996099, -0.623003, -0.393144, -0.006498, 0.510880, -0.010619, 0.320716, 0.261817, 0.156062, 0.387189, -0.544582, -0.061902, 0.548544, -0.271755, -0.379905, -0.276037, 0.000734, 0.037662, -1.089750, -0.816112, 0.817579, -0.037375, -0.128307, 0.023679, 0.725716, -0.185476, 0.057882, 0.441099, 0.498136, 1.824952, -0.039699, -0.598361, 0.851790, 0.548083, -0.825701, 0.527027, 0.332667, 0.307853, -0.168094, -1.183734, -0.288279, -0.334560, -0.490890, -0.467144, -0.868454, -0.221553, 0.444624, 0.379014, -0.177678, 0.065798, -0.412062, 0.810942, 0.419563, 0.172934, 0.689863, -0.805467, -1.042159, 0.570562, 0.048419, -0.061263, 0.021888, -0.283922, 0.366928, 0.343557, 0.435930, 0.039552, -0.324716, 0.190143, 0.380228, 0.814827, -0.272395, -0.090175, 0.555720, -0.516045, -0.240873, -0.094603, -0.057451, 0.176956, -0.692498, -0.681457, 0.892191, -0.066035, 0.415145, 0.209219, 1.096542, -0.076127, -0.602011, 0.333572, 0.079623, 1.341051, 0.455963, -0.160865, 0.990084, -0.457363, -0.142994, -0.495837, -0.390481, 0.082159, 0.079934, 0.046168, 0.024130, -0.339683, 0.817105, 0.387147, -0.354267, 0.008812, -0.896011, -1.297719, -0.909390, -0.311707, -0.248080, -0.230357, 0.114034, -0.424288, -0.520910, -0.645736, 0.616305, 0.088005, 0.920491, 0.838965, 0.914924, 0.558952, -0.011877, 0.054535, -0.227478, 0.150645, -0.067653, 0.834685, 0.257488, 0.892153, -0.050375, -0.210403, -0.178264, -0.279546, -0.672449, -0.121498, -0.145050, -0.151618, -0.880040, 0.183597, 0.276669, 0.472240, -0.244088, -0.357524, -0.277415, 0.035093, -0.027471, 0.011033, 0.355016, -0.408332, -0.816580, 0.345562, -0.493390, 0.475409, 0.347765, -0.324633, -0.114650, -0.384117, -0.147652, -0.387034, -0.175141, 0.046365, -0.378192, 0.188862, -0.022361, 0.169833, 0.334793, 0.101367, 0.102157, -0.075478, 0.225010, 0.315446, -0.712855, -0.164800, -0.052253, -0.243141, -0.102471, -0.411188, -0.881177, -0.124356, -0.277667, -0.028917, -0.145578, 0.397689, 0.256877, 0.234246, -0.048446, 0.356207, 0.153912, 0.795013, -0.190690, -0.704614, 0.063407, 0.121677, -0.541549, -0.003779, -0.360679, -0.125073, -0.462200, 0.133306, -0.211691, 0.587343, -0.103168, -0.137630, -0.478180, 0.343990, -0.121383, 0.007047, 0.507268, 0.015573, -0.529572, 0.394708, -0.186729, 4.565439, -1.765409, -2.478681, -2.322774, -2.414186, -1.441088, -1.231971, -1.585618, -1.856830, -0.453590, -1.155480, -1.214106, 0.032655, -0.320174, 0.170311, 0.204946, -0.401268, -0.853547, -0.023091, 0.290237, -0.323077, 0.448579, -0.034745, -0.127991, -0.335553, -0.144136, 0.009326, -0.758612, -0.332416, -0.937829, 6.896461, 5.731208, 2.527726, 1.912320, 0.535034, 0.056440, 0.539459, 0.283343, -0.042569, 0.376828, -0.629817, 0.636249, -0.725438, 0.578775, -0.719580, -0.147100, 0.110092, 0.696716, -0.035684, -1.023190, 0.034920, -0.630825, 0.229325, -0.489099, -0.152682, -0.803494, 0.376675, -0.866285, -0.970483, -0.148853, -3.333496, 0.620097, 0.189968, 0.453682, 0.515002, 0.527021, 0.418573, 0.330083, 0.362918, 0.275320, -0.273454, -0.584987, 0.784053, 0.057049, -0.277310, 0.270142, 0.236079, 0.524606, 0.066780, -0.518312, -0.308600, 0.349721, 0.786314, 0.305447, -0.081270, -0.573857, 0.670481, 0.075731, 0.026502, -0.299520, 6.797712, 3.558873, 1.946129, 1.501815, 0.485729, -0.254115, -0.269171, 0.577311, -0.128967, 0.188380, -0.213303, 0.489118, 0.037577, 0.354811, 0.138081, 0.173175, -0.272143, 0.725929, -0.092206, -0.602319, -0.100192, 0.232424, 0.229654, -0.251057, 0.031108, -0.403075, 0.658872, -0.759155, -0.273478, 0.081427, -0.055631, -0.902332, -0.015397, 1.147518, 0.911298, 0.855804, 0.243610, -0.434271, -0.560258, -0.542636, -0.580984, -0.722007, -1.988984, 0.727726, -0.243717, -1.525010, -0.024800, -0.658633, -0.291633, -0.295185, 0.374684, 1.163056, 0.492369, 1.274161, 1.646375, 0.696163, 1.112271, 0.486845, 1.544148, 0.999993, -0.104446, -0.428301, -0.506703, -0.693849, 0.080012, -0.338547, -0.377757, 0.478215, -0.224702, -0.342188, -0.196330, -0.301235, 0.841234, 0.229824, 0.546040, 0.358258, 0.074817, -0.475271, -0.386267, -0.695102, -0.454012, -0.502912, -0.117764, 0.242493, -0.352204, -0.466170, -0.259232, -0.200018, 0.395411, 0.002056, -0.005040, 0.011369, 0.077061, 0.090589, -0.212351, -0.026378, 0.273595, 0.647224, -0.087865, -0.501752, -0.032982, -0.024779, -0.199289, 0.175290, -0.269620, -0.570519, 0.169217, -0.108753, 0.396028, 0.326391, -0.236827, 0.167198, 0.031143, -0.283199, 0.442295, -0.094935, 0.691618, -0.033383, -0.298664, -0.001094, -0.369163, -0.422695, -0.275748, -0.609502, 0.594646, -0.033738, -0.013819, 0.497568, -0.228785, -0.105890, 0.062951, -0.439035, 0.444742, 0.281796, 0.649989, 0.392198, 0.006995, -0.521987, -0.254663, -0.364471, -0.025537, -0.430880, 0.083086, 0.092646, -0.399478, -0.357275, -0.204801, 0.180806, 0.336894, -0.715534, -0.129850, -0.801419, -0.075971, 0.769981, 0.937914, 0.602169, -0.050107, -0.218568, -0.693694, -0.673221, -0.357014, -0.418821, -1.351427, 0.076586, -0.671247, -1.497858, 0.167949, -0.098420, -0.526098, -0.595884, 0.382265, 1.351907, 0.622297, 1.034694, 1.394001, 1.089794, 0.749921, 0.742778, 1.322696, 0.286282, -0.050295, -0.270336, -0.013860, 0.221058, 0.748367, 0.175195, -0.199612, -0.347482, -0.139998, -0.516223, 0.936741, -0.597561, 0.637312, -0.534981, 0.420550, 0.105507, -0.176897, -0.884770, 0.287350, -0.709185, -0.439038, 0.934704, -0.484185, 0.142824, 0.002024, 0.062167, 0.516825, 0.139053, 0.045024, 0.492615, 0.308531, -0.021324, -1.015919, -0.784776, 0.295933, 1.149896, -0.460860, -0.798895, -0.465015, 0.048272, 0.010827, 0.857109, 0.544626, -0.124310, -0.352292, -0.356553, 1.018213, 0.223542, -0.520373, 0.187981, 0.071506, -1.106736, 0.106954, -0.171729, 0.137606, -0.325653, -0.805218, 1.737491, -0.937840, -0.039639, 0.007285, -0.293771, 0.558773, 0.653805, 1.466093, -0.011043, -0.231714, -0.158853, 0.154199, -0.594241, 0.960743, -0.362614, 0.463410, -0.690835, 0.003851, -0.119439, -0.542273, -0.904645, -0.027644, -0.883558, -0.010871, 1.521261, -1.142702, -0.493248, 0.342370, 0.188483, 0.257025, 0.555640, -0.078735, 0.223685, 0.899518, 0.192839, -0.153272, -0.910597, -0.523432, 0.135074, -0.724064, 0.209076, 0.518274, -0.260298, 0.378905, -1.486235, 1.650537, -2.448491, 0.796847, 0.843743, -1.832443, -1.464321, -1.890268, -1.017151, -0.754519, -2.457668, -2.206389, -1.608696, -2.470160, -1.590770, -1.361318, -1.207345, -1.316664, -1.322534, -0.482945, -0.801686, -0.297160, -0.589858, -0.457424, -0.291685, 0.388493, 0.061821, 0.854768, -0.346168, 0.026277, 0.248220, -0.207881, -0.436535, -0.572487, 0.049008, -1.110443, -0.033813, -1.439176, -1.005755, 0.443450, 0.331870, -1.097342, -0.773625, 0.094007, -0.043437, -0.664458, -0.316243, -0.326782, -0.425294, 0.329626, 0.322804, -0.640739, -0.718070, 0.653065, 0.285965, -0.123236, -0.902483, -0.278818, 0.652264, 0.450848, 1.121799, -0.072176, 0.063732, -0.448901, -0.131939, 0.082276, 0.237651, -0.146426, -0.201413, -0.924278, -0.670068, 0.254910, -0.795359, 0.203516, 0.215936, -0.701087, -0.702744, 0.521299, -0.162937, -0.487125, -0.900898, -0.226194, -0.184369, -0.410382, -0.842477, 0.620057, 0.401052, 0.430337, -1.063588, -0.531275, 0.392875, 0.029363, -0.068725, -0.624857, -0.173073, -0.872232, 0.001451, -1.439329, -0.625809, -0.526665, -0.328893, -0.321579, -0.051132, 0.401600, -0.062197, 0.098319, -0.836277, 0.436591, -0.786116, -1.020254, 0.910657, -0.700036, -1.043013, -1.031316, -0.061452, 0.348931, -0.615325, 0.143401, 1.677444, 0.877273, -0.011901, 0.886349, 1.322316, -0.037133, 1.162908, 1.131983, 1.498091, -0.151275, 0.146515, -0.119533, 0.582086, 0.234765, 0.291578, 0.180068, -0.449129, -0.052346, -0.403871, -0.277170, 0.188465, -0.334471, -0.653389, -0.373739, -0.156333, -0.564140, -0.552140, 0.055498, 0.112717, -0.356229, 0.524520, -0.615719, -0.307600, -0.485384, -0.286898, -0.158628, -0.118231, -0.666891, 0.242203, 0.027916, -0.267655, -0.485613, -0.251760, -0.247288, 0.524383, 0.534818, 0.096470, 0.106210, -0.128698, -0.235814, 0.641106, 0.203811, -0.202474, 0.045410, 0.209801, 0.106227, 0.181093, 0.143519, -0.184809, 0.234564, -0.342513, -0.351666, -0.025399, 0.059832, 0.022165, -0.797900, -0.924657, -0.245847, 0.415488, -0.435936, -0.134143, -0.104824, -0.219153, 0.225818, 0.478984, 0.264087, 0.244208, 0.251458, -0.130116, -0.094944, 0.412153, -0.452644, -0.722736, -0.368154, -0.210529, -0.590935, -0.693052, 0.174516, 0.161413, 0.005690, 0.953863, -0.514139, -0.182057, -0.459212, -0.225446, -0.134412, 0.098547, -0.534088, 0.373733, 0.171466, -0.159605, -0.437677, -0.087758, -0.246012, 0.800433, -0.025124, -0.224351, 0.029047, -0.111101, -0.125631, 0.351364, 0.356541, -0.555475, 0.836138, 1.179554, 1.035741, 0.425334, 0.777278, 0.328904, 0.329956, -0.964213, -0.010483, -0.646208, -0.625196, 0.545828, -0.069993, -0.377984, -0.186199, 0.028670, -0.507537, -0.120912, -0.047277, -0.465821, -0.174955, -0.798830, 0.559323, 0.166474, -0.685762, -0.260345, -0.498124, -0.380142, -0.119746, 0.033638, -0.287810, -0.498345, -0.601234, -0.018047, -1.048353, -0.334175, -0.177509, 0.042151, -0.152144, -0.776709, -0.569824, 0.249310, 0.170135, -0.079262, -0.251821, -0.127977, 0.276998, 0.308311, 0.150847, 0.407898, 0.963925, 0.462102, -0.650454, -0.565598, -0.339307, -0.786648, 0.139657, 0.627073, -0.161862, -0.187197, 0.410250, -0.050303, -0.459691, 0.460464, 0.138056, -0.068086, 0.158218, 0.558982, 0.166701, -0.251593, 0.021155, 0.268694, 0.067387, 0.218640, -0.012374, 0.067419, -0.086475, -0.464109, -0.453458, -0.752578, -0.382389, 0.313236, -0.082798, -0.020196, 0.075593, -0.342124, 0.142640, 0.138683, -0.343814, -0.571895, -0.546270, -0.738130, -0.478861, 0.065519, -0.786868, -0.337168, -0.281314, -0.136271, -0.532705, -0.485470, -0.186602, -0.195457, -0.199137, 0.129909, -0.416785, -0.749833, -0.036520, 0.148312, -0.164272, -0.176859, 0.015084, 0.563347, -0.510670, -0.455943, -0.028257, -0.817626, -0.459367, 0.344609, -0.113392, -0.879907, -0.441451, 0.707051, 0.520787, 0.103531, -0.226021, -0.063003, -0.474185, -0.484425, 0.085714, 0.178376, -1.188330, 0.650539, 1.322480, -0.056237, 0.906805, 0.817384, 0.379156, 0.030541, 0.110105, 0.778462, 0.095505, 0.284349, 0.450896, -0.024133, 0.096992, -0.311046, 1.037090, 1.142666, -0.082219, 0.069076, -0.521622, 0.312450, 0.012119, 0.516784, 0.115384, 0.608621, 0.038498, -0.345250, -0.287455, -0.003599, -0.272067, 0.307059, -0.123605, 0.653483, 0.280615, -0.693623, 0.396404, -0.020658, 0.002778, -0.308565, 0.742312, -0.311353, -0.106441, 0.114347, 0.126109, 0.018495, -0.018205, 0.015238, 0.051591, 0.150204, -0.373414, -0.229815, -0.184452, -0.140868, 0.479208, 0.139594, 0.240494, 0.368890, -0.277311, -0.227499, 0.042714, 0.796703, 0.005511, -0.982854, -0.754295, -0.102610, 0.128347, 0.591202, 0.141627, -0.196342, 0.165970, 0.249776, -0.539906, -0.274791, 0.105220, 0.078068, 0.592002, 0.469861, -0.161346, -0.057433, -0.450197, 0.199917, -0.216093, 0.100821, 0.483826, 0.736226, -0.146626, -0.662038, -0.237073, -0.490331, -0.534346, 0.171225, -0.389031, 0.595147, 0.150543, -0.570448, -0.117584, -0.500647, 0.128331, -0.288490, 0.715105, -0.386051, 0.248117, 0.105001, -0.364647, -0.265885, 0.202652, -0.144903, 0.154174, 0.515736, 0.616842, 0.817731, -0.964954, -1.620963, -0.946812, 0.310103, -0.086006, -0.305361, 0.130389, 0.550302, 0.264358, 0.225359, 0.464151, 0.536140, -0.208656, -0.618388, -0.010025, 0.777363, 1.439885, 0.860128, 1.903531, 1.289959, 1.006266, 0.916058, 1.460663, 0.701572, 0.575587, 0.458896, 0.015786, 0.756449, -0.292219, -0.172245, 0.138911, -0.483118, 0.458889, -0.632873, 1.081087, 0.292684, -0.746896, 0.802176, 0.045202, 0.604116, 0.040117, -0.286798, 0.121249, 0.267832, -0.109973, 0.408454, 0.586064, -0.280770, 0.325852, 0.230883, -0.541888, -0.000294, -0.150116, 0.284953, 0.699260, 0.372016, 0.061513, -0.481736, -0.434858, -0.056903, -0.297702, -0.267341, 0.353260, 0.374453, 0.251213, 0.284733, 0.001873, 0.426715, -0.053644, -0.647667, -0.062562, 0.088481, -0.226562, -0.018811, -0.025356, -0.284911, 0.008859, 0.033993, 0.297803, 0.018278, -0.073033, 0.308921, -0.408596, -0.258716, -0.124500, -0.227013, 0.286017, 1.428075, 0.108422, -0.224707, -0.090662, -0.413669, 0.829804, -0.243318, 1.668183, 0.444871, -0.598966, 0.724140, 0.179086, 0.457559, 0.155380, -0.154294, 0.617419, 0.249488, -0.307471, 0.854128, 0.774587, 0.039667, 0.098761, 0.103511, -0.570243, -0.461962, 0.031858, 0.316318, 0.588296, 0.654524, -0.855673, 0.495300, -0.629253, -0.818339, -0.854376, 0.129452, 0.183479, -0.394459, -0.051112, 1.568198, 0.993958, 0.114090, 0.669235, 1.351024, 0.254340, 1.191096, 0.861607, 1.232772, -0.249172, -0.051603, -0.141792, 0.848455, 0.264418, 0.379659, 0.249085, -0.251680, 0.069023, -0.284850, 0.019170, -0.341683, -0.283050, -0.669215, -0.582513, -0.435307, -0.256775, 0.172633, -0.562541, -0.103757, -0.295395, 0.051581, -0.495285, 0.303092, 0.045154, 0.012784, -0.563780, 0.212814, -0.264659, -0.260537, -0.293159, 0.063369, -0.159862, 0.053136, -0.060297, -0.364648, 0.711247, -0.024683, 0.669809, -0.534189, 0.189351, 0.194260, 0.020552, -0.208422, -0.087932, -0.448396, 0.150425, 0.026211, -0.413354, 0.109995, 0.137169, -0.270545, -0.076399, 0.090169, -0.257494, 0.032286, -0.170738, 0.184256, 0.113238, 0.141140, 0.626465, 0.117030, 0.182382, 0.094739, 0.256625, -0.413417, -0.366518, -0.047559, -0.356295, 0.163741, 0.341714, -0.273538, -0.291246, -0.537333, -0.639564, -0.216174, 0.054274, 0.307652, -0.339238, -0.117556, -0.303233, 0.119319, -0.153775, 0.419977, -0.336782, 0.004671, -0.618707, 0.207437, -0.613984, -0.363953, -0.400364, 0.154111, 0.165953, -0.063629, 0.013984, -0.351516, 0.782621, -0.022418, 0.718448, -0.418669, 0.096666, 0.033847, -0.293361, 0.212876, -0.183830, -0.407570, 0.416230, 0.409681, 0.068299, 0.087997, -0.110883, 0.659646, 0.325536, -0.583049, -0.341988, -0.574792, -0.444341, -0.138371, 0.084276, -0.179581, -0.755343, -0.092313, -0.676483, 0.119744, -0.830785, -0.295390, 0.018382, 0.088971, 0.137386, 0.038571, -0.279637, -0.177408, -0.062458, 0.002074, -0.128636, -0.463215, 0.112433, 0.184164, -0.452078, 0.160375, 0.149764, 1.102650, 1.005896, 0.589637, 0.355773, -0.064746, 0.112839, -0.133948, 0.452704, 0.458490, 0.584529, -0.589387, -0.508649, 0.729848, 0.072163, 0.115394, 0.287345, 1.467257, 0.284999, 0.665143, 0.513226, -0.334205, 0.036803, -0.263926, -0.024500, 0.059392, 0.302718, 0.227515, -0.087206, 0.656483, -0.217636, -0.573692, -0.079877, -0.148094, -0.037840, 0.096632, -0.501620, -0.492491, 0.021002, -0.395576, -0.253964, 0.172901, 0.035104, -0.132521, -0.887092, 0.437336, -0.374474, 0.667781, 0.473091, -0.003379, -0.148420, -0.015662, 0.253063, 0.262742, -0.228213, -0.076163, 0.072293, 0.533384, -0.577759, 0.480434, 0.150095, 0.921820, 1.100608, 0.557978, 0.692736, -0.313835, 0.164905, -0.271878, 0.079597, 0.273365, 0.735072, -0.179918, -0.476506, 0.868834, 0.255037, 0.119533, 0.571186, 1.846695, 0.473893, 0.929206, 0.458344, -0.419842, 0.856249, 0.072332, -0.333767, -0.778661, -0.510809, 0.050783, -0.492786, 0.412482, 0.605172, -0.215179, -0.055150, -1.461976, 1.693920, -2.405057, 0.521592, 1.047277, -1.584439, -1.512935, -1.869893, -1.266617, -0.557296, -2.352972, -2.402905, -1.432947, -2.593489, -1.731986, -0.994243, -1.025113, -1.244474, -1.811924, -0.501895, -0.957014, -0.418595, -0.711080, -0.798381, -0.703592, -0.233647, -0.554105, -0.109922, -0.046724, -0.352188, -0.150972, -0.188134, 0.017351, -0.809917, -0.814319, -0.918896, -1.112276, -0.341710, -0.310987, -0.351930, -0.530758, -1.049529, -0.474607, 0.538261, 0.162125, 0.534469, -0.508678, -0.195763, -0.407999, 0.106183, 0.360539, -0.118019, -0.248065, 0.020483, 0.156903, 0.116053, 0.202677, 0.146192, 0.390507, 0.253112, -0.862948, -0.521943, -0.260109, 0.006747, -0.239660, -0.257428, -0.481214, -0.222941, 0.085618, 0.852355, 0.463289, -0.339695, 0.018775, 0.303936, 0.227896, -0.801622, 0.367486, 0.650180, -0.440667, -0.420839, -0.770490, -0.507928, -0.397216, -0.611904, -0.075918, 0.040215, -0.536760, -0.411649, 0.010544, -0.137288, 0.119216, -0.127125, 0.524306, -0.398403, -0.478812, -0.495813, -0.811660, -0.376851, -0.290397, -0.477717, -0.341505, -0.430465, -0.710982, 0.424420, 0.830227, 0.536397, -0.299640, -0.175650, 0.171752, -0.946264, 1.358208, 0.313504, -0.075888, 0.684631, 0.739762, 0.392243, -0.015621, 0.403288, 1.000509, 0.069755, -0.201740, 1.156186, 0.153496, -0.472819, 0.180044, -0.041305, 0.292222, -0.822118, -0.754764, -0.857299, -1.315043, -0.644567, -0.047300, -0.335487, -0.222384, -0.205039, 0.544692, -0.622752, 0.315467, -0.282269, -1.128486, 0.234852, -0.042462, -0.244172, 0.360526, -0.811041, -0.634013, -0.673905, -0.314331, -0.770111, -1.334350, 1.148041, -0.763007, -0.263687, -0.208529, 0.031269, -0.743719, -0.309986, 0.641856, -0.816723, 0.316820, 0.969203, -1.445611, 0.112168, 0.173637, 0.156960, 0.840902, -0.595085, 0.959890, 0.930977, 0.439655, 0.048306, -0.188754, 0.484628, -0.094356, -0.064107, -0.427469, -0.118867, -0.540896, 0.340382, -0.008563, -1.345426, -1.449971, 0.779512, 0.844226, 0.462056, 0.043235, -0.470031, 1.397798, -0.757610, -1.767509, 0.426670, -0.826697, -0.812007, -0.684422, -0.480836, 1.017973, -0.512291, -1.355634, -0.229226, -1.236159, 0.294622, -0.803535, -0.551798, -0.599740, -0.137643, -0.354851, -0.304433, 0.185586, -0.522923, -0.964030, 0.541611, -1.286875, -0.316080, -0.264978, -0.287294, -0.540351, -0.411363, 0.866357, 0.084658, 0.339108, 0.696161, -1.203842, -0.025899, -1.027092, 0.562408, 1.452933, -0.537258, 2.505430, -0.320752, -0.504020, -0.015717, -0.076788, 0.268858, 0.894341, 0.717771, -1.095986, -0.663785, -0.954227, -0.972244, -1.188404, 0.527280, 0.156225, 0.670544, 0.163099, -0.315667, 1.067788, 0.662247, -0.104220, 0.867483, 0.366388, 0.477534, -0.203822, -0.132893, -0.811630, -0.840224, 0.417680, -0.612705, -0.046569, -0.449573, -0.420790, 0.432876, 1.002861, 0.121109, 0.358325, -0.219600, -0.298802, -0.397604, 0.541759, -0.763617, 0.551405, -0.895408, 0.220533, 0.772710, 0.507600, -0.435717, -0.394707, 0.028646, 0.215563, 0.116831, -0.144085, 1.406147, -2.101676, 1.023905, -0.507904, -1.334816, 0.459100, -0.577953, 0.496887, 0.092550, -0.086529, -0.615198, -0.531801, 1.110006, -0.475944, 0.755158, -0.280650, -1.148595, 0.466005, 0.776945, 0.503917, -0.211183, -0.382166, 1.406081, -0.727882, -1.594795, 1.209910, 0.250029, 1.074793, 0.896527, 1.313634, 1.117723, 0.456098, -1.001196, 0.463372, -0.743528, 0.941352, -0.101145, -1.263910, -0.596478, -0.749326, -0.179502, 0.740491, 0.506442, -0.109626, -0.090587, -1.444227, -0.989197, 0.112419, -0.611421, -0.101670, -0.932874, 1.278053, 0.465048, 1.217360, -0.406064, -0.338404, -0.597293, 0.019308, -0.432143, 0.499032, 0.462469, -1.184734, 0.946158, -0.519768, -1.001968, -0.184950, 0.105554, 1.166274, 3.250569, -0.465954, -1.909244, -0.692876, -1.472337, -0.333445, -0.586998, -1.064370, -1.937924, -0.407848, -0.693892, -1.461003, 0.273864, -0.315327, -0.239748, 0.280598, 0.277312, -0.547613, 0.357014, 0.525763, -0.892553, 0.254983, 0.090656, -0.756783, -0.218465, -0.261933, -0.693930, -0.934469, -0.248674, -1.323901, 10.078671, 3.513283, 4.649240, 4.608299, 5.196065, 1.535372, 1.512059, 0.708009, 2.120548, 0.571199, 0.869599, 1.459312, -1.142742, -0.778271, -0.140112, 0.213322, 1.312328, 0.006103, 0.793453, -0.893046, -1.549474, -1.101658, 0.232273, -0.480658, -0.179797, -0.664065, -0.657163, -2.203568, -0.612926, 0.166925, -8.419420, 2.281434, 2.964527, 2.384756, 0.643827, 1.506534, 1.111677, 1.405442, 1.617755, 1.180980, 1.991253, 1.822186, 0.799786, -0.319839, 1.163351, -1.171474, 0.301395, 1.226102, -0.015005, 0.174523, 0.699278, -0.251696, 0.481330, 0.208858, 1.285975, -0.641066, 0.616972, 0.201610, 0.031719, 1.116987, 8.953240, 2.598418, 5.090953, 4.298674, 4.327999, 0.710331, 0.272255, 1.036008, 2.446926, -0.026328, 0.517931, 1.462331, -0.461074, -1.011364, 0.392625, 0.405239, 1.166558, 0.818182, 0.385573, -0.068846, -0.526524, -0.420799, 0.985861, -0.218729, 0.623059, -0.462412, -0.658072, -1.687352, -0.045383, 0.835992, 4.444351, -2.374430, -1.942360, -1.153457, -2.097318, -0.582402, -0.212097, -1.162337, -2.180783, -0.266214, -0.104654, -1.385928, 0.323543, 0.168861, -0.076874, 0.470457, 0.028535, -0.528715, 0.237385, 0.152471, 0.231160, 0.809691, -0.204845, 0.257929, 0.282727, 0.664393, 0.062664, 0.282434, 0.144054, -0.798791, 7.128196, 5.150461, 4.003639, 3.160051, 3.241152, 1.569313, 0.857015, 1.419504, 1.382563, 0.275767, 0.708700, -0.240085, 0.121512, -0.374219, -0.645893, -0.520263, -0.800399, -0.585521, -0.278178, 0.700895, -0.463001, -1.347152, 0.214864, 0.379216, -0.783740, -0.523308, -0.972967, -0.814571, 0.074232, -1.163052, 2.305929, -1.591002, 0.581266, -1.670223, 0.181852, -0.567109, -0.106330, 0.456102, -0.409337, -0.285074, -0.924118, -0.477188, -0.402311, -0.128255, -0.219669, -0.911993, -0.517463, -0.148285, 0.376001, 0.353491, -0.252895, -0.559032, 0.018570, 0.247874, -0.142993, -0.524545, -0.189075, -0.344354, -0.607764, -0.044975, 5.251785, 2.712080, 2.696989, 2.438016, 2.517262, 0.865628, 1.253469, 1.617713, 0.876672, 0.526301, 0.980458, -0.209999, 0.091268, 0.001357, -0.308401, -0.206671, -0.511812, -1.012781, -0.033800, 0.304401, -0.252810, -0.700739, 0.880108, -0.407913, -0.052648, -0.399810, -0.607041, -0.624771, 0.447080, -0.779199, -0.689498, 0.487586, -0.081987, -0.621321, -0.158443, 0.460013, 0.221074, -0.228353, -1.399121, -1.238622, -1.162545, -0.571830, 0.065788, -0.564370, 0.133834, 0.894393, 0.515581, 0.415753, 1.033540, 0.568215, 0.676202, 0.527808, 1.549040, 1.339885, 0.198829, 0.066704, -0.559567, 1.369018, -0.308489, -0.245894, -0.109299, -0.682930, -0.181025, -0.262948, 0.355386, 0.458849, 0.315118, -0.152184, 0.135089, -0.033848, -0.654602, 0.249104, 0.156717, 0.036412, -0.079805, -0.067701, 0.290326, -0.146855, -0.324290, 0.399789, -0.152411, 0.224355, -0.406608, 0.047333, -0.319269, -0.263619, -0.305155, -0.541085, 0.045895, -0.455027, 0.054215, 0.035526, 0.318834, -0.236246, -0.344556, -0.467411, -0.162597, 0.065062, -0.011308, 0.026816, -0.228052, -0.375187, 0.194504, 0.289933, 0.187239, 0.230484, -0.285413, -0.137079, -0.051763, 0.064643, -0.191851, -0.092987, -0.198316, 0.090826, -0.210685, 0.282781, -0.008887, -0.194777, 0.113437, -0.049659, -0.151926, -0.461631, -0.214083, -0.177421, 0.263703, 0.703981, 0.305886, 0.016634, -0.102136, -0.116300, -0.670037, -0.130093, 0.100920, -0.199356, -0.065714, -0.141347, -0.155300, -0.113631, -0.396587, -0.121643, -0.315227, 0.041329, -0.310899, 0.137051, -0.317340, -0.684721, -0.238663, -0.429194, 0.115775, -0.170184, 0.245319, 0.833318, 0.626569, 0.288731, -0.171577, -0.081986, -0.050527, -0.143375, 0.074719, 0.476041, -0.423690, 0.542345, -0.390008, -0.180723, -0.873993, -0.936105, 0.007601, -0.212978, -0.199615, 0.564873, -0.584006, -1.032160, -0.061616, -0.079190, 0.353165, 0.740737, -0.331472, 0.397399, 0.408792, -0.113598, -0.112031, -0.142601, 0.140528, 0.027167, 0.257525, -0.471272, -0.527210, -0.499262, -1.013647, -0.488101, -0.082973, 0.015932, -0.289190, -1.213872, 0.200030, 0.342912, -0.542517, 0.447682, -0.092199, 0.303678, 0.292147, -0.115261, -0.499807, 0.399032, 0.673344, -0.106111, 1.143376, 0.588868, 0.776648, -0.142576, 0.079271, 0.141991, 0.109322, -0.256445, 0.088138, 0.124527, 0.393338, -0.141567, 0.017008, 0.154837, 0.407268, 0.096284, -0.072304, -0.249399, -0.131808, -0.498900, 0.096733, 0.356889, -0.033362, 0.134368, -0.042143, 0.013975, -0.143122, 0.035196, -0.134958, -0.716619, 0.526375, 0.216123, 0.002181, -0.475126, -0.255639, -0.402019, 0.278743, -0.153581, 0.335630, -0.503546, -0.553145, -0.477467, -0.811895, -0.497006, -0.629530, -0.050383, -0.139361, -0.816856, 0.101240, -0.056596, -0.636834, 0.183166, -0.485632, 0.430884, 0.247556, -0.550934, -0.271250, -0.079958, 0.225410, -0.204146, 1.167743, 0.792569, 0.475003, -0.132745, 0.927386, 0.218206, 0.058752, -0.612176, -1.015426, 0.078081, -0.257253, 0.085071, 0.447677, -0.323102, 0.220951, -1.435095, 1.408002, -2.244252, 0.519623, 1.212168, -2.051167, -0.825470, -1.431339, -1.174540, -1.235988, -3.168029, -2.027524, -1.216696, -2.296869, -1.957506, -1.365697, -0.619684, -0.972538, -2.442470, -0.649263, -0.865929, -1.127515, -0.294395, -0.577495, -0.447245, -0.314760, -0.339528, -0.025925, 0.700534, -0.336053, 0.071137, 0.909826, 1.531451, -0.203823, 1.034922, -0.230796, 0.756039, -0.477418, -0.248329, -0.880713, -0.623564, -0.531737, 0.266324, -1.236048, 0.014603, -1.039386, -0.356637, 0.274414, -0.707992, -0.293613, 0.243580, 0.097170, -1.264717, 0.464243, -0.255713, 0.461809, 1.465912, 0.270468, 0.627594, 0.115266, -1.477857, 0.179186, -0.799923, -0.540847, -0.433418, -0.338042, -0.117281, 1.066774, 0.453820, -0.519178, 1.040300, 0.976652, 0.894079, -0.296556, -0.555358, -0.606909, 0.672453, 1.492904, 0.529711, -0.641249, -1.091621, -0.302989, 0.001709, -0.811730, -1.179275, -0.519789, -0.209364, -0.912923, 0.824793, -0.670657, -0.265072, 0.014645, 0.499021, -0.074056, 1.729263, -0.291406, 0.669692, -0.132155, -0.591444, 0.422945, -0.808708, 0.358003, 0.577049, -0.925143, 0.114020, -1.400128, -0.279331, -0.129114, -0.758754, 0.443590, -0.986782, 0.706195, 1.393681, 1.247823, 0.172744, 1.159473, 1.670171, 1.091244, -0.439122, -1.285062, -0.349305, -0.729977, -1.207571, 0.087944, -0.983179, 0.310958, -0.658195, 1.285604, -0.211593, 0.782898, 0.138953, 0.061507, 0.726638, 0.075835, 0.959521, -0.329549, 0.557985, -0.009885, 0.242550, 0.167183, -0.187179, 0.032196, -0.188699, 0.143560, 0.107365, -0.231287, -0.486714, 0.056026, 0.335127, -0.404394, -0.436569, 0.333645, 1.081492, 0.572992, 0.863925, 0.227552, -0.175365, -0.495817, -0.790647, -0.548363, -0.168524, 0.261420, -0.034318, -0.106279, 0.716151, -0.141924, -0.116276, -0.420191, 0.054240, -0.356712, -0.020606, 0.287789, 0.252126, 0.152892, -0.237652, 0.160083, 0.133442, -0.044074, -0.140854, -0.104466, -0.501491, -0.825144, -0.351736, 0.444455, 0.824072, -0.038060, 0.036866, -0.435619, -0.197016, 0.244926, -0.481485, -0.192368, 0.219776, 0.023428, 0.553899, -0.031912, -0.218080, -0.342732, -0.308430, -0.185178, -0.488925, -0.027432, -0.117352, -0.377961, -0.036418, -0.357389, -0.505178, 0.042168, 0.051494, 0.267938, -0.085488, -0.020184, 0.570516, 0.149355, 0.431414, -0.251424, -0.295612, -0.271299, -0.690485, -0.464187, -0.205368, 0.261329, 0.367675, -0.317911, 0.589754, -0.402988, -0.157504, -0.243011, 0.328509, -0.553564, -0.094406, -0.538915, -0.334126, 0.324026, 0.181052, 0.252327, -0.043501, -0.479331, 0.782176, 0.487900, -0.032321, 0.029134, -1.233947, -1.229848, -1.350097, -0.584068, -0.206374, -0.259463, 0.227036, -0.211333, -0.414535, -0.511946, 0.369635, 0.322370, 0.890050, 0.994893, 0.831349, 0.798013, 0.180707, 0.133840, -0.048262, -0.137136, -0.445570, 0.129790, 0.471316, 0.016431, 0.110357, -0.287591, 0.132635, 0.474034, 0.421461, -0.148809, -0.804544, -0.040954, -0.329421, -0.208103, 0.331593, -0.337949, 0.455178, 0.415672, 0.676352, 0.265658, -0.314025, -0.374878, 0.117268, -0.255096, 0.425400, 0.128811, 0.084803, 0.184067, -0.279433, 0.039895, -0.047602, -0.259418, 0.366689, -0.112799, -0.164539, 0.518714, 0.478040, -0.256022, -0.530001, -0.146401, 0.355446, 0.200996, -0.069178, 0.549724, 0.452611, -0.427351, 0.232665, 0.020165, 0.180481, 0.142696, 0.018812, -0.329765, 0.355207, 0.157974, -0.733908, 0.058200, -0.062685, 0.505651, 0.390733, -0.144252, -0.116710, -0.111098, -0.090304, -0.185065, -0.333526, -0.086967, 0.162318, 0.723559, 0.184872, -0.105995, -0.587202, -0.138010, -0.465018, 0.361346, 0.406417, -0.028604, 0.548183, 0.664200, 0.932927, 0.161024, -0.310333, -0.064306, -0.034439, -0.007434, 0.741153, -0.136464, -0.140580, -0.667650, 0.318677, -0.343360, -0.845798, -0.160609, 0.553034, 0.037257, 0.219011, -0.525001, -0.645066, -0.127230, -0.289598, 0.690313, 0.104463, -0.170494, 0.653139, 0.802030, 0.547502, 0.382773, 0.367299, 0.254717, 0.216472, 1.253211, 1.013619, 0.350544, -0.541974, -0.449860, 0.451576, -0.063823, -0.234999, -0.424814, -0.701122, -0.093702, -0.632621, -0.216682, -0.329313, 0.135663, -0.610484, -0.170439, 0.292990, 0.412552, -0.043296, 0.452256, 0.175113, -0.217043, -0.271725, -0.460356, -0.308507, -0.895325, 1.041756, 0.972370, 0.555218, 0.057008, 0.300641, 0.069382, -0.979087, 0.047466, 0.021818, -0.538550, 0.121253, 0.631808, -0.083667, -0.928796, -0.575482, -0.132165, 0.272632, 0.963621, 0.543201, 0.158149, -0.743447, -0.578244, -0.174254, -0.770860, -0.655919, 0.241158, 0.244401, -0.173710, -0.992553, 0.143035, 0.646504, 0.753900, 1.248652, -0.615473, -0.466339, -0.664240, 0.079074, -0.020050, -0.708311, 0.692371, 0.346292, -0.460717, -0.358975, 0.122108, -0.280004, -0.484907, -0.606060, 0.564732, -0.398331, -0.078302, 1.059675, 0.385584, -0.097904, 0.692003, 0.622333, 0.297353, 0.082348, -0.486954, -0.524517, -0.711251, 1.272242, 0.887807, 0.410838, 0.107100, 0.078133, -0.103539, -1.207044, -0.339153, -0.117727, 0.404748, 0.109362, -0.639879, 0.431440, -0.031942, -0.467216, -0.132863, 0.368012, 0.165912, -0.092535, -0.597173, -0.645645, 0.038986, -0.281346, 0.608221, 0.351001, 0.285307, 0.640638, 0.405842, -0.089219, 0.067528, 0.631573, 0.920202, 0.392793, 0.846032, 0.447267, -0.280253, -0.620589, -0.434755, 0.480563, -0.150070, 0.009983, -0.335445, -0.666852, -0.308349, -0.317386, -0.320304, -0.556301, -0.605567, 0.422063, 0.026840, 0.505016, 0.175621, -0.044027, 0.293245, -0.140088, 0.629444, 0.238115, 0.559976, 0.672663, -0.308742, 1.253499, 0.742785, -0.021395, 0.309036, 0.334485, -0.231680, 0.125893, 0.309040, 0.148031, -0.083099, 0.236743, -0.471849, -0.015476, 0.458202, 0.328105, 0.105936, -0.381771, -0.312016, -0.675330, -0.511172, 0.782143, 0.599467, -0.075035, 0.152057, 0.102966, -0.979957, 0.096432, -0.218341, -0.625640, 0.285767, 0.361448, 0.452673, 0.093566, -0.174737, -0.331755, 0.054231, -0.067559, 0.315636, 0.519582, -0.801247, -0.680058, -0.342188, -0.582716, -0.539640, -0.630630, -0.267030, -0.544010, -0.554003, 0.309427, -0.009352, 0.549349, 0.224900, -0.197308, -0.106208, -0.123324, 0.326060, -0.106710, 0.772339, 0.768943, -0.554944, 0.673740, 0.076350, -0.222304, 0.351141, 0.740085, -0.053218, 0.012202, 0.193202, 0.026396, 0.120961, 0.120461, -0.066906, 0.206214, 0.350118, 0.999166, -0.894064, -1.635049, -0.465538, 0.218861, -0.244723, 0.413464, -0.439114, 0.761590, 0.020097, 0.620344, 1.127631, -0.464092, 1.084887, -0.742007, 0.043085, 1.601487, 0.596993, 1.206189, 1.172994, 0.689110, 0.489636, 1.084840, 1.647091, 0.960127, 1.191334, 1.503231, 0.039943, 1.170722, 0.342652, -0.079293, 0.212987, 0.247730, -0.846248, 0.582808, -1.091974, -0.001681, 0.607189, -0.389020, -0.604926, 0.103925, 0.346823, 0.868654, 0.001132, 1.047161, 0.195981, 0.511200, 0.285473, 0.031876, 0.816365, -0.110200, 0.350286, -0.756551, -0.203654, 0.021813, 0.394502, -1.127861, -1.168840, 1.173326, -0.827820, -0.024669, -0.584257, -0.480771, 0.539195, 0.003634, -0.042219, -0.022436, 0.688576, 0.502582, 1.239127, 0.409551, -0.274229, 0.790411, 0.035820, -0.965386, -0.132622, -1.261117, -0.297289, -1.377544, 0.042575, -0.774737, -0.234661, -0.023104, 0.733018, 0.756667, 0.216000, 0.592977, 0.657229, 1.924701, -0.059137, -0.304444, -0.266972, 0.250193, -0.611124, 0.111570, -1.072826, 0.152683, 0.474197, -0.308359, 0.854320, 0.104234, -0.048062, 1.405941, -0.219996, 0.554892, 0.088857, 1.049468, -0.014975, -0.083004, 1.698704, 0.346107, 0.399741, -0.452405, -0.060731, 0.596045, 0.300247, -0.785736, 0.816101, -0.608980, -1.505444, -0.956957, -1.533896, -2.598956, -2.550293, -1.837197, -0.022294, -0.690553, -0.754463, 0.893643, -0.150695, -0.656856, 0.346454, 0.889184, -0.874427, 0.314526, 0.907115, -1.548562, 0.795610, -0.366120, -0.142304, -0.437423, -0.451224, -0.045289, 0.992882, -0.504598, -1.326616, -0.158192, -0.219365, 0.045093, -0.233137, 0.369799, 0.092894, -0.067011, 0.504707, 0.054232, -0.184223, 0.027499, 0.341256, 0.142732, 0.105806, 0.827785, -0.457566, -0.092826, 0.322068, 0.442123, -0.238983, 0.257408, 0.039630, -1.118723, 0.505150, -0.108278, -0.501866, -0.151611, 0.296283, 0.113138, -0.619938, -0.184978, 0.162894, 0.498477, 0.357449, -0.291659, 0.233257, 0.042419, -0.390061, -0.198277, 0.648390, 0.035740, -0.040664, -0.226956, -0.379028, 0.132323, 0.005674, -0.546508, -0.454504, -0.600639, -0.765721, 0.494121, -0.112457, 0.149725, 0.011353, 0.089010, -0.355134, 0.178099, -0.269328, -0.206174, -0.074804, -0.288893, -0.247430, -0.014109, 0.076406, 0.110893, 0.059657, 0.028283, 0.776307, 0.078571, -0.290314, -0.198375, -0.281862, 0.162493, -0.083916, 0.599045, -0.741469, -0.051193, 0.008752, 0.957719, -0.100258, 0.344183, -0.149482, -0.756002, 1.083116, -0.404772, -0.617791, -0.044170, 0.386907, 0.098067, -0.611477, -0.043379, 0.254136, -1.056979, 0.702034, 0.457062, 0.266161, 0.658148, 0.888589, -0.631394, -0.348733, -0.884637, -0.188802, 0.306568, 0.354444, 0.297325, 0.960553, 0.179612, -0.076212, 0.414275, 0.137016, -0.076095, -0.304614, -0.237564, -0.024136, -0.945240, -0.214175, -0.333536, -0.426039, 0.279129, 0.034121, 0.413132, -0.281383, -0.167144, -0.368287, -0.146382, -0.285040, -0.306195, 0.043895, 0.536783, -0.109173, -0.346882, 0.585111, -0.365766, -0.291016, -0.935573, -0.784507, 0.040753, 0.318764, 0.314575, 0.530448, 0.149352, 0.141872, -0.341925, 0.517907, -0.605807, -0.211131, -0.298044, 0.139980, 0.112190, -0.607062, -0.297305, 0.073907, 0.136946, 0.052847, 0.207517, -0.019805, -0.350881, -0.421933, -0.049969, 0.246471, -0.117493, -0.471567, -0.221674, 0.160122, -0.117620, 0.260222, 0.183840, -0.094823, 0.075428, -0.217202, 0.100212, -0.371088, -0.290981, -0.675475, 0.282556, 0.048874, -0.048646, 0.972477, -0.199207, 0.026145, -0.327956, -0.474346, -0.553034, -0.383655, -0.177059, 0.138005, -0.158386, -0.208586, 0.048428, -0.146496, -0.419376, 0.546192, -0.592052, -0.043660, -0.546825, -0.584489, 0.050120, 0.332714, -0.023229, 0.048376, 0.085955, 0.120754, 0.026336, 0.213278, -0.461276, -0.323701, -0.337242, 0.152761, 0.130684, -0.590686, -0.643016, -0.023855, -1.191859, -0.572139, 0.832917, 0.577299, 0.503108, -0.013301, -0.195452, -0.281263, -0.815118, -0.132357, 0.369681, -1.443233, 0.231930, 0.470217, -0.898441, 0.348417, 0.363614, 0.277694, -0.336115, 0.381329, 1.020974, 0.156289, 0.707033, 0.652338, 0.377143, 1.514360, -0.555007, 1.559799, 1.188335, 0.007320, -0.244136, 0.104104, 0.186019, -0.594414, -0.000050, 0.292924, 0.638475, -0.017005, 0.454998, 0.469231, 0.039779, 0.821452, -0.800222, -0.645166, 0.021854, -0.089236, -0.104190, -0.315019, -0.204609, -0.380988, 0.221181, -0.124425, -0.409073, -0.527060, 0.567865, 0.645207, -0.173243, 0.241504, 0.392834, 0.083969, -0.274571, -0.446228, 0.367290, 0.012190, -0.139360, 0.057482, 0.664480, 0.276860, -0.599534, -0.070165, 0.163902, -0.277267, -0.017863, 0.052192, -0.221942, -0.062766, -0.238494, 0.543785, -0.082773, -0.059523, -0.476407, 0.625986, 0.011769, -0.242728, 0.392774, -0.291394, -0.084059, 0.159831, -0.444269, -0.091534, -0.441763, 0.312697, 0.369125, -0.715727, -0.111512, 0.253349, 0.352870, 0.098188, 0.384952, 0.411955, 0.468575, 0.227724, -0.897974, -0.200037, -0.043419, 0.353400, 0.205822, -0.113884, -0.089837, -0.126245, 0.218084, -0.118262, -0.448815, -0.575223, 0.651303, 0.296787, -0.616120, 0.216774, 0.214623, 0.091638, -0.799449, 0.751938, 0.386184, 0.402157, 0.667632, 1.015575, -0.476833, -0.252659, -0.872927, 0.217688, 0.353210, 0.197928, 0.311871, 0.996783, 0.390014, 0.280456, 0.568972, 0.344398, -0.206417, 0.122808, -0.169932, 0.134009, -0.783430, 0.264992, -0.204281, -0.111459, 0.768436, 0.209782, 0.691452, -0.121181, 0.074620, -0.138692, 0.085947, 0.229666, -0.618066, 0.101137, 0.050039, 0.281374, 0.328244, 0.624473, 0.352043, -0.728652, 0.252015, -0.652517, -0.166728, -0.271371, -0.283682, -0.229741, 0.204850, 0.239120, 0.054618, 0.010158, 0.345944, 0.166702, 0.210708, -0.495071, -0.141845, 0.047530, -0.256338, -0.097567, 0.413929, 0.109127, -0.211942, -0.223684, -0.135422, 0.144771, -0.010941, -0.474044, -0.670108, 0.234003, 0.251509, 0.267701, 0.471622, 0.216104, 0.060542, 0.091181, 0.130949, 0.033394, -0.362927, -0.287244, 0.024329, -0.134718, 0.158895, 0.122745, -0.307073, -0.577758, -0.388782, 0.511898, -0.105915, -0.261152, -0.193921, -0.359646, -0.282183, 0.196988, -0.814740, -0.067806, -0.577987, 0.090777, 0.302801, 0.193782, 0.230782, -0.736372, 0.194776, -0.673667, -0.350928, -0.169486, -0.190762, -0.121035, 0.561446, 0.021543, 0.261933, -0.125109, 0.384025, 0.111445, -0.034011, -0.843353, -0.265610, 0.113825, -0.332077, 1.278983, -1.105149, -2.038990, -2.078078, -1.601871, -2.701575, -2.916695, -2.054796, -0.585875, 0.177945, -2.823842, 1.871730, -0.497133, -0.898159, -0.082635, 2.200198, -1.974451, -0.356887, 0.208461, -1.611120, 0.045434, 0.232773, -0.309667, -0.454289, -0.706003, -0.640998, 1.343665, -1.455711, -0.471148, -0.839916, -0.446360, -0.184560, -0.134841, 0.686229, 0.298277, 0.073947, 0.222601, 0.217838, -0.134786, -0.098104, 0.311316, -0.178676, -0.475417, 0.448931, -0.044906, -0.177568, -0.368681, -0.312939, -0.056061, -0.054150, 0.261762, -0.382042, 0.106867, 0.309372, -1.013588, -0.299845, 0.546787, 0.217620, 0.128630, 0.364044, 0.318343, 0.016028, -0.585197, 0.649772, -0.078549, 0.299299, -0.411556, -0.351204, -0.502805, -0.524820, 0.256579, 0.325984, 0.180555, -0.191363, 0.076155, -0.450776, -0.040286, 0.247215, 0.555638, -0.272433, 0.115041, 0.215103, 0.845102, 0.152922, 0.051392, -0.248326, 0.028826, -0.575797, -0.310367, 0.338983, -0.447214, -0.334377, 0.068835, 0.476909, -0.168158, 0.420430, 0.537370, -0.132410, 0.122713, -0.370528, -0.004589, -0.059544, -0.155401, 0.568628, 0.351184, 0.213857, -0.420319, -0.228238, 0.311353, -0.358834, 0.112256, -0.430027, 0.840517, 0.257435, 0.156636, -0.007203, 0.666543, 0.322632, -0.012994, 0.422484, 1.325064, -1.155914, -1.946363, -2.057949, -1.385463, -2.357865, -2.925864, -2.307435, -0.962616, -0.155577, -3.179665, 1.472084, -0.503529, -1.041162, 0.018640, 2.182229, -1.635420, -0.707044, -0.041126, -2.045286, -0.674117, 0.439549, -0.359669, -0.584753, -0.594265, -0.657892, 1.269255, -1.853414, -0.988845, -1.155160, -0.458890, -0.421788, 0.147046, -0.051288, 0.487068, -0.315387, -0.445661, 0.232258, -0.536441, -0.348557, 0.465130, -0.084476, -0.703044, 1.101855, -0.584757, -0.841613, 0.549911, -0.608310, -0.013439, -0.313969, -0.072852, -0.468602, -0.415584, 0.127636, 0.408656, 0.227960, -0.057198, 0.016585, -0.067017, -0.317930, -0.044386, 0.239592, 0.654686, 0.242943, -0.202740, 0.371011, 0.011327, -0.542686, 0.071904, -0.261430, 0.037754, -0.304473, 0.602609, 0.771681, 0.113341, -0.027887, -0.363350, -0.242673, 0.141473, 0.099429, 0.438945, -0.121525, 0.097942, -0.392323, 0.083552, 0.202775, -0.165404, -0.200726, -0.255109, -0.100929, -0.497181, -0.483308, 0.180657, 0.010503, 0.301053, -0.261616, -0.228674, -0.284735, -0.557988, -0.619502, -0.209826, -0.316437, -0.412971, 0.527602, -0.137733, -0.237320, 0.506675, -0.443777, 0.236573, -0.061331, 0.145599, -0.434954, -0.578209, -0.227766, 0.654105, 0.103076, 0.027880, -0.137967, 0.259423, -0.428037, 0.148771, 0.090944, 0.822148, 0.826140, 1.105318, 0.217199, 0.312307, 0.426856, 0.241896, -0.407013, -0.763251, 0.610396, -0.587882, -0.055645, -0.396625, -0.749243, -0.147610, 0.063621, 0.059808, 0.092852, -0.200063, -0.164016, 0.132480, -0.179571, 0.007912, 0.614598, -0.682754, -0.595968, 0.187753, -0.785205, -0.140353, 0.096732, 0.197505, -0.549112, -0.370245, -0.184729, -0.359159, 0.546740, -0.258244, 0.192450, -0.281142, -0.970477, 0.877555, -0.004008, 0.326880, 0.083852, -0.183703, 0.450570, 0.721029, -0.049742, 0.454337, -0.362977, -0.273136, -0.739676, -0.468875, 0.501851, 0.573239, 0.201753, -0.049969, -0.579310, -0.234693, 0.175021, -0.458417, -0.113613, -0.053338, 0.131581, 0.575860, 0.705109, -0.208331, -1.053105, -0.359214, 0.114207, 0.641494, -0.211009, 0.548489, -0.199437, 0.345600, 0.015746, 0.483776, 0.423344, -0.427494, -0.275019, 0.450471, 0.764026, 0.509299, -0.722872, -0.263941, 0.716568, -0.635682, -0.075438, -0.293443, -0.571799, -0.429535, -0.499939, -0.565859, -0.473775, -0.513445, 0.317647, -0.082557, 0.194495, -0.444607, -0.312896, 0.667546, 0.030063, 0.522681, -0.384145, -0.310274, -0.345653, 0.130090, -0.080001, -0.144115, -0.234589, 0.174606, -0.558662, -0.507745, 0.318692, 0.108337, 0.498621, -0.333641, -0.506448, 0.035600, -0.417449, 0.332493, 0.154641, 0.661395, 0.689190, 0.984681, -0.172535, 0.705927, -0.629557, 0.154522, -0.316494, 0.039577, 0.234640, 0.487093, -0.073172, -0.283969, 0.178116, 0.049621, -0.360423, 0.329498, -0.356121, -0.127059, -0.573321, -0.105826, -0.297610, -0.441164, 0.104842, -0.082575, 0.222774, -0.089225, -0.301846, -0.087056, 0.067011, 0.137522, -0.462263, -0.581919, -0.082412, 0.401061, -0.384875, 0.060411, -1.110956, -0.184689, -0.569647, 0.370680, -0.620969, -0.524032, 0.154742, 0.444819, -0.334836, -0.068917, 0.772540, 0.248534, -0.825417, -0.053081, -0.024981, 0.303268, -0.421829, -0.135330, 0.728431, -0.093157, -0.236732, 0.005963, -0.172896, 0.168276, -0.731033, 0.600101, 0.034325, -0.684086, -0.145692, -0.146483, 0.492154, 0.897829, 0.035592, -0.613225, -0.038134, 0.203306, 0.374936, 0.266336, -0.339034, 0.065733, -0.869407, 0.110035, 0.224348, -0.506678, 0.640072, -0.940661, 0.004612, -0.780611, 0.160955, -0.114076, -0.343544, -0.075552, -0.084288, -0.339012, -0.303127, -0.115001, -0.437070, 0.727477, -0.507164, 0.186858, -0.992806, -0.174258, -0.518410, 0.902358, -0.316343, -0.084826, -0.190291, 0.132693, -0.899562, -0.562995, 0.305558, 0.358328, -0.272374, -0.119149, -0.265797, 0.471653, -0.356782, -0.825488, 0.299415, 3.750194, -2.034528, -1.790139, -1.086467, -2.127235, -0.424008, -0.107374, -0.874845, -2.257970, 0.063694, 0.142052, -1.055672, 0.509829, 0.130683, 0.233352, 0.823892, 0.263975, -0.176243, 1.053251, 1.292127, 0.686847, 1.311245, 0.593064, 0.471477, 0.917174, 1.017800, 0.040449, 0.903349, 0.382361, -0.618825, 5.837553, 4.746248, 4.005872, 4.180023, 2.735307, 2.447340, 1.663236, 0.332927, 1.358050, 0.698045, -0.394965, 0.367039, 0.159976, 0.148220, -0.914819, -1.257156, -0.064145, -1.112687, -1.329085, -0.899548, -1.071439, -1.943584, -1.468612, -1.597476, -1.103925, -2.034337, -0.549040, -1.714043, -1.029186, -0.894697, 0.540066, 0.218033, 0.206429, 0.376012, 0.458481, 0.179954, -1.138897, -0.806992, -0.707293, -0.972438, -0.308119, -0.398633, 0.937076, -0.352875, 0.438241, -0.160804, 0.101444, -0.513764, -0.918452, -0.348255, 0.267880, -0.002438, -0.548841, -0.288591, -0.183786, 0.364155, 0.516965, -0.273154, -0.435153, 0.289324, 4.270806, 2.303369, 3.524704, 2.743042, 2.138984, 1.233468, 1.621891, 1.257308, 0.335426, 0.305739, -0.932911, 0.535895, 0.111294, -0.386313, -0.871532, -0.800670, 0.163682, -0.327750, -1.004804, -0.850350, -0.352528, -0.834510, -0.742671, -0.713658, 0.091327, -1.060695, -0.648812, -1.125524, -0.764275, -0.168802, 0.764697, -1.338750, 0.969330, 1.278626, -3.614558, 2.239262, -2.990454, 1.099611, 1.124713, -3.930253, 4.889657, -3.328777, 2.008558, 0.193535, -2.272656, 4.876367, -3.491829, 0.392798, 1.126672, -4.953836, 5.096261, -3.810910, 0.862035, 1.116045, -4.240688, 4.248219, -3.012268, 0.957101, 1.029469, -3.740038, -0.273865, 0.095260, 0.547652, 0.186868, 0.649822, 1.734506, 1.334169, 0.029964, -0.299143, 1.186759, 0.780117, 0.950099, 0.106922, -0.231068, 0.317655, 0.274510, 0.254154, 0.679331, -0.484541, 0.713138, 1.334688, 0.057322, -0.325333, -0.771156, 1.332781, 0.637855, 0.393437, -0.299917, 0.604650, 1.058687, -0.198578, -0.827887, -0.070549, 0.107621, -0.302555, -0.354942, 0.284497, 0.789017, -0.003190, -0.144642, 0.695663, 0.195136, -0.327526, 0.014191, 0.493456, 0.033034, 0.058888, 0.121584, 0.689667, 1.126582, -0.588430, 0.011559, 0.530707, 0.899820, 0.040604, 0.066247, 0.288615, -0.234763, -0.071145, 0.714612, -0.057245, 0.455953, 0.467024, 0.096106, 0.518269, 1.286330, -0.128046, 0.718011, 0.341437, 0.573470, 0.003750, 0.752849, -0.241335, -0.144514, 0.267580, 0.000486, 0.233674, 0.613020, -0.463697, 0.526336, 0.698008, -0.521805, 0.210172, -0.622684, 0.338045, 1.158651, 0.397546, 0.304111, 0.271027, 0.791485, -0.036116, 0.415162, 0.637436, 1.160699, -1.059200, -1.389569, -0.720143, -0.040427, -0.201499, 0.047238, 0.372095, 0.568911, -0.573200, 1.129962, 0.871884, -0.459606, 0.750949, -0.668116, 0.328960, 1.494140, 0.835190, 0.781870, 1.444986, 1.357666, 1.051238, 0.583887, 1.767179, 0.140890, 0.878695, 0.675507, 0.184462, 0.924423, 0.595300, 0.131633, 0.478250, -0.036858, 1.002797, -1.000295, 0.237302, -0.150722, 0.050754, 1.170956, 0.194560, 0.092788, 0.153445, 0.213736, 0.823664, -0.717493, -0.731036, 0.283558, 0.558583, -0.903192, 1.504197, -0.117629, 0.552917, 1.038063, -0.804780, 0.463230, -0.732899, 0.270611, -1.450910, 1.726370, 0.996075, 0.598375, 0.760299, -0.095366, -0.824154, -0.406404, -0.367668, -0.240302, 0.873010, 1.212295, 1.513598, -0.492446, -1.060712, -0.512600, -0.180453, 0.265935, -0.056014, -0.442714, -1.035208, -0.247303, 0.380001, 0.827799, 1.350819, 0.941799, 0.348591, 0.597413, 0.491266, 0.491293, 0.835697, 2.162201, 1.030006, 0.212591, 1.541417, -0.282262, 1.130307, -0.575530, 0.689442, 0.885950, 0.411515, 0.646182, 0.610406, 0.604102, 0.285142, 0.331196, 1.170272, -0.433695, -0.170249, 0.137587, 1.201485, -0.808919, 0.529373, -0.020431, 0.909502, 0.457279, -0.772955, 0.363699, -0.761828, 0.218416, 0.154706, 0.462157, 0.619333, 0.775704, -1.062713, -1.447135, -0.647437, 0.225396, -0.378791, -0.491081, 0.160605, 0.267958, 0.180576, 0.341201, 0.613627, 0.780026, -0.120385, -0.520630, 0.520519, 1.050745, 1.404095, 0.961027, 1.684148, 0.875798, 0.974639, 1.492429, 1.436930, 0.736298, 0.571716, 0.447003, 0.051307, 0.705576, 0.029571, -0.035958, 0.005465, -0.068181, -0.486368, -0.040692, 0.905252, -0.026984, -0.506185, -0.157925, -0.282500, 0.107738, -0.354625, -0.497297, -0.352752, 0.424489, 0.400107, -0.382701, 0.019970, 0.033136, -0.243300, 0.469076, 0.320115, 0.420019, -0.186665, 0.265298, -0.124896, -0.365043, 0.023239, -0.253485, -0.542418, -0.198291, 0.244558, 0.360024, 0.439452, 0.734887, 0.254279, -0.137873, -0.158357, -0.150646, -0.094073, 0.341930, 0.073503, -0.363084, -0.049284, 0.420630, 0.593444, -0.128716, 0.668066, 0.104898, -0.028426, -0.490608, -0.566918, -0.360430, -0.377296, -0.178297, -0.174793, -0.090056, 0.365930, 1.339406, 0.562053, 0.098703, -0.044556, -0.171565, -0.200153, 0.101131, 1.229037, 0.000526, -0.300682, -0.316507, -0.247657, 0.436360, -0.288366, -0.495012, 0.178893, 0.710130, 0.778914, -0.098073, 0.262046, -0.378930, 0.344956, 0.697830, 0.067864, 0.189658, -0.077740, 0.404994, -0.166044, -0.108565, -0.057012, -0.997513, -0.153529, 1.117829, 1.042209, 0.563897, 0.127672, -0.252936, -0.646402, -0.496945, -0.549461, -0.258355, -2.187523, 0.441269, 0.017677, -1.215978, 0.220489, -0.282611, -0.161564, -0.493104, 0.222132, 0.971138, 0.450561, 0.937916, 1.376352, 0.921291, 1.408789, 0.264968, 1.710791, 0.982367, -0.161124, -0.281282, -0.332990, -0.510453, -0.092247, 0.051691, 0.411376, 0.216861, -0.184068, 0.151925, -0.576441, -0.427851, 1.189625, -0.356394, -0.278356, 0.331873, -0.465690, -0.207788, -0.701222, 0.445172, -0.621885, 0.308944, -0.215213, 0.512015, 0.900336, 0.413708, -0.020906, 0.588227, -0.233793, -0.062671, -0.065609, -0.108134, -0.624829, 0.046238, 0.170522, -0.678205, -0.055905, 0.657111, 0.377524, 0.019959, -0.202964, -0.097023, 0.177446, 0.176603, 0.045853, -0.068744, 0.054295, -0.106793, 0.143987, -0.204001, 0.576758, 0.619972, -0.058226, -0.112668, -0.057766, 0.105765, -0.755518, 0.054947, -0.021496, 0.439213, -0.364770, -0.505423, -0.011509, -0.159221, -0.086813, 0.270635, 0.442877, 0.403234, -0.239333, -0.131114, -0.412891, -0.161814, 0.392936, -0.145132, -0.221874, 0.142060, -0.204989, -0.092072, -0.472356, 0.545966, -0.332028, 0.407664, -0.257074, 0.329666, 0.941428, 0.384789, 0.009901, 0.441476, -0.328856, -0.164649, -0.042815, -1.043760, -0.210294, 0.993161, 0.562727, 0.267061, -0.124861, -0.305582, -0.427893, -0.900413, -0.355956, 0.140597, -1.465357, 0.647071, 0.496335, -0.755334, 0.384865, 0.057932, 0.001474, -0.243179, 0.419639, 1.071529, 0.606133, 1.044469, 1.039474, 0.448142, 0.966738, 0.006803, 1.377687, 0.993591, -0.054738, -0.338693, -0.278359, -0.229324, -0.503238, 0.094185, -0.289519, 1.169665, -0.018343, -0.011571, -0.308779, -0.427685, 0.913297, 0.106805, 0.507787, -0.519358, 0.427075, -0.186297, -0.547192, -0.894933, -0.375426, -0.116938, 0.266592, 0.545217, 0.358999, 0.207091, 0.348081, 0.981439, 0.839868, 0.193790, 0.088210, 0.042215, 0.063719, -0.350443, -0.079098, 0.442789, 0.139291, 0.214702, 0.078627, -0.206262, -0.314864, -0.431496, 0.088093, -0.153049, -0.045158, 0.397216, 0.445268, -0.124517, -0.312268, -0.170223, 0.402859, 0.238606, -0.172097, -0.640530, 0.086774, 0.533845, 0.304813, -0.813589, 0.255681, 0.399050, -0.353470, -0.291464, -0.197030, -0.265185, 0.128756, 0.021821, -0.090171, 0.840085, -0.274815, -0.128495, -0.182673, -0.249575, 0.618992, 0.020658, 0.366212, -0.536685, 0.272419, -0.005823, -0.159567, -0.445697, -0.118578, 0.035974, -0.058745, 0.239986, 0.234870, 0.274268, 0.267605, 1.190171, 0.709315, -0.225222, 0.107444, 0.395669, 0.337909, 0.906726, -0.883215, -1.412140, -0.627291, 0.265704, -0.389352, -0.202613, -0.023454, 0.210688, -0.026413, 0.683812, 0.804829, 0.018382, 0.685811, -0.326210, 0.318242, 1.535716, 0.857683, 1.059557, 1.598776, 1.046913, 0.655065, 0.986155, 1.323434, 0.359647, 1.063474, 0.380078, 0.018142, 1.241730, -0.341358, -0.241134, -0.464281, -0.360404, -0.577310, -0.422480, -0.017742, -0.309425, -0.114025, -0.185157, -0.376274, -0.454211, -0.162356, 0.224306, 0.361852, 0.257857, -0.140055, 0.767989, -0.317930, 0.426570, -0.052212, -0.088675, 0.242627, -0.223764, 0.253138, 0.361854, 0.143982, 0.146162, 0.632388, -1.191598, 0.114273, 0.384196, 0.109616, 0.406693, 0.196935, 0.115801, 0.367925, -0.132259, -0.006901, -0.087988, -0.343160, -0.011327, 0.392642, -0.831743, 0.080626, 0.030102, -0.361863, 0.710834, -0.347307, 0.763756, 0.453790, 0.091303, 0.137006, -0.127808, -0.001486, 0.028510, -0.301960, -0.403514, 0.337663, 1.996325, -0.321456, -0.255753, -0.529334, -0.154120, -0.253476, 0.096482, 0.194456, -0.329673, 0.237410, -0.254622, -0.090482, -0.297290, 0.072155, 0.246626, 0.458639, 0.566534, -0.244032, 1.192542, -0.211186, 0.566700, 0.065020, -0.276084, -0.174148, -0.256254, 0.115273, 0.518279, 0.087604, -0.132722, -0.153735, 0.255295, -0.145530, -0.532574, 0.385169, -0.108626, -0.556382, -0.010059, -0.216000, 0.973731, 0.573520, -0.472862, -0.178539, -0.447964, -0.934597, -0.694447, -0.957609, -0.624918, -0.652639, 0.289354, -0.378935, 0.123382, -0.616182, -0.163863, 0.390738, -0.064807, -0.011417, -0.176153, -0.626698, -0.209679, -0.122900, -0.149621, -0.020054, 0.059894, 0.083728, -0.094429, 0.045404, -0.401835, 0.254790, 0.202221, -0.054556, 0.351665, 0.098581, 0.561301, -0.095673, -0.175039, 0.540544, 0.671930, 0.014060, 0.307772, 0.371652, 0.330744, 0.310697, 0.798520, 0.000649, -0.579587, -0.215469, -0.514578, 0.159679, -0.272016, -0.056932, -0.095598, -0.442915, 0.119328, 0.304168, 0.291881, 0.501158, -0.343731, -0.391883, 0.389148, 0.181794, 0.045609, -0.355931, -0.232765, -0.264689, 0.176943, 0.909719, 0.932847, -0.396139, -0.372963, -0.614075, -0.005055, -0.082752, -0.141311, -0.236385, -0.113594, 0.310856, -0.141132, 0.221247, 0.003003, 0.222672, 0.412443, 0.137902, 0.040948, -0.434141, -0.150759, -0.406837, -0.410219, 0.114472, 0.123165, 0.389971, 0.995250, 0.362406, 0.913058, -0.262055, -0.247582, 1.075750, 1.083329, 0.154555, 0.378310, 0.500486, 0.862835, 0.203305, 1.019630, 0.319854, 0.064035, -0.104912, -0.671145, 0.505765, -0.314339, 0.634421, 0.523206, -1.960023, -0.981655, -1.818285, -0.639189, -0.415761, -1.568187, -0.452901, 0.632812, -0.336567, 0.011104, 0.321877, 1.005277, -0.391124, -0.007670, 0.958383, 1.019016, 0.902193, 0.680382, 1.226423, 0.031011, 0.306902, -0.661512, -0.488150, 0.212746, -0.184269, -0.264699, -0.187036, -0.905297, 1.447344, 0.297571, 6.259329, 2.229431, -0.351318, 0.450528, 0.416768, 0.641599, 0.121068, 0.444226, 0.335610, 0.339962, -0.656151, 0.386503, 0.017581, 0.517317, -0.453634, 0.512439, 0.475641, -0.354528, 2.239728, 0.946882, -0.440358, -0.788100, 2.404278, 0.592603, -0.074944, -0.492014, 0.178380, 0.079817, 0.950895, -0.796319, -3.082188, -1.567092, -0.382443, -0.324923, -0.573234, -0.979983, 0.056513, 0.574897, 0.098507, 0.508969, -0.888192, 1.074930, -0.770225, 0.224412, 0.581577, -1.027630, 0.251881, -0.350567, -0.526485, 0.503439, 1.670495, -0.339541, -0.142192, 0.516057, 0.141074, -0.023821, 1.227791, 0.173125, 1.376056, 0.152563, 4.733303, 3.145847, -0.539652, 0.895975, -0.041005, 0.671500, 0.116024, 0.529537, 0.018621, 0.804640, -0.045789, -0.116472, 0.407628, 0.438992, -0.930083, 0.389607, -0.231423, -0.353194, 2.402069, 0.646369, -0.066083, -0.229509, 2.138099, -0.472034, 0.307082, 1.034150, -0.160598, 0.536481, 7.050951, -3.187320, -2.662714, -2.724943, -2.909194, -1.289440, -1.130525, -1.860461, -2.804565, -0.482989, -0.698139, -1.572382, -0.147161, -0.258089, -0.030441, -0.012841, -0.135045, -0.383327, -0.268892, 0.444238, 0.133795, 0.339072, -0.164929, -0.002932, 0.118756, 0.309348, -0.035060, -0.020393, -0.447942, -0.844532, 4.065557, 2.673036, 2.842159, 2.118668, 1.740015, 1.182934, 0.614693, 1.096020, 0.635347, 0.201283, -0.221367, -0.317358, -0.297288, -0.618849, -0.512633, -0.488194, -0.674648, -0.572681, -0.722365, -1.031024, -0.885687, -1.129271, -0.920557, -1.248183, -1.136327, -1.077865, -1.107779, -1.074557, -1.036729, -0.982609, -0.252192, 0.061591, 0.418985, 0.497127, -0.204241, -0.059206, -0.278793, 0.048503, 0.128369, 0.091319, 0.060012, -0.078176, 0.195015, -0.062826, -0.263585, -0.234458, 0.024903, -0.012675, 0.165545, -0.368923, 0.063956, 0.092360, 0.180085, 0.271918, 0.159354, -0.213908, 0.253472, 0.041081, 0.099972, 0.119721, 2.025533, 1.199014, 2.135243, 1.472210, 0.959964, 1.074256, 0.322313, 0.853088, 0.600480, 0.259477, -0.253462, -0.154692, -0.140375, -0.176292, -0.381952, -0.231032, -0.078729, -0.100400, -0.100494, -0.576538, -0.435176, -0.295765, -0.158055, -0.717791, -0.721744, -0.473987, -0.580071, -0.217088, -0.370435, -0.491251, 0.096183, 0.263562, 0.632187, 0.926113, -0.759937, -1.447896, -0.647590, 0.419076, -0.155403, -0.500539, -0.077394, 0.219596, 0.235920, 0.372991, 0.632696, 0.414384, 0.319085, -0.076918, 0.309676, 1.111592, 1.380521, 1.035252, 1.339780, 1.028111, 1.048497, 1.045583, 1.240503, 0.284736, 0.447986, 0.173686, 0.028034, 1.277511, -0.217304, -0.169985, 0.616939, -0.153390, -0.185096, 0.083334, 0.160948, 0.233259, -0.114228, 0.006191, 0.253824, 0.615379, -0.188383, -0.073035, 0.162577, -0.508104, -0.527456, -0.150708, -0.417741, -0.268663, -0.569760, 0.351903, 0.778201, -1.036553, 0.313021, 0.574607, -0.335262, -0.027337, 0.645442, -2.513841, -0.094677, 0.977420, 0.607754, 0.602262, -0.188097, -0.053593, 0.339426, -0.574978, -0.288177, 0.618455, 0.452636, 0.433078, 0.237624, 0.160885, 1.202797, 0.748526, 0.084460, 0.041950, -0.157081, -0.015527, -0.211948, -0.020750, 0.426412, 0.003842, 0.059369, -0.858707, 0.005931, -0.781684, 0.358064, 2.060556, -0.245798, -0.272205, 0.037315, -0.193190, -0.459053, 0.331938, 0.499425, -0.033695, -0.343022, 0.508562, 0.293654, -0.092382, -0.528178, 0.105572, 0.450324, -0.151855, -0.480650, -0.589140, 0.127041, 0.029884, -0.721108, -0.308876, 0.025869, -1.157259, 0.076701, 0.234897, -0.190619, 0.128090, -0.637362, 1.160114, -0.272774, -1.025098, 0.003452, -0.144283, -0.167110, 0.880222, 0.695919, 0.670916, 0.058864, -0.687744, 0.072483, -0.208170, -0.575730, -0.267964, -0.724639, -0.703655, -0.244810, -0.482329, -1.414323, -0.492390, -0.662969, -0.181166, -0.132336, 0.060782, 0.207895, 0.893929, -0.200078, 0.533321, -0.280696, -0.420005, -0.098072, 0.449037, -0.214874, -0.219100, 1.041941, 0.244047, -0.203222, 0.776438, 0.235489, 0.635395, 0.259585, 0.665085, -0.068049, 0.223030, -0.434276, 1.078025, 1.362296, -0.374205, 0.146874, -0.652692, 0.461863, -0.146404, -0.166618, 1.216228, 0.071106, -0.682825, -0.129425, -0.101848, 0.452414, -0.468740, -0.150582, -0.340267, -0.057596, 0.582787, 1.122366, 0.115855, -0.027553, 0.823178, 0.099977, -0.282773, -0.205837, -0.055186, -0.897951, -0.489968, -0.025505, -0.148463, 0.288129, -0.015789, -0.489782, -0.199007, 0.897754, -0.161746, -0.153960, -0.178838, -0.584474, -0.337292, 0.391977, 0.467607, -0.264916, -0.154363, 0.112585, 0.583579, -0.689013, -0.473718, 0.362269, -0.039929, -0.233742, 0.589251, 0.544303, 0.070080, 0.039807, 0.356827, -0.063828, 0.281720, -0.480569, 0.840803, 0.547018, -0.385340, 0.030901, -0.043282, 0.023244, -0.166696, 0.058753, 1.271591, -0.229794, -0.085571, 0.534355, 0.589628, 0.001667, 0.708755, 0.716597, -0.193173, -0.022936, -0.177437, 0.057071, 0.435951, 0.421834, 0.043778, -0.504482, 0.049417, -0.511069, 0.523208, -0.334227, 0.538545, 0.073785, 0.509300, -0.014646, -0.210089, -0.472850, -0.838659, -0.338278, 0.213993, 0.251610, -0.074262, -0.643129, -0.507277, 0.405952, -0.245646, -0.103523, -0.086681, -0.181960, 0.533638, 0.456404, 1.089894, 0.559775, 0.194458, 0.711879, 0.845964, 0.119554, -0.162392, 0.518035, 0.484845, -0.210874, -0.126066, 0.500483, 0.246910, 0.007110, 0.086332, 0.535389, -0.182888, 0.649206, 0.070245, 0.607788, -0.106880, -0.176196, 0.033713, 0.678129, -0.011066, 0.265058, 0.316740, 0.063029, -0.284209, -0.248257, -1.301661, -0.886393, -0.162320, 0.298907, 0.446616, -0.269622, -0.332910, -0.073308, 0.792812, 0.500280, 0.076928, -0.571867, -0.067277, -0.314071, 0.484391, -0.069377, -0.573115, 0.012848, 0.129945, 0.448369, -0.165501, -0.031591, 0.465238, -0.023383, -0.055411, -0.196200, 0.005874, -0.238813, 0.086179, 1.093795, 1.292497, 0.986897, 0.478510, 0.499407, 0.503912, -0.084266, -0.131863, 1.318063, 0.380884, -0.114525, -0.042775, 0.428272, 0.081348, -0.215343, -0.337428, -0.068288, -0.061872, 0.532823, -0.022222, 0.463014, -0.256793, -0.424061, -0.127439, 0.801717, -0.322739, 0.517545, 1.281024, 1.682816, 0.399894, -1.695224, -0.513545, -0.743186, 0.568028, 1.455570, 0.237224, -0.241524, 1.750350, -0.544873, 0.305680, -1.106077, -1.094670, -0.957221, -0.549280, -0.974611, -0.281823, -0.030770, -0.652600, -0.108563, -0.610282, 0.429610, -0.025769, -1.210176, 0.036623, -0.443813, 0.339616, -0.045847, 1.176099, 1.276729, 2.046849, 2.154835, 0.619155, 1.177348, 1.597151, 1.174543, 0.997565, 1.635562, 0.773967, 1.381347, 0.257250, 0.748857, 0.012493, 0.980941, 0.824210, 0.660799, 1.839507, 1.933061, 1.234040, 0.489672, 0.088953, 1.720955, 0.652093, 0.509736, -0.312320, -0.050966, 1.339685, 0.564273, 0.329234, 0.070817, -1.102990, -1.472966, -0.943587, -0.117887, 0.917491, -0.186787, 1.301232, 0.639139, 0.149010, -0.613135, -0.983200, -0.784199, 0.977201, 0.068033, -0.492669, 0.205595, 1.032687, 1.416379, 0.078584, 0.015896, -0.827974, -0.583603, 1.355909, 0.728099, 0.393236, 0.404983, 0.446359, -0.183059, 0.640279, 0.799837, 1.162832, 1.790748, 0.602315, 0.857220, 0.710315, 0.793854, -0.000223, 1.472255, 0.340204, 0.653567, 0.640667, 0.597823, -0.149485, 0.176952, 0.517976, 0.342989, 1.654328, 1.715363, 1.087300, 0.250576, 0.205889, 0.868542, 0.656797, 0.901190, 0.183207, -0.320760, 0.197943, 0.188867, 0.493720, 0.235824, 0.524393, -1.278713, -1.346548, -0.652852, 0.401599, -0.333578, -0.036756, 0.185697, 0.494085, 0.048254, 0.890897, 0.886168, -0.184599, 0.270790, -1.052389, -0.073298, 1.669131, 1.276399, 1.035839, 1.859831, 1.190131, 0.857703, 1.066560, 1.716081, 0.250807, 0.719188, 0.191212, 0.138916, 1.209267, -0.077760, 0.013751, 0.039108, 0.143969, -0.265097, -0.400107, -0.075032, -0.074310, -0.506515, 1.375168, -0.157995, 0.593167, 0.584183, 0.564910, 0.462996, -0.344751, 0.611759, 0.838120, 0.002896, -0.004047, -0.319902, 0.340682, 0.571583, 0.225229, 0.007606, 0.433105, -0.497897, -0.130395, 0.328157, -0.744542, 0.547845, 0.383038, 0.421779, -0.060112, -0.315312, 0.002488, -0.145267, -0.420874, 0.039657, 0.180164, -0.615708, -0.572579, 0.449218, -0.023590, 0.337996, 0.147701, -0.148309, 0.191872, -0.532578, -0.304935, 0.272988, -0.026901, 0.501765, 0.182639, 0.087403, -1.070872, 0.401305, 0.169171, 0.369212, 1.826533, -0.098900, -0.480138, -0.043430, 0.049416, -0.356241, -0.224766, -0.073156, -0.223908, -0.868371, 0.815263, -0.220326, 0.552417, 0.931210, 0.652124, 0.591312, -0.173729, 0.940005, 0.857912, 0.205656, 0.176072, -0.354105, 0.214013, 0.532959, 0.626053, 0.187503, 0.745285, 0.022125, 0.154760, 0.843684, 0.190140, 0.089172, -0.505899, -0.486649, -0.042555, -0.239451, -0.159883, 1.134155, 0.182322, -0.152017, -1.272123, 1.728346, -2.468068, 0.524732, 0.784775, -1.968521, -1.451657, -1.577737, -0.945460, -0.568748, -2.427913, -2.249258, -1.195469, -2.356311, -2.044960, -1.540459, -0.913688, -1.661252, -2.018523, -0.628754, -0.888657, -0.059368, -0.563757, -0.752422, -0.045431, -0.165635, 0.220408, -0.596356, -1.146497, 0.618255, -0.689713, -0.094471, 0.038665, -0.228974, 0.235852, -0.936340, -0.286848, -0.550008, 0.026030, -0.769203, 0.111647, -0.742974, -0.167843, -0.318234, 0.530769, -0.756054, 0.137302, -0.532917, -0.490435, 0.097217, -0.598287, -0.170942, 0.207232, -0.778241, -0.293260, 0.784189, 0.847302, 0.195183, -0.356224, -0.752193, 0.007881, 0.278242, 0.792522, -0.076835, -0.158731, -0.645508, 0.114841, -0.468800, -1.145462, -0.166501, 1.239541, 0.293391, -0.164071, -0.103177, -0.304595, 0.337829, -0.107567, -0.185460, -0.391580, -0.616313, -0.716710, -0.313645, -0.234512, -0.356799, -0.078384, -0.319950, 0.082383, -0.354872, -1.231751, 1.651149, 0.172528, -0.358110, 0.670975, 0.208639, 0.088245, -0.293016, -0.190588, 0.075227, 0.008101, -0.716557, 0.249213, -0.853240, -0.248934, -0.318662, -0.052418, -0.437173, 0.017163, 0.019483, -0.646969, -0.587877, 0.570221, -0.103554, -0.127166, 0.012542, 0.656278, 0.547529, 0.125661, 0.993317, 0.453406, -0.008940, 0.197347, 0.340769, 0.672075, 0.444145, 0.407684, 1.007588, 1.053431, 0.265214, -0.137287, -0.203058, -0.157635, -0.579288, -0.733682, -0.558924, -0.667650, -0.537938, -0.225722, -0.116862, 0.111902, -0.238668, -0.069855, -0.199060, 0.203453, 0.215272, -0.564424, -0.259402, -0.421419, -0.725074, 0.245741, -0.530713, -0.760053, -0.432697, 0.158409, 0.715275, 0.089287, -0.173601, -0.607716, -0.162669, -1.050436, -0.284454, 0.630178, 0.383077, 0.664028, -0.017517, 0.174173, 0.590418, -0.519614, -0.156971, 0.690357, -0.300472, 0.692300, 0.704266, -0.186111, -0.347910, -0.035077, -0.069012, -0.083850, -0.248684, 0.426559, 0.508192, -0.028667, 0.087729, -0.015928, 0.014984, 0.476825, -0.048539, 0.186983, -0.077348, 0.488257, 0.054645, -0.626970, -0.274489, -0.578146, -0.314575, 0.033810, -0.001457, 0.112799, -0.027747, -0.763325, 0.032147, 0.417859, -0.041184, 0.314022, 0.246528, -0.623124, -0.016492, -0.465130, -0.589518, -0.218462, -0.305294, -0.498253, -0.192900, 0.130875, 0.425900, 0.200558, -0.255697, -0.586455, 0.218365, -0.929978, -0.096014, 0.230762, 0.274842, 0.706813, 0.146378, 0.316269, 0.612641, -0.520496, -0.344517, 0.845636, 0.893410, -0.638288, -1.799254, -1.292251, -1.376485, -2.875597, -2.560331, -1.949236, -0.146483, -0.434762, -1.582962, 1.277732, -0.518753, -0.818223, 0.267681, 0.923884, -1.058488, 0.073395, 0.776230, -1.438971, 0.922315, -0.355753, -0.184449, -0.668707, -0.523773, 0.026671, 0.501779, -1.113710, -1.541828, 0.258220, -0.427545, -0.224658, 0.187158, 0.568240, -0.357012, 0.309791, -0.138427, -0.280717, -0.515397, 0.247928, 0.267468, 0.400096, -0.543739, 0.957730, 0.090654, 0.135484, 0.248287, 0.239351, -0.096187, 0.545969, -0.073768, -0.307731, 0.176678, 0.131913, -0.204748, -0.420689, -0.342505, -0.208051, 0.525939, -0.161976, -0.333966, -0.542071, -0.451483, -0.131774, 0.237418, -0.181776, -0.067688, 0.749883, 0.491028, 0.411831, -0.775407, -0.780774, -0.002909, -0.224132, 0.037547, 1.245347, 0.302048, -0.820460, -0.119354, 0.904683, 0.440650, 0.077524, -0.209581, -0.388853, 0.003805, 0.530393, -0.004829, 0.510341, 0.253003, 0.367910, -0.525944, -0.490898, 0.343769, -0.289999, -0.531166, 0.203748, 0.238111, 0.045738, -0.365800, -0.140786, -0.257018, 0.754155, -0.229828, 0.195938, 0.105226, 0.736090, -0.053612, 0.628926, -0.358678, 0.464889, 0.095768, -0.187688, 0.598665, -0.009929, -0.697215, 0.104414, -0.283618, -0.290350, 0.246305, -0.271194, 0.248661, -1.175416, 1.126806, 0.190877, -0.082436, 0.649027, 1.013305, -0.805675, -1.016460, -1.346027, -0.380783, -0.498868, 0.581518, -0.475019, 0.869667, 0.248251, 0.050453, 0.788895, 0.363948, 0.339314, 0.018320, -0.057248, 0.229981, -1.123106, -0.702942, -1.112713, -1.054300, -0.398885, -1.212229, -0.942993, -0.168075, -0.290000, 0.415160, 0.105541, -0.099588, 0.519016, 0.708275, -0.119409, -0.181998, 0.394378, -0.398238, -0.072099, -0.184098, -0.103430, -0.217089, -0.447659, -0.207623, 0.001242, 0.582471, -0.179199, -0.144126, 0.142898, 0.153194, -0.042028, -0.186380, 0.137796, -0.186415, 0.627004, -0.188911, -0.318202, 0.043568, -0.051285, 0.197259, -0.171168, 0.023108, 0.487322, 0.381972, 0.259904, -0.001996, 0.143232, -0.020168, 0.110674, 0.321351, 0.163054, -0.142384, -0.198809, -0.086180, -0.467578, -0.160525, -0.143489, 0.094993, 0.041984, 0.117418, -0.329825, 0.247249, 0.277585, -0.050746, 0.094290, -0.318171, -0.402466, -0.467292, -0.507022, -0.060697, -0.163463, -0.077520, 0.297848, 0.412798, -0.037922, -0.067356, 0.577017, -0.210481, -0.087276, 0.167349, -0.135392, -0.342505, -0.387818, 0.040601, -0.465763, 0.425667, -0.382383, -0.170378, 0.035707, 0.092600, 0.151097, -0.522982, -0.073102, -0.276308, 0.167184, 0.020550, -0.554172, 1.294898, 1.387480, 0.453230, -1.215397, -1.940921, -1.775102, -2.100308, 0.598378, 2.545582, 2.065152, 0.271149, 2.585350, -3.499813, 0.315714, -0.638411, 0.383636, -0.445278, -0.228784, -0.268108, -1.004026, -0.737451, -1.120942, 0.109969, 0.162328, 1.139667, -0.546406, -1.314150, -0.730910, -0.090526, -0.346178, 0.628227, 0.412033, 2.827446, 3.256850, 1.541724, 1.386274, 2.329978, 0.986245, 1.988986, 1.472326, 2.720089, 0.381306, 2.956790, 1.454320, 0.402015, 0.403966, 0.895907, 1.213812, 2.018316, 1.646387, 0.929025, 0.980957, 2.486254, 0.508719, 2.185817, 0.548392, -0.559388, -0.312412, 0.744518, 0.153443, 0.175681, -0.231011, -1.463721, 0.562104, 0.391500, 0.034752, 0.968765, 0.721219, 0.887412, 0.097882, -1.255161, -0.485466, -0.230799, -0.811393, 0.623313, 1.234590, 0.557771, -0.905975, 0.074306, -0.191816, -0.355939, -0.986372, -0.045598, 0.022165, -0.021639, 1.078043, 0.028093, -0.150021, 0.775994, 0.786850, 0.647822, 0.385415, 1.780108, 2.498218, 2.025791, 0.970403, 1.256427, 0.700603, 1.348395, 1.453340, 2.699896, 0.091885, 2.883890, 0.536817, 0.448686, 0.414238, 0.184503, -0.137330, 1.826501, 1.437415, 0.999573, 0.720771, 1.025805, 0.492840, 0.913030, -0.095170, -0.006928, -0.527446, 1.241642, 0.436063, 0.894232, 0.167261, -0.452792, -0.785792, -0.354249, -0.006095, -0.558095, 0.146585, 0.680893, 0.244274, 0.427183, -1.374083, 1.700606, -2.281711, 0.332155, 0.611751, -2.002560, -1.109292, -1.315644, -0.927518, -0.726977, -2.201581, -1.969489, -1.394863, -2.525825, -1.797711, -1.394107, -1.060632, -1.492465, -2.131474, -0.478643, -0.944589, -0.062031, -0.379268, -0.566418, -0.961743, -0.506502, -0.767831, -0.373418, -0.377126, -0.190170, 0.085593, -0.557610, -0.814311, -0.797641, -0.446458, -0.930211, -0.229207, -0.746753, 0.357689, -0.857052, -0.452696, -0.361580, -0.404043, -1.010809, 0.629667, -0.260180, 0.441974, 0.370974, -0.385750, -0.219719, 0.219837, 0.005186, 0.468211, -0.213682, -0.666914, -0.164099, 0.717812, 0.135090, -0.057597, -0.083115, -0.458761, 0.617812, 0.364715, 0.498086, 1.163517, 0.830432, -0.001513, 0.056162, -0.232292, -0.517355, -0.307797, -0.814637, -0.316601, -0.297321, 0.225879, -0.119178, -0.830583, -0.313060, 0.499320, -0.507156, -0.799285, 0.025389, -0.538413, -0.347950, -0.131513, -0.428206, -0.498129, -0.092992, -0.231855, 0.064862, 0.518532, -0.631561, -0.610815, -0.543896, -0.403801, -0.313663, -0.485715, -1.107647, -0.072573, -1.216660, -0.565097, -0.545256, -0.450170, -0.798331, 0.753754, 0.058095, 0.779680, 0.993151, -0.183810, 0.249866, -1.081498, 0.905898, 0.474082, 0.220286, 0.591252, 0.901470, -0.235385, -0.114559, -0.973955, -0.047620, -0.083700, 0.323396, -0.066070, 0.573691, 0.038214, -0.285822, 0.062626, 0.065227, 0.350216, 0.372125, 0.010130, 0.188807, -0.763599, -0.192161, -0.547832, -0.674901, 0.152788, -0.081208, -0.257308, -0.247451, -0.292324, 0.189671, 0.462907, 0.512390, -0.035544, 0.160706, 0.259200, -0.781591, -0.092886, 0.076068, 0.408216, 0.036533, 0.091581, 0.183140, -0.111709, 0.628540, 0.384925, -0.173690, 0.528073, 0.353044, 0.085536, 0.239808, -0.802372, -0.289575, 0.524578, -0.061904, 0.634290, 0.032371, -0.323092, -0.242007, -0.406577, -0.180938, 0.641090, -0.049820, -0.282507, 0.250220, -0.248432, -0.037129, 0.151420, 0.206726, 0.015174, 0.866707, 0.048273, -0.027342, 0.528528, 0.378599, -0.086444, 0.129014, 0.107839, -0.664975, -0.103003, -0.005204, 0.166168, -0.427651, -0.263747, -0.047388, -0.101844, 0.361124, 0.724419, -0.473298, -0.625369, -0.259027, 0.716103, 0.090146, -0.338965, -0.008329, 0.150952, -0.515397, -0.167281, -0.425447, -0.146932, 0.195072, -0.302534, 0.433860, -0.221102, 0.528616, 0.240165, -0.446030, 0.156947, 0.657659, 0.289869, -0.030686, -0.562177, -0.281244, 0.416994, -0.085396, -0.032849, 0.281222, -0.272799, -0.212666, 0.425602, 0.421724, 0.526639, 0.133980, 0.196979, 0.474029, -0.174911, 0.682177, -0.084124, -0.050143, 0.231078, -0.856860, 0.648302, 0.680294, 0.110204, 0.915874, 0.147050, 0.418722, 0.211226, -0.293975, 0.237854, -0.310835, -0.817751, 0.291721, -0.253889, -0.070160, 0.217956, 0.446539, 0.653976, 0.085038, 0.180293, -0.185551, 0.127087, 0.609023, -0.291133, 0.986856, -0.030527, -0.073092, -0.305746, -0.414120, -0.127277, 0.283548, -1.452283, -0.504157, 0.025167, 0.433159, -0.506913, -0.319820, -0.892868, -0.415702, -0.227308, 0.507559, 0.087496, 0.678765, -0.248182, -0.094856, -0.089026, 0.504600, 0.251149, 0.681896, -0.505241, -0.108982, -0.138382, 0.445848, 0.322305, 0.497324, 0.199233, 0.323781, 0.273887, 0.032649, 0.095034, 0.212657, 0.017487, 0.372182, -0.304182, -1.091639, -0.178367, 0.298085, -0.076382, -0.136011, 0.020702, -0.194473, -0.629084, -0.001092, 0.675743, -0.077060, 0.007581, 0.039536, -0.040224, 0.426761, 0.870041, -0.209616, -0.165426, 1.122922, -0.143760, 0.825764, -0.049777, 0.329369, -0.028446, -0.369036, 0.380443, 0.408109, -1.033069, -0.811414, 0.496785, 0.627200, -0.449164, -0.384377, -0.823201, -0.728908, 0.090521, -0.163779, -0.318756, -0.045902, -0.250972, 0.092235, -0.083848, -0.019548, -0.194177, 0.201074, 0.098736, 0.459077, 1.153196, -0.721811, -1.361491, -0.886442, -0.252844, -0.771661, -0.055775, 0.050885, 0.488867, 0.265426, 0.428105, 0.486675, 0.185074, 0.419082, -0.011328, 0.403582, 1.464141, 1.002291, 0.798001, 1.737339, 0.880218, 0.739732, 1.213839, 1.073287, 0.772501, 1.104635, -0.179365, -0.007216, 1.318011, 0.284326, 0.136292, 0.329978, -0.201469, -0.068988, 0.197253, 0.291828, 0.149552, 0.023988, 0.069345, -0.108028, 0.505998, -0.477046, 0.211217, 0.116398, -0.014747, 0.683249, 0.056092, 0.063919, -0.236014, 0.104551, -0.336513, 0.342718, 0.401608, 0.307752, 0.585716, 0.413183, -0.002827, -0.124852, 1.279910, 0.502609, -0.321041, -0.436233, -0.244604, -0.730476, -0.916300, -0.714133, 0.597939, 0.735355, -0.087826, 0.036056, -0.111261, -0.318431, -0.094845, -0.242924, -0.583139, -0.368463, -0.205176, -0.261270, 0.315677, -0.428088, -0.253098, 0.113559, 0.039724, 0.818538, 0.591958, 0.027938, 0.001546, 0.240992, 1.955466, 0.442839, 0.145519, 0.423836, -0.301949, 0.157213, 0.597369, 0.266636, 0.019633, -0.174522, -0.045695, -0.250123, 0.634005, -0.213668, 0.096239, 0.093816, 0.110960, 0.711714, 0.411308, -0.400520, -0.483950, 0.030410, -0.066993, -0.321994, 0.700979, 0.504601, 0.308858, 0.272058, 0.243855, -0.383284, 0.218000, -0.106420, 0.093774, 0.012542, 0.811024, 0.483287, 0.948429, 0.832056, 0.330271, 0.201962, 0.412584, 0.473767, 0.144626, 0.409642, 0.497087, 0.755714, 0.519165, 0.430801, -0.117482, -0.346523, -0.364269, -0.717424, -0.750392, -0.762894, -0.739075, -0.955204, -1.047912, -0.690904, -0.153761, -0.136865, 0.278326, -0.046981, -0.474149, -0.124393, -0.246902, 0.274172, -0.414228, 0.424876, 0.381998, 0.161068, -0.146909, 0.138311, -0.112096, 0.398517, -0.425331, 0.132912, -0.330146, 0.418699, -0.166704, -0.451850, 0.038678, 0.372291, 0.439900, -0.076103, 0.025933, 0.093588, -0.387831, -0.080338, 0.039951, 0.325928, -0.067248, -0.671075, -0.347715, -0.079914, -0.200402, 0.230665, 0.388375, 0.217266, 0.217061, 0.134724, 0.206760, -0.039885, 0.135294, 0.017623, -0.424847, -0.107532, -0.296576, 0.064428, -0.016659, 0.006173, 0.196608, 0.108232, -0.030793, 0.335872, 0.443386, -0.166715, 0.180398, -0.350240, 0.308690, 0.178184, 0.590342, 0.264890, -0.285217, -0.091671, -0.014978, 0.385981, -0.287542, 0.496011, 0.305533, 0.500937, -0.172982, 0.140747, -0.038825, 0.652868, -0.368951, 0.131850, 0.190397, 0.582219, 0.128351, -0.310535, 0.071979, 0.173169, 0.391524, 0.272103, 0.116103, 0.193967, -0.222031, -0.229436, 0.429741, -0.459930, 0.673370, -0.049252, -0.622808, 0.556708, -0.880161, -1.213845, -0.318752, 0.322172, 0.372879, 0.890259, -0.612115, 0.430416, -0.378489, -1.679831, 0.375714, -1.422183, -1.161354, -1.083422, 0.256355, -0.852336, 0.445842, -0.544891, 0.845893, -0.406637, -0.024571, -0.318381, 0.165783, -0.748518, -0.480951, -0.444360, -0.595581, -0.136445, -0.621327, -0.196789, -0.362725, -0.301806, -0.270913, -0.136661, -0.056465, -0.661567, 0.783058, -0.704540, -0.637586, 0.376856, 0.230097, 0.530106, -0.191907, 0.691794, -0.308021, 0.212966, 0.586737, -0.613793, -0.163361, 0.445174, -0.133346, -0.448871, 0.216947, 0.189097, -0.754468, 0.488309, -0.216610, 0.068559, -0.226079, -0.001911, -0.417445, -0.313337, -0.106053, -0.301497, -0.050314, -0.279020, 0.244876, 0.179171, -0.153327, 0.234618, 0.275495, -0.336485, 0.020765, -0.503068, -0.334100, 0.234351, 0.347449, -0.242415, -0.040965, -0.141700, -0.377247, 0.235350, -0.303519, 0.007257, -0.258952, -0.432239, -0.509796, 0.008816, -0.569753, -0.503416, -0.300001, -0.242028, -0.358225, 0.275899, -0.030924, -0.419780, 0.641005, -0.274400, -0.569135, 0.155253, 0.225861, 0.383673, 0.107365, 0.677966, -0.644002, 0.474861, 0.624509, 0.135107, 0.158887, 0.352414, -0.236613, -0.422814, 0.426765, 0.142890, -0.804548, 0.894287, 0.192888, -0.039410, -0.867011, -0.666129, -0.009769, -0.433280, -0.123419, 1.054217, 0.368622, 0.476230, -1.353455, 1.477152, -1.841358, 0.862616, 0.510163, -2.171519, -1.180431, -1.792230, -1.002908, -0.546347, -2.938464, -2.268174, -1.789876, -2.345537, -2.120540, -1.462615, -0.650862, -1.586374, -1.990901, -0.575405, -0.745661, -0.442412, -0.713356, -0.710297, 0.314073, -0.467720, -0.678761, -0.656961, 1.251961, 0.180568, 0.714933, -0.249028, -0.340695, 0.414174, -0.041177, -0.025052, 0.058699, -0.533018, -0.402777, 0.434591, -0.211674, -0.711859, -0.228711, -0.712936, -1.396279, 0.098922, -0.672614, -0.569455, 0.183475, -0.086187, -0.000868, -0.456969, -0.241823, 0.063046, 0.585218, -0.322549, 0.822664, 0.241017, -1.069633, -0.842442, -0.657081, 0.093448, 0.078556, -1.231918, 0.371708, 0.599497, 0.486570, -0.736412, 0.320839, 1.025292, 0.681039, 0.230976, -0.825303, -0.082547, -0.880977, -0.939473, 0.219968, 0.851431, 1.052032, -0.618132, -0.528395, -0.119243, -1.009770, 0.005879, 0.091631, 0.292438, 0.084431, -0.569984, -0.204936, -0.154291, 0.458839, 0.209542, -0.524201, 0.843330, -0.822584, 0.143327, 0.061948, -0.665139, -0.201514, 0.356094, 0.150770, -0.348462, -0.283852, -0.376471, -0.920438, 0.328051, -0.268298, -0.239769, -0.062267, 1.027454, 1.793040, 2.604588, -1.152449, -1.494674, -1.071247, -2.013246, -2.151083, -1.480069, 0.843599, 0.960269, 2.689665, -0.326702, 1.866174, -0.048409, 0.417082, -1.111479, -0.940719, -0.472641, -1.050891, -1.923108, -2.124958, -1.768155, -0.044364, 1.573400, 0.695319, -0.986184, -0.542228, -0.193808, -0.195924, 0.048957, 0.907792, 1.691146, 2.466322, 1.368760, 1.082261, 2.552133, 2.853567, 2.439398, 0.063742, 0.816583, 1.811834, 2.376269, 2.075443, 2.394848, -0.502456, 1.543801, 2.684524, 2.138833, 2.052766, 1.643482, 1.997185, 1.786175, 3.051451, 0.873652, 3.663638, 0.496608, 1.036681, 0.972641, -0.426067, -0.009375, 1.572429, -1.776515, -3.226478, -0.966267, 0.734574, 0.043750, 0.984806, -0.869413, 0.139425, 0.420708, -0.304068, -0.007931, 0.294156, 0.144757, 0.920438, -1.418635, -0.849269, -0.509459, -1.326341, -0.343290, 0.046857, 1.236090, 1.160903, 1.890746, 1.957455, 0.180285, 0.645279, -1.272779, -0.266013, 0.485642, 0.504154, 1.189620, 3.393312, 2.113286, 1.049245, 2.881969, 3.660812, 1.324504, 0.204156, 0.786505, 0.531524, 1.416139, 0.799077, 2.135951, -0.330386, 0.554728, 2.024656, 1.814868, 1.337151, 1.090746, 2.603758, 0.934650, 1.261877, -0.068082, 2.367436, 1.708205, 1.591260, 0.429292, -0.217478, 0.033128, -0.418782, 0.646301, 0.562720, 0.553977, 0.606013, 0.739122, -0.211688, 0.181474, -0.414800, -0.261688, -0.759359, -0.267717, 0.106466, -0.288526, -0.181410, -0.050546, -0.280273, 0.288616, 0.009885, 0.220646, -0.150332, -0.268989, -0.002263, -0.184011, -0.516700, 0.025267, 0.047581, -0.288297, -0.817249, -0.107889, -0.013124, -0.019476, -0.143921, -0.207812, -0.260126, -0.527425, -0.458191, -0.827422, 0.822933, 0.316317, -0.397107, -0.174558, -0.044430, -0.952241, -0.452558, -0.061845, 0.243360, -0.118958, 0.120606, -0.044826, 0.272139, -0.915475, -0.832577, 1.133838, -0.417926, 0.520465, -0.177747, -0.328691, -0.017396, -0.144889, 0.157847, 0.596571, -0.031370, 0.485729, 0.185695, -0.507756, -0.088108, -0.353500, 0.773099, 0.837695, 0.128711, 0.238021, 0.224051, -0.555546, -0.980494, -0.856606, -0.054258, 0.483285, 0.157778, 0.592027, 0.922298, 0.830365, -0.210946, 0.216646, 0.214250, -0.067364, -0.239928, 0.240697, 0.582156, -0.183977, -0.022912, 0.199143, 0.542442, -0.071051, -0.572425, -0.399262, -0.909911, -0.676377, 0.777057, 0.560628, -0.182096, -0.466577, -0.511270, -0.938294, -0.216378, -0.331063, -0.045885, -0.342193, 0.342642, 0.023593, 0.233804, -0.899255, -0.677711, 0.885696, -0.256179, 0.463200, -0.196380, -0.472645, -0.288119, -0.363821, -0.531667, -0.476594, 0.355030, 0.532045, 0.775877, 0.393184, 0.252694, 0.439996, 0.107732, 0.665974, 0.297795, -0.714076, 0.757682, 1.127450, 0.162813, 1.406913, 1.115565, 0.499002, 0.211168, -0.112179, 0.883641, -0.507045, -0.094170, -0.096825, -0.614006, 0.378567, -0.971389, 0.675720, 0.589873, 0.023985, 0.065239, 0.023989, -0.128117, -0.438382, 0.206221, -0.310900, 0.292598, 0.177119, -0.104414, -0.091315, -0.217864, 0.626918, 0.217138, 0.093662, 0.512601, 0.008734, -0.155763, -0.057440, -0.169038, 0.035671, 0.116882, 0.714360, 0.170612, -0.232712, -0.035125, -0.177984, 0.170648, 0.372203, 0.236748, 0.181628, 0.072480, 0.411239, 0.011976, 0.241920, -0.037492, -0.160963, -0.166185, -0.445302, -0.313013, 0.009632, -0.340126, -0.720696, -0.129125, 0.205953, 0.255668, 0.110629, 0.052754, 0.333554, 0.017223, -0.309225, -0.019072, 0.128066, -0.113677, -0.076586, -0.365508, -0.284836, -0.170217, -0.771396, 0.274130, 0.308158, 0.233119, -0.128661, 0.074314, -0.176361, 0.494853, 0.096567, -0.092376, 0.383785, 0.103371, -0.040010, -0.160865, 0.826024, 0.573638, 0.093254, 0.378289, 0.092523, -0.373009, -0.269463, -0.000482, -0.163287, -0.035422, 0.182034, 0.518235, -0.151833, 0.240891, -0.336646, 0.075449, 0.473699, -0.063151, 0.186039, 0.540872, 0.145074, 0.445762, -1.092589, -1.526226, -0.550521, 0.527782, 0.038064, 0.017846, 0.051379, 0.056196, -0.110200, 0.185466, 0.428835, 0.130722, 0.116263, -0.160850, 0.111248, 0.726277, 0.883908, 1.019937, 1.671459, 1.140710, 0.901231, 0.986707, 1.442415, 0.471333, 0.836489, 0.513835, 0.000444, 1.269781, 0.426014, -0.108200, 0.368616, -0.020405, 0.310007, 0.472723, 0.385848, 0.268392, 0.251756, -0.291814, -0.260338, 1.019714, -0.314332, 0.529459, 0.747506, -0.304309, -0.203512, -0.023822, 0.177344, -0.044276, -0.479181, 0.124056, -0.540895, 0.007815, 0.216395, -0.196604, 0.457378, 0.602667, 0.729708, -1.854385, -0.366626, -0.222307, 0.203631, 0.381168, 0.741123, 0.313629, 0.600150, -0.017156, 0.137875, 0.115808, -0.258457, 0.794870, 0.558051, -0.473484, 0.953654, 0.453018, -0.084878, 0.171714, 0.092812, -0.013795, 0.147449, -0.194063, -0.266566, -0.195176, -0.239932, -0.598255, -0.288096, -0.013040, 0.405745, 2.012643, 0.613561, -0.002394, 0.216050, 0.143972, 0.416382, 0.420091, 0.341017, 0.319087, 0.295664, -0.436405, 0.060771, 1.429502, -0.189404, 0.329740, 0.776891, -0.058734, -0.135590, 0.102558, 0.356432, -0.421478, -0.624809, 0.117228, -0.623596, 0.445163, 0.762782, -0.345099, 0.359489, 0.611522, -0.914683, 1.356722, -0.191502, -1.377073, -0.204945, -0.376716, -0.278529, 1.725002, 1.484684, 0.738616, -0.378522, 0.316056, 0.844622, -0.105738, -0.920716, -1.535156, -1.334960, -1.064342, 1.233575, -0.938621, -0.308303, -0.239328, -1.581595, -0.027757, -0.013314, -0.133048, 0.267935, 0.993938, -0.755751, 0.791741, -0.482226, -0.282561, -0.548276, -0.805995, 0.113885, -0.378459, -0.423183, 0.589322, -0.664151, 0.349362, -0.277151, 0.849225, 1.020563, 0.412798, -0.906378, -0.142809, 0.632856, 0.399032, 0.645476, 0.115102, -0.925273, 1.058028, -0.070590, -0.719307, 0.607886, 0.537538, 0.327594, -0.514846, 1.438640, -0.780724, 0.797342, -0.494379, 0.179648, -0.857262, -0.078574, 1.006713, 0.149524, -0.870321, -0.700055, 1.430007, 0.108056, -1.632895, -0.727082, 0.329724, 1.016551, -0.011956, 0.132863, 0.000873, 0.723696, 0.485285, -0.657831, 0.395077, 0.213481, 0.116737, -0.585825, -0.811477, 1.185681, -0.172882, -0.907556, -1.383537, -0.348431, -0.360408, -1.140196, -0.154954, 0.355332, 0.661247, -0.310509, 1.100657, -0.833761, 1.312397, -1.001181, 1.897064, 0.751486, 0.251199, 0.220171, 0.009223, 0.246427, -0.563937, 0.523876, 0.812813, -0.401921, 0.305941, -0.500300, -0.270801, 0.590854, 0.539036, -0.040511, 0.708321, 0.137395, -0.630854, -0.475510, -0.051864, -0.214687, 0.391536, 0.738413, 0.808936, 0.580922, 0.265748, 0.804480, 0.237973, 0.615808, 0.244029, -0.698053, 0.799898, 0.642251, 0.082134, 1.087792, 0.892230, 0.087344, 0.135641, 0.152295, 0.690699, -0.570636, -0.349252, 0.260460, -0.670905, 0.090679, -0.135450, 0.592314, 0.882959, 0.164051, 0.180711, -0.242715, -0.269612, -0.078127, 0.569775, 0.079181, -0.215345, -0.275578, 0.441161, -0.066803, -0.174341, -0.083384, -0.173870, -0.250519, 0.249595, -0.133576, -0.113119, -0.073278, -0.594721, -0.338221, -0.103337, 0.009636, -0.204221, -0.201454, 0.490236, 0.243834, 0.298032, 0.458960, 0.326058, -0.668758, 0.752999, 0.164621, -0.279131, -0.270187, -0.929415, -0.663652, -0.299080, -0.302713, 0.604038, 0.293269, -0.126354, 0.248645, 0.275872, -0.040531, 0.464088, 0.080843, 0.179787, 0.008051, -0.070800, 0.243523, 0.063335, 0.400681, -0.253943, 0.109945, 0.467835, 0.126823, 0.010699, -0.382404, 0.072587, 0.637306, 0.511095, -0.240971, -0.079455, 0.227123, 1.025986, 0.403380, 0.054982, -0.235274, 0.521729, -0.053032, -0.015381, 0.058536, -0.148260, -0.025304, 0.535865, 0.090945, 0.036543, 0.132753, -0.624660, -0.177210, -0.075691, 0.031382, -0.065077, -0.291286, 0.577796, 0.145681, 0.034540, -0.028353, 0.247835, -0.042331, -0.770382, -0.076846, 1.257595, 1.034089, 0.580024, 0.327640, 0.001234, -0.335010, -0.725927, -0.516266, -0.678578, -1.939535, 0.519977, -0.195170, -1.354404, 0.193321, -0.446404, -0.393468, -0.108308, 0.369564, 1.274066, 0.421754, 1.183688, 1.461184, 1.109460, 0.700848, 0.252125, 1.090366, 0.553177, -0.168411, -0.331089, -0.845239, -0.682597, -0.666742, -0.403670, 0.004418, 1.418825, 0.668759, -0.378638, -0.508903, 0.628848, 1.072731, -0.159509, 0.241516, -0.051049, 0.250951, -0.512856, 0.238598, -0.138477, -0.404015, -0.340247, -0.116852, 0.245710, 0.336536, 0.522594, 0.117939, -0.079511, 0.038833, 0.054572, 0.272174, -0.086287, 0.036242, 0.052810, -0.328573, 0.006231, -0.285186, -0.408355, -0.068881, -0.273211, -0.443394, 0.698220, 0.781996, -0.246117, -0.680106, -0.146322, 0.299364, 0.055913, 0.265471, 0.310281, -0.039224, 0.285135, -0.260700, 0.348039, 0.826686, -0.283942, -0.750431, 0.003339, 0.096657, 0.101731, -0.471956, -0.297548, -0.504476, -0.473956, -0.115795, -0.522390, 0.073922, 1.170153, 0.275394, -0.228275, 0.025392, 0.580715, 1.598132, -0.295026, 0.380623, -0.049688, -0.378636, -0.119912, 0.331620, -0.240018, -0.116083, -0.170432, -0.276468, 0.224525, 0.523592, 0.680856, -0.135364, -0.013418, 0.016992, -0.323528, 0.889234, 0.180396, -0.063898, -0.769770, -0.525501, 0.066074, -0.443384, 0.007971, 0.760017, 0.234407, 0.357743, -1.554126, 1.393144, -2.451457, 0.570302, 1.022534, -1.882509, -1.277779, -1.466819, -0.979361, -0.759734, -2.508468, -2.142636, -1.217668, -2.973894, -2.020150, -1.278600, -0.615264, -1.751644, -1.887255, -0.551882, -0.688980, 0.066920, -0.390357, -0.507855, 0.291526, -0.661447, -0.295921, -0.488652, -0.706345, 0.310984, -0.540268, -0.924295, -0.044774, -0.451820, -0.288531, 0.002234, -0.293788, -0.834314, -0.214479, -0.727422, -0.184377, -0.203158, -0.188643, -0.045074, 0.016601, -0.815842, -0.602584, -0.409090, -0.141000, -0.125134, -0.307337, -0.089479, 0.642610, 0.665528, 0.668501, 0.134882, -0.192137, -0.103297, -0.054899, -0.498881, -0.166883, -0.021845, 0.059930, 0.103442, 0.090645, 0.083932, -0.424323, -0.063468, -0.001428, -0.041752, -0.583591, 0.488100, 0.395637, 0.030059, -0.090314, -0.063971, 0.403343, -0.417840, -0.226845, -0.601574, -0.410213, -0.061662, -0.510601, -0.270030, 0.809078, -0.450421, -0.195347, -0.529413, -0.459214, 0.710731, -0.433356, -0.581817, 0.094450, -0.404070, -0.194274, -0.146214, -0.063136, -0.738585, -0.326555, -0.424251, -0.391656, -0.378688, -0.259491, 0.023447, -0.058171, -0.298125, -0.454289, -0.483317, -0.212638, 0.187096, 1.508085, 1.042155, 0.129424, -1.152364, 0.018543, -0.322590, -0.527701, 1.169664, 0.158166, -0.348794, 1.113962, -0.254031, -0.023496, -1.125132, -1.385653, -0.013131, 0.568042, 0.203578, 0.230019, -0.532144, -1.283344, 0.331905, 0.079834, 0.583843, 0.915423, -0.259393, 0.258680, 0.155081, -0.402988, -0.007611, -0.199916, -0.103694, 0.056660, -0.404196, 1.022626, 0.072386, -0.612641, 0.046978, -0.227104, 0.198482, 0.216868, -0.074941, -0.860768, 0.192856, -0.010170, 0.256323, 0.260510, -0.184546, 0.477452, 0.313593, 0.078735, 0.191325, 0.172588, -0.073269, 0.136625, -0.539024, 0.560449, 1.037421, 0.228423, 0.107198, 0.185471, 0.407895, -0.192797, -0.074671, -0.153088, -0.244935, -0.212790, -0.164647, -0.086806, 0.008298, 0.004017, -0.137940, -0.189806, 0.421969, -0.092121, 0.211184, -0.196339, -0.170973, 0.171163, 0.333261, 0.235974, 0.362570, -0.376040, -0.245327, 0.155559, -0.546096, -0.045418, 0.439018, 0.272691, -0.267913, -0.459857, -0.397772, -0.248261, -0.703160, 0.197968, -0.367570, -0.445202, 0.035259, -0.133807, -0.210296, 0.047189, -0.122577, -0.299853, 0.117239, -0.639069, 0.181604, 0.117647, -0.301110, 0.146768, 0.204494, -0.213452, -0.101828, -0.609624, -0.389292, 0.043524, -0.604765, 0.301324, 0.451253, 0.345058, -0.654434, 0.113990, 0.325476, -0.409725, 0.325697, 0.556345, 0.281114, -0.292634, -1.056097, -1.175384, -0.817288, -0.432747, 0.442967, -0.535060, 0.173980, 0.574748, 0.429315, 0.275488, 0.932577, 0.529666, 0.830466, 0.366148, 0.881598, 0.920682, -0.139204, -0.450107, -0.520850, 0.868378, -0.160221, -0.106012, -0.242255, -0.687760, -0.153454, -0.173307, -0.018247, -0.324440, -0.202948, -0.302422, -0.335278, -0.249128, 0.435000, -0.098296, -0.362806, 0.396861, -0.164159, 0.191393, -0.134634, -0.274088, -0.038871, 0.212960, 0.696646, 0.034294, 0.141769, -0.596731, 0.520963, -0.322644, -0.701790, -0.072907, -0.603190, -0.564050, 0.260102, -0.032760, -0.653826, -0.480276, -0.302814, 0.091220, 0.286065, -0.131127, 0.369317, 0.495613, -0.430800, -0.338679, 0.210532, 0.088644, 0.375559, 0.225842, 0.227803, 0.102744, -0.198814, -0.608291, -0.174918, 0.194084, -0.342284, 0.126496, 0.337790, -0.062336, -0.245504, 0.452639, -0.341884, 0.188242, -0.363126, -0.696268, -0.030923, -0.048542, 0.262478, -0.383779, -0.342015, -0.211388, -0.280204, -0.309974, 0.400631, -0.119555, -0.575084, 0.251154, -0.303151, -0.024986, -0.443680, -0.363816, -0.363450, 0.129273, 0.409137, -0.041786, -0.156082, -0.483975, 0.258169, -0.561775, -0.508507, 0.039298, -0.467302, -0.451367, -0.063919, 0.653303, -1.228375, -0.593062, -0.704042, 0.078188, 0.113416, -0.261580, -0.245470, 0.971143, 1.141244, 0.198513, 0.959638, 0.963406, 0.300266, 0.646606, 0.804312, 0.702735, 0.100417, 0.921429, 0.663754, 1.023126, 0.627816, 0.472917, 0.310428, -0.361543, 0.230630, -0.247399, 0.346447, -0.248408, -0.023921, -0.583516, -0.405996, 0.243331, -0.142666, -0.644138, -0.637779, -0.499205, -0.307550, 0.238946, 0.112091, -0.276172, 0.077999, -0.166778, -0.230970, 0.024362, 0.937716, -0.578556, 0.493718, 0.045617, -0.026505, -0.421493, -0.719687, 0.429065, 1.116598, -0.110012, 0.141790, 0.032325, 0.691127, 0.344482, 0.314116, 0.019682, 0.256376, -0.300254, -0.177668, -0.120733, 0.171007, -0.135724, 0.534343, 0.549587, -0.447290, -0.215081, 0.231958, 0.413734, -0.284006, -0.252143, -0.378525, -0.224159, -0.375939, -0.497077, -0.017527, 0.274219, 0.142976, -0.206391, 0.360793, 0.264622, 0.159195, 0.869651, 0.049593, -0.015831, 0.030728, -0.354547, -0.073107, 0.688483, -0.184051, -0.275229, -0.622738, -0.393342, -0.091666, 0.258270, -0.281484, -0.734175, 0.047409, -0.529824, -0.380033, 0.170345, 1.501431, -0.249701, 0.609096, 0.030881, -0.291771, -0.721134, -0.251969, 0.108388, 1.391200, -0.044215, -0.625781, 0.173523, 1.115324, 0.371378, 0.393284, -0.808098, 0.785827, 1.154790, 1.160653, 0.731000, 0.969521, 0.277375, 1.170646, -1.067454, 0.053974, -1.191269, -1.140401, 0.279343, 0.002641, -0.624892, -0.331610, 0.016125, -0.394376, 0.126233, 0.373478, -0.013393, 0.108669, -0.722924, 0.435462, 0.041267, -0.251797, -0.169259, -0.321332, -0.463199, -0.088590, 0.123109, 0.065743, 0.350934, -0.180241, -0.125687, -0.351658, -0.359127, 0.043825, 0.234765, -0.429805, -0.029131, 0.319335, -0.042839, 0.179069, -0.014047, 0.484037, 0.295724, 0.188370, -0.168226, -0.115226, -0.704021, 0.077534, -0.542387, -0.245984, -0.483850, -0.541521, -0.170656, -0.256398, 0.131404, 0.081708, 0.074371, -0.162936, -0.175840, -0.077938, -0.032315, 0.102144, 0.060182, -0.262329, -0.242017, -0.153442, -0.027853, 0.142792, -0.138936, 0.211466, 0.110032, -0.109433, -0.021803, -0.207882, -0.184055, 0.224581, 0.266290, -0.141883, 0.184933, -0.337265, 0.021367, 0.005435, -0.061160, -0.122871, -0.017305, -0.333493, -0.475921, -0.121203, 0.471207, -0.073128, -0.225948, -0.209323, -0.044517, -0.252600, 0.030281, -0.415993, 0.135376, -0.363467, 0.031554, -0.285363, 0.037255, 0.190191, -0.266965, 0.030179, -0.369818, -0.458775, -0.581552, 0.121898, -0.326232, -0.301475, -0.437733, -0.475913, -0.315100, -0.347699, -0.153029, 0.402099, -0.951371, 0.629900, 1.207241, 1.104328, 1.006078, 1.044214, 0.099085, 1.197676, -1.218318, -0.123718, -1.374013, -1.123333, 0.428980, -0.104962, -0.402780, -0.091442, -0.198181, -0.649673, 0.505598, 0.183667, -0.161715, -0.264007, -0.509366, 0.442752, 0.409137, -0.061104, -0.168610, -0.622310, -1.007253, 0.033202, 0.267789, 0.650147, -0.240553, 0.019199, 0.275640, -1.018858, -0.324750, 1.184898, -0.292807, -0.443481, -0.452986, 0.656667, 0.277152, 0.482092, -0.002321, 0.438500, 0.605686, -0.456829, 0.008836, 0.162184, -0.634755, 0.459845, -0.113823, 0.056936, 0.690252, -0.008291, 0.002298, 0.049997, -0.633809, 0.288607, 0.205551, -0.055173, -0.464546, -0.170932, 0.665739, -0.251732, 0.288795, 0.499981, 0.084516, -0.638417, -0.465558, 0.540125, -0.324618, 0.188816, -0.036160, -0.482397, -0.098893, -0.367404, 0.208186, 0.340386, -0.080602, -0.326569, -0.757991, -0.613026, -0.279631, 0.609809, -0.027599, 0.284835, 0.123098, -0.213522, -0.326111, 0.188353, -0.635139, -0.224280, 0.348746, -0.873861, -0.417958, 0.658870, -0.450317, -0.151374, 0.071390, 0.271275, -0.027097, 0.159025, -0.176212, -0.192506, 0.017903, -0.640785, -0.088836, -0.051786, -0.478453, 0.211957, 0.300706, 0.321240, 1.077678, -0.281462, -0.225790, -0.113336, -0.426931, -0.270101, 0.004504, 0.519356, 0.695201, 0.614790, 0.596918, 0.609736, -0.285968, 1.211011, -0.174223, 0.011614, 0.017308, -0.499167, 0.490784, 0.464277, 0.352069, 0.776429, 0.321810, 0.579535, -0.126963, 0.068263, -0.200188, -0.375601, -0.648844, -0.064354, -0.189521, -0.283814, -0.023949, 0.181796, 0.362969, 0.052695, 0.258076, -0.042994, -0.303047, 0.150784, 0.038998, 0.197189, -0.492577, 0.737405, 0.254411, -0.512957, -0.685079, 0.230862, 0.185534, 0.042764, 0.461399, -0.175445, -0.127555, -0.156691, -0.085459, 0.323914, -0.157561, -0.152164, 0.322461, 0.165481, 0.102794, 0.504363, 0.404353, 0.147843, 0.325609, 0.057009, -0.427442, -0.258455, -0.024988, 0.284400, 0.606153, -0.175108, -0.387383, 0.769673, 0.145107, -0.110272, -0.084423, 0.058833, -0.193644, 0.023802, 0.000663, -0.156835, 0.396368, 0.278955, -0.159545, 0.266471, 0.027370, -0.091353, 0.074637, 0.078084, -0.304314, -0.337966, -0.110098, -0.113460, 0.181801, 0.317706, 0.711777, -0.056835, -0.335246, 0.300915, 0.260721, 0.464721, -0.356321, 1.153149, 0.131787, -0.421645, -0.871218, -0.151869, 0.028001, -0.334211, 0.300151, -0.044748, 0.152939, 0.211225, -0.173128, 0.075620, -0.213029, -0.364118, 0.140507, -0.129858, -0.101595, 0.615516, 0.039371, 0.038564, 0.259024, -0.478126, 0.791025, 0.040484, -0.077051, 0.305889, 0.814915, 0.641525, 1.318583, 1.238353, 0.596340, -0.140152, 0.057100, 0.390802, -0.052820, 0.231774, 0.644970, 0.504186, 0.091919, 0.233402, 0.045369, -0.074488, -0.409495, -1.067154, -1.049829, -1.007604, -1.268696, -1.223435, -1.211553, -1.519284, -0.954915, -0.217473, -0.182922, -0.190463, -0.172653, -0.017419, -0.313917, 0.073536, -0.136598, 0.147788, 0.116337, 0.018466, 0.151227, -0.205966, 0.165491, -0.062877, -0.141211, -0.425380, 0.317006, 0.396628, 0.028708, 0.148685, 0.061075, -0.163377, -0.303511, -0.213895, -0.364133, 0.033546, -0.365443, -0.238145, 0.032696, 0.185793, -0.039128, -0.446105, -0.018456, 0.066024, -0.112978, 0.248667, 0.392136, 0.103527, 0.186684, 0.505080, 0.072141, 0.033878, -0.138829, -0.010124, 0.190200, -0.181931, -0.757618, -0.800908, 0.037904, 0.517398, 0.212232, -0.264050, 0.080216, 0.154725, -0.261971, 0.359015, 0.015876, 0.097226, -0.355514, 0.083221, 0.124059, -0.017961, -0.095591, 0.230549, -0.150385, 0.157893, 0.182306, -0.107206, 0.365020, 0.167482, 0.206312, -0.038918, 0.081282, 0.007118, 0.247816, -0.444383, 0.419930, 0.248779, 0.298967, 0.175989, -0.048611, 0.027427, -0.437553, -0.138245, -0.252773, -0.134556, -0.215367, -0.199572, 0.270246, 0.181944, 0.141164, 0.204969, 0.711007, -0.670519, -1.042737, -0.614733, -0.237013, -0.503695, -0.339115, 0.309382, 0.272268, 0.103783, 0.509139, 0.183107, 0.271030, 0.251122, -0.220966, 0.124326, 1.031330, 1.093773, 0.578453, 0.946510, 0.951433, 0.858123, 1.196637, 1.507989, 0.901801, 0.710055, 0.291293, 0.099577, 0.736695, 0.227386, -0.241991, 0.143320, -0.211500, -0.102860, -0.124549, 0.218971, -0.494942, 0.479930, 0.337699, -0.191639, 0.211547, -0.572066, -0.021019, -0.574728, 0.257472, -0.171150, 0.238977, -0.181038, 0.230146, -0.334813, 0.120397, -0.201725, 0.600111, 0.488321, 0.525453, 0.037303, 0.252100, -0.044644, -0.022596, -0.010897, 0.230638, 0.558176, 0.032841, 0.072821, -0.391692, 0.034577, 0.357273, -0.427413, -0.007678, 0.203823, -0.156825, -0.345088, -0.333785, -0.094604, -0.554348, -0.319321, 0.800482, 0.186265, -0.427073, -0.143685, 0.178074, 0.268007, 0.208657, 1.027267, -0.121765, -0.298353, 0.317061, 0.448222, 1.116340, 0.503361, -0.390077, 0.104115, 0.044259, -0.215311, -0.046661, 0.520218, -0.554868, 0.733135, 0.500894, -0.306247, 0.137784, -0.607362, -0.053293, -0.519321, 0.523486, -0.227985, 0.171427, 0.133502, 0.624691, -0.400544, 0.299543, -0.369105, 0.230212, 0.378496, 0.334574, 0.062885, -0.137722, -0.107913, -2.813448, 3.943670, -2.559668, -0.299397, 1.537071, -0.992575, 1.711965, 0.648208, -0.046651, 1.724499, -1.444337, 2.196831, -0.162075, 0.423228, 1.023942, -1.194940, 0.950740, -1.665135, -0.750177, -0.938296, -1.428684, 1.516222, -0.680859, 0.950643, -0.135644, 0.057423, -0.283073, 0.488044, 0.009376, -0.299608, 1.306338, 2.766424, 2.803293, 2.218467, 1.476373, 0.703358, 0.585371, 0.311545, 0.171669, 0.723919, 1.524416, 0.797474, 0.891998, 0.716059, 0.027769, -0.592321, -0.263464, 0.934829, 0.476584, -0.082452, -0.045468, 1.027705, 0.028294, 1.031061, 0.590480, -0.010772, 0.196657, 0.531020, 0.698478, -0.046737, 0.839009, 0.256070, -0.105531, 0.381059, 0.056520, 0.293447, -0.101809, -0.842168, -0.590223, -0.213643, -0.039397, 0.097849, 0.438870, -0.927777, 0.533401, -0.177092, -0.082892, 0.096408, -0.451893, 0.248112, 0.089009, 0.215192, -0.747603, 0.267287, -0.105779, 0.590770, -0.636667, 0.051947, -0.910279, -0.244028, 0.614806, 1.884044, 1.463585, 1.240296, 1.377239, 0.910476, 1.540341, 0.487671, 0.835996, 1.035909, 1.148994, 0.965840, 0.296324, 0.073787, -0.600018, -1.128372, -0.744869, 0.193354, 0.233091, -0.414298, 0.310502, -0.380338, 0.127606, 0.362782, -0.277605, -0.011807, -0.624980, -0.143580, 0.717091, -0.917202, 0.483398, -0.583417, -0.183732, -0.462565, 0.541285, 0.507607, -0.281810, -0.421618, 0.898936, 0.823244, -0.194407, 0.941735, 0.825186, 0.198065, 0.717554, 1.055586, 0.837213, -0.107493, -0.207542, -0.104508, 0.486105, 0.433501, 0.050209, 0.061547, -0.550392, -0.299036, -0.476397, -0.032130, -0.278228, -0.134113, -0.621196, -0.481901, -0.436930, 0.023498, -0.111862, -0.261740, -0.417651, -0.036874, -0.479118, -0.042852, -0.179839, 0.067035, -0.203789, -0.481339, -0.483458, -0.527289, -0.750845, -0.074512, -0.078644, -0.356230, 0.139385, 0.088102, 0.066937, -0.872373, 0.298092, -0.164719, -0.356962, -0.154483, -0.541446, 0.026842, 0.102576, 0.455220, 0.142925, -0.203349, -1.052367, -0.490306, 0.181294, -0.130287, 0.071132, 0.311619, 0.161937, -0.336169, -0.498753, -0.650263, 0.114338, 0.503170, 0.457891, 0.960983, 0.420686, 0.246134, -0.028697, -0.148436, -0.338951, 0.016261, 0.342104, 0.095427, -0.381153, -0.711748, 0.328896, -0.131539, -0.605154, -0.395118, -0.209733, -0.206555, 0.198698, 0.127135, -0.281154, -0.107106, -0.255714, 0.217437, -0.230586, 0.053734, -0.380245, -0.312123, -0.700895, -0.460169, -0.460860, 0.297400, -0.091138, -0.802309, 0.399001, -0.011341, -0.107537, -0.908633, 0.243906, -0.489665, -0.234730, 0.135772, -0.252349, 0.894841, 0.274596, -0.246704, -0.844689, -0.462980, 0.042063, -0.575749, 0.154511, 0.464456, 0.194563, 0.877787, -1.736502, 1.495308, -2.144454, 0.879106, 0.834678, -2.328005, -1.081251, -1.791077, -1.522550, -0.477724, -2.593315, -2.514392, -1.613918, -2.642719, -1.766915, -1.171631, -0.972720, -1.443681, -0.929887, -0.597165, -0.823672, -0.291009, -0.094971, -0.350666, -0.280267, -0.957899, 0.033992, -0.837150, -0.099006, -0.471123, 0.247152, -0.952225, -0.024349, 0.448611, -0.441052, 0.086955, -0.753865, 0.033806, -0.424626, -0.075351, -0.927296, 0.659980, 0.740036, -0.976498, -0.978652, -0.659396, -0.750550, -1.157737, -0.108119, 0.192176, 0.126494, 0.187264, 0.641416, 0.113064, -0.089831, 0.713197, -0.442878, -0.025181, -0.824899, -0.521188, -0.162578, -0.144143, -0.538591, 0.110278, 0.688456, 0.634629, 0.136034, -0.097498, -0.419353, -0.688372, -0.065266, -0.830430, -0.239329, 0.299601, 0.130322, -0.132759, 0.289303, 0.074030, -1.005917, -0.750473, -0.405339, -0.174372, 0.065557, -0.343297, -0.374020, -0.597594, 0.332874, -0.471028, 0.329322, -0.339375, -0.289467, -0.703545, -0.025820, -0.363155, -0.363265, 0.356737, -0.622399, 0.010532, -0.191802, -0.478291, -1.335594, 0.027971, 0.870270, -0.679425, -0.923893, -0.119763, 0.188405, -0.643212, 0.863854, 0.085722, 1.178874, 1.235195, 0.222082, -0.624226, 0.096466, -0.037090, -0.546519, 0.440057, 0.189569, -0.238849, 1.013999, -0.029634, -0.142986, -0.981802, -1.089268, 0.065977, 0.406793, 0.114189, 0.192282, -0.592841, -0.955795, 0.229075, 0.498104, 0.446501, 0.572842, -0.255989, -0.182945, 0.863727, -0.635626, -0.087885, 0.153423, 0.150418, 0.119518, -0.033164, 0.990521, -0.004542, -0.058345, 0.179874, -0.043171, -0.104849, -0.287065, 0.061827, -0.593977, 0.199537, 0.543638, -0.629602, -0.546381, -0.268426, -0.312230, 0.559503, 0.455041, 0.239940, 0.510065, -0.095526, -0.079871, 0.383877, 0.263790, 0.443745, 1.047385, 0.164634, -0.068230, 0.300058, 0.485901, -0.291592, -0.669548, -0.349360, -0.244881, 0.098229, -0.384490, -0.152484, 0.242747, 0.327800, 0.236518, 0.146907, -0.072076, -0.339930, -0.142578, -0.274238, 0.162728, 0.241703, 0.215884, -0.379200, -0.257783, 0.276910, -0.303006, 0.028600, 0.144414, -0.204004, -0.591944, -0.177606, -0.129727, -0.128781, -0.011202, 0.168024, 0.101570, -0.019143, 0.591917, 0.174975, -0.280285, 0.130111, -0.430225, 0.402463, -0.743712, -0.087082, 0.311554, -0.459558, -0.458239, -0.539661, 0.055248, 0.533695, 0.068784, 0.457088, 1.145263, 0.073205, -0.078281, -0.014853, 0.327230, 0.241498, 0.993422, 0.522891, 0.457305, 0.690821, 0.722424, -0.048185, -0.261868, 0.075667, -0.300562, -0.513454, 0.341385, -0.140243, 1.513869, -0.238709, 0.401303, -0.896627, -0.301837, -0.553461, 0.085760, -0.143049, -0.299122, -0.069729, -0.778315, -0.519298, -0.418936, 0.245542, 0.258015, -0.576900, -0.299581, 0.113480, -0.143600, 0.111546, 0.109883, 1.940946, 0.920190, -0.030370, 0.686627, 0.526465, -0.132068, -0.305018, -0.274627, 0.480804, 0.602200, 0.196027, 0.109546, 0.438187, 1.142616, 0.823927, 1.347621, 1.305940, 0.059181, 0.549754, -0.016182, 0.038962, 0.369428, -0.913073, -0.582421, -0.197847, -0.152846, 0.355943, 0.396930, 0.206410, 0.116438, 0.063330, -0.226953, 0.067876, 0.405531, -0.639697, -0.774789, 0.154709, 0.774396, -0.162459, 0.304167, 0.273340, -0.532860, 0.040569, -0.398625, -0.407862, -0.365174, -0.268324, 0.361405, -0.284904, -0.411035, 0.876795, -0.327883, 0.061819, 0.388641, -0.350843, -0.059896, -0.738463, 0.349043, 0.018360, -0.372983, 1.763700, 0.480879, 0.240860, 0.960654, 0.401674, -0.478595, -0.445196, -0.303438, -0.155393, -0.073862, -0.363913, 0.093946, 0.287150, 0.149435, 0.635382, 0.598078, 0.471168, -0.311728, -0.133522, -0.716358, 0.457538, -0.002315, -0.760165, -0.298274, -0.383962, 0.041261, 0.047870, 0.004601, -0.337764, 0.633241, 0.676422, 0.289680, 0.323266, 0.631570, 0.552975, 0.137367, 0.799729, 0.379307, -0.275837, 0.007607, -0.302752, 0.428586, 0.302088, 0.216080, 0.114771, -0.049166, 0.053739, -0.612733, -0.588596, -0.501517, -0.380398, -1.241952, -0.284687, -0.596334, -1.005501, 0.100965, -0.188321, 0.266049, -0.003451, -0.168846, 0.666907, 0.610412, -0.095112, -0.532012, 0.677612, 0.217548, 1.063946, 0.422846, -0.366166, 0.592046, -0.375450, 0.615503, -0.249789, 0.175902, 0.296354, 0.188598, 0.196238, 0.117140, 0.475114, 0.346263, 0.849414, 0.510490, 0.587579, 0.578950, 0.972361, 0.045002, 0.213862, 0.477234, 0.098673, 0.417556, -0.031104, -0.347300, -0.404133, -0.177896, 0.676926, 0.765109, -0.303150, -0.311800, -0.603217, -0.330862, -0.119614, 0.720446, -0.112732, -0.420296, -0.379094, 0.201505, -0.427217, -0.072073, 0.710809, 0.085464, 0.357962, 0.395666, -0.319305, -0.469536, -0.214018, 0.126081, 0.612247, -0.322742, 0.063056, 0.035807, 0.243202, 0.185465, -0.051534, -0.232892, 0.816410, -0.080749, 1.258517, 0.323659, 0.087466, 0.450166, -0.255271, -0.146022, 0.014724, 0.425527, 0.056820, 0.134261, -0.486224, 0.011897, 0.281988, 0.302689, 0.213523, 0.434909, 0.537067, 0.309237, 1.150446, -0.245889, 0.363956, 0.468361, 0.130367, 1.208970, 0.974101, 0.174660, -0.797281, 0.077298, -0.014521, -0.387816, 0.811099, 0.133232, -0.201453, 1.014046, -0.416220, -0.072163, -1.137848, -1.078045, -0.072618, 0.121361, 0.059040, 0.910835, 0.147638, -1.030919, 0.031444, -0.170463, 0.394782, 0.718166, -0.096946, 0.193482, 0.431935, -0.006455, -0.078430, -0.039090, -0.417630, -0.018439, 0.032646, 0.914191, -0.019592, -0.082831, 0.356691, -0.090483, 0.111433, 0.417036, -0.026422, -0.194368, -0.116150, -0.006952, 0.100646, -0.010542, -0.319004, 0.488068, 0.146506, -0.218518, -0.191092, 0.265060, -0.094410, 0.027329, 0.662201, 0.211292, 1.272701, 0.694911, -0.072655, -0.281956, -0.460548, 0.330054, 0.415390, 0.806186, 0.528657, -0.383885, -0.356037, -0.463735, -0.459355, 0.094939, 0.698586, 0.305967, -0.029738, 0.321637, 0.100544, -0.388999, -0.038416, -0.090382, -0.191402, 0.059580, -0.340340, 0.139148, -0.277902, 0.713407, 0.606876, -0.279293, -0.158488, 0.205178, -0.196666, -0.307195, -0.381482, -0.326395, 0.131260, 0.323121, -0.054558, -0.124463, -0.165480, 0.037733, -0.061479, -0.190043, 0.228233, -0.035835, -0.245196, -0.128330, -0.266088, -0.204956, -0.270023, 0.247169, -0.148765, -0.412742, -0.639899, 0.169515, -0.383671, -0.311812, 0.521992, -0.308511, 0.878955, 0.586406, -0.145690, -0.408292, -0.596614, -0.615193, 0.570510, 0.193736, -0.139688, 0.048744, -0.946301, 0.909720, 0.878881, -0.753924, -0.431146, -0.847054, -1.143315, -1.215625, -1.067559, -0.352803, -1.428075, -0.070433, -0.507784, 0.090411, -0.581609, 0.843795, 0.217785, 0.316816, 0.609590, 0.359656, -0.024371, -0.098411, -0.025458, -0.183572, 0.075004, 0.004677, 0.446741, 0.546780, 0.210360, -0.272394, -0.156544, 0.004102, -0.067579, -0.355313, -0.214031, -0.401629, -0.005501, -0.263180, 0.123529, -0.464802, 0.045133, 0.566656, -0.436495, -0.307641, 0.037135, 0.309822, -0.269839, 0.473164, -0.200087, 0.223262, -0.322587, 0.140634, -0.181150, -0.281690, -0.082673, -0.276837, 0.671432, 0.667317, 0.365822, 0.370266, 0.219548, 0.331192, 0.162103, 0.041051, -0.222728, 0.149506, 0.163683, -0.599830, -0.218427, 0.018266, 0.093594, 0.308946, 0.245321, 0.411827, -0.092665, -0.026565, 0.221870, 0.736637, 0.067800, 0.182507, 0.219153, -0.191969, 0.286870, 0.206351, -0.003481, 0.232116, 0.218527, 0.689291, -0.352398, -0.263162, -0.274743, 0.064664, -0.179685, -0.055156, 0.000801, -0.168737, 0.215379, -0.353654, 0.473405, -0.229763, 0.225760, 0.753232, -0.250097, -0.131460, -0.097736, 0.362755, -0.430589, 0.424598, -0.064018, 0.007306, -0.169093, 0.184821, 0.303312, -1.291171, -0.939046, -1.156085, -1.868935, -1.467640, -0.235711, 2.274909, 1.788531, 2.219767, -0.924050, -0.978548, -0.454737, -0.275913, 0.509020, 0.788955, -2.613837, 0.182452, -1.342051, -3.349422, -1.518285, -0.621505, 0.820391, 0.495703, 2.255569, 0.843307, 1.368330, 0.504502, -0.348144, -0.285373, 1.261593, 8.559605, 0.512146, 3.096065, -0.690688, 0.690260, -0.212982, -1.342806, 0.053488, -0.461898, -0.721679, 0.759517, -0.618053, 1.188754, 2.819515, -1.030556, -0.113111, -1.578923, 0.334617, 2.695625, 0.238467, 1.091914, 2.868098, 0.938112, 1.561310, 0.425850, 0.648380, -0.698519, 0.352038, -2.193791, 0.247806, -2.314366, 1.066710, 0.466540, 0.185235, 1.124780, -0.128097, -0.481417, 0.593626, -0.171510, 0.121161, 0.965428, 0.352717, -0.186335, 1.817742, 1.774042, -0.393337, 0.785727, -0.093555, -0.638467, 0.496260, -0.782060, -0.233775, 1.025521, 0.036646, 0.701059, -0.175325, -1.153830, -2.950357, 1.111774, 1.817924, 7.141747, 1.579527, 3.044568, -0.647380, 0.402022, 0.502123, -1.034767, -0.608912, -0.372118, -1.163337, 0.634237, -0.030166, 1.845542, 1.627799, 0.195767, 0.636708, -1.089716, -0.544888, 0.583901, -0.043968, 0.677361, 1.005368, 1.731795, 1.863349, 1.114627, 1.742327, -0.229882, 0.331858, -0.703775, -0.202833, -1.120576, -0.254377, 0.046750, -0.053817, 0.194175, 0.112003, 0.126296, -0.428610, 0.900588, 0.614167, -0.027866, -0.133889, -1.041070, -1.272011, -1.063141, -0.658480, -0.223357, -0.143142, 0.090542, -0.424095, -0.620544, -0.469453, 0.435673, -0.153883, 0.616505, 0.431419, 0.675462, 0.323548, 0.086049, 0.785230, 3.043458, 0.400267, 0.638739, 0.947258, 0.932025, 0.218509, -0.165403, 0.092682, -0.104815, 0.446472, 0.016600, -0.209673, -0.301517, -0.691583, 0.397256, -0.507397, -0.290080, -0.119207, -0.150644, -0.127558, -0.026399, 0.298043, 0.329245, -0.379852, 0.302250, -0.226647, -0.164652, 0.638938, -0.098641, 0.554548, -0.022359, -0.343072, -0.083216, 0.222820, 0.435283, -0.037227, -0.366107, -0.239346, -0.088336, 0.146410, 0.285607, 0.101426, 0.032321, -0.496330, 0.071357, -0.208978, 0.048806, -0.496948, 0.455504, 0.616716, 0.131776, 0.355739, -0.099247, 0.368837, 0.118714, 0.124388, -0.098362, 0.505747, -0.371210, 0.899132, 1.994297, 0.188721, 0.878989, 0.360396, 0.720768, -0.136076, -0.138397, 0.335065, -0.111528, 0.482593, -0.070843, -0.157920, -0.390915, -0.535763, -0.393895, -0.534045, -0.121213, 0.114042, 0.012307, 0.241642, 0.333352, 0.112564, -0.071013, 0.033613, 0.218480, 0.044849, -0.076632, 0.135450, -0.256735, 0.184156, -0.923123, 0.898599, 0.454143, 0.361004, 0.758300, 0.961144, -0.648021, -0.289880, -0.819486, 0.396531, 0.237448, 0.269753, 0.257770, 0.845992, 0.032620, -0.389290, 0.484881, -0.126014, 0.172714, 0.039130, -0.170695, 0.025269, -0.868289, -0.071103, -0.319167, -0.067484, 0.556047, 0.003964, 0.385802, -0.141931, -0.068224, -0.020102, 0.060981, 0.574967, 0.290712, 0.246996, 0.278278, 0.350692, -0.507246, -0.279788, 0.440798, -0.023445, -0.224873, -0.356269, -0.781217, -0.982522, -0.328924, -0.061303, -0.263896, 0.447453, -0.117538, -0.187813, 0.117122, 0.748637, 0.029959, -0.516609, -0.019319, -0.162213, -0.219943, 0.349922, 0.247737, 0.084955, -0.417646, -0.405568, -0.219458, -0.025645, 0.116824, -0.125078, 0.148210, 0.560486, 0.211661, -0.231090, -0.205724, -0.108885, 0.340808, -0.017961, -0.211574, 0.778802, 0.349988, 0.022644, 0.226504, -0.249816, -0.441373, -0.572688, 0.165339, 0.658564, 0.396019, 0.121776, -0.121992, -0.326691, -0.682297, -0.148815, -0.070571, 0.520518, 0.120078, 0.030515, -0.162877, -0.010045, -0.401267, -0.559413, 0.505572, -0.082734, -0.277824, -0.328829, -0.913256, -0.794443, -0.467647, -0.317599, -0.639694, 0.294690, -0.092489, -0.128701, 0.092921, 0.334965, 0.376685, -0.487131, -0.295564, -0.136521, -0.310166, 1.058540, 0.354410, -1.654468, -0.731647, -0.994240, -0.026104, -0.160412, -0.070276, -0.679614, 0.309066, 0.263723, -0.235377, 0.278299, 0.993462, 1.023851, 0.711355, 0.749150, 0.635035, 0.374967, 1.149349, 0.430970, 1.002998, 0.235637, 0.278316, 0.623082, 0.520914, 0.644517, -0.141510, 0.724997, -0.127697, 0.283465, -0.258778, -0.140865, -0.040636, -0.146612, 0.041575, -0.219543, -0.001463, -0.076622, -0.158193, -0.334413, 0.110337, 0.231710, 0.254149, 0.727979, -0.620806, 0.037234, 0.309176, 0.138243, 0.020237, -0.422376, -0.534328, 0.022111, -0.005518, -0.394445, 0.891540, 0.607910, 0.129593, 0.315220, 0.024290, 0.224307, 0.035511, -0.050921, 0.074172, 0.167851, 0.394884, 0.576889, -0.079276, -0.354608, 0.149755, 0.026058, -0.112843, -0.381412, 0.203659, -0.018300, 0.044388, 0.054711, 0.283050, -0.672219, 0.129814, 0.109706, 0.460485, -0.112652, -0.002369, 0.122923, -0.527573, 0.198124, -0.145016, -0.162056, 0.378343, 0.328600, -0.236763, -0.000739, 0.136380, -0.114962, 0.413291, -0.278831, -0.086301, -0.182048, -0.300167, -0.418386, -0.018397, 0.101438, 0.363721, 0.631081, -0.318635, 0.255262, 0.038402, 0.385321, -0.404441, -0.530137, -0.200682, 0.041231, -0.059379, -0.478062, 0.838881, 0.805649, -0.151578, 0.265963, 0.005481, 0.043491, 0.538897, 0.789244, 1.034522, -1.191822, -1.509543, -0.930376, 0.105580, -0.278910, -0.072934, 0.144182, 0.568183, -0.032887, 0.787307, 0.951387, -0.342960, 0.605172, -0.688310, -0.031699, 1.211911, 0.664533, 0.792421, 1.864848, 1.130090, 0.487025, 1.355664, 1.212580, 0.472482, 0.948749, -0.006169, 0.114444, 1.495510, -0.003336, -0.267081, -0.015566, 0.016124, -0.018889, 0.052366, 0.523212, -0.239354, 0.692999, 0.347216, -0.212750, -0.290130, 0.311681, 0.330812, 0.184957, -0.205068, -0.145876, 0.209884, 0.407857, 0.197927, 0.611388, 0.392582, 0.776089, -0.024095, -0.218811, -0.258849, 0.382998, 0.421756, 0.366680, -1.064506, 0.363576, 0.426579, -0.192314, -0.641262, -0.265892, 0.575490, 0.530247, -0.218489, -0.759814, 0.052022, 0.008649, 0.030578, 0.082775, -0.130748, 0.719721, 0.477191, 0.437570, 0.109672, 0.018207, -0.142283, -0.411562, -0.616640, -0.082716, 0.090873, 0.343423, -0.030358, -0.303111, 0.755732, 0.530334, 2.261908, 0.311756, -0.188782, -0.030752, 0.489903, -0.245879, -0.078862, 1.057894, -0.191863, 1.068605, 0.330204, -0.344810, -0.393977, 0.555329, 0.102412, 0.014600, -0.351506, -0.317772, 0.248045, -0.038134, 0.334328, 1.091098, 0.521606, 0.928730, 0.052525, -0.160733, -0.248123, 0.510061, 0.289975, -0.428886, 0.061288, -0.539579, -0.212850, 0.280170, 0.050576, -0.279189, -0.168178, -0.518749, 0.687233, 0.739483, -0.100812, -0.044516, -0.841101, -1.052803, -1.222179, -0.150149, -0.020054, -0.022334, 0.486726, 0.281811, -0.269788, -0.240081, 0.619574, -0.199318, 1.127698, 1.039828, 0.242737, 0.750291, -0.400563, 0.248532, -0.437601, -0.492920, -0.435861, 0.524399, 0.332507, -0.184556, -0.699985, 0.071101, -0.416527, 0.428206, -0.436586, -0.143687, 0.455739, 0.731656, 0.285768, -0.775897, -0.024627, -0.364846, -0.098394, -0.218662, -0.637695, -0.535526, -0.202593, -0.022367, -0.225616, -0.015817, 1.111287, 0.437024, -0.211256, -0.660254, 0.206331, -0.298000, -0.152611, 0.139051, -0.215218, 0.394377, 0.563399, 0.204498, -0.356240, -0.072508, -0.397300, 0.346402, 0.429179, -0.115540, 0.230003, 0.136814, -0.127189, 0.003045, -0.328881, -0.334087, 0.323251, 0.309140, -0.134438, -0.100439, -0.111310, -0.424459, 0.584899, 1.026592, -0.335813, 0.706857, -0.140352, -0.453587, 0.262112, 0.029123, 0.222135, -0.367555, -0.659609, 0.071883, -0.107620, 0.846780, 0.143577, 0.223279, 0.501333, 0.600909, 0.340309, -0.654646, 0.351743, -0.360091, 0.507130, 0.731160, -0.407662, -0.129945, -0.229792, -0.009893, -0.286282, -0.405407, 1.396079, 0.511761, -0.203950, -0.486027, -0.051598, -0.246630, 0.277526, 0.903453, 0.730274, 0.425900, 0.081345, 0.428778, 0.203145, 0.433892, 0.346229, -0.526469, 0.601536, 0.708180, 0.017015, 1.142918, 1.186413, 0.371286, 0.028537, 0.082725, 0.358909, -0.350864, -0.012212, 0.312618, -0.365853, 0.214484, -0.346881, 0.348195, 1.143669, 0.060186, 0.006271, -0.590781, -0.308818, -0.258349, -0.205468, 0.084629, 0.415151, -0.455388, 0.367722, 0.089652, -0.536991, 0.413793, -0.506774, -0.531679, -0.231918, -0.324297, -0.112811, -0.182059, 0.254154, -0.091798, -0.111238, -0.158492, 0.387988, 0.512654, 0.422124, -0.217444, -0.142694, 0.021588, 0.683010, -0.600862, 0.096732, -0.114133, 0.080473, 0.188386, 0.616974, -0.053229, -0.647042, -0.024811, 0.116464, 0.405109, 0.492512, 0.164415, -0.053958, 0.065447, -0.235466, -0.371008, 0.272720, -0.323653, -0.081098, -0.249609, -0.218469, 0.168438, 0.772410, 0.339332, 0.610037, 0.311968, -0.130313, -0.187278, -0.673904, 0.426225, 0.350338, -0.410299, 0.128232, -0.421439, -0.156981, -0.100540, 1.285311, -0.055709, 0.559628, -0.424761, -0.243215, 0.808724, 0.113246, -0.428816, 0.312497, -0.166666, -0.164754, 0.112425, 0.365004, 0.040607, -0.125164, -0.179546, 0.589255, 0.128815, 0.310945, -0.089326, -0.190203, -0.256029, 0.140915, 0.602452, 0.587896, -1.450528, -0.384229, -0.819017, 0.065138, 0.097622, -0.041666, -0.591032, 0.392298, 0.606495, -0.073374, 0.606492, 0.932124, 0.548790, 0.739444, 0.803931, 0.172490, -0.102564, 0.697002, 0.143529, 0.363894, -0.007366, 0.073298, 0.427738, -0.046027, 0.504634, -0.195396, 0.082058, 0.099139, 0.805130, 0.462969, 1.323617, -0.028835, -0.108384, -0.378956, -0.649145, 0.310910, 0.487450, -0.303578, 0.695195, -0.646859, 0.158124, -0.490651, 0.198676, 0.074638, -0.386635, -0.156472, 0.341083, -0.440829, 0.435486, 0.382093, 0.033993, -0.145016, -0.017703, -0.387864, -0.130175, -0.094730, -0.368419, 0.616100, 0.327144, 0.947055, 0.428025, -0.876286, -0.609103, -0.373372, 0.095106, -0.723910, -0.728608, -0.361405, -0.920679, 0.110917, -0.050540, 0.471441, 0.841102, 0.352752, -0.014248, -0.221854, -0.124975, 0.043823, -0.219554, -0.207655, -0.311367, -0.169085, -0.323486, -0.250047, -0.457101, 0.282717, -0.163693, -0.320274, 0.815022, 0.002636, 1.078964, -0.182284, -0.124936, -0.103995, -0.739415, 0.363673, 0.437214, -0.108325, 0.587380, -0.874786, 0.548335, -0.465480, 0.878969, 0.100326, -0.179433, 0.036229, 0.556374, -0.156971, 0.280946, 0.263821, 0.118753, -0.025432, -0.271313, -0.410196, 0.151964, -0.167562, -0.485007, 0.464341, -0.004944, -0.917914, -0.504998, 0.458907, 0.423015, 0.094521, -0.050762, 0.048885, 0.019616, -0.755756, -0.029049, 0.334553, -0.918157, 0.955069, 1.552331, 0.006459, 1.033933, 1.291446, 0.683737, 0.193427, 0.562198, 0.585990, 0.061971, 0.297597, -0.012688, -0.375104, -0.017587, -0.393710, 1.023909, 0.274506, -0.125752, -0.100989, -0.202577, 0.044628, -0.701577, -0.336098, -0.018824, 0.615302, -0.452295, 0.109203, -0.680835, 0.102277, 1.101149, -0.081084, -0.305534, 0.745149, -0.167294, -0.993221, -0.615441, -0.500516, -0.049552, 0.883745, 0.057267, 0.799847, 0.735631, 0.036702, 0.695454, 0.274888, 0.197625, -0.117554, 0.063920, -0.376009, 0.142580, 1.072912, 0.125974, 0.028255, -0.027888, 0.115662, 0.255964, -0.199073, -0.760244, -0.602019, 0.444193, -0.464983, -0.713835, 0.181033, 0.293402, -0.074144, -0.348567, -0.123916, -0.796908, 0.207762, -0.122786, 0.301372, 0.047126, -0.424592, -0.781424, 0.173118, 0.002250, 0.858133, -0.359864, -0.118545, -0.168474, 0.307473, -0.237839, -0.585981, -0.034338, 0.124186, -0.214068, 0.444798, -0.378607, 0.855001, 0.950577, 0.112403, -0.109040, 0.647578, -0.212091, -0.659365, -0.587838, -0.708729, 0.051988, 0.818750, 0.053994, 0.156323, 0.671959, -0.240061, 0.757796, 0.274593, 0.820043, -0.406269, 0.035981, -1.029726, 0.755508, 0.384944, 0.401998, 0.915032, 1.042339, -1.008707, -0.401270, -0.686945, 0.681291, 0.403594, 0.717565, -0.002244, 0.966652, 0.308526, 0.055786, 0.734047, 0.398461, -0.062777, -0.139173, -0.456789, 0.018730, -0.934174, 0.190256, -0.459672, -0.101293, 0.718223, 0.192705, 0.968575, -0.217252, -0.221267, -0.058501, -0.077984, -0.622506, -0.074527, 0.681167, 0.908754, 0.506400, -0.362808, -0.186611, 0.182988, -0.167016, 0.097307, -0.387862, -0.318267, 0.017942, 0.890726, 0.092801, -0.719698, 0.268708, -0.125195, -0.133301, -0.276957, -0.004229, -0.340378, -0.240519, 0.788751, -0.233260, -0.838112, -0.070458, -0.139745, 0.151872, 0.178361, -0.056788, 0.266967, 0.104930, -0.218843, -0.030249, -0.033404, 0.471157, 0.280262, 0.256713, 0.039130, 0.271430, -0.131758, -0.558315, -0.629170, -0.346061, -0.177880, -0.113037, -0.722957, -0.276389, 0.256469, -0.379391, 0.513858, 0.236419, -0.043824, -0.065426, -0.453585, -0.354951, -0.500114, -0.183190, -0.258900, -0.561869, -0.279127, 0.302932, 0.791770, 0.182986, -0.308947, -0.225003, -0.295674, -0.147286, 0.105273, -0.298040, 0.242053, -0.138994, 0.729964, 0.189009, -0.804485, -0.064764, -0.305578, -0.125258, 0.070890, -0.276903, -0.364036, 0.005934, 0.393770, -0.424321, -0.620195, 0.022273, -0.622594, 0.724667, 0.392448, 0.673519, 0.615016, 0.563207, -0.020662, 0.107301, -1.260276, 0.305873, 0.109681, -0.159085, 0.514280, 0.444509, 0.345549, 0.054577, 0.475572, 0.380467, 0.028646, 0.384444, -0.259441, 0.097872, -0.822926, -0.187922, -0.606926, -0.527796, -0.201905, -0.207188, -0.119422, -0.265525, -0.182295, -0.267143, -0.380250, -0.089160, -0.019347, 0.119312, -0.504713, -0.623885, -0.089688, 0.091747, 0.571694, -0.068125, 0.449553, 0.342513, -0.166799, 0.395160, 0.174759, -0.170298, 1.122533, 1.325138, 0.082242, 0.523738, 0.161282, 0.248654, 0.172527, -0.461301, -0.207026, -0.527892, -0.364744, 0.106194, 0.276465, 0.373154, 0.146765, 0.749006, -0.293966, -0.950997, -0.072652, -0.119054, 0.359742, 0.008605, -0.366490, -0.159353, -0.435225, 0.401608, 0.543820, 0.344898, -0.224394, -0.171512, 0.281119, -0.361413, -0.094856, -0.864081, -0.221408, -0.345027, 0.211111, 0.064792, -0.040491, -0.421270, 0.016234, -0.535485, -0.635600, -0.222134, -0.112149, 0.006986, -0.541628, 0.077585, -0.842347, -0.768525, -0.361487, 0.035937, 0.622496, -0.101972, 0.235057, 0.163265, -0.101466, -0.249543, 0.191149, -0.473617, 0.477059, 0.557462, 0.445066, 0.220277, -0.306979, -0.027502, -0.259989, -0.204669, -0.495586, -0.277561, -0.571974, -0.560761, 0.899628, -0.046316, -0.340416, 0.988728, -1.234180, -1.537444, -0.195613, 0.094434, 0.132365, 0.762577, -0.929769, 0.726566, -0.241288, -1.274140, 0.520833, -1.539555, -1.312553, -0.946243, -0.578635, -0.758373, 0.816436, -0.217479, 1.016157, -0.057869, -0.867335, -0.167959, 0.230811, -1.198514, -0.131626, -0.223989, -0.450519, 0.195166, 0.472030, -0.690301, -0.626272, -0.371526, -0.664930, -0.287673, -0.585511, -0.124262, -0.236842, 0.128691, 0.341843, 0.251173, 0.259603, -0.347478, -0.862909, 0.833453, -0.366093, -0.399884, 0.091293, -0.679147, 0.849990, -1.302336, 0.049407, -0.846151, -1.048273, -0.539198, 0.186058, -0.100718, -0.374643, 0.205480, 0.169146, 0.056580, 0.168391, 0.662869, -0.025739, 0.005060, -0.087193, -0.127306, 0.414752, 0.179525, -0.146995, -0.078683, -0.520398, -0.616530, 0.477678, -0.621298, -0.176567, -0.274408, 0.262682, 0.525406, -0.479029, 0.594721, 0.120527, 0.138739, -0.491580, 0.194306, -0.259756, -0.284230, -0.636536, 0.578185, 0.112111, -0.682817, -0.490159, -0.195100, -0.400942, -0.385588, -0.152118, -0.326312, -0.230084, 0.207998, 0.501701, 0.339999, 0.320194, 0.200722, -0.591439, 0.698547, -0.585884, -0.300991, 0.251234, -0.439487, 0.337311, -0.939135, -0.138169, -0.602311, -0.671200, -0.448869, -0.029739, -0.920483, 0.628645, -0.569923, -0.394285, -0.541567, 0.180450, 0.309227, -0.581581, -0.074277, 1.144690, 0.777336, -0.333140, 0.834929, 1.165166, -0.025400, 0.670138, 0.908833, 1.002422, -0.222928, 0.313756, 0.407358, 0.581271, 0.665025, 0.268417, 0.318474, -0.275304, -0.233925, -0.236490, -0.148713, 0.076575, -0.339712, -0.662405, -0.456963, 0.314126, 0.660675, 0.587493, 0.376499, -0.298177, -0.047286, -0.169428, -0.482489, -0.134841, -0.659826, 0.212487, -0.087808, 0.402166, -0.371127, 0.601523, 0.163496, -0.324214, 0.463319, 0.228231, -0.090697, 0.100035, 0.338510, 0.500819, -0.122791, 0.216194, 0.165412, 0.391608, 0.074610, 0.029665, 0.208905, 0.794897, 0.730243, 0.598498, -0.404842, -0.641820, -0.588010, 0.153435, 0.291309, -0.509898, 0.048084, 0.021129, 0.638951, 0.563254, 0.695177, -0.294843, -0.879051, 0.320113, 0.169727, -0.325197, 0.167110, 0.754938, 0.445367, 0.151160, -0.318112, -0.117452, -0.181711, -0.620124, -0.350055, -0.540016, -0.357616, 0.006436, 0.510934, 0.409992, 0.148347, -0.130816, -0.276403, -0.094510, -0.091554, -0.259634, -0.560896, 0.021475, 0.278370, 0.421962, -0.107582, 0.815672, -0.252234, -0.538082, 0.202945, 0.193788, -0.274285, -0.283561, 0.386018, 0.360591, -0.048716, 0.586677, -0.109793, 0.361095, 1.270716, 1.457051, 0.196465, -2.202005, -1.263714, -0.748083, -0.994620, -0.047593, 1.663897, 2.090802, 0.958419, 0.622066, -2.082268, 0.561168, -1.887571, -0.579625, -0.758291, 1.763659, 0.616449, -0.514604, -0.890151, -0.124474, -1.780059, -3.196295, -0.869906, 0.078282, 1.239345, 2.688199, -0.708092, -0.770319, 0.798608, 1.003301, 1.783525, 3.261552, -0.188332, 3.419354, 4.105080, 1.862185, -1.391245, 1.788416, 1.022189, 1.385476, 0.104963, 1.073798, 0.168298, -0.095426, 0.456969, 1.693307, 2.342800, 1.702116, 0.582797, 4.111530, -0.591776, 1.014205, 3.032569, -0.639872, 3.035203, 1.558142, 0.169712, 1.352398, -0.968578, -2.027415, -0.162292, 0.956143, 1.459710, 0.466027, 1.626278, 0.709397, 0.587811, -0.034204, 1.424139, 0.391056, 0.908309, 0.384656, -0.572722, -3.420266, 0.177654, -0.598681, 1.415486, -1.011909, -1.437445, 2.794826, -0.316138, 0.454446, -0.379894, 1.398157, 0.121436, -1.114118, 0.561956, -0.051912, 1.721580, 0.686929, 0.974256, 3.999385, -0.414856, 3.233068, 5.155573, 3.561827, -1.060807, 2.033391, 0.945256, 0.200148, 0.564902, 1.537202, 0.114112, 0.150123, -0.521853, 1.649781, 4.105305, 0.830316, 0.870033, 1.874184, 0.365591, 1.881765, 4.308774, 1.378795, 4.159629, -0.350615, 0.848021, 0.596229, -0.130679, 1.144650, -0.475618, -0.739966, 0.004511, 0.315409, 0.566586, 1.103568, 0.416816, -0.653872, -1.772505, -1.162791, 0.322880, 0.087209, 0.226241, 0.303113, -0.025934, -1.305591, -0.119036, 0.605199, 1.195581, 0.128233, -1.026197, -1.182069, -1.686766, -1.243893, -1.088867, -0.198701, -1.583316, -1.265480, 0.362730, -0.152222, -0.274236, 0.265681, 0.125390, -0.009193, -0.077068, -0.144798, -0.149788, -0.275329, -0.836048, -1.032741, -0.850505, -0.876927, -0.371588, -0.698714, 0.066595, -0.241300, 0.550919, 1.403452, 0.575760, 0.884994, 0.158091, -0.285381, 0.402475, -0.693702, -0.294934, -0.656720, -0.443709, -0.622166, -0.373656, 0.694041, 1.095534, -0.133788, -0.153604, 0.127998, 0.014263, -0.445912, 0.381809, 0.195560, 0.026276, 0.277521, 0.142134, -0.392609, 0.150277, 0.509511, 0.340202, -0.203815, 0.051681, 0.271066, -0.434913, -1.190880, -0.045891, -0.528641, 0.190135, -0.314270, 0.390813, 0.410219, -0.371967, -0.851491, 0.586075, 0.119213, 0.069234, 0.553413, -0.137077, -0.119492, -0.040634, 0.188884, 0.101384, -0.590696, -0.220343, -0.897548, -0.578980, -0.595877, -0.061022, 0.083172, 0.018241, -0.267650, -0.104124, 1.117867, 0.782419, 0.622052, -0.173228, -0.425660, 0.266983, -0.044515, -0.259034, -0.503895, -0.324086, -0.977805, 0.332654, 0.741214, 1.503439, 0.898397, -0.154444, 0.031928, -0.295341, 0.694574, 0.479874, -0.232379, -0.320302, 1.769500, -0.398288, 0.187136, -1.201322, -1.166301, -0.649267, -0.794007, 0.011949, -0.150160, -0.268188, -0.556264, -0.690599, -0.584857, 0.801153, 0.149997, -0.928999, -0.235839, -0.424641, -0.167853, -0.148420, 0.806371, 0.559888, 0.434746, -0.443706, 0.519737, 0.072204, -0.527309, 0.009784, 0.194137, 0.036565, 0.296446, 0.289643, -0.200225, 0.307029, 0.502847, 0.970926, 1.444332, 1.224169, 1.440186, 1.727656, 0.663310, 0.027377, -0.416602, -0.065880, 0.151173, -0.206018, -0.354714, 0.930273, -0.026222, -0.147929, 0.048171, 0.275748, 0.357112, -0.010749, -0.166088, 0.254404, 0.449370, 0.088925, -0.285461, -0.177326, -0.074716, -0.733801, 0.220582, 0.359051, 0.231692, -0.014506, -0.066104, -0.444032, 0.132880, 0.169090, -0.632706, 0.259726, -0.009405, -0.309558, -0.382588, 0.173016, 0.159348, -0.316768, -0.320191, -0.367707, -0.030307, -0.076047, 0.211124, -0.540390, 0.115558, -0.419081, -0.553037, -0.042711, 0.251191, 0.029106, -0.238689, 0.141789, -0.076225, -0.121171, 0.044219, 0.344981, 0.985367, 0.576057, 0.899526, 0.900998, 0.114418, -0.185528, -0.447701, 0.066551, 0.374159, -0.084079, 0.013670, 0.880843, -0.158292, -0.202503, -0.287703, -0.452603, -0.405957, 0.573065, 0.293742, -0.354885, -0.042316, -0.779473, 0.756882, 0.234073, -0.815526, -0.280527, -0.554173, -0.877058, -1.024767, -1.014001, -0.775908, -1.046829, 0.120522, -0.456858, 0.082355, -0.798965, 0.363790, 0.543592, 0.535959, 0.206451, 0.315798, -0.147294, -0.558213, 0.019252, 0.061481, -0.410072, 0.217943, 0.150334, 0.913815, 0.480354, 0.008314, 0.799077, -0.015639, 0.388245, -0.562267, -0.841049, 0.038144, -0.255600, 0.251173, 0.180566, 0.113648, 0.734608, 0.011449, 0.218601, 0.392239, -0.682155, 0.307339, -0.291129, 0.098590, 1.203720, 0.749663, 0.196985, -0.088895, 0.171678, -0.007983, 0.062313, 0.047272, -0.335146, 0.152705, -0.058771, -0.270154, -0.144939, 0.529373, 0.480996, 0.142878, -0.176988, -0.812152, -0.172809, 0.125170, 0.119294, -0.215965, -0.332549, -0.653955, 0.289136, 0.391354, -0.051125, -0.301784, 0.165443, 0.016430, -0.392226, 0.442723, -0.178510, -0.381647, 0.378588, 0.471411, -0.163142, 0.444039, -0.164148, 0.817751, 0.086593, -0.296503, 0.832344, 0.222779, 0.626988, -0.369589, -0.459036, 0.480637, -0.476759, 0.132735, 0.408612, 0.439239, 0.922486, 0.480196, 0.730663, 0.736671, -0.022613, 0.225179, -0.110907, -0.325893, 0.761967, 0.541917, 0.268923, 0.084931, -0.084295, 0.474347, -1.361508, -0.557823, 0.654711, 0.185485, -1.000446, -0.787286, -0.201959, 0.469319, -0.821985, -0.909262, 0.841591, -1.176802, -0.329750, 0.792685, -0.361526, -1.262855, 1.399689, -0.263786, -0.692540, -0.261626, -0.047545, -0.131860, -0.777493, 0.979983, 0.148197, -0.393603, -0.953257, -0.762978, 1.866489, 0.697815, 6.646833, 1.375888, 1.076887, 0.039186, 0.153052, 1.715571, 0.784934, 1.665605, 0.517238, 0.907222, -0.605714, 1.674984, 0.756725, 0.653310, 1.616744, 1.006949, 1.839949, -1.230058, 0.905960, 0.473005, -0.029465, -0.324096, 0.405698, 0.768759, 0.477190, -0.122317, -0.308693, 0.149329, -1.971213, 0.607700, 2.933486, 0.326333, 0.215621, 0.443683, 0.416389, 0.940590, 0.825626, -0.811396, -0.053798, 0.419675, -0.927612, -0.215092, -0.112809, 0.382057, 0.118693, -0.425031, -0.709557, -0.083381, 0.792341, -0.494870, -1.089439, 0.408551, -0.396302, 0.703621, 0.349547, 0.219867, 0.291553, -0.321060, 2.172207, 0.887535, 5.743416, 1.981631, 1.565526, 0.945675, 0.920042, 1.701101, 1.352903, 1.448091, 1.060958, -0.025851, 0.350791, 1.308282, 0.539033, 0.332465, 1.558862, 0.763296, 2.162046, -0.842645, 1.179936, 0.552280, 0.037292, 0.011089, -0.422468, 0.222032, 0.265476, -0.184543, -0.308750, -0.576373, -0.662433, 1.137493, -0.103168, -0.668259, 0.290833, 0.284103, 0.094347, 0.766642, 0.661499, -0.275359, -0.342424, -0.246494, 0.542917, -0.552091, -0.659918, -0.176376, -0.228720, -0.534168, -0.215978, -0.611352, -0.669605, -0.527193, -0.635004, 0.054062, -0.552847, -0.305852, -0.363347, -0.078797, -0.405087, -0.267640, -0.424595, -0.735381, -0.803758, -0.287095, -0.606442, 0.006706, -0.423462, -0.921670, -0.494317, 0.289908, -0.067427, 0.530363, -0.439068, -1.495157, -0.395819, -0.305305, 0.248951, -0.214071, 0.321883, 0.473882, 0.177262, -0.087777, -0.320459, -0.508266, 0.151132, 0.329725, -0.805351, 0.320786, -0.215790, 0.186951, -0.065114, -0.413805, -0.329560, 0.077551, -0.022128, -0.011150, 0.146120, 0.721749, 0.160481, -0.255207, 0.219550, 0.752584, 0.896620, 0.308666, -0.442816, -0.181613, -0.531060, -0.436715, -0.745009, -0.444692, 0.354856, 0.191671, 0.578975, 0.179675, -0.450065, 0.520456, -0.270941, -0.094990, 0.551806, -0.283641, -0.449748, -0.651225, -0.720389, -0.109640, -0.616999, 0.226867, -0.420550, -0.881575, -0.694591, -0.108079, 0.280407, 0.882728, -0.318526, -0.856539, -0.344609, -0.476880, -0.042572, -0.598393, 0.075701, 0.576290, -0.020415, -0.051879, -0.354124, -0.501302, -0.296335, 0.617388, -0.732450, 0.522778, 0.089655, -0.062885, 0.233385, 0.255084, 0.453068, 0.691063, -0.959531, -1.525492, -0.672979, 0.240161, -0.181119, -0.537170, 0.150045, 0.447617, 0.379311, 0.544282, 0.584228, 0.424441, -0.235095, -0.179767, 0.761906, 1.184885, 1.692600, 0.941034, 1.509737, 1.080047, 1.026371, 1.331697, 1.281574, 0.587191, 0.765840, 0.322583, -0.001299, 1.028421, 0.122286, -0.088706, 0.344888, -0.048632, -0.063973, 0.144566, 1.195637, 0.207940, -0.416582, 0.688279, 0.154920, 0.028802, 0.040091, 0.079849, 0.290999, 0.185824, -0.128836, -0.292802, 0.071419, -0.131761, -0.054047, -0.460359, 0.549275, 0.689874, 0.626031, 0.050139, 0.361271, 0.697210, 0.046833, 0.156529, 0.410690, -0.209990, -0.381309, -0.177059, -0.252349, 0.065276, -0.180183, -0.413999, -0.535678, 0.312509, -0.169402, -0.333067, 0.409822, 0.354606, -0.008431, -0.428241, 0.167036, 0.205130, -0.092481, -0.008129, 0.427575, 0.152051, 0.077707, 0.404901, 0.558820, 0.444475, -0.168847, 0.118439, 0.315502, 1.717790, 0.613428, -0.318517, 0.060245, 0.053427, 0.304661, 0.108856, 1.713615, 0.030318, -0.596840, 0.481162, -0.181399, 0.519460, 0.347724, 0.041943, 0.728474, 0.474834, -0.101685, -0.007348, 0.014531, 0.091961, -0.167528, -0.245855, 0.183655, 0.282894, 0.950557, 0.655064, 0.485291, 0.680337, 0.911702, 0.385236, -1.043799, -0.145576, -0.205296, 0.870385, -0.232239, -0.311911, 0.676331, -0.240550, 0.753022, -1.202510, 1.075944, 0.135942, 0.700112, 0.115039, -0.185075, -0.292392, -0.674416, -0.387788, 0.119794, -1.080809, -1.047272, -1.415976, 0.094146, -0.641506, -0.585167, -0.132718, -0.230326, -0.915319, 4.782970, 0.490361, 1.315503, 2.526916, 2.320829, 1.125605, 1.131620, 0.311777, 1.647058, 1.067400, 0.148737, 1.131991, -0.334447, -1.429416, 0.507809, -0.902623, 0.035461, -0.199064, -0.468655, -0.418713, 0.911986, 1.952426, 1.231082, -0.183142, 0.597320, 0.551515, 0.242955, -0.287511, 1.034458, -0.470009, -5.609471, 0.764280, 1.312756, 0.816623, 0.846786, 0.850688, 2.090948, 1.562847, 2.394324, 0.248947, -0.026813, 0.212354, 1.753080, 0.278154, -0.866530, -0.098904, -0.398991, 0.431301, 0.498894, -0.543563, -1.460545, -0.541438, -0.099263, 1.179423, -0.579226, -0.159539, 0.230109, -0.759477, 0.495536, -1.689006, 4.925703, 0.540824, 0.736636, 2.498700, 0.929738, 0.730030, 1.533052, 1.079671, 0.926567, -1.040840, 0.662817, 1.858929, 0.736080, -1.358549, -0.032914, -0.342992, 0.559938, -0.302361, 0.078635, -1.072314, 0.051578, 3.111331, 1.542682, -0.275081, 0.979230, 0.249283, 0.536865, -1.157903, -0.729875, 0.359260, 0.328087, -0.940921, 0.611378, 0.830775, 0.768773, 0.472640, 0.307120, -0.013764, 0.922055, -1.146239, 0.223334, -0.026441, -0.178576, 0.658506, 0.675542, 0.099875, 0.350851, 0.466543, 0.461621, 0.791349, 0.389554, -0.095542, -0.375734, -1.154726, -0.074133, -0.683970, -0.685187, -0.531959, -0.388039, -0.277701, -0.168964, 0.205865, -0.352254, -0.276908, 0.096366, -0.021387, -0.196889, 0.062873, -0.043218, 0.038508, 0.226876, -0.173981, 0.171196, -1.065735, -0.088718, -0.521926, -0.124643, 0.481290, -0.282670, -0.047025, 0.588093, 0.195974, 1.134658, 0.079490, 0.466663, 0.407849, 0.456765, -0.033616, -0.144410, 0.054257, -0.038202, 0.224814, -0.158890, 0.142355, -0.089961, -0.157335, 0.329524, 0.186037, 0.178210, -0.409512, -0.538899, 0.376122, 0.400647, 0.108361, 0.140224, -0.094651, -0.124505, 0.743375, 0.370334, -0.131650, 0.284584, 0.378025, 0.148466, -0.003454, 0.013814, -0.260665, -0.919971, -0.063055, 0.349108, -0.246134, -0.310875, -0.271794, -0.472205, 0.161770, 0.010850, -0.310986, -0.422206, 0.039077, -0.562314, -0.143109, 0.045620, -0.072545, 0.036973, -0.696137, -0.307084, -0.331789, -0.334427, 0.488537, -0.241531, -0.437865, 0.037152, -0.426994, 0.316118, 0.509362, -0.013570, 0.255265, 0.433032, 0.185403, 0.146206, -0.104723, -0.453035, 0.857160, 0.060106, -0.693378, 0.547838, -1.023378, -1.370548, -0.441286, -0.295507, 0.091477, 0.443647, -0.670482, 0.391215, -0.118105, -1.012643, 0.676340, -1.131266, -0.856574, -0.944983, 0.262679, -0.507385, 0.583309, -0.200902, 0.324037, -0.395797, -0.352210, -0.094431, 0.625815, -0.898225, -0.072733, -0.349936, -0.608193, -0.411048, 0.093965, -0.298481, -0.269042, -0.442738, -0.013088, -0.610677, -0.032703, 0.370660, 0.720451, -0.423055, -0.067103, -0.123578, 0.093725, -0.487964, 0.285291, 0.102388, -0.542058, -0.160786, -0.785854, -0.476800, -0.056324, -0.983002, 0.245228, 0.366642, -0.067813, -0.447796, 0.475980, -0.099385, -0.063371, -0.268618, -0.211045, 0.848085, -0.235085, -0.658623, -0.295700, 0.130215, 0.496234, 0.146558, 0.195375, 0.014594, 0.207672, -0.066273, -0.094839, 0.127345, 0.230373, 0.302591, 0.221670, 0.396506, -0.426316, -0.368746, 0.176170, 0.210946, 0.490235, 0.333814, 0.188003, -0.054842, -0.790941, -0.365009, -0.627005, -0.217086, 0.518609, 0.036720, -0.176986, -0.393725, -0.364685, -0.353443, 0.045500, -0.037196, 0.510893, -0.154942, 0.078526, -0.369009, 0.201059, -0.539861, 0.376075, 0.078821, -0.559066, 0.284452, -0.698875, -0.735140, 0.218018, -0.798424, 0.160492, 0.410862, 0.024808, -0.613002, 0.426664, 0.263386, -1.045991, 0.665738, 0.395193, 0.303997, 0.640956, 1.041269, -0.833491, -0.634219, -1.150067, -0.013972, 0.242083, 0.583753, 0.246081, 0.990352, 0.357449, -0.100088, 0.385760, -0.054311, -0.345161, -0.238458, -0.297706, 0.211920, -0.820162, 0.123897, -0.320478, -0.053905, 0.588945, 0.205610, 0.608817, -0.278772, -0.246779, -0.027226, 0.156716, -0.051597, -0.146445, 0.372411, 0.566710, -0.250749, -0.125867, -0.023083, -0.161143, -0.109997, 0.291102, -0.020238, 0.027000, -0.176358, 0.024038, -0.329811, 0.392188, 0.001467, -0.284045, 0.190986, -0.077198, 0.575636, -0.135514, 0.608242, -0.279551, -0.271371, -0.012147, 0.055379, -0.025047, -0.320734, -0.257647, -0.118640, 0.199463, 0.405431, 0.125745, 0.081054, -0.538561, -0.308794, 0.445242, 0.058012, -0.151180, 0.084086, 0.164087, 0.264745, 0.174823, -0.172578, -0.035231, 0.164699, -0.068209, 0.168844, 0.038554, 0.502977, 0.147559, -0.305420, -0.058148, -0.089099, -0.242276, -0.515560, -0.637396, -0.266929, 0.186319, -0.294202, -0.102656, 0.098348, 0.168926, -0.452986, -0.170456, -0.289079, -0.211883, -0.211000, 0.075931, 0.219551, 0.014135, -0.280614, -0.016910, -0.125031, -0.195542, -0.013127, -0.416025, 0.078587, -0.022745, 0.198322, 0.116382, 0.407011, -0.442557, -0.264689, 0.316398, 1.417765, 2.199469, -0.123363, -2.369997, -2.502666, 0.536488, -0.971097, 1.307839, 2.347513, 2.389284, -1.823545, 3.864693, -2.665267, 1.120596, -0.979104, -1.312239, -0.826201, -1.306878, 1.176867, -0.306406, -0.153576, -1.369043, 0.016339, -2.039188, 0.978433, -1.186604, -1.486628, 0.452200, -0.515449, 1.954916, 0.566691, 1.579759, 4.356233, 3.060998, 2.722338, 0.503655, 0.955158, 1.847550, 6.413731, 5.033020, 2.723917, 1.457132, 2.521505, 2.444487, 0.035210, -0.854816, 2.742990, 2.492530, -0.223033, 0.541888, 0.569457, 3.096430, 2.770888, 4.140659, 1.424551, -1.064123, 2.995568, 1.578968, 0.439226, -0.721054, 0.602961, 0.508372, 0.006211, -2.521645, -3.057321, -1.334333, -1.144252, -1.005835, 1.735101, 3.498006, -0.925810, -1.005561, -3.138366, -0.271377, -0.955417, 0.218746, -0.487057, 0.648975, 0.251508, -0.836510, 0.953089, 1.936209, 0.720324, -1.699783, 2.260576, -0.264235, 1.680585, 1.754071, 0.314197, -1.810089, 0.358090, 0.774861, 1.570408, 1.445263, 2.361754, 0.598036, 1.833860, 3.034789, 1.868780, 1.957919, 0.771788, 2.200564, -0.591151, 1.373453, -1.073696, 0.270672, 3.136533, 1.388874, 0.037968, -0.514842, 0.507929, 2.485067, 2.068264, 3.163396, 3.034250, -0.045752, 3.027893, 1.746469, 0.849832, 1.242942, 0.194656, 0.963421, 1.240260, 0.357398, -0.172534, -0.218808, -0.176567, -0.219426, 0.232341, 0.180891, -0.104318, 1.291340, 0.121762, -0.002237, -1.140059, -0.964597, -0.342416, 0.101976, 0.266607, 0.312962, -0.678768, -0.892149, -0.067968, -0.134658, 0.324844, 0.551218, -0.588609, -0.276039, 0.517767, -0.271610, -0.084596, 0.000854, 0.145297, 0.265514, -0.128671, 0.367474, 0.341611, -0.182253, -0.346198, -0.057926, -0.069096, 0.446564, 0.157726, -0.110146, 0.305173, -0.012092, 0.418122, -0.146859, 0.727037, 0.446180, 0.757243, 0.329123, 0.065225, -0.604551, -0.282991, -0.552741, 0.177457, 0.084107, -0.124013, 0.399583, -0.093459, -0.116269, -0.405980, -0.397543, 0.165277, 0.170791, 0.076521, 0.101963, 0.040833, -0.145141, 0.149213, 0.191224, 0.081890, -0.123786, -0.012352, -0.089640, 0.172792, 0.187566, 0.564010, -0.365915, -0.373405, -0.286491, -0.434724, 0.393119, 0.286649, -0.201890, -0.139140, 0.178402, 0.089504, 0.223083, -0.255125, -0.314490, -0.224158, -0.058699, -0.308985, 0.114493, -0.052928, -0.005444, -0.570901, -0.035693, 0.036746, 0.174475, -0.011633, 0.148735, 0.052207, -0.296481, 0.053783, -0.254473, 0.586321, 0.387451, 0.367425, 0.220510, -0.103373, -0.515861, -0.316515, -0.466344, -0.149785, 0.084793, -0.351030, 0.456256, -0.423488, -0.337931, -0.624220, 0.140531, 0.604956, 0.636541, 0.599663, 0.683948, 0.539206, 0.396332, 1.046325, 0.513475, -0.681068, 0.861410, 0.868005, 0.101064, 1.211979, 0.950977, -0.318739, 0.254049, 0.042028, 0.941933, -0.358084, -0.134140, 0.406763, -0.494108, 0.308714, -0.386327, 0.791014, 0.482787, 0.157579, 0.233278, -0.003856, -0.126052, 0.352957, -0.234307, 0.213670, -0.335451, -0.114387, 0.515326, 0.039544, 0.179119, 0.037194, -0.107463, -0.032234, 0.723159, -0.315689, 0.054448, -0.087626, -0.473625, -0.140047, -0.115226, 0.509050, -0.001019, 0.104356, -0.261085, 0.438778, 0.198210, 0.603996, 0.566591, 0.855146, -1.462506, -0.103352, 0.406379, 0.081900, 0.505847, 0.115188, 0.122052, 0.435371, -0.684971, -0.677303, 0.411930, 0.346763, -0.325457, -0.656603, -1.086662, 0.762186, 0.209424, -0.918635, -0.045185, 0.104699, 0.553291, -0.615987, 0.154471, -0.010784, -0.748793, 0.410617, -0.191436, 0.103633, 0.155221, 0.536970, 0.641201, 0.080081, 0.328965, 0.121457, 0.129070, 0.330628, 0.007126, -0.017670, 0.838781, -0.070457, 0.032761, 0.100482, 0.513155, 0.347480, 1.267664, 0.172541, -0.108436, 0.302952, -0.460937, 0.017126, 0.122506, 0.396023, -0.031799, 0.166939, 0.229797, 0.461927, 0.037042, 0.673400, 0.403285, 0.261167, -0.908406, 0.577387, 0.825407, 0.813016, 0.519827, 0.609001, 0.144877, 1.018014, -0.914644, -0.022767, -0.169636, -0.464937, 0.457522, 0.600087, 0.018954, 0.398724, 0.402681, 0.389040, 0.176048, 0.413884, -0.184750, -0.462435, -1.144897, 0.078556, -0.480783, -0.464993, -0.327623, -0.302424, -0.269263, -0.174165, 0.339870, -0.194684, -0.187533, -0.513604, -0.501425, -0.531157, -0.480520, 0.242834, 0.578940, 0.210309, -0.070246, -0.101217, -0.108971, -0.398703, -0.197058, -0.085756, 0.080824, -0.280951, 0.295710, 0.106198, 0.208174, -0.247769, -0.262707, 0.888346, -0.385841, -0.169371, -0.105239, 0.311281, -0.163908, 0.214924, -0.548845, -0.090702, 0.162163, 0.169102, -0.114816, -0.260305, -0.115400, 0.126948, 0.143472, 0.606051, 0.154973, -0.494287, -0.444174, -0.140296, -0.589551, -0.097499, 0.267681, 0.517595, 0.240536, -0.245430, 0.352249, 0.134638, -0.161978, 0.173552, 0.193237, 0.011158, 0.281917, 0.204704, 0.102761, -0.293743, -0.150424, -0.256769, -0.375987, -0.520895, -0.250173, -0.386978, -0.352277, 0.096552, 0.260377, 0.445423, 0.006342, 0.083629, -0.150182, -0.822530, -0.176580, -0.302883, -0.213988, -0.109982, -0.209300, -0.386982, 0.134067, -0.600068, -0.404696, 0.510662, -0.443190, -0.223213, -0.129108, -0.086765, 0.120265, -0.274062, -0.366912, -0.526271, 0.013971, 0.183776, -0.088528, 0.235629, -0.321464, -0.744126, 0.575463, 0.417714, -0.233867, 0.188054, -0.098266, -0.560740, -0.751087, 0.017992, -0.136783, 0.158079, 0.536293, -0.067939, -0.076276, 0.529757, 0.862498, 0.305828, 0.738958, 0.686399, 0.754557, 0.882680, 0.210982, 0.254297, 0.453830, 0.392564, -0.449887, 0.939205, 1.021980, 0.087458, 0.523675, -0.166661, 0.418150, 1.125206, 0.890751, 0.722038, 1.206768, 0.860165, 1.073799, 0.966998, 0.594137, -0.364282, 0.371814, -1.272470, 0.083947, 1.009308, 0.854785, 0.487477, 0.322564, -0.827936, -0.303530, 0.234720, 0.974648, 0.988177, -0.521709, -0.302701, -0.230970, -0.601578, -0.289912, 0.041497, -0.939043, -0.061153, -0.614820, -1.051801, -0.455019, 0.800568, 1.195314, 0.204925, 0.242333, 0.254196, -0.165542, -0.216395, 0.533290, 1.103356, 0.320354, -0.372785, -0.259039, 0.030760, 0.858119, -0.519847, 0.072394, -0.446884, -0.472239, 0.743779, 1.093882, 0.707284, -0.054277, 1.127585, 0.141136, -0.261068, 0.224493, -0.693338, -0.037271, 1.444699, 0.598009, 0.712043, 1.027706, 0.615701, 0.618059, 0.850856, 0.754772, 0.212584, 0.495994, -0.849290, -0.433039, -0.010028, 0.286654, 1.049705, -0.311586, -0.639367, -0.545013, 0.328652, 0.316566, -0.867007, 1.122803, 0.014599, -0.464969, -0.450385, 0.183978, 0.442503, -0.156564, 0.191456, 1.261212, 0.389656, -0.340089, 0.302185, 0.538391, -0.447283, 0.464200, 0.423440, 0.270346, -0.427844, -0.155258, -0.636438, -0.267037, 0.128640, 0.092098, -0.115324, -0.369287, -0.263513, -0.142934, -0.271658, -0.233137, -0.302395, -0.745031, -0.370613, -0.534860, -0.822612, -0.293775, -0.823574, -0.153070, -0.095845, -0.495339, 0.033115, 0.141480, -0.445901, -0.008963, 0.102908, -0.332177, -0.051852, -0.188308, 0.289817, -0.565530, 0.136264, 0.834891, -0.310488, 0.787388, -0.191302, -0.377235, -0.451765, 0.604678, 0.048281, 0.368266, -0.213880, 0.133396, 0.143409, -0.399930, 0.161268, 0.696711, -0.033899, -0.708665, -0.063272, 0.288817, 0.199851, 0.315935, -0.332121, -0.071492, 0.351213, -0.320805, 0.209675, -0.315720, -0.183188, 0.154239, 0.149242, 0.166772, -0.150250, -0.025802, 0.410834, -0.214847, 0.082910, -0.430314, -0.220815, 0.093712, -0.314078, -0.667519, -0.105702, -0.471603, -0.799635, -0.019683, -0.935886, -0.078987, -0.116594, -0.196389, -0.159693, 0.183446, -0.402119, 0.279899, 0.176799, -0.394576, -0.502166, -0.142942, 0.046076, -0.544616, 0.222287, 0.612977, 0.091317, 0.565259, -0.010585, -0.442922, -0.640553, -0.094509, -0.131423, 0.500119, -0.334933, -0.144429, -0.163242, -0.117201, 0.356530, 0.246632, 0.357240, -0.152503, -0.426653, 0.801784, 0.446289, -0.211746, -0.050330, -0.603659, -0.975909, -0.768246, -0.261447, -0.033749, -0.348455, 0.457499, -0.464068, 0.076067, -0.549820, 0.617392, 0.595480, 0.596342, 0.172584, 0.184359, 0.128092, -0.282481, 0.039234, 0.141091, -0.263051, -0.117551, -0.022518, 0.827243, -0.034699, -1.106112, -0.713949, -0.720718, -0.531398, 0.403198, 0.646579, -0.477356, -0.335000, 1.058445, 0.044957, 0.272914, 0.451814, -0.485991, -0.454617, 0.585703, 0.611702, 0.317752, 0.234127, -0.466755, -0.382770, 0.770765, 0.895645, -0.194316, -0.025474, 0.045793, -0.270707, 0.153083, 0.196687, -0.289815, 0.009860, 0.104769, 0.254891, -0.338181, 0.190797, 0.765935, -0.986261, -0.638204, -0.453312, 0.040887, -0.241927, 0.087447, 0.033043, -0.146674, 0.062231, -0.399065, 1.203400, 0.109302, -0.036046, -0.361725, -0.134300, 0.391596, 0.560261, -0.462786, 0.350281, 0.347116, 0.328406, -0.115985, -0.376881, 0.986174, -0.319928, -0.917273, -0.359874, -0.350620, 0.115412, 0.106760, 0.145533, 0.046414, -0.349015, 0.963524, 0.191510, 0.904986, 0.010017, -0.059427, -0.170371, 0.737993, 0.448597, -0.173465, 0.070550, -0.776207, 0.574423, 0.372580, 0.936127, -0.105667, 0.007269, -0.974062, -0.386235, 0.991927, 0.878340, 0.423922, 0.034219, 0.167684, -0.703065, -0.848717, -0.446190, -0.495212, -1.744357, 0.588527, 0.454250, -0.975960, 0.502886, 0.268911, -0.216817, -0.546970, -0.027695, 1.118730, 0.796358, 0.892205, 0.798610, 0.640124, 0.693652, 0.292295, 1.370041, 1.514175, -0.108245, -0.453217, -0.418982, -0.070178, 0.349374, -0.122561, -0.137313, 0.197441, -1.073276, -0.116012, -0.804522, -0.906902, 0.530054, -0.313020, 0.311021, 0.332706, -0.406659, -0.351259, 0.380660, 0.121871, -0.060329, 0.128769, -0.320860, -0.004461, -0.070819, -0.515628, 0.580456, 0.267929, -0.212978, 0.682038, 0.282977, -0.719209, -1.435898, 0.854326, 0.875434, -0.007792, -0.487158, -0.285830, 0.489652, 0.573850, -0.501052, -0.669178, 0.297527, 0.911304, 0.307435, -0.126224, -0.672530, 0.071603, -0.961809, 0.182186, -0.253781, 0.474764, 0.528546, -1.031929, 0.101390, 0.444526, -0.328401, -0.107599, -0.701346, -0.537912, -0.237612, -0.450412, -0.134737, -0.153772, 0.379874, 0.014321, 0.010722, -0.532336, -0.355465, 0.155759, -1.367848, -1.163476, 0.168309, 0.225038, 0.557438, 0.015898, -0.447039, -0.158695, 0.616369, 0.022015, 0.407939, 0.781165, 0.047833, -0.172253, 0.069859, 0.000383, 0.176034, 0.014544, -0.198291, 0.883385, 4.286694, -0.508382, -1.952830, -1.614682, -1.917387, -0.819065, -1.111525, -1.903213, -1.876348, -0.395497, -0.770514, -1.838615, 0.088723, -0.447406, 0.093361, -0.216186, -0.258147, -0.825190, 0.058708, 0.648632, -0.308292, -0.033345, -0.405659, -0.569962, -0.228794, 0.436596, -0.401790, -0.231322, -0.740819, -0.966630, 8.972971, 4.472180, 2.819494, 3.119841, 2.783034, 1.448490, 0.418501, 0.015756, 1.182211, -0.959525, -1.125373, -0.472082, -0.269512, -0.103977, -0.723233, -0.663068, -0.612157, -0.721313, -1.375029, -1.436096, -1.661325, -1.051797, -1.324883, -1.998883, -1.857897, -1.285870, -0.179249, -1.155648, -1.218519, -1.044649, -6.072367, 1.348654, 0.609819, 2.466798, 2.417631, 1.040106, 0.179092, 1.063138, 1.143693, 0.382446, 1.087094, 0.365735, 0.236970, 0.189586, 0.252741, 0.850464, -0.107722, -0.051931, 0.378259, 0.138304, 0.269076, 0.403641, 0.464174, -0.472716, 0.229576, -0.288809, -0.829569, -0.304537, 0.257328, -0.338478, 9.313084, 3.220296, 2.831462, 2.623580, 2.287649, 0.911337, 0.689830, -0.487300, 0.567707, -0.261115, -0.740947, 0.368349, 0.531320, 0.480286, -0.360990, -0.423437, 0.039493, -0.140338, -0.676463, -0.614451, -1.055642, -0.563090, -0.866134, -0.827736, -1.352747, -0.696468, 0.662069, -0.579303, -0.713184, -0.480113, 1.106432, 1.320717, -0.795504, -0.609743, 0.334579, -1.977273, -0.861991, 3.354959, 3.496949, -0.132063, -1.575963, 1.612837, -1.213403, -0.504205, -2.864809, 1.404412, -0.925861, -0.558165, -1.749111, 0.437803, -0.226118, -0.246412, -1.568071, -0.654933, -0.365419, 0.346828, -0.003527, -0.908495, 0.679644, -1.009137, -0.248740, 0.283666, -0.465920, -0.952127, 1.942545, -0.229579, -0.844631, 0.546784, 1.539797, 1.731192, -0.227465, -0.667429, 1.732751, 1.834417, 0.187376, -0.072599, 2.281311, -0.620124, 1.585933, 2.254743, 1.853519, 1.469420, 0.067484, -0.819385, 2.425460, 0.859319, -0.625101, 0.985698, -0.467969, -0.238566, -0.493566, -0.913547, 2.478377, 0.458568, 1.862653, 0.086888, 0.101835, 0.176485, -1.598616, -0.577365, 0.261349, 0.227036, -1.797530, 2.500124, 0.240245, -0.223183, -1.779905, -0.384604, 3.077058, 1.774863, 1.219958, 1.243129, -0.306907, -0.188535, -1.650250, 0.340070, -1.718568, -0.251189, 1.460991, 0.590882, -0.385560, -0.163104, -0.229174, -0.668689, 0.294152, -0.216431, -0.427268, 1.390024, -0.045790, 1.231359, 0.668713, -1.292979, 0.018572, 1.285080, -1.273067, -0.039032, -0.730105, -1.394104, 2.360820, 1.569151, 2.778356, -0.277529, 1.086495, -0.643414, 3.089914, 1.491560, -1.023540, 0.395575, -0.473627, 0.740203, -0.742335, 0.660303, -0.008113, -0.401998, 0.439110, 0.331421, 0.034715, 0.188870, -0.161077, -0.096903, -0.646877, -0.332982, 0.587330, -0.290240, -0.261698, 0.740485, 0.046225, -0.274945, 0.134271, 0.064552, 0.063748, 0.026800, 0.086372, 0.320869, -0.301363, -0.904366, -0.731661, 0.125208, -0.628728, -0.418712, -0.256602, -0.478969, -0.312359, -0.319764, -0.128000, -0.423650, -0.924216, 0.238665, -0.721877, -0.011162, 0.062943, -0.316199, -0.678527, 0.152817, 0.156916, 0.392184, -0.257864, -0.219737, 0.002470, 0.243585, -0.276787, 0.294158, -0.505414, -0.326580, -0.423625, -0.848132, -0.432988, -0.445819, 0.103594, -0.382674, 0.142998, 0.037134, 0.700377, 0.548114, -0.634214, -0.155524, -0.251007, 0.786490, -0.043498, -0.485096, -0.636499, -0.318310, -0.157870, 0.473351, 0.044631, -0.081051, 0.065569, -0.590349, -0.241666, 0.064808, 0.207646, -0.163023, 0.180843, -0.445294, -0.223619, -0.359517, -0.872710, -0.049823, -0.038047, -0.237317, -0.181316, -0.454992, -0.317486, -0.024336, 0.191362, -0.610956, -0.825912, 0.273258, -0.648360, -0.076180, -0.053066, -0.068017, -0.570158, 0.134488, 0.501290, 0.117588, -0.261371, -0.692763, -0.243243, -0.432827, -0.532431, 0.059875, -0.677960, -0.146208, -0.316805, -0.728873, -0.264775, -0.194329, 0.280422, 0.009712, -0.411618, -0.208783, -0.678391, -0.326821, 0.072716, 0.129329, 0.166548, -0.216091, -0.835746, 0.738709, 0.497915, -0.064621, 0.019580, -1.175274, -1.173807, -1.216056, -0.166592, 0.209515, -0.006314, 0.585207, 0.062892, -0.308339, -0.230898, 0.388001, 0.219282, 1.072753, 1.010690, 0.655235, 0.902250, 0.063043, 0.089320, -0.090576, 0.020091, 0.005201, 1.152718, 0.477118, 0.094098, 0.004047, 0.157439, 0.489842, 0.192566, 0.147229, -0.315308, -0.159498, 0.186284, 0.386874, -0.327227, -0.346967, -0.273458, -0.290798, -0.026060, 0.313557, -0.104592, 0.041740, -0.402935, 0.447776, -0.173448, 0.068327, -0.080303, -0.218355, 0.026756, 0.348577, 0.083930, -0.151960, -0.431263, -0.176711, -0.098453, -0.093176, -0.081516, -0.064492, -0.172340, 0.102151, -0.236488, 0.110407, 0.174141, -0.152242, 0.108755, 0.034167, 0.273526, 0.017780, -0.001816, -0.168310, -0.285456, 0.314495, -0.122512, -0.176721, -0.012049, 0.423021, -0.153332, -0.006906, 0.500092, 0.220361, 0.180625, -0.073664, 0.808725, 0.269582, -0.166657, -0.189403, 0.164863, 0.217867, 0.362441, 0.496464, -0.025744, -0.272171, 0.192947, 0.506856, -0.159075, -0.346789, 0.085470, -0.057227, 0.157303, 0.496693, 0.110871, 0.214439, -0.242462, 0.499958, 0.030552, 0.228132, -0.206641, -0.071632, -0.034802, -1.079641, -0.561127, 0.631036, 0.311563, 0.072532, -0.119950, -0.283664, -0.653123, -0.764113, -0.274192, -0.243676, -1.211875, 0.822736, 1.502457, -0.146853, 0.960371, 0.632859, 0.294268, 0.051295, 0.709993, 0.654394, 0.329121, 0.786029, 0.098607, 0.540056, 0.403329, 0.265609, 0.974054, 1.136490, -0.095229, -0.338386, -0.105962, 0.040936, -0.109383, 0.017390, -0.053273, 0.488782, 0.318188, -0.398241, 0.074123, 0.361029, 0.281719, -0.161859, -0.218794, 0.623499, 0.179557, -0.250346, 0.372999, -0.174160, -0.279477, 0.292640, -0.279443, 0.842216, 0.145361, 0.473768, 0.044350, -0.189945, 0.221433, 0.415221, 0.116193, -0.000706, -0.490073, -0.084157, 0.025489, 0.516440, 0.319362, 0.012532, -0.125372, 0.175826, 0.396456, 0.173046, 0.137314, -0.361421, -0.129935, -0.517549, -0.230611, 0.147395, 0.000523, -0.285866, -0.103239, -0.019989, 0.084550, -0.017052, 0.146116, 0.057535, 0.251211, -0.310763, 0.142102, -0.278306, -0.367791, -0.385400, -0.089464, 0.068886, -0.064610, 0.060177, -0.031187, 0.158872, -0.003125, -0.521022, 0.035372, 0.260750, -0.097435, -0.184397, -0.090595, 0.234537, -0.143613, -0.125829, 0.278442, 0.082914, 0.088968, 0.165661, 0.073767, 0.389529, 0.381208, 0.256925, 0.168490, -0.218750, -0.061586, 0.311882, 0.454635, 0.918404, 1.193398, 0.564648, 0.265717, -0.481215, -0.292090, 0.499224, 0.323135, 0.752655, -0.829696, 1.354455, -0.349951, -0.306892, -1.025508, -0.795381, -0.550435, -0.397420, -0.443223, -0.232775, -0.082302, -0.711647, -0.058174, -0.394849, 0.047719, 0.288703, -0.921428, -0.498142, 0.342605, -0.671869, -0.196846, 0.351826, 0.888987, 0.271113, 0.028841, 0.016571, 0.264690, 0.254152, -0.023015, -0.551736, 1.283870, 0.287128, 0.958790, 0.042072, 0.366738, -0.206828, 0.369937, 0.261465, 0.697971, 0.336299, 1.096807, 0.602711, 1.123712, 0.346542, 0.114906, -0.240529, 0.222303, 0.014890, 0.190621, -0.197796, -0.165783, -0.187526, 0.200114, 0.222716, 0.591454, 0.585407, 0.153169, -0.502813, 0.074149, 0.042207, -0.066375, 0.249654, -0.317546, -0.071180, 0.202344, 0.154085, -0.048043, -0.601304, -0.449225, -0.501157, -0.406457, 0.079824, 0.282190, -0.092597, 0.048688, 0.186032, 0.626309, 0.176206, -0.082022, -0.192096, -0.326431, 0.003472, 0.678034, 0.139991, 0.102566, 0.094718, 0.071463, 0.124376, -0.147878, -0.692028, 0.546155, 0.024222, 0.554445, -0.076376, 0.277152, -0.564154, 0.047416, -0.156375, 0.458367, 0.016807, 0.463592, 0.130059, 0.820651, -0.065955, -0.107359, -0.178692, 0.066672, 0.246343, 0.188797, -0.070492, -0.541527, 0.617337, -0.561596, -1.405616, -0.522252, -0.280183, -0.288819, 0.481080, 0.428970, 0.713550, 0.130044, 0.688908, 0.539909, 0.098464, 0.070799, 1.128060, 0.254226, 0.411471, 0.247276, -0.459545, 0.354468, 0.462515, 0.359434, -0.108892, 0.112532, 0.216311, 0.494674, 0.729522, -0.414954, 0.552851, -0.464106, -0.754484, 0.129343, -0.159283, -0.354487, -0.096009, 0.430190, 1.043633, 0.153923, -0.066190, 0.416557, 0.691560, -0.258552, -0.938785, 0.090069, -0.234838, 0.341144, -0.035599, -0.841265, -0.924749, 0.006533, -0.009156, 0.802409, 0.904741, -0.328154, -0.069597, 0.032965, -0.611759, 0.370547, 0.459480, 0.339518, 0.443145, -0.757263, -0.683127, 0.272693, -0.817411, -0.723752, -0.500553, 0.044356, 0.736278, 1.215337, 0.510557, -0.703896, -0.202913, -0.300610, -0.440823, -0.203471, 0.067215, 0.757159, 0.352017, 0.306075, -0.860044, 0.152777, 1.197149, -0.228781, -0.312947, -0.366132, -0.792290, 0.593515, 0.185227, -0.679472, -0.779366, 0.344400, -0.420867, -0.267672, 0.117754, 0.377325, 0.615616, 0.162247, 0.570233, 0.611308, 0.493001, 0.619821, -0.387709, 0.092983, -0.396792, -0.159088, -0.140263, -0.918261, -0.913950, 0.064274, -0.390858, 0.576582, 1.160135, -0.159205, 0.195732, 0.112877, -0.164843, 0.450623, 0.641371, -0.708827, 0.886425, -0.300246, -0.302409, -0.095555, 0.507130, 0.561786, 0.079079, 0.074088, 0.887748, 0.439873, -0.239838, 0.445116, 0.700256, 0.169247, 0.392978, 0.748555, 0.435726, -0.106708, -0.054664, -0.226464, 0.379040, -0.010041, -0.280416, -0.302352, -0.861491, -0.561790, -0.710157, -0.228526, -0.357824, -0.278943, -0.459747, -0.573471, -0.483616, 0.046195, -0.163917, 0.091832, -0.241120, -0.077975, -0.166215, -0.544708, -0.011262, 0.158316, -0.214939, 0.699998, -0.359370, -0.057966, -0.318344, -0.321998, 0.334144, -0.208455, 0.437246, -0.272033, 0.599550, 0.096641, 0.470973, -0.458861, -0.205078, -0.245779, -0.193827, 0.411315, -0.300775, 0.167870, 0.303648, -0.223484, -0.605127, 0.066725, -0.019765, -0.212483, -0.727025, -0.475984, -0.101685, 0.156068, 0.283288, 0.521682, 0.124242, 0.317583, 0.494708, 0.182625, 0.757676, 0.154512, -0.000177, 0.060639, 0.511895, -0.056387, -0.701857, -0.262455, -0.022342, 0.089454, 0.523994, -0.189978, -0.265164, -0.434408, -0.377326, 0.103275, 0.082673, 0.275737, -0.129834, -0.068358, 0.008871, -0.248309, -0.068405, -0.112596, -0.554879, 1.167438, -0.296696, -0.203340, -0.124467, -0.691281, 0.421115, -0.249583, 0.710857, -0.300399, 0.605135, 0.093563, 0.273315, -0.499134, -0.422106, -0.285463, -0.035130, 0.040140, -4.017118, 4.554648, -3.506537, -0.221351, 1.713373, -0.882953, 2.299019, 0.516283, 0.534516, 1.150198, -0.667811, 1.803640, -1.278615, 1.008335, -0.648385, 0.051702, 1.079611, -1.289758, 1.242417, -0.622422, -0.107456, -0.051975, -0.353363, 0.223395, -0.567717, -0.692146, 0.910176, -0.848618, 1.202970, -0.104418, 0.873456, 3.811211, 5.602687, 5.940643, 3.847050, 1.006113, 0.849354, -0.136001, 1.978493, 0.456780, 0.207610, -0.194396, -0.095200, 0.841024, 1.300410, 0.311496, 0.610108, -0.183524, 1.569592, 0.928893, -0.222269, -0.496096, 0.046342, 0.637542, 0.465619, -0.906476, 0.217172, -0.430365, 0.297829, 0.058891, 1.961290, -2.481319, 3.753098, -2.997125, 1.500152, -1.180157, 0.856333, 0.296569, -1.400827, 0.355960, 0.507927, 0.034034, 0.892527, -0.726314, 0.485754, -0.519525, 0.354983, 0.106463, 0.318860, -0.177096, -0.333459, -0.282896, -1.060220, 1.377291, -0.512681, 0.373429, -0.760191, 0.374141, -1.559730, -0.078485, -0.270183, 0.007776, 0.601624, 0.393452, 0.782972, 0.714812, 1.449930, -0.541587, 0.463742, 0.564987, 1.083345, -0.965304, 0.533948, -0.122869, 0.530241, 0.332504, 0.284087, -0.699774, 1.984279, -0.134097, -0.116483, -1.504348, -1.022977, 0.727346, -0.236671, -0.298383, -0.057393, -0.718864, -0.401390, -0.016434, 0.237191, -0.310736, 0.076206, 0.180119, 0.615621, 0.518314, -0.159413, 0.040093, 0.466658, 0.347215, 0.293967, -0.296303, 0.638109, 0.560899, 0.274005, 1.135677, 0.747814, -0.194562, -0.032207, 0.206500, 0.725228, -0.084853, -0.183477, 0.131982, -0.520324, -0.061736, -0.768350, 0.350067, 0.556237, 0.341461, 0.310923, -0.246505, -0.515118, -0.308565, 0.150025, -0.346476, -0.108232, 0.135862, -0.674884, -0.431313, 0.324343, 0.957697, -0.336282, 0.485800, -0.627897, -0.509217, -0.481396, -0.328220, -0.951887, 0.081821, -0.169974, -0.196601, -1.039545, 0.082168, -0.439451, -0.057509, -0.210679, 0.104044, 0.578747, -0.129227, 0.311531, 0.314607, 0.208015, 0.202363, 0.318873, -0.127928, -0.229757, -0.690201, -0.319029, -0.439798, -0.282224, 0.092569, -0.712525, -0.450456, 0.074957, 0.028774, 0.379471, -0.098276, 0.248500, 0.299039, -0.419438, -0.268666, -0.320424, -0.347572, -0.109718, 0.004912, 0.553391, 0.436806, 0.539269, 0.539455, 0.571845, -0.152098, -0.125921, -0.106137, 0.528902, 0.330263, 0.046113, 0.588787, -0.574263, -0.374611, 0.637531, 0.893350, -0.413513, 0.734507, 0.005209, -0.345972, -0.297344, 0.182282, -0.499660, 0.058170, 0.169051, 0.100015, -1.053166, -0.298434, -0.611344, -0.167210, -0.118210, 0.360183, 0.758004, 0.854806, 0.054483, -0.225577, -0.967432, -0.501692, 0.167004, -0.396859, 0.356322, 0.450115, 0.095360, 0.441652, -1.634200, 1.854210, -2.630576, 0.550383, 0.920290, -1.937035, -1.159240, -1.262516, -1.394548, -0.751454, -2.986211, -2.263441, -1.525399, -2.277983, -1.658366, -1.296103, -0.754166, -1.050009, -0.637159, -0.533242, -0.780347, 0.330464, -0.152540, -0.464195, -0.694275, 0.074600, 0.122901, 0.175611, -0.508332, -0.094510, -0.240291, -0.124576, 0.248704, -0.307785, 0.413493, -0.201574, 0.144127, -0.097771, -0.124275, -0.578945, 0.662034, 0.090861, 0.258475, -0.395438, 0.353691, -0.363044, -0.262117, -0.945637, -0.740298, -0.006204, 0.526065, 0.260886, -0.491847, -0.197369, -0.132045, -0.816196, 0.797144, -0.436251, 0.089626, 0.303208, -0.006461, -0.398608, -0.573761, -0.303339, 0.257118, -0.277807, -0.049289, 0.021328, 0.530744, -0.079050, -0.250070, 0.070692, -0.509190, 0.964843, 0.680370, 0.101700, 0.179712, 0.252762, 0.510205, -0.515692, -0.552796, 0.652909, 0.406131, -0.338426, -0.515331, -0.267880, 0.259126, 0.270442, 0.045692, -0.707037, -0.203307, -0.281849, -0.374898, 0.446271, 0.213213, 0.052739, 0.304524, -0.041156, 0.040806, 0.014765, 0.365918, 0.457027, 0.071025, 0.044314, 0.869070, 0.178789, 0.062847, -0.140645, -0.099424, -0.525656, 0.601112, 0.011836, -0.442417, 0.895059, -0.876107, -1.277897, -0.275419, -0.156340, 0.648654, 0.461936, -0.936174, -0.038191, -0.260767, -1.379314, 0.239519, -1.190308, -1.212539, -1.849205, -0.380425, -0.030258, 0.754954, -0.121036, 0.790983, -0.255467, -0.223444, -0.286665, 0.756388, -0.518269, -0.303101, -0.382860, -0.535531, -0.472415, -0.410327, 0.063039, 0.120893, -0.177561, -0.467728, -0.565542, -0.774630, -0.127764, 0.582794, 0.108180, 0.011631, 1.096266, -0.062032, -0.305326, -0.265014, -0.553009, 0.360484, 0.939200, -0.355746, -0.327652, -0.532756, -0.587560, -0.057243, 0.399454, -0.162787, 0.236840, -0.382195, 0.236808, 0.556785, 0.134740, -0.420809, -0.099872, 0.612871, -0.476475, -0.586479, 0.353455, -0.093101, 0.277397, 0.075879, 0.099722, -0.394595, -0.884195, 0.275539, 0.434429, 0.060636, 0.250601, -0.304059, -0.575378, -0.017951, 0.299439, -0.182474, 0.133364, 0.301692, -0.458636, -0.472083, -0.469121, -0.219167, -0.398355, -0.341492, -0.411053, -0.262596, 0.490995, -0.032048, -0.111687, -0.641768, -0.337488, -0.712001, -0.497315, 0.202631, 0.035904, -0.065352, 1.675687, -0.334379, -0.000338, -0.021021, -0.327386, 0.120445, 1.642068, -0.249817, -0.121574, -0.104927, -0.217974, 0.154893, 0.239593, 0.061497, 0.275949, -0.092981, 7.641819, -3.312038, -2.189301, -3.022446, -3.260672, -1.313626, -1.679314, -2.070057, -3.128108, -0.486346, -0.748447, -1.384555, -0.147836, 0.021256, -0.350692, -0.295561, -0.734544, -0.268720, -1.215585, 0.016702, -0.085245, 0.081407, -0.279871, -0.430576, -0.597820, 0.319178, 0.195970, -0.361630, -0.191542, -1.089366, 2.306843, 1.330798, 2.903297, 2.713065, 1.094569, 0.335933, -0.299509, 0.164326, 0.109437, -0.492870, -1.286263, -1.255323, -0.508388, -0.133705, -0.987228, -1.116017, -1.547869, -2.219082, -1.275177, -0.382438, -1.409339, -1.605011, -1.198206, -0.614438, -1.086205, -0.543132, -1.981289, -1.332150, -0.976147, -0.234297, 0.060004, -0.165321, 2.955880, 2.047483, 0.725035, 0.051852, -0.784600, 0.875316, 0.131510, -0.430750, -1.125544, -1.542713, -2.525519, -0.484696, 0.518641, -0.093745, -0.758390, -1.495671, -1.453768, 1.636436, 0.386739, 0.307059, 0.476285, 0.473023, 0.338161, -1.017721, -0.395702, 0.425595, -0.292523, 0.579140, 1.584767, 0.672879, 2.104499, 1.576410, 0.462274, 0.852886, -0.456419, -0.433846, 0.445784, 0.124094, -0.121076, -0.168123, 1.147378, 1.046131, -0.363428, -0.448089, -0.683660, -0.049280, -1.219166, 0.005549, 0.141208, -1.050574, 0.124002, -0.283644, -1.271061, -0.504543, -0.636874, -1.250047, -1.002689, -0.408203, 0.449077, -2.129250, 2.951909, -0.866114, 1.199170, 1.115275, 0.266174, 0.491809, -3.346738, -1.196759, -1.771388, -0.748323, -0.187992, -2.410928, -0.405567, -0.930006, 0.329665, 1.077168, 0.369995, 1.967913, 1.035763, 1.074629, 0.432856, -2.090991, -0.364676, -1.553364, -1.836013, -1.279770, -4.074393, 0.038175, -0.070452, 2.567185, 3.386505, 1.661915, 0.449866, 0.017282, 2.380503, 1.174250, 2.209251, 3.676855, -0.518102, 0.045014, -2.821329, -0.138308, 0.947965, -0.676355, -1.348565, -1.370097, -0.039175, 1.193649, 4.421659, -0.396991, 0.299970, -0.125429, -0.536080, -1.081941, -0.158028, 1.014493, 2.042216, 1.797172, 0.950700, -2.740244, 2.344521, 0.517227, 0.398738, -0.694153, -1.332485, 1.011018, -1.198795, 2.505013, -0.271995, 0.156113, 1.511063, -1.593743, -0.130710, -0.665701, -0.670121, 0.817586, -0.558923, 1.206347, -1.600843, 0.343877, -0.223742, -1.378941, 0.742073, 0.736599, -0.253873, 1.065518, -3.200396, 0.802929, -0.743702, 0.075472, 0.673884, 1.690150, -0.363103, 1.320015, 0.804206, 0.060091, 0.965096, 2.567701, -0.681561, -0.191887, -2.441112, -0.330395, 0.668304, -0.297286, -1.534494, 0.029338, -1.468972, -0.003566, 1.093797, -1.279949, -0.233824, -0.733296, -0.793344, -0.054972, 0.051097, 1.050439, 0.384228, 0.686095, 0.281104, 0.319688, 0.896554, 0.036985, 0.705307, -0.081783, -0.371173, 0.436066, 0.022616, 0.583034, -0.710086, 0.806597, 0.038603, -0.363258, -1.089334, -0.759689, -0.709705, -0.262023, -0.417832, -0.142862, -0.288064, -0.371533, -0.325650, -0.422609, -0.033463, -0.086070, -0.534901, 0.091089, -0.183054, -0.455483, -0.118171, 0.181004, 0.181201, 0.341176, 0.422936, -0.377281, 0.799462, 0.196522, -0.062721, 0.059125, 0.764091, 0.487877, -0.062387, -0.069691, 0.136891, 0.808183, 0.465204, 1.014067, 1.526292, 0.392939, 0.312060, -0.129405, 0.512683, 0.538317, -0.189940, 0.089050, -0.366141, 0.759309, -0.182251, 0.089279, 0.333776, 0.140122, 0.000463, -0.396422, -0.062343, -0.517053, -0.304208, -0.046252, -0.255913, -0.543888, 0.031103, -0.299970, -0.220957, -0.088351, -0.149764, 0.619532, 0.178565, -0.295619, -0.231897, -0.227299, -0.193074, 0.466324, 0.153537, -0.496201, -0.141511, -0.327222, -0.109926, -0.585236, -0.073039, 0.384003, -0.169610, -0.101640, -0.317565, 0.324481, 0.610609, -0.328243, 0.272462, -0.169682, -0.241838, -0.164207, 0.990148, 0.385024, 0.101293, -0.459778, -0.227317, 0.717275, 0.115859, 1.201527, 1.355866, 0.217872, -0.122431, 0.015279, 0.560188, 0.855507, 0.074875, 0.152381, -0.330181, 0.912075, -0.226638, 0.191382, -0.852044, 1.198911, 0.707110, -0.315252, 0.735361, 0.951163, 0.443404, 1.089790, 0.346958, 0.173301, -0.239875, -0.287536, 0.175051, -0.240720, -0.291391, -0.158381, -0.511351, -0.955691, -0.709139, -1.235859, -1.090154, -1.307632, -0.456958, -0.604711, -0.919297, -0.675495, -0.981986, -0.391461, -0.442313, 0.388270, -0.244348, -0.671881, -0.389579, -0.497810, -0.606161, -0.497520, -0.384856, -0.109452, -0.243988, -0.351489, -0.573735, -0.521897, 0.007651, -0.346012, -0.036138, -0.108172, 0.008013, -0.062445, 0.129130, 0.138235, -0.028488, 0.219232, 0.179034, 0.065359, 0.011474, 0.004648, -0.100856, -0.092602, -0.127115, 0.242432, 0.026363, -0.012187, -0.142548, -0.040761, 0.004732, 0.044379, -0.037344, -0.189186, 0.066884, 0.311663, 0.042070, -0.152347, -0.326843, 0.087964, 0.080872, 0.020156, -0.049569, -0.155315, -0.005107, -0.035450, 0.076241, 0.175549, -0.237147, 0.029478, 0.144906, 0.017157, 0.107849, -0.084758, -0.022869, -0.098918, -0.278551, -0.656703, -0.358246, -0.223462, -0.493255, -0.382760, -0.314955, -0.201550, -0.165784, -0.349418, -0.590042, -0.536390, -0.056996, -0.441152, -0.050241, -0.200096, -0.250380, -0.319079, 0.095000, 0.036382, -0.248202, -0.074603, -0.060967, -0.054407, -0.224198, -0.170816, -0.322413, -0.091550, -0.254174, 0.141739, 1.055656, 1.143261, 1.065089, -0.690993, -1.335798, -1.063644, -1.430129, 0.620477, 1.163315, 0.687562, -0.614946, 2.078079, -1.843073, 1.015595, -0.993273, 0.337786, -0.587892, -0.356435, 0.267130, -0.605346, -0.579043, -1.113503, -0.301482, -1.779759, 0.497932, -0.656760, -0.847087, 0.036735, 0.246920, 0.136317, 0.138219, 0.209472, 1.850653, 1.814569, 0.760488, 2.668668, 2.394781, 1.901335, 1.457096, 0.721784, 2.010148, 1.186936, 0.677724, 1.586512, 0.513605, 0.346345, 1.657037, 1.345415, 1.070792, 1.514449, 0.743321, 0.921103, 1.214776, 0.693177, 0.899596, 0.163031, 0.375579, 1.161513, 0.364172, 0.087169, -0.648090, -0.102507, 0.352973, 1.307002, 0.635856, -0.527523, -0.086324, -0.702543, -1.027820, -1.296094, 0.561361, -0.225428, 0.782609, -0.098507, -0.096408, 0.142238, 0.612613, 0.624598, -0.533678, 0.197371, -0.137327, -0.210869, 0.005040, 0.618598, 0.422812, -0.316771, 0.751340, -0.212556, -0.829126, 0.907871, 0.028130, -0.162075, 1.731503, 1.003337, 1.035384, 2.136728, 1.882972, 2.163068, 1.376336, 0.542198, 1.652573, 1.353976, 0.603213, 0.796403, 0.275115, -0.003931, 1.715459, 0.921868, 1.041142, 0.560998, 0.321404, 1.109442, 0.854136, 0.017210, 0.501746, 0.586436, 0.455489, 0.991660, 0.678056, 0.291479, -0.335166, 0.237224, -0.054379, 0.087662, 0.152817, 0.888587, 0.551983, 0.762987, 0.960724, 0.312597, 0.002191, 0.345715, 0.381264, -0.061490, 0.538791, 0.335174, 0.631777, 0.745086, 0.737031, 0.154790, -0.207268, -0.398164, -0.852208, -1.096739, -0.911315, -0.956813, -1.013160, -1.062798, -1.149018, -0.651177, 0.061839, -0.062546, -0.272829, -0.496453, -0.222047, -0.164024, -0.851896, -0.284493, -0.288658, -0.108532, -0.087096, -0.317570, -0.276978, -0.129600, 0.250919, -0.455640, 0.084962, -0.134305, -0.066824, 0.012316, -0.858306, 0.209427, 0.249222, 0.106306, -0.566903, -0.136071, -0.227965, -0.367976, 0.138814, -0.249183, -0.471081, 0.557691, -0.256971, -0.187342, 0.154502, 0.101740, -0.039629, -0.018620, -0.486558, -0.446251, -0.239415, -0.443204, 0.054672, 0.368804, 0.080606, 0.076725, 0.251522, 0.660693, -0.066612, -0.542693, -0.308101, -0.128929, 0.006948, -0.217333, -0.305687, -0.055524, -0.179481, 0.112558, -0.085511, -0.101258, 0.410712, 0.379917, -0.288732, -0.271760, -0.041815, 0.120959, -0.696791, 0.032191, -0.314972, -0.079543, -0.226735, -0.169720, 0.002087, 0.074810, 0.077048, -0.491115, 0.115982, 0.022544, -0.168627, -0.294701, -0.760847, -0.106617, 0.437228, -0.045268, -0.306485, 0.107513, -0.023118, -0.388425, 0.598017, 0.048978, -0.534749, 0.810321, 0.073261, -0.348307, 0.710060, -1.262460, -1.472430, -0.378052, 0.009065, 0.274565, 0.784915, -0.759081, 0.237383, -0.349119, -1.570568, 0.697848, -1.273995, -1.114313, -1.355352, -0.003891, -0.719362, 0.716271, -0.170435, 0.631238, -0.205393, -0.327604, -0.561231, 0.341053, -0.927695, -0.452359, -0.409727, -0.359324, -0.288635, -0.409325, 0.179561, -0.120905, -0.295908, -0.165852, 0.143099, -0.426284, 0.074597, -0.220382, -0.012127, 0.382331, -0.450383, -0.506234, -0.090380, -0.319622, 0.078690, -0.433529, -0.055373, -0.284250, 0.079295, -0.594953, -0.094175, 0.028282, -0.397971, -0.244927, -0.598339, -0.254500, -0.013636, -0.159013, 0.147249, 0.212112, -0.078139, -0.114597, 0.049492, 0.221890, -0.106764, 0.075085, 0.080091, 0.093611, 0.008666, -0.123439, -0.040028, 0.102037, 0.048445, -0.215572, -0.106287, -0.056220, 0.304260, -0.031680, -0.234418, -0.071244, -0.151971, 0.003174, 0.047220, -0.027163, 0.091637, 0.201267, -0.414411, -0.411035, -0.023336, -0.179758, 0.179381, -0.098975, -0.455166, -0.251793, -0.062332, -0.283370, 0.025654, -0.285541, -0.168078, 0.171485, -0.632748, -0.156347, 0.061534, -0.323267, 0.054729, -0.550913, 0.191817, -0.053878, 0.028980, -0.365599, -0.007909, -0.000021, -0.065087, -0.189366, -0.319132, -0.273792, 0.361748, -0.795395, 0.821286, 1.225654, 1.348014, 0.617022, 0.923348, 0.844992, 1.304054, -0.940474, -0.548917, -1.534366, -1.354697, 0.481237, -0.044760, -0.467220, -0.278016, -0.159746, -0.828517, 0.157544, 0.334569, 0.063967, -0.071955, -0.487281, 0.479004, -0.029211, -0.504754, 0.411616, -0.089060, -0.592922, -0.070557, -0.157582, 0.225393, -0.037585, -0.107939, -0.280683, -0.158420, -0.643678, 0.212960, 0.204118, 0.194724, 0.295822, 0.697379, 0.197224, 0.389866, -0.226438, 0.584062, 0.715225, -0.295218, -0.283631, -0.008411, -0.129560, 0.414382, -0.296186, 1.000724, -0.324949, -1.122010, 0.470504, 0.283851, 0.583771, 0.512426, 0.023704, -0.355220, 0.191570, -0.459484, 0.090109, 0.631880, 0.339596, -0.521506, -0.824114, 0.327702, 0.271351, -0.819231, -0.213397, 0.154939, -0.660408, -0.604306, 0.341273, 0.268774, -0.171320, 0.644408, 0.507181, -0.539098, 0.951187, 0.496771, -0.820727, 0.181398, 0.985724, 0.313972, -0.588810, -0.370349, -0.683025, 0.004247, -0.641281, -0.528684, -0.488518, -0.225797, -0.815771, -0.549816, 0.284555, -0.039512, 0.374546, 0.180185, -0.232045, 0.052068, -0.571280, 0.176107, 0.277919, 0.088176, -0.309079, 0.517388, 0.061276, 0.622549, -0.013556, 0.224651, -0.251932, -0.727430, 0.424648, 0.025219, 0.514636, 0.925000, 0.076249, 2.167732, 1.886890, -0.509941, -1.242061, -1.411454, -1.802268, -1.157425, -0.873419, 0.391634, 1.676637, 0.825153, 2.369991, -2.114033, 1.308385, -1.117938, 0.217550, 0.476551, -1.402551, -1.957909, -1.248427, -1.537671, -0.680487, 0.307001, 0.739759, -0.701392, -0.124941, 0.158997, -1.017560, 0.122054, 0.075047, 0.276936, 0.264076, 0.441006, 1.132138, 1.283767, 0.304554, 0.596426, 1.100481, 0.995043, 0.425930, -0.274266, 1.132313, 1.238481, 1.730737, 1.316109, 0.927997, 1.731678, 1.328081, 0.054895, 0.364433, 0.328501, 0.770909, 0.633502, 0.123653, 0.194334, -0.075181, 0.431495, -0.600255, 0.160698, -0.513022, -0.119115, 0.074360, -0.216783, -0.112051, 0.748532, 0.093149, -0.580509, 0.327977, 0.267932, 0.288798, -0.088850, -0.923165, -0.846232, 0.660193, -0.443613, 0.260545, -0.474114, 0.676818, -0.718405, 0.207470, 0.384274, 0.039912, 0.042756, 0.892581, 0.562231, -0.964352, -0.206743, 0.056307, 0.069037, -0.402214, 0.675611, 0.457169, 0.717473, 0.729373, 1.530272, 1.958800, 0.047541, 0.411935, 0.250245, 0.378868, -0.211517, 1.347700, 0.102694, 1.206949, -0.191162, 0.677949, 1.717191, 0.383414, 0.448573, 0.866925, 0.417200, 0.453333, 1.944809, 0.517729, 0.252463, 0.242013, 0.655824, 0.228367, 0.420166, -0.926081, 0.634881, 1.311471, 1.158089, 0.154163, 1.067568, 1.748762, 1.041621, -0.381143, -1.518010, -0.141002, -0.546317, -1.197277, 0.348596, -0.773328, 0.310282, -0.744823, 1.087524, -0.450260, 0.791356, 0.079523, 0.319624, 0.777965, 0.368583, 0.895285, -0.296523, 0.486866, 0.008506, 0.236116, 0.068750, -0.251019, -0.185044, -0.324266, 0.284504, -0.341676, -0.026372, 0.247861, -0.299340, 0.132082, -0.032960, -0.010376, 0.049870, 0.112573, 0.595097, 0.572840, -0.230626, 0.003218, 0.206972, -0.121495, -0.146933, -0.165941, -0.409751, -0.166850, -0.041299, 0.040907, 0.155250, -0.497932, 0.216020, 0.223613, 0.018137, 0.060915, 0.009754, 0.226702, -0.073989, -0.157670, -0.169174, 0.035681, 0.139038, 0.210742, 0.101483, 0.100975, 0.122751, 0.130812, 0.203950, -0.115840, 0.192396, 0.118277, -0.144782, -0.172181, -0.255658, -0.348736, 0.140255, 0.033130, -0.256050, -0.228786, -0.177461, 0.117429, -0.098036, 0.149233, -0.326026, -0.486951, -0.083775, -0.177344, -0.127921, -0.299134, -0.087815, 0.054163, -0.178971, 0.112680, 0.329846, 0.111841, -0.115952, -0.099874, 0.042828, 0.126795, -0.257609, -0.094816, 0.103324, -0.119230, 0.001323, 0.070685, -0.194791, -0.025255, 0.266715, -0.030671, 0.177093, -0.337994, 0.057752, 0.033989, -0.803670, 0.615783, 0.261366, -0.448394, 0.493530, 0.685190, 0.064824, -0.221153, -1.057705, -0.921675, -0.913778, -0.793700, 0.346497, -0.429496, -0.105963, 0.325074, 0.010081, 0.194467, 0.918214, 0.180864, 0.413492, -0.100530, 0.720380, 0.807475, -0.452154, -0.720448, -0.769996, 0.262793, -0.447680, -0.770154, -0.404301, -0.830626, -0.154140, -0.409755, -0.503184, -0.648328, -0.351205, -0.226414, -0.507922, -0.290371, 0.114943, -0.019819, -0.113640, -0.195474, -0.331862, -0.253098, -0.335028, -0.272086, -0.289691, -0.002910, -0.157001, 0.077874, -0.272165, 0.163525, -0.400754, -0.053858, 0.007969, -0.299952, -0.344017, 0.050572, -0.171629, -0.139897, 0.257327, 0.313943, -0.044744, 0.203673, -0.288315, -0.787517, -0.017297, 0.252402, 0.344780, 0.143151, 0.034315, 0.058966, -0.299466, -0.379665, 0.262973, -0.065459, -0.499408, -0.058963, 0.148874, -0.190843, 0.030539, 0.106130, 0.291260, -0.326453, 0.009660, 0.009551, -0.034156, 0.298803, -0.441366, -0.695589, 0.002189, -0.333033, -0.410781, -0.558338, -0.168419, -0.083527, -0.445732, -0.198144, 0.243886, -0.312882, -0.174984, -0.400143, -0.631355, -0.480854, -0.426333, -0.535976, -0.507524, -0.528167, -0.166548, 0.153739, -0.244953, -0.046551, -0.166718, -0.046563, -0.170252, -0.137691, -0.124671, 0.293971, 0.879853, 0.143036, -0.036971, -0.611939, -0.370662, 0.102799, -0.422517, -0.031878, 0.665760, 0.162826, 0.171831, -1.658191, 1.510756, -2.409968, 0.747852, 0.993758, -2.101573, -1.074787, -1.651962, -1.029619, -0.791629, -2.403839, -2.280135, -1.448728, -2.878308, -1.765010, -1.462346, -1.359398, -1.507190, -1.751912, -0.462505, -0.825218, 0.007597, -0.081165, -0.674975, -0.564016, -0.369285, -0.322270, -0.172185, 0.482594, -0.247047, 0.009446, -0.669909, 0.386481, -0.334474, -0.268697, -0.081524, 0.598322, -0.839997, -0.209730, -0.033754, 0.324493, -0.251091, -0.005616, 0.104424, -0.835002, -0.470492, 0.201679, -0.587773, -0.448610, -0.103953, -0.001090, 0.578251, 0.259056, -0.227565, -0.166062, 0.291436, 0.126159, 0.099422, -0.250706, 0.415662, -0.042856, -0.186253, -0.093985, -0.175578, -0.502178, -0.052599, -0.071611, 0.070414, 0.091410, 0.124631, 0.290269, 0.281993, 0.136495, -0.346638, -0.306616, 0.154042, 0.054327, 0.103675, 0.005026, -0.515468, -0.701930, 0.037614, -0.061443, -0.516407, -0.540730, -0.030075, -0.579569, -0.187189, 0.545283, -0.157591, 0.001549, -0.863034, 0.434160, 0.068981, -0.195882, 0.062000, 0.526015, -0.975975, -0.054584, -0.039649, 0.368479, -0.345684, 0.063468, 0.412005, -0.821080, -0.243423, 0.216255, -0.465182, -0.028939, -0.372451, -0.137701, -0.465839, -0.183782, 0.233234, 0.052160, 0.016260, -0.093664, -0.577484, 0.593929, 0.422404, -0.113785, -0.082814, -1.117481, -1.034204, -1.275521, -0.449851, -0.059607, -0.534436, 0.286252, 0.259797, -0.465746, -0.403114, 0.430521, 0.304277, 0.981068, 0.880579, 0.592541, 0.702559, -0.128585, 0.276264, -0.081811, 0.033060, 0.443604, 0.255172, 0.651487, 0.602020, 0.134958, 0.221220, -0.285755, 0.262739, -0.363810, -0.757995, 0.147970, -0.003317, -0.269313, -0.137112, -0.303566, -0.582125, 0.370948, -0.236209, 0.057946, 0.331474, -0.719444, 0.131546, 0.356090, -0.134486, -0.144939, 0.197235, -0.500429, -0.235792, 0.143338, -0.207720, 0.166298, -0.358126, -0.167637, 0.459301, 0.575351, -0.020141, 0.153400, -0.011986, -0.080842, -0.179190, -0.111559, -0.310842, -0.052376, -0.442598, 0.131879, 0.197577, -0.087631, -0.258612, -0.244899, -0.156609, 0.047887, 0.882379, 0.644110, 0.325277, -0.102472, -0.034747, 0.257535, 0.655122, 0.552509, 0.051277, 0.805852, 0.110974, 0.525731, 0.344387, 0.176091, 0.063499, -0.445995, 0.761677, -0.135035, -0.701578, 0.157783, -0.006536, -0.134198, 0.271783, -0.068152, -0.517337, 0.648847, -0.108289, 0.175425, 0.234612, -0.463947, 0.404405, 0.471926, 0.156727, 0.035049, 0.174519, -0.346121, 1.355373, -1.029670, -1.691147, -1.563949, -0.766007, -2.451605, -2.715582, -0.866814, -0.014403, -0.146025, -2.473139, 2.656128, -0.458163, -0.184662, 0.367281, 2.094224, -1.458160, -0.107766, 0.741135, -1.201503, -0.050877, 0.062440, 0.563890, -0.102028, -0.693588, -0.210314, 1.477430, -0.641394, -0.765758, 0.013873, -0.512083, -0.221529, -0.294953, 0.302455, -0.267636, -0.447812, 0.140335, 0.081915, -0.453949, -0.278489, 0.698997, -0.114617, -0.041664, 0.574331, -0.124519, -0.133733, -0.132084, 0.087651, 0.060191, 0.351123, -0.355257, -0.286817, -0.170943, 0.296687, 0.071782, -0.167002, -0.081880, 0.448591, -0.217242, -0.178813, -0.011766, 0.182218, 0.074324, -0.226676, -0.296175, -0.405431, -0.013615, -0.020192, -0.050474, 0.443245, 0.134194, -0.164812, 0.291340, 0.079261, 0.305122, -0.171919, -0.155879, 0.297290, 0.101193, 0.114574, 0.053868, -0.229772, -0.311701, -0.017935, -0.295542, -0.111864, 0.290479, -0.197935, -0.012877, 0.030751, -0.581559, -0.363253, -0.359830, 0.305273, -0.050819, -0.252620, 0.415601, 0.018632, -0.469181, -0.025075, 0.418133, 0.023346, 0.292360, 0.414698, -0.162504, -0.220006, 0.003700, 0.032058, 0.007582, 0.260437, -0.228159, -0.248935, -0.368154, 0.261889, 0.541028, -0.183952, -0.242166, 0.385122, -0.244610, 0.047460, -0.123477, -2.688282, 4.308441, -4.109481, 2.264054, 0.281090, 0.395449, 1.818776, 0.017012, 0.359237, -0.072917, -0.400162, 1.265095, -0.606589, 0.640865, -0.684023, 0.386859, -0.304656, -0.555135, -0.215179, -2.051413, -0.949418, -0.894428, 0.117216, -0.882372, -0.401310, -1.052382, 0.359405, -0.277394, 0.389852, -0.037599, 2.824570, 5.718868, 5.382618, 2.443427, 1.522187, 0.289077, -0.108983, 0.623895, 0.596158, 0.130528, 0.868126, 0.311623, 0.657771, 0.738810, 1.318228, 0.179894, 0.177247, 1.154436, 0.357493, 0.582180, 0.347044, -0.037207, -0.060533, 0.181185, 0.498796, -0.044506, -0.907335, -0.464598, -0.736672, 0.777104, -2.788501, 2.151920, -1.657418, 0.684261, -0.934086, 0.301430, 0.098885, -0.599585, -0.088065, -0.452222, 0.134624, 0.125037, -0.673113, 1.061353, -0.359364, 0.379891, 0.120169, 0.027256, 0.887654, -0.470614, 1.275287, 1.068154, 0.498478, 0.876042, -0.186901, 0.059669, 0.059740, 0.147666, -0.104612, -0.228685, -0.163803, 2.285204, 2.023194, 1.185490, 0.557991, 0.072516, -0.229251, 0.182633, 0.550733, -0.006991, 0.309470, -0.182011, 0.243790, -0.136667, 0.523955, 0.070220, -0.115684, 0.559581, -0.031991, 0.391970, 0.324566, -0.845408, -0.513017, -0.199298, 0.471398, 0.040718, -0.448968, -0.851799, -0.361230, 1.380531, -5.469742, 5.999779, -3.591675, 1.170018, 0.230039, -2.266803, 1.962602, -5.081641, 1.622364, -0.347792, 2.251193, 2.160402, 1.126348, 0.499512, 1.833673, -3.064185, 1.984344, -5.462937, 1.011456, -1.956151, 0.662693, 2.819144, -1.025296, 1.613177, -1.592158, -2.145738, 5.321788, -7.170669, 8.097795, 0.700313, 3.845475, 4.036800, 1.722333, 0.695724, 1.257227, 3.203885, 2.574757, 3.845294, -1.128770, -0.487834, 4.348413, 1.479321, 1.853474, 0.364942, 0.083060, 0.130377, -0.012222, 2.180419, 0.767543, 0.137249, -0.571862, 2.955646, 0.021235, 1.012213, -1.250306, 1.784349, 1.863353, 4.950518, 3.311476, 1.244679, 0.093822, 2.213356, -0.304173, 0.905787, -0.472069, -1.969024, -0.317630, -1.530279, -0.075912, -1.145667, 1.438155, -1.220905, -1.554694, -0.822553, -0.193645, -0.461981, 2.706458, 1.423254, 1.664127, -0.626782, 0.792033, 3.145276, 0.987633, 0.730591, 1.567622, -0.297163, 1.663415, -3.108790, 1.672470, 1.726649, 2.631238, 3.246346, 2.030969, 0.222876, -0.074757, 0.915273, 1.112752, 3.613702, -0.722839, 0.063445, 6.332204, 0.201362, 0.587920, 0.504208, 1.002308, -0.923235, -1.089159, 2.342634, 1.315995, -0.602883, 0.347547, 6.384108, 1.427801, 0.691792, -1.256040, 2.165915, 3.469613, 6.364047, 1.116341, -0.668282, -0.080032, -0.409515, -0.034228, -1.196459, 0.343095, 0.364424, 0.047542, -0.345071, 1.142397, 1.007094, -0.449772, 0.693935, 1.188277, 0.145603, 1.001101, 0.923495, 0.918359, 0.486618, 0.019794, -0.135530, 0.674235, 0.527745, 0.186885, -0.312365, -0.449421, -0.319212, -0.414079, 0.169815, -0.345444, -0.225053, -0.151810, -0.060652, -0.140741, 0.093428, -0.282973, 0.867011, 0.037759, -0.537291, -0.099475, -0.204339, 0.062028, -0.012484, 0.038101, -0.374338, -0.721939, -0.434582, -0.434681, 0.048362, -0.227501, -0.025793, -0.085611, 0.685371, 0.412673, -0.214092, 0.523796, 0.299836, -0.212704, -0.127362, 0.145638, 0.020326, -0.374718, -0.593762, -0.019247, 0.040680, -0.013591, 0.609545, 0.749073, 0.312133, 0.450483, -0.564060, -1.196478, 0.188059, 0.212336, 0.160044, 0.081772, -0.376332, -0.426265, 0.060944, -0.326382, -0.236759, -0.413049, 0.357610, 0.478595, -0.307648, 0.307425, -0.615212, 0.335818, 0.989280, -0.017696, -0.267714, -0.221902, -0.121490, -0.047881, -0.028709, 0.066140, 1.509443, 0.298135, -0.432930, 0.290307, -0.488680, 0.009741, -0.237432, 0.283869, -0.093890, -0.423763, -0.631210, -0.182399, -0.409897, -0.417079, -0.056650, -0.132602, 0.953005, -0.069711, -0.259604, 0.397663, 0.005541, -0.375254, -0.062515, 0.091799, -0.569403, 1.091421, -0.584681, -1.091650, -0.157683, -0.039400, 0.202661, 1.269503, 0.283881, 0.465996, -0.145710, 0.263267, 0.783972, -0.769674, -1.381756, -0.346204, -0.857902, -1.003357, 0.232298, 0.137282, -0.878156, -0.481789, -0.255872, 0.305475, -0.550855, -0.317490, -0.236095, 0.844548, -0.704231, 0.118706, -0.315861, -0.570080, -0.003121, -0.088140, 0.421689, 0.179514, 0.373622, 0.225373, -0.483843, 0.358672, -0.240087, 0.054432, 0.308648, 0.390771, 0.040640, 0.452595, 0.285620, -0.158692, 0.786870, 0.036203, 0.637335, 0.182021, -0.613912, 0.292990, 0.373209, 0.319834, -0.568039, -0.201125, -0.591249, -0.350790, 0.100369, 0.067676, 0.309949, 0.101796, -0.579124, -0.040978, 0.082239, -0.283104, -0.266552, -0.221042, 0.471328, 0.775319, 0.359255, -0.215145, -0.339231, -0.421640, 0.045770, -0.224184, 0.698384, 0.378103, -0.565387, -0.158635, 0.271717, 0.604226, 0.031791, -0.602674, -0.430200, 0.624037, 0.213856, 0.043280, -0.324608, -0.492091, 0.348279, 0.240193, 0.315967, 0.237230, -0.000578, 0.294786, -0.548437, 0.287465, -0.510175, 0.262321, 0.032619, 0.290026, -0.026835, 0.320836, -0.110589, -0.096333, 0.705452, 0.417808, 1.437329, 0.136686, -0.231465, 0.474453, 0.502035, 0.406936, -0.452074, 0.012057, -0.491577, -0.058583, -0.413784, 0.159407, -0.418401, -0.353203, -0.167900, -0.300875, -0.405388, 0.028204, -0.090826, 0.852718, 0.074549, -0.161933, 0.319699, -0.683659, -1.249910, -0.730548, 0.186722, -0.561107, -0.768452, -0.289542, -0.622965, -0.555747, -0.257033, 0.768723, 0.660756, 1.151524, 0.916399, 0.729496, 0.405277, -0.236176, 0.115969, -0.078222, 0.391096, 0.525808, 0.607803, 1.549061, -0.038848, 0.304004, -0.286633, 0.662647, 0.142217, 0.154080, -0.068561, 0.487148, -0.117319, -0.302832, -0.260396, 0.236967, 0.091899, -0.336378, -0.478773, 0.277473, 0.129386, -0.342230, -0.488930, -0.284577, 0.013761, 0.044790, 0.003553, -0.454414, -0.012806, -0.123300, 0.137166, 0.198653, -0.131542, 0.515421, 0.225681, 0.003712, -0.177660, 0.200288, 0.050014, 0.145883, 0.061639, 0.008807, -0.009062, 0.159124, 0.088707, 0.157853, 0.047620, 0.155064, -0.100928, -0.086367, 0.399113, -0.367892, -0.714835, -0.040423, -0.292410, -0.127270, 0.499426, 0.460866, 0.535000, 0.381588, 0.570489, 0.421444, 0.317349, 1.386076, -0.272441, 0.108659, -0.038212, 0.801379, 0.370523, 0.236652, 0.345132, 0.340579, 0.142730, -0.413405, 0.514785, 0.055720, 0.397490, -0.062327, -0.361905, 0.261718, -0.261120, -0.167079, 0.084301, 0.185855, 0.013248, 0.259723, 0.051544, -0.379667, 0.053824, 0.550224, 0.493104, 1.066883, -0.945951, -1.435807, -0.718014, 0.360024, -0.485683, -0.265626, 0.180502, 0.329430, -0.172439, 0.529020, 0.642572, 0.039823, 0.403226, -0.391482, 0.510204, 1.485179, 0.476103, 0.641574, 1.447398, 0.839227, 0.690852, 1.126089, 1.374875, 0.587211, 0.688067, 0.328857, 0.094456, 0.797661, 0.220421, 0.086037, 0.548144, -0.287937, -0.020244, -0.051287, 0.198419, 0.337618, -0.316015, -1.230836, 0.667300, -0.077268, 0.303828, 0.081384, 0.401144, 0.030537, -0.593975, -0.122975, -0.137369, -0.439442, 0.226923, -0.277609, -0.398226, -0.490461, 0.208592, -0.347348, -0.452509, 0.111935, -0.337826, 0.528761, -0.131600, -0.091814, 0.335016, -0.041299, -0.178173, 0.463488, 0.082967, 0.116122, -0.090585, -0.030790, 0.243341, -0.373910, -0.636860, -0.245259, -0.449212, -0.330133, -0.142366, 0.200890, 0.460843, -0.074183, 0.086227, 0.280696, 0.198833, 0.095041, 0.116487, -0.021782, -0.035285, -0.190201, 0.516927, 1.469524, 0.355255, -0.024450, 0.989451, -0.150805, 0.136861, -0.169754, 0.479445, 0.725437, -0.573727, -1.024051, 0.807284, 0.046970, 0.650545, -0.279611, 0.932372, 0.335783, -0.545193, 0.162761, 0.094390, -0.104637, 0.126673, -0.793262, -0.530706, -0.643503, 0.023976, -0.211520, -0.575670, 0.286980, -0.167394, 1.658618, -1.944810, -2.973846, -2.041842, 0.210736, -0.569333, 0.308554, 0.151957, 4.109307, 2.009409, -2.939035, 1.528815, -1.400256, -0.469677, 1.760697, -0.807026, -3.963906, -4.366499, -1.087677, -0.156855, 2.204516, 0.290290, 0.346099, 0.944295, 0.455910, 0.816776, 0.184806, -2.122733, 0.670466, -0.136296, -0.741421, -0.582488, -0.410766, 1.955228, 0.741672, 0.448014, -0.484816, 1.584466, 1.341329, 0.083832, 6.096698, 0.194912, 1.385378, 0.317764, 1.629316, -1.095152, -0.834770, -0.168434, 0.291595, 2.100124, -0.604928, 0.150880, -1.025959, 0.908663, -0.459079, -0.578211, 1.218705, 0.479396, -0.641807, -0.567236, -0.816993, -1.305468, 1.255640, -1.299159, -0.113962, 1.297575, 0.856977, 1.746939, 2.291215, -0.291834, -3.623784, 0.506611, -0.903824, -0.840855, -0.320198, 0.360938, 1.552568, 0.454904, -1.082489, -0.772686, -0.109713, 0.838039, -0.003250, 1.574532, -0.371696, 0.662701, 0.674765, -1.373684, 1.813186, -0.117334, -0.664077, 1.048507, 0.324614, -0.164487, 1.563366, -0.669851, -0.401571, 0.435480, -0.048485, 0.004209, 1.163649, 0.158576, 1.529513, -0.109198, 0.516932, -1.675932, 0.964676, 0.655955, -0.600553, 1.060800, 0.416057, -1.158768, -1.478869, 0.123262, 1.030955, 0.345118, 0.359773, 0.048920, 1.163112, 0.671604, 1.705058, -0.831819, -1.886499, -0.464001, -0.649084, -0.142806, 0.236325, 1.072073, 1.880946, -0.322913, 1.061054, -2.046128, -0.066923, -0.039638, 1.157891, -0.226188, -0.198848, -0.317699, -0.452562, -0.464188, 0.039294, -0.176539, -0.815690, -0.334054, -0.557760, -1.226991, -1.268354, -0.396313, -0.693549, 0.266314, 0.068437, 2.396641, 4.742244, 0.584593, 2.468151, 0.677420, 0.179780, 3.591162, 2.488302, 1.308205, 0.626376, 1.802903, -0.757312, 0.795981, 1.505227, 0.933209, 2.212723, 2.388871, 1.867270, 2.762640, 1.070071, 0.623357, 1.832405, 0.473592, 0.119311, -0.047469, 0.150817, 0.080925, 0.983980, 0.452616, 0.698216, -1.187006, -0.857179, 1.328804, -0.642036, 0.141948, 0.267307, 0.303913, -0.730465, -0.184584, 0.896650, -0.278474, -0.506350, -1.090154, 0.043822, 0.370500, -0.480009, -0.340928, 1.256215, 1.185689, 0.306570, -0.663127, -0.283560, -0.011470, 0.890359, -1.011645, 0.065737, 0.058035, 0.020194, 0.120160, -0.235167, 1.146662, 2.501015, 1.270386, 1.971035, 0.894025, -0.188178, 2.485705, 2.567708, 1.347018, 0.599470, 1.104124, 0.064726, 0.398543, 2.001818, 0.456162, 2.138474, 1.931365, 1.333506, 1.725344, 0.477204, 0.032346, 1.228060, 1.552661, -0.326160, -0.127094, -0.078454, 0.199910, 0.439725, 0.640419, -0.634030, -1.596548, -1.066676, -1.520987, -2.686752, -2.483921, -1.832521, -0.391641, -0.603950, -0.987177, 0.985732, -0.522015, -0.724538, 0.422570, 0.226949, -0.587032, -0.114155, 0.741798, -1.474512, 1.247676, -0.855814, 0.459790, -0.822760, -0.368780, 0.050894, 0.782980, -0.545878, -1.237215, 0.695648, -0.531898, -0.217977, -0.479686, 0.496262, -0.195684, -0.545481, 0.138595, -0.095074, -0.170736, 0.189665, 0.291230, 0.358341, 0.111567, 0.106431, -0.463966, -0.328652, 0.007088, 0.565371, -0.551651, -0.013275, -0.392188, -0.095977, -0.211622, -0.261825, 0.416359, -0.900081, 0.249934, -0.288605, -0.037504, -0.341721, -0.009793, -0.118793, 0.275328, 0.376492, -0.148267, -0.111645, -0.187828, -0.000539, -0.582656, -0.243580, 0.211946, 0.566397, -0.030412, -0.237556, -0.142623, -0.561872, -0.323571, 0.311083, 0.162264, 0.422467, 0.102595, -0.556235, -0.094142, 0.549424, 0.166443, -0.168420, -0.047400, 0.420903, 0.390798, 0.010135, -0.574454, -0.466590, -0.349540, 0.174713, 0.142288, -0.681808, -0.321165, -0.299850, -0.106639, -0.132933, 0.214155, 0.210968, 0.570344, -0.240828, -0.401292, -0.327901, -0.212721, 0.840397, -0.037164, -0.294694, 0.024458, 0.051165, -0.034110, 0.040845, 0.078069, -0.388611, 0.203092, -0.313373, -0.325949, -0.242023, -0.858168, 0.501041, -0.651542, -0.237321, -0.172554, 0.617076, 0.515642, 0.119187, -0.032616, 0.800789, 0.740553, -0.129090, 0.549620, 1.001100, 0.296413, 0.683202, 1.067289, 1.099149, -0.020848, -0.298894, -0.090780, 0.314057, 0.297604, -0.159069, -0.371759, -0.634734, -0.126744, -0.709712, 0.130745, -0.055012, -0.216207, -0.395224, -0.277548, -0.341176, -0.517481, -0.370074, -0.334998, -0.469328, -0.223166, -0.738794, -0.606543, -0.425050, -0.547780, -0.601373, -0.360205, -0.518764, 0.096486, -0.170197, -0.406522, -0.307017, -0.203805, -0.273474, 0.537764, 0.477337, 0.272037, -0.086459, -0.101909, 0.306064, -0.529934, -0.084439, 0.142390, -0.024109, -0.126033, -0.334896, -0.471635, -0.029651, 0.357335, 0.164262, -0.085871, 0.131085, 0.117405, 0.361231, 0.025251, -0.078665, 0.248842, 0.095323, 0.398681, 0.000220, -0.364349, -0.362117, 0.025539, -0.032459, -0.019939, 0.167149, 0.269505, 0.192037, -0.052662, -0.475973, -0.418094, -0.107073, -0.178393, -0.252691, -0.313381, -0.300733, -0.284081, -0.220968, -0.190249, -0.362295, 0.070673, -0.570492, -0.482007, -0.483461, -0.525883, -0.570842, -0.099393, -0.203607, 0.146572, -0.111164, -0.244655, -0.271948, -0.014227, -0.651532, 0.698329, 0.221381, 0.182678, -0.286324, -0.110484, 0.232797, -0.486634, -0.185533, -0.043112, -0.978931, -0.145223, 1.077217, 0.857162, 0.559568, 0.155246, -0.032862, -0.655218, -0.653613, -0.392338, -0.434000, -1.921891, 0.392213, -0.055899, -1.255792, 0.120007, -0.374964, -0.168495, -0.530741, 0.501561, 1.282915, 0.501901, 1.390412, 1.262614, 0.826481, 1.215820, 0.254991, 1.567834, 1.190833, -0.192505, -0.407224, -0.348802, 0.171556, -0.387291, -0.410114, -0.254317, 0.752348, 0.088179, -0.099256, -0.210550, -0.210570, 0.479396, 0.366813, -0.565064, 0.086446, 0.217185, -0.102372, -0.321931, 0.081644, -0.373640, -0.310232, -0.347158, -0.033522, 0.267821, -0.076710, 0.247934, 0.053484, 0.331805, 0.283615, 0.149169, 0.107805, -0.152053, -0.459445, 0.016085, 0.292884, -0.384705, -0.252426, 0.378914, 0.423744, 0.270238, -0.222299, 0.131120, 0.025610, -0.027923, 0.009837, -0.070186, -0.021348, -0.412204, 0.243822, 0.310938, -0.159300, -0.027684, 0.148722, 0.106082, -0.104781, 0.131670, -0.165896, -0.465943, -0.260697, -0.481251, -0.542938, -0.137663, 0.263969, -0.177303, -0.218700, -0.068955, 0.238457, -0.172547, -0.020010, -0.065950, -0.178302, -0.185653, 0.425750, -0.341903, -0.182240, -0.071333, 0.153313, 0.312006, 0.228337, -0.439365, -0.286266, -0.112380, -0.093062, 0.413750, -0.082575, 0.131179, -0.241477, -0.070774, 0.170284, 0.424552, -0.378206, 0.293453, 0.677342, 0.100873, 1.091188, 0.325525, -0.864382, -0.068615, -1.529559, 0.439078, -0.981748, 1.593799, -0.614278, 0.886879, 0.226270, -0.008751, 1.001437, 0.575130, -0.605735, 0.453683, -0.251802, 0.257096, -1.485243, 0.601259, 0.279120, 0.656255, 1.499576, 0.232031, -0.219838, 2.757712, -0.179272, 0.474425, -0.769186, 0.475820, -0.503311, -0.252991, 1.812083, 0.742627, -0.421279, -0.944960, 0.012443, -1.193715, -0.992025, -0.118613, -1.481493, -1.751571, -0.109743, -0.244140, 0.392034, 0.379689, -1.667786, -1.547736, -1.639364, 1.060165, -1.278885, 1.563141, -1.355386, -0.284799, -0.508074, 4.492289, -1.326394, -1.849780, -0.448134, 1.326781, -1.409040, -1.212705, 1.300985, -1.201307, -1.362618, -2.679409, -0.970815, -0.134469, -0.247779, -1.215732, -0.120029, 0.926800, -0.103421, -0.226468, 0.991405, -1.402118, -0.543874, -1.013757, -0.880494, 0.023254, -0.598554, 0.934245, 0.588896, 1.223884, -1.071163, 2.599496, -0.519594, -0.370371, 0.226855, 2.358650, 0.949298, -0.830075, 2.086350, -0.220158, -0.233970, -0.397677, -0.708304, -1.718377, -0.268883, -0.003886, -0.774616, -1.482697, -0.637025, 0.105984, -0.798393, 0.077521, -1.517781, -1.279393, -1.096950, 0.941176, 0.323594, 0.840528, -1.139313, 1.491660, -0.935448, 0.363500, 0.594881, 1.276734, 0.017346, -1.024256, -1.119682, -0.020658, -1.688329, -1.187570, -0.267447, 1.984231, 1.131548, 0.224425, 0.817311, 1.060637, 1.210053, 0.425325, 1.550092, 0.088360, -1.811507, -1.900928, -2.353511, 0.037290, 1.581808, 1.705737, 1.616870, 1.167576, 2.468321, -1.121182, 0.651474, -0.014307, 0.906516, -1.033633, -0.100842, 2.880500, 3.775531, 1.066503, 1.704041, 0.036926, -0.717180, 0.252150, 0.062416, -1.390207, 0.812506, -0.638581, -1.896424, 0.091585, 0.627279, -0.718113, 0.697459, 1.144236, 0.325404, -0.011908, 2.359916, 2.398797, 1.131042, 0.626313, 2.167130, -1.246908, 2.076638, 0.748980, 1.635403, -0.331168, -1.131350, -1.851808, -3.472056, -0.937710, 0.692655, 1.290931, -0.131054, -1.042351, -0.158064, 0.982609, -1.217912, -0.480600, -0.285359, 0.472048, -0.203228, 2.834992, 0.263705, -0.196754, -0.402707, 0.812940, 1.724457, 2.436677, 0.354608, -0.572256, -0.201844, -1.097022, -0.440984, 0.019263, 0.580508, 0.047240, 0.279645, 3.025084, 4.549909, 1.169825, -0.274083, -1.444116, -0.767405, 0.262484, 0.861757, -1.020192, 1.137540, 0.112811, -1.019718, 0.603555, 0.732747, 0.485854, 0.161144, 0.364912, 0.300516, 0.365484, 0.174689, 2.085739, 1.202392, 1.632950, -0.138911, 0.092942, 0.828738, -0.016261, 0.419718, 0.664171, 1.191077, -1.008230, -1.428403, -0.673021, 0.110737, -0.317766, -0.070795, -0.629472, 0.914636, -0.395143, 0.691467, 0.924500, -0.639340, 0.917245, -0.991019, 0.051326, 2.135645, 0.698512, 1.451326, 1.641147, 1.010956, 0.648358, 1.089252, 1.603475, 0.628321, 0.899010, 0.780374, 0.214442, 1.879577, -0.703484, 0.015814, 0.137041, 0.066625, -0.105226, -0.158580, 0.113191, 0.012387, 0.424891, 0.147104, -0.177668, 0.186723, -0.713335, 1.096944, -0.637583, -0.517385, 0.003426, 0.529771, -0.652372, 0.398484, 0.257075, -0.416915, -0.608808, -0.127469, -0.157035, 1.123482, 0.805472, 1.271885, 0.404820, 0.433651, -0.200169, -0.403814, -0.437126, -0.156763, 0.434779, 0.109106, 0.067454, 0.671004, 0.351295, 0.307031, -0.493840, -0.487025, -0.476465, 0.741686, 0.470515, -0.506713, -0.516222, 0.064341, -0.673893, -0.690705, 0.741350, -0.011242, -0.383136, -0.045458, 0.184960, 0.074799, -0.298574, -0.215584, 0.579573, 2.594544, -0.477162, 0.197341, 0.178799, 0.253828, 0.120550, -0.137938, 0.047630, 0.017106, 0.817257, 0.328562, -0.066590, -0.522609, -1.126834, 0.891241, -0.032832, -0.316907, 0.113189, 0.442750, -0.881885, 0.435232, 0.726595, -0.491024, -0.568002, -0.133800, 0.330755, 0.339006, 1.067897, 0.881598, -0.536709, 0.350187, 0.161530, -0.117843, 0.458656, 0.790368, 0.315530, 0.378052, -0.544117, -0.808027, -0.553247, -0.607309, 0.083292, -0.173262, -0.005301, 0.603689, 0.221598, -0.183141, 0.180295, 0.126602, 0.080808, -0.115394, 0.246672, -0.000537, -0.664458, -0.874067, -0.771515, -0.328231, -0.580132, -0.696421, -0.301369, -0.439882, -0.559328, -0.333407, -0.430625, -0.047024, 0.066162, -0.438546, 0.017174, -0.154600, -0.132996, -0.207691, -0.567399, -0.176071, 0.376205, 0.077042, 1.290734, 0.413979, 0.358475, 0.618176, 0.529886, 0.068353, -0.292560, -0.721375, -0.027400, 0.310200, -0.022242, -0.124071, -0.635365, 1.133646, 0.140632, 0.152882, 0.055898, 0.046943, -0.301778, -0.275176, 0.280534, 0.395212, 0.400425, 0.160304, -0.370405, -0.112555, 0.099881, -0.105016, -0.230675, -0.061505, 0.327945, 0.784699, 0.005980, -0.594725, -0.498976, 0.122550, -0.120346, -0.014857, -0.099454, 0.080752, 0.034739, 0.075356, -0.306502, 0.384136, -0.249428, -0.266081, -0.342309, -0.176351, 0.031264, -0.266114, 0.020657, -0.508210, -0.068265, -0.390004, -0.090730, -0.010029, -0.522222, -0.267044, 0.080721, 0.148705, 1.317776, 0.057365, 0.138787, 0.377347, 0.223716, 0.284505, -0.184781, -0.347229, -0.164450, 0.037572, -0.176556, 0.422532, -0.743309, 1.010127, -0.482724, -0.076096, -0.632549, 0.201108, 0.957935, 0.810657, 0.491183, 0.582216, 0.306216, 0.592814, 1.272170, 0.260836, -0.613115, 0.708468, 0.858111, -0.011919, 1.130661, 0.864872, 0.010895, 0.102435, 0.015588, 1.263430, -0.211592, -0.007992, 0.632489, -0.441987, 0.133581, -0.568027, 0.759639, 0.928537, 0.280904, 0.146677, 0.299457, -0.031020, 0.308788, 0.402269, -0.365292, 0.406011, -0.214223, -0.325169, 0.077304, -0.378588, 0.101799, -0.103757, -0.280912, 1.584374, -0.190896, 0.101449, -0.409719, -0.037917, -0.134130, -0.200778, -0.145336, -0.080662, -0.080438, 0.050521, 0.265198, -0.094727, 0.216994, 0.058043, -0.011277, -0.229600, 0.115593, -0.088801, 0.201487, -0.237131, 0.297237, 0.275969, -0.082901, -0.037890, 0.575885, -0.186607, -0.074944, 0.111773, -0.269571, 0.142961, 0.110410, -0.333939, 0.127769, 0.333609, -0.257267, -0.135752, -0.006547, -0.337506, 0.097753, 0.097864, -0.067254, 0.097030, 0.130693, -0.407002, 0.677876, 0.386541, 0.401095, -0.261087, 0.315275, 0.444909, -0.097143, 0.882645, 0.117568, -0.447221, 0.325929, -0.434924, 0.471137, -0.101042, -0.333735, 2.569933, -0.247375, 0.138313, 0.002377, 0.174544, -0.164774, -0.141858, -0.250375, -0.175873, -0.233804, 0.105365, 0.099845, -0.659710, 0.010555, -0.080839, -0.319930, -2.176190, 3.412498, -2.327090, 1.161977, 1.020144, -0.104091, 1.330456, -0.037586, 0.582334, 0.599948, -0.546018, 2.036690, -0.449735, 0.715492, 0.014697, -0.455345, 0.138641, -1.535522, 0.382115, -1.128188, -1.709891, -0.261583, -0.754338, -0.214957, 0.408712, -0.788439, -0.414465, -0.895938, -0.111379, -0.239437, 1.275573, 2.253360, 3.063827, 1.928926, 0.878545, 1.753763, -0.603108, 1.054430, 0.424194, -1.226602, -2.030575, 1.172706, -0.173208, 0.542611, 0.555838, -0.566084, 1.227391, -0.143049, -0.353486, 0.623741, 0.342854, 1.914771, 0.522331, -0.118286, -0.740352, 0.471787, -1.110937, 0.473094, 0.683748, -0.734121, 2.118413, -1.863154, 1.972179, -1.149233, 1.460156, 1.050039, 0.008216, 1.482525, 0.922506, -0.954134, 0.100672, -0.744741, -1.456981, -0.482144, -0.511525, -1.256580, 0.735057, 0.196138, -0.477501, -1.512115, -1.324668, 0.656005, 0.191539, 0.431310, 1.467102, 0.587920, -0.260827, -0.461890, 0.171141, -0.557166, 0.103022, -0.627612, -0.722959, 0.906540, 0.760405, -0.012773, -1.219437, 0.702820, 1.014789, -0.591338, -1.492554, 0.283456, -0.776955, -0.239607, 0.427988, -0.864882, 0.173131, 0.991872, -0.366984, 2.559936, -0.611737, 1.078718, 0.279214, -0.334606, 0.185004, 0.670100, -1.139111, -0.644750, 0.562557, 0.146896, -0.957791, 0.795308, 0.421121, 0.354415, 0.661778, 1.108310, -0.606345, -0.459545, -0.933611, 0.029085, 0.106995, 0.464988, 0.032201, 0.936121, 0.401960, -0.162200, 0.112556, -0.053367, -0.291316, 0.150575, -0.348063, 0.233803, -0.665770, 0.011359, -0.440460, -0.113423, 0.583744, -0.216409, -0.012057, -0.176366, -0.248726, 0.057131, 0.107485, -0.194475, -0.255374, 0.747725, 0.397327, -0.258405, -0.497366, 0.454689, -0.342834, -0.524462, 0.414999, -0.482538, -0.584649, -0.253730, -0.037161, -0.046684, -0.116954, 0.010025, -0.002316, 0.795164, 0.119618, -0.370734, -0.072173, -0.360958, 0.562736, -0.042996, 0.364281, -0.057589, -0.216661, -0.085300, 0.195365, 0.440525, 0.224670, -0.199985, -0.380898, 0.184902, 0.148008, -0.381708, -0.299411, 0.166542, 0.244073, -0.242699, -0.135286, 0.184314, 0.179292, 0.037314, -0.203209, -0.246802, -0.198704, 0.051857, -0.315139, 0.158622, 0.016343, -0.031096, 0.168371, 0.117058, 0.782914, -0.370517, -0.499397, -0.168712, 0.014237, -0.335705, -0.314794, 0.712946, -0.275005, -0.430932, -0.511728, -0.035297, -0.074367, -0.335142, 0.442150, -0.464293, -0.412005, -0.382937, -0.251775, 0.054383, -0.422357, 0.020707, -0.172564, 0.576327, 0.223465, -0.271712, -0.410903, -0.427544, 0.244644, -0.019680, 0.145672, 0.355336, -3.143464, 3.436203, -0.899311, 1.015190, 1.077470, 0.037060, 1.179049, -3.909764, -0.059667, -1.838026, 0.341902, 1.492206, -0.755778, 0.822333, 0.167864, -0.385003, 1.021560, -0.575807, 2.852849, -1.259683, 0.066329, 1.607046, -2.543033, 1.226120, -3.265809, -1.694358, 0.480605, -2.980243, 2.882251, -0.009424, 0.854690, 1.578594, 1.569301, 1.643404, -0.257460, 1.449538, 2.741229, 4.245250, -0.811828, 1.160763, -0.790136, -0.063142, -0.223952, 0.481601, -1.114998, -1.918203, -1.490913, 2.452603, 0.080147, 2.484214, 1.703481, 0.247443, -0.807575, -0.095142, -0.317006, -0.530868, 0.117731, 1.648770, 1.022493, -0.773658, 1.388276, -1.357072, 0.464646, -0.333000, -0.835704, 0.414984, -2.471735, 3.597702, 1.508439, -0.925063, -1.007004, -0.556421, 1.327302, 0.623843, 0.950169, 0.827953, -1.768874, -0.689906, 0.777698, 1.869652, -1.247752, 1.121932, 2.196338, -0.943817, -0.470901, 0.527240, -0.321957, 1.846358, 0.611146, -0.727056, -0.059572, 0.987627, 0.203786, -0.133422, -0.411781, -0.027677, 2.643314, 2.867877, -0.862041, 1.138978, -1.056505, -0.859965, -1.201143, 0.495813, 0.385776, -1.320187, -1.868716, 1.464398, 0.455669, 1.332595, 0.330407, -0.152051, -1.505393, -0.364844, -0.908458, -0.199359, -0.896840, 0.826130, 1.696469, 1.420185, -0.621582, -1.507830, -0.045075, -0.314097, -0.065568, -0.569221, -0.386568, -0.911972, -0.188830, -0.137306, -0.899562, -0.040593, 0.288081, 0.545957, 0.089072, 0.851855, -0.327101, 0.495949, 0.626118, 0.200882, 1.026019, 0.167093, 0.597279, 0.708762, -0.192072, 0.875308, -0.400395, 0.856257, 0.405877, 7.051060, 2.022454, 2.625812, 4.017099, 2.084208, 1.791900, 0.948384, 1.936199, 0.695451, 0.119871, 0.489587, 0.283422, -0.501231, 0.602547, 0.177742, 0.594730, 0.080163, 0.403649, 0.493894, -0.595325, -0.454635, -0.329287, 0.076183, 0.372305, 0.660244, -0.204250, 0.124119, -0.519740, -0.067075, 0.867978, -7.713629, 0.747115, 1.581290, 2.070174, 1.120090, 1.190915, 1.382209, 0.645569, 0.624686, 1.424379, 0.814239, 0.731777, 0.401034, 2.091863, 0.771127, 0.542526, 0.700249, 1.160938, 0.285007, 0.721803, 0.537590, 0.712074, -0.312141, 0.543733, -0.416784, -0.286280, 0.687144, 0.252524, -0.092381, 0.776663, 6.981308, 1.023365, 1.820184, 3.439018, 1.388795, 1.657975, 0.824537, 1.462214, 0.727134, 0.772811, 1.005834, 0.627562, -0.263416, 0.836874, 0.546080, 0.242531, -0.109604, 1.083826, 0.966468, 0.155285, 0.227822, -0.683534, -0.155969, 0.420090, 1.225997, -0.448164, -0.399693, -0.144471, 0.358022, 0.934670, -0.566130, 0.510609, 0.504886, -0.360455, 0.084008, 0.578607, 0.555809, 0.205481, -0.261009, -0.485095, -0.857961, -0.454892, 0.157356, -0.212817, 0.189157, 0.445859, 0.173670, -0.310571, 0.190520, 0.221238, 0.254237, -0.352511, 0.254157, 0.160967, -0.685668, -0.341761, -0.842892, -0.228742, -0.671691, -0.460025, -0.361324, -0.625681, -0.222328, 0.077109, 0.126903, -0.720286, -0.005017, -0.963847, -0.397287, -0.311869, -0.220271, 0.012670, -0.466821, 0.119869, 0.241992, -0.026039, 0.173604, 0.461685, -0.066997, 0.188901, -0.045075, 0.184135, 0.477193, -0.004383, 0.230602, 0.032909, -0.175938, -0.173769, 0.531621, 0.304732, -0.021574, 0.327327, 0.158616, 0.341898, 0.187228, 0.064489, -0.164793, -0.024005, -0.287303, -0.730241, -0.743584, 0.149637, 0.041539, 0.617137, 1.161194, 0.279765, -0.602292, -0.315153, 0.022139, 0.480954, 0.786507, 0.427254, -0.130179, -0.696853, 0.016943, -0.158079, 0.465146, -0.154984, -0.946379, -0.094964, -0.455991, -0.605900, -0.235021, -0.124751, 0.240249, -0.663722, -0.187295, -0.605219, -0.271395, -0.457050, 0.166782, -0.056191, -0.690850, 0.388984, 0.552868, -0.114342, -0.315555, -0.225886, -0.208070, 0.225931, -0.286372, -0.149425, 0.491164, -0.064390, 0.242453, -0.370942, -0.028702, -0.224863, 0.912344, -0.120742, 0.697845, 1.316947, 2.225768, 0.443864, -3.051904, -0.681883, -3.046381, -1.178510, 1.641469, 0.734604, 5.073540, 3.930284, 0.491934, -0.018653, -2.927828, -2.258956, -4.092634, -3.012355, -0.328283, 0.142100, 4.390007, 0.484043, 0.997164, 1.073687, -0.962057, 0.938008, -2.935394, -2.455046, -0.128479, -1.230645, -0.277951, 0.339684, 0.891576, -0.251893, 0.880696, 1.751849, 1.223675, 0.344296, -0.729163, 1.372013, 1.370883, 1.347685, 0.215848, -1.033001, 0.114212, 1.252559, 1.013947, 1.195899, 1.006495, 1.804352, 0.864753, 1.173270, 2.018575, 0.620946, -0.365562, 0.670587, 1.352845, -1.136959, -0.118054, 0.271581, -0.187322, -0.463819, -0.182704, 0.491968, 0.104176, -0.719168, -1.101062, 0.559777, 1.290968, 0.070583, -0.289210, 0.385354, -0.267388, 0.148045, -0.575676, 0.577904, -0.551903, 1.138093, -1.083995, 0.067662, 0.608335, 0.198770, 0.829831, -0.323793, -0.368732, 0.952374, 0.903376, 0.841512, 1.102725, -1.146678, -0.538561, 0.014692, 0.145674, 0.405287, -0.468363, 1.703865, 1.403859, 0.761321, -0.096423, 0.797192, 1.263122, 1.437142, -0.218067, 0.300336, -0.640789, 0.539546, 0.507592, -0.343704, 0.859147, 0.228195, 0.193874, 0.774454, -0.107130, 0.254401, 0.137425, 1.200132, 1.250081, 0.164948, -0.441696, 0.581669, -0.695814, 0.762362, 0.337484, -0.229730, 0.508586, 0.829257, 0.163300, 0.599705, -0.338419, -0.675286, -0.292580, -0.332041, 0.215298, -0.421184, -0.210692, 0.332436, -0.019835, -0.533599, 0.378867, -0.408068, 0.063513, -0.546065, 0.154608, 0.075739, -0.570743, -0.727838, -0.769732, -0.190525, -0.529149, -0.328934, -0.431694, -0.618858, -0.303895, -0.556024, -0.399594, -0.497786, -0.555614, 0.025771, -0.377974, 0.460541, -0.071267, 0.298726, -0.942462, 0.226654, 0.374353, -0.450399, 0.214071, 1.387063, 0.427188, 0.774073, 0.043506, -0.380817, 0.075196, 0.022308, 0.081829, 0.126444, 0.458651, 0.363531, 0.332202, -0.333180, 0.200798, 0.286536, -0.322135, -0.078600, -0.201625, 0.409515, -0.446311, -0.237827, 0.109489, 0.599786, -0.000317, -0.351454, 0.178318, -0.257828, 0.425148, 0.609807, -0.098142, -0.557644, 0.290543, 0.061635, -0.125813, -0.458256, 0.085832, -0.448092, -0.151286, -0.224896, -0.128425, -0.199201, -0.029332, 0.278455, -0.442541, -0.588431, -0.061257, -0.352025, -0.223510, -0.420962, -0.405985, 0.360997, 0.083763, 0.601889, -0.081473, 0.154369, -0.437176, 0.065496, 0.210048, -0.300040, -0.161148, 0.745271, 0.190652, 0.546993, 0.030818, -0.457175, -0.204896, 0.055344, -0.360907, -0.314040, 0.204546, 0.221949, 0.570859, -0.243575, 0.866632, 0.100943, -0.127986, -0.702787, -0.501993, 0.071057, -0.540975, -0.050063, 0.535745, 0.011330, -0.121859, -1.584234, 1.656541, -2.425795, 0.704540, 0.929643, -2.026911, -1.453490, -1.681233, -1.348472, -0.714695, -2.199534, -2.002234, -1.492036, -2.351561, -1.436020, -0.933443, -0.939824, -1.164384, -1.834951, -0.540736, -0.833386, -0.374089, -0.299384, -0.419206, 0.402659, -0.267585, -0.049309, -0.089739, -0.102100, -0.353055, -0.233672, -0.024539, -0.502377, -0.259157, -0.437653, -0.239676, -0.128970, -0.121217, 0.259100, 0.026179, -0.108768, -0.234363, -0.426255, 0.472521, -0.252142, -0.038857, -0.545296, -0.366518, -0.200207, 0.151311, 0.184578, -0.202440, -0.187997, -0.123848, 0.108332, -0.396267, -0.292063, -0.529130, 0.007401, 0.381444, 0.395695, 0.432182, 0.313657, 0.258506, -0.089120, -0.161766, 0.255055, 0.050851, -0.541581, -0.265671, 0.370916, -0.239050, -0.046522, 0.742326, 0.051056, -0.132943, -0.479162, 0.167423, 0.211901, -0.527449, -0.779377, -0.251962, -0.267098, -0.326616, 0.421580, -0.421039, 0.228534, -0.141391, 0.054557, -0.306862, -0.435568, -0.323938, -0.338562, -0.022678, -0.623905, -0.159714, -0.230288, 0.219496, 0.068813, 0.141687, -0.006359, 0.102565, -0.329970, 0.190475, -0.218419, 0.182494, -0.318347, -0.523746, -0.212902, -0.505154, 1.106988, -0.445381, -0.503991, -1.652735, -0.751382, 0.053558, -0.239890, 1.359982, 2.883297, 1.914022, 1.226268, 1.333529, -0.814499, -1.323478, -0.064416, -1.666677, -0.348994, 4.399295, 2.884532, 2.715943, 1.461360, -0.768860, -2.335473, -0.136073, -2.996725, -2.704647, 0.152903, -0.663070, -0.377429, -0.427384, -0.583425, -1.046427, 1.277900, 1.884606, 1.821118, 0.656554, -0.071728, 0.041304, 1.369592, 0.637686, -1.487759, 1.587463, -0.752662, 1.850067, 2.070976, -1.251484, -0.725831, 0.896548, 1.235134, 0.367154, 0.632977, 0.058979, 0.347716, -1.525844, -1.317753, 0.892136, 0.441523, 1.866691, -0.976738, 0.020221, 0.527495, 1.242335, 1.550318, -0.294802, -0.095622, 1.975632, 0.103852, 1.346927, -0.335999, -0.220821, 0.197301, 1.369773, 1.303890, 1.260059, -1.009128, -0.656445, -0.057838, 2.915402, 0.657434, -1.920802, -2.076921, -0.081440, -1.143308, -0.507829, -0.894088, -0.558370, 0.815090, 2.496573, 0.290596, -0.132578, -0.248879, 0.468667, 0.903335, 0.895314, 0.448227, 1.259069, 0.094174, 0.980011, 2.370036, 0.475817, -0.774132, 2.273440, -0.323320, 2.703733, 2.958840, -1.076741, 1.320213, -0.191404, 0.295532, -0.614940, -0.801037, 0.332306, -0.322824, -0.375481, -0.241655, -1.483354, 1.117327, 1.555259, 0.387533, -0.770673, 1.188776, -0.407002, -0.973595, 0.356018, -0.079442, 0.308007, 1.110565, 0.387519, 0.398557, -0.195327, 0.318573, 0.949296, -1.098878, -1.792541, -0.857328, -0.631260, -0.538594, 0.585684, -0.450249, -1.412870, -0.624891, -0.760582, 1.080930, -0.019883, 0.121418, 0.060693, 1.208753, -0.404759, 0.050840, -0.344946, -0.486517, -0.264483, -0.547139, -0.108193, 0.215098, -0.087671, -0.398656, -0.345032, 0.354818, -0.237277, 0.523448, 0.100781, -0.303321, 0.611401, 0.779500, -0.351722, -0.205236, 0.040859, -0.126944, -0.132048, 0.070550, -0.830123, 0.420380, -0.380727, 0.004104, 0.060460, -0.682092, -0.345626, -0.131613, -0.174353, -0.116907, 0.191951, 0.424449, 0.111780, -0.120605, 0.258330, 0.468624, 0.132760, -0.139210, 0.464027, -0.460922, -0.994107, -0.363711, 0.466866, 0.966422, 0.119584, -0.417362, -0.346921, 0.427847, 0.024415, -0.131408, -0.154549, -0.395761, -0.203407, -0.079056, -0.097332, -0.430304, -0.351708, 0.040870, -0.430285, -0.514032, -0.008448, -0.704206, -0.126269, -0.006160, 0.122828, -0.006020, 0.009597, 0.578370, -0.545128, 0.423845, -0.124109, -0.155643, 0.220969, 0.775523, -0.313873, -0.189437, -0.085128, 0.048815, -0.128023, 0.028706, -0.570618, 0.549234, -0.280070, 0.114982, 0.103770, -0.334045, -0.295813, 0.087143, -0.746749, 0.691699, -0.244894, -0.555215, -0.128713, 0.262838, 0.009732, 0.105069, 0.139178, 0.818601, -0.266332, -0.126425, 0.465788, 0.257129, -0.134707, 0.465065, 0.377584, 0.463806, 0.750082, 0.117525, -0.005231, -0.229503, 0.291386, 0.390523, -0.081679, -0.332301, -0.567026, 0.598798, -0.126278, 0.161711, -0.228566, -0.445720, -0.252126, -0.486295, -0.458424, -0.200803, -0.255755, 0.446067, 0.072575, -0.098221, -0.663989, 0.889496, 0.876887, -0.550546, -0.967195, -0.069192, -0.128909, -0.617658, 0.237124, 0.480943, 0.543594, 1.164853, -0.660129, 0.226608, -0.364235, -0.287793, 0.018345, -0.106207, 0.149226, -0.464963, -0.133098, 0.369648, -0.669939, -0.718134, -0.128555, 0.663480, -0.254364, -0.708640, -1.400305, -0.165824, 0.605017, 0.603940, -0.085897, 0.401511, 0.197068, 0.127312, -0.632817, -0.714449, -0.032206, -0.007062, 1.187078, -0.283701, 0.874492, 0.498094, 0.109970, -0.451528, -0.589523, 0.260740, 0.298377, -0.132247, -0.235222, -0.209435, -0.240760, -0.534364, -0.525857, 0.056482, 0.168366, -0.324372, 0.375149, -0.015565, -0.753822, 0.940800, 1.283296, -0.490651, -0.794236, 0.246678, -0.443220, -0.069129, -0.132810, 0.436153, 0.266304, 0.273239, -0.071772, 0.228866, -0.806680, -0.161607, -0.246197, -0.119516, 0.202778, -0.837653, -0.949742, 0.592804, -0.743700, -0.629684, -0.668275, 0.257222, 0.552338, -0.133840, -0.190597, 1.449797, 0.743573, -0.240433, 0.912749, 1.088213, 0.333116, 0.864259, 1.043452, 1.465746, 0.361098, -0.085952, -0.101823, 0.600675, 0.379708, -0.042408, -0.072023, -0.491432, -0.105880, -0.452590, 0.198178, 0.105083, -0.321914, -0.575473, -0.103862, -0.076336, -1.110965, -0.402125, -0.313627, -0.373451, -0.525879, -0.796817, -0.342265, -0.175650, 0.038778, -0.227448, 0.184812, -0.067456, 0.200610, -0.632160, 0.348825, -0.435375, -0.804295, 0.171583, -0.109919, 0.121144, 0.171243, 0.223959, 0.431278, -0.447479, -0.284217, -0.442444, -0.457455, -0.352638, 0.026054, 0.166348, 0.073756, 0.172586, 0.227559, 0.205857, 0.466656, 0.791740, 0.502331, 0.032985, -0.003197, -0.151935, 0.031574, -0.106135, -0.151543, -0.201139, 0.533398, 0.254527, -0.313290, 0.843803, 0.348958, -0.362379, -0.419120, -0.371060, -0.429765, 0.120060, 0.697093, -0.277083, -0.366664, -0.474205, -0.092021, -0.179149, -0.709799, -0.414459, -0.121175, -0.164386, -0.279130, -0.717054, -0.183701, -0.136051, -0.252814, 0.004691, 0.201210, 0.104911, 0.434201, -0.433873, 0.115436, -0.335318, -0.529239, -0.015879, -0.398456, -0.242032, 0.334223, 0.082913, 0.144330, -0.273995, -0.396776, -0.658193, -0.685962, 0.851345, -0.392592, -1.115162, 0.133673, -0.392364, -0.011173, 0.598754, 0.736259, 1.217004, 0.608352, 0.494736, 1.015556, -0.462360, -1.610757, -0.770797, -1.316379, -0.694407, -0.054980, -0.496737, -1.440220, -0.035213, -0.754040, 0.622463, -0.112790, 0.351815, -0.205766, 1.002860, -0.224128, 0.202052, -0.429820, -0.571622, -0.223157, 0.221097, -0.616702, -0.421494, -0.488989, -0.915157, -0.195160, 0.263317, -0.173957, 0.486845, -0.070101, -0.050366, 0.155776, 0.168986, 0.006362, -0.390133, -0.378305, -0.124610, -0.422901, -0.336267, 0.015415, -0.208653, -1.077352, 0.348016, -0.358733, -0.165293, 0.130481, 0.063598, -0.073923, 0.323674, 0.437168, 0.185521, -0.135890, -0.334004, -0.211051, -0.401097, 0.180117, 0.457005, 0.152382, -0.178044, 0.369910, 0.032232, 0.078647, -0.047103, -1.049303, -0.565974, -0.191029, -0.083844, 0.132938, 0.071222, 0.706145, 0.273145, -0.001854, 0.357542, 0.270675, -0.100839, 0.400339, -0.206614, -0.531867, -0.550382, -0.097520, 0.196725, -0.265253, -0.086460, -0.338457, -0.639937, -0.218560, -0.262088, -0.288864, 0.082563, -0.019591, -0.038897, 0.053461, -0.098444, 0.231754, -0.443125, -0.469634, 0.060552, -0.490283, 0.132828, 0.285418, 0.371725, -0.840298, 0.351854, -0.474496, -0.001821, -0.030745, -0.206231, -0.680359, 0.878305, -0.415164, -0.902789, -0.103915, -0.354254, 0.041290, 0.515832, 0.626958, 1.488293, 0.353945, 0.086945, 0.610104, -0.364584, -1.342769, -1.177495, -1.064534, -0.279370, 0.239575, -0.533536, -0.952136, -0.408077, -1.002057, 0.196965, -0.065162, 0.383452, 0.060403, 1.032528, 0.020391, 0.360645, -0.400985, -0.488649, 0.127495, 0.126205, 0.011177, -0.378517, -0.699766, 0.242754, -0.510100, -0.485807, -0.292306, -0.105814, -0.415096, 0.304722, 0.203925, 0.089320, -0.218642, -0.329325, 0.065745, 0.479393, 0.261360, 0.095545, -0.419559, -0.410443, -0.068862, 0.195299, 0.052205, -0.707646, -0.815446, -0.030055, 0.003886, 0.078626, -0.010004, 0.102898, 0.352501, 0.140419, 0.016765, -0.041718, -0.033361, -0.015504, -0.010734, 0.383016, -0.074790, -0.357939, -0.457659, -0.437021, -0.057908, 0.153950, 0.009149, -0.465093, 0.369529, 0.147942, 0.037032, 0.151265, -0.094577, -0.128893, -0.080517, 0.081538, 0.080742, -0.140119, -0.475251, -0.471307, 0.193849, -0.047642, 0.277552, -0.368196, -0.533833, -0.069411, -0.491037, -0.294135, -0.247680, -0.301455, -0.600374, 0.046118, 0.057338, -0.033361, -0.041358, -0.461986, -0.339808, 0.686177, 0.336176, 0.101781, -0.278027, -0.262562, -0.177429, -0.249950, 0.004958, -0.537704, -0.608668, 0.079753, 2.865561, -1.204735, -1.146073, -0.588917, -1.461068, -0.345099, -0.345205, -1.083778, -0.869367, -0.166656, 0.332887, -0.954107, 0.215673, 0.024467, 0.274450, 0.275563, -0.000944, -0.547460, 0.035233, 0.999130, 0.309825, 0.818464, 0.296782, 0.255867, 0.393365, 0.073855, 0.054914, 0.431372, 0.033821, -1.367526, 8.719196, 2.666626, 3.064080, 3.657724, 1.681193, 1.021332, 2.637551, 0.063431, 1.317204, 0.123073, -0.293851, 1.215963, 0.378008, 0.710265, 0.008425, 0.888172, -1.051397, 0.355125, 0.352040, -1.115301, -1.226053, -0.351029, -1.502511, -0.264953, -1.068522, -1.254227, -1.209866, -1.091669, -0.962882, -0.778990, -3.064348, 0.571395, 0.558034, -0.051304, -1.357424, 0.459997, 0.869965, -0.494721, -0.639129, 0.426260, 1.103593, 1.122175, 0.679121, 0.303041, -0.721554, -0.392115, -0.336245, -0.017450, 0.500661, 0.302567, 0.247103, -0.589331, 0.512918, 1.346364, 0.723833, -0.525350, 0.270049, 0.185554, 0.204190, 0.714326, 8.017619, 1.010234, 1.593777, 3.269455, 1.944391, 0.612038, 1.367923, 0.564232, 1.779065, -0.195141, 0.050709, 1.215615, 1.769606, 2.099152, 0.213415, 0.913982, -0.303838, 1.447078, -0.112524, -0.675294, -0.261031, 0.475704, -0.926777, 0.248667, -0.833728, -1.065747, -0.976036, -0.803334, -1.338882, -0.113311, 4.531963, -0.705895, -1.769440, -1.090021, -1.997239, -1.299631, -1.190563, -1.609673, -1.296915, 0.039384, -0.421988, -1.607599, -0.047594, -0.679934, -0.577816, -0.050004, 0.248506, 0.257749, 0.318133, 0.251627, 0.294240, 0.704372, -0.578333, -0.068111, 0.344974, 0.476431, -0.306425, -0.965496, -0.481098, -1.674407, 8.114284, 4.868337, 1.678181, 4.841803, 0.930852, -1.128601, 0.154926, 0.692732, 0.843667, -0.536601, 1.182552, 1.799489, -0.044111, -0.656541, -1.552471, -0.316527, -0.122038, 0.970191, 0.413396, -1.360293, -0.637564, -0.012252, -0.481538, 0.398615, 1.643512, 0.100758, 1.118505, -0.890732, -0.724762, -2.686497, -9.390576, 1.763955, 2.385797, 3.609779, 1.522474, 0.726094, 1.152267, 1.630296, 2.148254, 1.189508, 1.415220, 1.092633, -0.159973, 0.891712, 0.373996, 0.566081, -0.237562, 0.750114, 0.530994, 0.439760, -1.654468, -2.381883, 1.250924, 0.640880, -1.279116, 0.758424, -0.448772, -0.797674, -2.407620, -0.166049, 9.661210, 5.361369, 4.420248, 3.460263, 0.117883, -0.365323, 0.734614, 2.230387, 0.852926, -0.059180, 2.126795, 2.677320, -0.990816, 0.614303, -0.379745, -0.759574, -0.636417, 1.322869, -0.317545, -0.468497, 0.243810, 2.281150, 1.685899, 2.605693, 1.917002, 0.370591, -0.538401, -0.195104, 0.158731, -1.709596, -0.430572, 0.457768, 0.160251, 0.237038, 0.507667, 0.885264, 0.645605, 0.949935, 1.064631, 0.101727, 0.011694, 0.135359, 0.101668, 0.205189, 0.314436, 0.192832, 0.717570, 0.688718, 0.205882, -0.417685, -0.512714, -0.430048, -0.686157, -0.868119, -0.783807, -1.195218, -1.073009, -0.786182, -0.828171, -0.306407, -0.129642, -0.044754, -0.455055, -0.304195, -0.801824, -0.204322, -0.109005, 0.102499, 0.185091, -0.622099, 0.192665, 0.091994, -0.025494, 0.119100, 0.281775, -0.709028, 0.587905, -0.442596, 0.130811, 0.049939, -0.314929, -0.390490, -1.210965, 0.091005, 0.101192, 0.148591, -0.198471, 0.229221, 0.575453, -0.070218, 0.692158, -0.398067, 0.040342, 0.067490, -0.153472, -0.345175, -0.787727, -0.405677, 0.048595, 0.179755, 0.000835, 0.073235, -0.122394, 0.047752, 0.445316, -0.198650, -0.079896, 0.252772, 0.604292, 0.062696, 0.174006, 0.219810, 0.135632, 0.602091, 0.299028, -0.265510, -0.143767, -0.008521, 0.023178, 0.178140, 0.203036, 0.165606, -0.202096, -0.563517, -0.795632, -0.324962, 0.188133, 0.617323, 0.206226, -0.603584, -0.295771, 0.068470, -0.297808, 0.057420, 0.300754, -0.614693, 0.644241, -0.457360, 0.414646, 0.286929, -0.146510, -0.000522, -0.881879, 0.379498, 0.245907, 0.242479, -0.175482, 0.049454, 0.512301, -0.069812, 1.276323, 0.018716, 2.415639, 0.998969, -2.806309, -3.533160, -0.428344, 0.973076, 0.817661, -0.656188, 4.059265, 3.829339, -3.863419, 2.516742, -2.636698, -0.855958, -1.944507, 0.413678, -0.420354, 0.793487, -0.888842, 0.491950, -1.400153, 0.732593, -0.731507, -1.701147, 0.022262, 0.052943, 0.184508, 1.787635, 0.386619, 0.912158, 1.903016, 2.384794, -0.159197, 3.380080, 2.515427, 2.437782, 0.440847, 2.808780, 3.093676, 1.855805, 3.828955, 1.248039, -0.050839, 1.915179, 2.419638, 1.970394, 1.382030, 0.189423, 3.369502, 1.637184, 2.738305, 1.112056, 2.044525, 1.547026, 2.420182, 2.015585, 1.936444, 1.587464, -0.114168, -2.638763, 2.158491, 2.040551, -1.501130, -0.224805, 0.686843, -0.447442, 0.938058, -3.092747, 0.150192, 1.326036, 0.555568, 3.128178, -1.174055, -0.778111, -1.672964, -2.511722, -1.019928, 0.587259, 1.920077, 3.015101, 0.613120, -0.485477, 1.541577, 0.278013, -0.718299, -2.172223, -2.592001, 0.186680, 0.917058, 0.860855, 1.786903, 1.537151, 0.320963, 2.726122, 3.913267, 1.088473, -0.772085, 1.689977, 2.083490, 2.273988, 2.692268, 0.646888, 0.485285, 1.652196, 2.429779, 1.798820, -0.676776, -0.403156, 4.017876, 2.360867, 3.488420, 1.405698, 1.718890, 1.201814, 1.357920, 1.897134, 2.983953, 1.813593, 0.059143, 0.494444, 0.461413, 0.851787, -0.946222, -1.324200, -0.685597, -0.064313, -0.420761, 0.223479, 0.117319, 0.492163, -0.469546, 0.900792, 1.153434, -0.618245, 0.946565, -0.481272, -0.103461, 1.484221, 0.855475, 1.154895, 1.660227, 1.051709, 0.611152, 0.962707, 1.509725, 0.471339, 0.927747, 0.379612, 0.246792, 1.531753, -0.388354, -0.086543, 0.033101, -0.269617, 0.168648, -0.420297, -0.046013, -0.345950, -0.151150, 0.181884, 0.226412, 0.325817, 0.043161, 0.677206, 0.196789, 0.211363, 0.093172, 0.467435, 0.255597, 0.064260, 0.204561, 0.127767, -0.073150, -0.481762, 0.373739, 0.568832, 0.093678, -0.036923, -0.765501, 1.731282, -0.174197, -0.242964, -0.202188, -0.681269, -0.331376, -0.532097, -0.449962, 0.055787, 0.628188, -0.435823, 0.366003, 0.170252, -0.317124, 0.909542, -0.439958, 0.021048, 0.371836, -0.713239, 0.407506, -0.238224, -0.179369, -0.181892, -0.066400, 0.031170, 0.433106, 0.309840, 0.040853, -0.121986, 0.765595, 2.354876, -0.451441, -0.119157, 0.075916, 0.036964, 0.137075, -0.165993, -0.028418, 0.055067, 0.146877, -0.011371, 0.121729, 0.120803, 0.512314, 0.675285, 0.574016, 0.414864, 0.274842, 0.622831, 0.180891, -0.027746, 0.167048, -0.263062, -0.096879, -0.411594, -0.011859, 0.193266, 0.147335, -0.105300};
static RBF_CONST rbf_float RBF_WIDTHS[] = {6.222310, 4.670043, 7.090424, 4.478333, 4.292078, 5.164783, 6.768141, 6.377090, 3.685146, 12.619549, 3.915476, 3.387211, 9.310360, 4.461267, 5.460709, 8.344058, 3.700959, 3.894891, 3.920449, 4.562595, 4.528488, 6.842022, 4.374800, 5.576422, 4.312837, 9.590368, 3.710051, 6.276600, 5.393766, 4.281523, 4.491545, 4.226955, 4.261139, 3.821630, 5.691202, 4.622876, 7.364440, 7.689899, 11.447745, 8.368222, 4.362099, 5.161122, 6.836504, 3.781721, 3.995852, 5.787108, 5.023748, 5.475809, 4.802350, 4.164969, 4.658226, 4.107878, 4.894159, 4.901167, 5.207500, 5.163067, 8.368222, 16.671043, 6.977084, 4.739967, 4.101264, 4.391926, 3.920449, 5.458278, 11.733850, 8.254550, 5.219517, 5.673088, 5.879200, 8.577808, 4.953256, 4.961400, 4.934197, 4.881760, 4.515039, 9.674286, 5.549249, 4.510634, 4.948803, 4.510597, 3.844984, 4.251046, 5.725151, 12.980867, 4.526775, 3.894891, 5.272747, 7.775043, 4.097353, 4.338174, 4.484674, 4.361144, 4.121491, 5.239257, 4.491401, 4.565217, 4.654893, 3.844984, 4.802100, 10.964362, 4.235284, 5.503499, 4.705021, 5.470490, 5.200902, 4.361144, 4.503609, 15.756673, 5.453676, 4.360519, 5.408648, 5.003313, 4.724210, 4.205320, 5.787075, 5.153366, 4.290597, 4.590750, 4.777426, 4.945435, 15.247128, 6.460414, 4.669649, 4.992521, 12.205958, 5.079831, 4.261139, 12.179419, 4.495986, 4.284843, 3.804255, 16.899860, 4.434500, 4.966362, 4.491401, 6.644177, 4.473429, 5.655947, 5.244023, 9.590368, 13.055911, 4.531818, 3.995852, 4.226955, 4.606993, 6.184933, 4.542782, 11.978675, 4.895699, 4.835952, 5.182812, 8.254550, 14.487339, 5.109411, 4.881944, 9.499441, 4.081955, 4.251046, 4.632504, 8.647755, 3.781721, 4.121491, 4.511266, 4.059028, 4.894159, 11.022820, 24.660990, 4.824930, 4.813379, 4.423712, 5.025877, 14.349620, 10.284164, 3.915476, 3.685146, 3.387211, 11.566153, 13.589262, 5.544503, 5.120955, 4.594545, 11.635476, 3.804255, 15.221746, 10.909318, 4.712191, 13.451198, 4.765752, 4.484674, 14.449355, 3.986830, 5.787594, 3.946134, 3.700959, 3.743537, 10.436971, 13.985129, 4.419330, 16.292984, 4.510597};
static RBF_CONST rbf_float RBF_WEIGHTS[] = {0.733650, 4.354008, -7.041035, 5.841667, 0.025818, -4.904522, 7.697200, -1.500966, -2.431328, 2.013525, -0.484021, -4.266929, 1.928419, 2.542552, -3.089280, 4.431477, -0.755024, -9.901601, 6.609167, -3.185888, -2.199676, 1.596174, 4.177451, -1.999263, 1.936056, -5.022490, -1.145983, -0.901886, -0.760940, 1.755185, 3.495025, -4.972522, 1.198397, 1.675084, 4.785454, -1.988928, -3.010438, 5.221355, 1.712794, 3.272191, 5.283974, -1.366508, -2.931607, -2.460978, -3.028273, 3.169258, -2.491888, -3.389847, -5.053472, 6.108753, -4.370231, -3.731130, 2.647862, 2.248197, -0.754613, -1.846871, 1.926555, -7.551291, 6.685441, 3.480651, 0.384341, -4.305035, -0.484583, -1.571906, 0.093651, 4.638477, -0.948248, -2.679614, -1.444844, 2.941045, 3.205834, 0.189538, -3.705243, 3.397064, 1.544887, 3.684365, 3.662404, -3.019941, -3.392124, 0.620451, 0.873819, 3.163547, -2.211753, -4.761029, -0.643873, -3.284300, -0.743250, 10.391787, 7.388218, 1.974260, 1.192556, -4.496723, -0.125886, -3.720775, 0.655730, -8.398181, -9.973517, 6.549281, -5.475276, -0.456559, 0.154468, 3.899127, 3.037393, 2.122422, 0.323441, -0.209676, -0.230887, -0.186878, -3.986467, -4.045150, 3.195590, -1.129834, 6.712732, 0.141754, -6.873796, 1.234287, -2.970503, 2.221522, 1.240887, 4.313536, 0.913566, -1.555081, 2.442244, 3.699942, -6.307788, -3.757520, 2.403314, -3.671446, 1.997212, 1.764701, 3.393151, -1.310826, 0.880835, 0.560856, -6.822348, 5.017845, 0.801203, -6.296486, 7.424979, -2.543150, 1.028804, 0.215423, -0.959830, 0.777038, -1.925844, -2.117706, -0.410913, -0.804768, 8.457214, 4.725381, -4.508601, -1.240613, 0.375232, -4.877180, 2.101763, 0.277000, -3.273921, -4.599504, -3.860171, 1.539421, -3.226615, -0.149491, 10.039763, 1.028623, 0.959610, -0.264698, 3.999089, -2.295383, -3.187666, 0.760794, 2.241303, 4.071848, -7.444395, 3.012907, 0.796314, 0.341632, -0.707977, 1.177883, -2.995073, 1.812819, 0.050654, -1.886410, -1.300458, -1.745326, -1.676932, -2.055866, 1.403819, 2.452977, -0.645145, 2.889341, 0.826649, 1.659442, 1.615574, -2.778667, -1.088451, -5.602542, 3.484443, 5.348117, -8.871457, -1.709388, -2.042813, 6.140871, 1.677383, 3.819009, -0.933084, -7.513012, 3.954666, 2.919353, -0.620490, 11.580468, -0.333027, -4.666300, -2.867278, -1.663693, 3.072443, -2.807297, -1.433014, -0.502283, -0.297541, -1.618587, -3.823658, 2.630958, -0.614224, -0.432670, -0.134734, 4.345910, 3.295246, -1.592161, -3.374929, 3.528055, 1.991947, -3.537029, -2.586538, -2.724019, -1.125050, 0.960172, -1.595232, 7.025362, -0.790594, 2.027871, -5.557422, 5.302368, -1.372511, -8.707805, 0.944101, -1.119474, -4.157458, 2.849590, 0.472234, 2.339911, 7.545023, 1.085469, 5.117023, -9.413899, 2.557558, -2.382355, 2.091472, 8.248961, -3.599879, 0.701029, -1.105933, -0.003138, 2.336456, -4.357623, 8.921026, -3.678280, 2.259559, -3.562218, -2.938428, 1.855839, -1.386348, -1.402445, 3.190388, -4.418558, 3.092706, -1.727598, 2.907365, 5.015286, 0.647852, -3.566375, 0.795426, -7.964075, -2.053327, 1.289229, 0.230693, -0.910751, 1.146597, 2.528108, -0.576075, 1.801232, -0.368841, 6.449081, 1.778671, 4.031643, -1.369746, -0.126047, -2.883631, 0.532376, -9.407447, 0.222815, -1.884407, 3.761114, 0.151924, 3.375653, 2.022377, -1.807984, 0.866922, -5.159715, 0.841634, 0.886660, -2.253242, -0.823847, -0.488254, 0.275234, -4.457272, 3.421498, -1.895192, -0.834962, 1.190512, -0.923846, 1.127091, -0.591069, 3.715876, -0.599919, 1.506201, 0.447128, -0.792607, -0.946535, 0.747308, -0.959120, 0.904651, -0.422007, -2.333984, -5.244260, 3.050343, 4.223937, 1.275040, -1.687374, 2.652780, 0.826486, -1.711626, -1.889013, 0.791293, 0.567025, 0.534505, 1.490304, -2.224119, -0.572466, -10.680599, 11.530398, -2.033181, 5.964401, 4.795063, 1.583619, -3.376356, 0.853371, -2.037391, -1.456653, -9.078799, 3.662212, 5.683327, 0.463184, 1.411878, -4.211639, -2.125035, -3.628335, 1.007716, -0.893314, 0.230149, 0.013354, 1.638649, 0.549779, 1.959016, 6.526388, -5.247030, -7.327050, 4.240338, 1.191322, -3.635455, 2.936436, -0.761187, -3.188980, -0.899805, 4.161232, 1.542838, -5.330494, -2.757910, 0.349063, 1.430545, 1.355169, 1.278499, 4.389955, -1.694984, 0.372623, 1.155113, -2.009024, -4.159500, 0.464952, 1.050098, 7.188386, -2.178873, 1.784895, -0.955569, -1.254911, -1.494419, -0.856223, 1.113056, -0.747179, 6.304712, -6.485492, 4.296812, 2.124774, 2.281294, 4.135325, 1.064373, 1.799326, -1.615257, -6.937969, -5.715337, -0.829210, -0.040591, -0.391959, -0.231282, -2.051582, 1.449760, 3.430768, 0.479935, -1.820622, 0.509526, -2.297532, 2.900427, -1.953219, 2.324224, -4.682438, -1.588379, -6.044027, -5.800555, 3.625827, 2.697642, 0.615860, -1.389703, 2.480298, 6.162736, 1.571760, -1.957521, -3.921106, 0.219892, -0.242041, -0.371426, 6.305949, 0.252040, 2.674606, -0.202785, 0.974942, 0.557564, -4.406009, -3.102397, 2.524713, 2.394307, 1.581964, 0.904715, -3.625153, -0.643834, -1.159916, 2.124057, 1.082180, -2.821302, 0.649241, 3.375803, 0.174971, 2.143637, 0.575901, -5.145291, -0.889061, -1.242998, -2.420092, -2.426439, 3.772925, 2.362308, -0.195712, 0.210930, 2.818159, 2.038701, -2.687662, -11.848809, -2.236266, -1.904046, -0.990516, 2.550209, 10.852526, 0.539769, 0.331630, 0.744532, -1.844542, -4.256696, -4.432142, 0.265246, 3.406638, 6.045827, 0.334527, 0.868063, -7.739017, 6.609235, 0.021233, -1.942375, 0.861796, 0.398933, -0.879821, 0.596904, -4.988082, 1.027675, 1.827252, 2.765675, 1.374810, -2.370255, 1.226424, 0.254539, 0.806224, -2.587795, 2.730727, 2.249537, -3.678108, -2.187076, -1.007646, 3.121835, -1.225429, 0.699437, 0.818683, -0.906990, 2.278219, -2.072404, -1.545916, -0.316065, -6.732052, -2.707209, 1.730751, -0.774877, 3.854228, 0.793433, 6.351765, 0.461193, 2.523984, 1.482109, -0.070708, 3.023169, -3.342631, -3.066046, -4.048177, 0.739027, -1.373687, 1.894963, 1.852467, 2.862098, 2.910527, -0.890561, 4.835223, 0.382313, -6.781990, 0.017557, -1.228498, 2.735263, 1.157667, -5.501187, -0.421597, 0.949560, 1.266808, -1.476994, 4.885993, -0.151631, -4.884668, 2.585123, -1.310985, -1.330556, 2.325673, -2.927876, 0.175044, -0.679657, -5.595398, 0.105534, 5.348794, -4.330585, 8.467799, 0.682348, -4.513985, 2.839057, 0.408329, -1.754447, -1.025762, 3.754635, -2.870271, 8.172065, 4.233832, 3.394322, -3.385597, -2.102394, 3.028250, -3.235319, -1.602781, -8.606176, -0.392190, 2.017752, 0.092868, -1.163257, -5.498475, -6.318437, -3.934195, 2.280577, 3.121499, 1.209710, 2.738987, 4.059743, 1.279857, 2.661305, 3.145813, -0.944193, 0.568954, 3.557489, -0.559371, -5.237185, -2.214212, 3.777447, -0.865136, 0.786715, -4.717806, 0.258341, 2.327286, 0.625862, -0.109380, 2.371159, -2.685230, 0.366598, -1.617618, -0.858637, -3.714036, 1.835651, 1.309340, 2.386576, -2.784463, 1.388011, -1.588872, -4.170047, 2.443697, -4.625011, 2.686302, -3.801772, 3.569780, 2.109236, 2.443562, 3.509576, -3.476392, 2.367644, -0.964009, -4.535607, -4.213245, 1.727662, 0.953694, 3.704236, 0.939397, -1.929805, 1.976382, -3.418116, 5.483853, -1.019775, 4.366107, -1.511533, 5.678465, -3.023871, 0.543686, -1.766292, 1.934808, -5.659102, -1.794604, 1.752370, -5.319127, 0.733880, 3.188417, 1.079774, 0.336446, 1.846563, -1.870280, 2.322696, -0.232773, -2.551997, -1.161760, 0.529199, -4.931833, 3.886536, -2.190324, 6.268799, 4.018231, -1.792823, -2.237338, -6.248065, -0.368276, 0.772149, 2.589658, 0.606739, 4.033097, 2.198498, 2.165690, -1.091781, -1.194866, -3.965750, 1.928484, 0.667742, 0.028119, -7.118136, 1.731660, -0.942928, -6.794704, 7.401799, -0.340087, -4.013921, 4.504038, -2.824315, -1.819443, -1.270186, 4.157627, 0.774819, 1.197195, -2.273611, 5.103389, -3.841615, -4.282822, 2.305094, -0.546220, -0.237211, 2.119160, -0.214437, -4.164478, 4.534750, 1.366886, -2.579836, 2.920042, -0.539588, -2.190093, 1.699605, 2.052211, -0.915587, 1.850393, 0.144574, 0.920053, -4.244426, 0.738692, 5.563270, 2.638975, -0.806613, -1.206893, 2.999482, -2.892525, 3.741710, 2.006369, -1.395851, -6.609692, -1.938390, -1.837702, 0.635196, 1.009904, -1.513164, -0.576314, -1.564754, 5.617160, 3.236454, 2.325990, 2.228611, -7.488812, -1.593238, -2.364364, 2.888353, -0.660311, 0.544786, -0.511399, 4.071980, -1.375300, 1.300637, -3.297958, -0.304040, -4.930284, 1.614542, 0.897235, -1.072206, -4.599540, 2.486395, -3.141031, -2.969779, -0.091190, 3.797564, 5.500196, 0.079827, -2.353594, 2.827995, -0.484905, 2.049676, -0.082440, -1.424883, -0.695816, -2.557982, 1.056749, 1.207773, 1.602884, -1.530217, 3.801611, -1.797133, -1.648235, -1.136121, -0.037461, 0.615954, -1.589206, 0.283712, -3.769224, 1.914458, 1.639678, 0.652147, -2.464904, 3.985203, -0.104741, -1.315488, 3.588686, -0.154818, -9.823906, 4.636380, -2.384445, 2.575418, 1.679521, -0.586252, -9.022378, 10.209471, 0.593717, 1.125669, -4.994382, 0.222478, 0.648045, -6.019573, 4.484038, -1.593343, 1.146582, 3.200289, 5.155847, -1.822525, -1.704688, -1.805946, -3.639099, 3.049241, 1.216157, -2.077126, -0.718779, 1.916146, -2.656286, 1.681220, -1.528266, 1.444353, 3.156819, 0.741850, -0.061222, -0.237823, -3.836182, -1.078668, 2.236794, 0.653785, -2.086511, -2.435518, 0.534839, 3.007772, 2.597482, -4.520822, 7.123105, 1.834317, 3.408324, 4.257868, -8.949338, -2.116364, 1.732565, -4.795038, 0.330098, -1.049324, 2.792745, -1.916716, 2.982936, -2.215272, -1.979258, 0.613505, 1.865807, -0.633300, 1.205775, -1.561401, -0.675746, 0.406142, 1.818630, 3.535687, 0.934354, -11.636523, -9.240307, 5.573353, 11.753919, 2.496304, 4.051543, -3.109442, -12.464201, 5.017023, 3.178009, 2.490854, 0.253459, 1.416871, 0.493484, 1.831135, 4.273780, 0.835536, 0.097686, -3.172772, -5.554201, -1.677361, -1.079242, -0.911380, 1.730341, -0.559245, 3.010136, -0.315011, -1.021647, 2.297584, -0.083472, -0.000559, -0.877230, -2.830188, -0.436376, -2.856836, 3.351876, -1.579139, 2.014204, 2.182755, -6.133494, 5.141991, -0.961611, 3.788185, -5.349041, -2.557590, 2.940105, -1.775475, 5.317776, -1.072475, 0.086473, -1.499510, -10.009773, 3.992012, -3.470869, 0.818320, 4.420494, -0.784299, 3.910929, -5.628645, 8.084660, -2.761412, -4.540409, 0.891869, -3.900071, -4.771028, 2.993359, -1.454197, 3.055580, 2.311518, 5.426842, 1.977344, -3.037567, 3.626263, -6.054250, -2.797918, -6.438333, 1.569797, -1.349955, 7.905365, -1.639878, 5.530291, 0.643798, -1.814686, -0.359943, -0.362612, -0.846436, 4.620279, -6.147132, 1.388639, 0.316670, 1.107521, -3.085576, 5.217576, 0.001804, -2.529202, -2.752510, 0.226377, 3.508405, -2.154411, 2.902214, 0.517891, -1.084064, 2.550886, 1.871266, -1.402145, -1.783611, -1.303361, -0.164797, -0.589388, -0.627210, 5.074106, -0.198830, 0.217635, -2.024677, 1.975627, -1.118207, 0.477560, -1.739887, 6.043523, -3.521171, -0.350273, 0.196983, 2.480814, -1.212832, 6.391534, -1.301562, 1.766371, -4.412996, 0.582619, -6.417875, 1.289588, -5.948975, 4.493511, 3.036342, -3.711849, 3.033868, 0.616512, -2.313321, -3.807062, 6.292670, -1.300341, -1.545414, 0.953742, 4.186790, 0.286781, 3.474364, 1.127052, -1.736732, -5.101542, -0.118427, -4.440199, -2.141086, -0.463058, 4.144147, -5.221660, 6.862330, 3.028340, -4.793665, 2.784381, -3.299898, -2.844633, 4.620820, 3.369732, -3.163647, -3.306295, 1.709200, -0.534302, -7.252442, -2.055034, 4.153641, -2.829413, 5.069287, 8.272548, -3.071958, -0.014172, 0.470310, 1.936950, -4.106540, -0.434634, -3.921087, 2.780756, 3.840441, -1.909129, 0.210630, 1.932709, -3.457544, -0.954508, 3.318397, 0.016428, -1.346713, -0.426349, 4.869550, -4.970976, 4.957675, 2.494840, -1.883636, -2.097542, -0.674572, 1.387957, -0.028135, -1.375854, -2.331397, 9.763309, -6.626151, -0.183077, 6.267742, 0.232871, -1.521876, 5.016061, 0.125473, 1.108046, -3.666241, -3.289015, -6.809496, 2.177896, -2.887029, 3.464660, 8.329040, -7.040700, -0.847248, 2.338678, -2.453907, -2.930962, 1.484270, -1.423859, 0.000292, 5.976183, -6.360092, -1.311513, 1.630984, -5.468785, 3.689442, -0.241281, 1.085409, 0.045345, -0.497332, 0.476693, 1.142330, 1.903466, 1.832085, 6.205062, -0.163867, 1.073170, -0.602780, -14.007267, -1.019167, -1.881617, 0.339917, 0.746273, 5.704782, -1.148028, -3.621374, 2.099476, 1.006834, 0.597561, 6.663338, -2.963500, -1.597884, -0.059120, 1.354351, 1.995722, -4.382290, 3.020182, 0.772252, -3.882109, -3.935374, 2.656889, -14.015803, 9.914831, 7.070906, 8.813081, -5.317466, -3.583123, -1.529258, 5.526929, 7.531117, -6.877855, 8.229349, -0.501108, -10.039002, 6.213312, 4.834672, -7.117979, -1.651958, -6.984117, 1.178351, 3.510775, -4.422140, 2.878755, 7.096523, -2.401940, -1.225521, -2.147953, -1.772620, -3.268610, 3.872658, -0.616940, -1.255214, 3.218463, 4.061127, -10.960325, -3.988293, -3.829421, -11.166299, 8.501506, 2.830909, 5.236644, 4.838365, -0.273980, 1.331170, -0.851200, -0.325204, 0.184899, -1.402511, 4.091701, -5.301350, 2.804527, -2.651592, -1.863123, 0.218815, 4.345988, 0.863683, 0.686562, -1.007909, 0.237744, -0.773189, 3.266961, -1.988122, 1.625680, -1.126689, 0.819529, -1.792798, 0.731956, -0.593949, 1.244130, 3.225519, 2.797302, 4.770875, 2.607404, -2.044744, -3.369249, -0.195370, 4.345881, -2.533581, -6.690103, -4.147143, 4.542842, 2.919178, 2.672208, -5.065147, 1.043554, -7.276326, -1.411335, 3.333349, -3.369614, -0.144488, -1.357409, 4.331960, -1.478580, -3.821325, 4.293191, 0.984855, -2.475162, -6.210612, -3.633665, -3.107935, -2.318640, 10.372450, -1.645080, 9.115478, -5.609534, 1.149712, 1.360198, -5.736381, 3.608081, 4.590798, -3.385658, 0.468318, -0.731476, -1.372097, 7.079129, -1.639775, 1.036048, 1.716588, 11.023655, 12.960155, 4.287319, -5.443128, -7.563108, -1.441115, -2.551850, 2.728262, -10.823698, -5.635236, 3.207993, 0.575171, -6.370206, -10.045202, -0.100623, 0.117252, 5.005905, 6.849270, 5.985106, -3.021529, -0.183229, -2.225891, -4.229568, 0.851635, -3.717408, -3.542108, -4.869195, 8.541590, 0.697393, 0.772226, 2.058377, -0.437256, 3.543719, -0.027038, 3.718001, -7.536167, 7.658199, 4.625663, -3.738949, -3.830870, 0.547294, -2.393750, 1.682744, 0.924899, -0.803808, -0.594952, 10.124018, -5.761735, -1.861984, 2.040361, -2.331466, -5.544664, 2.687172, 1.398072, 1.843620, -0.935230, -0.529582, -0.791382, -2.356018, 2.297039, -2.696040, -5.211001, 1.041707, -1.109878, -1.354181, 0.083773, -1.667555, 0.173142, 3.674968, 7.051048, 0.506296, 3.274530, 0.290431, -10.796161, -1.380345, -1.554080, 0.074562, 5.600237, -0.227516, 1.240331, 0.242226, 2.578616, 7.007910, -9.671712, -0.210139, -5.843929, -0.545267, -0.858080, -0.137447, -1.558799, 0.954323, 3.183660, 7.493862, 0.381858, -4.059206, 1.113781, -5.189187, -6.119189, 4.431726, -3.425727, -3.448960, 8.098362, 4.870394, -0.727673, 0.839197, 3.308279, 3.343719, 2.675287, -0.874068, -0.100181, 0.229436, -4.894049, -0.715829, 6.369435, 2.981638, -1.575109, -6.460873, -0.976276, -0.284225, 1.613344, 2.643533, 1.403991, -3.869758, -0.038978, 1.431748, 0.584273, 0.857445, -4.813646, 1.655551, -1.188282, -1.121305, 4.085822, -3.172320, -3.083709, -1.270239, 4.322404, -0.347701, 2.138378, -5.200129, 0.735873, -3.047725, 5.924030, -0.314622, -2.416565, 5.634243, 0.996568, -0.284925, 1.899791, 0.059275, -0.345088, 1.736989, -1.881798, -2.632242, -2.415767, -1.880258, -3.845207, 2.539216, 1.556535, -1.891718, -2.572458, -2.523538, -6.411263, 0.654163, 7.177923, 5.630868, 1.525994, -0.480296, -0.232222, -1.224861, -1.453485, -0.683141, 0.343243, -0.799173, -0.109728, -0.677354, 4.033276, 4.799013, -3.631305, 0.030694, 0.932374, -2.470452, -4.004906, 6.672470, 0.463796, -0.460716, -1.713766, 6.504339, -0.015070, -1.192086, -4.916771, -7.654761, 7.342180, -0.547598, 1.689464, 2.080080, 1.722419, -0.365396, -1.387848, 1.882146, 3.320040, -3.597483, -4.867087, -3.510359, 0.992432, 1.399313, 8.109723, -2.748920, 3.731463, 0.512086, -4.805433, -0.757566, 3.253218, -7.391805, 1.174029, -3.552470, 5.897050, -5.164609, -1.231941, -2.123282, 1.333967, 2.985342, -0.559470, 3.002589, 2.406891, -1.479516, -1.862828, 0.754986, -0.689447, -0.099289, -3.883535, -1.637404, -5.624040, 1.380965, 0.571718, 3.088610, 1.944685, 0.161990, 3.985055, 0.619767, 3.243747, -1.248089, 0.357061, 2.293354, 5.888074, 4.295816, -0.194226, -5.453347, -2.973622, -4.578875, -2.123587, 0.910082, 3.142494, 3.466933, -0.614266, -0.149575, -1.678484, -4.988462, 2.727904, -4.302036, -3.290427, 2.539165, 2.368728, -1.230407, 3.492294, 0.895514, 0.069250, -4.583229, 11.570910, -8.674025, -1.935133, -7.082199, 2.425004, -0.334107, 5.338753, -0.708384, -3.698533, -0.191525, -0.540787, -2.974197, 4.451081, 0.549341, -0.823903, 3.882721, 0.508506, 1.673630, -2.279496, 0.829909, 5.490260, 1.097672, -0.794204, 5.475338, -4.648289, 5.330173, 5.081609, -3.254313, -8.824115, -4.922642, -0.640132, 0.599789, -0.621840, 0.627605, 0.161413, 1.474112, 2.867383, 0.087481, 0.709221, -2.549870, 0.485166, -2.701222, -1.066976, -1.879508, -6.340431, -1.348535, 7.556674, -1.475952, 9.142039, -0.741789, -6.420112, -0.166706, 7.186164, 1.068357, -6.673192, -1.139081, -8.844482, 0.541118, -2.535497, -5.040924, 3.435318, 1.119842, -3.386589, 3.836798, 3.610904, 9.166198, -0.915084, -8.320272, 2.097405, 0.603121, -0.046890, 2.309038, 5.028168, -18.019761, 4.428021, 2.633422, 12.783332, -8.704330, 4.682159, -1.090314, -2.877618, 4.688487, 0.223850, 3.753997, -2.841416, 2.727772, -3.732692, 0.767633, -0.124846, 0.254550, -1.634904, -2.186180, 2.928635, 1.098132, -4.395987, -1.434663, -0.213231, 1.873796, 0.732361, -1.079866, 2.521685, -4.932799, 4.993768, 2.682061, 0.812246, 3.933246, 7.764257, 2.039615, -6.456123, -0.541250, -2.285636, -1.220454, -0.782923, -5.094003, -0.555819, -3.688906, 1.690036, 1.775511, 3.966156, 1.305937, 5.239218, -5.498979, -4.195318, -1.609674, 7.085544, -5.034628, -1.168248, 1.439047, -0.230583, -0.381378, -0.945549, -3.936534, 4.802043, -1.694750, -0.952192, 1.072510, -0.775524, 1.508298, 0.033005, 0.585186, -0.225161, 2.487515, 5.228709, 1.200881, 0.362999, 8.478475, 1.215255, -0.866647, -11.982443, -4.169615, -2.036909, 5.996760, -9.156358, 0.140844, 2.399763, 1.267424, 1.936021, 2.762530, -0.761575, -0.017386, -0.324975, 1.324694, -5.288554, 1.554218, 5.580909, -2.712123, 3.345866, -0.048198, -1.218899, 3.612100, 0.549630, 4.931446, 1.033813, -9.983049, -6.792156, -4.109509, 6.985541, -16.723039, -1.349434, 3.024040, 3.702893, 7.787609, 3.654629, -1.537064, -0.608320, 1.524903, -2.680551, -2.593185, -3.900181, -1.361465, 3.218802, 3.717498, 0.635564, -0.904623, -3.525258, 2.669633, 3.815217, 3.766905, -5.649427, 5.817539, 0.749686, -1.386640, -4.334774, -0.434302, 3.656630, -0.295378, 2.505253, 1.478058, -3.273693, -0.969656, -3.473877, -1.480823, -6.856555, 0.624792, 1.378436, -0.386176, 13.415758, -2.765713, -1.709881, -0.390062, -1.390189, 5.148613, -5.657431, -0.965062, 1.263562, 2.619357, 0.608036, 0.174958, -0.560362, 0.081503, 0.867234, -0.434196, -1.166016, -0.952893, -1.535241, 4.618590, -0.843725, 4.931618, -0.735670, 5.167901, 3.127839, -8.380471, 0.021717, 0.008519, -1.561281, -2.683255, -3.496624, -0.392998, 1.940102, 0.186480, 1.635754, -0.325102, 4.357307, -4.502929, -2.584260, -0.015682, 1.409882, 0.706862, -2.503243, 0.378114, 3.236177, 3.486649, -2.373373, 2.279278, 1.320395, -6.367158, 3.016313, -3.528966, -1.595619, -2.491295, 2.713425, -0.947312, 2.686766, -0.240292, 0.135993, -0.661777, -1.784169, -1.522715, 1.964478, -1.193290, 2.183246, -1.161276, 0.474088, -0.950066, -1.174614, -0.717481, -0.955174, 0.910660, 2.830786, 4.475705, -0.102816, -1.044197, -7.013997, 1.531992, 2.308648, 9.128115, -3.875185, -5.071585, -4.573119, -0.810527, 3.625520, 4.496582, 2.960093, -2.383042, -2.602616, 4.558083, -5.233713, 4.769279, -0.945468, 2.917273, 13.098243, -26.084550, 11.810604, -0.205112, 6.641724, -8.642786, -0.953409, -8.053215, 5.799044, -5.093774, 0.942607, 2.545198, -0.036468, -3.564309, 7.912203, -5.215484, 0.556487, 0.583973, 2.443029, 1.115331, -2.502783, -0.823323, 2.339051, -4.213085, -3.220876, 2.858687, -12.508884, 5.411023, 0.936600, 0.196563, -0.743067, 4.563091, 5.252610, 1.237919, 9.654429, -8.925696, -13.303965, 2.876485, -9.732762, 3.460304, 8.373852, 3.741361, 0.401314, -0.038684, 1.959476, -3.302206, -1.844381, 2.295662, 0.288971, 1.522445, 2.280755, 0.764465, -2.732914, -0.967740, 0.074891, 1.813967, -0.205725, 5.751304, -3.930091, 5.036045, 5.586854, -7.775777, 1.091279, -6.093431, -0.328970, 1.499774, 3.855506, -4.430070, -0.140169, -4.371288, -3.657620, 10.770209, 0.189277, 1.693509, 8.960990, -10.757435, -0.260685, -0.616918, 0.444907, 0.209233, -2.686703, -3.116718, -1.245514, 5.930245, 1.322147, -5.124811, 5.207085, 2.261079, 0.155464, -4.102973, -1.312491, 0.367126, -0.327795, 2.644339, -2.375055, 0.895360, -2.305572, -0.372902, -0.224412, 0.899382, 0.026659, -0.980551, -0.644956, 1.486100, 1.077276, -3.679982, -2.713855, 1.102658, -0.735674, 1.943843, -0.591010, -1.133715, 0.419118, 0.552548, -0.649010, 1.308588, 4.146165, -5.587703, 3.670095, 0.448920, 5.225966, 1.964782, -1.244973, 0.962375, -4.248468, 5.035615, 0.768679, -6.523418, -0.672761, -2.808805, 0.328984, 2.152218, 5.885590, -3.773930, 0.658147, -4.409942, -3.473803, -2.994928, 3.816076, 0.033737, 4.592650, 0.654508, -0.419183, -0.677102, 2.998757, 2.465866, -4.938792, -1.933793, -2.414848, 0.684788, 0.342556, 3.134820, 0.190838, 4.340413, -7.783070, 5.926477, 0.071147, -2.013880, 6.439699, -0.154796, 1.261469, 1.251149, -0.279831, -4.853014, -4.057132, -2.561510, -0.062871, -2.828058, -1.947147, 1.491445, 1.407556, -1.604541, -0.249994, -2.814971, 2.674937, 3.040401, 3.391140, 1.635239, 1.654222, -0.119697, 0.865798, -2.537953, 3.458640, -0.834779, 1.236286, -0.780811, -1.889408, -6.990403, 4.361062, -5.849650, -0.088278, 0.487451, 3.724552, 2.947120, 5.049281, 0.303650, -0.339764, 0.419776, -4.286686, -2.212539, -0.239645, 6.210791, 2.234790, 0.898977, -3.756325, -1.899995, -2.254497, -2.159110, 1.157711, 0.970415, 3.027693, -1.922974, -2.474362, 1.695048, 2.813582, 0.409241, -2.497784, 3.326723, -6.590429, 0.008683, 2.891891, -1.346528, -2.669542, 1.449268, 0.630257, 3.429078, -1.071770, 2.138319, -5.807081, 4.279501, -3.089769, -1.217781, 0.579336, -1.949864, 0.681381, -0.007962, 2.223712, -3.574071, 0.699195, 1.886547, -1.707056, 3.191645, 2.702529, -3.338081, 0.290636, 3.297660, -0.231286, -1.016095, -2.397633, 1.756878, 0.917059, -4.274649, -4.716642, 3.038848, -4.389613, 1.671463, 1.468332, 1.794742, -0.520542, 2.598978, 0.638054, -5.998770, 10.007032, -5.554131, -0.700498, 1.396029, -5.066890, 5.619572, 3.283201, 1.458319, 0.212162, -4.033187, -0.948998, -0.927304, -0.581880, -5.370218, 1.283607, 1.752768, -3.520334, -0.846608, 0.982608, 1.467245, 0.352481, 3.328131, 2.026350, -2.288541, -0.351653, 4.188138, 0.088128, -2.865253, 3.394093, -0.964883, -2.501292, 2.971439, 1.731015, 0.253520, -3.833582, -1.040254, -1.794651, -2.436603, -5.535317, 3.393601, -0.406362, 0.902184, 0.673256, 4.419178, -2.012942, 4.867474, -1.167116, -1.850905, -5.195027, 6.488985, 0.802430, 1.630551, 4.255829, -1.246962, -0.779377, 1.845373, -2.860001, -3.964683, 0.942103, 3.811099, -2.860538, -3.156513, -0.526842, -6.958544, -0.892599, 5.232009, -1.567368, -0.113554, 2.399869, 5.148832, -0.481907, 0.769224, -5.905816, -1.373787, -1.512717, 1.580261, -1.537973, 6.550415, -1.065882, 1.905704, -3.402858, 6.841324, -2.759845, -0.069733, -7.109023, 4.225660, -4.557157, 7.133306, 1.776689, -4.916882, -2.304532, 4.960816, -0.162691, -1.296610, 2.367160, 5.028901, -3.338778, -3.960032, -3.589061, 2.836732, 2.241621, 3.799558, 1.108186, -2.588939, -2.263394, 3.292419, -2.370369, -0.212639, 1.338441, 0.176735, -2.473098, -8.236337, -0.156983, 3.059030, 6.146178, 5.801822, -0.839780, -7.256333, 2.408170, 2.112810, 2.416349, -6.482589, -1.851150, 2.499494, -7.889862, 3.238573, 3.522967, 4.032798, -5.891435, 1.767271, 2.545124, -3.010141, -5.829530, 1.334660, 3.514413, 1.268188, 2.507431, -4.103255, -4.911390, 2.082455, 4.442542, 6.463954, -3.861941, -4.060038, -0.710271, 0.708522, 0.621099, -0.285458, -0.289219, 0.360855, -1.706045, -2.123457, 4.542899, 0.037706, 2.835786, 1.114181, 0.143405, -2.999643, 3.669840, -5.563857, -4.502398, -0.928126, 1.357613, -3.073931, 3.238362, 1.759056, 5.851271, -0.037506, 2.398833, -2.537066, -7.890373, 4.307721, -1.658239, 0.847203, 1.628458, -1.152731, -3.849585, 3.439766, 4.526748, -2.069927, -0.298666, 2.811321, 2.083906, -2.026815, -0.105486, -4.731594, 1.540773, 2.383662, -0.214475, -2.916202, 3.461643, -2.663350, -1.689628, 0.179748, 4.505308, 4.546143, -1.117799, -0.455989, -4.435563, 0.711401, 3.818351, -0.672877, -2.734448, 0.256486, -0.742567, -1.953982, -1.183914, 0.278640, 3.866205, 2.060151, -1.192673, -3.498255, -0.138737, 2.722972, -0.422445, 6.304070, -3.019867, 0.734513, -9.792461, -3.418979, -3.122098, 4.473717, 0.580005, 1.960692, -4.161435, 8.691159, 0.896232, -5.069181, 6.512409, -5.780603, -1.489903, -0.440879, 2.001717, 1.386157, 2.418007, 0.754868, -0.549993, 0.057384, -0.126379, 0.789525, -3.045042, -0.000317, 1.375994, -0.038953, -4.937961, 0.580607, 0.165717, 0.794678, 1.104567, 1.907080, 1.384669, 1.000868, 10.945525, -2.022672, 3.744771, 1.310302, -9.395398, -0.049946, 2.909615, -3.623485, 0.670736, -8.073240, 2.669175, -2.793449, -0.482768, 0.520224, 2.817413, -2.863362, -1.789850, 0.883234, -2.616380, 3.390739, 4.143676, -2.094347, 0.730380, 2.889519, -1.883252, 4.306765, -4.948536, 2.544868, 4.062057, -4.426593, 0.953369, -3.890467, -4.913972, 2.596158, 2.942715};
static RBF_CONST rbf_float RBF_BIAS[] = {-3.224730, 6.425414, 11.501447, 5.541205, -4.656497, 20.794197, -5.253694, 1.109354, -12.039239, -3.746949, -10.737736, -5.653542};

#if RBF_USE_NORMALIZATION
static RBF_CONST rbf_float NORM_IN_MEAN[] = {0.007725, -0.007038, 0.007455, 0.011877, 0.001866, -0.003087, 0.004067, 0.002325, 0.003148, -0.006066, 0.004758, 0.000636, 0.004189, -0.007824, 0.003690, -0.004952, -0.002980, -0.015579, -0.010094, 0.002106, 0.004459, 0.006238, -0.002720, -0.000873, 0.007270, 0.009699, 0.006898, 0.001832, 0.005006, -0.007759, 0.005082, 0.013317, -0.002149, -0.000781, 0.011293, 0.011511, 0.005884, -0.005790, -0.009952, -0.009337, 0.005552, 0.014381, 0.010618, 0.015250, 0.005429, 0.003803, 0.008677, -0.012048, -0.007581, -0.018476, -0.000717, 0.010397, 0.001276, -0.002031, -0.007865, -0.015925, -0.004742, -0.004977, 0.008823, 0.009801, -0.012115, 0.003178, 0.000795, 0.004078, -0.008358, -0.003247, 0.002985, -0.001700, 0.003416, -0.003666, -0.008242, 0.004791, 0.002949, 0.003835, 0.013085, 0.002617, -0.000862, -0.003491, 0.012320, 0.005680, -0.008778, -0.010445, 0.013855, -0.000230, -0.028151, -0.007351, -0.002369, 0.003762, -0.006667, 0.005783, 0.009740, 0.013742, 0.000966, 0.002236, 0.001234, 0.012526, 0.005553, 0.000584, 0.001718, -0.007526, 0.010426, 0.019006, 0.001946, -0.000085, -0.001752, 0.006428, 0.012480, -0.011479, -0.004705, -0.011416, 0.002779, 0.019718, 0.009155, -0.006767, -0.002370, -0.006690, -0.004474, -0.008191, 0.013075, 0.004443};
static RBF_CONST rbf_float NORM_IN_SCALE[] = {0.996629, 0.996456, 1.006960, 1.000724, 0.998965, 1.007205, 0.996358, 1.008930, 0.999738, 0.999265, 1.000178, 1.004599, 1.005564, 1.001433, 0.999537, 0.996337, 1.004369, 1.001488, 1.006371, 1.002854, 1.013769, 1.009204, 1.012719, 1.009145, 1.007766, 1.013448, 1.006060, 1.004181, 1.004699, 1.012301, 1.011381, 1.004705, 1.005709, 0.999788, 1.014250, 1.007092, 0.998332, 0.999420, 1.000578, 0.986307, 0.990726, 1.000894, 0.987749, 1.003016, 1.003188, 1.002182, 0.999670, 1.003895, 1.005160, 0.987971, 1.003442, 0.998074, 1.001403, 0.997493, 1.004569, 0.999488, 1.000520, 1.005482, 1.005012, 0.999332, 1.021121, 1.009623, 1.005972, 1.000076, 1.007258, 1.004143, 1.013018, 1.009041, 0.999489, 0.987664, 1.004903, 0.995086, 1.004900, 0.999231, 0.991359, 1.003120, 1.001450, 0.991679, 1.002761, 0.996638, 0.996337, 1.011198, 0.990578, 1.001591, 0.993474, 0.997636, 0.995683, 0.991396, 1.004184, 1.003337, 1.017125, 1.011451, 1.014767, 0.996731, 0.999880, 0.999353, 1.003289, 0.993435, 1.000970, 0.994051, 1.002609, 1.002306, 1.001798, 0.999421, 1.000606, 1.006095, 1.006228, 1.003175, 1.000111, 0.992152, 1.000916, 1.003823, 0.992797, 0.989172, 1.004844, 0.997501, 1.006134, 1.001482, 1.007577, 1.002577}; // StdDev
static RBF_CONST rbf_float NORM_OUT_MEAN[] = {0.078289, 0.085565, 0.081781, 0.081781, 0.081490, 0.084692, 0.082654, 0.084692, 0.087602, 0.085565, 0.083818, 0.082072};
static RBF_CONST rbf_float NORM_OUT_SCALE[] = {0.268625, 0.279720, 0.274031, 0.274031, 0.273586, 0.278422, 0.275359, 0.278422, 0.282715, 0.279720, 0.277115, 0.274475}; // StdDev
#endif

// ==========================================
// Implementation
// ==========================================

RbfModelRBF::RbfModelRBF() {
    for(int i=0; i<RBF_HIDDEN_DIM; i++) hidden_activations[i] = 0;
}

void RbfModelRBF::predict(const rbf_float* input, rbf_float* output) {
    // 1. Prepare Input (Normalize if needed)
    rbf_float processed_input[RBF_INPUT_DIM];
    #if RBF_USE_NORMALIZATION
        normalizeInput(input, processed_input);
        const rbf_float* in_ptr = processed_input;
    #else
        const rbf_float* in_ptr = input;
    #endif

    // 2. Hidden Layer (RBF)
    for (int i = 0; i < RBF_HIDDEN_DIM; i++) {
        rbf_float dist_sq = euclideanDistanceSq(in_ptr, i);
        rbf_float width = RBF_READ(&RBF_WIDTHS[i]);
        hidden_activations[i] = computeKernel(dist_sq, width);
    }

    // 3. Output Layer (Linear)
    for (int j = 0; j < RBF_OUTPUT_DIM; j++) {
        #if RBF_FIXED_POINT
            int64_t sum = 0;
        #else
            float sum = 0.0f;
        #endif

        for (int i = 0; i < RBF_HIDDEN_DIM; i++) {
            rbf_float weight = RBF_READ(&RBF_WEIGHTS[i * RBF_OUTPUT_DIM + j]);
            #if RBF_FIXED_POINT
                sum += (int64_t)hidden_activations[i] * weight;
            #else
                sum += hidden_activations[i] * weight;
            #endif
        }

        #if RBF_FIXED_POINT
            sum = sum / RBF_SCALE_FACTOR;
            output[j] = (rbf_float)sum + RBF_READ(&RBF_BIAS[j]);
        #else
            output[j] = sum + RBF_READ(&RBF_BIAS[j]);
        #endif
    }
    
    // 4. Denormalize Output
    #if RBF_USE_NORMALIZATION
        denormalizeOutput(output);
    #endif
}

void RbfModelRBF::normalizeInput(const rbf_float* input, rbf_float* norm_input) {
    for(int i=0; i<RBF_INPUT_DIM; i++) {
        rbf_float mean = RBF_READ(&NORM_IN_MEAN[i]);
        rbf_float scale = RBF_READ(&NORM_IN_SCALE[i]);
        #if RBF_FIXED_POINT
             // (Input - Mean) * SCALE_FACTOR / StdDev
             int64_t diff = (int64_t)input[i] - mean;
             norm_input[i] = (rbf_float)((diff * RBF_SCALE_FACTOR) / scale);
        #else
             norm_input[i] = (input[i] - mean) / scale;
        #endif
    }
}

void RbfModelRBF::denormalizeOutput(rbf_float* output) {
    for(int i=0; i<RBF_OUTPUT_DIM; i++) {
        rbf_float mean = RBF_READ(&NORM_OUT_MEAN[i]);
        rbf_float scale = RBF_READ(&NORM_OUT_SCALE[i]);
        #if RBF_FIXED_POINT
             // (Output * StdDev) / SCALE_FACTOR + Mean
             int64_t val = (int64_t)output[i] * scale;
             output[i] = (rbf_float)(val / RBF_SCALE_FACTOR) + mean;
        #else
             output[i] = (output[i] * scale) + mean;
        #endif
    }
}

rbf_float RbfModelRBF::euclideanDistanceSq(const rbf_float* input, int center_idx) {
    #if RBF_FIXED_POINT
        int64_t sum = 0;
    #else
        float sum = 0.0f;
    #endif
    int base_idx = center_idx * RBF_INPUT_DIM;
    for (int k = 0; k < RBF_INPUT_DIM; k++) {
        rbf_float c = RBF_READ(&RBF_CENTERS[base_idx + k]);
        rbf_float diff = input[k] - c;
        #if RBF_FIXED_POINT
            sum += ((int64_t)diff * diff) / RBF_SCALE_FACTOR;
        #else
            sum += diff * diff;
        #endif
    }
    return (rbf_float)sum;
}

rbf_float RbfModelRBF::computeKernel(rbf_float dist_sq, rbf_float width) {
    #if RBF_FIXED_POINT
        if (width == 0) return 0;
        double d = (double)dist_sq / RBF_SCALE_FACTOR;
        double w = (double)width / RBF_SCALE_FACTOR;
        return (rbf_float)(exp(-d / (2.0 * w * w)) * RBF_SCALE_FACTOR);
    #else
        return exp(-dist_sq / (2.0f * width * width));
    #endif
}

void RbfModelRBF::printInfo() {
    Serial.println(F("Model Loaded: RbfModelRBF"));
    Serial.print(F("Normalization: ")); 
    Serial.println(RBF_USE_NORMALIZATION ? F("YES") : F("NO"));
}
