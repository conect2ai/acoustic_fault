#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][16] = {
    {-1.7206594443641738, -0.5621688278724286, -0.28436546582749783, 6.8285783781561396, 0.03559836680547002, -1.635958092197123, -0.7484885662820235, -2.567825843740319, 0.6279876417084403, 1.9255843284123109, -1.1767000558051464, 5.615163731384614, -1.8071075168570068, 1.5815186824830594, -1.6090915851220084, 1.532218065557297},
    {-2.5163295356305166, -3.250860641049515, -1.665880044851842, 4.269911765506891, -3.7318510354100707, -3.6100613684153906, -2.894348031644199, -4.841451661031496, -0.0466053979978028, -3.1154716263200735, -3.4526859780188923, 4.383667795836437, -2.6449349514569667, -0.1677674588049934, -3.9683996566656483, -2.013249355019543},
    {-3.3292539252126843, -5.425704260148011, -4.368274268572798, 7.039757649646566, -5.142712412769368, -4.477193115156838, -3.5927689890133023, -5.381512267436738, -4.063443053780194, -3.8830673285286936, -5.971971460998287, 6.090574933071292, -3.5086400770960378, -0.35374787851005823, -4.771442494670651, -1.4247560424946963},
    {-5.819716302923652, -5.10277879091214, -6.442866848854056, 5.170107901775646, -5.550837739099151, -5.223468007178197, -6.00718565983591, -6.154268159815089, -3.829734511753539, -5.277994002877412, -5.195397240935893, 5.332133797395772, -6.153541065659851, -4.85620442834706, -5.485927290415166, -3.0823552131802017},
    {-6.185134295785981, -7.220154893527029, -6.451733487580479, 5.976429408738802, -5.892264366036577, -6.462776340679912, -7.082602416487282, -6.491226781421631, -5.269343247344873, -6.496818665676421, -5.672003768896255, 6.626644283981112, -6.808202757558264, -4.8924032184279165, -7.325686947041682, -2.707879040119683},
    {-5.9431909045589215, -7.118152441477553, -6.933272736831939, 5.4520376271304425, -5.511080792283923, -4.8317468069864296, -7.232506652057643, -7.01760113561752, -5.969582164195906, -7.1417698172775905, -6.186063977296725, 4.946511112051685, -6.742140341318663, -3.685421489873343, -7.449338261330168, -2.6806006888089318},
    {-6.5021788861484335, -6.644675535350181, -5.32883195919112, 4.410653626519155, -6.894610708743119, -4.7841652748329535, -6.930561941686788, -5.628627310358656, -4.514171338441815, -7.647901041253814, -6.952099571053677, 4.4334553466489375, -5.6089235993489845, -4.012880653142104, -7.381728171553768, -3.1729009000636994},
    {-6.017311110602275, -6.010359400768911, -7.134487609731915, 5.258133233831843, -6.629501435459021, -6.471511417005946, -7.696862017854885, -5.785790407312887, -4.301768858773712, -6.4047003321506315, -7.002873095583192, 4.774633669468238, -5.940410708104696, -4.43979219386889, -6.355672512907237, -3.343361784356903},
    {-5.949969150095703, -6.2005804346983115, -5.566096370325287, 3.509537032480441, -6.05157885061518, -5.768512191058587, -6.588965559037251, -7.361182447422348, -4.510060576163242, -6.259257623356644, -6.902617588597407, 3.9302494080088874, -6.841398100049012, -5.178133289191638, -5.862158722480905, -3.5679743698254787},
    {-4.884618347327867, -5.455101423793085, -6.183902789582528, 5.667308010940844, -5.787477814898763, -5.663171714777356, -6.85495484224231, -5.314270409797924, -3.3771250837200846, -6.355149590378776, -6.999690058644486, 4.392248748472131, -5.561579452347945, -3.1843425350818335, -6.483803002942845, -2.928860776855563},
    {-4.031219584583495, -5.53027681789761, -5.942784776998847, 3.7477110305101706, -4.960969848157987, -4.555114961251737, -6.13323768690696, -4.935462638951164, -2.2939364914358236, -5.127567687626865, -5.575075361103055, 3.2169968354149514, -4.395667563712058, -3.2696029166837848, -5.869171573604674, -1.752176841531766},
    {-5.070753277021988, -5.655793406351719, -5.798162957583939, 4.351225309690186, -5.85301884406214, -6.540055848376044, -6.656904768559028, -5.354593894343034, -3.3034189762902124, -5.17627723199019, -6.714417275656371, 2.99814841351023, -5.470744452542764, -5.235122614178932, -6.150048156674339, -2.272822161189142},
    {-4.767329418506613, -6.007990822722321, -6.114583790169616, 3.688334562561604, -6.158683117715109, -7.167661478478355, -6.840001602976691, -6.546068099712409, -4.487488016339191, -6.373713292153441, -5.853651456121756, 2.4825006342869926, -6.53724423337127, -5.300609883792761, -5.618456083516829, -4.319310757653878},
    {-5.013362686017428, -5.853305668527831, -6.6993405949935365, 2.550340364837325, -6.055426455760585, -5.264523246071343, -6.212088674212139, -5.052879712321242, -5.130242265777691, -5.9410251893392045, -7.376327603005631, 3.7067454759732374, -5.740357840491431, -5.327987202611869, -5.477455319775897, -4.039839934278951},
    {-4.621885064864205, -6.261022851585589, -6.166247644988465, 4.897216746254949, -5.572431775698377, -6.093003806037909, -5.774360997183742, -5.906903944277621, -4.710639311069459, -7.393539925075524, -6.827688665156402, 4.410436876707611, -6.253598804325832, -5.60863389986836, -5.833906910630944, -3.222967547213748},
    {-4.9789301104478145, -6.470022702390562, -6.383891815086529, 4.677792180968437, -5.926190859698299, -5.347728456600444, -5.826525616743403, -5.6940330129322385, -4.344956317310862, -6.0530615804471415, -6.775993322591187, 4.769268607457235, -6.1363847484134775, -5.21957251382703, -7.117412376984773, -4.5923632016332965},
    {-5.265136761099916, -5.750236927646982, -5.757307521504542, 5.860360615246801, -6.947238920047724, -5.071887447320593, -6.879156875472431, -5.629693797115673, -3.9473792956537292, -5.9966763019567875, -7.083895335832105, 6.724761810469415, -6.153558187709639, -4.394754862390645, -5.998233403279758, -4.013130560564473},
    {-3.421885324931683, -4.841857639761622, -6.471592553199538, 6.587276440608407, -5.826152788307507, -4.191767807769717, -4.102906596268352, -4.4469915405537845, -4.366938506659399, -5.720585223078255, -5.466136521610428, 6.642587503587054, -4.581562735942027, -3.271959550023138, -5.188520737443076, -3.1637798409298297},
    {-4.57374631617485, -5.102324534704486, -6.653808468775536, 6.409502272900198, -6.015430462921872, -5.351724871958359, -5.218034868218136, -4.434776715689293, -4.899606593463126, -6.497446343849082, -6.296316971642447, 5.159243589537448, -5.579329317475613, -4.204773190463416, -6.137266640969634, -2.751161991193317},
    {-4.5000979644586945, -6.790773275504958, -5.258851488150012, 6.229877414531341, -4.967501767836302, -5.59818962480017, -5.445435211812896, -6.361659260871549, -3.7756605470738642, -6.339950257056584, -6.654205456469808, 5.354260596092317, -6.287131303591871, -3.201882104245348, -4.923979930147185, -2.4939472262754836},
    {-3.718148571638945, -5.460968064664233, -5.813930554514442, 5.558308486335797, -4.9781601181655, -6.524612935713519, -5.136778628151803, -6.379757461382828, -2.9597419211316764, -4.3462243328273376, -4.936880987992391, 5.9901861900719275, -4.896251358281029, -3.7548719828189365, -5.28616509255707, -3.8933926059718527},
    {-3.4311918237575583, -4.62718689494194, -4.408955113587326, 6.843956580755527, -4.126752882581516, -5.982516114652571, -5.456385807614631, -5.744720742443045, -2.334533882179239, -4.7440965560844734, -4.994463964902582, 6.062623571672433, -5.600331583447863, -2.602065870367778, -5.613977514927032, -2.6286263838335597},
    {-1.4237066299987533, -2.3788114535945137, -4.196149428709167, 6.263982616566918, -2.9427519358873577, -4.795391321520554, -3.20171655651751, -3.3058728671861703, -1.8030023695894133, -2.8486548762147206, -2.1215822728605698, 6.7543287905116225, -3.318337837764703, -0.16348402403212475, -3.759150243556812, -1.5547422142083809},
    {-3.709991854307741, -4.010285391015502, -4.4078716544604175, 5.212488152457193, -4.505842799889912, -4.88261402499773, -3.7458875733875283, -3.7440895611915934, -2.645225304821652, -3.654672136298437, -4.882178672361124, 5.737275270475253, -3.2186845359738547, -2.629095019344078, -4.257746465739871, -1.4633428116675276},
    {-2.630959688041368, -5.925626540810251, -4.24734025771554, 5.206409689427023, -4.946544862697007, -5.698093993235143, -5.354518839813402, -4.699990249306095, -3.1269781298752335, -5.2079117583395, -3.943784194111079, 4.501105545636647, -4.338479179393222, -3.8084129186017655, -4.004362823459515, -3.6044335520875994},
    {-3.40415482087129, -4.489094009143287, -4.14416997455765, 4.798637015218817, -4.6475160278602, -4.278528114830634, -4.059816204042115, -4.034298497767199, -3.465968855459678, -4.512026478550649, -5.020542929009501, 6.46391028336499, -4.063985983101793, -1.9961621925912265, -5.411470561229574, -2.586157465945357},
    {-3.348342919097286, -5.208026016724423, -5.713003771983918, 5.26159643139426, -6.501759391822616, -4.592459358698594, -4.612141930158546, -5.755934434369548, -4.101364560622758, -4.076181748666015, -4.8058266878667455, 5.914159942382533, -4.253123033417235, -2.147945494139528, -5.31678718560906, -3.462003360350856},
    {-3.6757268652698913, -5.146165408228328, -4.378695751070832, 6.374344565727455, -5.687865473983698, -5.717288686085297, -5.405432337644617, -4.977792897450278, -3.9109483806834904, -4.327215850132524, -5.615627303414868, 6.162008566742312, -5.315621512412367, -3.4095424584782337, -5.068570135646534, -2.5407858094975264},
    {-3.506339030505684, -5.813314291752207, -5.6158348249787045, 5.851191712957664, -4.688400710821769, -4.390360876480831, -4.053374047624184, -5.084878068778204, -2.992741099598313, -4.7786777599092245, -4.329951234294538, 6.281363110083501, -5.419753352803052, -2.2468458294595983, -4.7260967534579725, -3.9100095611692627},
    {-2.2257281760107497, -3.7539135320227666, -3.3188600001047317, 5.338068262880208, -4.445027042842875, -4.900096329071338, -3.8369829984249515, -5.687075116718465, -3.1658785022892477, -3.1859662392546384, -3.404925985966411, 5.258598895405959, -4.002568984134957, -1.4773726172882538, -3.4391281148564476, -3.0662760271366496},
    {-1.9717523175568314, -2.986765187065006, -1.3128838280302848, 1.7678869985735703, -3.7805576330833848, -3.219335786261831, -2.4218947545198595, -3.1531694847759937, -2.6945632795784777, -2.607205318102411, -2.238462135158656, 0.5663689062808047, -1.4573078131850408, -0.5576358032194424, -1.461804118574508, -1.4272875442533608},
    {-3.4559255677089005, -3.6917786267064105, -4.394639558611735, 2.6936096208217095, -2.977761919774107, -2.8899325604163577, -2.5592366021181094, -4.637628672884189, -1.5635167061589745, -4.043408817952294, -3.763785728815775, 2.1087848732099985, -3.1082178382493324, -1.2421042724957276, -4.042581537179678, -0.9840385197055227},
    {-2.285589650272624, -1.684355898351842, -3.3074905512287156, -0.31641491047466475, -2.998885592510933, -3.0337363043068484, -2.5370443035236527, -2.4322504006992247, -2.70294311721985, -3.7774377756357413, -2.7093924217987206, -0.1706761942468616, -2.6441764562647068, -3.233437329625275, -3.1236506880160206, -1.0209758928322628},
    {-1.6813968159440738, -0.04126766133039988, -1.3610466203825462, -0.9628849061255366, -1.5157300985470274, -2.1643147983284377, -1.9033414400822761, -1.0033597793174294, -2.2010779573447463, -1.2736964097099088, -1.2990707403211113, -2.0755260775118947, -1.8594462480851257, -3.515644938914173, -1.2186253238346252, -0.8009399431838643},
    {-3.80424864049476, -2.9627984473673346, -2.9176421478683507, 1.1546801624293406, -1.3397025803804503, -4.218072233588107, -3.165191124983776, -2.685716116927959, -2.718571676474949, -4.2369157344828725, -2.988882075053684, 1.8581272706332326, -1.4173333055592885, -2.5149124740340816, -3.409941870043347, -0.8329562368915474},
    {-2.3843198205134852, -2.1541923397511265, -3.1807872370429977, 2.5139866370511124, -3.923656557964214, -2.30715164600571, -3.2083795306450478, -2.610062060064777, -3.5142896984094505, -3.3256174980779245, -3.8632375200498212, 2.045149406525084, -2.9313141863460945, -3.5904367634199863, -3.1821326158122774, -1.2983277965689666},
    {-4.659008258296541, -3.0550485832852985, -2.288807143640225, 2.548384913300651, -4.14125245349764, -4.212471451302112, -4.462459780951654, -3.7872448553363807, -3.3620744793926978, -4.925333140105577, -2.7969721845405884, 0.38911251869964075, -3.1832873449942998, -3.813285828144155, -2.8128611124134966, -1.1181709335183876},
    {-2.149427181813925, -1.8214684826013796, -2.8428783500258916, 1.7331749592522832, -1.9834290402112995, -2.211106973565883, -2.3388438264523628, -3.1916513422966766, -4.08851557628559, -3.2005445897153986, -2.4739113831389328, 1.6901568286978148, -1.8164217829526663, -3.649026915431322, -2.0993738325552713, -2.1314324508657876},
    {-3.985241448434067, -2.305040344464902, -3.631793441271672, 1.6645377260776641, -3.879821082736037, -3.579245972131949, -4.301254476924158, -3.533962529989874, -1.839662964040901, -2.965758332016437, -3.622845785639737, 1.4430769341300038, -3.271238667926789, -3.4514986772203846, -4.12145243696851, -0.19299931159101447},
    {-3.618941507591325, -3.8323197540721683, -4.036516817821984, 1.4806276829898806, -4.060977248070541, -3.9093364000357766, -3.3295959447310994, -3.8188192340740876, -3.8863075713190853, -4.312970303969439, -4.164345755120687, 1.69597965152881, -4.361240760085898, -4.089951618828293, -4.151628882587231, -1.1654555845486845},
    {-4.587569275911244, -2.445833488773093, -3.7748263192407103, 0.1508747771805456, -2.796706598861195, -3.93335814401036, -3.309794754407899, -2.590550048446343, -3.3581958483738727, -3.371157496098128, -3.905151544090113, -0.8059706466627019, -4.147129668002016, -3.136072141879549, -3.2594896887097313, -1.2267812001716383},
    {-2.4932211113518035, -2.743533003683826, -2.877894272075547, 0.7111553098687865, -3.843157806171478, -1.7932918108587712, -2.223298576112743, -3.1569892825780563, -3.1161257277304975, -3.3236948183359085, -2.633794522804652, 0.27615852424795884, -3.7423097319331586, -2.9151521704946366, -3.413887253009562, -1.481281453212418},
    {-3.763709035363523, -3.03484588264692, -4.338928990536648, 2.00857091849137, -5.561393788334963, -5.00899018909262, -3.749051897514753, -4.209386801409271, -4.383944654385385, -3.582296568532291, -4.623176515245609, 0.6910360220396597, -4.764531308320945, -4.55520621221163, -5.397516468490191, -3.0211078098932913},
    {-2.9528902866567175, -3.36150406618316, -4.009155082046724, 0.8751977135706877, -4.8628867119933945, -3.5029267116162663, -5.830250964678452, -5.1443432347440226, -5.603963732724013, -5.509592881540252, -5.524380530177581, 1.4870300831466123, -4.328194191521976, -4.461207788801937, -4.945769098095757, -2.4831176858841673},
    {-3.986472553482365, -3.537808387313656, -3.3641961757698096, 0.41145556441677195, -4.920298034750366, -4.204191425042768, -4.976463584415841, -4.247712739715076, -4.525350866435261, -5.542571214367901, -4.109016854620067, 0.5499786373964004, -3.749534634839853, -4.490085489881697, -4.243964400359196, -1.5703345619830953},
    {-3.434025636578404, -3.6699120824648386, -3.89034712839728, -0.7542418551185074, -3.896834098563509, -3.24801315750856, -4.08741817225265, -3.98668654454503, -2.8572280005263817, -4.507209682957027, -3.038071819250622, -1.2238564157246192, -4.251771851197395, -3.418545621578788, -4.352363219403309, -1.5282337448482706},
    {-2.947791863286381, -2.157552025033566, -2.3678019146465266, -0.08370981849504558, -4.201903639295999, -3.069477282518194, -2.797494905397268, -3.0359658474260054, -2.216846079777605, -3.1533732641678656, -4.085651235684045, -0.9057059421330421, -3.749661536052104, -2.9553876186973422, -2.799973016602327, -1.2051235956982203},
    {-2.076761524945342, -2.482602434252371, -3.571445265790614, 0.26945458841428116, -2.3891392938370384, -3.2371776605297353, -2.0581455134770565, -2.9548467736496264, -2.2000348603423, -2.915047538385774, -2.3392636331228625, 0.007714169003399718, -2.1766268622579763, -2.746564888959094, -2.0773431751559257, -0.3341064905904912},
    {-4.548375802559051, -3.263353679695252, -3.6282253027119458, -1.2394676322817268, -3.4731108640552524, -3.6633732136963606, -3.1178091870253066, -3.261135996868121, -3.5125668504035095, -3.3022964301008484, -3.7027585967395655, -1.2955706707179753, -3.591611269603919, -4.39233846410646, -2.779096081509733, -2.0558868658398866},
    {-5.3163342344422375, -4.010433882075596, -3.1227270413623796, 0.6685654104288877, -3.356585993577287, -3.9098174737603975, -4.441336841311764, -5.108516202784738, -5.8078616859299705, -3.784204395008646, -5.51644889427691, 0.5142769982566953, -3.809575180690134, -3.289362974139354, -4.3087700645581215, -2.472754005945585},
    {-3.891004259989858, -2.1972698337669123, -3.5845792917530326, -0.36964236562340796, -5.291501471981208, -4.828786389611343, -4.93973034062264, -4.05873798093246, -5.000226483192894, -5.019589105229687, -3.637957000390339, 1.0957251998677746, -4.084358059926002, -4.402398705407666, -4.054951711031442, -1.8855846505107128},
    {-4.6970015233171605, -5.125814774101214, -5.576504627974094, 4.457241278306821, -3.9062948358083642, -3.9664744204464784, -4.113893015991153, -4.1503033861671135, -4.501409170507883, -5.500427002061485, -5.787500740718164, 2.990447020456104, -5.636558513447403, -4.47937380906839, -6.019861681500372, -0.9925744028562375},
    {-4.852491175793634, -4.879266974551108, -5.016188647730205, 4.231760220988351, -4.166150244419496, -3.499745227578607, -4.182577833046696, -3.861531481198477, -4.415681465166346, -3.468018853650034, -4.500226418653833, 3.394488874511197, -3.686448647625981, -4.256604700809496, -4.606278216432125, -1.335613389215761},
    {-5.322150895420254, -4.6817082835636565, -3.4304020645166284, 1.0166262212962498, -4.683394389295785, -3.1583430053032986, -4.221245160183654, -3.038428567081747, -4.524462063639356, -4.004169865083666, -3.8398992484000756, 2.297582878019491, -4.541929287846827, -3.8247791723758273, -4.7611390785653, -2.430607520127032},
    {-5.502237061791903, -3.486789598918267, -4.740113638031652, 0.6161666845802246, -4.715841696786519, -5.187110522974115, -6.045505089940818, -4.328905920816213, -6.3112283307155685, -4.606206987042551, -5.551436033759655, 0.5775210592271688, -5.7106624414159715, -4.580096404740034, -4.509622999403212, -1.5154551883522476},
    {-6.074405360379527, -3.2138695222432507, -5.269600623885158, 1.682194198233339, -4.0065698601856425, -2.7734528442870263, -3.97103389914663, -3.6800265271074837, -4.338946626373121, -3.691028770524347, -4.538653581271264, 1.1690156859415726, -3.2002604630176474, -4.430580566768741, -4.359368617297259, -3.0547882555164465},
    {-5.644488018848524, -4.9770280108756815, -4.505226719150814, 2.0476222028274162, -6.086725587247612, -4.550529828452003, -4.7093932907498255, -4.777315576455446, -5.0614600398822835, -5.04572414805994, -5.37803778359842, 2.0573174594978347, -5.241301529944421, -3.7816515847061813, -5.248525857676798, -3.2235512741753607},
    {-6.421881458682291, -5.790334720518714, -4.3506506495564965, 1.3031085868125498, -5.9916446063745905, -2.7975837273562294, -5.0393550510187834, -4.465653954328953, -5.536234012937974, -4.220773173582645, -3.6903202278029252, 2.150531926295958, -4.272694124762173, -4.5046486563488815, -4.815595059985448, -2.6652880542508863},
    {-6.192164264359722, -5.690928835779432, -4.97662706191845, 3.1949757271259647, -5.131271774606098, -4.368289342991511, -6.180650736990008, -2.9635805522523944, -5.89282901833569, -5.064721223516822, -4.453191751127002, 2.958074083634421, -3.900412714210348, -4.356061438765136, -4.39370137289701, -3.146853560950479},
    {-5.538566798392197, -3.713958834415257, -3.1424778496128236, 3.3912779609514767, -4.968033495156794, -3.4092387121880168, -4.774819970794128, -3.4828773104987603, -3.6421146286805968, -4.225001835506726, -4.3750680718782, 2.559151960925486, -4.293390072133305, -5.360871088449509, -3.7862682435824815, -3.170209899948907},
    {-1.1980467406859319, -1.0712732696599525, -1.1852397759721651, -2.806396003131582, 0.2170752358192838, 2.519980688933946, 1.6660871927555954, 1.0245363007734334, 1.446743572163705, -1.1446422183812983, -0.367002500833197, -3.307852047803211, 0.289589735532616, -3.1454048449904985, -0.9019236651424539, 2.8576018521103257},
    {-0.410079896418409, 0.9405194857957925, 0.3719106505886112, -2.3184451612390613, 1.766367307759024, 2.3453857183898648, 2.9495580650382687, 2.4025841881671504, 1.933038738238033, 0.6475477869983507, 0.7510238821341637, -2.059370139050425, 0.6952981201640013, -1.431178975366482, 1.0639446084653996, 4.0298919478572515},
    {-3.497705321185057, -0.7877703921906529, 0.5844296069051449, -4.082556941720722, 1.8307611564498096, 3.6130812002181836, 2.248398351541752, 2.7700540261137556, 3.1843806397172574, -1.0588764026268442, 1.755823482864839, -3.376533216693623, 1.7751475488019448, -1.6266341967009663, 0.6467421895497016, 4.1095875585682045},
    {-3.3479678496088154, 0.3571552679081306, 1.0337478987950184, -2.4422210305323, 1.7993559346375823, 1.9279745687584944, 1.9023249287102142, 1.7074514333020963, 3.4805178293650365, -1.2383441897443095, 1.6701756847672027, -2.835766993139022, 0.8050939465736812, -1.444928696678929, 0.19169071159373877, 3.5714859680483264},
    {-3.382135264375713, 0.7161040228011537, -0.08287546012765784, -3.643205040273144, 1.0640021410626184, 2.8816554672705927, 2.370771269991867, 1.8115088171779326, 3.4033735757449013, -1.6475491060700653, 0.8954099317660401, -2.899973267000961, 1.5494814048877974, -2.0059787834220373, -0.2596203761688079, 4.117132335863193},
    {-1.755900899588245, -0.45764943026294097, -0.16540563999620833, -4.223365641825287, -0.023144380359924648, 2.3428285634705035, 1.7846454690132756, 1.7912660124546333, 1.75417852876748, 0.02362854805334402, 0.4015065309129651, -3.2051987246802796, 0.8803166244854357, -1.6043741068452304, -0.6862008687159806, 4.144752153787007},
    {-1.8503561104228519, -0.27482719549833556, -0.6873661806315922, -3.5925952414593145, 2.2874699107678995, 2.565971598649672, 0.03165677980412232, 0.5191696233976593, 2.5254953141125074, -0.5212972267198955, 0.37564240065588445, -4.032559469623878, 1.672072736107045, -2.8461259819390397, 0.5256123103594379, 4.664910493816986},
    {-3.1002326464790775, 0.5801169356927013, 0.6201507477801511, -3.1574301988575675, 1.6464426667224334, 3.392523559579961, 1.2988282088101457, 1.4480051908727527, 3.121583028885362, -0.645267019111462, 0.417846164407386, -4.461033798664474, 1.8109174732898266, -2.307811965083793, 0.5043304039030634, 4.633507159652273},
    {-2.638215342635934, 0.6401385858790979, 1.4212918213905497, -4.040694071081475, 2.84924006262018, 3.566958164932123, 1.7076121466944154, 2.481718501374075, 3.229631834304573, -0.9278364091513471, 1.0771383404862669, -2.7051678968463797, 1.9573278168049435, -2.8091145125042494, 1.1506832165479801, 4.769392150562564},
    {-4.410997882491271, -0.7898099031866781, -0.458252100480245, -4.259087665789707, 1.6125665456381655, 2.276018155859822, 2.0924981735045893, 2.7314009162296258, 2.153600253327144, -2.083432812852697, 1.099637703506279, -4.155108804205726, 2.026428521482962, -3.9024289199459887, -0.678603301046573, 4.306948707416465},
    {-3.057887288433844, -0.8253043009999116, -0.6691252773326136, -4.187640758205646, 1.0084184033553163, 3.1637218902369293, 1.7247339297225694, 1.2362697331465848, 3.026749477447987, -1.2065828154624214, 1.029266806289256, -3.248056810443439, 0.7617182555534906, -1.952805841113019, 0.2093307270059905, 4.998609277646373},
    {-3.3032943294596415, -0.8395274401865849, 0.7261033608341976, -1.6385054577424087, 1.8332267219012925, 2.5535957531487465, 2.448071076862761, 2.298266218684949, 4.104710008042993, 0.03414701267669216, 1.7743708930233615, -2.963850832585739, 1.0227612785360256, -1.606362195172107, 0.5325294782606592, 5.193766098613},
    {-3.710980989665568, 0.21517449195046562, -0.3215553873482863, -3.63002251758296, -0.41081092048032786, 3.4184360505936815, 1.5945071304055447, 1.7400673679357228, 3.3949051068847003, -1.4267672502386541, 1.4591688245313439, -3.929157455720996, 1.4626020933789736, -2.8743489297145794, -0.7171327927144644, 5.37048757945415},
    {-1.9852237335485792, 0.37366900914493906, 0.41066506131109975, -2.8605212375678493, 1.0511698019630622, 3.2740597951442476, 1.3326788627127188, 1.4510756434877068, 2.801503153041228, -0.1909565164625379, 1.9636789348072963, -2.612390489612651, 2.4808550318089524, -2.3971848095754824, 0.5871612405035843, 3.443660923042072},
    {-2.0712834034160212, 0.5796082874382051, 0.6008675740382247, -3.260264333724238, 1.1472240184629412, 3.4356686098736366, 1.9876636034294421, 1.3898464591717845, 2.369836970470921, -1.097659185110491, 0.8316928589667003, -3.296608862859366, 2.22926082586354, -3.0941859207626665, -0.18636631948188107, 5.114655675368866},
    {-3.9832339500049674, 0.7558041658216779, 0.06631391935418375, -2.3361724639141452, 0.9294840326008343, 2.613837116457071, 2.3344216493088377, 1.385587894266922, 2.8436660839425487, -1.2295480420495795, 1.539146438653843, -3.3720707879065763, 0.3881357835365078, -2.3774561090377175, 0.5444617623798713, 4.863676022361844},
    {-3.4194169524333646, -0.7361922286672252, -0.18539984367964865, -2.810769275820799, 0.9565189967092448, 1.6313555275812717, 2.0719390424789617, 0.9660203628418097, 3.764393086963305, -1.7177341069746948, 1.7059137949256737, -3.0021755828362853, 1.6319561041239, -1.4556419744501217, -0.8290769049312049, 2.9574590240969387},
    {-3.5617819226731666, -0.48222828077817875, 0.1394073333144321, -3.457836480632441, 2.2439752562162396, 2.944794071418452, 3.26453511980974, 2.810270556106682, 4.7318387017401555, -1.6912412326475916, 2.5671944333159793, -2.80318751997604, 2.137576930787305, -2.6980095150198204, 1.0171422634947074, 4.1860279808693175},
    {-3.0574829121949763, 0.41366133609549144, 1.0226433988070633, -3.4277995123605747, 0.8855227419054238, 3.5904329157263732, 0.8831281750607654, 1.509003638823988, 3.9950149305146527, 0.08226010056049127, 1.8095640933781167, -3.3302512711196464, 1.7670953789344728, -2.7356616255238255, 1.3767541984818055, 4.174497487425639},
    {-2.9859612374771674, 1.1229010835994888, 1.29567968198412, -3.4641346891519555, 2.9712758542236415, 3.0985972142908187, 1.8341874841198396, 3.0572582137577817, 3.566172350317617, -0.46387514520632944, 2.0107398550059354, -2.5979288610028393, 3.073891446612942, -1.9629348297736755, 1.9823682734042747, 5.081941513740285},
    {-1.5693321276231535, 0.36257461002769226, 0.047123001665658984, -3.58117249193699, 2.561682694808278, 3.065891927483774, 1.305501253109188, 1.4519268293166399, 3.6994151151012975, 0.03253425546371448, 1.2537147100639363, -3.7387467735038764, 2.7735683350781417, -2.5193244839807813, 1.0084502148878998, 5.781045422047997},
    {-1.9540194249352536, 0.5742348009037325, 0.47829236285887183, -3.757110751532497, 1.4304376685741196, 1.6536531349330994, 1.5448052356564435, 2.50948202521741, 3.3583378008309133, -0.47435546918903815, 0.15407908085891867, -3.540496360970955, 1.435651015762031, -2.3484126604649056, -0.35855809034618435, 4.546955817683942},
    {-3.7232497542749727, 1.6356277487982191, 1.0406521129388646, -4.395587256442852, 1.1282990944863491, 3.419195907978151, 2.1258868783513605, 1.625299270877616, 2.6808205924624806, -1.0126482763459852, 0.8444453284005033, -3.563742982797792, 1.1635574068456163, -1.7126813813972028, 0.9695538699565696, 4.512555332700286},
    {-4.480838567169401, 1.4031392526913276, 1.0216153309842635, -4.432956600521052, 1.5022001771057116, 3.4744394070492444, 2.6524819440337866, 2.223647613924794, 3.476932764900463, -2.1438720786260665, 1.1989957908813578, -4.320623023112772, 2.7005198259696153, -3.1855585301722296, -0.7735367202040381, 6.037069587527521},
    {-2.2561518206085256, -0.2751702006816131, 0.6619443078332015, -4.506075333642461, 0.651105082174212, 4.1417705294928515, 2.596442366580215, 2.665130552341897, 4.450247425956208, -1.591410459506668, 1.6583986177511065, -4.395373591682772, 1.4003789876084178, -2.5471166498779665, -0.23307494969334588, 5.342520615610867},
    {-4.214668283152753, 0.06615546530742199, -0.19618804377841517, -4.948462874377398, 1.9108089036784368, 3.0502204937885202, 3.3383027632115367, 1.9669345591758662, 4.051585541992103, -0.5835420912386712, 1.022182947920969, -5.06879222852302, 0.7972702406705482, -3.175810811732245, 0.08106273130796343, 5.655878332344901},
    {-4.120426553146978, 0.7964575690517453, 1.2214857973131235, -4.766136240912985, 2.0262522090345936, 3.805792966506901, 2.317796874920213, 3.206370845237326, 4.560638080875186, -1.6303226567346867, 1.4473537056188563, -4.575954768574028, 2.4219187198350034, -2.4954424372328043, -0.011219213571906458, 6.285958757070937},
    {-2.761549825542207, 0.5904996122166424, 0.4977945004009226, -3.3882570186234124, 1.5794614568331924, 3.2993975312305297, 2.5592176954209442, 1.9819678388448332, 4.22256617171876, -1.9277818964187923, 1.7606590177407508, -3.797149600824985, 2.3715038625253144, -2.4948778935588525, -0.029061273209176952, 6.01872056041186},
    {-3.2191910361542098, 0.7638852823992456, 1.0711728735709474, -3.1502780175888985, 0.5682163233335289, 3.340291339220488, 0.8940394736053443, 1.5963268495356384, 2.338392455795976, -2.9225391596935224, 0.9249211561769948, -4.1079114234728396, 1.8931750700864793, -3.75977719539398, -0.44246506652438067, 5.304711807229419},
    {-2.8023278671428655, 0.4817345558229901, 0.4042496160417778, -4.251316557221759, 2.148406534692335, 1.5813320480559148, 2.1664591329998615, 2.210303246497021, 4.241398058668192, -1.465939295014258, 1.0793865663361344, -3.701863710817148, 1.7917310432707858, -2.5626243091392604, -0.1841500609217067, 5.033658918909184},
    {-2.848519972150977, -2.8215320322148743, -0.08101583777792594, 1.4659965044684455, -2.242061541974523, -1.450159174900074, -1.5559542189386446, -0.4516078273817404, -1.1707748990187832, -3.23563377986933, -1.691603280786826, 0.6662683830179209, -1.3812688110856832, -0.9657333432864046, -2.1076726167425, -0.838379341913894},
    {-1.8982861366278438, 0.017766504371569396, -1.280308704169413, 0.42156232199219695, 0.0384835402509443, -0.997069455331992, -1.2919790317454296, 0.7995722361358942, -0.9161066884960147, -1.114091708847271, -1.689527031560851, 0.20510188728638631, -0.17301666910621014, 0.5506005565002999, -1.3505378342343302, 0.1964522928997798},
    {-2.0283715808953175, -4.088126903395504, -3.6550600377143976, 2.4196881860315016, -2.7481278486444647, -3.4834162314565527, -4.169873699442303, -3.7312537083390005, -3.129812590841138, -1.932979089004177, -2.9067493740288826, 1.6972363460077693, -3.28566820916209, -3.087670212948908, -3.187141237920836, -1.4971968896637333},
    {-1.7693716794390868, -1.0421469674678219, -2.230927891069322, 1.1640913566842643, -2.333678292511577, -3.198792433888164, -1.8148334656759098, -2.277292093518628, -2.8617327187916377, -2.548127785797369, -2.8257373072413743, -0.09331428647325579, -2.9621320253094443, -3.5870285955063, -3.1231034241754454, -0.09115719408758709},
    {-3.1573114702356744, -1.2071647684217057, -1.7953397300510816, 0.16751329198738807, -2.3467903892872917, -2.6717159656021554, -2.272302149954929, -2.989710397792286, -1.5979034650858825, -2.5592909350727724, -3.0856283132633835, 0.9560574378514632, -1.639879216434177, -2.393377984721885, -2.9597433608530133, 0.9428636041011746},
    {-1.1840369526788093, -1.4401929054837153, -0.9945481403510494, 2.006617096792557, -2.0020668657184797, -2.0395336597074314, -2.635357986697305, -0.9374932043951385, -2.9895533394058873, -0.7588062198209244, -2.140134476092135, 2.309698374969681, -2.360379751700754, -2.067820483961609, -1.4023675374022428, 0.16975721128531976},
    {-2.1377618912740544, -1.4790455789215926, -1.294657710587956, 1.2838600490309264, -2.392662425944088, -1.8663310480256121, -1.672831627439539, -2.237574118056854, -2.0156300566958354, -1.489218843006255, -2.4717682255869984, 1.447437253443358, -2.928481219925432, -1.1118157328629343, -1.8709199584858702, -0.8638020767618215},
    {-3.4470445286165403, -0.1385859978595225, -0.8940194486611173, 1.0595379963366693, -0.9018361990081816, -2.0390433366970835, -1.216736633541104, -1.9376057049201239, -2.2869676088093205, -2.630144638995798, -1.226330697205007, 0.24603528338836023, -1.064179816442717, -2.588023009642938, -1.7880060381634377, -1.0486079539376907},
    {-2.5748468021209545, -0.8537286514940632, -1.4506830693377422, 1.102231576961195, -1.917317026409777, -1.9998709607908172, -2.1986393154962087, -1.7984393444769804, -1.6790886717859321, -3.0085513433662214, -2.1306058850111453, 1.8821805984267863, -1.014447007467318, -3.4748744668572296, -1.6842928345690105, 0.320077552190635},
    {-3.9928051963869637, -4.14947189182976, -3.8340333667389053, 2.8683919721281272, -2.851435745821896, -2.698932502550936, -3.8174747600214545, -3.544554892261067, -2.5109271983802746, -3.033354171433524, -3.4300037403013754, 2.567682694475549, -3.555995093841542, -3.258970549398105, -3.0005085949819863, -1.7258490012383139},
    {-3.527449045774697, -2.9480423155261954, -2.2799094833039413, 1.1726827559366186, -2.254300372690185, -2.6983109996928727, -3.5710323589604953, -1.8632209970347775, -1.5205042243474505, -3.4283084329114626, -3.607237596628663, 0.6009466217714876, -3.15462320328365, -3.6612400743332887, -2.114543763538973, 0.3001510366580503},
    {-3.8082938594837645, -1.8311196374822296, -2.7735160710388693, 0.3769301633560441, -2.9608697129118795, -3.0980840768241196, -3.0934135745873292, -2.7213113914615827, -2.864581086184445, -3.018230215053128, -3.6285391574389805, 0.008037219025644887, -2.0803201421313857, -1.6435548015534378, -3.214005008607414, -2.043733309086573},
    {-3.0356913115857886, -2.82147732321188, -2.834889863889428, 1.4912323341485, -4.231042172294142, -3.1033818026800417, -3.863604309030269, -3.9633804052115904, -4.773699327641798, -4.359158825562416, -3.6812283660088494, 1.9211604826734996, -3.112276371471292, -2.8283844169189387, -4.069404139699703, -1.839620630821575},
    {-3.2770030762583664, -1.5596718134870307, -3.0096501375039395, 2.3098563440919335, -3.854603246107528, -2.4932498549001734, -3.77023290416575, -3.4038823505562195, -2.840671775015173, -2.586378655210572, -3.223769656732357, 1.2128248285660579, -2.1136701914944247, -2.7140676204594834, -3.417578249154645, -0.7635104240826719},
    {-2.500201763231336, -1.3647675975025224, -2.2816484063872844, 1.995150631884699, -3.1743879813156717, -3.2846818306969245, -4.076330283017051, -2.075139570287269, -2.3191959426452815, -3.081053855071247, -3.011398762040275, 2.399971136454353, -3.012181199646973, -2.1093606770984517, -1.8641319732412063, -0.06585773466491816},
    {-1.9062151117601132, -0.4555452699727174, -0.2427911199637404, 1.7461073679029009, -0.9900230014807662, -0.9443340623033054, -1.1573209004723164, -0.4244989793293293, -1.4675695914608868, -2.178024526478349, -0.7946920319150708, 0.30339238992395556, -0.5150599507390718, -2.4816390929072174, -1.2665519847939717, 0.35469413703117286},
    {-2.39634966097152, 0.17698283065847664, -1.8675187206475905, 0.23859832397991568, -2.092698270998942, -1.2045276115235601, -1.2580945325071906, -1.817636973565054, -1.9876300305209063, -0.9755367462984617, -1.4626516778803698, -0.0543168737625914, -2.1826636214686035, -2.7996851971130527, -1.319791779505049, -0.2511486954315807},
    {-2.474212393992093, -1.7069157305410052, -2.2091692116289763, 0.5321273947468782, -2.909010271291225, -1.1833146935051515, -3.1232267919528938, -2.0202294577249287, -2.408724620593513, -1.4052467878402777, -2.6037882779980164, 0.529729037677753, -2.4726057029650947, -3.058578018130012, -2.6042369796804237, 0.6162737101001263},
    {-2.7783737278477374, -1.3451977152546253, -1.9780475849669548, 0.20376426321785251, -1.9311073316722593, -2.391542168200875, -3.202787500867544, -1.387650453687904, -2.2079544185462394, -2.460838643344591, -2.4044389240023922, -0.1331684586355733, -0.9755647292848918, -3.2445736009799666, -2.6041638154155025, -0.24723765256977726},
    {-4.101606058040692, -2.478608910250217, -2.8767432565840942, 1.436245334962226, -3.0098408018594394, -2.5469520271412875, -3.9534128697315754, -3.0582092371347867, -2.21314515611514, -3.548029865236504, -1.990110779775005, 0.2772259896360855, -2.4862710697942307, -2.8916664855307133, -2.187762670966696, -0.06037579019493854},
    {-4.985857658091323, -2.7681803491971224, -1.9017893983121932, 1.6644030258713927, -4.253356615715076, -2.0112043474622294, -3.6792863710080046, -2.6836673487654177, -3.6000843934410725, -3.3881817567608326, -3.8416389025318183, 1.7673452333245523, -3.6575236098945387, -4.126172363204494, -3.742008802571372, -1.3157905095892721},
    {-5.326478744959816, -2.97724308452034, -3.630754197922271, 1.5927397015551017, -2.8805112270977635, -1.953287840564352, -3.0017141678166697, -3.1409658455220346, -3.292774521589753, -2.791671147908427, -4.759788674018112, 2.353711128322122, -4.158395813811161, -3.563605862373003, -3.051352902394571, -1.134680028988965},
    {-3.8101054905671017, -2.4749615680301646, -3.180297581679767, 4.018008956735025, -3.959929561654698, -1.6146793517570561, -2.869401376427386, -0.9006756228769691, -4.143476024860501, -3.02734873242479, -2.9184234881462636, 3.848928100781928, -2.0316132431754186, -3.1294213320614124, -3.0805937262628573, -1.1525649610906417},
    {-4.8795282138124305, -2.638372215151748, -3.215040167696701, 2.8030159898279776, -2.554114643129585, -1.3645628404186287, -2.5918073838993223, -2.0718947887307797, -4.319342546969997, -1.8407050684718194, -3.769550003717875, 2.161300001826265, -2.307996822868247, -2.9577996993913556, -2.562521533326014, -2.32780757664075},
    {-5.586687323418533, -3.536309551767161, -3.2092069953608586, 1.4967332787148917, -3.361428645675249, -1.798457208855307, -3.444174452619219, -3.1503128895159236, -4.705837201420004, -4.984933678421863, -4.757376622582997, 1.8642802221616035, -4.095646654213742, -3.6584012996881343, -3.123435677481649, -0.9985427793735678},
    {-4.540186101703886, -1.535650310789181, -3.0665651550535746, 2.6417756754870094, -4.32976780197053, -2.2271666627124205, -4.201554886666784, -1.9765719171509046, -4.452389341281046, -3.377685196109578, -4.0448708940893, 1.5103778640065504, -2.273391678633302, -4.664264132898067, -3.6786751751543787, -0.3572129077024565},
    {-4.6378298585062705, -4.354753999426187, -4.062250183046524, 2.6806294519946863, -5.222536787213677, -4.00825356935296, -4.215480510178661, -2.2621874280046486, -4.587003557749449, -4.702230056954895, -3.962242952415883, 3.0002335099759034, -2.938934503624024, -4.90111765190379, -4.726295317892514, -2.381981270491301},
    {-5.273335752998831, -3.159236984012551, -3.394128893461315, 3.2175855521708723, -5.1314841598438115, -1.6178413660388375, -5.432901890398203, -2.4407154013727226, -5.447591795405357, -4.344540897998367, -4.646275121800186, 3.146905281234789, -2.8695621995794087, -4.133119371757223, -3.336133777604127, -1.6534548706560104},
    {-4.535854986221496, -4.263779433096972, -3.453733575041812, 2.6379505922715563, -4.484781995870562, -1.771579207319531, -4.440843326371422, -2.2734738058473587, -4.588752502543668, -3.398806485129162, -4.317999646019352, 2.989525448060904, -3.4827630010022608, -4.157835536797559, -4.083967018423998, -0.8166427117892731},
    {-3.8838661668931844, -3.395301920568266, -1.1826659897756118, 2.861718237241472, -4.295043863382472, -0.9873529317364391, -4.25862963332618, -0.7919148544021164, -4.433612789038107, -2.394291196853695, -3.611030246878342, 1.5552588000978944, -2.6992083616912774, -4.589173404738279, -2.583524525485197, -1.205891163099455}
};

static const float b1[16] = {7.964733722328463, 7.431187315532314, 7.085673891750589, 8.679553219108028, 7.371440951234867, 7.179104518544307, 7.68995800299902, 7.075718667581439, 7.617839946170007, 7.894721918939302, 7.541585928861294, 8.289974235045376, 7.740743315436146, 7.787334997461175, 7.730363188965644, 7.501814152819335};

static const float w2[16][12] = {
    {-4.1979352906319365, -4.494301569425732, -4.246491223210736, -4.30090386591167, -4.678399377224367, -4.650690133371667, -3.8828744195424356, -3.855365056802537, -4.441735310549937, -3.737418349222822, -4.086946779319145, -4.72508723163883},
    {-3.3417183210319905, -3.270219054553821, -3.60528676820079, -4.038371332578978, -4.350689282708991, -3.7277205831191336, -4.498180701028761, -3.1661200221757064, -4.699123116153788, -3.962210252005416, -4.938117049990196, -3.7488777892488314},
    {-4.365912373859663, -4.368202615406984, -4.915965305828466, -3.857429273160951, -3.132816227219091, -3.0276206668942747, -3.2966134581412514, -3.3227204597476283, -4.429009727175991, -3.110607405678236, -3.2695389835851345, -3.6066590731955257},
    {-5.547209158176534, -4.921767146881001, -5.588602488022036, -4.825421050280052, -5.008088867883487, -4.5583421851999875, -5.610357099260263, -6.3092011795320655, -5.495218738979659, -4.608162432851382, -4.833183666433855, -5.650865944994401},
    {-3.432178438576587, -4.486339916037686, -4.60233016862574, -4.065972887727999, -4.425798559419581, -4.848372406819054, -4.042520762200633, -3.2758187157498084, -4.322123988572299, -3.9712007712570876, -4.752558692439724, -3.499275324231907},
    {-3.9914094213230005, -4.816414637341885, -5.016136372463329, -3.834557896979847, -4.644248951320741, -4.465704678941111, -4.069456027595004, -3.1695701112509105, -3.166573665553878, -4.257755308849297, -4.600812315842861, -3.68159856350981},
    {-4.7523229901391115, -4.179729415103996, -3.444481057794575, -4.272889935618738, -3.3262835388459644, -4.536054289647565, -3.335320307840721, -4.868319147511171, -4.5107994088041075, -3.3686693719500513, -3.8399417151418294, -4.393150964252961},
    {-3.2371560452351225, -2.536752689978859, -3.6154215168084702, -3.7714754145303115, -4.601947145691885, -3.2490147328350143, -5.107876358166125, -3.589903494505712, -4.616501644392181, -5.1330113694974235, -3.2811456539303565, -4.3674064728322675},
    {-4.194833579036229, -4.137360588797049, -4.139056773060197, -4.2420391923980905, -4.234431367757156, -3.432611900780334, -3.495231713032809, -3.088116061596684, -4.749383070085901, -3.891000295203383, -4.530988551638495, -3.805334492051044},
    {-4.339717672983706, -3.399592650506838, -4.259883408224941, -4.52156005086297, -3.7472486114955244, -2.801156365633911, -4.621321990845285, -4.788817112240169, -3.938193224701753, -4.0979288113415455, -4.796869015678027, -3.911172512987134},
    {-3.122979231214899, -4.109154894580993, -4.531121775543961, -3.96289119579198, -4.584700402466777, -4.585391503463726, -4.457796582601237, -4.86533268723194, -3.39051601711539, -4.098179981640899, -4.948724442937181, -4.007834828256404},
    {-5.2167533071746375, -5.658124942397725, -5.107787887165574, -6.116670741277843, -5.742001509170403, -6.140349788101855, -4.991009454063975, -4.2753201117057795, -5.084880637640953, -6.157514407874652, -5.938772234341485, -5.018452677956808},
    {-4.9382941463861405, -4.028623468575827, -2.9508640862669906, -4.060054555578571, -3.6902796380616083, -3.7796703858793395, -4.702631724706643, -5.206462069366392, -3.8493570947927713, -3.8324990283138893, -3.0021951661276782, -4.380931413222115},
    {-4.33564314247869, -4.678792039156385, -4.43831577634237, -3.9039392929238823, -4.5819268899961925, -4.864665995745739, -4.914570428551812, -5.079176862787541, -4.576786973957863, -5.0147208529109255, -4.35578163554902, -4.000568383906829},
    {-4.631562272057989, -4.533592793701535, -3.3088150054917045, -4.005441189401985, -3.175501707995425, -4.810508853714307, -3.0411031390189622, -4.214215779345869, -3.3510316057141716, -4.693016319414408, -2.854004019158113, -4.977095402760016},
    {-3.9988150760873373, -3.889073091719274, -3.783563614082655, -3.882521560571143, -3.7419854565684556, -4.124955983478513, -3.9818621831618666, -4.824778379866331, -3.630410324927277, -3.844299459957818, -3.701344735387938, -3.9857020770391856}
};

static const float b2[12] = {-4.9851825159938, -6.602251383135762, -3.3624293053349157, -4.926847812050833, -4.827376493951668, -4.64656687176558, -5.0109788698928375, -4.905436913397553, -5.2455013599992215, -4.68246680280988, -4.585438955882438, -3.8528528168072946};

    // Input Layer 
    float z1[16];
    for (int i = 0; i < 16; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Output Layer
    float z2[12];
    for (int k = 0; k < 12; k++)
    {
        z2[k] = b2[k];
        for (int j = 0; j < 16; j++)
        {
            z2[k] += z1[j] * w2[j][k];
        }
    }
    softmax(z2, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
