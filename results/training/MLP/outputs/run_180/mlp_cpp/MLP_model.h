#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][16] = {
    {-6.797299998419744, -7.021710485863833, -7.3382544966683305, 5.651453121271701, 6.54009415142812, -7.573970853882305, 5.339495348870078, -7.6018138315798565, -7.286464459514013, -6.860506523573821, 3.4606211769701867, -7.575316157328897, -7.451734100480379, -7.3056622597203384, -7.004045841354537, -7.178111830710028},
    {-8.078189030640235, -7.216096291499783, -7.880128344430735, 2.9601642715389334, 2.175307710097167, -8.024692712021535, 0.8014729616129204, -8.000637583068627, -7.830263021939447, -7.578472706703177, 2.193125818980511, -7.830599190054273, -7.77172373720941, -7.514848166713279, -7.557209398545642, -7.829799169211058},
    {-8.435886201351146, -7.789024664498801, -8.63235181380732, 1.5780664860566898, 1.1243315489687378, -8.372232096403792, 1.227769396262871, -8.37415140895444, -8.609819920594491, -8.974167840975026, -0.10466931054490404, -8.826770940632514, -8.369756581438395, -8.005125390992285, -8.190356024104462, -8.462285127536116},
    {-8.779812557498888, -8.191952754073963, -8.400718993044038, 5.0255965731411365, 4.769262430270209, -8.43942521287222, 5.077020679449892, -8.416419319558296, -8.402443142537825, -8.33224509606525, 3.7390070171052625, -8.862119152316064, -8.165068793624982, -8.231202269454423, -8.612639434013806, -8.432612016283649},
    {-8.635669310851341, -8.167255926474738, -8.74627485026137, 3.8415948069532972, 2.5159393022600103, -8.82460418223028, 4.31420966134089, -8.620101638629938, -8.7303783014835, -8.657476340716185, 2.9260525286038255, -8.859644865117515, -7.9981788385120005, -8.728685640445573, -8.683212015742765, -8.838216612394888},
    {-8.354866234131933, -7.594559416422305, -8.110786316713455, 1.8871880267192471, 0.5764711816218938, -8.251823185203744, 2.004057489646116, -8.070354337929782, -8.232163723952933, -8.08116888384445, 0.7845814926702586, -8.374020010408515, -7.810486441822274, -7.835986100981297, -8.350854933846348, -7.921766544207493},
    {-8.27422090907364, -7.140530674958533, -7.666994301413519, 1.867907531712432, 0.4535930278301745, -8.310042439288761, 1.5733316071227055, -7.6643092837541245, -8.2390406471654, -8.078391450618442, 0.7575219602630923, -8.1014732137514, -7.553741039614336, -8.06073314920502, -8.03945596827973, -7.904786262761965},
    {-8.102528483137904, -7.144065952724822, -7.713682784834214, 3.5990242505435917, 3.7874273385821366, -8.069864566160314, 3.6890950229875186, -7.907313568757362, -8.072254495566563, -7.89885471847169, 2.7585528205754457, -8.07321577797938, -7.27752710405414, -7.401719404241798, -8.049027497239926, -7.992773001547848},
    {-7.9667234078854, -7.598527870500307, -8.001574448987682, 4.4104045263064355, 4.234919203268711, -8.052257583689792, 4.479372035686788, -7.82855197779752, -8.28107549666553, -8.263791458086576, 3.9541689131844167, -8.411681614996647, -7.457411610210792, -7.570796930558443, -8.086221392898851, -7.968789775909667},
    {-8.471729696687936, -7.609277409763008, -8.2969167128341, 4.458165744388299, 4.5417048456313776, -8.323707225388144, 3.8281191634763525, -8.119722370551166, -8.444602968006532, -8.35341635323121, 3.9642784101642428, -8.712061463945297, -7.8023688535580185, -8.11749818956051, -8.296714285435407, -8.183567748241307},
    {-8.095546478595113, -7.449347288428022, -8.045307980221233, 5.113902446540091, 4.466321197077269, -8.203052983237841, 3.5493821562746035, -8.0450439209693, -7.91160690202049, -7.977988792280863, 5.16563235281494, -8.188917122372816, -7.88230427829195, -7.777790452183685, -8.145974087915897, -8.2509472309326},
    {-8.420824950828754, -7.9639169636819, -8.186650905481185, 5.352851494987509, 4.7961665467410635, -8.300083967530943, 4.649728800116933, -8.239328841295272, -8.113873373653265, -8.265681082605893, 5.6327796848617915, -8.31488855183871, -7.823540278972776, -7.710659730296357, -8.106552525492368, -8.313809488722644},
    {-8.393744191225405, -8.502944058089316, -8.469950723643514, 5.145129499099598, 5.284703774343147, -8.65472000236958, 4.749631383388502, -8.556591216901703, -8.443229902203498, -8.476571059439364, 5.799475913847412, -8.420477567406063, -7.965945313297673, -8.230712766685356, -8.2699921485489, -8.476967875936554},
    {-8.460169494290446, -8.215713779911901, -8.508809003590134, 4.891773925335159, 5.044286566252653, -8.497088554185826, 4.3938056846316496, -8.20592865381537, -8.700835142749625, -8.617998980908373, 5.222438271929067, -8.57579789979707, -7.945746410628419, -8.178090505288779, -8.583541006874329, -8.644891952923743},
    {-8.549428413704977, -8.032753258190576, -8.46276672612661, 5.007145467190563, 5.017704896950391, -8.408336095259319, 4.236872022691631, -8.426436897631856, -8.555802195632488, -8.481413137942386, 4.532667244829991, -8.469178494803403, -7.680229561393352, -8.179647180407667, -8.289540967853608, -8.663855056587597},
    {-8.64670523887661, -7.8011292372918355, -8.36599335092826, 3.7143296526397034, 3.621075671487448, -8.522935925600597, 3.3824625161141713, -8.532454732008482, -8.441217620926285, -8.666123480982973, 3.5384606775909666, -8.345968648147636, -8.15651076959804, -8.12956408395318, -8.562853166347017, -8.60914249895597},
    {-8.545897587545785, -8.548811616091859, -8.326398224579851, 4.210619628386901, 4.049630636085196, -8.457613328892807, 4.567273615789808, -8.44268828887633, -8.336983190344622, -8.666235912597521, 3.5946877269992275, -8.517226039626554, -8.17795516730008, -8.14651338212594, -8.717094554731629, -8.635323721508005},
    {-8.661767368316747, -8.23318470928347, -8.442420085568479, 4.33069710143976, 5.343115859484669, -8.384820499588468, 5.014058530507192, -8.759167752608167, -8.490818928244346, -8.691786005325923, 4.167632941214299, -8.691691588450936, -8.030157754330258, -8.392180323373527, -8.507432187331005, -8.655635723670931},
    {-8.647009575271303, -8.40852919750893, -8.469283412578383, 4.917775546145547, 5.468473065441877, -8.439951758765718, 5.294499619369812, -8.434588029255156, -8.566465673798483, -8.652149630682937, 4.791321998435632, -8.515857422047405, -8.292157625588679, -8.363173422707954, -8.600893075275595, -8.45285227598353},
    {-8.385509610118756, -7.94777730258992, -8.229721174855781, 4.31139715322061, 4.890697615296007, -8.426518124913677, 4.580585020999752, -8.343752369683791, -8.504697557181707, -8.327423874045921, 4.744611830911992, -8.850625393643144, -7.976912190443868, -8.010540530629223, -8.745233756722637, -8.36877874591793},
    {-8.49275696975437, -7.785227884891735, -8.548637341302395, 5.07086213727552, 4.902456347330687, -8.47717522290123, 4.88540167610573, -8.628968532859842, -8.39682022026907, -8.62182333527554, 5.1933264885257895, -8.53993823255899, -8.006301045036412, -8.144981433967956, -8.79989323597454, -8.608461384200046},
    {-8.420410725865876, -8.100742559467454, -8.622110133546501, 5.207386230435653, 5.365384815931838, -8.574921206331997, 5.575371083444807, -8.62403668401299, -8.562268710324457, -8.385492698341267, 5.423003381528214, -8.41521752587564, -8.248808399790803, -8.044326927898732, -8.500818332789343, -8.467634722283652},
    {-8.232723876166919, -8.011594728864093, -8.511305762871917, 5.612004365643321, 6.11890000673957, -8.127183510261709, 5.868887279626634, -8.461479112077411, -8.718221102816285, -8.624099017192913, 5.193884707726734, -8.462362630398982, -8.182596814372276, -8.084928731382051, -8.202896157665123, -8.430106706961052},
    {-8.432020832336228, -8.09162746093608, -8.384249292954541, 4.9731772750578935, 5.345803755697448, -8.347017080271137, 4.871744862080903, -8.444193583370165, -8.503481491787435, -8.482432537392416, 4.781840042084514, -8.452362172447433, -8.02572575730304, -8.07878214053176, -8.26213142080311, -8.4028751155793},
    {-8.325551837236967, -7.6970151834708656, -8.326425478837972, 3.8875825411811995, 3.9336157622405787, -8.330086325919137, 3.763391726003951, -8.321087172817247, -8.171829835835378, -8.534618163818372, 4.385899899794775, -8.466203902229648, -7.96925623170412, -8.131246150514302, -8.403109698514568, -8.526446220919745},
    {-7.8632873650338455, -8.181032140454723, -8.352299952757507, 4.476238768848266, 4.707811758897045, -8.6719212798293, 4.874749147069664, -8.528242825144225, -8.059648201199186, -8.498984803493794, 5.232731087419959, -8.469622977400014, -8.242448662393906, -8.22383839249169, -8.493692286193944, -8.4355570891168},
    {-8.389665611311774, -8.320429027404867, -8.596505482896806, 4.460439900289218, 4.368894104856712, -8.518026492457452, 4.162963711759313, -8.427680360191243, -8.43335148928216, -8.714457683174228, 4.361305010321507, -8.626631242791342, -8.239058544562782, -8.264727026169831, -8.359992383516905, -8.592477572464592},
    {-8.340648202070126, -7.957677876524341, -8.413720253771869, 4.009006409669262, 3.7754299004719893, -8.727092229479782, 3.476855567477522, -8.561259736468378, -8.416578681053188, -8.73509843678405, 3.7411641461947474, -8.637903882694486, -8.331356867692623, -8.33399268303171, -8.445167089420472, -8.929018036568175},
    {-8.090625888725157, -7.57717894340183, -8.508761978452002, 3.3474287901447988, 3.2079484288977125, -8.295233236941826, 2.8153959225202, -8.492383450340514, -8.312974873471708, -8.613924603294345, 3.6087113800497628, -8.466590079485051, -8.009101864716937, -8.138725460553392, -8.114173156607853, -8.66388469012195},
    {-8.231045509651127, -8.022420790094332, -8.414131396112898, 2.901612690781401, 3.490703256530062, -8.709044324175627, 2.855712990513383, -8.680396695433227, -8.226125490442483, -8.447082132761123, 3.4155142910094463, -8.56398325414215, -8.184143195128899, -8.178759978623619, -8.370505427344451, -8.722647554060476},
    {-4.8803640913960615, -4.533749908445198, -4.294739270254483, -0.9245924007122088, 0.03086082149535971, -5.02298847732211, -2.2386257663286386, -3.769234821205006, -4.0670796264437605, -5.10533546361871, 0.2883666337850015, -4.824136484246428, -4.652724551276348, -4.392995149536337, -4.362579784777409, -4.804322109970397},
    {-4.21849424753504, -3.9172610479039127, -3.5886977553500827, 1.50896953523815, 0.7397308551361925, -4.799471532337583, -1.6303121343899916, -4.314994128522349, -4.01637653079606, -4.123795267485732, -0.9617856752237631, -4.698624108594397, -4.384490287171253, -4.081603248311904, -3.9314273035004015, -4.063917020379145},
    {-1.9237465445095672, -1.9538719147091914, -1.6978302197534385, 0.46700773940068074, 0.8873255810177274, -1.8006385028102094, 1.5719823230786092, -2.2178308354272485, -1.9732874612011144, -2.610761015102269, 1.140817952608472, -1.401332143518697, -1.7813203286880441, -2.2351291561766184, -1.932388321877517, -2.018894220970676},
    {-0.13970767336499718, -0.7966737179128706, -0.8980436057351662, 2.760780949242048, 2.7469613983353303, -1.0607772527728072, 2.0759707275649224, -1.2600859651677045, -0.4093386299569262, -0.9479570899858013, 2.743997749865807, -0.5528500124351966, -0.6618006975180998, -0.8398336519599254, -0.7809423597923264, -1.1362684260754798},
    {-6.091691446208058, -6.006010076444702, -5.9550832634100495, 2.0292510371331125, 1.3359327965990893, -6.4915831663565005, 1.0960731794498337, -6.264487467200352, -6.055629832447459, -6.22268737836284, 1.6576909570331402, -6.260033747685464, -6.250939382998802, -5.978903721754052, -5.8518801127628, -6.056137143120564},
    {-4.221938685833869, -4.270267767870942, -3.894306793841625, 1.5723260913357462, 1.701329162563529, -4.071064517132293, 0.8552223647493526, -4.177165710018368, -4.000747846749679, -4.113222927354401, 0.9415041080552518, -3.922483215189874, -4.495890902154526, -4.134236862061279, -4.071389619793713, -4.209718429633798},
    {-6.029290171333937, -5.760675243723726, -5.899466932300768, 1.527735527268111, 1.2307205028692219, -6.670601812543378, 0.9544949361660171, -5.969883466886581, -5.858035437696816, -6.082387555746712, 1.5821307744418673, -5.937240474018357, -6.139637158249123, -5.821600199753603, -6.009446789676254, -6.122222420872694},
    {-4.164385982447439, -4.135929347099237, -4.1624792608530585, 1.097652812647847, 1.2860078836778215, -4.216228321162854, 0.45704165103670175, -4.179002520515111, -4.2532906908904105, -4.432830287485651, 0.735180252133769, -4.17837446158349, -3.9687088742767003, -4.10500420767816, -3.9168564336679097, -3.9333680652620053},
    {-5.232267569819525, -5.0685911890059145, -5.009422771229275, 2.5886563673861622, 2.256726602736694, -5.416313504850182, 2.162102307331035, -5.102647538775155, -5.192430785500771, -5.231656251954917, 2.3434877461981416, -5.4589930792977235, -4.946901930289301, -5.209610581041855, -5.1040245794267385, -5.299620712986607},
    {-7.328625163302423, -6.804964842342784, -6.809277683019145, 2.1271682387297606, 2.1172063333570312, -7.148035158467836, 1.6853200727793327, -6.651483384441694, -6.850727254761518, -6.947295254189837, 2.066846946511722, -7.227062239288472, -6.7960858008825795, -6.80280811625029, -6.786911989310113, -7.172128009381831},
    {-4.056454247620839, -4.427658709730459, -4.459455915550973, 1.0432696138895103, 0.7101392963802771, -4.507149484680704, 0.5125743442452325, -4.590447468338879, -4.336173558004227, -4.6063282281690325, 0.8516723099577445, -4.556234334535203, -4.575763842851289, -4.615111886352454, -4.210622712182553, -4.761329156424164},
    {-5.318228344730273, -5.253172027786676, -5.158170620559813, 1.9846479460235986, 1.9726613441260974, -5.336084819380069, 1.3624618163603375, -5.3240247000879695, -4.825721329224244, -5.230095174237746, 1.7886621095253088, -5.167921337593051, -5.182704870820507, -5.220624277478752, -5.266802750513812, -5.663808833055024},
    {-6.977099159626653, -7.096299616019019, -6.786184214589606, 1.5816826000063804, 1.1233860009722525, -6.986557918926846, 1.1161993320545773, -6.603031316311341, -6.73476126863747, -6.8811118701374046, 1.1616082306882929, -6.688847283214971, -6.757852443522025, -7.10050641123149, -6.6497864171201915, -7.091230212547749},
    {-5.7657219275785305, -5.939542872265257, -5.588822956976736, 0.9776326433457108, 0.9085797934809029, -5.907827131886357, 0.6456629409052002, -5.6225465367846565, -5.707077063154502, -5.694251023417516, 0.7297795406495999, -5.865592509306357, -5.98717097418925, -6.013518739312333, -6.154999495220036, -6.358015042776504},
    {-6.971952800612268, -6.67825355354938, -6.568499764879169, 1.2329218133384687, 0.9957781740270629, -6.789658128569004, 1.0820678172415472, -6.804572121134104, -6.473398172924631, -6.734016113601476, 0.838686173547451, -6.685157851186057, -6.7572012347528325, -6.8023351402338585, -6.712621513169971, -7.099302678898688},
    {-6.406916999082907, -6.2394200899787196, -6.226478697544087, 0.17505335913268855, 0.45276798199320756, -6.262818977502168, 0.19525527128430628, -6.228324977266789, -6.361298932068634, -6.348390340136442, 0.2000759369788689, -6.328470234367106, -6.405848729630479, -6.568226673640388, -6.710606145115386, -6.681437791435638},
    {-6.640051031800059, -6.793517692255507, -6.645515861121523, 1.9930119718457635, 2.13160240792811, -6.659851367499075, 1.7153587196750026, -6.632453605070694, -6.585721808493366, -6.5250736867736165, 1.3779430866494253, -6.36799696743829, -6.5309045647829915, -6.714627460326523, -6.8960376818060265, -6.970670615927683},
    {-7.4210560381727415, -7.4820810526784305, -7.199417127041547, 0.6021580808410074, 1.3528044634481269, -7.367302477158736, 0.544186558627684, -7.354663161251281, -7.7696047211293635, -7.679979829522622, 0.31316898151511674, -7.334174313224582, -7.257828263446724, -7.214167508486291, -7.383215234075683, -7.529954334940824},
    {-7.223520945629938, -7.344041286816648, -6.889047748476791, 0.1273643421051794, 0.32894491361501904, -6.890405539897231, 0.14969796264986904, -6.993156067096815, -6.975969656478986, -7.271029408915507, 0.31376605526931894, -6.8775235102867365, -7.037797881302213, -7.14142651093854, -6.8956691736986215, -7.348723668656784},
    {-6.598909736651127, -6.799885510205366, -5.9081558178533635, 0.9379112713396153, 1.343275367300792, -6.4463604048902035, 0.47089677360443616, -6.212132431480798, -6.118751991357997, -6.099578612489686, 1.1481221205591787, -6.424720469595923, -6.882416511667876, -6.515632677822139, -6.598855146771721, -7.01343756371549},
    {-7.674293550481845, -7.660671286760656, -7.548428461059773, 1.1556754597958458, 0.2949222161232889, -7.773742997645551, 0.9260753363040419, -7.5297883221313775, -7.177814359302726, -7.364073215132283, 1.058105708143259, -7.461782739944704, -7.67134167216138, -7.745498912086295, -7.7538005732603885, -8.023086900693547},
    {-8.085059804986008, -7.933997993257214, -8.185265054392975, 1.1197757034937885, 0.33527597702768835, -8.361218658565223, 1.3218057846320777, -8.377216335289347, -8.20810574380553, -8.296952453898768, 0.2918298035509911, -8.298179699542223, -8.206364719879202, -8.042541874771507, -7.988883603007156, -8.158429575916182},
    {-7.991627182714157, -7.940151325969004, -7.880062331983331, 1.4522443577175799, 0.8206552258941117, -8.264338059326466, 1.6359915350876186, -7.946502467721656, -8.273183699507015, -8.169881583553378, 0.31032046014412645, -8.0732040596547, -8.379714900278143, -8.2284573047763, -8.056454184960899, -8.174971497370585},
    {-7.887599139325615, -7.882735367069309, -7.612614886555678, 1.2234952362326619, 1.0646616120316497, -7.974842239374094, 1.5057926291870523, -7.684658270056568, -7.612954646815978, -7.648583868078806, 1.1196567741546433, -7.376336516860561, -7.722102646544745, -8.08626538165228, -7.729873458955621, -7.86342098978078},
    {-8.0012487657755, -7.660304324544175, -7.3784789423134205, 0.41291570952209383, 0.24416325974677652, -7.783280870887024, -0.42905719384535834, -7.624449105716656, -7.279343024554483, -7.539847976371315, -0.21017030852371005, -7.275703319957335, -7.674649343343248, -7.751472507482857, -7.3727878099670825, -7.590930688417707},
    {-7.519312108097059, -7.833237756921208, -7.376713569236173, 1.4638166406722268, 1.5217813215447717, -7.582437811443292, 2.5401615444370367, -7.4195343468816, -7.125404575935069, -7.669647083457391, 1.4792998348870812, -7.273925657596656, -7.607699862476321, -7.899090988574373, -7.434307154776722, -7.37387320391731},
    {-8.16108046595332, -7.904837221472894, -7.879584629482733, 0.07316605652478528, -0.09621003671432729, -8.185057973455448, -0.3614802674271854, -7.7452132589989935, -7.899652756989535, -8.014454678526606, -0.27880331851438306, -7.892363503487279, -8.139648717074762, -7.944061921235202, -7.965309457961446, -8.111456958660321},
    {-8.052197015861493, -8.046884072533429, -7.95577579944048, -1.1221283381591185, -0.6112870945261836, -8.143955796935607, -1.0760116955942527, -7.749023054319751, -6.935539104545027, -7.659717396703415, -0.584420128939983, -7.661065804752936, -8.262064155455313, -8.124466619937307, -7.723204513537135, -8.062626326909857},
    {-7.8061263749962615, -7.7714204459335114, -7.809094721116658, -0.7321542099593533, -0.3477698561469135, -8.0011782195568, -0.6592392481032937, -7.737019906489685, -7.758982906883241, -7.6922440418558935, -0.8271108820065447, -7.2703387592756945, -7.8089437760481575, -7.9617766627539535, -7.69561828672356, -8.032244997133414},
    {-7.804426455702837, -7.709295944569555, -8.02066027765947, -1.2590110877985692, 0.5201765625376883, -7.980876540160001, -0.2775231507561769, -7.632562275602455, -7.6398107161192, -7.7491455942896375, -0.4744419965396689, -7.638938504066858, -7.923114204855879, -7.597076224224266, -8.131126876829047, -8.07943919152555},
    {2.783370596339368, 2.4843083829306267, 2.25538216770463, -2.2206472908331603, -2.3158211449102892, 2.6108709031090505, -2.0429085953057795, 2.6502762098953583, 0.8120998324725159, 2.1670444830388664, -1.9672843920285408, 1.440596218734549, 2.2613524803561846, 2.4802733830738948, 0.5326791398233993, 2.337624603453585},
    {2.073734396611346, 1.6328096567000383, 1.5455140506623606, -2.007756828575072, -1.8665287726403126, 1.7785220960769574, -1.9638528989213544, 1.7831088484377886, -0.16080571532761348, 1.361367686747036, -2.182846018234959, 0.6005761360606244, 1.3456895736706365, 1.7590270964221213, -0.5236612378790938, 1.6336495756205784},
    {3.2695706529194917, 2.987849488881549, 2.8112114783126967, -2.4054981112372538, -2.4170486432877705, 3.2227137284316743, -1.898693168937656, 3.059155381881945, 0.7808760516056942, 2.4833435199913914, -2.2145100557837445, 1.6145405700206548, 2.5903011575575094, 3.0028419335459424, 0.3631046504494891, 2.9380856792725054},
    {2.8389736908694583, 2.8182675307408394, 2.3203323561512037, -2.067903160210814, -1.7141476276195353, 3.0496773837266873, -1.5177436401534545, 2.604130794825724, 1.3783617404601745, 2.303747390262341, -1.7575348265753694, 1.8541232238833756, 2.461124142044267, 2.888205060833759, 1.2651238586621893, 2.746897766157058},
    {2.657946748603025, 2.338688878799257, 1.964328241646815, -1.6563837777905015, -1.4977159349260805, 2.5785681258716218, -1.4226176967794109, 2.0738192431660156, 1.3890965133587978, 1.8968864163511543, -1.2049617968691146, 1.6018970176449618, 1.9330631032606327, 2.536327038646724, 1.0566229410815273, 2.368224018657159},
    {2.9132278158350893, 2.5975756440393876, 2.3200877611261994, -2.561836195530537, -2.612973855936716, 2.809450279004568, -2.170747268841352, 2.402395963001676, 0.9960785036129512, 2.1074656277494754, -2.443804371802362, 1.8095773927223067, 2.160782136641486, 2.843795335256036, 0.6389865355724649, 2.8023081114562305},
    {3.482531731296821, 3.331261137304864, 3.155321622495523, -3.3167566101965154, -3.2037291979653317, 3.6087999566154076, -3.0890204161192725, 3.3214983896492263, 1.2762146412993394, 3.0248141077034028, -3.1740505132828507, 2.1674624960395747, 2.720433023817389, 3.3939403389538305, 0.767689606506127, 3.294222229860184},
    {3.2609779662824434, 3.0525808599205884, 2.6088231897303427, -3.112996336855423, -3.2439099591335805, 3.2968473251479904, -2.9280958321238573, 2.664515220297999, 1.1103923032191312, 2.187732497994551, -3.246564937203908, 1.8137086473654749, 2.431973790238992, 3.183894225198692, 0.7119232063991429, 2.9165086040474395},
    {3.4585641106198737, 3.2745415463545164, 2.963181979117005, -3.857246190679299, -3.8142153217730717, 3.4771945717151835, -3.169215781100356, 3.334203408081916, 0.9641004301609152, 2.834266367002654, -3.940994062043621, 1.9000347462937175, 2.7561034468029764, 3.3846846409290605, 0.48783576636746645, 3.29682995318077},
    {2.9474817136584015, 2.3859327023945194, 2.2102021878636613, -3.2468663023472946, -3.2474016121411395, 2.724297170667846, -2.7250535143809156, 2.3649459660810375, 0.4091561194875085, 2.044041777557919, -3.1654570280359797, 1.2733907649540765, 2.1259650058871307, 2.7072298964906185, -0.15749101209425714, 2.4146204228123205},
    {2.4277721808701695, 2.0518146115108222, 2.190955710768196, -2.2802270450552724, -2.2999191598299116, 2.723896728426514, -2.0558238608717567, 2.4462685101833492, 0.6834695544416521, 1.778218168064138, -2.1092257765525875, 1.4297988095507623, 1.6630726308255903, 2.357349269831474, 0.40052981688812256, 2.25209180960619},
    {2.717836988598796, 2.350063582020869, 2.0119917511988232, -2.5089280300087395, -2.0456438453874557, 2.8185496647211687, -1.7562385628288082, 2.4978242347669797, 0.8455732836350567, 1.993771515583524, -2.137051925250719, 1.3808858376372042, 1.7485418082992814, 2.530297205196069, 0.11000918696606003, 2.5163465615108205},
    {2.7560190387343866, 2.2908447066415225, 2.0017119548368805, -2.865394125080401, -2.666871954489554, 2.7553405445312382, -2.3565246572274066, 2.652301838866412, 0.13913449400794412, 1.8960303195637043, -2.4966101680832273, 1.0430144117481908, 1.9619158124850749, 2.544883120520078, -0.1840535596491382, 2.289847545955443},
    {2.259476233527952, 1.836946480256598, 1.671909824139364, -3.072918595089367, -2.9211323899841224, 2.323519782547833, -3.1063167551598534, 1.7261557241558363, 0.2696484465454334, 1.554994982177261, -2.9600261149387457, 0.819142009235381, 1.535334776663843, 2.1917781172464323, -0.1572734156282589, 1.9934900929510158},
    {2.6753775290663286, 2.2624673461492026, 2.0200460742412427, -3.50696807681177, -3.2695837500138616, 2.6365686067185186, -2.9019016427021693, 2.3056137555079856, 0.5643410044579382, 1.9834367651334985, -2.9351489684704637, 1.3789056629065457, 1.7181805520132962, 2.341346264614108, 0.0495771560811564, 2.268460185399376},
    {3.2992375753419476, 2.662652655753774, 2.7479644915855723, -3.6314498479656523, -3.443678995964593, 3.2677983844063236, -3.15125636315426, 2.9216134920334937, 0.6845252924139226, 2.2559171284838513, -3.4799959908259095, 1.574357624784839, 2.2593559674414623, 3.0283532343664414, 0.11446598922426784, 2.7251498057780523},
    {3.606305502758194, 3.193343385446533, 2.9397659139561334, -3.360899754095602, -3.2977078921430367, 3.3841870867599635, -2.664803499561728, 3.1863423873927847, 0.970215184834359, 2.5617668303158405, -3.22735370459185, 1.8203410939619067, 2.471032381891193, 3.2798579429597043, 0.383244882755793, 3.0704321136548667},
    {2.7155267468824027, 2.549636078162621, 2.2251183028114285, -3.519709151012475, -3.308514765097734, 2.8235044580225748, -2.796692386603886, 2.752006251972383, 0.5312963497660474, 2.475761487965898, -3.3455808111320002, 1.3973457918305003, 2.233861878064332, 2.805258004619131, 0.3542414849184286, 2.7100877013473195},
    {3.0167097579656925, 2.646624420167066, 2.6763013169152243, -2.997181762367024, -3.0351032842094114, 3.042701374614396, -2.676922895059576, 2.737762616363877, 0.5842325222322026, 2.2535975623143196, -2.9731473018308447, 1.57490305744485, 2.3829415000210683, 2.7869691758446864, 0.2680210063563313, 2.6327118914993997},
    {4.1403195902135534, 3.787398809794229, 3.844420423133028, -3.2977962496925106, -3.2974220461460497, 4.103198853480435, -2.8335334534604764, 4.03494707261509, 2.3349689441167367, 3.5199217215525085, -3.0996989274270947, 2.8295613932523747, 3.5099642687126402, 3.977890154986805, 1.6568184796054926, 4.052491896429798},
    {4.125002488390199, 3.716822415792291, 3.5550178062442823, -4.0453413597581305, -3.8237709416221732, 4.220564905658008, -3.4685553675819065, 3.9409902926940057, 1.4279472172203702, 3.50685449597377, -3.8236607274244534, 2.4722151964949375, 3.36308123418377, 3.9593704853360148, 1.0186622861111494, 3.7447330823067615},
    {4.4533238871671506, 4.1117844590160955, 3.626276454648225, -4.114217584942636, -4.137981479359487, 4.152794925856574, -3.511470065232165, 4.070402186023221, 1.2886613783769674, 3.39074538799588, -4.211639840516854, 2.5985910740290845, 3.470951490894981, 4.001287647523659, 0.9236094628589594, 3.95003699333687},
    {4.157472944284752, 3.6874220610836934, 3.38660920352847, -3.687712698728439, -3.661532977267579, 4.1395366709159305, -2.710159196090492, 3.9794349937403193, 0.7147389001245227, 3.109272241478831, -3.751262826858166, 1.7184951669872348, 3.13962760592018, 3.914255241720281, 0.4502127425465472, 3.6281015614541126},
    {4.341612905477968, 4.0338333174575505, 3.509288181319367, -4.028102316815887, -4.054048728932178, 4.106924657283078, -3.620361371472251, 4.115574396767601, 0.9104670790031779, 3.1475741336715415, -3.994116119726264, 1.9509921482831978, 3.4853218798186645, 4.236469222747106, 0.5254860495430115, 3.940626872062872},
    {3.8479186554352505, 3.5085137955777315, 3.105452700066764, -3.2807944579418846, -3.3201900615804307, 3.6338930069656965, -3.075273677622303, 3.5391125052035908, 0.5276397282382528, 2.731843559229691, -3.3791724250591275, 1.700106789848873, 2.925391493072471, 3.5225390470717333, 0.1275923017177527, 3.3177428952982986},
    {4.016954637586125, 3.939952817622217, 3.181182905260243, -4.115573327702391, -4.239695455044377, 4.174288708366312, -3.4064122761819906, 3.727667497327873, -0.028740637363870846, 2.7909967441523897, -4.293959906832717, 1.364201750568505, 3.108988578165143, 3.935641254377735, -0.3954653440427161, 3.592951709024143},
    {4.915903145045243, 4.787029433534471, 4.422335389226068, -3.764127013718385, -3.722747300596854, 4.981735818014599, -3.2456783893171335, 4.878421918613845, 1.8478687258579127, 3.9715158358798117, -3.7192469494109974, 2.913500098086935, 4.199532974277833, 4.726416380852129, 1.422531180374328, 4.770534363340742},
    {4.658307501163592, 4.3644261578660775, 4.1539061698460795, -2.7793257149230866, -2.8399168813952747, 4.445932576246922, -2.050508881549987, 4.485729266473315, 2.0357865540527094, 3.872062149192091, -2.589048740076124, 2.8583634890550083, 3.822834080790474, 4.490213146764955, 1.3288273655938398, 4.433718948946093},
    {4.178706590400487, 4.005054213022002, 3.8807918194533038, -2.741005925312252, -2.839039665739086, 4.160434008841422, -1.9884295806499324, 4.085455115715469, 1.338262678495316, 3.2908533856716033, -2.611586998371915, 2.269776708399916, 3.4588728282499464, 3.941923414275178, 0.698640045748546, 4.024371808564854},
    {4.549670016068981, 4.479532297305117, 4.13935317107764, -3.8651280805105865, -3.993105736936875, 4.753402590111308, -3.1185340160512425, 4.613494150098224, 1.6231797220898077, 3.9383666137309215, -4.068574455282089, 2.617763509771725, 3.7660801992559367, 4.5333263316343, 1.0185899109210679, 4.34709031715356},
    {-2.007140540135228, -2.9544782051117733, -2.4724599258977933, 1.9312814108757337, 1.9296447568572597, -2.4441879300967235, 2.172568034797014, -1.7100288751908594, -2.2622108583052936, -2.6127542957891987, 2.628371290956222, -2.367306434793189, -2.040462478047344, -1.7362486787736984, -1.7150182616060519, -2.305912636285385},
    {-2.0235805875953576, -1.3267932632457307, -0.6267128554606932, 2.4240910685649797, 1.344596428479452, -1.3047151065451925, 2.1146652090468, -1.8513397234077256, -0.6500998394952469, -1.664596107202804, 1.4936695834463103, 0.44557901286263724, -1.6423982611702446, -2.1306902703252546, -0.5351447018762328, -0.6577132826952591},
    {-2.7344567178113, -2.477038305296425, -2.067073855901655, 2.02873606674253, 2.648876091175973, -2.869355081533161, 2.4847584126495157, -2.5109482745903424, -1.8807125236951492, -2.076738438146193, 2.1938550688911556, -2.0850367187079244, -2.534470290147508, -2.432225936120704, -2.3085477869347333, -2.924783002333638},
    {2.736625236349239, 2.2633091811076156, 3.0854626074346636, 2.0038067897990377, 2.524185007421786, 2.4277740905512686, 1.681716342708094, 2.6630921711142017, 2.8217926146487238, 2.7199496682579785, 2.4445670759742137, 3.0511890165623776, 2.932702293631796, 2.4329404015294176, 2.8978312892913265, 2.338529812758114},
    {-5.328137381049038, -5.602879137884642, -5.216247793811818, 0.9522792188760465, 0.5180072526237431, -5.458230091747998, 0.8664782976997437, -5.233925228595178, -5.214598390120376, -5.164693415315842, 0.47564285529466344, -5.524566129756503, -5.329916852691906, -5.221906743841133, -5.382908376593212, -5.569838582412009},
    {-3.115508223727953, -3.2241212234504317, -3.1568487333193973, 1.3158272418123964, 1.119013677811486, -3.3190086612402228, 0.871909486472957, -3.1590161048967103, -2.994888990662031, -3.1647206049213845, 1.0287369201835377, -2.8859594440502274, -3.124978151480005, -3.1956254871488143, -3.074277844252763, -3.216469615091585},
    {-4.920027481019413, -4.968419052855331, -5.119500873467673, 1.4356771126698882, 1.3051820325290047, -5.176924773384992, 0.958607694566614, -4.773009345504213, -4.582408115091017, -4.690342873547496, 1.5736168148168854, -4.90046173736178, -4.783837537348661, -4.807131240325676, -4.548964735651728, -4.740147978714243},
    {-3.703470119584716, -3.699129295992342, -3.417456869002342, 1.7270500198738925, 1.7031973865238061, -3.6563596602416295, 1.640268783190677, -3.7544450038081965, -3.2326076399289425, -3.7322988217866837, 1.6931434348325833, -3.2256096479176994, -3.73424828049277, -3.4951754603138148, -3.1653342218946623, -3.7682517563127877},
    {-4.128067663701206, -4.160014745571166, -4.032072994762326, 2.331443314798221, 1.8903102595611485, -4.428541012857424, 1.76734726572977, -4.04346489706342, -3.7335835323211928, -4.000314586739823, 2.04384277702427, -3.9211351865381237, -4.098594005848634, -3.9407468322471626, -3.608944580531823, -3.9692654946147354},
    {-5.952146177532252, -5.59934708175487, -5.775541839464855, 2.1956106359038423, 2.307653363847846, -5.868530533999827, 1.9252366057483699, -5.7219819736117685, -5.490752402207706, -5.8026812270062935, 2.128292533239153, -5.505648608114437, -5.76849882817626, -5.765364312191966, -5.834909057655142, -5.858134282449673},
    {-2.140448591117108, -2.061342210259227, -1.4887183968825866, 1.0231252823857298, 0.7498924538863688, -2.3294922382984278, 0.6607805586999986, -1.8978218164693867, -1.980328183660905, -2.1518087141493187, 0.6124247595957942, -1.888177272526825, -2.319295853432345, -2.0345417573645777, -2.1799934053003818, -1.943921190884553},
    {-4.2827652440180195, -4.107919323619866, -4.184656331676002, 0.9285995461095603, 1.0010679192900316, -4.001273487600496, 0.4482421219089634, -3.889977479248579, -3.8092722270051356, -4.031919869671068, 0.7675732254561146, -3.8348256573888735, -4.299093031903593, -4.399444237563674, -4.176020047526469, -4.3545532664439435},
    {-5.721522251358756, -5.876301225992492, -5.734109042794335, 2.4058875610784316, 2.0560749283445503, -5.792294044420653, 1.8321702101303274, -5.674356821347266, -5.370781797970227, -5.578943459899784, 2.3355040991165326, -5.658817675460038, -6.005245710749108, -5.842448288916049, -5.5966933878264795, -6.060016899792222},
    {-4.8506517886555, -5.152334204324026, -4.259168957685186, 1.3220583862759447, 1.4830317463529201, -4.6473852793514085, 1.5828018089060738, -4.383132294052388, -4.324942955237517, -4.359757635675141, 1.4249691375541191, -4.47361657309161, -5.125461773872009, -5.153814369677886, -4.651718090110528, -5.318281425253508},
    {-5.905769838270007, -6.12808392443541, -5.490184795896201, 1.4610449437090267, 1.6118507843983638, -5.9999358799188665, 1.9846501512598342, -5.455184650856264, -5.464475625168297, -5.772426551038399, 1.6067198425969267, -5.47569588211819, -5.8993632222107655, -6.1188009855151675, -5.431970894695394, -6.074385687293182},
    {-4.951321415712431, -5.090222212029196, -4.841089812196032, 0.888603565085019, 1.0239324130202865, -4.932036033021331, 1.2764138806898184, -4.610346053970133, -5.240094320300268, -4.672764777077945, 0.822180246859501, -4.748576734360334, -5.250990822147193, -4.975487602706773, -5.429904497169953, -5.279291626459754},
    {-5.977974584480981, -5.922303413937665, -6.073770481150274, 2.437222194203569, 2.290572691524842, -6.096154318940762, 2.3624460805537866, -5.859116827582905, -5.931266243168642, -5.350850891889719, 2.052487988703393, -5.521598439463011, -6.091998845468379, -6.252870654997746, -6.106840749672202, -6.203791055675475},
    {-6.7610283835800935, -6.502807204909902, -6.683067906138268, 1.0851350770806214, 1.1892881084569593, -6.851785965201972, 1.7818498195558574, -6.664193621899856, -6.764349170491941, -6.753065856412084, 0.826383691387916, -6.496254088109201, -6.907934268687987, -6.870522787495651, -6.781890679033643, -6.710635612675488},
    {-5.9785512616649275, -6.150454727658094, -5.559796737350291, 1.3205979942222232, 1.4551919448069766, -6.156245960686566, 1.9540080911649347, -5.877889632436243, -5.316335079593286, -5.84477785440227, 1.520086411692917, -5.120970330718032, -6.132312539172537, -6.200702816708404, -5.556354340952618, -6.357323455350447},
    {-5.344151410598341, -5.728056302595166, -5.146548903135391, 1.311992738180975, 1.2883351380603143, -5.297716658409439, 1.0429223204940683, -4.97454883571105, -4.917021471717672, -4.641116249587907, 1.20702257333814, -4.940163934695909, -5.5045073109313245, -5.693844487489595, -5.390982695567106, -5.477847703402559},
    {-6.8186411923562105, -6.720384469623556, -6.849301590342047, 1.496260707999868, 1.7606596909038814, -6.634487226232045, 2.2388130295930084, -6.589294703526118, -6.217132882009014, -6.206677489116012, 1.9094128811715085, -6.106122555573565, -6.953287230851206, -6.80779448173636, -6.813528263872685, -7.174382765789924},
    {-7.611974712077086, -7.725349584806771, -7.292764544563067, 0.5948853215462077, 1.0472254114894952, -7.968073057875249, 2.6907233239879713, -7.125732790564409, -7.323851093142266, -7.269279379852982, 0.35976555452061393, -7.140030613927595, -7.840699320976678, -7.574364200318889, -7.308925480122215, -8.007290258050215},
    {-7.596932688715786, -7.4792864416493305, -7.1815361586460424, 0.9808126000557121, 2.2404280949081508, -7.62463646351881, 3.137180222648882, -6.968047443123118, -7.033740875357247, -6.997504547880721, 1.679862007304215, -6.296234942196303, -7.354817939424723, -7.574815342743422, -6.71006353160186, -7.5156489606031975},
    {-7.690958258876022, -7.542873080564107, -7.085093208650314, 1.1697622404204748, 1.7520203411712552, -7.493189912478376, 2.4708684936766208, -7.132410397748745, -6.878533999131989, -6.917573977823489, 1.8319320029146895, -6.163449201931111, -7.455378746387141, -7.401870752584296, -6.914041598696362, -7.370136966667409},
    {-7.4948188958504804, -7.229647653426922, -6.778380400619125, 0.8845135301043031, 1.060895124037285, -7.095876406562963, 1.4154811200696928, -7.002782200656237, -6.738759713799709, -6.854591396597221, 1.2771048469188744, -6.721182657076798, -7.152702546220447, -7.2381114036729235, -6.7028478461349, -7.1888402819674875},
    {-7.167100137151985, -7.154794819521468, -6.7550221339171825, 1.7517741089356798, 2.3187671570787676, -7.448752357071555, 3.5313915060239376, -6.882947554191582, -6.601751849782567, -7.09043242080315, 2.614008927245525, -6.197571578906125, -7.428907602873149, -7.177948036754524, -6.671543204981332, -7.391910058027136},
    {-7.828973742312168, -8.004635108950314, -7.840763086943942, 0.7743853758916895, 1.2399192205468905, -8.073887937531145, 2.151713290094134, -7.548755744901377, -7.669276342787734, -7.782831630379074, 1.3594441649725741, -7.295940636371687, -8.01318864421612, -7.904708049023009, -7.495771191125507, -8.008700679057544},
    {-7.771043470275994, -7.591373939729814, -7.884399060961843, -0.22350968903102558, 0.2805680104338889, -7.868484183252334, 1.272968783282476, -7.290625377610011, -7.243443434317659, -7.734656913715146, 0.5315372846584819, -7.1709363361001985, -8.108601544824985, -7.550240294025606, -7.750891814035599, -8.046890818742556},
    {-8.06142612580948, -8.05238544086258, -8.09180717057207, 0.40914302235483424, 0.7804656411288378, -8.137512267308997, 1.7811844930913177, -7.733888208946312, -7.756969158637012, -7.873337236803572, 0.64655159976282, -7.289823557569009, -8.203261241840893, -7.93403595458517, -7.711259733157701, -7.968548326872685},
    {-7.797372309379991, -7.873303098239031, -7.950779214628878, 0.26592042297808266, 1.4444527648461232, -8.08474057355408, 2.3958398404817283, -7.015362369588987, -7.773603388619811, -7.080910302729616, 0.8844977887726873, -7.113757198809761, -7.970802008437742, -7.606100229966722, -7.6336209423937165, -8.124735584519533}
};

static const float b1[16] = {9.021115155383008, 9.003945208205188, 8.859987411405971, 7.563741907301289, 7.710050912873551, 9.100391921075042, 7.949531501735, 8.963054601777326, 8.786609254218122, 8.964317232186442, 7.65768407008514, 9.064775033669148, 9.070718812409481, 8.801315271710013, 9.067135350711169, 9.018416440306556};

static const float w2[16][12] = {
    {-6.37808289821281, -6.233721342768647, -5.835944074202568, -6.847665267108639, -6.2268236921180256, -6.323901664106748, -6.628727131504447, -6.733748423544343, -6.344327625751687, -5.637782752858761, -6.675543177752657, -6.263232190157221},
    {-6.459979941494556, -7.0691298454773, -6.798696885314223, -6.111057571095799, -7.223936868609242, -6.577135186309369, -6.0320679856401105, -6.614734009660327, -6.664506955332954, -6.349184298836358, -6.731988073063094, -5.967417583983889},
    {-5.943359878072506, -6.136824485203898, -6.502187501313332, -6.222158224450211, -6.413447889199715, -7.089556089577014, -5.918449307517142, -6.402206228674984, -6.27563099004895, -6.356412661240435, -6.624080391156404, -6.185171617319197},
    {-3.924877052113448, -3.6342476536174355, -3.2094629726057193, -2.8293817505557706, -2.8737336388319807, -3.7727815390909534, -3.7174269729600016, -3.3263287896242915, -3.8086777059362387, -3.254393479745394, -3.9982806537361326, -2.5076661326241045},
    {-3.0715932075391463, -3.0954404115248377, -3.3201744649887774, -3.6864919785987555, -3.332521068929922, -3.144291025135849, -1.767565008960032, -3.874130911929656, -3.2399342768735693, -3.3415986779851408, -3.6414275731128076, -3.553220138613188},
    {-6.566235384154444, -6.516819446924758, -5.751092175685737, -6.4147801829753615, -6.366317508448014, -6.485569625003698, -6.138674956510538, -6.399223447433949, -6.247229912667668, -6.609729934238147, -6.356028389121368, -6.01118293395125},
    {-3.3326210399339384, -3.450604553178029, -3.4567967829191426, -4.295923257649248, -3.8249979695336176, -3.0535823654354814, -3.9824347609908575, -3.0964003648163985, -2.446773944411386, -3.7982616938454012, -3.6293302800862426, -3.5805144997141385},
    {-6.522723557068683, -6.408451642257593, -6.756003747288434, -6.528001111288186, -6.2699507712729465, -6.179851288101026, -6.895442539104364, -6.314878603174665, -5.63384643108055, -6.4411956938723955, -5.489602138052888, -6.570118445997053},
    {-6.0943465349762365, -6.871151048786663, -6.886707864952805, -6.320377878470424, -6.15667721594006, -6.804525086879662, -6.845454024576316, -5.65997009818668, -5.791100180295576, -5.80105573697864, -6.392307724509462, -6.86501509521591},
    {-6.882980452585618, -6.3205784860949334, -7.277195198587539, -5.952079108018295, -6.246830005584839, -5.651911808061417, -6.2564465539443495, -6.658577662288404, -6.604264763036004, -6.3375569384258865, -6.804986197790917, -6.052146040563605},
    {-3.3104916830491598, -3.0694805545294495, -3.356334605954953, -2.779395336684112, -3.512747239601282, -3.321347096948562, -3.9095458323173093, -2.9570579996430975, -3.8038558473682618, -2.927769836758762, -2.0731540250726357, -3.719423041952328},
    {-6.906328115483827, -5.5007383867591955, -6.006874462709521, -6.260199822744707, -6.788785762210901, -5.850301928717943, -6.4625714136189165, -6.348884612885128, -6.898579710185115, -7.171082727083184, -5.809783189340422, -6.726517529265505},
    {-6.14952258905162, -6.244377944340048, -5.83224648751709, -6.87420251058044, -6.691746029067031, -6.96453680519812, -6.391315436660504, -5.4315775072863275, -6.539402139555948, -6.341553941156557, -6.806994632543874, -6.6821221450082255},
    {-6.30393258022022, -7.086243108816097, -6.96911236987908, -6.339798992026375, -5.9033502240736695, -5.820496219921803, -6.107366195707605, -6.309856382563625, -6.5565829284026815, -6.569022841225835, -5.810857170386354, -7.448596068285752},
    {-6.4223695646778545, -6.77471170181082, -6.202551254392745, -6.742978252686218, -6.484418360903944, -6.453953753157088, -6.277724963613042, -7.326376650906015, -6.774315380877688, -6.646156423718101, -6.685762756098251, -6.097815725708612},
    {-6.1798360466346045, -5.679595916339824, -6.017285677242851, -6.183959483779341, -6.053069150928429, -6.609344937418791, -6.864222981792556, -6.598759121795852, -6.4905859585884045, -6.548844290435882, -6.614203359158746, -5.963330983560558}
};

static const float b2[12] = {-5.458998484509141, -5.775820121334943, -4.475420976285262, -4.973405974665347, -5.051479458427961, -4.532880118890546, -4.962135400314039, -4.845637539352312, -4.866592075236952, -4.820193451601906, -4.42096637309286, -4.474757832680589};

    // Input Layer 
    float z1[16];
    for (int i = 0; i < 16; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Output Layer
    float z2[12];
    for (int k = 0; k < 12; k++)
    {
        z2[k] = b2[k];
        for (int j = 0; j < 16; j++)
        {
            z2[k] += z1[j] * w2[j][k];
        }
    }
    softmax(z2, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
