#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][16] = {
    {4.49738525792601, 4.5838042755575135, 5.099440867983911, 1.9938536114077767, 4.965662324572699, 3.555838125960596, 3.4664626377202663, 3.209826579674497, 2.301235417761402, 1.0561071955999655, 0.9612718002374462, 3.5647322797697925, 2.4141378083618745, 2.154658150637724, 0.2831238942813801, 2.6027050181739138},
    {-0.8180422192934332, 3.6561377183068506, 4.338164872899608, -0.8923703578110398, 1.0662146389288594, 0.5101432617843854, -0.3784311259166483, -1.1573605452517826, -1.0949850214792265, -3.0638170484823615, -2.8528933679228405, -0.24263909518943874, -2.8193773784025438, -3.6250969522034073, -3.4285146168881795, -1.4448337214179514},
    {-4.850560504446538, 1.4626581882731087, 4.378472822223102, -4.401515530148788, -0.6969964654492576, -2.4394724441248488, -3.6369937542747657, -4.643947557363693, -4.011700032254357, -4.993788654499221, -5.460283722245852, -2.8255049246006974, -5.954701592427118, -4.4506273251509825, -5.377613072651356, -3.6735946802622945},
    {-2.182106301775147, 3.268802263584803, 5.5665393330103665, -3.406257521777831, 2.31445410100737, -2.1192665428132953, -3.671072110088526, -2.8613440151898226, -3.7112134362631726, -5.283494404400319, -5.2440451546795135, -1.3493204987833967, -4.866010818079464, -3.1434177848042784, -5.571223421744213, -3.55973932530222},
    {-4.545666838118641, 0.8604919216007487, 4.616604008262567, -4.461117908422268, -0.4106991547896498, -2.041601474170598, -4.999915180023434, -5.089362249452255, -5.00607950775848, -4.889329042331454, -5.027203797510564, -3.9200606847044748, -4.9823967869916945, -4.1052778582173, -5.565180109473913, -4.318327723323372},
    {-5.2167883724523545, -0.8973331455526032, 3.6546931514314043, -3.849311858885062, -1.505813930537079, -0.9753743955745438, -4.53603199628204, -5.246532088909499, -5.443929533104626, -4.487257321299259, -4.577284731436474, -4.04642744104051, -4.304770501681764, -4.285817963743439, -5.075098373174276, -3.718338025047699},
    {-5.005915255669474, 0.2272122346809738, 3.4681783655279417, -3.5424885744778827, -1.3360388212290768, -0.5011443985247364, -4.38577309117723, -4.54101375297923, -4.847847302274825, -4.226153899411777, -4.195607495119587, -3.4933090493247114, -3.972922152145917, -4.393595217593177, -4.466665477867599, -3.4058096751569282},
    {-4.535364525797034, 0.6085336190444408, 4.565127041409234, -2.70353042732339, -0.5083094081394395, 0.23393429791661824, -3.5277848135111323, -3.8723633327446496, -4.926219191925377, -3.8789554761818663, -3.7691442251536778, -2.82909806932375, -3.2795495978310796, -3.1445637612902635, -3.9830784670571755, -2.5198088182193454},
    {-3.17990330496243, 1.2818436618408873, 4.936206338938848, -2.0679964835541638, 1.1069084958128446, -0.6941003705919127, -2.9537043757147696, -2.963728489686244, -4.002352305772088, -3.587451503362365, -4.2549909108155, -2.2501503049488023, -2.9614639786364787, -2.0213408925082974, -4.383973835586407, -1.668199953856278},
    {-3.282061576622709, 1.9226919999244536, 5.05562027208436, -2.506679945062578, 0.8667328738316391, -1.9202146324097509, -3.3558813247665644, -3.4886567522048355, -3.546502471619438, -3.975412820937322, -4.610796600925509, -2.381913984743604, -3.7914067588196856, -3.534888605045699, -5.051502467392499, -2.274028632535711},
    {-2.7552564403774227, 2.1236880349892697, 4.389893321524744, -2.6763476195669362, 0.15611370648782044, -1.3287836410342457, -3.2192412342983423, -3.3611046932127353, -3.2891558577659463, -2.9790084443944527, -4.372313863688972, -1.7239613339576063, -3.628644748361305, -3.6416469484639573, -4.340762086707697, -1.7668951263371242},
    {-2.608736385159683, 1.9026139262596946, 5.008745971006344, -2.8214393447997037, 1.178955128224757, -2.2665455230879945, -3.595498633434353, -2.252928518340799, -2.7050070334286076, -2.6764266355698183, -4.336913457152844, -1.2909408616145375, -3.4153603171715172, -2.804326991862069, -4.3648552764979724, -1.7908068092477105},
    {-4.041856180318973, 1.7947284865393773, 5.318757109715757, -3.232246468330859, 1.1177277498700973, -2.4854994441011318, -3.8624454980585248, -2.9860083871983054, -3.3122447944258897, -3.614410892628113, -4.533414972384948, -1.1620450073598763, -4.512039737409281, -3.51654395367528, -4.76074601371585, -2.572856893759809},
    {-4.670752474452798, 0.8353038577708543, 5.148297509736417, -3.8751697981724833, 0.7787570985559319, -3.140076121014958, -4.309120168274517, -3.300192411351691, -4.2165369222533675, -4.098589209113825, -4.936444984500815, -2.0920917567108037, -4.5188757205410415, -4.352756615754737, -5.069049052244072, -3.2523806067695973},
    {-4.652677851288395, 1.5747213321919042, 5.1906390846447605, -3.5030575462717355, 0.4797123839976563, -1.8173382501596602, -3.6343651892760156, -2.6234193804675896, -4.1978100546588575, -4.040027232557642, -4.921462217986656, -2.0526784909573057, -4.4507623567897685, -4.4308212072619435, -5.019695025182481, -2.614566954449004},
    {-5.2730592548098745, 1.3894890173492103, 4.963649898128331, -3.6383439573347105, -0.12020558731773621, -2.2064149133581896, -4.199087967993423, -3.776781907849511, -4.452940735393238, -5.009067977262567, -5.167037062704832, -3.2153623050661393, -5.41752076019506, -5.156338142817273, -5.521668734132851, -3.232047367445725},
    {-4.666994802714969, 1.3258866042001904, 5.793052829645715, -3.2653285004302677, 0.5085426434735247, -2.4099921950099246, -3.923650272350019, -3.3570218292778744, -4.442324565392711, -4.912431181058697, -5.532004312240657, -3.215759900029788, -5.446030506865186, -4.346971510745938, -5.232909144477646, -2.9671164731680326},
    {-4.102689556274, 2.1524250461329353, 5.948637894065457, -3.413742026999829, 2.1312217001219635, -1.983127102598205, -3.338467134754374, -2.378538948881824, -3.830449022012488, -3.5917682450310426, -5.219280894653105, -2.4411766436052504, -4.877075504757913, -3.7172994109553916, -4.6547458090276415, -2.5126233532854623},
    {-4.082644485433767, 1.3561360967393723, 5.814026316552752, -4.31829156667884, 2.197670237163824, -2.6539866237408045, -3.7872841379449738, -2.696122335279969, -4.420236722113476, -3.7878600125604995, -5.269499464424422, -2.904095539165329, -4.981493669975373, -3.2902204024573507, -4.635089338052941, -2.661004478700564},
    {-3.588467288698592, 1.4611405225143035, 6.12178487651396, -4.118463966649799, 2.1903741284253395, -3.1002743007488642, -4.48466341395376, -3.374893944831645, -4.169141890323055, -4.017394741310013, -5.2558433625229135, -2.3949626794626235, -4.755986249103566, -3.9427682625144063, -5.211507312995809, -3.396764364337157},
    {-2.7529301798257517, 2.332486248593731, 6.010186395038196, -3.8093990930900987, 2.856207288661325, -3.3918376361763336, -4.219199461772422, -2.9512016425089493, -3.683090458813562, -4.185289523060043, -5.3109243282990155, -1.8168995508429886, -5.041910298058242, -4.131738227142896, -5.5735278164241135, -3.4261248194707328},
    {-1.6269520919514717, 3.502933130960532, 6.42816567774662, -3.248911225886772, 3.429224181272949, -2.476926796125594, -3.355678024762814, -1.5992434948469285, -3.213396814961548, -3.929482816651927, -4.791675115404898, -1.048314692532576, -4.896301707494315, -3.1939198537537457, -5.097895729744892, -2.9298030153355223},
    {-0.9673310308146067, 4.135233556891829, 6.308098597259636, -2.5267155949526576, 3.9571336016273273, -1.3077371576195642, -1.6715294111147683, -0.37026135514219505, -2.4275011249499236, -2.9242962209633863, -4.690166687132377, -0.0007608335557386614, -4.216655763267166, -2.8451938145372484, -3.9214072602270114, -1.8572752430363964},
    {-2.1964420156276936, 3.28078576414737, 6.301918685232832, -2.887837583629291, 2.948954320234946, -2.4617822408920844, -2.789652028290297, -1.722503883518459, -3.2224171816785527, -3.3775502229683907, -4.613736517730962, -1.1259855892532784, -4.49355439622472, -3.1286151471445898, -4.766835964675564, -2.476405030423505},
    {-2.6049105951445384, 2.4191332109267747, 5.824068036582352, -2.1331128338331813, 1.8076450223206768, -2.716972379633785, -2.8238831535320195, -3.378712829030505, -3.2576033850329322, -3.4636739511235763, -4.355077219367299, -1.9918138498153817, -4.171427466999025, -3.008284804334255, -4.576274058695857, -2.344127262613366},
    {-1.7958949161395241, 2.2886399972201903, 5.796292452439567, -1.8370485846170617, 2.505331488433978, -2.1967866802510554, -2.6811140567729725, -2.301040256057062, -2.7125694251635215, -2.389509378155434, -4.078046691923947, -1.289777788676322, -3.3998232797610197, -2.6670423793483184, -3.9060076666486876, -1.2860151050658755},
    {-3.2911414202366456, 2.904743545092327, 6.134400125641311, -2.6760904783946717, 1.2848558526047222, -2.004443125106186, -2.7484829855223163, -3.545200348582281, -3.6519032526233346, -3.943017608529834, -4.75881402066174, -1.6498466792230546, -4.851962725707878, -3.601033833133966, -4.686900061979035, -2.520776777730859},
    {-3.0145575723030507, 2.8202924407355527, 5.696212456610588, -3.472849501298932, 1.505799964536894, -2.0255500981798265, -3.552666998483941, -3.2970128484190058, -3.7699489077236326, -4.038129711013076, -5.062710105034184, -1.9920018527213788, -5.0664963997013945, -3.682260800364556, -5.24490967297148, -3.1236895330462113},
    {-3.3997629123664788, 2.037355991810223, 5.497622412216937, -3.1084230271536923, 1.2467006867161678, -2.2222321416806117, -3.4097392706310674, -3.696148268280474, -3.0000537188471927, -3.219313935763138, -4.5957662920510804, -2.0123465107431247, -4.5614979765864465, -4.212300765179286, -5.078367988832213, -2.8840920108653276},
    {-2.195103460198518, 1.9643374220985828, 5.244430094856291, -2.279937231939137, 2.053924613911635, -3.0924260011643327, -2.6938724619071164, -3.0075463808546012, -2.408629416396586, -3.302377703217391, -4.816636214533806, -1.78849160686956, -4.520491742820536, -3.8273779457011563, -5.003684133688779, -2.5809893692503993},
    {-2.6755085101206437, -1.6296290085023941, -2.064010922371776, -2.522016744886479, -0.9558543848804963, -2.9030164846524977, -2.937657335251434, -2.9936860493676067, -0.7356488099741244, -2.8969328256140376, -1.9652765363554061, -0.9321163125882557, -3.3471950108679565, -2.2706661985035104, -1.755152591466708, -2.231774595803076},
    {-1.6812439539693114, 0.6521565789323346, 1.4863135976730262, -1.2801213395662538, -0.6112052807605123, 1.3363312377400127, -0.49843358707942165, -2.845414491442234, -2.0366095475642925, -0.9997419829200743, -1.7151937359513314, -0.23480280135889675, -1.6785056527313587, -0.901512192799355, -2.2803258744049626, -1.3863507137661837},
    {-2.9548051176769867, -3.024702673171412, -1.6551478356137834, -2.1027784672685934, -1.1730657190600942, -2.348124482667011, -2.7257230497826863, -2.0389612347916763, -2.2703977651857863, -1.3894767990429708, -1.5562457787026538, -0.5727298127771315, -1.9920971642834728, -1.193247257911771, -1.3801692885545953, -1.739722432580283},
    {1.0133749711394293, -0.1432525456641581, -0.0763816607854548, 0.690833271690818, 0.23869704594038896, 0.11337628829768977, 0.05114753827219503, 0.6153086589081211, 0.30103338461972157, 1.1868171676942587, 0.5077260766609364, 1.3513487011707936, 0.9540506794118712, 0.5741852638650315, 0.06332288681019457, 0.5351598940591363},
    {-2.691896449252551, -2.0339724431513577, 0.02378091744118819, -1.8432985675908378, -2.5229130824829347, -0.6895957538703228, -2.680082934936716, -3.8500007392991575, -2.9830292512351266, -1.8726739650814614, -2.8602792073093015, -1.507179861577707, -2.8557168970138904, -1.794202286024865, -2.4706007283424216, -1.7156576004807749},
    {-1.6250329960844803, -0.3140367117802484, 0.687422240896012, -0.07609830117394256, -0.07591255462423982, 0.45611053036735333, -1.0558290341515548, -1.5602027486518444, -1.2295655213130645, -0.7515840177463045, -1.1472199380830352, 0.7746185366680793, -0.7162505128121325, -0.5222323555072703, -1.145470808087236, -0.5376397380287576},
    {-1.5209817818586766, -1.1661175299967514, -0.2572250770569251, -1.6414999880302636, -1.0314722549401125, -0.4792226015680589, -2.1646534461967364, -2.0321574251510426, -1.4613394548988876, -1.9431008180885843, -2.0020004485234058, 0.23019922957465852, -1.6104678081183483, -1.6394224175660943, -2.150318996088733, -1.753914302654626},
    {-2.883527211564091, -1.2565768177620327, 0.5930540905624962, -1.2635965751419016, -1.3216159577582276, 0.17181356955025415, -1.774403275693288, -2.711569889255, -2.3280955609753637, -1.4755223565716853, -1.7547975514264678, 0.026302039476537392, -1.5169207447877384, -0.5912773162266642, -1.0205832990515649, -1.8373628705786649},
    {-1.9409054206074197, -0.38081108453988427, 0.1653152452251717, -1.7062120999075465, -0.6318829477406839, -0.01976898963736527, -1.9504452313659835, -2.1476671217757364, -1.3562837563683852, -1.3359101662661563, -2.3836875696934507, 1.0036648444339806, -1.3864235286498356, -1.5598407870922104, -2.209161805086522, -1.9061257629792372},
    {-3.3657154630864317, -0.975318330088815, 0.29919818146024835, -3.1122280505265785, -0.596007859626925, -2.0187259124216546, -3.256408845753041, -3.171330852349073, -2.53255369304103, -3.6032054676714904, -3.9843535935983763, 0.004725376985860287, -3.2182778130137972, -3.0526016632663935, -3.604629159883782, -3.4496094427758948},
    {-3.2331827728823037, -2.0708744143611773, -1.1262106482068193, -2.82158367346804, -1.8789367215971262, -2.2962108480837378, -3.5037030351158855, -3.550049768978267, -2.5169059124867306, -3.103575379553346, -3.1900332956892004, -0.2181759045690581, -3.2326650470030622, -2.600817107815404, -3.3205138252383106, -3.177593942083465},
    {-2.5472142417362815, -1.2434087328216585, 0.793501494293054, -1.2398825275148226, -0.5421241315858935, -0.8142303267598107, -2.41813003772935, -2.531533693352699, -2.0618065093819213, -1.9818292828795148, -2.292688783415015, 0.3463682813611305, -1.3491558183540724, -1.5627392960118953, -2.2058537499068414, -1.7517924642501146},
    {-3.063461445971268, -0.6228219521472457, 0.6877115343523769, -2.1051054863398795, -0.2720773676653137, -0.8839916834281989, -2.9841416450324787, -3.1616287850257723, -2.0543323836848386, -2.8136682085956233, -2.4720885365772696, 1.4288268304228433, -2.52930802401757, -2.1961459507533276, -2.7187363087131966, -2.1086243353162084},
    {-3.4930696351869064, -0.9521547290651303, 0.5791774524789428, -1.8330421853776095, -0.6883619387100929, -1.8149773362855635, -3.020859461545364, -3.2981487828480085, -3.006465771529693, -2.6498123692754225, -2.448324339508555, 0.551303698444303, -2.266171867736806, -2.084863666194093, -2.7323212991126247, -2.605285658550745},
    {-3.236419738160868, -1.8732270412954162, 0.061560550793775065, -1.830667175166587, -1.3395248513551783, -0.43687007164156694, -2.6524112035653027, -3.4199070086641123, -3.045522076928274, -2.7184653278640094, -2.612826775932068, -0.29933697423741745, -2.0301202775925145, -1.7845655769486248, -2.712968634954288, -2.2912584976963912},
    {-3.926651352839533, -3.1577118718526167, -0.20617774362340993, -1.5562184383393043, -2.003318299246072, -0.9384615000452572, -2.146173275235197, -4.309786932960718, -3.712714907803246, -1.9023429232004243, -2.4810335744675656, -1.4447150692159472, -2.0683957815249614, -1.768471500374084, -2.424239264805863, -2.0336825346254894},
    {-2.4728380713079074, -1.613123314589042, 0.24044299048151058, -1.613810684038518, -1.2447929490665866, -0.8291826291284288, -1.7181128692702627, -2.190272149685324, -2.5367447517979627, -2.1120524100483817, -1.974510322698849, 0.3074936693607144, -1.0859378095524324, -1.456536674090308, -1.7999632059937707, -1.6766030726474057},
    {-2.9495913842881016, -1.532219409433954, 0.7987483383625963, -2.21948671875681, -0.8073913096902504, -1.2164360188102408, -1.413176193940116, -2.060152580709351, -2.3691620780816907, -2.3441362704051585, -2.514526812438916, 0.29610342923958766, -2.079566030576183, -1.8060494716452848, -2.152965380386036, -2.4495044853412606},
    {-3.2187798358407362, -3.47630951048483, -1.9352172398334597, -1.7681771255827847, -2.1520090975439685, -1.3319381685916933, -1.8682995794137163, -2.844898861848068, -2.6023039658858473, -1.715825073260715, -0.9770206216541795, 0.2943643247105092, -1.396790432660406, -0.9260429317235751, -0.7954764187681304, -2.0290142008799528},
    {-3.016302281066245, -2.1255807214792157, -1.5255324333139628, -2.179011122878974, -1.2112180026578394, -1.4670400682199154, -2.5952638312565197, -2.6258583217806657, -2.0089195651282643, -2.661665306973684, -1.7673717415113865, 0.9681788374030181, -1.3748854933844723, -1.8650049311513572, -1.820101035112035, -2.584615507199653},
    {-3.0531551196886637, -1.9135360882271162, -0.9007965611856896, -2.6314614859879044, -0.7823749944455519, -2.6061946634764914, -3.693719426572169, -3.439921950717205, -2.67441992349873, -3.2769496358854706, -2.377183881869466, 0.5192454586637403, -2.2265372056750112, -3.039478336190454, -2.824952562224362, -3.2424476276734193},
    {-2.3205741761687837, -0.92112275098656, 0.8077703699845445, -2.983187081319332, 0.030155254209356698, -0.4705992693771976, -3.4330471250208787, -3.896214094529101, -2.780376753222649, -2.801142844895501, -2.1735282395411506, 0.47903713552353006, -1.8672912643904183, -2.8447063296216837, -2.895856361377364, -2.689449558533199},
    {-1.343355658394038, -2.0752786055833985, -0.5361988063203807, -1.7516425340801782, -0.6844986102487749, 0.9902825329523127, -0.7921641222550939, -2.0609199865349392, -0.42119912956223027, -1.1748281873786073, 0.3589524030989197, 1.1275701687561126, 0.22384593721921922, -0.5928559767413653, -0.0050092923045706, -0.4227097277101978},
    {-2.64003983400216, -2.4498595789550053, -1.0652374703533394, -2.0433318819664463, -1.8986072682694977, -0.06133948204711136, -1.7910504446253461, -2.30699122082318, -2.305476711003028, -2.097633705102606, -0.36711112409297125, 0.8414200526318509, -0.396122974718574, -1.2072489314961028, -0.4673963396490196, -1.7105968869062858},
    {-4.443195304009921, -3.3111317726741207, -1.3138746078460486, -2.6148502648480862, -2.408012744209446, -1.5042516827766637, -2.8745829046459814, -4.813126782592039, -4.05719264967534, -2.7214179167638504, -2.163238068853669, 0.5105657000758176, -2.051055723066904, -2.0990722965515056, -2.0677271872285226, -2.950056980353522},
    {-1.4689643080598254, -2.4134723329784054, -0.5349863374761051, 0.004914556830544836, -0.6094292298677229, 0.7527654128196094, -0.3877470141396021, -2.0005426538682234, -0.9690108652124185, 0.7582680550661317, 0.9869655225799645, 1.6846384218044776, 0.9546515034476345, 0.7220955066772047, 1.087255503066457, 0.1832556341556248},
    {-2.831891707053878, -2.470150585402954, -0.5765623406685227, -1.0146246304169395, -2.226659411317414, 0.6178419867202156, -1.1177836227559836, -4.761950887402801, -3.2169358669109056, -1.234289295130075, -0.48782862308832636, 0.28965836388181915, -0.44168077510744047, -0.8046950336066341, -0.29436908356028935, -1.4386744126676556},
    {-2.1052871737812286, -3.8177155681441333, -0.8206449939510283, -0.6657767219235396, -2.226624140980545, 0.5010974283072795, -1.048203030374108, -4.185876283207644, -2.8867761879568574, -0.9361205725942354, -0.22928886003239143, 0.11679816315203338, -0.2106343177617244, -0.37864689141051083, -0.4278703332510815, -0.42553632698116495},
    {-2.258095942179329, -4.373920438208115, -1.2081049635608208, -0.6397683414529389, -2.2769834719448165, 0.47986741876651035, -0.8562319127514355, -4.118221566042655, -3.172397073280563, -0.69782321208385, 0.049837768354780494, 0.4423684834361332, -0.08967755304198113, -0.19386209079899952, 0.4058819474224431, -0.5173154297892907},
    {-0.5393782658896938, -2.6411131729973296, 0.14187412939344282, -0.18960086473001653, -0.746226113696243, -0.27556382206092706, 0.027745613490099096, -2.8874533193454934, -2.123336618268459, -1.4879245731348816, 0.05276520101964485, 0.21164510643674303, 0.5670457337088152, -0.2830996453184618, -0.10515508284343478, -0.6949941773053929},
    {-1.0904260361564702, -3.8463867980072832, -0.7835262118948898, 3.743912743822292, -3.830224181367267, 3.1164294706356523, 3.0682011756983876, -1.8598269110273178, -2.039289015527817, 3.0546571970580407, 2.1595932659270516, -3.253762960847457, 2.7704275905321007, 2.678052987896855, 2.4349233853506953, 3.539084420112939},
    {-0.6552296839719043, -3.1659638963439325, -0.31334198342642494, 3.1435412047902394, -2.9899424949526896, 3.0880792332645113, 2.7934185775033056, -1.1654223117070468, -0.8381052511932833, 2.9828179699316917, 1.979287159042847, -2.4679608928842574, 2.1277102027297636, 2.4089056419395907, 2.336359058888763, 3.1809924447330764},
    {0.48498109414551216, -3.8490786195687914, -0.625369401016047, 3.612491805046531, -3.873384912845236, 3.932530593113833, 3.7069610426197936, -0.5074545395562914, -0.5244642420438299, 3.439956624193977, 3.0332106007450834, -2.6839614983979927, 3.1987785500518595, 2.8205881067552583, 3.2698496960738708, 3.9583286379599496},
    {0.5784396797974732, -3.2014038102023847, -0.29968718900142005, 3.3406573860729134, -3.1186488900831346, 3.1101889236843854, 3.12830270782621, -0.434665318963004, -0.6596364264325628, 2.9387655047217947, 2.401933472511302, -2.501434916874271, 2.4225646226072204, 2.5285736039248934, 2.426305899027383, 3.321959607713573},
    {0.6804900373328939, -2.6875938339091525, -0.42599557041935515, 3.3112856052660558, -2.905208881328919, 3.026591650284706, 2.942998655499948, -0.3033879418333768, -0.4678437576940084, 2.649300990138686, 2.0254763690927997, -2.52912819106771, 2.5869534242497374, 2.091926274103223, 2.018125982076398, 3.215143249324958},
    {0.03616302316176018, -2.945348154562395, -0.2800440561824175, 2.962561789240474, -3.366949123363497, 3.190786491178793, 2.7903752232813703, -0.7358415528110018, -0.7571778155579869, 2.559357301140916, 2.2850168388985965, -3.3643463434827825, 2.5919603673808, 2.340729106736578, 2.569926945330203, 3.2823608217697084},
    {-0.6196312125830313, -3.105047595556499, -0.33259595317621327, 3.0872743101963933, -3.657911709990584, 2.981630858577197, 2.7436467524853105, -1.2576993948636537, -1.3158200407219898, 2.541268466048815, 2.340308833423441, -3.4797482031896103, 2.420925907544848, 2.6293828319163115, 2.4003264345045174, 3.170089705275383},
    {-1.1116021340341373, -4.176381309136398, -0.8184748671193526, 3.2624577512636357, -4.607246517539845, 2.8951671306869713, 3.0397833921560617, -1.9963470878056448, -1.993747284591979, 2.7955439093638392, 2.202953456105674, -3.9090430595942274, 2.325610249458428, 2.449513749971185, 2.393532784370495, 3.313180681088081},
    {-0.9046999077126356, -4.361403925035108, -1.5002774558265528, 3.742440279982887, -4.312861933634877, 2.8724582627598987, 3.3873326569127147, -2.1036309731171903, -2.0026028932040694, 3.036101090154876, 2.6927186500651326, -4.112459949102009, 2.7062027718850215, 2.938356093176742, 3.076923364049113, 3.5891129244732656},
    {-1.4374683498219354, -4.049434752685292, -0.6303878539511344, 3.546887192473508, -4.545742789459003, 3.3246236589403293, 2.649701100951358, -2.3107573613271097, -2.4451466871245393, 2.3011255285520105, 2.257002653267013, -4.370467294899293, 2.5019358927147333, 2.7581332887441796, 2.70523668761286, 3.143004405396408},
    {-0.7254230233083413, -3.2614833299458206, 0.5235209539455525, 3.3908747679641413, -3.7668641797331217, 3.2370593411812534, 3.2507977876032714, -1.7217803503727123, -2.0180979174590132, 2.8129438694718463, 2.165510737697319, -3.848650340845117, 2.6525674859532393, 2.5057921768044826, 3.030300795962596, 3.6340592472547244},
    {-0.8982676669685086, -3.829973072018686, 0.20712315748157198, 3.4477904058987785, -4.213329032209052, 3.8352383514714377, 3.657868825792577, -2.1579605159462645, -2.294822888932456, 3.091796265736309, 3.148864984109479, -3.3771476065546997, 3.2048986890695708, 2.8117411636107468, 3.1664834953488605, 4.24971709536775},
    {-1.1505926038384469, -4.085750083344911, -0.33229210942486437, 3.768209352376225, -4.637858028879965, 3.8387778132921, 3.220677154665242, -2.532587841702521, -2.5925450467000353, 2.882000136093332, 2.8630776096152726, -3.6115665117684355, 3.183450961152266, 2.9940465287121754, 3.219658477871498, 3.7133194351396703},
    {-0.9601988095758963, -4.182314992509839, -0.7880334549588637, 3.3875132001222976, -4.399611677162951, 3.288939139932489, 3.4491541870201803, -2.2685593892322395, -2.20450341605003, 2.8113830630549494, 2.5217614782299798, -3.452436800207266, 2.6862541612496513, 2.7724597170059977, 3.143517022392443, 3.6602075688727753},
    {-1.7529974535244417, -4.476666232459561, -0.8933767821159075, 2.883477310760817, -4.675913018342561, 2.496641015994246, 2.4761403367787675, -2.759664023022097, -2.8554343934067203, 2.2868256750855256, 1.5030670250878266, -3.9183350541942503, 1.6670407620368441, 1.9849673291435999, 2.2498222700184587, 3.214429746040129},
    {-1.037420566578319, -4.316346722821158, 0.8217459740991051, 3.7606272920575283, -4.7998309056486645, 3.67537294524527, 3.4658031796433146, -2.4610530349230206, -2.590360865232999, 2.6374407059901963, 2.0680962826039075, -4.141336713069004, 2.448897069858078, 2.544984130398153, 2.4854726034085504, 3.5890610770809155},
    {-0.5335667376707409, -4.0875860865809175, 1.480594744538843, 4.203461586898078, -4.599498111371857, 4.443435811577566, 4.022533567725247, -2.04446299252208, -2.146696603805038, 3.8089646726531288, 3.207000698275306, -4.074989634148852, 3.4177836332005374, 3.446189384829853, 3.6274538820010624, 4.521398925638683},
    {-1.039002368889137, -4.370624722683821, 0.05693508929456192, 4.029898216348119, -5.090709756082006, 3.961655150915043, 3.9520440101829086, -2.0972398228682927, -2.6274918491118235, 3.48586455010233, 3.147478884472703, -4.074490974399542, 3.32365436582431, 3.1306609560347534, 3.392491607316116, 3.914196563867605},
    {-0.817767131020784, -4.469040430169779, 0.4272761317224639, 3.932137981562519, -5.04659883778469, 3.6839260697409806, 3.5222331951515895, -2.038562449396792, -2.2012770747863826, 3.2777227667296316, 2.84282970026722, -4.1283926697266615, 3.0280623839018617, 2.806928029839347, 3.1208054237775316, 3.8321523633432575},
    {-0.42828498270281135, -4.44570346601593, 1.045515931846064, 4.4516991626184454, -4.541168493253374, 4.796008065192849, 4.237125537259996, -1.8756464183583155, -1.7072433986635138, 4.040099863154276, 3.8820480972925804, -3.655064420978871, 3.547481872109118, 3.6597630457841706, 3.9588600944129535, 4.610683235926112},
    {-0.5456232143453159, -4.122472924390599, 1.3097851586439264, 4.3412997272070735, -4.858547757700357, 4.444730728914019, 4.265775016583701, -1.7945258880845438, -1.9155514514240162, 3.8234398175270807, 3.156768952859632, -3.6757748819172997, 3.4456844087628666, 3.377332556867751, 3.2526403347405646, 4.426581343064661},
    {-0.7780540014191532, -4.412330979189053, 0.9709519272629045, 4.4976639097070565, -5.059951143995464, 4.612659058070423, 4.150943454505138, -2.2001258709158678, -2.2175343993070213, 3.862592267955489, 2.9596304332662045, -4.131985789536669, 3.3419784758880255, 3.516787801552518, 3.47305256912237, 4.564465615098576},
    {-0.11844985457768799, -4.5832090859447865, 0.6351776602892084, 4.268375359444756, -5.472448142479292, 4.552877827365707, 4.296936465030665, -1.671771180873934, -1.799347415902249, 3.9137888270371155, 3.2673275680959493, -3.890303302883643, 3.267693596751666, 3.583519338064601, 3.422905460468304, 4.727488190514068},
    {-1.0022800203617355, -4.949830874193812, 0.23756297224614176, 4.666875910839988, -5.300451613215157, 4.8817712342027075, 4.298152662683759, -2.3843507651397995, -2.6809901335993067, 4.0339385757472455, 3.2115676456549105, -4.399359285494859, 3.3803610009280645, 3.5996109762626753, 3.9756679232998544, 4.624765220395539},
    {-0.6200383812845559, -4.549239801224879, 0.5654833282450504, 4.223067879459229, -5.027582165440436, 4.5555124190867025, 4.283385717590609, -2.0138157186340755, -2.315663807002501, 4.0619770525173955, 3.3829087595288594, -4.103711009827647, 3.454328804299313, 3.461487735779332, 3.8016532566362033, 4.62230355198916},
    {-0.40829222109624314, -4.863947230399451, -0.00833606537212717, 4.1041301491629305, -5.2273424071906005, 4.838039848615415, 4.26123206809825, -1.9106601385085544, -2.2499641054318005, 3.702454562309487, 3.4445012389605165, -3.9049530266526187, 3.495090177037458, 3.605127771606966, 3.6677078225372517, 4.518894184225176},
    {-0.5886333875288998, -4.876313560073083, 0.016843373607055696, 4.375738426506375, -5.3496349543119175, 4.179877175995369, 4.067134074629807, -2.302505832365907, -2.371949568374485, 3.956635263885347, 3.2138417351534767, -4.333422306007524, 3.734210382463298, 3.318814900777355, 3.909062765312306, 4.665413906767183},
    {-0.05261071121672962, -4.880717326884442, 1.2991620976189713, 4.505756938996639, -5.1580085360575145, 4.898663859082948, 4.484611407004942, -1.8616933919523733, -1.851380178221425, 4.274536460093507, 3.784101379167066, -4.190803912434516, 4.230671410515235, 3.8489327323804607, 3.991904590850576, 4.860906565610696},
    {0.016541758929692566, -4.583330794772607, 1.0143801136301147, 4.194289852746122, -5.081727575981518, 4.637874035544689, 4.282481893155275, -1.5845929053892194, -1.5506593878376678, 4.083695282598444, 3.497443812426381, -4.0722006859837805, 3.8618808850425728, 3.7515014901077364, 3.5562800234404013, 4.7697831435679525},
    {-0.3939647092229536, -4.5598007321491405, 1.0780821357376191, 4.605201109610411, -5.101644980757881, 4.71962955481783, 4.590098254473744, -1.8490778918686905, -2.016111087970173, 4.373943139550024, 3.689015988082496, -4.033385099013231, 4.092664336855404, 4.1237212338556315, 3.9238946067092892, 4.975152104013361},
    {1.7629048883668186, 0.35678826024687205, -0.8303409309439289, 0.20231939559195602, 1.0042907763682665, -0.060029588695105475, -0.09646699216079341, 1.061396837819268, 1.6520296728080426, -0.4420967711204759, 1.5472036398119553, 1.550648658747009, 1.0848355882301555, 1.7109295139655918, 1.8830267081533925, 0.49910406651433603},
    {-1.8366799385615185, -1.5102304588540767, -0.6077235029100619, -0.7417342328436884, -1.8905391084445693, 0.9579915429044621, -0.7206214878050913, -0.6735230796810998, -1.3201153735193305, 1.291527805009216, 0.4170929155901345, -0.16324151367231804, 0.3837670500540537, -0.05996801297179746, 0.48198189708614825, 0.10632096967918607},
    {-0.8309044850425463, -0.8853048917291054, -0.7242646201509838, -0.0023862813679912036, 0.5284219205312387, -1.0112401284027366, -0.4357805503219064, -0.5164908240868556, 0.3894060388395647, -0.6115426098204007, -0.014153578917941528, 0.9829982245389712, -0.10513343789120669, 0.03492799661586096, -0.48608366460366476, -0.27413921168516453},
    {0.043316786933084536, -0.15574873535967704, 0.4235674850295749, 1.1662213346359236, 0.6031089734927185, 0.9477871941753838, 0.8994610897089244, -0.04134786460066318, 0.39005296243475956, 0.9968280727868026, 1.2386761848628693, 1.2525674112989846, 1.7286749848121123, 1.1833202095805335, 1.140374353063949, 1.1387722902914872},
    {-2.2053169564063677, -1.9977550396653745, -0.011884923320576014, -1.4426737834983132, -1.4892164328181674, 0.3349691789471701, -1.7361932770969393, -2.6461910895418113, -2.1404127841436305, -1.788882645559663, -1.4069662734625186, -0.9987439310058063, -1.315145547005012, -0.9485274916335353, -1.8371960088024968, -1.5015789013367336},
    {-1.163094984815766, -0.2149776301354945, 0.9528948786519634, -0.6144329644387672, -0.23201160140443236, 0.18409722701118314, -1.385171099499917, -1.5670156979566205, -1.6666673669832401, -0.8441015054965468, -1.2762459948133136, 0.037644065557398916, -0.873670781189863, -0.7308924285338537, -1.1168515379310697, -0.5157058120557297},
    {-0.7028229897469082, -0.6725366634280437, 0.17333443793718603, -0.5452847451803067, -0.8274277561401389, 0.31088647689738097, -1.6511069862937944, -1.3536277791134192, -0.7141035648767075, -0.9069286994700128, -0.9094248135489579, 0.09759159159047395, -0.42633086545747856, -0.5411249749161983, -0.859749738174677, -1.007619464738891},
    {-0.6876232262296865, -0.34617292256761406, 0.6586388041289339, -0.8578432664255707, -0.2353327749071212, 0.30711956968802007, -1.2126785347902784, -0.5258897518441502, -0.5393473602420229, -1.1392605325299638, -0.8888238285603622, 0.7442624489303956, -0.579875540214224, -0.944522122324453, -0.7542642668227512, -1.1538263366009804},
    {-0.8980605518983635, -0.5233669507266895, 0.287827712244456, -0.7085395227036185, -0.5452869849311606, 0.37180773151030216, -0.9440160076069826, -1.3226636184650147, -0.6214057855886173, -0.5893407502771323, -1.4102792208822337, 1.0991168938859257, -0.7721966713216032, -0.8344276791943487, -1.257319740234707, -1.194303051273261},
    {-1.9402152941101474, -0.36965461459093046, 0.6033717706685281, -1.5347613647476726, 0.17224985421377875, -0.7602943032110042, -2.225459972293159, -2.0094944777092456, -1.427144687724569, -2.007942358218041, -2.6174228025042274, 0.6579628513597179, -1.6001365585812937, -1.730626361964595, -2.152359515250061, -1.6887521237756336},
    {-2.4235728859076393, -1.2262766321146115, -0.9309379058783742, -1.640101810693547, -1.1448962213029483, -1.0457091724819736, -2.4244441839544026, -2.8113923417059614, -1.6568735014401612, -1.4151573476186565, -1.5484730894393637, -0.05360095632106791, -1.0193480211601624, -1.4530458172540843, -1.3838066736655206, -2.0628956187306673},
    {-1.7106663597120655, -1.2684052055736175, 0.6092258193111907, -0.6769801336080151, -0.9107205749733082, 0.5640849519025553, -1.3378928157926815, -2.1229623760498293, -1.791882003763132, -1.0317511158162902, -0.6973584828434288, 0.7290305255675461, -0.31520918252358643, -0.43551614748901313, -0.5557712355060899, -1.1374434289969104},
    {-1.663066439317325, -0.41197987394683594, -0.025208585875174938, -1.552766482189563, -0.2068071354619265, -0.5980989389523066, -2.4614641415785314, -1.7143382617171568, -1.1764918596892224, -2.2430625440483194, -1.497345471278749, 2.0310402121732176, -1.1139114513910866, -1.4581300488574664, -1.382009451434052, -2.344248000744186},
    {-2.4391162479037165, -0.9391592352007606, -0.011323292754681698, -1.3833937285684006, -0.36498283256693465, -0.9307092859373787, -2.2224813044826, -2.528729095345871, -2.0677524929981885, -1.754058146908112, -1.3223921580852604, 1.182607854932843, -1.0450209699188662, -1.1161009522954783, -1.7656524440824117, -1.9515553455591326},
    {-2.3076046340244623, -2.065643193178314, -0.6584281106556439, -1.5561812885673758, -1.34922861687835, -0.41477062293002137, -2.0330554109935344, -2.605140360129441, -1.973256459934293, -1.6629969018388309, -1.3066807224391253, -0.2772303341798348, -1.1800169206422122, -1.1628932359458084, -2.1261145565197177, -1.802106095349111},
    {-1.3665769184128678, -1.8482093975321081, -0.08941083028009789, -0.3285145019839341, -1.28285935768281, -0.16098284578633928, -0.48471591737142744, -2.301812705080309, -1.8505501349802662, -0.7036156465548934, -0.44149737260959987, -1.0857791367912653, 0.1392585940192926, -0.4402264408426234, -0.36176211452229085, -0.22314590533988604},
    {0.8149449633034151, 0.20970002390248196, 0.31682758630629676, 0.03909857777091294, 0.11457468711691036, 0.6257702726211184, -0.3002337029741704, 0.5093267020329488, 0.47663163606917985, -0.482769132758894, 0.1697571286154387, 1.5399749228569366, 0.9477543259010656, -0.3752128486396819, -0.11319755810119746, -0.03184957005876545},
    {-0.9399626411816994, -1.2388260645113618, 0.13040406730771967, -0.8385657795837222, -0.43241216974543284, -0.1854361832143681, -1.0021375829882646, -1.2830806452943533, -0.5986863175126769, -0.9449968707379635, -0.405833128606942, 0.5724907956970953, -0.46883141119355914, -0.8141124358538903, -0.8764641944776689, -0.9490654710829031},
    {-1.2683382880365663, -3.1297180454753066, -1.3768759997596185, -0.10704178288961602, -1.8918128937200716, 0.3544295888475484, -0.698688958784982, -1.8921265884019722, -0.8261824796782327, 0.13827437459590447, 0.8617752874809825, 0.1710566823677171, 0.7046730547031096, 0.10308921972388278, 0.6536300377938041, -0.4207182745293806},
    {-1.328049169666623, -2.1825533333933143, -1.5318328298971469, 0.0562947334186646, -1.2625680410123252, 0.8161744496591713, -0.6271366321498888, -1.8701205922825794, -0.9101283487345632, -0.2806813661209666, 0.5822318703330842, 1.1086303172989644, 1.1289217735717154, 0.41430952315842595, 0.43152205236795, -0.4404019239040423},
    {-0.5822553180677876, -1.2677194520042814, -1.070679723109807, -0.38338777303584565, -0.9071433493909392, 0.036359259501873874, -1.005665681744429, -1.4508762441723895, -0.979337529959867, -1.3325544945382881, 1.3069733098131116, 1.3195972272956873, 0.8089353523676094, -0.1735014829890823, 0.8056637502428879, -0.833929437354564},
    {0.0229553441492611, -1.9485253528415558, -1.0851385317231173, 0.05974500194377768, 0.14275022138545684, 1.7058358560871334, -0.39729877017437265, -0.9648618913870902, 0.051346871769087185, -0.39485964572965343, 1.715682089459041, 1.3783616047389629, 1.9497818228656156, 0.4858356231289022, 1.2795757833040373, 0.5099876360279849},
    {1.7153992092814465, -1.4539815700316294, -1.9125654573511421, 0.763432460357235, 0.339306384763466, 2.4131540675184437, 1.2849048812446695, 1.2155908332860343, 1.7948304953411969, 0.8272906318347973, 3.2706729168809243, 2.16565517508012, 2.976504891510493, 1.7389193113023045, 2.4533574767847477, 1.9298792597695404},
    {0.5703336029103672, -1.430130994859707, -1.3302520976691077, 0.1213485503592873, -0.4933458772495309, 1.2760637428826755, -0.10220263787396999, -0.07972575531712288, 0.3825484156026451, -0.07900257156867677, 2.081046311029523, 1.4803848953365997, 1.981721055178679, 0.7418990711418364, 1.555080350237746, 0.5749335869186917},
    {-2.0063897913829694, -3.743479386592385, -2.2042287981687987, -0.3799596942942937, -1.9590530201971452, 0.40916531016865465, -1.0378092133154224, -3.1982266532775436, -2.0765524741153034, -0.8953930045648653, 0.44579752564084413, 0.39850148244098427, 0.42184269713943967, 0.0012281252110234418, 0.14606697690069426, -0.44626237199643565},
    {0.6750579422680569, -2.058799588997501, -0.6794618235860945, 1.1401127809947165, -0.09353988903374778, 2.401654280408319, 1.1115802812168412, -0.18812913944197374, 0.968839105286009, 1.6597140541899706, 3.146783426153365, 1.9515755475886472, 3.1559823510356115, 2.1586565438089416, 2.5579041771148816, 1.8946305456520836},
    {-0.9844141527857853, -2.5903723163568606, -1.4306275595523674, 0.30706594493005923, -1.2191029585180955, 1.6513087588682394, -0.014871866434584387, -1.8594847355262272, -0.3018951612024164, 0.3526709078234406, 2.0581630117703065, 1.0296590806467822, 1.9304232128949603, 0.8962388066260815, 2.0160385347900456, 0.6571041385880605},
    {-0.8118462310255933, -3.2455924092190838, -1.108485035086727, 0.4937612959485774, -1.4788399160180268, 1.47747438239918, 0.28977479430130343, -1.8801206467830578, -0.7936843783274045, 0.32326553983097206, 2.1720036730098, 0.6826332354135817, 2.042333082299144, 1.2734649879136979, 1.8456043901958585, 0.9728735209865823},
    {-0.9423268723206342, -3.4314009952188367, -2.2040884630522286, 0.2511575682721461, -1.5543134753204235, 1.5969939248810108, 0.10318267699321199, -1.5913334537112884, -0.6712074860925313, 0.6382491851900056, 2.1378229719736903, 0.8019355984159909, 2.137760438156214, 0.8480159747100943, 2.2395232610570206, 0.7267655468489322},
    {1.3669923495213552, -1.3916540802035702, -1.5634928194376891, 1.200109716018904, 0.13714650411176718, 1.15550218123425, 0.9742950012471442, 0.27266604308077347, 0.884629320097537, 0.08637937728572583, 3.2438814147064012, 1.548045514788789, 3.0377140121487973, 1.6167687039853922, 2.973208962323264, 1.3841942827575913}
};

static const float b1[16] = {6.727179058887472, 7.17452494434287, 7.08890069008721, 5.590575072204335, 7.1511120224985385, 6.256276001987334, 6.0005411006658935, 6.651394013877664, 6.66097733171309, 5.891724626370002, 5.78405039049911, 6.762308371222318, 6.045411032183935, 5.686113967167078, 6.279150885726545, 5.968235092448514};

static const float w2[16][12] = {
    {-2.580941914676054, -3.2794233155542822, -3.32293799641619, -3.577487448543512, -3.0123131738685154, -2.6880420299654153, -3.320089832310152, -4.363372241171456, -3.0976529229122143, -2.618210184769489, -3.790225822916094, -2.873161360552968},
    {-3.987551748034271, -4.128706777033424, -3.5124106819888756, -3.4886500000740845, -3.2946430833788876, -3.8557269024650296, -3.5268642877962613, -3.2161309454063307, -4.568497116391753, -3.4583431176465482, -3.639332003681519, -2.593350417799528},
    {-3.3188318932874177, -3.06386249503141, -3.4150644762980984, -3.580197974248515, -3.4313111857230254, -3.3560918633587504, -3.2942199661066267, -3.1411410904596324, -3.230692111528148, -3.409150021812426, -3.338472719548333, -3.545462862584904},
    {-3.318432853592807, -3.538786772635897, -2.955152405180423, -2.7671466277015226, -2.878515422805997, -2.633353238324325, -2.7001709483605905, -2.2829686745568734, -3.5799879178634084, -2.1678079725677764, -3.427699189787591, -3.3730799387088615},
    {-3.210584535969293, -3.2362860739842256, -3.7421900257004306, -3.6793303373709256, -3.9016960296074235, -3.3600471569448858, -3.5808926260212046, -4.094575407469012, -2.508226844607641, -3.5074486341296445, -3.422745278010607, -4.429159616426322},
    {-3.1533742685016053, -3.0123882380063285, -2.742621066001699, -2.998780277563624, -3.102585477086733, -3.0508995037476407, -2.787231694218492, -3.330272241251594, -2.3812231251855045, -3.057126088948486, -3.0496144135439986, -1.7480048699111939},
    {-3.254115774125181, -2.909045874214794, -2.8538876634689867, -3.094989352934748, -2.674948482984403, -2.578175928024576, -1.8358376184811471, -3.6668406476440825, -2.6401099391137066, -2.801552532326779, -2.861691657095191, -2.149557358092606},
    {-2.636794219509632, -2.776141042610023, -2.171879048170174, -2.667133392423678, -3.359345284293492, -2.574137703828027, -2.715289121601327, -2.822120479656788, -2.866926692966999, -3.5993422061025258, -3.6653897742751207, -3.7228762052638054},
    {-3.8393978140824836, -3.1346098999716907, -3.797348242057686, -2.9252380782521685, -2.6693511258807927, -3.8170688453357653, -3.5023955361403174, -2.9593385324299635, -3.308108131335458, -2.790313941829902, -1.864123833748181, -2.83749723153996},
    {-2.2465154347516076, -2.518423736892067, -2.3176940042540695, -2.118376396632005, -2.938078433843615, -3.545315282977959, -3.1008531196880686, -2.6070100956101125, -3.413254997098888, -2.310776071376907, -3.1310503208406186, -2.6399219229376403},
    {-3.3556158630971638, -3.0560478031102, -3.5186051154838607, -2.889935433363345, -3.2699076400241633, -3.1942209590088786, -2.916827241132943, -2.4375402796486836, -2.942315651769598, -3.0491832850427167, -2.655145437012928, -2.7933869182044337},
    {-3.1129757839978693, -2.915356387217715, -2.82035030044208, -3.096885126955239, -2.9591528240869542, -2.8501633351401456, -2.9938540536687386, -3.409019043364214, -3.1782899091329293, -3.1529356320286195, -3.2624652366163893, -2.8903695973473718},
    {-2.3573247534702935, -2.2814120204578265, -3.8236891300230154, -2.487474073631022, -2.9821210360601005, -2.2586439849507496, -3.534855761487757, -2.669336254941373, -3.085696718082829, -3.2284024680681624, -3.5752841714657118, -3.6689454194462403},
    {-2.295884099429462, -2.998177145993172, -2.4021789721169, -4.034773885179769, -2.3141279246420354, -2.840647584998307, -2.92107867885149, -3.816273823352083, -2.146064683356045, -3.1240667683415224, -2.824496264462498, -3.5403401977127698},
    {-2.922044675705336, -3.143355577265581, -2.3832857846538773, -2.867139377022792, -2.924645668587806, -2.9547719048348697, -3.267583032731209, -2.9256438447930564, -2.883178077766815, -3.7593523966640574, -2.241274583760153, -2.9788182300935246},
    {-3.2800087398846633, -2.582837230811641, -3.100378142212478, -2.8651675441594007, -3.010202357285857, -3.1025381354353874, -3.2534994081375457, -2.643241308132141, -2.9693393886785375, -2.8556454168946397, -2.2994991688210695, -3.3331209972760716}
};

static const float b2[12] = {-2.8208182046049846, -4.439679879546226, -2.077587544314088, -2.049026230753817, -2.563657045733752, -3.267397510338051, -2.7498937155732066, -3.2864533868931236, -2.065442857630911, -2.8968499734743762, -1.8632101512697086, -2.721910971933485};

    // Input Layer 
    float z1[16];
    for (int i = 0; i < 16; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Output Layer
    float z2[12];
    for (int k = 0; k < 12; k++)
    {
        z2[k] = b2[k];
        for (int j = 0; j < 16; j++)
        {
            z2[k] += z1[j] * w2[j][k];
        }
    }
    softmax(z2, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
