#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][32] = {
    {-4.252532982591886, -5.858013392823941, -6.677491932014195, 2.128069425995772, -1.2105294194854221, -4.242433254970931, -2.2601328588656546, -1.3071971837007204, -2.2838488247829414, -4.699153051646174, -3.2916502375862544, 0.4221024496829079, -4.21019450446954, -5.789347602304228, -4.376810962654754, -4.622005132328097, -5.3436146161777325, -5.528037384785039, -5.314875598144774, 0.10244283769561341, -6.158766248668041, -5.346220764386397, -5.46486704701769, -4.290567924561889, -6.136415658550058, -6.544677153920878, -5.866587423466748, -5.508571055794958, -4.956497456533055, -5.116509288333576, -6.250465246897587, -5.876704588874156},
    {-1.4803201046649452, 3.619690317019239, 2.96546792546259, -4.225837003022398, -4.3514648777043865, -2.187703932422055, -2.5978739078223905, -1.3259194371477467, -0.4310326718606649, 3.366107457914287, -4.799494885621466, 4.229844430198676, -3.0492873031180716, 3.199821053947573, -3.37106424236901, -0.9938847278120783, 3.700123203205913, 0.2599380581767142, 1.4619380412930385, -3.0388712116527765, 1.7066048811443237, 4.254837793479715, 1.7456174768822073, -2.880655533408451, 1.0637867337741, 0.8536625022484934, -0.3747501429198722, -1.7552398339023214, -2.4950436109366647, -3.1241623007355273, 0.04467665176584242, 0.2956908903384953},
    {2.0451601293838357, 1.7574558938335085, 1.0209204613100353, 2.26742930120656, 0.27293657168932156, 0.3343631105903142, 2.063211500668873, 1.1309623171596894, 1.0943347814510218, 3.966913769864722, 1.1088706453383568, -0.758188091152014, 1.2530909883111943, 0.4732773722105649, 0.467584710220289, 3.805593627645584, 4.8089868770260855, 1.419923063258686, 2.3784070311836203, 0.3968462823167129, -3.6713527455595285, 1.1728743928370595, 1.7518094853735788, 2.242411983757417, 0.5098670588182809, -1.7715131322145243, 2.2218566071678483, -0.651132127414594, 1.9916629659739387, 3.261194563255882, -1.4816238145796201, -2.318595722120518},
    {3.1454657091853147, -0.5383667916295455, 0.48352064837750763, 4.695749980132782, 3.2671673631863065, 3.5922426133229086, 3.6168278202103488, 3.363416103705466, 1.1023400808603234, -2.4712934551706183, 4.85254744951842, -4.145703630141922, 4.3791783226469985, -4.098726444191313, 4.403816895112421, 3.7206890187280997, -0.9613942271624688, 0.3903177775586282, 0.36913663641810385, 3.9603846016687565, -1.705325342907203, -1.3904311126635203, -1.05573944283062, 4.4278328144039465, -0.003090503116562084, 1.0640831735206933, 2.97414731849671, 2.220735777305891, 4.428364422792084, 4.9320204013686, 0.42854197119684473, -0.06231960586461535},
    {5.333166408794173, 4.461838467862588, 5.4653894560574585, 2.444877105419852, 3.4261774563854397, 3.7000234800793472, 3.5461142179328005, 3.017483701573118, 3.1826815594177607, 3.431819095878313, 3.9606271235255353, -2.3121274949122554, 4.4238681956102335, 2.9837252306068875, 4.550892740032883, 3.9349414252813264, 3.8870257085262194, 5.0822312900640325, 4.986727084765105, 2.4803975465043875, 3.266764980107626, 3.3858301554622128, 3.1950195288968604, 5.0309764288320755, 4.588565081250272, 5.470571424061158, 5.183261852975465, 4.206762124184705, 4.832141286190793, 5.088200435953892, 4.836990089568625, 4.423415434660476},
    {4.533667727409727, 4.833747131482295, 4.815935057462165, 3.8260958243088767, 5.123833725010843, 5.940382254095517, 5.352574919107197, 2.352259724268851, 3.1784922034497525, 3.084005809989998, 6.021248947941563, -4.511745244175054, 5.795339674186961, 4.072419115804037, 6.630688787461063, 7.106946942917756, 4.718131082423046, 3.787523180391907, 4.137310005591989, 3.4937062286553107, 2.9491518605981537, 4.239353516069054, 5.32808881476792, 7.041729491696944, 5.571256901903279, 4.357409287867929, 6.318495116572901, 5.6456971975015335, 6.691498399074202, 6.823518382832399, 6.147398854994381, 4.351443913016262},
    {4.604603734392417, 4.058730937884201, 3.7938154810996556, 4.0717422866929525, 5.020237274930378, 5.844561654099265, 5.018560991201796, 1.7468404633439407, 2.7528778408227206, 2.2865391542944327, 5.706512248609859, -4.3059398410527585, 5.577476265601366, 3.239781886760172, 6.444109782856481, 6.577723130294198, 3.874952190058892, 3.177327199213539, 3.7880747926925915, 3.30243006788156, 2.3286755378512285, 3.349138873932562, 4.877697702244262, 6.868719001647938, 5.122812017460399, 4.099426264095782, 6.040128983861079, 5.70787632397656, 6.605365548348481, 6.688680760625938, 5.872811592453044, 3.8072973375889174},
    {1.9902623922086236, 2.73282300749852, 2.8120880010480507, -1.0767240785655652, -0.5846079350445186, 0.6464003169115953, -1.191181611285894, 0.5797400902175519, 1.6183675480818855, 2.8919566653554725, -1.1706628204213367, 0.20227266485305273, -0.24474443792915804, 1.435848426596436, -0.0656589981035366, 2.265003830310641, 2.7318168845399353, 1.2843729472925651, 2.99143878810223, -0.6068007672153386, -0.6629752267533199, 4.171613932240386, 0.5198356530561188, 2.0240784482360765, 1.2121971470247646, 1.466349876363174, 1.0773634226026676, 0.7803508793200069, 0.733148558846336, 1.9785428460692907, 0.9965275217900034, 0.001808266757639196},
    {0.12514362528868256, 1.2076766254914173, 2.1195967900215695, -1.2420405277428457, -1.706576924974316, 1.0074561604582237, -1.4748961101295734, 0.7603748085642648, 0.6279130895904528, 0.15167898186433332, -2.4805792558489554, -0.5021335652045842, 0.17368106928200672, -0.7495866774650771, -0.7730751664735689, 1.9535015626246477, 2.993227655100641, -1.1216620416203729, 1.2077940084041026, -0.819785959540836, -2.6751849346322785, 3.493575919867008, 0.9100789518077711, 1.0095444394677577, 1.3086400158712135, 0.8097207897753469, 1.1375885287571312, -0.057367554567808995, 0.7470092636782686, 0.8540269496056446, -0.8045461147151323, -0.3683743272147243},
    {1.0313763926170831, 2.208289426440207, 3.847157341299138, -1.4400729397444165, -0.9668281210199057, -1.7466692074167178, 0.17328017929231426, 2.30904573347258, 3.534422905850609, 2.272769791776954, -3.394072302902627, 5.212743118266866, -3.140620844697915, 2.577472637879222, -1.9085036073770218, -1.9526069417714034, 1.8602846094063648, 1.8383276909834314, 2.90713749447591, 0.27685586059380213, 3.765154195423543, 5.011312044240184, 1.2994709903518757, -3.327600433034849, 0.3388159860387816, 2.6895508769370355, -1.4228577784567094, 1.5668999342958205, -2.523234385883437, -2.6281319737336166, 0.9363006121557002, 2.0864236418220767},
    {0.9106187341316986, 1.462930636720401, 3.3474537041261714, 1.093163029582145, 2.1851748195057734, 0.10148441065513814, 2.0684293139724708, 2.1241136424804954, 2.699760303394393, 0.5893204217518571, 1.5942083724553895, 1.2842872660584062, -0.27090870483955815, 3.3314808905349285, 1.817705783665076, 0.34619639494724164, 0.9851509312523239, 2.4876715367319187, 1.621689998644959, 1.2939674636592444, 4.049099323420172, 3.479107358687774, 3.1158969532839516, -0.6707269035518194, 1.943579153583781, 3.415134980638732, 1.2801400449797922, 2.417523183910246, 0.24158998078413332, 0.13872111303781204, 3.0037969636953026, 2.8733946958562724},
    {1.3005286376212715, -0.745313267424276, -0.8171121318247317, 2.293835707336442, -0.8004361556022234, 0.5554658485981082, 1.2299914761774857, 2.1279449307576064, 1.5378162647357203, -0.24190417699929329, -1.245277570132579, 1.6340177370007265, -0.7666359976363152, -1.7278642617087288, -1.0841249951668237, 1.8623052799308835, 1.7453861227982101, -0.0322785122592402, 1.4518973749900586, 1.0178831851596881, -1.530845760899304, 1.715565481780913, 0.9733839315638726, -1.542377654126157, -0.19385566635783255, -0.6261781790116475, 0.5065598706634069, -0.07527473770520587, -0.06351208383097126, 0.23119547413344232, -0.9580305137211019, -0.8431785598942028},
    {-3.140966560956812, 1.810800285365023, -1.80362176324198, -4.1456233544018195, -3.8824335781782575, -1.7754228798963163, -2.630239518846763, -3.4582657549786133, -2.3720573974817794, 3.967204541941192, -2.7542910042897257, 1.825643767255809, -2.037565379493792, 4.861662798166906, -2.064866475609547, -1.418390956290015, 3.6848507324456774, -0.27877290068785515, -1.2948046195502836, -4.333925810797563, -0.8720320534843106, 1.391512307263681, 3.1681421431725516, -0.9517257580719647, 0.8216315670891151, -1.94581454047158, -0.355320874223336, -2.1898739626859127, -1.9273762609698437, -2.543242444155475, -0.7439624918443823, -1.4565527797543114},
    {-0.5736273352052673, -0.807547835480481, -0.6444219213276561, 2.379297586737004, 2.4523609061945613, 4.615617723984274, 1.8670098479198023, 1.0606743509219432, -0.5879134788705114, -4.65464989281023, 2.198666076861897, -4.608720762771235, 4.67170245221884, -2.0154384071400098, 3.174174300967074, 4.461007248290788, -0.38729812405998165, -3.111332691869996, -2.276781327728435, 1.2765167524995913, 1.715916157175873, -1.2732564652246454, 2.3451447713698594, 4.526773787151174, 3.2909583514132694, 0.7029671907846342, 3.447485455788652, 1.541210175801509, 3.8596983625483294, 2.600265937362713, 0.8209492999630749, 1.6064600720876099},
    {-2.8842667538048756, -4.558333102173149, -4.705838136280195, 1.635749715986128, 2.7882322064903313, 5.605127716222547, 0.6673046832431558, -2.172023986418372, -4.347364812613852, -6.059617725588291, 4.559258711586305, -6.243784623564628, 6.2541880797290785, -3.6282254703638674, 3.879180358546038, 4.953524081863074, -3.43096446842055, -4.42535308465676, -5.1824113129812925, -0.06677445932217382, -2.7946698464350597, -4.6049865935941225, 0.6765325061883602, 6.62983677322806, 1.4574964148478895, -2.9360170040321507, 2.449927506280321, 0.08447659576711547, 4.903652660849186, 4.37976705601528, -0.5744717809304825, -1.2625035088360022},
    {-5.108795962993739, -2.6114883070197377, -3.9746914215041627, -3.7652096705657114, -2.2416025725809825, 2.1693703990537263, -3.151797185224338, -4.819377013526075, -4.954966799287889, -3.4510214136585, -1.2324376900484195, -3.5297112452483534, 1.621835775578651, 0.20320681926615122, -0.23370413878495552, 1.9693494670578684, -0.2553621855299113, -4.377768387246051, -4.989041492394114, -4.319142170118835, -2.2696447727661853, -2.5475468963624124, 2.2687052568506787, 2.5582373607601374, 1.831193836533113, -3.5762504476485613, -0.04328516676668802, -2.934567543613125, -0.06695774300432158, -1.262300670121858, -1.686696874777788, -2.2613356674020224},
    {1.3209416145613506, -1.671503058178555, 0.19851960426557927, 3.393279478304472, 4.623832793602844, 5.967664296162969, 3.8749756084046907, 0.6693757859818892, -1.2271877381713905, -4.806212927504709, 5.285951077649346, -5.8910011238605104, 5.944970622391885, -1.9406462285505564, 5.6090584117322555, 5.412219697342305, -1.1416466376287124, -2.522230198575107, -1.8115590815086837, 2.6439508838713413, 1.4195229886889364, -0.20093612193912083, 1.8757762661757305, 6.0897611123040365, 2.8381229093550733, 1.692150630108909, 4.696837738291722, 3.913431631138562, 5.755800537349871, 5.769731487356428, 4.083631472505941, 2.807105993360567},
    {1.249608263159682, -0.9892399898355464, 0.04792125434710378, 3.3946917802013403, 3.9983653771032373, 5.035946440766116, 3.8368908886986377, 0.624986621009719, -0.7812619627594217, -3.0133543058143917, 4.357093296989421, -4.4933719496057964, 5.105673065844043, -0.12377484324289843, 5.016498051917161, 4.553187671862669, 0.6143080379246361, -1.7086469587025435, -1.1874618939670818, 1.8929778590476907, 1.4855408864808886, 0.36127665342172144, 3.133311503219394, 4.642699526574829, 3.235127829456111, 1.7023721418282354, 4.097849466532174, 3.2251438498440126, 4.899730421532583, 4.541077800413793, 3.4521719199885363, 2.8400393737495815},
    {-0.9311419408645493, -1.6595717721564147, -1.9081924735821536, 0.7989009674810236, 1.501802052664593, 3.555322682669384, 1.0054939797555071, -1.0059529978850292, -2.807367395735014, -1.4631352307637742, 2.112680295429972, -3.2686586180343054, 3.0698255129647123, -1.1839746199651633, 2.269334570928805, 3.253166926706675, 0.18204997267951553, -2.38196795609792, -2.07470137867204, -0.09400910740172082, -2.768833063545963, -1.6520246275027803, -0.24055199272803676, 3.1981616326426523, -0.08928886226346947, -1.0528513373683503, 2.649973450644466, 1.537212794392441, 3.030346602416612, 3.3271672287888996, 1.2966851052224448, -1.490018796903169},
    {-1.256379527866614, 0.4891421690266261, -0.5629644514660117, 1.421471510060477, 2.2091858166930085, 1.0470089042312434, 1.1688940943513721, 0.7584118423324087, 0.07373405333886304, -0.03332871578306192, 2.733499863698262, 0.7350302244337323, 0.8099572513222487, 1.4689833167295652, 1.942192923431808, 0.3640897925123046, -0.1983475300461649, -0.02358414994294162, -0.6445827749683987, 1.6665520272777876, 2.500267619967898, -0.14355150837430325, 1.2544582541786762, 0.1134497779558499, 0.47613449063300745, 0.9150482929345833, 0.9965762066986039, 2.3063172771886986, 1.5109889605532576, 0.8913961855191036, 1.7298471215178721, 0.923356838079826},
    {-2.1637871128679396, -2.2704003382508287, -3.1910933097035237, 1.0207025175158064, 1.8203996303735797, 2.3507627562403672, -0.725083010970619, -0.7628879685020034, -2.349096007997929, -4.379440052733793, 4.21494861034267, -3.416588810593536, 3.3015324470366747, -3.0246805985428002, 2.365744459834283, 0.3782630824713386, -4.061877875202517, -3.2179802699822537, -3.429186857368757, 1.0887442281723605, -0.9720456733607984, -4.016916184775261, -2.4465109671143703, 2.3521689121850455, -1.6314591716851632, -2.0686253870149582, 0.35529455324465853, 0.2057985729041983, 2.8432498885509774, 2.4726800002586726, -1.325923453285491, 0.006024200800597316},
    {0.12270854696452027, -0.6729414259972258, 0.096750300626173, 1.320015989708662, 2.578422003230453, 3.580008823575717, 0.5545959969864988, 0.7296188362705357, -0.6223537007700005, -5.211007804651023, 3.50453042714899, -4.262993999913733, 3.6596724476927545, -1.8161959830882621, 2.9265608691367895, 1.0308084741440642, -4.553091853574867, -1.0014287168339373, -1.7564360815621924, 1.8982386743323143, 4.23881376423573, -2.2314758588833055, -0.15618120852665507, 2.9910768875774965, 2.27888248332967, 2.072428780541269, 1.9203622621591303, 2.1064635050183935, 3.1455077945598875, 1.5260967500317209, 2.440762204188872, 3.174097140243045},
    {-1.9969175938623305, -2.830657789729958, -3.4554290844751705, -0.34052395620232595, -0.01404595683733441, 1.3311515745639118, -1.066953213238451, -2.0982424196259704, -3.6607466265587827, -4.037903287402041, 2.511139339439306, -3.437560479501108, 2.58677104867721, -3.7802572735178592, 0.5770042367096143, -0.3375143549734326, -4.2097491944319225, -1.8961325925299244, -2.727288184326436, -0.7929271870127638, 0.4086633517975025, -5.097681006034299, -3.261457005219842, 1.1248510022152585, -1.7991364433028811, -2.451227932724724, -0.25875586008536516, -1.193847722010551, 0.3319578185449977, -0.001042609511623268, -1.6949112596669282, -0.11565392726123133},
    {2.7657135978368124, 1.2957329980824666, 2.526525370351514, -0.011359977441521025, 1.0451218495912142, -1.1194752080212325, 0.43446140796807703, 2.195006747320637, 1.807846425074162, -1.107422967587304, 1.2499546975888223, 2.742320105083937, -1.1290554836855258, -1.317049387800871, -0.4480952828354338, -3.030647893375855, -3.3345935691395696, 3.600007905973821, 2.7161130829275737, 1.9892684879209612, 5.245966174051759, -1.2876450220455575, -2.8390097934451735, -2.275450023769064, 0.06321568634384506, 3.7721179633398187, -0.10167667757766051, 2.0506290571627313, -1.0403481813202642, -1.6475743698772525, 1.969017539825579, 4.2805120660841744},
    {5.0663619244053795, 0.3622934524028062, 2.750522423236309, 5.182607281871561, 4.64411978698431, 1.2880001036188493, 5.0099958600936185, 5.617807906612048, 4.957681406581638, -1.9188584492738636, 4.050784982248583, 2.0080717089406273, 1.3158779803319984, -2.9008282683439983, 2.4508748430529925, 0.08202718467687387, -2.2675147569383793, 3.909028590296689, 3.5187011593371555, 5.584543438673054, 4.067983471674836, 0.022982079037681145, -2.8171048735051656, 0.45233358095094245, -0.6206493622438872, 3.415042189106835, 1.2678158572814142, 3.8900069489914353, 1.5347966212422472, 1.2785328767544695, 1.5317221078912329, 3.3923600916101018},
    {4.077194807370251, -1.4346039293509463, 0.8695832049585052, 3.481014863156069, 1.2631417740033508, -2.6516142529589626, 2.43494442973896, 4.905202587678121, 4.37391993658925, -1.0693108071476036, 1.5435404500421155, 4.155761293837804, -3.1564058496246115, -3.8903475341641944, -0.9332601524200316, -4.1458667351868215, -3.3893298944502805, 3.2495443612674526, 2.8062254613358357, 4.595494139832727, 2.9977890741800457, -1.5237175714981621, -4.558652709402438, -3.9381161364102253, -4.422711476827896, 2.164011976245972, -2.4934937869327465, 1.8685420478423818, -2.5586131080216936, -1.7505626212444623, -0.7574272100946332, 1.4620297088074297},
    {2.1696494633543923, -4.178467535068086, -0.48605072608442845, 2.385273789538613, 1.7413102100290998, -1.0722616948639008, 0.9412627750663894, 3.0477881283214865, 1.4756963528716474, -4.611425609858642, 2.2216555264230715, 0.44159595248860917, -1.0764685018422822, -4.663877719974509, 0.03251283530269129, -4.9334403478902855, -6.032946690344359, 0.9936112120044486, -0.9590739781069335, 3.4493462702948694, 3.7290201895811297, -4.250705881401074, -4.708051110404847, -4.10535355147172, -4.120739785529352, 1.5396201801081724, -2.620725088685435, 1.9387986807244715, -2.0489238535089838, -1.873719240427979, -0.4043741778363716, 2.137197314447892},
    {3.992768091828197, 1.7223992404151858, 2.315608614661148, 1.6136788174955226, 1.4878367003383581, -0.8900570596077255, 1.8297675144182104, 2.917255546776322, 3.637138513006089, 2.4545268824871287, 2.5591999686200757, 3.235724025180849, -0.4908345213425996, 1.656360963055302, -0.08502284491227136, -3.2239312014874506, 0.7452811598859306, 5.126308550513241, 4.6201804388461625, 2.835890662290483, 3.803382166617531, -0.742225035254854, -1.5323932081411693, -1.9993044033142482, -0.8522616522364077, 3.1173507287332916, 0.8776708975812151, 3.221162221003143, -0.43447191737199264, 0.03048962600727845, 1.698023219194825, 2.7697672326814873},
    {4.741386667884528, -2.0074034712925375, 1.9230889857698363, 5.330632388156151, 4.365090401228553, 2.127864894328728, 4.306235583073632, 4.53087109006148, 3.58764232033407, -4.5307585209141985, 4.801243550571485, -1.608182238269123, 2.1824195558552653, -4.376399871116343, 3.496629056476867, 0.4670982357454506, -4.0645349607055365, 2.3918546217162797, 2.7444333978568403, 5.311593999821117, 4.463978616256595, -2.1987920678251367, -2.870703855449064, 0.9806704647390581, -0.9407422340080855, 4.0728502754908185, 1.7746094316600416, 5.041308124186581, 2.326317548260843, 2.4976429724925637, 2.369113966225793, 3.967276637565113},
    {3.1986157098411927, -0.8843244373350818, 2.22563558621107, 2.99148889361005, 3.5755609970897213, 2.690441755100571, 2.1626003814235335, 2.8365721725956448, 2.065691606753494, -4.184233750045976, 3.5704304199578902, -3.152844763066166, 3.142842612946198, -3.342792556542086, 2.588841774788102, 1.758556651251131, -2.396971894136243, 2.727126929973538, 1.940345778624437, 2.960628818382307, 2.924414260516291, -1.4068241956539957, -0.32605814399776684, 2.425018162873985, 1.4828436579765654, 3.2872823865309684, 2.678295825884579, 3.6772575725694137, 2.3549909753342018, 2.5038256488873767, 2.468284047738552, 2.781944985549783},
    {-1.4685157510765419, -6.779954725537288, -5.603327681844984, 2.372574554600015, 1.708223960014854, -5.1873777698369485, 1.0264429323441355, 1.3825744021948878, 0.24747168474294295, -5.476816606914597, -0.9054044557987065, 0.2903594667018297, -4.269997408874762, -6.67310040536238, -2.2761724654782567, -4.891121497829967, -5.978934306660013, -3.5740690450292214, -2.9518620291223443, 2.082934545314438, -4.89146724946888, -4.07971271898987, -6.428823982746111, -3.558102041211833, -6.598381366044396, -4.843048240299652, -5.518637306100005, -3.3003097589697425, -5.177273854297841, -3.4491438824807887, -3.882181597969986, -5.130944239049111},
    {0.8713318150433823, -5.857432216140817, -4.673822441762403, 3.7615024912523767, 1.724417168308613, -3.871995306952755, 1.5477131011937153, 3.1114666116643988, 1.368845040958755, -2.8252900362628828, -1.6734373991264302, 0.9220159151751328, -3.8075253335610126, -5.760538710883232, -1.346686860032074, -2.7524987194444157, -3.269636081843145, -2.3648460422981716, -2.774495844867857, 3.271278624797376, -4.789180237960615, -2.515152136891436, -5.730268930845768, -3.159708704663776, -5.739726935360751, -3.206204844998009, -5.363597196195241, -3.393127580827069, -4.310631816165577, -2.4006258148121216, -4.926946777441918, -5.553485508588739},
    {0.05456298753361751, -3.183379480446363, -4.21481412808295, 2.83069992165423, 1.2627198626119522, -3.877049853230136, 1.9884404329157446, 2.270420058239387, 2.5335355844771437, 1.7839948406950907, -0.9555744626614253, 3.1245503518070135, -3.1732667724367807, -2.4691172117605613, -1.3989424419111114, -1.106473583896736, 0.36512467761195005, -1.705225487961146, 0.1101941030819147, 2.356877284523455, -4.085644690924086, 0.3949961009082485, -2.4083975983642327, -0.9683325009508547, -4.707692585412709, -4.19833162518007, -4.2889484626691825, -2.119651042527506, -3.6076294818051093, -2.093633688917476, -3.5283512210887706, -4.8926750415558615},
    {0.9895635449444817, -2.3053597112271653, -3.068665848507502, 2.489626410893544, 1.7563447076933103, -3.4778630250030997, 2.1366398196220286, 1.9561326187334807, 2.5582608557717577, 0.4241678707557663, -1.6254385472717536, 3.4731444689892292, -2.639243528558636, -2.323010865211264, -2.8059001900846368, -0.7451827685355071, 0.11805227461461112, -0.011855389751088186, 1.0929433225481813, 1.8362712514164914, -3.9297974299372975, 0.3848024439506745, -2.8055803219393067, -1.9478197683409997, -3.8610684824290615, -3.1300885512651857, -3.650158256954168, -2.480908973526617, -3.720956786330923, -2.196666234633325, -3.8259478641322895, -4.171621625949896},
    {2.139400301873811, -1.5099476023824043, -0.46923232750293936, 2.2240045612953585, 0.7720285233281202, -2.9144490837107417, 1.9105022207074434, 3.354620780889477, 3.0951623797439, 1.4855492001098949, 0.48952632832791304, 3.110148519583545, -2.2106225809233244, -0.06588574098032887, 0.2365792133688626, -2.281788591026067, 1.2178249052697883, 1.5877813177230435, 2.92659634601795, 3.3582302285659122, -1.039764997965377, 2.010928772913983, -2.0514927445135354, -0.6523463198756508, -4.097019944719779, 0.07184296735635469, -2.117346785676654, 1.222200268499019, -2.031154220399786, -0.10083246842046442, -0.06624037085558336, -0.9352392681042447},
    {2.729444830043048, -0.6115075054059244, -0.7465859093096974, 3.436193471136782, 2.9623109171685584, -2.239978820968401, 3.333974971246479, 3.1740808431986034, 3.4724323345125265, 1.5218076752626983, 0.1564263163819005, 2.9838647051355496, -2.653550065217254, -1.1231043081610887, -0.4935976836330843, 0.21645015684591332, -0.21147680006988256, 1.6680136128642662, 1.240502734268662, 3.5483704612631275, -1.0970627228112773, 1.915914350262627, -1.1881146014685584, -2.1731456055600873, -3.114595509805132, 1.061731096504109, -2.4910476365994687, 0.8272688869795288, -2.7301565559857863, 0.0906949260034613, -0.621844904553839, -1.522332531293874},
    {1.1204776506007452, -2.263539253907808, -1.5778147771861066, 3.4760353363518033, 2.575227525085547, -1.410572991968162, 2.5898931888894463, 1.5667977368274955, 1.43718281702709, 0.8912320926479392, 0.6573413466386836, 2.8379946632084376, -1.807151560432664, -0.22471238553583983, -0.14016234731422675, 0.8322594522790012, 0.9355481954747854, -0.9203014523565828, 2.630154178118591, 2.04830955470411, -1.6945171587142847, 0.34540622355177564, -2.1934492738069036, -0.2886159577299497, -3.073823131454174, -1.1638780704168703, -2.60699065670978, 1.5475766779466156, -1.0769051687641122, 0.1568703156868892, 0.2014212203077706, -2.496093864398151},
    {0.5528818977009007, -2.0001515660665055, -2.428151451523336, 3.0087392883620194, 3.253195928221605, 0.9622975305623244, 0.4462294487477373, 1.3945983480074866, 1.4861083566215512, -1.7095014421080073, 1.31661022262517, 0.04940268317179321, 1.2692155662282842, -2.839140897276997, 1.513583218919879, 0.588073996492256, -0.41360470558524653, 0.5231623334796258, 1.1839452996448765, 2.435438906882771, -1.1157620849233956, -0.49556279559777133, -1.1867156339255673, 0.9390380638180488, -1.3947116972455595, -0.08845296851872159, -0.7274620458235659, 2.0593048143013024, 0.7094814537370251, 1.4333650430938056, 0.6565469702186102, -0.09095644062263224},
    {0.7137672961143431, -2.438488384960049, -1.279221107972516, 3.031720148559971, 2.2163139769047304, -0.8422794192154959, 1.6391427267087546, 2.497351366338304, 0.12660909873838333, -1.8670948908762064, 0.8507693044176593, -0.23571814784966358, -0.4705053169062706, -2.86351177116655, 1.3084337391668337, 0.22730545808823113, -0.02075709021002431, -0.46442159129171207, -0.8460643594314124, 3.114860933601141, -2.0211919398071205, 0.27171625368945185, -1.9905421594263886, 0.01955522666988806, -2.6666759563940237, -0.13989395254133793, -1.461580133077427, 1.7632468906187142, -0.024380365543240034, 0.898860913521386, -0.08265324920389566, -1.4379322135908392},
    {0.19381186152436247, -0.68719057699275, -1.003693886289636, 0.8324171139687722, 1.7793318540935805, -0.29072866158985583, -0.8145334036035913, 1.2156514013311035, 0.14752061034900285, 0.4941526792105442, 1.3776402921462991, 1.2690841232757457, -1.1648711681967665, -0.8758272015785417, -1.2527058831102764, 0.9557492008265315, 1.3974001569369174, -0.405426413847434, 1.42750494351944, 0.6040859133219195, -1.9356190594759413, 1.779097455434067, -0.629647696353726, -0.43830743127695615, -1.5318586418460753, -1.7191978305548536, -1.3636673157436843, 0.5289045916745867, -1.2790256615775406, 0.6525097771364307, -0.6963717208334589, -1.5219394236185846},
    {1.259920182933302, -0.516780357802168, -0.28342138048058496, 1.3103704546193302, -0.574974272022705, -0.9791533221634074, 1.1895177602893579, 1.9101810979759626, 1.741694070622453, 0.8739604393345358, 0.8513765124290932, 2.6747029045150543, -1.323563819012377, -0.2124959101793376, 0.020973665069978047, -0.6788711880167083, 1.4795819387381002, -0.8519676389067298, 0.18946918999840973, 0.6965990057540871, 0.08834750558877383, 1.1310228095988706, -0.11037668232340019, -1.7174443187995618, -1.3554162305305484, -1.0862252732116267, -1.005630127028323, -0.5980906035901419, -1.298221506555373, -0.915845902531916, -0.877040081991776, 0.6344215927455126},
    {-0.43948956755995106, 0.8023636369274993, 0.8493324477260995, -0.09305648810449775, 1.281306696283147, -1.2074562773425475, 1.8562164331103137, 1.3506385941235939, 2.889923217222739, 1.623622737328519, 0.4078654596274161, 2.8712837866223393, -1.1430629631936042, 0.9224280085658974, -2.661138161281161, -1.342583636160082, 1.23555023814032, 1.939325378090196, 0.8033536473902573, 1.6808262419490836, 1.204958584315366, 1.2274659399816183, -0.5395657291010406, -0.9448197909379951, -0.4892944675086332, -0.5408645239604468, -1.3727823858622465, 1.4981168215534921, -0.511079811817876, 0.14879648967355436, 0.10526070089674339, 0.7554994202441001},
    {1.4815979137102282, -0.3077972953630459, 0.24668157362572127, 2.075043974467229, 0.3100278268066679, 1.9214351176131683, 0.0471405104583665, 2.593905562071666, 1.0129888020559454, -2.435251156541822, -0.04322358677040276, -0.47946025506773166, 1.3687988007083107, -2.7961257110947706, 0.27594689289183155, 1.7413865014852874, -1.24718270401155, -0.685190718857938, 1.686143961548381, 1.9103927709772317, 0.4092635147680833, 0.9877713482105127, -0.34455299543354234, 0.724190739440092, 1.7155403925730328, 1.8308965129703065, 0.7814198677684652, 1.1116570515577784, 1.4045114229147868, 0.8090206306539586, -0.9030825256341778, 0.03644471785194619},
    {-0.10397899274185032, 0.029518111004121914, -1.750681143198344, 1.9596889965105058, 0.41877595307559806, -0.581053454632779, -0.10536829693733561, 0.08819521276561981, -0.5583663005674563, 0.21147637238260542, -1.2264227462527206, 0.13394111884854193, 0.040234201937389545, 0.17247318502014622, -0.6545616660404018, -0.6923179169887607, 0.30332123014821344, -0.6825338875594406, -0.1380757711450995, -0.5311330681755361, -1.540690188159769, 0.3173738409207756, -2.3686266624449175, 0.2932174384135055, -1.5487035564599916, -0.6390495288077208, -0.9610744524198082, -0.1785405888426371, -0.571423072243427, -0.5687354122793526, -0.6319472248054986, 0.34509347174905997},
    {0.5938033278106286, 2.2778949027467643, -1.34336879120755, 1.024322922220643, 1.8778395954913045, -0.00815251597654434, 0.3345519913690217, 0.3469059274620768, 1.3461330759390016, 1.4953491775901757, 0.6203845939560253, 1.7220954780128168, -0.0007817044754331806, 1.034722731299355, -0.15793168286720444, 1.7519689981598547, 1.271929811637001, -0.1170063348539778, 1.719958831172658, 0.08867856000068197, 0.25733534598632757, 2.3749760965788056, 1.9101353683164626, 0.2634966741695462, 1.086315808209126, -0.45442747144073653, 0.14356614763805917, 0.6870179133586507, 0.2618593682108116, 0.30986298053544187, 0.9268019834318495, 1.800418532829024},
    {1.5022577337251601, 0.608201529642512, 0.8654534422064033, 1.670149231360547, 1.5378901179251558, 0.6407992980061394, 1.0279849585105676, 2.661231307760274, 1.6552415493559443, -1.1472467929051204, -1.0172528776626375, 0.8601285155457218, -1.0759152623021513, -2.2984185608978334, -0.6655380187463288, 1.048016684624842, -1.3800229879340502, 0.2160634906443931, 1.8893707866167924, 2.4025977760944204, 0.44021103080528673, 1.4128644859036967, -1.686364818133533, -0.4746792691069676, 0.6752799670119854, 0.5370333966651036, -0.0012601844739001324, 0.9795679678382139, -0.41211184970615594, 0.13823852184967805, -0.3391809377885437, 0.9262735100455832},
    {-0.01752574950901572, 0.6101688791204705, -0.31486181785444123, -0.13360245755884925, -0.9142803438239839, -1.7497027553677247, -0.29659189786069706, 0.6989663645530853, 1.0568303179605685, 0.6277410569532679, -1.9354298862543047, 0.41500974758588594, -0.44625202062167973, -0.08517768163785955, -1.4835723712751059, 0.49502467323194105, 1.5326316837151919, -1.0059731401835654, -1.497181391683402, 0.5827362106516185, -1.2257318937122559, 0.8201004718506835, 0.7779787324415588, -0.7262100730210679, -0.754629559428075, -0.09825593396915806, -1.1063720382501692, -0.38358535046163633, -0.10919429054718535, -1.7402212783231272, -1.6301335964142627, 0.12150530518408181},
    {-1.1696261653506725, 1.9229557192721962, -1.7976094332525643, 0.9188293939626515, -1.2831118224169882, -0.9266750849245807, -0.15251909926621965, 0.7722757732782142, 2.2999632849273413, 2.141681547641897, 0.24180323617668067, 2.3564635112532146, -0.6703067448947683, 0.8516749851816559, -1.0539468809254007, 0.5268360224570693, 3.1534344423856435, -0.7676718181503928, 0.3317424837741245, 0.6103534177931759, -2.520100148819492, 0.11456550851117416, -0.5012063678756111, -0.34543938215647474, -0.22424112517382272, -0.6198862946192076, -1.1128512867930462, -1.4341435377267606, -1.8101767148964596, -2.578868300400046, -2.4800496357238484, -0.6486767340961318},
    {0.16136229009474667, 2.9571351035599736, -0.25524959795841956, 0.05838187949277096, -0.561859564925677, -1.6187194509258214, 0.5976928898966477, 1.3451557330477633, 1.4673014043818715, 2.9615764143987895, -0.9964522769753329, 2.787147953504663, -1.1134800566153695, 1.2494575695249526, -0.826578160882912, 1.3099256308959462, 2.815854336708515, -0.8299495982672734, 0.04216929487094905, -0.19844940436040734, -1.709717515366824, 3.1218550937446015, 2.505867911353293, -0.5447357361639354, 0.1644795402153357, -1.8390482220587818, -0.6824818309820198, -0.8881137508654685, -1.3240998909353985, 0.06843133188000743, -1.467653927341705, -0.8364341455331545},
    {2.237756035349242, 2.583172011081951, -0.024089798200637082, -1.2881346632840431, 0.15347231802175437, -1.3883960934403654, 0.1081801794891462, 0.6208824685476865, 0.031969208373615034, 2.3820193689120917, -1.029637361645546, 1.3946881642367976, -1.5443983733078146, 0.7139979844664947, -1.885175332906677, 0.34244728377725264, 2.536500633334896, 0.11666720371500973, -0.20827221669510704, -0.16541834667837985, -1.7862900834730047, 0.8390984632407026, 0.7623822871457641, -1.200815154733365, -2.365179858977332, -2.2156285072446096, -0.40875778691633763, -0.8048051753518508, -0.685636399302405, 0.3362904721665592, -1.4914578617647718, -1.6749333971303273},
    {1.028890820777369, 0.04837367005233696, 0.42622370476081084, 0.2882509212052568, -1.3708565642139412, -1.4534262401700564, 1.42296370065683, 1.4572376659595965, 0.8883240211441321, 2.0144074807466996, -1.7802405592439756, 1.6105566668954252, -0.5143368577507931, 0.26759628387134266, -1.068507906021249, 0.954382483022648, 1.9049353397018267, 0.4397478109937757, 1.343971332181655, 0.6240657465499655, -0.733883399048575, 1.216491791614721, 0.188665670778904, -0.2804043018949485, -1.008132214384155, -1.1976132053983815, -0.7776543699647455, -0.854232523367208, -0.32041808780573977, -0.8269670835603111, -2.1216323776600534, 0.1339151344296531},
    {2.0515333139936995, 0.7859616478271384, 0.887724486792686, 0.18215730128344068, 0.872456226932326, -0.8911743547104711, 3.4316092744309508, 2.0665790046398347, 3.2306107299564486, 2.4433902199096225, -0.20476477387560302, 1.745960484215116, -0.9959473279567365, 1.3331916430361574, 0.3360374401525764, 0.8049348723903645, 2.5713644953521775, 2.5976010198581636, 1.9493380167961183, 2.4020911449120392, 0.7108550761181587, 2.1250213211979423, 0.550949337072232, -0.10863437737591701, -1.3663055463809681, 0.07036487234425157, -0.3737495730278091, 0.4519856563792313, 0.590286764877371, 0.3459551887727347, 0.6325257909152974, -0.3886485304919433},
    {0.167551729309125, 0.14289954740679642, -0.41575723070816756, 1.8998872285974715, 1.1656232396374315, -1.4782605582955624, 1.93590270334918, 1.309591305166639, 2.373146779170082, 0.670477917975516, 1.1160670548397713, 1.6463857158179647, -1.1870915106084121, 1.9652914697934896, -0.08944426836404114, 0.045282028095985034, 1.557027637227235, -0.8475755898581007, 0.31192730104626254, 1.2018307078718011, -0.7585519976788089, 1.2925584306626052, 1.2028946852122662, -0.19210701344436765, -0.5359859983886988, -0.8598847486578209, -1.876422002815667, -0.8261341046283335, -0.12964723231462003, 1.0046486463382955, 0.28357902483487596, -1.4960601598281953},
    {1.3808644846118612, -0.43202403367745384, 0.06603037877468183, 0.4603630282720882, 0.46599666761169906, 0.282420308288341, 2.0594425943098993, 0.12688976288539297, 0.6641844985860496, -2.320782562795715, -0.683011111638751, -0.25957311218353624, -0.5108299926832339, -0.21669736567211137, 0.47210774335057537, -0.40884950869118564, 0.5402041249108125, 0.13205799559358336, -0.8866015441639716, -0.1253957934626679, 0.12432757124580748, -0.40792896014625474, 0.5927654462693532, 0.08429297101688288, 0.4578801518353528, 0.8881294663762875, 0.319151620430896, -0.24741768960808894, -0.6226672822700262, 0.9484469883882798, 1.2348571184662498, -1.1508128928743393},
    {1.2041178517314328, -2.9929270638140166, -1.2124222818763906, 0.5464052742660003, 0.4070429887996202, 1.7058599830074126, 0.4755067356113702, 1.8241005931461336, -0.35550708751137655, -2.2426788449950186, -0.29256298477876613, -2.100784320578839, 0.629520733980267, -2.6713544431127225, 0.9674613924905285, 1.6444334658936803, -0.7274709617429749, -1.9176418803388113, 0.5087649941352744, 0.8587759268948637, -1.7202631053293782, -1.454071807731002, -1.3408540965726496, 0.5803663246199494, 0.10472990325522724, -1.9098684493528808, 1.415815941832599, 0.7218910635616912, 0.3077957159424055, 0.8379259493984191, -0.8215365589011855, -1.929005952385773},
    {1.1660295216978631, 0.43071061032210695, 0.5167388462836257, 1.7393637079705235, 1.3073918589145894, -0.13599937676342894, -0.6037717097479545, 1.8820158731595693, 1.1935075390357595, 0.12555736716499546, 1.138127807388077, 0.7366881750972155, 1.355117696650456, -1.0635299787099035, -1.2947734361220644, 0.4213850174499174, 0.27389474491816146, 1.9129171184054963, 1.7808534220758188, 1.9635821259994468, -0.03666664871599669, 1.573629971673377, 0.1384740628903184, 0.7055451152833415, 0.042803280961733296, 1.6925463342081402, 0.07712298371728982, 2.2485670061453447, 0.6386697651343497, 0.7281862250356393, 1.503589280973634, 1.440396371694122},
    {0.6570254669308266, -1.2282149695674882, 0.3289768177244013, 1.8214770567784995, -0.25040065117362237, -0.6069939604785802, 0.5720419645008897, 1.3446425822533443, 0.1293941949777804, -0.8376857775338078, 0.03643891213445722, 1.1104704797461276, 0.3847306154778971, -1.8073169511140088, -0.7249524013110944, 1.0963778940142754, -0.9398794591960483, -1.2887415843055523, -1.1811522980705373, 1.8765623150052433, 0.4155361233671966, -0.5803899162701018, -2.096683041358055, -0.04999964842175186, -0.797399725706385, -0.6315858995538041, -0.8951457285857641, 1.1172659069847817, -0.025613283135458353, -0.7220118903640772, -1.7825554589011419, -0.7088573388267992},
    {0.30900878521178343, -0.9330616401780234, 0.40339387260583454, 2.1315949425924905, 2.2949170735083975, 0.628158612832467, 1.8208912084899653, 1.6568281733192969, 2.1256592780687957, -0.4952244860513634, 2.3821320431665254, 0.006753945761126727, 1.8104980019329957, -0.8012051785768337, 0.49442694109475394, -0.5268049014399337, -0.5087589524677121, 1.059649947412552, 0.30869954525578014, 1.1805463209085196, 1.427903450123242, -0.5508412408962512, 1.4196865099199367, 0.23691266170445813, -0.22780500399701065, 0.6637993358506029, 0.6230877084217652, 2.043714906671109, 1.2543952979431898, 0.5222081603101321, 0.37576712420110936, 1.4286771865246766},
    {2.595034219616881, 0.24460670922551841, 0.20271757268960836, 2.838971232698055, 1.6655853778743945, 1.13543477879706, 2.4811279586850565, 3.1778110506185575, 2.489002224513577, -1.5613237741755142, -0.11562582093744866, 0.5295617066099033, 1.4749156259950105, -2.1595765819351507, 1.810859076397261, 1.4160631848952197, 0.014720890300965194, 1.1601788878934893, 0.7027726172665226, 3.6314947428917916, -0.3126768330777619, 0.3186971085012531, -2.4769145345838197, 0.37881610357155804, 0.3529194570311011, 1.1397432652839679, 1.5854585602781062, 0.7164218177868095, 0.9255923833663383, 0.7453888011225162, -0.6830464670418025, 0.5664952572255664},
    {1.0909583051741218, 0.24888879443510645, 0.9318803631752851, 1.6058028661477626, -0.6209293067230256, -0.39823267284135583, -0.432496844608856, 1.630929465479782, -0.4046925456911189, -0.8152262684588018, 0.9517000603040376, -1.1221089527018564, 0.5792948341231189, -2.4842153269148537, 1.2148176131164279, 0.9639455046043675, -0.3936684735059156, -0.23189267635891028, 0.23539313754795213, 0.5566636072660147, 0.2495331937437335, 0.9929879080317566, 0.8725141640365319, 1.5677462923564447, 0.007892872212892395, 1.4223681021931631, 1.4701928558309458, 1.1186307318163267, 0.7433520867192952, -0.00862509941239057, -1.295538083368885, 1.0328541273616676},
    {1.1165370700938668, 0.03309127810652799, 0.2541974931481196, -0.7995781227735533, 0.47211274988540225, 1.7800146961638434, -0.29902450935031005, -0.8374345127746105, -0.9302808370260433, 0.6658065900726649, 0.8434606581513252, -1.081541057976053, 0.6864279566795767, 0.6566493465049856, 2.085105746044199, 0.9205995902133728, 1.3855550311138531, 0.5835823740186167, 0.7818418588193826, -0.3217411189578474, 0.18615231819235442, 0.029299916185130725, 0.8966147408082142, 0.4489228086992284, 0.648322916275004, 1.1682554148964284, 1.031946100069542, 1.263972241541745, 1.0436979511692899, 0.5490853105294875, 1.0721054877697171, 0.5797328504427377},
    {0.11381775001620341, -0.34178788238588054, -1.250238095477232, -0.07711293715996213, -0.23248384432817767, -0.8016012942272587, -0.153105407444873, -0.6998110835023258, -1.6463365670745491, 0.31763519038059973, 0.17338749229529443, -0.6751446418907325, -0.9150720017770083, 0.82150404085354, 0.5286173319994181, -1.0720233010020574, -0.010904519659041911, -1.0454050957570653, -0.4707450236074351, -0.49273638075976767, 0.1831986085287062, -1.4503142669944658, 0.9029553519427436, 0.7524360667313034, -0.9871803336939554, 0.35485577123922585, -0.5566449742621437, -0.3112495304424635, -0.304938964174549, 0.8456509836347078, 1.0093168618379427, 0.7767600184903338},
    {0.03178184668542571, -0.6102368584275377, 0.010530316251857706, -0.34602091668575496, -1.3259005651066589, -0.8792226747897891, -0.29519215549149463, 0.4339962357295391, -0.9079897267082034, -0.5066934524313547, -0.1498274168412845, 0.5238282579028002, 0.46897662140648805, -0.876008755260196, -1.042103885994561, -0.3061469869922503, -0.919573918859166, 0.07562496700054842, 0.16957582675854763, 0.09910841864734585, 0.8087700383909054, 0.10666322508078123, 0.4232162903717686, 0.31541806382063453, 0.6481151570161652, -0.6707099416870139, -0.058396715355202064, -1.1384610595966684, -0.404206837907634, 0.05071007458888868, 0.42423757007568946, 1.3720240857995492},
    {1.0514548412382723, -0.07549146387419928, 0.1900877892315481, 0.4204577713104184, -0.8222002278734981, -0.12381481268679104, -1.017865134319173, 1.0488875596684095, -0.12598265640360376, -0.21837349747268656, -0.0880785696075926, 0.6910296160626516, 0.033163323957413664, -1.262716019272263, 0.09656210412514965, 0.21932155432248607, -0.5775092020887569, 0.14762439444616962, 0.3835457476666753, 0.46260511127439247, -0.346586040879963, 0.5098181315353859, 0.37230395147936357, 0.411655609537776, 0.46814916184101635, -0.15385255909992063, 1.075164900908181, -0.08634803042302219, 0.15189757338753307, -0.13990692659387902, -0.575757164772471, 0.7341832119953138},
    {-0.6457203809067518, -0.26734410927879854, 0.41139098889773085, 0.2652789064931889, 0.2385349281887747, -0.18321049405369505, -0.5349677081851092, 0.7234566026673234, -0.053378265169142874, -0.6358388187544294, -0.379833605039361, 0.5218077299110245, -1.228481500300204, -0.6817998060508629, -0.9193557727182461, 0.35223113319915555, -0.06869606118451148, -1.806803901632432, -0.6487557475911981, -0.7239831589794646, -1.067698062456148, 0.5061488193262277, -1.050483081901457, -0.32894935931211455, 0.017971637186362615, -0.6591970683683198, -0.7320389429646897, -1.0473006010346841, -0.5632575386494482, -1.1801525994913027, -1.6927777523638823, -1.3294528453400845},
    {0.028288483375237438, 1.3785124569023595, 0.8392703736827434, 1.705068035957661, 1.1695848052774545, 1.1606754696200121, 0.7688283996337868, 1.0411660612362712, 1.9850383286455209, -0.759131324544175, 0.6802803628557147, -0.4589451003601593, 0.10978461190617532, 0.5702401394964649, 0.24354014753103595, 0.051710319825284505, 0.4245743540458803, 0.6235717572208846, -0.1497574087899937, 0.6762843637750979, 0.29325020904367044, -0.21272186638209367, 0.5805683851405795, 0.34513504641403, -0.0051084703262761514, -0.02890795329837323, 0.417368729952589, -0.3231499782773376, 0.822784430530465, -0.5197950888677896, 1.0678166489826162, -1.2384300625060498},
    {-0.03971819576939237, 0.42338104086266165, -0.16706820425093344, 0.7171535312418613, 0.5819511524430198, 0.7907113516462386, 0.3519723192165906, 0.5677259379077757, 1.9903276113225283, 0.443032515184016, 0.2646703071811809, 0.2452648031476148, 0.3124007923713985, -0.10121833910098105, -0.5899730801130487, 0.3971226371627045, 1.0236767039830423, 0.9525514445162251, 0.16158414048263497, 0.5927236177365383, 0.10944022449119561, -0.29569879213825895, -0.44239973155201573, -0.13091734180729725, -0.5940397999284842, -0.18541635501298448, -0.38607016020137874, 0.8572581219666938, -0.5049105615814715, -0.13555100658817257, 1.073557565033845, -0.9025901014701655},
    {-0.5701715321617686, -0.6233444495138525, -1.298283773056632, -0.3136696780892749, -1.0425799797356536, -0.4483477725029919, -0.7941644530564685, -0.26249846143020567, 0.32377592324542004, 0.3955444559389309, -0.5173524830436667, 0.4373093291534694, 0.055431927573979946, -0.9813931549808442, -1.206294858733969, -0.19162345830103467, -0.03623322789158359, 0.28788735893695894, -0.038866225429857064, 0.09965304783253237, -1.01027759830068, 0.2856804869398688, -1.6379886845582663, -0.600753344662246, -0.10521949913323211, 0.570706616646804, -1.1859079159477832, -0.21994665311689432, -1.2276925109547925, -0.3623108893191219, -0.32704244755809775, -0.7927225586256366},
    {-0.9479734212850935, 0.4192047423742176, 0.0038535735187527945, -0.1921608421097735, -0.5832835857580321, 0.15852136176801065, 1.049019541459295, 0.27758481232168314, 0.9048732521545717, 0.09360379898536617, -0.31589393409833344, 0.5113363842609562, 0.8797385452601263, 0.13662584944586087, 0.25613525534849046, -0.37353691905185116, -0.6721797519298774, 1.394188511347676, -0.7989789610928241, 0.14617792989435247, -0.507977256212864, 0.4490939313527545, -0.4041329752237219, -0.4700695164125438, 0.7465702521045098, 1.3158219756770342, -0.7024422877978796, -0.658179619956897, -0.07789684460039457, -0.8893044053874469, -0.949902399005681, 0.07883659771085491},
    {-0.6737244144442478, -0.1924733900193209, 0.1360423398940253, -0.22000798738756233, -0.9369689344246963, -0.7341827423563986, 0.5440077838800927, 0.12863154235102425, 1.3246170857277464, 0.30135383149425266, -0.8582476970959636, 1.109107902667333, -0.3040597189768316, 0.38434067917950765, -0.833998106995753, -0.9842285438443495, -0.9355060951745596, 1.7155510444883426, -0.49141201849311583, -0.5966779299675088, 0.4321177406422532, -0.027175443463374492, 0.2136325853126452, -0.8764849206664188, -0.16513145305342333, 0.6772904475096954, -0.7504088568817766, -0.8317577939717486, -0.4456881174392163, -1.0248295920189021, -1.150347386453041, -0.2198526938575222},
    {1.0362821841598926, -1.2048239774359402, -1.1301456587702554, 0.5799048016807804, -0.2729665452979233, -0.33298289266771974, 0.8892937255610485, 0.45738946792453256, 1.6967212307002377, 1.0707055869898188, -0.738091552529529, 1.0203575110941538, -1.0297035690115075, -0.49484330709040203, -1.9947696000990436, -0.8868286450953027, -0.24958281371369334, 1.4877606591101649, 1.0384422642307916, -0.22763272546780094, -0.33174091234351627, -0.22928953835351906, 0.47678123925794363, -0.5808068914659026, -1.1976680443099217, -0.17127980756231717, -0.6332468710550125, -1.1816635497494137, -0.9056011356730972, -0.3771214018542016, -0.9732311607437499, -1.0813593785847488},
    {0.290899942315313, 0.04520466229780709, -0.13602003629680687, 0.5335821736316203, -0.20291257444332028, 0.2874808803156763, 0.5310528569997616, 0.17883938447184114, 0.5206688769126628, 0.7236009269134452, 0.5678332420597474, 1.2798674276160857, 0.23425092538759182, 0.23460187046585604, -0.4887004093700877, -0.5875557462869041, 0.7052190376926754, -0.24879375729741765, 1.2253730692004434, 0.2980777978431023, 0.45979567051086445, 0.6524234504118412, 0.33849841471468034, -0.8388557787679016, -0.48972354861830625, -0.0951830394730245, -0.2429403114986186, -0.5669543216694792, -0.23779444526305302, -0.10447513536988033, 0.22866250805653623, 0.42700546817208307},
    {-1.2785229768681392, 0.17887685181667304, 0.32069031416514354, 0.6138954959123396, 0.6203455267753887, -0.5060720870116722, -0.0782620566362187, -0.3272839307033775, -1.386931093183334, -0.2680376234821467, 0.5268484009322648, -0.2564310470154362, 0.10853515236683829, 0.9246465751769557, -0.1032615065781217, -0.23793039349671882, 0.570388867306077, -1.4513081097245322, -0.34753735120471513, -0.15819010982292867, -0.05016850591699065, -0.12623602799815226, -0.11782529083024082, 0.4191369516015759, 0.28431026090210343, -0.2560416808950152, -0.07138941610523067, 0.8468001363566959, 0.3348851569207429, 1.362635800883443, 1.0003268940977035, 0.7642721223016709},
    {-0.9482789734521373, -0.04957462556218294, 0.24183820529084665, 0.6378231416740461, 0.13312491792307576, -0.16298817672278385, -0.3999516892192325, -0.37460083080705925, -1.4940328447674054, -0.5008861284560284, 0.18820097166911734, 0.2730505259293399, -0.31674958707376283, 0.40645970106548246, 0.6010442369945578, -0.3967990163187905, 0.3301948518914294, -0.7714101545926247, -0.6460345154998117, -0.09859588371706206, -0.40649502287318184, -0.39615582660359056, -0.09460503132239204, 0.8688886703508784, -0.2666021749349102, 0.3938340022446118, -0.07116213679597608, 1.7056389936578427, 0.1038500870173767, 0.9296996654916205, 1.147765031143277, -0.12720067666192914},
    {0.40696490569769034, 0.5894737458460275, 0.23297791470031987, -1.4649223537496123, -0.41467864071694766, 0.36949514465866246, -1.3471449735072876, -0.7687618218183259, -1.8831832828748043, -0.455838819801113, -0.7154112323321007, -1.85109375330179, 0.1892041751650728, 0.41759162667860505, 1.1223837943347856, 0.8547547840549236, -0.09567209807928553, -0.678221789420298, -1.19410399354227, -0.40334710427471354, -0.6092297767866345, -0.18779857742396974, 1.533915987172214, 0.8989417777510649, 0.547604356874612, -0.7648919812596873, 1.5227330997250645, -0.8240465331558671, 0.20616505150860856, 0.7825387717667779, -0.6026975939408797, -1.0844785423114007},
    {0.11776213237180998, 1.9187321166952773, -0.2633961839489652, -0.13872301559970732, 1.335613098965341, 0.772963090734212, 1.4976522884368884, 0.2985658566656749, 1.508799349110896, 1.3114333648163672, 0.13078463241105046, 0.5779871195298169, 0.2505254408000047, 1.4759751615077084, -0.09298495636195694, 1.169806087133173, 1.1666525355357076, -0.5525488027602653, 0.9627901933576248, 0.4628902423903786, -0.19509441785300485, 0.6477680971409598, 1.2738524272339409, -0.005922344347983031, 1.1519602688299166, -1.0549839218202386, 1.1846204726823688, 0.4797503535163434, 0.4001075170395325, 0.527312262896416, -1.041083946054462, 0.09085204211901061},
    {-1.5137550048847432, 0.41222470135911543, 1.031497700039708, -0.17046708286270199, 0.10352255728799321, 0.13650841150642265, 1.0971564983359257, -0.6076450288806058, 0.2213422300796729, 0.5604130322871823, 0.3509447380677486, -0.42537970137673253, 0.27398386209358916, 1.0164799698099682, -0.41665375079854405, 0.21385674240414423, -0.22671753792009297, -0.48528533661825346, 0.41820161552117796, 0.5116933906054416, 0.6861772355014415, -0.44795426277027334, -0.4033822861810045, -0.012012244797179909, 0.7791814307002449, 0.27237399545377844, 1.0700936074403762, 2.1283375788189116, 0.7102436744827177, 0.4826110263134163, 1.2533257458936709, 1.628773411439191},
    {0.07248116653535239, -0.4019711061567542, 1.20446457058781, 1.4338198288512813, 1.173201943415926, -0.5931928520830188, 0.3138797532440035, 0.5296631487416269, -0.5230453329297579, -1.072974743061803, 0.009733380756029182, -0.023959239037615234, -0.2846780639297108, 0.07238071441210807, 0.5620865795084845, -0.6526679570513422, 0.12768030124224836, -0.6364388378563165, -1.402545427725282, 1.0070436465590449, 0.759617749010808, 0.17403170693747796, -1.383632423713141, 0.14171953770913517, -0.12433028117022223, 0.3786399152557312, -0.23891215890322026, 2.000240966893034, 0.8114243260425611, -0.43169415488983226, 0.5361141379464639, -0.5882412277372392},
    {-0.2739464410301143, -0.45195681688676387, 0.5988310839043108, 0.046746754227083194, -0.3874468238336227, -0.38126194428907234, -0.35482673944837134, 0.6629989819953571, 0.15873224665911184, -0.260077519923018, -0.20078516880993416, 0.2973894766785375, 0.2162672438453931, 0.6220549550252601, -0.23955640443605788, -0.286299823223226, 0.45771638299649875, 0.8432245061118485, 0.6854614471799494, 0.6958754214883792, -0.3975695353611815, 1.1599353769546015, -0.46889501071095085, -0.46591961565697615, -0.1025065849804061, -0.45162957046408253, 0.13639694880299552, 0.6211426884616391, -0.15077316543329208, 0.9816433325673376, 0.8745423144686142, -0.576695245829985},
    {0.1737148894380602, -0.8063982203677463, 0.030622906001147168, -0.6896404441188425, -0.5011753010180461, -0.474592848009309, -0.28573180691272293, 0.2788270144687444, 0.010952373692048148, -0.961188795282141, -0.7830280442887511, 0.21874606908832067, 0.5152385265124695, -1.3702634847286563, 0.3186451952171529, -0.4547016118113765, -0.6267853462752362, 1.0303992285219907, -0.7625938622432331, 0.35796715638694554, -0.02159748014790629, -0.07862512609310324, -0.9092446279126697, -0.289217213507676, -0.14457830283035528, 0.27926023143596274, 0.6059405349658497, -0.770486835755389, -0.5749447799358569, 0.012233286130571966, -0.6824366101337811, 0.9749149001798532},
    {0.36404733541527595, -0.5494201927845147, -0.9266940606542984, -1.5161022898218557, -1.7236706843788556, 0.5050213141712193, -0.5921045700109269, -0.3162169545645957, -0.24835888311567492, 0.07535703193098432, -0.9868836316170703, 0.19859997400134685, -1.080197050376806, -0.6362458941342017, 0.6766937528913117, -0.54720209765647, -0.15134932246429245, -0.6684520605057152, -0.9257623747560505, 0.030052418800307124, 0.33108797013828334, -0.6462371155153139, 0.13151859733787213, 0.0418206760774357, -0.8826625438817756, 0.4623204722383016, -0.24425945615753655, -1.5065950416883231, -0.5649926652496423, -0.7046588557017633, -0.22104133646556784, -0.7614085178754744},
    {0.008786936616069429, 0.20983991526102796, -0.011512687442296204, -1.435029225334548, -1.008653554593966, 0.39437732078036963, -1.2251007139568917, -0.2647188707810589, -0.5390014381624377, -0.13791774112939442, -0.6093655000651389, -0.3670622369440979, -0.46471437240590646, 0.37899417009588915, 0.6639249551747833, -0.15961713745803993, -0.2411011649549653, -0.034083176734288595, 0.5144821624574981, 0.07476769753508801, 0.6396526790481899, -1.359331986246356, 1.5865367468591767, -0.3003101517562284, -0.008197934578168262, -0.5420210014602954, -0.12144982978067406, -1.6328052828946553, -1.3279864793611558, -0.12193254564937346, -0.06422591900957893, -0.7344126994303781},
    {0.16512919825126224, 1.7456777936800036, 0.3989272802539994, -0.20736835351538416, 0.6020810826784226, -0.09493074770248273, 0.12568950592999747, 0.22579216766421165, 0.7227562446282727, -0.3718714772374126, -0.7725775978084982, -0.13435271182698955, 0.4083795468701585, -0.2861803822570256, -0.308450542950334, -0.21859033864479804, -0.2835257988213066, 2.1000041214346714, 1.5858816903366735, -0.33877952088767793, 0.14249076333197136, 0.44659640566182207, 0.4313944907916468, -0.27864330173663676, 0.8900207547256153, -0.026196568236794178, -0.05446227062860412, -1.4995068873391746, 0.024198274823279613, -0.6974803706036031, -0.7477615675414849, 0.802023962190053},
    {-0.1353925980032285, 0.2552196665636224, -0.8460862722639643, -0.11931231832319539, -0.36182725862118975, -0.77060255566157, -0.7076497385512998, -0.23392569095409996, -0.13445232388119946, -0.5333646422394841, -0.3006879257480007, -0.8537664018296836, 0.05922747681469661, 0.23044252103323612, -1.0845410167074239, -0.2800357678409228, -0.173301412086529, -0.7369629992823798, -1.4273576013451217, -0.7120987255884508, -0.5865908503284137, -0.6071847813955226, -0.3416884690132921, 0.00028798588200411096, -0.317121494273093, -0.2261016695606238, -1.0616698749435354, -0.9231898051871316, 0.409022114604825, -0.6483158653559844, -0.6146993531654292, 0.3888908242504593},
    {-0.4076453248290404, -1.2607416491896357, -0.3772947407559615, 0.3278057895197642, -0.07645012845915335, -0.48076054326762413, -0.09531735530015549, -0.9662631255000796, -0.7592382092916579, -0.2576663614812266, -0.4616599507919133, -0.6265602027408937, -0.4684511950995674, -0.608644980392402, 0.525606149264694, -0.06763254012012103, -0.9233632097720876, -1.129652256545547, -0.33329764247099763, -0.35491346426784515, 0.4620172135186502, -0.017662099465322604, -0.6979217517801718, -0.22372375147978907, -0.29244024521873774, -0.4022710804655824, -0.033918236993123276, 0.5910337658267116, -0.7766932585399946, 0.5892729675796917, -0.3440258909948987, -1.683082794568892},
    {-0.728821307842912, -0.3026679877843168, -0.7775850260989942, -0.12324794252104285, 0.8226891858361386, 0.10250278790668337, 0.9906795351830369, -0.3670063867420715, 0.7487912558312332, 0.4422497359687698, 0.6909815244497808, 0.4625271539962784, -0.679821765552361, -0.14903118305902802, 0.015903482722857975, -0.2828532072781033, -0.24710416092198811, 1.2829003619126154, 1.5773227724721854, 0.426006238549438, -0.19697950340229914, -0.07155867723311762, 0.34430422302058766, -0.9121455767812614, 0.08126179873938585, 0.4650830179058192, -1.062448407082757, -0.5081211943532127, -0.8393218999338127, -0.6409939516068778, 0.3783310473627473, -1.1791412108046797},
    {-0.943396907342887, -1.2678902756230144, -0.9286755416539461, -0.08227658748498828, 0.30282110325227274, -0.23755695622681808, 0.018992186787802623, 1.103259808203918, 0.8575651983503809, -0.06876557574529078, 0.42177105550946026, 0.33613590004324734, 0.15396671066585046, -0.943428028461312, 0.6386470695616471, -0.27706420033580914, -0.4977193347100188, 1.1517530789416146, -1.0300873581974928, 0.682873089375337, -0.4414102309866379, -0.8220480473136148, -0.2878846878408168, -0.4400753586447066, -0.2519459264054192, -0.08688423653958882, -0.5372774207828124, -0.06817208330243621, -0.7582966300506007, -0.502250761739263, -0.027977692746766505, -0.3000942227429255},
    {-0.495238170663414, 0.24361699259485173, 0.11335256958146588, -0.436928325114786, -0.08878758330126311, -0.04069757205783555, -0.23567782230465553, -0.1907343593013715, -0.7178774314532431, -0.9608204786242328, -0.6401269133062104, -0.5260592190011658, 0.1723672963364114, -0.0656454237074713, -0.30278330942079257, -0.18925336845026458, -0.9816485147591192, -0.2911560806356998, -1.0422298821906169, -0.47836078390975983, 0.023390742738040496, 0.35380934765416694, -0.21935996074166142, 0.04326788365373114, 0.320001591906238, -0.25767576433842726, -0.1280197831004193, -0.09025590560144894, 0.6856386148251775, 0.14566589770829408, 0.9022755388078928, 0.4320873508300508},
    {1.2778065960405223, 0.37884042765204634, 0.19081406261717707, -0.2813378266335814, -0.5647625874045278, -1.5281739875034397, -1.1600677425734967, 0.4298483815156881, -0.09434742473088546, 0.3142179302017698, -1.9659130803774287, 0.601916814481333, -0.5778459417083148, 0.30370978682474176, -0.9527358543198919, -1.3239478069846011, -0.46059960335807243, -0.08867137656972145, -1.6301961769079252, -0.3055368601236525, -0.7095085608784224, -0.5724411148171993, -0.8009612091583154, -1.1849260120625615, -0.21240194795572406, 0.2560009905883216, -0.4071968370121363, -1.1493828981127296, -1.103110305827539, -1.1027078341020329, -1.30889226735779, -0.7607149195259476},
    {-0.34073379948839555, -1.5970470384133566, 0.26525044435958883, 0.08516619794389899, 0.14679561383234982, 0.2814475183669456, 1.9188339961765524, 0.00030645863410423376, 1.005749206566663, -0.5824800649968694, -0.07744247305041943, 0.4880996964895804, -0.19910855585472925, -0.48275839509670826, -0.3415252066955408, -0.5529058195379158, 0.3934596647759552, 0.14300025914159484, -0.3289486448060638, 0.44426385093209275, 0.03850192107615054, -1.6087540878410567, -1.8837739278406027, -0.28716358260922953, -0.8887230846539707, -0.5302787233584645, -0.2316342529556006, 0.5916973413066067, -0.49379090889429844, 0.5011586165878148, -0.125994131150165, 0.2743604035234825},
    {0.9072815828241488, -4.871837788629032, -1.7885229163969971, 2.912139676325833, 2.492209644211644, -3.233198652285484, 2.191638783933281, 3.022377279834886, 1.2458218024598624, -3.9197703013739993, 0.45560178643893556, 1.0949293116452652, -2.6627241734778466, -4.409652881813526, -0.2192488340390685, -3.8808356336889895, -4.210515547119057, -1.4367799877369367, -1.4037089553411723, 3.1114021723131393, -1.121345543927996, -0.8472358979020098, -4.612150693821971, -2.344516650265651, -4.6456630169536774, -1.3855606434724257, -3.9881745268997504, -0.297132875379029, -2.6103816212574507, -1.542256808610867, -0.3905441510393278, -2.537864610565962},
    {0.769775455201896, -5.536955692468829, -2.8163404124112716, 3.3954028899069395, 2.13421515339601, -2.435733600849904, 1.575244156914507, 3.969872596275933, 1.0427608491669578, -3.828565255548868, -1.1196886494638658, 0.5801986300520876, -2.928674488741973, -5.502167604557152, -0.2442838300914711, -2.9200301707119047, -3.1281972482722367, -2.230089446115602, -2.56671775576243, 3.417721050796474, -2.2859863081687273, -1.5073248704208335, -4.993895604411004, -2.7197799192622907, -4.979646494087661, -1.2457804325833168, -4.443405421907883, -1.5322292448395438, -3.0105751090249653, -1.6079243427247838, -2.633762431948862, -4.581992471879867},
    {0.5271273977094671, -2.1857860228222816, -3.012606995375329, 2.7678314629476493, 0.7006265252279565, -2.310872545074726, 1.913000403846359, 2.6652589299586746, 2.7191202733410225, 1.671334596916668, -0.8402569103005502, 3.2773992132691236, -2.3350597550214385, -1.896544476704573, -0.6815453215433069, -1.372248906473843, -0.04319205394654644, -1.1019855013518622, 0.48786606385839265, 2.5374032416381027, -1.8341030690390012, 0.26550674877761854, -2.0669699072817265, -0.6040645216856255, -3.8466374621009605, -2.488668670632414, -3.0688200198066053, -0.5256833860241168, -2.395277030959355, -1.8066860392336739, -2.459394112178916, -3.123895088734337},
    {1.022384865718885, -0.7555727773036468, -0.7414994262916317, 2.1901660998309107, 1.9944991735226838, -2.6502994056395344, 1.7299630118453995, 2.1614780497736077, 2.7644304265727166, 0.6437297854311842, -1.1561972624303978, 3.483192541754396, -1.6798798859387372, -1.376978539373569, -2.395810904454316, -0.9203537981500994, 0.5036477365499988, 0.9598533156594327, 1.77150305999995, 1.8802002623367096, -2.25327863378596, 1.6276538113764518, -1.7681607852237162, -1.187346637219314, -2.2939337048117263, -1.0146709168593768, -2.802206114084947, -1.320463511846433, -2.528134638384448, -1.5392870595018666, -2.303401705219002, -2.2327254754205894},
    {1.7601463175333234, -1.3545530921716764, -1.5256735003267412, 1.8540975156395516, 0.141496268254064, -1.4963414770564019, 1.9282070905544022, 2.4898629034947644, 2.6944466148943453, 0.995496804674353, -0.012948631703376304, 2.7031257206087345, -1.582404730124251, 0.049069057597098203, -0.025336057588543168, -1.514111889765726, 1.2166063944776517, 0.9850127838156144, 2.1767815847911223, 2.8161393519406617, -1.1985875633644232, 1.5223026046980581, -1.4136542538883063, -0.04118905486771431, -2.6913835349483266, 0.3058833111139375, -1.8444894378367733, 1.2271087720616531, -1.3675049740678848, 0.08034544442688632, 0.4296278033362416, -1.1007577780793365},
    {2.055970918704174, -1.6643585392214426, -1.1687328650362137, 2.6332932802747555, 2.5029694375495914, -1.7211853406222455, 2.3308600084926394, 2.821297939944189, 2.793471736898796, -0.11073904587761021, -0.20292816145639717, 2.377860233929636, -1.8935705122773485, -0.5709412040114772, -0.6668839042403126, 0.4173005147303817, -0.7061646366919975, 0.7287933942047847, 0.2324514100628112, 2.836045957506876, -0.7143062347930601, 2.2546410562037376, -0.7036612659099253, -1.2463613163700644, -2.5659542490529, 0.8721680773401861, -2.845995810405643, 0.575437505231347, -2.4288788917787882, 0.33911464490265186, -0.2609963281223167, -1.54851171530641},
    {0.3187605054779543, -1.9431255981031736, -1.260930545470786, 2.780313238505285, 2.2527200564513428, -0.8672044923187299, 1.4940626193788975, 0.9642007572333708, -0.22455779528528905, -0.6688220184342976, 0.8311861335138581, 1.076420094459227, -1.0667323022617095, -0.2283644690805621, 0.2724970366569731, 1.177271297555654, 0.4693232854146915, -2.2895287499749846, 2.1030501073746657, 1.2227925734670944, -1.9750428538856475, 0.0017855688820905555, -1.8552741465347404, 0.4207023961187138, -2.59529928719947, -0.8102639617211149, -1.385789979829435, 2.276961475676188, -0.5416025688056494, 1.05765143793897, 0.7530258625302809, -2.045454481028098},
    {0.0015370205534355988, -2.178805029238779, -2.5260175475071778, 1.968235595559248, 2.60521127371405, -0.14210741792257633, -0.46183549492253273, 0.7781766359358941, 0.6930594415103283, -1.778331590945525, 0.6686573532618538, -0.38475383022126197, 0.38776918752657974, -3.2982493807606836, 0.993580215505372, 0.8936545629357497, -0.32175846726916996, -0.5081496929512059, 0.5598334163567987, 1.9482963231303365, -1.9122642045467448, -0.16821222891282164, -0.888952122488227, 0.8895923011540968, -1.6769181212443687, -0.11067903407786786, -0.8134807808793667, 1.1507393086735513, 0.1266155144904126, 0.47936635974680625, 0.061230344367743696, -0.6456605540944595},
    {1.0364507833493668, -2.566180638014228, -0.7653633980837851, 2.7764868674767698, 2.4013341364026966, 0.0625208040159606, 1.7941179342538431, 2.3957825395497756, -0.5556446982620534, -2.2205682033394623, 1.0171749265314542, -1.1300657121647726, -0.0003218819547314185, -2.942584398338167, 1.5788912121366654, 0.745284766224135, 0.058510175239591546, -0.8522804520545225, -1.3575419617340012, 2.7607637951850235, -2.3158130445792757, 1.0278370248846385, -1.1540402499011682, 0.32586683414255285, -1.9104389725021613, 0.0530000858992347, -1.1664036054165148, 1.4493685686510638, 0.3181455093315694, 0.21943076692860994, 0.578945645010772, -1.0969940960208726},
    {-0.27712756794073995, 0.2862436440644113, -1.286419887081598, 0.6767000546982364, 2.0948156182667703, -0.5238951394401342, -0.8780509861816009, 1.18257682244339, 0.14787321113309648, 0.4332185328795421, 1.0486778281837508, 0.9603685010872601, -0.9385188907429762, -0.6820769056772352, -1.4011578201424828, 0.9298352476198778, 1.5401716781903716, -0.3466228720034476, 1.5303242452126395, -0.05100865843892648, -2.494233329272134, 2.257604302641913, 0.1714781604274352, -0.2585074055035203, -0.9390760494994366, -2.3287213251200742, -1.1196777431732194, -0.9458161753815001, -1.6706690779930693, 0.10169952128397222, -0.7528179687632893, -1.4965037655559057},
    {1.0263308481459517, -0.5405362405992106, 0.06078746069866169, 1.2490268810303626, 0.32958766811488255, -0.805052609293999, 1.7064893950374103, 2.5828332474683497, 1.837569138788519, 1.164387626974067, 1.1942856129866464, 2.2123556517391987, -1.2438362448776183, -0.501949892177267, 0.6655236418390548, -0.4847048441104582, 1.0210476599770821, -0.291374114510727, -0.17563476030084554, 0.8995198192846188, 0.7593950040623304, 1.422325456996916, -0.7933455445827893, -1.4269471341178361, -1.5731205871728444, -0.5327815563358538, -0.8288211354535923, -0.18385059033662557, -0.6343809591977312, -0.5995275380093067, -0.019174959349609957, 1.438774154879885},
    {-0.7419638080172194, 0.20663255254997304, 1.0480885521283052, 0.21300457371661757, 1.2084384166774995, -0.8264916079339026, 1.73449689982362, 1.5363231008289107, 2.230256015963617, 0.5762623309629965, 0.6911073750265121, 1.6663944425277848, -0.19511845720610363, 0.42060075366169813, -2.2770729323478864, -0.6695949563909989, 0.4998177966909772, 2.1626430330515056, 0.41957437522183233, 1.2552101556754203, 1.3014732250956396, 1.0253461642299524, -1.1502171561373695, -0.05620317670378652, -0.08952172337445376, -0.19992672527772984, -0.8014987210231196, 1.6389823436657796, 0.06979964305341763, 0.434124997796909, 0.7283959658180205, 0.4521509265109649},
    {1.181962092615113, -0.26628729736463963, -0.3913303158241037, 1.3473169489505321, 0.3700686311868144, 1.9951088102978536, -0.03654808469724955, 2.7449152121436486, 0.41045036667469614, -2.374310834045034, 0.057755827208163586, -0.43737247716879285, 0.7265309634286874, -2.910366996274662, -0.19603280141461657, 1.121030262311109, -0.8592722603389545, -1.2255729768791728, 1.3319729562839306, 1.6641805142462525, 0.2597966245891679, 1.6888595157455526, -0.19452208764676748, 0.6944292450690125, 1.4335021455272354, 1.7970306984448357, 0.06573779651811532, 0.5602562839429499, 0.907871143351456, 0.9265529712601472, 0.2854838178287568, -0.29534717612486155},
    {-0.5984267509508192, -0.13189638109541024, -1.9681222443023192, 1.015042499076311, -0.4496354903160414, -0.7986228604699659, -0.11808500621986996, 0.3338605381468113, -0.44354446907502426, -0.30843801283497185, -1.8110458055116303, 0.03346953403236125, -1.0284242843578553, -0.16762906990955354, -1.2279536264236803, -0.48013061875912183, -0.5440789834013586, -1.4574486767694326, -0.8180821759245738, -0.7347036946991986, -1.3994851731015587, -0.3697044873533868, -2.7382457574494663, -0.6909592760670699, -1.0484293985396047, -1.1242920270505599, -2.386615407914961, -1.2185118582630943, -1.0744517863314276, -0.9913290635770067, -1.0277758983716816, -0.09781828789441319},
    {-0.3235146105656101, 1.387235076732958, -2.035046985067865, 0.42919600015730774, 1.5413575463517424, -0.22992514073222234, -0.3712852351226665, 0.1813226255355407, 0.28802928858543575, 0.5972504372294253, -0.17105351216822529, -0.05378599958828038, -0.06936967685044466, 0.6121813184032987, -0.5476914299711634, 1.1015384209926897, -0.15732077726750546, -0.5391949922663088, 0.44686130744973, 0.01786872054048022, -0.2266499520734859, 1.224502251441808, 0.9770280248225088, -0.37328640902128585, 0.8698419517227058, -0.7768957155941625, 0.11189355621017216, 0.20679004255275313, 0.16024864949474968, 0.07958504798097593, 0.67814862263721, 1.1401536739025444},
    {0.9076984444707082, 0.3981319575844699, 0.8357811281360384, 1.4313024388334845, 1.5929819289999378, 1.1829916914763352, 0.358824641532195, 1.9716149543651298, 1.2289537069899314, -2.0807177428475483, -0.35438800549253086, -0.022431032248951797, -0.8408559491548904, -1.656606553300775, -0.5298628352446338, 1.4670635314900844, -1.08390958512958, -1.130645170936803, 1.4840785132640042, 2.0815306353412533, -0.02244085494243769, 1.3118213288472576, -1.0608588982265361, 0.4033589163618803, 0.7193227005900075, -0.40916211096979693, 0.25675942483672726, 1.4328235750206495, 0.5515163862748664, 0.7265397858005196, 0.6511492450955041, 1.3179926578326246},
    {-0.21620102481215148, 0.03549558252383101, 0.3736962221384666, -0.18355809097738476, -0.24674239639482293, -2.072844466482392, 0.058498500699399096, 1.3353649326472885, 1.494400286751434, 0.2229314087376805, -1.6645330896291644, 0.5249872361876582, -1.184764704093377, -0.09180697648596028, -1.6495249409689752, -0.8802713095515515, 0.5469698521666295, -0.10154413922516962, -1.5719270571686035, -0.008085973074606569, 0.11753049460685064, 1.4225667750867936, 0.19549996420501195, -1.4069802040844654, -0.7560557435089467, 0.35582568636211914, -1.6514493428756165, -0.3975932545392778, -0.2663718693232091, -2.410882724348841, -1.0536614411251386, 0.25413051420800603},
    {-1.9223271588783337, 0.45730201822032873, -1.9412656304643687, 0.14189590056418888, -1.5578085961673311, -0.802606793082576, -0.17755603025589795, 1.2324085651710255, 0.6106746312806193, 0.8385985749550362, -0.4894798612512007, 1.6503019461192738, -1.0178936115945156, 0.34449208418130706, -0.4670493604968884, -0.6086021414893004, 1.3788360943264117, -2.2101538729972727, 0.008171147495259538, 0.49979829162346384, -1.8593003165218256, -0.6745265804454663, -0.9461779385526851, -1.0352785741292179, -0.3880872069101295, -1.0064422164064772, -1.6698947176651744, -1.7279794145051501, -1.2972286016466126, -3.027070927355809, -2.2200732232816827, -0.8153320199894026},
    {-0.012220370892097106, 1.8088330457427437, 0.008830168729879198, 0.10522449504218001, -0.674969351103237, -1.7308997799723826, 1.2350881465624535, 1.6417083309625595, 1.3737715415175835, 1.7613452378239445, -0.016635499578458387, 2.0510207020973987, -1.2006108386970176, 1.1632414948867547, 0.013520769257903652, 0.5747719522234528, 1.724822426909779, -0.44907776532957516, -0.07742351583422072, 0.9936440717917893, -1.1433402643372237, 2.508670161201265, 1.0816820760887222, -0.3563832090416033, -0.021159274559677515, -1.9278141015115375, -1.1605536308828692, -0.59877254137067, -0.7709831106918739, 0.5697709679269314, -0.14535244952160808, -0.7837309915587685},
    {2.1195193886677046, 1.82979002368126, -0.03752638369489881, -1.084029549994794, -0.20961606364884833, -1.6082308597817991, 0.30000484056808835, 1.5003799716124637, 0.3508121929473574, 1.742679015461971, -1.391674899610245, 2.0854526322638685, -2.6090679667609202, -0.2655721034544799, -1.8402815654709654, -0.4591012945046653, 1.647613367288924, -0.3117154904107712, 0.34216933061304494, 0.7849447403118305, -1.1323641841990857, 0.3903951769176792, 0.23249603401998348, -1.3822112617578555, -2.9198712753055593, -2.022413939078688, -0.8042020223816471, -0.41148352230868934, -1.6966302795681665, 0.42028274317041575, -2.2493819499810246, -1.4870901678112638},
    {1.246451134932969, -0.8812869930851827, 1.4414550773133672, -0.09335590802946835, -1.106295189715633, -2.0671738849517567, 1.8928474924021423, 1.7125697893381449, 1.516923091773133, 2.1165590177368734, -1.943284798007352, 2.3023096633988502, -1.5099685995966723, 0.5278839816391335, -1.2595674706897548, -1.2517937437840088, 1.119855685574909, 1.4806575147779795, 1.880504400536087, 0.5997736081911614, 0.502279536988824, 1.5545745929026802, -1.1419205691238248, -1.6853590222578285, -1.2078382270704418, -0.1558529775044895, -0.9583698704327901, -0.3729740809215006, -1.3015849604710727, -1.0777678491596054, -1.5903827200680383, 0.7756475981904708},
    {2.325202512315935, 1.720897643897857, 1.7554430064183664, 0.0754550038350005, 0.7472529435841048, -1.087970814752326, 2.9719041855483694, 2.618288814986406, 3.287546792233477, 2.2875480903124825, 0.031868739130237876, 2.3408634559976327, -1.024443465898268, 1.4696446764249003, 0.8277689664816423, 0.23417416440867891, 2.1141746695311388, 2.79341751488923, 1.717853518099921, 1.9527250719844085, 1.4203299101543525, 2.5257680729213607, 0.8521548607739565, -0.26968957118627074, -0.8804448668695078, 0.6133655714339249, -0.8167595592264125, 1.0413225443421252, 0.3201614937388142, -0.3328915353582148, 0.8696330479731101, 1.4779530895297568},
    {0.17544533901891018, 1.0018381942574364, -0.27629282889611334, 1.3817575297319389, 1.4269386216096451, -1.1198022072206915, 0.8966998637095452, 0.6247379355616416, 1.5960642515468457, 0.6290846721404374, 0.7901138341530464, 1.50474543540315, -1.380223192640105, 1.9524767888880434, -0.3180472174619022, 0.1692464666775508, 1.0139839509585578, -0.6753374063195579, 0.042158609925698656, 0.2994460318058058, 0.34544854693999527, 1.3529525095123387, 0.9256564624307261, 0.07321716940019007, -0.25833530047201014, -0.6943765710419946, -1.814658511941524, -0.9580225345183706, -0.22985099601098036, 0.8787890700354313, 0.6964339490831145, -0.01858409916368149},
    {1.7647799259466799, 0.33538322823446454, 0.15595152744399857, 0.3379712275327182, 0.8982554674092883, -0.1765808227575719, 1.4155712834670535, -0.45180211421370325, 0.7950138060492844, -0.7028526801818146, -0.493460348335153, 0.6290776359072093, -0.7256493913414499, 0.7684998795224229, 0.4227642012636548, -0.69333692212807, 1.137763571993695, 0.7407456683667782, 0.2087295007035874, -0.6425755058505472, 0.1311626620993206, -0.14757566633946806, 0.9356317176362414, -0.1752040230127092, 0.2602327463217342, 1.1437273954055331, -0.10450505705433245, -0.6933520230896464, -0.5790924092158721, 0.8684956067979954, 2.0805162322031334, -1.5868203965779986},
    {1.527544154970444, -2.9441734089159266, -0.44509987207268153, 0.44535584038619624, 0.4021209809394036, 0.9680242064661452, 0.9059737327372253, 2.0067945243731407, -0.23307472132651869, -1.874134957823137, -0.7976149637051421, -0.5249211051721782, -0.4214652520748393, -2.3739411968862694, 0.7709477550694785, 0.3191388214591479, -1.2420800856783254, -1.6269507711817164, 0.46772051392630076, 1.3216856748436931, -0.7506436058340267, -0.7660806517893577, -1.9836738611558746, -0.729837405967021, -0.39865229450929585, -1.2530379495754278, 0.6042030676534162, 0.8376168313458728, -0.07992808729418598, 0.5079853105611457, 0.014050714958300015, -1.1733356709725298},
    {0.8198998135214832, 0.4156408246043963, 1.094181582260646, 1.652600768427673, 0.7540582588527811, -0.5542996285736633, -1.0457286059321529, 1.850954418404799, 1.6863995374219856, -0.12610958877264175, 0.7851966303987518, 0.9469751620521433, 0.8278804442367825, -0.8451387896437742, -1.5996785401401554, -0.47496175931256424, -0.24965409287240434, 1.95288057574295, 1.5335422292442518, 2.03817728445794, 0.2269257499184666, 1.3161725591650908, -0.34430705457688826, -0.14124220720816838, 0.1575579203768697, 1.4887521330156845, -0.46633795162923514, 1.3747406247611882, 0.321789510499401, -0.33944983243352594, 0.8378908303707541, 1.4495201719273798},
    {0.41310987731560567, -2.183720980256075, -0.5806385125849705, 1.282425918029284, -0.7848115320840369, -1.077158552270312, -0.318914842744637, 1.477404483003022, -0.5007218561164333, -1.2876789321334927, -1.0151031216629767, 1.4541162740978644, -0.24570410134505552, -1.730240150427175, -0.9943154891429263, -0.25658204689330555, -1.4510468371884901, -1.5085398167237913, -1.4002625807010647, 1.5856602873594023, 0.9484676833569682, -0.5675635350614373, -2.3352139090763897, -0.9824083557164569, -0.9477997107040576, -0.5506281799204303, -2.318360198460221, 0.7017354602842727, -0.4838796176694446, -1.7909550792099578, -2.1829514362769835, -0.968194188618155},
    {0.24518731869288815, -0.41857129213405114, 0.35650029645398507, 1.3016608401404055, 1.4462662423652621, -1.2776813523676798, 1.3087927140995388, 1.243007427910261, 1.818832635609105, 0.460682867399075, 0.935852709012063, 1.0540434491983932, 0.6310193889542773, -0.679070115539046, -0.941757331185183, -1.8147420552876297, -0.6381222460110627, 0.7270985957601216, 0.035726877255854994, 0.4937508688871059, 0.9759615914449384, -0.778449527945026, 0.19059109318893375, -1.4945240067328993, -1.7330523058749967, 0.07083525203082545, -0.18133666264389878, 1.2994239375093548, -0.4592190240097366, -0.23780059691378433, -0.09900095692363516, 0.5072211761623554},
    {1.6753092882621847, 0.5295914023215945, 0.11278618664710151, 1.5171420604929227, 0.7740626253328378, 0.6223874445113998, 0.9699603375431054, 1.9458547858660313, 1.6995077974798831, -1.3107491494449106, -0.796732460500979, 0.07142210211801561, 1.1972207729132904, -0.771169506346403, 1.0336638144795278, 0.8529358030007055, -0.10399918491678753, 0.2556038667478255, -1.2348206491702423, 2.541224658636154, -0.5760331676983848, -0.7269004456618153, -2.1094282989903057, -0.5949697238623628, 0.050416638285598725, 0.311780380091821, -0.08089465344610883, -0.482333430495272, 0.45518405182810373, 0.4048297412494809, -0.5399943650098985, -0.6941498378934804},
    {-0.049230264484598864, -0.859767102157473, 1.1670834912270296, 0.5933560540162055, -1.3217561212648574, -0.47423331421386067, -1.4856408886798396, 0.5701534964219271, -1.9344285799005687, -0.8786541810098424, -0.04730846123173535, -0.6043184662044109, -0.4696840031437556, -2.207447973346292, 0.18606685437774953, -0.10721236756031824, -0.9820688901771369, -0.4682651597247526, -0.28176196866197045, -0.1320062547572829, -0.2563115391435734, 0.42748809910238117, 0.6337771369041684, 0.8162846049236931, -0.30289601145380746, 0.9516263581285813, 0.0612002048059043, 0.7864796289561501, -0.1894450767079052, -0.6234329457845497, -1.6205654423031206, 0.26275364753581515}
};

static const float b1[32] = {8.270267389952746, 8.593189825202863, 8.538076034303051, 8.430219648290729, 8.381377941849514, 8.169048818768458, 8.487127381834567, 8.345522578872599, 8.337162161116437, 8.642770664716432, 8.184599093616688, 8.079646428110765, 8.193264024676258, 8.440647786014301, 8.178472854175332, 8.302739432684087, 8.35297907282334, 8.318617284218794, 8.56541334740143, 8.163812824375801, 8.422011889777878, 8.339505532125651, 8.418749654215375, 8.151294178394162, 8.418228765546951, 8.490821149608836, 8.366362461614884, 8.27341389225555, 8.14411203239668, 8.13086716391726, 8.425028906873743, 8.463705020649941};

static const float w2[32][16] = {
    {7.3327681437552785, 7.3536869680455785, 7.457160553518202, 7.277027694909377, 7.513889947442597, 7.525831266203686, 7.6464532534780085, 7.7178514792924, 7.023426503202716, 6.441542502333093, 7.67797422172833, 7.8054435971268665, 7.715098340638692, 7.597902031451202, 7.482560047614832, 7.409876986924084},
    {7.5089304230883895, 7.825793221051064, 7.506739210880402, 8.103332884103553, 7.751954395253526, 7.257565146745087, 7.841183899439417, 7.607981362881502, 6.96497478889158, 6.643840182208305, 7.617805534912274, 7.684463642979369, 7.668438094711908, 7.720713658986482, 6.990238505878349, 8.260760505325516},
    {7.794396725085028, 7.310333372638181, 7.974288926176969, 7.701166075520397, 7.923484936665231, 7.111935681365178, 7.351091371541713, 7.684122187851286, 7.301453179582781, 6.459677189569407, 7.374253634935539, 7.7888556914590215, 7.886661297278018, 8.148570893104733, 7.39828427408135, 7.879861242586003},
    {7.44074241253445, 7.6030240711327, 7.596838921936295, 7.4033377503564575, 7.814795242088714, 7.011884115570503, 7.407569806628549, 7.058721154035875, 7.025409338326049, 6.315616434081455, 7.493793884644495, 7.3900055272955845, 7.185485608752228, 6.830548379060155, 7.441543712807737, 7.158012781572836},
    {7.367669004233633, 7.475672019067767, 7.0084784368803605, 7.329216537989386, 7.581977530834775, 6.944296946374444, 7.385069907074903, 6.964671726134107, 7.034250517339598, 6.586995819019582, 7.332047234955096, 7.222298936115265, 7.472566577202026, 7.3255835559502085, 7.0528927547948195, 7.155878119169045},
    {7.471550261286128, 7.623619195893896, 7.14359091986731, 7.664114262368684, 7.096589530864562, 7.2886567468338255, 7.587858193808091, 7.453032463155519, 7.156837396240699, 6.362465639148752, 7.074343892771724, 7.278676894615731, 7.524090979574592, 7.654833576570409, 7.12380133545456, 7.1301613057906685},
    {7.462157504049628, 7.383692489762749, 7.500803584732812, 7.215751932252018, 7.513706678061931, 7.508860208545261, 7.38309213572217, 7.080487541544478, 7.050688205024693, 6.3132690902355915, 7.423789392989077, 7.500956788479713, 7.725708914634054, 7.677713621985501, 7.423109283951296, 7.731905088236935},
    {7.663076823524245, 6.9694110317013855, 7.302253916272805, 7.5178015570383145, 7.631334862860452, 6.86334764520162, 7.742039243121293, 7.147596135932028, 7.5697079143727155, 6.646331131256241, 7.610198913986639, 7.162765976572177, 7.666285269145181, 7.277703199401286, 7.350193089362627, 7.299039154999951},
    {7.782975143536514, 7.6363490605592705, 7.423677634797026, 7.476240281026203, 7.559450843096707, 6.5636054788752505, 7.342514367791362, 7.431274770908854, 6.891029231269624, 6.4510157336982425, 7.507571880678511, 7.698164019125913, 7.327489231960922, 7.486782004877482, 7.63728857613662, 7.299901434382511},
    {8.17153784085346, 7.5069449347334265, 7.7169395693153735, 8.119459218552386, 7.860981529331538, 7.921028719472919, 7.6910018628523265, 7.239759133031372, 7.38282164925391, 6.421024526007386, 7.423438290943743, 7.662828518580389, 7.487123582748174, 7.72986828258768, 7.607997402745738, 7.5240885821845485},
    {7.0500038422081275, 7.24525771331699, 7.4099427111735485, 7.382059727146325, 7.3501223156708635, 6.946208481284077, 7.5133930832287446, 7.195249080764541, 7.083743896374232, 6.681440286464211, 7.429443945452385, 7.40103297075464, 7.410862928152879, 7.49482742856767, 7.017087163903594, 7.085547909607249},
    {7.509146248102414, 7.2320053175722645, 7.24262254472028, 7.288917532006335, 7.691608947141829, 7.757915476420832, 7.563583510904399, 7.179571992738622, 6.863176808755364, 6.063719375248097, 7.373841870569713, 7.41249113695876, 7.092512401335972, 7.531154102646098, 7.171672010232075, 7.300199719848903},
    {7.555519870705104, 7.4510267187452826, 7.680277262381189, 7.454591266763692, 6.90507171003303, 6.562554848179021, 7.411486677069259, 7.423622230254136, 6.973053011443989, 6.161531102849273, 7.134835972072503, 7.62491134562063, 7.663764185808737, 7.4467264483819555, 7.094415622096115, 7.367915561464747},
    {7.500035155923011, 7.651435221760806, 7.722180617782533, 8.190807944469592, 7.868746191883306, 7.749548707474461, 7.959096539095223, 7.429505369154135, 7.139182560451092, 6.142918598067902, 7.55035196685797, 7.805736848166471, 7.948587040398868, 8.294024435132586, 7.6646712692097685, 7.848706010742072},
    {6.971973176881608, 7.659311578201196, 7.624736731381066, 7.260165148254485, 7.690270268510897, 6.978503720956294, 7.344601755265912, 7.410475778655057, 6.779576140483269, 6.363371414763242, 7.344579482850557, 7.460253427746324, 7.220912724509958, 7.26008364603023, 7.5032241823218, 7.322149318348657},
    {6.990203630156419, 7.925413825386096, 7.235305555299051, 7.80360005137939, 7.38046323882357, 7.270385759995695, 7.464673585875825, 7.097284080967022, 6.902482634768408, 6.256682879844672, 7.284801138063154, 7.384034521788835, 7.932517199609716, 7.249308731668256, 7.291082309544137, 7.903580639566375},
    {7.836406580828978, 7.893553104066101, 7.942696765244628, 7.545429579124794, 7.6901184628154855, 7.941473896823004, 7.614416768203203, 7.7689090788781865, 7.3751423339569495, 6.597342985703998, 8.004943856023075, 8.005442371072158, 8.030033549021377, 7.543591810811413, 7.482808907503104, 8.297601682077628},
    {7.382515133989708, 7.2084032288918705, 7.582905294691298, 7.717679536985034, 7.523582893255464, 7.422965672693644, 7.840304615377041, 7.409075309314083, 6.919986154443708, 6.480159043518659, 7.932846438261813, 7.649696882231889, 7.566567639485593, 7.267790636279288, 7.466806238027193, 7.325826705578782},
    {7.925636293177467, 7.648093787380896, 7.737331894184383, 7.853151522835913, 7.682282134674049, 7.15109144128421, 7.354483444469889, 7.4446527158657805, 7.333552476777778, 6.762203159788737, 7.50361007353112, 7.59611672742432, 7.478440920394417, 7.521427475161128, 7.497838636194168, 8.002742933191684},
    {7.199187801862367, 7.582925275087803, 7.462173057663196, 6.872731820191704, 7.764479988030517, 7.213982041087023, 7.407244969361029, 6.615160676000539, 7.756893650978605, 6.354102556061561, 7.827374364221518, 7.308718891219395, 7.6391790185887, 7.488121514375511, 7.398407260563799, 7.1075285479672},
    {7.656641494832724, 7.43557702948431, 7.658560738568932, 7.35743599552568, 7.44540656986317, 6.674813662637508, 7.490596410523334, 6.867517482754083, 7.505379994507819, 6.6877452986358294, 8.014392690269128, 7.686703265570797, 8.050982084221516, 7.598175190315305, 7.493015516933483, 7.6002948119191185},
    {7.70408572248435, 7.882927921897163, 8.197842476027013, 7.707222866679392, 7.648563352235124, 7.81125042237587, 7.759550648466196, 7.806013193822928, 7.524568841353746, 6.911559792908697, 8.10595989002447, 8.13980639253683, 7.924393403025702, 7.7787768844810135, 7.349253599138505, 7.607266021553936},
    {7.726995697234318, 7.817300657285091, 7.715930586943615, 7.575312289115447, 7.6216485936711305, 7.565818274104905, 7.318519918976505, 7.282173403973953, 7.605720795075209, 6.581117713032629, 7.483375220144338, 7.317360046907926, 7.601377436702627, 8.108562855452103, 7.585108226185164, 7.830739432510098},
    {7.585519437077871, 7.5800021868651095, 7.328305446113638, 7.286108987896513, 7.510426339732653, 7.358263423291217, 7.538562052221871, 7.289725957746931, 7.212511891614852, 6.557818534845953, 7.350416310944591, 8.021615556896561, 7.430370491712469, 7.942894522309894, 7.3091741796161696, 7.232954721089556},
    {7.834346664983303, 7.453767171234956, 7.427678144430005, 7.852773417475752, 7.479959740160065, 7.072337360312554, 7.332990219323965, 6.873390348267514, 7.2293323261936475, 6.214791944305671, 7.494773218571821, 7.654114353421776, 7.734135823290408, 8.036566994655761, 7.62446266331244, 7.379497894603586},
    {7.547076310199681, 6.866677955847881, 7.182018040957952, 7.685144801316462, 7.610190236237945, 7.010917590774219, 7.35363988880713, 7.558047534423202, 7.360626028872797, 6.895714569265842, 7.441104731741787, 7.34304278785824, 7.7069732693840045, 7.445966632067302, 7.429022237582285, 7.577610508673196},
    {7.606720120517229, 7.426420872192005, 7.3553962925726974, 7.56029254279132, 7.604021984326592, 7.366799205908613, 7.430688218745355, 7.078772818674831, 6.890766028490685, 6.602893047844364, 7.905662822879659, 7.67068824703801, 7.427058280288287, 7.465064797031105, 7.163578356492032, 7.338492693401179},
    {7.935016349226219, 7.544711409271723, 7.4457072919255465, 7.470222867292903, 7.008896022216692, 7.108265853516425, 7.637191514351795, 7.436206741646941, 6.716187857568365, 6.424406587004416, 7.446760784802986, 7.388395047191182, 6.906772337937425, 7.620362070993604, 7.653438952215997, 7.144650604275772},
    {7.218415405486936, 6.818108819646843, 7.53690900150442, 7.442343714764511, 7.370940620593348, 6.790773746536934, 7.458501417798297, 7.308688010814754, 7.238992959377308, 6.122005400412101, 7.653236901043585, 7.8400878796719216, 7.391645125029307, 7.148714063967916, 7.2600301834421614, 7.007493834344091},
    {7.127268095135772, 7.6350348927024445, 7.222512345033005, 7.661389826888883, 7.592919610284202, 6.983184929901287, 7.383081780551223, 7.4387809969132, 6.93700734000289, 6.322840120209106, 7.411417049624882, 7.519547146115761, 7.460834950817281, 7.043624775814939, 7.689740003694743, 7.422696452301885},
    {7.874707665510205, 7.3996401002750725, 7.598791510275043, 7.968935374059347, 7.546141783807793, 7.347052785806415, 6.9474321052958325, 7.655508059668472, 6.99540597589499, 6.3481437562091365, 7.862384468999417, 7.2954605687048515, 7.098526545558187, 7.636585627517736, 7.190737800890674, 7.282919439123633},
    {7.593566744996132, 7.437017858957299, 7.465810601048068, 7.464123579302404, 7.728650105824259, 7.438079789039042, 7.534177716725357, 7.309971829228111, 6.955501698474837, 6.561679045099157, 7.2803567757795795, 7.295574628048248, 7.783989122364639, 7.613183153137349, 7.650614070339777, 7.5979870623230426}
};

static const float b2[16] = {7.111410946218562, 7.040834828378997, 7.115803046728127, 7.150058998172737, 7.093027903367736, 7.235733737208788, 7.153069085845548, 7.073495177163878, 7.161992673307256, 6.924462398611565, 7.04880339082353, 7.13589600724184, 7.152592707752041, 7.0526673397366215, 7.093438327596054, 7.089678724019291};

static const float w3[16][12] = {
    {-5.30023918615239, -5.217169204221693, -5.411379358103071, -4.845766513431487, -5.021427872098415, -5.499370487341189, -6.043624942433943, -5.323867578267025, -5.438417068804937, -5.319038154971152, -5.446235701749597, -5.049540115246114},
    {-4.558976938575005, -4.908115656390885, -5.036492092938144, -4.907266985229069, -5.668415801450402, -5.273668670325691, -5.080140551019726, -5.457039935732501, -5.8488369369389765, -4.613748372159765, -4.838969451571235, -5.357860201567007},
    {-5.3407179397328, -5.014530258973032, -4.794307270461436, -5.290948589473819, -5.8067499170177035, -5.216163242602841, -5.474037757909023, -5.573219479348248, -5.225913189279206, -5.881910699352331, -5.374311984930955, -4.823585926120476},
    {-5.675525578119325, -5.365293365092084, -5.479751210677196, -5.072435973027436, -5.16645214232354, -5.468112899569924, -5.260261200939464, -5.046146849447266, -5.116342795572311, -5.46719789237254, -5.260892671897825, -5.227066352655825},
    {-5.8483591052307595, -4.506846267124328, -5.4089161994602595, -5.892524359357249, -5.378964996054477, -5.421890372666384, -5.312337607067391, -5.145360153206535, -5.063171400027245, -5.402615656336371, -5.115350935907647, -4.970852514941478},
    {-5.564638063324097, -5.355200641706285, -5.213028859295332, -5.418702099811423, -5.026745883139441, -4.986177048643319, -5.247041715821658, -4.6264153667225525, -5.296243307961742, -5.198238555631194, -5.256759669126052, -5.242135031177757},
    {-4.838565915497339, -5.153917594286458, -6.218779593581093, -5.26627631655617, -5.682318886410108, -6.085567952927772, -5.149044332425801, -4.953078110472212, -4.773873510989568, -5.161890148794704, -5.725611210287922, -5.623633352547042},
    {-4.611309242103091, -5.649766092561495, -4.780860256551125, -5.372622684739283, -4.892556851460572, -4.783211598438518, -4.891987890805322, -5.657539151554829, -5.697659610477747, -4.988952161123285, -4.856735179139392, -5.80345399035696},
    {-5.338221402660967, -5.176441858003335, -4.5715290919614535, -4.901523676807077, -5.596099827938133, -4.4350908236768944, -5.369264333242558, -4.92937230777193, -4.360543589037838, -4.830522590067344, -5.257165558440754, -5.54616296495511},
    {-4.279348866743271, -4.816336736287383, -4.040637631384331, -4.536297147561305, -3.800192320454378, -4.22385023575582, -4.432111311496927, -3.74836101349288, -3.9421523381176797, -4.336175654367211, -4.389596666243152, -3.5822379259736223},
    {-5.275117311961385, -5.084954026396947, -4.9921321464049155, -4.806335726800662, -5.335362773574434, -5.410273598772719, -5.586998351312892, -5.575910137311685, -4.894075934724745, -4.530504116282214, -5.143187749168311, -5.178684374272303},
    {-5.559834244144182, -5.181528526798873, -5.590347969618088, -5.448874330013072, -5.1243955659657985, -5.725299809460639, -4.623099098847188, -5.3770173897110105, -5.6113170876961025, -5.173763557286499, -4.896545057820789, -4.861768762309789},
    {-5.057563961472011, -5.321592069740825, -5.405521941418381, -5.171485232676641, -5.276119336363475, -4.950846026253825, -5.089177461628406, -5.445960405996469, -5.0310789485275595, -5.885815680587304, -5.059075750031731, -5.355126692368467},
    {-4.701315381263952, -5.43781904420757, -5.696108185903699, -6.026451892475715, -5.319301410705983, -5.476657961902798, -4.938110973426289, -4.793078750482756, -5.746117272392075, -4.732608556068978, -5.630749506667904, -5.442496734978471},
    {-5.33874956774492, -5.407746600976437, -4.823880796015485, -4.348212789695894, -4.800309646519673, -4.565752147170258, -4.6134468485736635, -5.26156270678905, -5.580723418258645, -5.553261749691964, -4.855011222431157, -5.900455511380905},
    {-5.591471112818225, -5.3713425499151635, -5.315316394514514, -5.581362990729744, -4.900384869536741, -5.26781047237003, -5.783552030173369, -5.88111928579524, -5.169337388906282, -5.780780891822827, -5.7815683438123315, -4.860660435178387}
};

static const float b3[12] = {-3.109950571346635, -3.200405858290153, -3.4070352672481325, -3.2594580894715928, -2.740542238031438, -3.113396419816791, -3.4145038542203108, -1.0590909239872082, -2.1378663361612937, -3.822314442798587, -3.228850614560198, -2.1543921906713495};

    // Input Layer 
    float z1[32];
    for (int i = 0; i < 32; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[16];
    for (int i = 0; i < 16; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 32; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Output Layer
    float z3[12];
    for (int k = 0; k < 12; k++)
    {
        z3[k] = b3[k];
        for (int j = 0; j < 16; j++)
        {
            z3[k] += z2[j] * w3[j][k];
        }
    }
    softmax(z3, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
