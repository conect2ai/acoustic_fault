#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][64] = {
    {0.8131474205791552, -0.0798554764846969, -0.3990423207849322, 0.2136612331344625, -0.7294606308462781, -0.6909858833981407, 1.0729293313105297, 0.7971409808392703, -0.9272905978063373, 0.043581105907895226, -0.21580718020089532, -0.7494298630267099, 1.0232049392334122, 0.09472801127113148, 0.7049965951548589, -1.088537924032129, -0.5588709455332459, -1.2923383028210802, -0.8874174315048001, -0.14306275362183005, -0.5731629425383482, 0.30880741440310977, -0.17284167266295905, 0.6455841664274932, -0.3454545005523218, -0.7277733816762294, -0.44496094292664706, -0.8636511814824868, -1.032144400007778, 0.9506729012473428, -1.2763257582426304, -1.0374933642878688, -1.265184817918627, -0.4896874618585762, 0.7385206302518369, 0.32903220784297116, 0.23520538548175307, -1.4051113074834798, -0.4137200664383062, 0.9040686336675595, 0.22825526894410442, -0.96321314154141, -1.1219401048256907, 0.6064284323212942, -0.37714510008026203, -1.058573043003629, 0.8717604711408584, 0.4658941676364108, 1.038182178280851, 0.7082207977314097, 0.8901691479530677, 0.6706736090883233, -0.844209039727538, -1.4309426041295736, 0.934897770472447, 0.5849866804373463, -0.9096999257307188, 0.19985010652243193, 0.8933345160651682, -0.6532147976463967, 0.019542858158269876, -0.9004221703893834, -0.38169946826394135, 0.3836888492226853},
    {0.5844920489585754, 0.8931191840870047, 0.7741812235928435, -0.5362669354775214, -0.2373864756660026, 0.10360320305942493, -0.9121941812207246, -1.5743744853923287, 1.1493639943010825, 0.9755922960627208, 0.8475757302217428, -0.8485643417579158, 0.7174573996977871, 0.5587821982441344, 0.5132229704295244, 0.7738393377200298, -0.27658955481881065, 0.7276851419547423, -0.10767947384365022, -0.9064767720615099, 0.02798949710030854, 1.339973387679646, 0.013134671934200762, 0.7230787283942699, -0.10396186484897824, 0.0668863200649326, 0.16169608558136284, -0.698309365397494, 0.31224463199751956, 0.9342603466583401, -0.7578471104737433, 1.022642559162052, -0.9831093211129779, -0.6676413005251436, -0.6795479534633969, -1.0884984872028811, -0.04260488477085507, 0.1436437746092086, 0.1829274644841659, -0.8698614683590513, 0.3696522561732165, -0.2031661446990344, 0.5487108600890185, 0.5690892360354013, 0.9517168680819423, 0.09316864651158392, -1.1378034084169393, -0.28064589467741796, -0.09483347670330433, 0.47762053065585663, 0.38389563909971625, -0.7730495380488681, 1.2026728404715892, 0.137930163705602, 0.5737641771732135, 0.0927434803897827, -0.5183312366848609, -0.08749269058647811, 0.0909968168521631, -0.6661832489367023, -0.5665476699868801, -1.1785521174921998, 0.6653431412359467, 0.8956679436583842},
    {-0.5981626839491203, -0.41377164881762835, -0.45815907432709446, -0.432006264457625, -0.845243907609787, 1.350443360549015, 0.20699846048289786, 0.86397983375624, -0.646947873627456, 0.9394432163021397, -0.8337018532570322, 0.2586864098583965, -0.02704022852689401, 0.5123481750360795, 0.8485415030028995, 0.5250560479135061, 1.1508000831238119, 0.27371716377783584, 0.9301958139375759, 0.4768812488847656, -0.8728676566992399, -0.9088322006175006, 0.2542563462033171, -0.25230678426686387, -0.2161532939754301, -0.6329727018125823, -0.7335129443478834, -1.1275096403286446, 0.5233612249034827, -0.5605407564371602, 1.4341450137528278, 0.43610856380651053, -1.3375607762248534, 0.7172099644337334, 0.8980018623763272, 0.25662373912380504, -0.8918406040843417, -1.1786909894622501, 1.0137167128754014, 1.3886947944802144, 0.34574436850840046, -0.7758030372172846, -0.7925421041169315, -0.8147947903235261, 1.160056927017198, -0.523252138596765, 0.11976059581519936, -0.5697091593752281, -0.3602868137636808, 0.43738830093758413, -0.6121942866939984, 1.2455671767240082, -1.1363101239713755, 0.8216186862388933, 0.02614177306233636, 0.9130531630054499, -0.9187811970757677, 1.2972192398488276, -1.2970208036576663, -0.46262156722092274, -1.180811781127296, 0.5933786791243694, -0.44215687131821957, 0.6929545785346314},
    {-0.6343025219860604, 0.5709508527280769, -0.18017167303737797, -1.0097134447951706, -0.02888040816469764, 1.0805515102335517, -0.5144403721949052, 0.9207027333237496, -0.4133562570710837, 0.6575462693894608, -0.6474443309814268, -0.7709287946184862, -0.7994305957686245, -0.38238652004242407, -0.30770837920242455, 0.21932486518096417, 0.9027043637036748, -0.0972000216855641, 0.24139654263595778, -0.6941793443979245, -0.9193346074719556, -0.5746431046946037, -0.8630406079039763, 0.29804563964911773, -0.07080874751141562, 0.2304683412622625, 0.007403780188120536, 0.809221186889335, 0.7801396242931542, -1.0278000640726832, 0.15954261081907808, -0.5489973756182316, -0.3548851703234944, 0.7311918209003269, 0.3734225259675197, 0.3157855229596361, 1.140036005333747, -0.9092879435386937, 0.9970826658468172, 1.0038613682886248, 0.3633666064598009, 0.9860174557548964, 0.44261994388663195, -0.776186731809758, 0.8171606964332876, -0.04626960576216736, 0.780738848644831, -0.10740489787777315, -0.4530466822088474, 0.36387336692894995, -0.5629337625546058, 0.8059883518456719, -0.7565597426801235, 1.4047851406734533, -0.6036759333141329, -0.35568763209507714, 0.41196734127901974, 0.6263213139074598, -0.37545114209898456, 0.7117239074236686, -1.3994733813997364, 0.8083913784034469, -0.10080209429019354, 0.8805201250874068},
    {0.34000940617474223, -0.01726135374739688, -0.00395855959447908, 1.0428010210504681, -1.0312235854224494, 0.33322737997008484, -0.6910205517911029, 0.2470399925282475, -0.6131918874059982, -0.2868493256427257, -1.1624344464444538, 0.15606585076334434, -0.9237900315877564, -0.7550998723153745, 0.772360252311546, -0.07798233628002181, -0.6271227294449572, 0.35432019356052646, 1.5358246321581808, -0.9047445933898234, -1.0941826946066335, -0.12107291592894473, -0.6506155678698415, 0.8889409104385623, 0.07048074042911674, 1.555473849095703, -1.4584199898318526, -1.0057787676185437, 1.452885603500836, -0.37508827922268345, 1.0298345836508291, -0.3977676872443899, -0.5946661239357667, -0.9223665671871621, 0.5034290544527701, 1.5851501853047525, -0.16342477123493682, 0.7213795000169125, 0.5497495821860287, -0.35874182566892004, 0.2602246409721804, 0.3646582633517712, 0.32546329744827346, -0.6080701381447416, -0.879468726572004, 1.130747019650778, 0.23582382501257187, 0.057559368401516445, -0.19316148767641864, 0.3072308324866023, -0.323263985402465, 0.3320286267506059, -0.2721875007843076, -0.05863577265290939, 1.004073400388365, -0.3599786401126167, 0.027316431651047503, -0.4777293738325439, -0.7207288986468942, -0.9686398444394512, -0.534909520784964, 0.6611002091250361, 1.0616025312542272, -1.1195491972326967},
    {-1.2788292909833179, 0.1708027446393599, -1.286134291294438, 0.532359255434802, -1.0541439334764777, 0.9688659168834913, -1.2633090034453331, 1.1772339800710934, -0.5101806191803677, -0.9292318711274475, -0.9549245829914853, 0.03152205577512195, -1.4391008059316739, 0.09608880129824852, 0.9912288243075906, -0.034629035198965236, 0.3922549366369393, -0.8354110477941283, 0.7161543125289509, 0.00933815132718888, -0.43486666240475774, 0.40978170068398373, 1.0421376858179796, -0.01971106362817687, -0.37433171057148057, 1.1440280477246356, -1.0819976497855337, -0.9552574506425706, 0.16145626263998733, 0.007302046089461101, 1.2857158016022823, 0.8004022875524367, -0.44937072163015995, 0.6626778527108237, 0.19561339538225717, 1.4655885459341436, -1.014645449574916, 1.216969423139008, -0.22839092354690307, -0.90912777776976, -0.8115754731858936, 0.32917118918961263, -0.8155726663647872, -0.6797805890133132, -0.01537053421251505, -0.44825776286187813, 0.16076026953828143, 0.7847957215388878, -0.7052383981781809, -0.553915274570552, -0.03231973521074962, -0.46837085377201393, -0.18905149266164212, 0.7294069851441184, -0.8343016996340852, -0.24030672325257135, 0.7052896601894366, 0.9777292436431487, -1.0390845177204886, -0.6603864082802636, -0.6713595197031507, 0.5635383941058988, 1.083687492714712, -0.9909074854017432},
    {-0.05670926310790534, 0.05933276349444315, -1.2669704089985232, 0.2108421685182238, 0.035148943702547716, 0.5334125978519834, -1.0832941525043296, -0.5872876108217233, 0.7808407943069967, -0.13370605185524276, -1.6092308125823749, -0.30348064390262375, -1.62993187601737, 0.980341059154045, 0.5557426587684412, 1.088351712965559, 0.2701984018111359, 0.5976472401126284, 1.3493075110102475, 0.17527058592132236, 0.6156781649636388, 1.1270829337439157, 0.206920705824872, 1.2175523783639723, 0.6035873619852905, 1.284972002304583, -1.311882061616829, 0.11373384323189367, 1.1216719304828295, -0.8769687032664457, 1.2054620262504208, -0.8712821202211658, 0.6788723324358892, 0.686491062233086, 0.6511016401562364, 1.0489734888466289, -0.24076046397365763, 0.947476312280862, 0.2902113084914646, 0.7780038631457038, -0.7594167940043852, 0.9115406619162625, -0.4400234437860262, 0.1386942691781859, 0.22390860305649818, 1.1976175449974977, 1.0030799420427088, 0.6931760960913276, 0.4169333636424964, -0.6460581518259891, 0.7421017300853714, 0.4012860009484308, 0.27847705621238167, 0.3414069349996557, 0.12128267875378483, 1.1013442415053294, 0.9669479213639275, -0.29714678422222235, -1.0436370489686353, -0.3970901924905233, 0.11064767426768685, 0.891482805412074, 0.8354622061856788, -0.26431790110324654},
    {0.595748013715423, -0.558198995826705, -0.9634713045133713, -0.966090014678912, -1.2070046862173138, 0.6389880933658049, 0.8562456496729789, -0.7805435026498759, 0.44999854036758974, -0.26956643329376345, 0.42202749984126037, -0.6290541242806723, -0.878756946012382, -0.025477776476218676, 0.5177205271484, -0.9055126279417431, -0.24634057960222625, -0.3931245568287215, 0.290078392783989, 0.35458692352752674, -0.41164126186284117, -0.8835170885894796, -0.08277461643355656, 0.8817643516232568, -0.039705422152883176, 1.2355191159170178, 0.45626865676979206, 0.15071918381779184, -0.7074788824317894, -0.194697219830741, 0.10895189448006058, -0.44677356541294566, 0.241297767759711, -0.5508955241037583, 1.4479440871747304, -0.781433327159956, -0.571187331092857, 0.3573139486698044, 0.5019869267723743, -0.4630233854278319, 0.6633909617677842, 0.95318035958236, -1.079464309131248, 0.7936909619099197, 0.5115681011773134, 1.0283595727403751, 0.6836060630871855, 1.204502606515784, -0.49714848303867243, 1.1238113429263428, -0.6024924620827565, -0.193537729888461, 1.1166966098848814, -0.3870960791766187, -0.3526540112957777, 0.48449162497636256, 0.7445743217424325, -0.6711318558292222, -0.4677629905037913, -0.31167496789451393, -0.17868848318966737, -0.07737277511230506, 0.09815712612109342, 0.14798504395966802},
    {0.6352924086456655, -1.0952056584432281, 0.5842651303274662, -1.034416443195776, -1.3310618160046044, -0.13595665727797088, 0.28358409186664885, -0.6566391903584733, -1.0983299972494442, 0.9740826591047828, -0.777157763268456, 0.4499955187926639, 0.3413143197340471, 1.2616327040123059, 0.8082413336335459, -0.26514753576574085, -0.8601926061315588, -0.9194061793808336, 0.6049086340110271, 0.5418903998120731, 0.6301203850479767, -0.4590923546717573, -0.3812898885816171, -0.47796654285079565, 0.9706204702660244, 0.47966291519223064, -0.15822110148679536, 1.1749490446044777, 0.8589402600376385, 1.0667860048171842, 0.49433059321662187, 0.7378607857609538, 0.9262807758103612, 0.4223353407540056, 1.3625577763420225, -0.8424284578184645, -0.35418039900256065, -0.468285171636267, 1.0936915168255799, -1.2800304882598585, -0.8739263516465017, 0.21300468370792341, -0.7963976854032208, -0.02086201285016133, -0.004022598846656161, 0.8927911423172289, -0.5714851615161135, 0.7106954767149591, -0.3312078487392458, -0.7295690358861018, -0.09756042696202485, -0.18391898652832053, 0.47350960517890583, 0.19561536363028853, -0.9584257029306994, 1.2087859067972606, 0.9200286890701972, -1.010204584421568, -0.4666511232545188, -0.41985365945827163, -0.36008542111211356, -1.0525937085694463, 0.7655261728841638, 0.09639978554529217},
    {-0.38891313403471367, 1.0039024740889433, 0.18275335681083127, 1.0461636869370654, 0.4740303743469274, -1.2446402222768373, -0.5243371341664798, -0.6432116725276344, 0.9759699469900748, -0.42006182567055883, -0.15656439382291168, -0.10837252571439746, -0.7210006822778849, -0.1596423336791183, -0.6647813320712921, 1.0914648415507417, -0.22991444193531732, 0.01245403999689269, 0.39146527004802606, -0.4702636778800856, 0.1447535309614207, 0.7148667252773165, 0.31369001833609433, 0.20089830808555809, 1.405393998066163, 0.7755922313312087, -0.22223299565352717, -0.6636888742003066, 0.1425032839631413, -0.8809717287791256, -0.2343640690439656, 1.282455647654747, 0.8028346228059021, 0.3150377015321984, -0.047452251328626245, 0.3300280329288054, -0.7523222892483863, -0.2607521892897718, -0.18880000091229207, -1.4018793092925006, -0.8385648223455934, 0.41969578251729367, 0.5358933259447966, -0.4330833513005676, 0.602517254937468, -1.004060902120958, -0.22487226872656996, -0.4123719552751687, 0.3877732712291754, -0.06042419725131832, -0.6570957239906671, -1.3468983810007935, -0.9023955756181048, 0.31335393269543727, -0.9548787927535229, -1.2461056611641588, 0.029639075617901658, -0.6790740065992477, -0.35043646235367953, 1.2855677016515645, -0.6461071916176526, -0.13439762085306933, 1.311990019106171, 0.0444596762452182},
    {-0.529686240018604, 0.1238789177910099, -0.5540277447505287, 0.037087104097375756, -1.038875149570633, -0.4512440797922403, -0.008375185327308592, 1.1147423804308358, -0.9552933906791587, -0.134458866944043, 0.1981760187926274, -0.038752650933575786, -0.14885054790070892, 0.34804716364812704, -0.3121705904841523, 1.3830013387025692, -1.1255188666909932, -1.0205310947003352, -0.7683807588950017, -0.01667282897443264, 0.122953344370456, 0.9469419243864174, 0.5312388847989648, 0.43923272889398973, 0.9802206156143104, -1.1898612180239854, 0.08027621375687496, -0.12867439334317196, 0.16658812416212493, -1.344765045791117, 1.1033262027382567, 1.39078523291239, 0.7823802548523305, -0.24312835623520426, -0.25818995027423625, -1.1656122017960757, 0.6028577552148007, -0.20857652454594508, 1.2253699319287021, -1.3398880378091156, -0.7125641902664908, -1.138739654332863, -0.36790615310343644, 0.4200636561328149, 1.2461184620357377, 1.1146701138274908, -0.5424037703830538, -0.3885116391345097, -0.8492758335989501, -0.38817163853851006, 0.23419666684591992, -0.5474395009959747, 0.39818176988753073, -0.317723555862973, -0.18266778589316982, -0.9021884323974891, 0.5435341988522182, -0.022659565105902772, -0.6917945287353876, 1.1222326207227722, 0.059508375950428176, -1.1676182824870012, -0.3414079268790366, -0.46790531595295753},
    {-0.119238816234646, 0.006956883317182717, -0.024303773805310014, 0.6219929688139354, -0.8576221609177498, 1.2896743409626463, -0.8242422549586537, -0.23550314785131937, 0.6296793712077566, 0.8425539363898817, -0.6261023630168041, -0.6612227585225162, -0.5348680633824068, 0.9807379078425151, -0.03383979127335983, -0.6778239384678711, 0.6766416773135746, 0.5711478754961179, -0.6672906093295031, 0.8479785064054745, 0.6435115406936242, -0.687752090332035, -0.25495315993942463, 0.1056468659647831, 0.1857373755460223, 0.21425416181713153, -0.1291357580328297, -1.1086144844014927, -0.21859958458227016, -0.6587447016757964, -0.2626115087401673, 1.0298222570568203, -0.7070782387974487, -0.9699609730840661, -1.0736398508165221, -0.6957093469536989, 0.06477093444683342, -0.5918661020028546, 0.14367375288743078, 0.158188113477531, 1.3516378623249938, -0.7350135382117738, -0.355487512900419, 0.7961579073048376, 1.2668606981364534, 0.018162479559512407, 0.5627915591208027, 0.06601404461855484, 1.4446909164142918, -0.5483074626908644, 1.2817381627087552, 0.5380971798871562, -1.1241772460578376, 0.6584784772609668, 1.0267989852606794, 0.6559782449272362, -0.9114954149043193, -0.5845809906853414, -0.7795638166848345, -0.8939899338233332, -0.668875220916732, 0.8597801013269517, -0.4367207699491552, 0.19707857812819737},
    {-0.2784899579170662, -0.7427693658096964, 0.48895806026306393, 0.9218025331642935, -0.5497437203071776, -1.2446917025390494, 1.1687899821693262, 0.6214574701122354, 0.804046966932134, -0.5130242795198019, 1.0747241182846368, -0.09586378988054724, -1.4749601592963568, -0.9804029163399638, 0.7451120762850758, -0.5900475383465419, 0.36881259310347503, 0.8474426600826014, 0.17848408653042466, 0.7043413319088008, 0.07489982076954577, 1.5901683276810659, 0.7404237642807571, 0.19043334410231416, -0.3812180503606822, -0.23562751351768188, 0.7157190369638691, -0.8711069558462652, -0.08198121155945659, 0.6498002547842245, 0.12211518067299067, -0.5178104780411352, -0.0633787705673924, 0.5721667292850335, 0.2870936695844608, -0.18861758675176488, 0.5905800468026627, -0.10147763786042542, 0.416363008771377, 0.5652956355388692, -0.8037675869336663, 0.29029934796611184, 0.5606909849016715, 0.8447564679516949, -0.27317870101162556, -0.1427425159221147, -0.06642109737820731, 1.0559973618078513, 0.01148932964660802, -0.5938188711793524, -0.28416946147924765, -0.3641647304391781, -0.13317501270680793, 0.6398327948198737, -0.8719346582464961, -0.9263409099314075, -0.6079315196132984, -1.445439211515679, -1.2362728427294234, 0.3624414059387611, 0.6843928483448576, 0.8166312870171313, 1.069469064264207, -0.6647714525310396},
    {-0.9305686914240031, -0.6403444914185686, 0.9880814815584601, -1.5109174996847565, 0.8756723810611872, 1.2181735556105542, 0.8374150316625567, 0.6203423745191602, -0.7651093624246074, 1.0247840601504083, -0.2506386617962353, -1.4150959404477848, 0.5113488039969396, 0.0772110679655299, 0.6514988366709509, 1.741573684281407, 0.7270221348057939, 0.5166220293592267, -0.4597975471072892, 1.2175770108993358, 0.1207366197459342, -0.5199758112375468, -0.8025340488739295, -1.0151654640281145, -0.5495727301250166, -1.0985419169867932, -0.27464719037459945, 1.1147335464450208, -0.6966739644855325, -0.32393508702878254, 0.41351691404099505, 0.14928983713489674, 0.5018372832168522, -0.5946121070012697, 0.11455490759801883, -1.12784717062296, 1.0490857045522495, -0.5496949282733377, 0.9083121699369826, -1.120419932331816, 1.1321604709257487, -0.9911411863004513, -0.760846659980486, -0.2951040914144252, 0.8173606093945086, 0.1803632449486704, -0.7577630375414952, -0.3452784872092872, -0.12966212487189935, -0.18804460827650937, -0.5303801693456527, -0.017262997170113138, -0.6631722899940615, 1.5457304021167027, -0.7786229514245058, -0.5390660934132753, 0.9237316605972791, 0.3439176613025472, 0.9409184438483816, -0.10121651060206206, -0.4643595357285251, -0.7461625299838984, -1.3913967039371684, 0.09538473841890317},
    {-1.6140846215465958, 0.29380517283149515, 0.10157485848451381, -0.615080517752994, 0.40904057258236, -0.0801918955060113, 0.983535590520735, -0.6071399863185162, 0.9383700556135567, -0.11935358419529031, 0.8002043075469442, -0.929407925242979, -0.7032672772349704, 0.6894470380326991, 0.09565974523338848, 0.872005193143174, 1.168414508768195, -0.9377654399245084, -1.3641466557218265, -0.9427111006755914, 0.5043676342509518, 0.6222053288697617, -0.10926272984929274, 0.9207089538632546, -1.103037169120999, -1.0430663345952733, -0.888224851838244, 0.5552734829507394, -0.9437774597317357, -1.3818877169868395, -1.1359377878937933, 1.175876967091964, 0.2720546559321174, 0.11480971711791921, 0.19077670251842005, -0.928056922729927, 0.4346019221830297, 1.1183063014955401, -1.0063559538533082, 0.2638010356678506, 0.4397983704992661, 0.45114609052926696, -1.0708892345483196, -1.0641519456647481, -0.0015797251697707189, 0.34509016121092995, 0.03688447711729183, 0.9205935783871205, -1.016270372597792, -0.398595528885838, -0.8061933031676414, 0.6797418443159899, -1.1800165666926605, 0.8090976367746442, 0.3137457556936078, -0.37381838435620196, 0.6707639572055576, -0.3510098518558972, -0.5866027313112417, 0.3604635622486649, -0.42018645464906124, -0.1600799336415604, -1.2927244856865832, -0.5528666844575147},
    {-1.0433461647510374, -0.6440843875794675, 0.7543854380751848, -0.007376509427601776, 0.29028082193136956, 0.023709589078905528, 0.048291876300160574, -0.2119766083807478, -0.12434701173153911, -0.6138873788304167, 0.7536315832735084, -0.6296727716220872, -0.47420346378135325, 1.0125616606377197, 0.21892762619360293, 0.8723667125300374, -0.7154199854666846, -1.2948366542603205, -0.925401236095968, -0.866936293341262, -0.8493325792242384, 0.7913324211842812, -0.1707065393466278, -1.0393602337567447, -0.7635684489919087, 0.4438708758582961, 0.17740742868786458, 1.3728875192020191, -1.1610199975163382, -0.02808329618337285, -1.0602803931623714, 0.765766386056833, 0.5499524096103771, 1.056613219723828, -1.1903922130876488, -0.804045300993255, 1.0190842459346892, 0.24111951163018275, -0.9240321527769517, 0.5640603727693289, -1.0730918825763915, 0.545474493617395, -0.8537152758380171, 0.7960983628671542, 0.06859104863541235, 0.9194501745357629, -1.0537414610240967, -0.8445777726825378, -0.8895889183701347, -0.22633165586511447, -1.4529950811543615, -0.358011841958872, 1.0456050189466328, 0.6605947167446196, -0.3400683048605741, 0.4976083690119778, 1.0008520853002556, -1.0742250691191972, -0.4693318544064369, -0.8813446130203032, -0.731395200521974, -0.30145092833814163, -1.08589056217472, -0.06969153133172636},
    {0.28640743155228765, -1.1000674963337038, 1.0762559365840358, -0.8349346804167246, -0.3491165525647145, 0.09121252909817605, -0.14184725872634424, 1.0093822640318777, 1.0668980415090663, 0.8339529186434688, -1.1422997438817764, -1.2101342359817573, -0.027686896408577872, -0.5045529119769834, 0.32143731950465687, 1.733331059373032, 0.7731008601761615, 0.6736151601920062, -1.279264041201505, 1.0225542151849423, -0.8109337877360887, -0.1284612821511156, 1.006117657452152, -0.12920218655715254, -0.03732410669816378, -0.5022636923720188, 0.026285199866747298, 0.17513129376393005, -0.665614586466503, -1.3376435242568425, -0.5847389154411937, 0.6699634611171563, -0.7712564090847166, 0.5205000099154842, 0.3099707360425931, -0.3728279683389843, 1.3765121986538724, 0.9671113933864268, -0.8811126587819552, -0.7160773674329367, 0.36626831999107445, -0.4520351008959259, 0.21621419050255006, 0.21446634956906746, -0.4078323146657998, -0.18986055834815402, -1.1795057161912197, 0.6304587858621856, 0.4261365488143292, -1.3364792364075433, -0.0320998201616322, 1.3033170089672335, 0.04588983622503799, 0.9112624394757802, -0.36856463272172574, 1.0852362219727627, -0.3277630320920351, 0.7174823637507841, 0.8557474713889196, 0.46020877914296515, -1.1904135632810633, 0.906371930453826, 0.34181432284434426, 1.0555212454979035},
    {-0.8645942229229482, -0.5268993197315883, -0.888227946269821, -0.8966573763148987, -0.6113207884652032, 0.7517128920781705, -0.2909407396194487, 1.0850764168802274, -1.087290404207721, 0.9603843627676137, -1.0511287689124347, -0.7826673452182117, -0.008992873807248423, -0.6056355402465178, 1.0947172685427726, 0.7950452739029508, 0.4997045251943233, 0.4284083669184532, -1.2855505115366201, -0.7446041859098149, 0.5426941531503924, 0.5267972394813619, 0.2024597601363815, -0.07088929209140858, 0.144035332667382, -0.552453367924605, 1.0459187875720515, 0.955716668081341, 0.16489654716211538, -1.3084136779881586, 0.3555442175625524, 0.9162811931081676, 0.9847486087177225, 0.001662340197330147, -0.7596523187535777, -0.2614139677959058, 1.3682088090725084, 0.4290716784316169, -0.4315784168861233, 0.2768736100446219, 0.19484723133710655, -0.7729257668900485, -0.4001980367641542, -0.8998662905186348, -0.012553566953268256, -0.12719424510497662, -0.7683407593205192, -1.0095147644345503, 1.1142589423761944, -1.1946764665241338, -0.16722801224383121, 0.6363184493983259, 0.47131039108960193, -0.3638723010227989, 0.9133180356235272, 0.5936394661276563, 0.6761698110884262, 0.11869927648321008, 0.9266793980081847, -0.7622868472079992, -0.9567990814602227, -0.9914245623469482, 0.6072800167756779, -0.9208397391441056},
    {-0.44256182434875824, 1.2152031987988636, 0.19916335740638913, 0.3509338060551265, 0.6227413580692497, 0.44793924387064954, 1.0149214992659985, 0.41736150214237255, 1.3501676100210696, -0.30139597922262784, 0.5660571102266663, 0.15180432736204896, -0.7588216527463468, 0.6544605817034935, 0.3163450353823484, -0.6070753222832778, 0.9830363173068937, -0.49234379609422985, -0.2324327637168106, 0.1314576118789765, -1.0124389733382362, 0.05116672158559406, 0.8225957430540999, 0.35813220092941084, 0.27381110629427313, 0.08081514076941097, 0.6436860500525878, -0.4015071209938876, -0.9337998999575897, -0.9760923669694178, -0.010106351748907911, -1.0011750336887075, -0.8651756553745391, -0.9463916702691682, 1.0551268309054649, -0.7003135880181321, 1.1087938563638868, -0.8663712316483254, 0.36981299712996374, 0.011662028581652275, 0.3636270397120699, 1.1326174983957316, 0.9899339849417643, -0.16294103254649348, 0.5935640590531023, -1.0861459248167862, -1.1465095609803164, -0.861541846528565, 0.541574235364049, 0.4134049714303415, 0.9116197661968369, -0.3706467068955367, -0.6368503532935236, -0.24702266083493313, 0.7074448359630036, 0.7383315117385827, -0.566389931444732, 0.4911714144798088, 0.14975040562997224, 0.8039778718943599, -0.3123065245846761, -0.008516877381405604, -1.1132392762461472, 0.6938238729597195},
    {0.2593336714895929, -0.5429420252537495, 0.5596246820812636, -1.2274341332209195, -0.5515922643352796, 0.7491297431495645, 0.16527162241761337, 0.531289358330817, 0.03840077788095329, -0.9400681503154474, -0.3360411840816722, -0.7136724315951165, 0.9549631072915038, -1.0432519182976088, -0.041360432282994235, -0.04473162111212358, 0.07691844997739375, -0.08150269129942521, -0.7319130914838379, 0.6572879670388768, -0.5486276173873492, -1.3201459373404112, 0.806085880681679, 0.09665248705648012, 1.0047344077636953, -1.4793333393992856, 1.010611157470147, -0.9258025518838129, -0.5893132092078475, 0.6655654180191495, -0.16043901207358252, -0.9031885560854814, -1.2430789572970677, -0.9181686492772787, -1.0915639052040937, -0.4784837773218024, 0.9397754077516599, -0.42804170276608605, 0.9859869053074068, -0.9687596096903383, 0.8929299099429823, -0.6120757702320536, 0.6630603665012479, -0.5244429283291305, 0.014223533254939521, -0.11161569575395129, 0.5028026821735331, -0.25489085858380806, -0.23448891050283446, -0.5942331926233518, -0.8347203314265047, 1.1127235822892056, 0.6794051723062177, 0.2640905753134886, -1.1856228691136739, -1.1398672602149107, 0.005350872687530347, 0.06519405201405304, 1.2133716572771152, -0.80730588812585, 0.4862441550981227, -0.3682573610667181, 0.946239573580235, 0.7797340851634702},
    {-0.5637308847498775, -0.39137405554209337, 0.4871025217804473, -0.16729788072953783, -0.7036645686596691, -0.9962024377662059, -0.12811686484864018, -0.08802621809212641, 0.9977603616936629, -1.0390884879320377, 0.5246749066381574, -0.05172565197744221, 0.13508248602164247, 0.16911499682064604, 0.9404697735755394, 1.3225734421756612, 0.35321553268378586, 0.9066602684175524, -0.6473806065445115, -0.1494090267223782, 0.6244126735344228, -1.223810872835039, -0.38623161545000945, 0.6872551141571172, 0.19740532316617126, -0.5401296240271739, -0.34289038044439296, 1.033550664906046, 0.6281827919859089, 0.38946424320526635, 0.6549919775293537, 0.7090820172237188, -0.8256684154187862, -0.5449638877208022, -0.1770589638825296, 0.39712094292729855, -0.601632389300876, 0.471517500049104, -0.6834518280528825, -0.6174202883428805, -0.20124494040891636, -0.8396139292233804, 0.7222290405919166, -1.1644596903503903, 0.48171462822350575, -0.49486233094891696, -1.0981413501819106, 0.5799853485033718, 0.18147686755338432, -0.9346450962751685, 0.2991881191258574, -0.3847557270682036, -0.6884226715175461, 1.324627051246526, -1.0413581852491445, -0.31877205137354464, 0.11167534889965204, 1.2700392809464172, -0.4495583607267999, -0.5957715630293273, 0.23450682667035025, -0.38253869746463465, -1.4318977666400505, 0.7657233109492833},
    {0.6102505455571002, -0.8044698785886988, 1.2533673359475355, -0.48676274079563797, 0.7990697809531051, 0.2724151958267137, -0.9259956236360476, 0.09114798766091185, 0.4920074279652462, 0.9749137000899095, -0.5900344593843475, -0.22117277896649057, 1.2744476667445894, -0.936809539467269, -0.36414195188071247, 1.3008333081172507, -0.9419951736012557, -0.43025516050727314, -1.4962738242813853, 0.9411557060412078, -0.8583912914321702, 0.20806657522477215, -0.26236926294852864, -0.5507105297580837, -0.006938002538493354, -1.5657109966782554, -0.6589811800360652, 0.8654331521199857, -0.5898139215544187, 0.39999758846020106, -1.1458177069923234, 0.5350154464390385, 0.7133767917747679, 0.23438726669864, -0.5478709916993977, -1.3432079484354944, -0.6011549323121083, 1.267571383847684, -1.265398114774605, -0.8469169778992697, -0.2835269760426074, -0.9463640551941659, -0.34622907342769765, -0.767206893300484, 0.33437463658171296, 0.5652746635090147, -0.19255390982136483, 0.15815477718448476, 0.24580009394534175, -0.15730814491128323, 0.06821040057442966, 0.2451431958147048, -0.012622962675007881, 1.264357855779417, 0.5617171060928499, -0.9393835845825902, 0.875145721910323, 0.5600984206288989, 1.2730257816474866, 0.6765562015314139, 0.5835863768363432, -0.6131375632243855, -0.7810736734272354, -1.2184909793349965},
    {1.0371922234405695, 0.7642886698316713, 0.16857997054923726, -0.4382555277071594, -0.12973187088760257, 0.3756410979977142, -0.32950516268192714, 1.2174179357698356, -0.5642487170917639, 0.5039591283553249, 0.08033424845449007, 0.9163164138203321, 0.25840790975307154, 0.5223488578553476, -0.32362675741370506, 1.35198776440666, -0.5954507816449639, 0.3636494273169033, -1.1431227000091995, -0.11121845228579891, -0.34227420459752533, -1.255471450387393, -1.002042826381481, -0.7731766280820287, -0.5959802657528378, -1.1934573579174048, 1.1622132240605305, 1.0778215611294357, -1.4142960525488983, -0.5875227283162082, 0.0025926878847811912, 0.9294879613394627, -0.153084253061008, 0.8997000844145975, -0.7216540172284944, -1.3360556822511567, -0.4513203351987155, 0.97177358141625, 0.6895628884858428, -0.12168704534734108, 0.5546198869527761, -0.8242824961420513, 0.10516976487767107, -0.31610271194272765, 0.025351590548293827, -0.9079748368683754, 0.0025036830279097995, -0.4311191519505474, -0.6572826201085877, -0.702809242180084, 1.0533214376824958, 0.5922468080427955, -0.7110436206778776, -0.44492586236372106, 0.23820583547100194, -0.45457410980111307, 0.10298722593257684, 0.7717502612410405, 1.3136573329016177, -0.6270544155742005, -0.49381859965904307, 0.2838524179131259, -1.2786266736828886, -0.46960919375863897},
    {0.8509526883069294, 1.0943491429858487, 0.3245798877101967, 0.019899299898274922, -0.4025550604420367, 0.22499349206015154, -0.8791904551398423, -0.7962686456272005, 0.5206142125814793, 1.2803574860225264, 1.0228929792457422, 0.9264402947761304, 1.608890660757789, -1.3388721882574957, -1.0988360483238033, 1.0154610218019169, -0.21551829302943604, 0.1383635588792972, -0.22274824710063598, -0.5132246915440394, 0.2749964438078814, -1.6192627057550253, 0.5076183753524282, -1.29200771164534, -0.2731751053605948, 0.10772949441764872, -0.5068469349517936, 0.825039637677668, -0.8673228314248741, -0.08186526936418645, -0.5869690071714, 0.819429253047228, 0.22201108149325482, -0.47862979816383233, 0.6545939596298809, -0.7984083716732782, 0.4121034334886042, 0.6711976447669421, -0.2791853453044933, -0.1324308339830792, 0.7680800315174374, 0.39787222903960384, 0.4440458037591788, 0.9791439669991399, 1.3994739917024392, -1.3360089603660479, 0.0678521700077011, -0.9039998995680638, 0.4786586695087247, -0.15836001917604378, 1.4961735966529264, 1.0615735848659793, 0.7426351223102645, 0.7150003418874047, -0.5849090804172274, 0.07660960953756558, 0.7972828032539993, -0.5579356770951724, 1.6019147769681528, 0.30223955839629696, 0.7898634939763879, -1.1539428386857764, 0.06513297377183512, -1.0823738628400825},
    {1.4961444288761876, -0.008563405030643114, -0.5658756028512406, -0.014228494146513448, 0.6618689756921339, 0.4257045364406645, -1.1946461043251517, 1.6680714355045823, -0.018274177418168357, 0.32283998601288033, -0.19345722941151205, -0.11336088647253229, 0.5795868982854961, -0.6951262416915872, 0.6489145548675226, 1.5625710508187987, 1.3346920426254214, 0.995808928139455, -1.1652769338581626, 0.7343360519835009, -1.3245393961718577, 0.16809116499883614, -0.16671466774193816, -1.0147346846835745, -0.10261045327034549, 0.4885719754296092, -0.9478700464048662, -0.40479609132664696, 0.18385576360907546, -0.910677328613209, -1.2967673946126774, -0.7532237976941708, 0.7577299597893877, -0.4870418357728153, -0.3522021896266798, -0.4728975841539534, -0.6837876561747415, 1.1153121203768748, 0.7254255502654534, 0.3345710624038931, -0.30884752972981794, 0.8114303931303176, -0.5524224789848386, 0.03783864233183086, -0.7516019469802473, -0.738468577359821, 0.7860775763485882, 0.7503550248825912, -0.05558096393044241, -0.7192907294486486, -0.3779977085519015, 0.4643081916448413, 0.6430377971714856, 1.2585735817485384, -0.3254720874505557, -0.5075990731284795, -0.9014062476906771, 1.7517080048006564, 0.9103384093631048, -0.4722217998770727, -0.4906546779426142, 0.05533632390298009, -1.3747868324389207, -1.2248973466659432},
    {1.9107399673656562, -0.6582901418449639, 1.484025672728636, 0.4057041146256931, 0.06411620586225943, 0.061454546711115624, 0.32403306191714143, -0.06478263639764217, 0.6139794695436697, 1.3957517620889617, 0.18409576723070292, 0.6112768624164685, 1.7009358167577848, 0.6524712386766833, -1.0803308507549758, 0.02916000033170571, 0.9948582979010961, 0.14681254939531807, -0.3923056269258928, 0.9716091616460618, -0.8842237695878763, -1.717270582274155, 0.506435017720646, 0.7920227120014861, 0.276621929797757, -0.9434932695973546, -0.30103204068781464, -0.17282266675658287, -0.15983460272254255, 1.1104126676473367, 0.3762719240511069, 0.011559546992633778, -0.22778310316623182, -0.06766354316086126, -1.030507877523967, 0.7832957560204893, -0.8666685701809828, -0.4694116013287717, -0.6713941187133959, -0.9739098985577457, 1.1824791145869202, 0.7572390519728315, -0.9219638150169149, 1.0160320661153883, 1.23795352183972, 0.7576172798926265, 0.1294745918130815, -0.19818167672137574, 0.5532085432415911, 1.2517385129923462, -0.39403775097290084, -0.24566797580123517, -0.5652181678233026, -0.29463950255195276, -1.090735498588545, -0.975554329420244, 0.6311579149977202, 1.7139601050801188, -0.41861536152079426, 0.9643303350004395, 0.5108396029405873, 0.9135176840437045, -0.36587995695097214, -1.0025858934786833},
    {-0.19049405546458073, 0.825990352595272, 0.9795877630951432, 0.14191458660551262, 0.5442242316186592, -1.2565096570442262, 0.2468129169150679, 1.4434292581805344, 0.5937850135992, 1.1431012235666125, 1.2221919894289752, 0.6769925248679508, 1.611560635421531, -0.659715900968775, -1.4003580072967536, 1.4653989415475837, 0.7327986693895021, 0.8010927964449366, -1.7861150762883513, 0.46510636945617717, -0.28780023859348824, -1.5885608958835824, -1.2014640795103413, -0.4606242085085426, -0.5338931470854371, -1.628340351308845, 1.176227409039469, -0.5509748522690304, -0.22214126568610698, 0.3716042750323307, -1.3593091558953443, 0.2539216012110854, 0.6917662719515882, 0.36697266461232597, -0.9574474060027824, -0.5444865427280945, -0.53919379249081, -0.38486995909337063, -0.7384057319713845, -0.574934528524481, -0.218621746111824, 0.3946115390806828, -0.27194978389336427, -0.4973578778007241, 0.13449348557423493, -0.6590641053478268, 0.4083457200618067, -1.0241854896070055, 0.7979768953666238, -0.25535595550263496, 1.171928208012742, -0.5035188478382592, 0.2771338061709554, 0.1755550937707553, -0.27289153154540075, 0.02839018549429128, -0.27946198397822697, 1.4647061244345807, 1.4793276127472943, 0.4565860149090772, -0.8376143363613426, 0.17294988987160317, 0.5230336688175635, 0.04860076998239433},
    {1.616913526205935, -0.9272348137790403, 0.8375867735263257, 0.8150462749213304, -0.22367971466639353, -0.6914964847299875, 0.42823819674405916, -0.05744082304997877, -0.7339912922595114, -0.9786860801954798, 0.9948261507017737, -0.6344902397959451, 1.0470902494403358, -0.5046094421390187, 0.12635749864039422, -0.44946839065056576, 0.3081699613665029, 0.9766469619145453, -1.1471343582016584, 0.12331268255587077, -0.30942046284280017, 0.15271177039713105, 0.44317726925367623, 0.6708590247418568, 0.27545279661410077, -1.2763708505154945, -0.8490813028855805, 0.1744790860146656, -0.2890399389860016, 0.052588817256118296, 0.11425789198142695, -0.4010698019304603, -0.1768239674239789, 0.8113606368271549, -0.4521967387959644, 0.9788725100221378, 0.07617467169941092, 0.47403583287586554, 0.06960478130291244, -0.3593663654516307, -0.9201572560175116, 1.174808899561206, -0.3217672294243376, 0.8340962313293241, 0.31782689540439324, -1.2812557496608314, 0.6621775192352266, 0.5084039955904093, 0.43071399119527753, -0.685624831236708, -0.031563360368987416, 0.9465352091956073, -0.12486498820944447, 0.9132876330036837, -1.2623212587068213, 0.22920020726003396, -0.9392180756516035, 1.1654480806850047, 1.061292417664085, -0.02064798983392136, 0.044039229597901304, -0.3957496681993432, -1.0767451126109393, 0.4976340293136226},
    {0.24785650911468482, 0.06397590527655761, 1.0362291978267995, -1.1572398911263808, 0.9157082019052717, 0.4471012470939957, 0.5187610894813008, 0.8987741264128806, 0.1539894157524825, -0.1304641815891476, -0.5693754698056395, 0.6155485577647741, 0.16483862310856837, -0.26355138078712076, -0.5719787744079021, 0.05524025445054176, -0.6848420823299031, -0.2140549418090811, -0.9127204284411655, 0.4074740015864867, -0.6185018615067872, -1.3831297519834127, 0.9730462029832975, -1.2455404263763445, 0.6110246829845488, 0.1367985311791665, 1.0520095890529693, -1.0934511450927655, -0.3955053304130861, -1.0218682026554036, -0.7250411713784323, -0.5325250971518753, -0.6190578115511544, 0.5937498411995553, -0.7071112015443596, -0.18803289127000172, -0.42742227113087666, 0.8147943751979979, -0.32477266918844355, 0.35274024513195934, -0.588747778685474, -0.5790681662322901, 0.0805907504986864, -1.0601642427198028, 1.213915322309507, -1.2965060090782337, 0.10920692090872099, 0.39040589801811193, -0.052883790953778494, -0.5840657189743615, 1.3794456202744065, 0.4107836674375751, 0.780059905772811, 0.9104107862035449, -1.3748217300075367, -0.3997988615976897, 0.46424750421848904, 0.8734175660345233, 1.2589362751598048, 1.0806214926225264, -0.010305490859497533, 0.5239945428005708, -0.5878928959920201, -0.38264981387009384},
    {0.39226272812717594, -0.5498171825449659, 1.1692945978463354, -0.1503950006144668, -0.34407070815119467, -0.39701983603347324, 0.6036700561747638, 1.099356917415912, 0.4184725638283015, 0.3300930444847446, -0.8916646363622089, -1.083282328776469, 0.723539815401976, -0.6029479189792485, -0.10363478296695375, 0.5665472448996153, 0.0014395752302442447, 0.8571776975998242, -1.0130805454633323, 0.41515813580404337, -0.3082671224154088, -0.7171506880864694, 0.199405845153692, -0.010489059430661784, 0.6325510021530064, -0.9309623159502551, -0.3709430661155097, -0.8040762979553487, 0.9825076825861857, 0.15966007138482227, -0.8466668470080478, 0.42155388827097884, -1.0190207255161998, -1.031210241489078, 0.7330028525427613, 0.7277960885665669, 0.6291287403688668, -0.8049973896099843, 0.8960850515633887, -0.9480097008930871, 0.6419174269637409, 0.2627106522015593, -0.8407325416534469, -0.4405796270446877, 1.4396193087157685, -0.11322543879073484, 0.3779371122317518, -0.9147144254390841, -0.5658481781971129, 0.5736792560086171, 0.15354772470123987, 0.491033718226932, -0.257572141037653, 1.164693843830667, 0.513017024157068, -0.5476681538371192, -0.07824808593689843, 0.09543550263857754, -0.44842039567347536, -1.0223960165575317, -0.7184003929330228, 0.15735489945613854, -1.27348947085019, -1.2257627344449507},
    {-0.4563161565528593, -0.7459974088847893, -0.35411036276906216, -1.6579254114835218, 0.2710336986603278, -1.2099476695775793, 0.39543316592569916, 1.1514258170855225, -0.20000844953885913, -1.2952555685451628, -1.1116212558502998, -0.43004341603644763, 0.6006217136962628, -0.5867227156733965, -0.2878602049595914, 0.6271390012945046, 0.8639069994941508, -0.8674266698372911, -1.2891155150589286, -0.22392411343443427, -0.9598639478378337, -1.6913371416429999, 1.0329900580948408, 0.5823180024693037, -0.44607153797377846, -0.7534978953209361, 1.0474570995953536, -0.5064001185065301, -0.3906405448044975, 0.39182174978583906, -1.7602350820362251, -0.11776338166355206, -1.7997822912977857, -0.5850264561817246, 0.189383774779179, -1.2138846439802402, -1.1083596112487564, -1.2321331976196632, 0.038530025599311096, 0.7087792984238706, -1.066685162769445, 0.21601350677451844, -1.1931166364395187, -0.58086974913857, 0.13373322328871504, -0.04919683949816335, -0.6485979917338573, -0.27094227594360665, 0.49196811210535973, -0.22301507307180377, -0.16667904999467967, -0.2898425503743431, -0.3180174336309346, -1.020944435858296, 0.7074772201061506, -1.0474442740174017, -0.1052388469882264, 0.843496002031366, -0.019742837194048554, 0.5806186442181749, 0.18734886162101114, 0.5507251430163248, -0.2021358865676576, -0.7837222201191871},
    {1.1045329456894577, 0.5109857969982371, 0.725335915742769, -0.15334496724758767, -0.6880776608647515, 0.3838650849733477, 1.0382623437639273, 0.9820851357133182, 0.3836844310561255, -0.5851807252873172, -0.5358449976400121, -1.4465194913994726, 0.2537187765581416, -0.7835813168916607, 0.8754776136255278, 0.6614559722066036, -0.6464375215061492, 0.4349290028011446, -0.35179898589543845, 0.7516257348873738, 0.6278351514094733, -1.3408368013249246, -0.587239526615498, -0.0030809773842039243, -0.8466015585786898, -1.3615540893189853, 0.9723841528960379, -1.1779216137992337, 0.8672667992624019, 0.8715660489881406, 0.2570121779064366, -0.3037401702605756, -0.5801081897225248, 0.6496284766731752, -1.0797272834178075, 0.7122513568239853, 0.9667730571769602, -0.47109788238119576, 0.7666922442267713, -0.7477280869888219, 0.4878686290467452, 0.3217854458507351, -1.1141099602726652, 0.8186364924425162, 0.8877867208588068, -0.14539400451986056, -1.0879855129355258, 0.1838765560086475, 0.08470669349313195, 0.08011006549833892, 0.2462728647742248, 0.9778201616846011, -1.3586447638114016, -0.6194418177377856, -1.0282854701631596, -0.06933829081803349, 0.2595250038469478, -0.19197046352488517, -0.8232467550885463, 0.18943971238679208, -1.0066428901226034, 0.7823549242305432, -0.2881602730791633, -0.2756274016172196},
    {1.337443275150165, 0.8935804614275031, -0.6474897185495853, -1.3601027896812612, 0.6244141377758863, -0.8309923336179624, -0.8874267880426869, 0.8246093564227527, -0.3941694740406446, -0.37788588601279455, -0.830175696089984, -0.6239314292913094, -0.22174499768352637, 0.5025892103905971, 0.47883804257852913, -1.2230306705105065, 0.6745223915547189, -0.3969199691391112, -0.6399991176238324, -0.9294514832952643, 0.7933605007663964, -0.2677154985538802, -0.23537746084743283, 1.0106026748338215, -0.37296329949457724, -0.3252532917375082, 0.6250882751167984, -1.4790641086621152, 0.5904943544861332, -0.1988352263825013, -0.9953226724606277, -0.532698571297988, -0.2622935830792656, 0.9938906780613582, -1.2626384280926248, -1.1115577808797372, 0.34666607099581287, -0.3666843250562233, -0.32140407836239887, 0.9896098885206508, -0.2746329417244043, 0.5107355094570546, 0.10704734046679003, -0.06662501022234653, -0.9745313063342982, 0.29907172547671934, -0.5805331133833745, -0.33740870826263114, 0.7869147989646937, 1.2034845040749607, 0.05277992475463848, 0.4002085055183867, -0.7409165214205518, -0.6355998548336866, 0.7714800012890685, -0.7684116934239904, 0.4963980049531303, -0.9873327135698317, -0.7248189847587397, -0.0015539302446869849, 0.6864826000070933, 0.9716626392703094, 0.6956603809899592, -0.6760936636678395},
    {-0.3255295241524072, -0.21949669737702146, 0.9264231895080824, 0.15058207514767113, 0.026872610038950973, -1.3531984386563258, 0.434263352492008, -0.0742826682570784, 0.8001489643036307, -1.3904704444701617, 0.7612660492555179, -0.19812444782108443, 0.8828495526960404, -0.9335616026222705, -0.6334154190109205, -1.0136632986247645, -0.4895137264513254, 0.24310933528791073, 0.9126199380579716, 0.34824891749207093, 0.1467971030582151, -0.36748354372748765, -0.3328668518133086, -0.38437931849570217, -0.5525615710614737, 0.7875199575508055, -0.020770535851708447, 0.7278001723795772, -0.8181042814297054, -0.17981748756620952, 0.06793610458523644, 0.942504335388447, -1.4861574268938715, 0.6695859593583668, -0.8004562104724708, 0.29667857137749315, -0.8087118001810728, 0.09015067533552584, 0.4512512731926235, 0.9360893846879885, 0.5476343159979796, 0.22121062763419913, -0.15741090588938578, 0.6533520847769921, 0.42444100132945495, 0.13134651532450978, -0.4395337353528682, -0.07989074076407801, 0.7733212412747752, 0.9082840814539156, 0.8809375132430616, -0.8207037631798739, -0.5896202743015002, -0.2803201886585666, 0.8303193477666684, -0.15268835046458526, -0.454700028032702, 0.5761490345393382, 0.637740402294909, -0.6571379899693487, 0.05068602935613013, -0.7422668036054699, 1.0799727124228944, -0.08232857750036189},
    {-0.09053533930145498, -0.5402336154994337, -1.0188584150319584, -0.8537749136790909, 0.040304814801372935, 0.11007167583326162, -0.23100279862189368, -0.562528587974857, -0.2394114716816441, -0.28951906241902603, 0.9861842122907682, -0.49267531909997997, 0.8898648950758925, -1.3736669437928177, 0.15926111506107196, -0.22274404641023768, 1.2097208449891566, -0.9926201435861647, 0.8831332920639404, 0.36486753015477585, 0.2603485664730222, -0.3335306752684815, -0.564952200819798, -0.6860281209489885, -0.7989589589017541, -0.16372409907852303, 0.5579467777643885, -0.6229218705841538, 0.6254911870004226, 1.1634857270861299, 0.3653964585724392, 0.5343889941179863, 0.824122580894027, -0.7899886611338142, 0.8816035441569694, 0.32434711918699616, 0.3478804599054887, -0.22193149163016837, 0.17827720458923826, 0.6376692876297617, 0.02018975210072603, -0.5585190135673799, -1.0764965101468846, -0.17684928509447734, 0.9422558539766135, 0.33359053878800715, 1.0614723328530487, -0.6446886976586099, 0.8608001911579116, 0.26813837284842323, 0.8426427521530743, -0.3262578121054967, 0.45713087724943746, 1.1712226998277047, -0.4925053514544158, -0.5173474170598359, 0.4628720219254408, 0.8627970795778725, -0.8312543176823199, -0.43673855036206516, 0.19747566179002887, -0.3108873523007876, -0.8178990274267771, 0.5783611001936153},
    {-0.9384753127420757, 0.5201637659159547, -0.5473389399797961, 0.522746284416504, -0.07307238369356939, 1.170769335617524, -0.7835187180473706, 1.1494811643296363, 0.7653793747813065, -0.8563368256998743, -1.1061580105875173, -0.17387091687240624, -0.6605619183496884, -0.45622157188247703, -1.0982140972710621, 0.06550641557337537, -0.23281159701979476, 0.6025935866239246, -0.6639632136014747, 0.2805595831758115, 0.3955460391831946, -0.612759908208432, 0.9810733411349926, 0.6753181918189609, -0.6643099544891401, -0.6198814244458334, 0.02886999596344962, -0.11907406478780978, 1.0858913614582708, 0.22382424830828643, 0.2982052934433447, 0.4790572461497108, -1.1987545868351301, -0.8696656528158571, 0.5988728543373812, 1.0425606992122294, 0.7347271730139048, -0.5585371523148748, -1.0872750866109466, 0.6235396341689253, 1.2809190651761622, -0.8658246186409266, 0.5702002038579462, -1.2532164944064061, -1.075886176975883, -0.4344472807698113, -0.4290537375719141, -1.068292323847665, 0.8187081401854317, 0.19921537542137097, 0.0334540409022573, -0.10863572489865281, -0.3232336186753903, -0.5773975232668904, 0.053897462877947895, -0.4126871365112975, -0.04871407548727128, -0.9150879664612294, 1.1884039280728331, -0.896434601262346, 0.3118689493932392, 0.12287846087146365, 0.598220846038337, -0.032986425706466774},
    {0.17570882970792187, -0.547684781245042, 0.30757401791895433, -0.5435452510492245, -0.03154641129834539, -0.6830367549896895, -0.41877918275118964, 0.4048279511087413, 0.506165730909671, -1.3255716639998911, 0.5927913107064827, -1.219460202977768, 0.6200008511553614, 0.8431426727683685, 0.2962291980663051, -0.3821903633555408, 0.8991994341996201, 0.429760114223211, -0.570413254960279, 1.0964386809118407, -0.5719143795763978, 0.032349855605328, -0.7184523160249188, 0.28531850185085395, -0.6056851027424145, 0.4103009961664417, 0.42866507040835194, -0.3260394934350626, 0.15369403882764296, -0.13543777383511468, 0.9708810549838495, 0.9925989266960263, 0.8589821298696912, -0.38297691242520904, -0.5213149054531332, -0.3748415319514134, 0.862760228443997, -0.12250715988564313, -0.12897119186556838, -0.32757958845066343, -1.0428698968658623, -0.8604192800887972, -1.0481350259028135, 0.368150761902291, -0.9748163428215451, 0.560182101202536, 0.2042476504958776, -0.7870606520084151, -0.9001871061353913, 0.13584037406628618, -0.4281892070440267, 1.1630768817229902, 0.5156719902006851, -0.258740926823255, -0.18686113915921623, 1.1629750126976566, -0.3323139854570848, 0.4395202582158419, 0.30313751161127617, -0.28108640284372005, 0.564526769406175, 0.20333419077985765, -1.2007661547217607, 0.3794581799160208},
    {-0.5753387863064445, 0.6451878023321321, 0.7322626309084155, -0.6118638266874549, 0.7299897891760867, -0.5528940066270904, -1.1303539269672527, 1.0675184907749147, -0.8072612667833926, -0.6143207697819925, -1.1304557823051027, 0.5080286145163495, -0.8558126989460567, 0.7852298182361315, -0.8844252968575567, -0.14746998003931647, -1.331270104333059, -0.24649166361782532, -0.003866886501630062, -0.8238224414793035, -0.059569077227772736, -0.9084197247014103, 1.1021823094992047, -1.0125035368184203, -1.137424868970627, -0.2548983204253974, -0.0179087039374545, -0.9470423683188861, 0.7440216071782136, 0.4180618924400142, -0.6326024712519548, 0.8107050988987224, 0.16006013260133634, 0.30624602708253357, -0.792048202283819, 0.32871373950412025, -0.12514630011035258, 0.3547004108612444, 0.7250525895930887, -0.5904448802697064, -0.4349976329342204, -0.6834439914749989, -0.4032262318424124, -1.3645812586715866, 0.21864114104342114, 0.9576392706533223, -0.8898517146361905, -0.6807549556179622, 0.5549199494381537, 0.5786624483202016, -0.5214900280701932, 1.2539322749346322, 0.9741980436273737, -0.6956686056038351, -0.956010910113105, 0.2879951100630515, 0.15046935823173307, -0.43591201617279246, 0.17907661766925878, 0.8959763334656902, -0.6946057195381721, 1.0550877063535757, -0.06250222936616152, -0.7662441098573369},
    {0.4874549956475893, 0.44866965008478116, -0.030380700272605015, -0.7675436959552305, 0.6995022536695698, -0.1980471824428206, 0.5896921629664882, -0.19511276822460796, -0.9247786338348032, -0.7328837302795098, 0.12136926248570562, -0.6758333279388536, -0.40331915227010995, 0.2773935700171431, -0.1921567725477839, 1.0916410872010904, -0.2092217436414933, -0.4792037867520241, 0.4422850605199924, 0.5921714393661072, 0.9408647411699782, -0.5620472174955574, -0.34617857354007187, -0.3609893059485636, 0.7970233287350613, 0.6320260870442986, -0.959315842775442, 0.06600397159060073, -0.3665812659356673, 0.8681902372567134, -1.205589049872479, 0.6021125075450552, -0.42182105599268227, -0.9278974557117544, -0.5083307100383249, -0.8145429074711108, -0.11139077929591192, -0.8481990940304674, -0.8519520678160056, 1.0590388226441425, 0.23141963748961258, 0.2021439912661061, 0.5707147736661654, -0.9906167756654014, -0.7781805116741671, -0.7637930953194874, -0.45470616497642297, 0.39127327208217094, -0.8929491047940402, -0.4368720195287106, -0.3337511916215813, 1.1436250154508036, 0.2730322921081577, 0.6056312227400171, 1.0877843598137107, 0.18240651935013458, -0.4913637214621793, -0.3391340770511691, -0.7580176715689698, -1.03483717232386, -0.973532894832198, -0.3550177678366678, -0.11988178315664333, 0.06638147588571783},
    {-0.46535571375635376, -0.016787094939954197, -0.17333048980021645, -0.39034884527991065, -0.3175207681188624, -0.5566415917688841, -0.6729953011648794, -1.2611492627454464, 0.7622369183964909, -0.242426301139871, -0.24282789289847354, -0.00571225949301191, -0.26657556215887285, 0.09758757053302587, -1.0120638698541913, 0.1512534915036973, 0.17387913766434251, 0.9516212599697318, 0.5421811406453214, -0.5037231765991868, 1.0069075995119618, -0.2952729953964823, 1.1248198852593343, 1.1640323841144076, -1.1597321475033804, -0.5047510170558006, -1.2811507376432512, 0.8397266031349144, -0.1709226131862621, 0.4602046368310012, 0.5561809004016308, 0.2137895842834553, -0.23427363797527948, -0.3293013540643663, 0.642495322112875, -1.013243604364906, -1.0773342375517403, -0.2988390976639462, 0.5092946101853179, 0.8323425034672158, -0.48914122826322676, -0.49838786745228664, 0.5781614246940566, 0.1357248076788172, -1.423218158376626, 0.9068577803845146, -0.7592535052422978, -0.564143789805228, 0.016889234318224915, 0.29989837207509196, 0.14732184567799914, -1.087643781663976, 0.690769234541808, -0.7323343316560058, -0.3033841553178846, -1.0470324494555698, -0.678231122554497, 0.17329789982143176, 0.23153415385306647, 0.6582380082234661, 0.7715915260355172, -0.8689371883508459, -0.8062917100066561, 1.106158914640334},
    {1.1644552682795988, 0.3386902384543353, -0.1462336287539327, 0.6223563830902944, -0.4128645262363365, -0.4111588782295877, -0.6727484338939154, 0.9861085476153982, 0.38524273928491176, 0.6282151782261113, 1.0394635855128505, 0.7882879604695239, 0.6522964952120502, 0.4176602962602183, 0.8688668311886482, 0.7985352064426878, -0.8100792381332088, -0.8617996583107705, -0.37762232214428276, 0.7658247751037751, -0.6360748871156782, 1.201753796149052, 0.48239867211609844, -0.7611896574502707, -0.19567453217192876, -0.11748672519411758, -0.9493203904718971, -0.16754369196387, -1.1897442580959183, 0.6675531929166014, -1.2118161065408921, -1.0623995874754815, 0.4395694808502841, 0.44027592787170217, 0.5129237012402962, -0.8549398119462314, -0.3362095078334276, -0.5636219480099853, 0.9313397508180897, -0.9685719080572782, -0.11888392456998786, -0.6549826156880865, -0.1540306423376406, -0.6091263025293719, -0.07055132310587461, 1.0691200434928034, -1.2059808778085053, -0.36016505431620527, -0.36989620378095533, 1.253515641877141, -0.3008094527431672, 0.8256378813931804, 0.5992747282354489, -0.5695911604829862, 0.7558023514793984, -0.1413357984932024, 0.7881411032823474, -0.487707369874459, -0.08171194157942663, -1.385161469186106, -0.02316434014522466, 1.0606175583182278, 0.026495079054649796, 0.0509597891449606},
    {1.1345164708427586, 0.6982157264242017, -0.21039469913937248, 0.2979341292460293, -0.7817383219257995, 0.22338926202542053, 0.8867714035614361, 1.046322683287713, 0.5214745001622105, 1.046745811483292, -0.34395897270270226, 0.9741915035622928, 0.020515285257379636, -0.2608623944882007, -1.0185545297710952, -0.5267897136516769, 0.28280597221217524, 0.7758261937616059, -0.5937799093734432, 0.16600607875481396, -0.4341548524112114, -0.07920657040096589, -0.34413903991924716, -0.5835091071102646, 0.26219115416282807, -0.8910363291487657, 0.8973342875643326, -1.1646236583405825, 0.5607696133813955, 0.8398102159425017, 1.0237958783135208, -1.097594305274239, 0.02125819623809119, -0.8695150705637965, -0.47697795321774705, 0.9465697248279585, -0.5134013481197262, -0.5924861661330544, -1.2762596463580977, -0.8708956257352557, 1.3545320369197371, -0.3622181344848193, 0.7233007597944244, 1.0644707043971715, -0.8181520475513725, -0.44273695173543637, -0.8570934335884577, 0.4872772361497494, -0.3846487561382705, 1.2486091336458676, 1.0010591172320475, -0.14776659873483175, 1.1976558788309277, 0.4116767470605555, -1.1071866609352259, -0.7166651818954051, 0.7360815051743196, 1.152397895044093, -0.18980845730275359, 1.0527028376115262, -0.9383928029315293, -0.2801145154928387, -0.4254243004928626, 0.5626452010553489},
    {-0.1862452278929043, 0.5517829558091406, -0.9873104644411572, 1.1473276732582793, -0.6214031422689071, 0.2628553610787558, 1.2356057619823348, 1.2304118345261952, 0.5159105269614229, 1.3000398260666566, -0.9260842491066845, -0.15253907780791287, 0.8892258556105446, -0.39297984379506495, -0.9316663748634136, -0.451705785380556, -0.17320936127289452, 0.07089641512047631, -0.9963761275489316, -0.07231771927092003, -0.797936260138886, -0.9406444666019699, -0.38948760358690987, 0.5357233805572128, 0.23004706826731605, 1.2527460781198976, -0.945030057178661, 0.24178184872088646, -0.6240471791204826, 0.24114881707302288, 0.015847893755962402, 0.33856494342025123, 0.4983392922395005, 1.047006068251974, 0.3030815307136007, -0.2731646664861416, -0.12014836752753555, 0.3108231121338472, 0.9578158458105788, -0.9684027743067743, 0.3697952930523122, -1.0796656472458932, -0.28534919339749637, -0.8638517808376982, -0.5460955176007308, 0.4871215312257007, -0.378830984999853, -0.6069301331834405, 0.5821157820989127, -0.31846476193286166, 1.076339714130106, -0.7519687485999644, 0.7626130236174068, 0.24807659079828914, -0.9419505860405244, 0.028146364580576927, 0.8714434564845646, 1.4570514778925605, 1.2714875308653741, 1.142615514924147, -1.1009351079982632, 0.6503432684117243, 0.9292155705026339, -0.05946830871210325},
    {-1.026953500375611, -0.19331281458873859, -0.7671161930861939, 1.1590444598304757, 0.32735455237241057, -0.6138668476556348, -0.7897322195960044, -0.556745658409307, 1.1434685720455326, -0.9372884438946135, 0.4727412110025326, -1.3141678079165955, 0.8065357291465576, 0.4608832081567687, -0.9736818056871627, -0.6856818848065505, 1.0696697808413094, 0.058147535062547155, -1.268622335421123, -0.23232996599005273, 0.9847324473327466, 0.24399014111897205, 0.9535252570910633, -1.354243380321372, 0.060355503880101045, -1.4148500294979094, -0.10258868410254021, -0.18110029136472852, 0.677266689157616, -1.005805855137748, 0.9993026516737502, -1.1758240912685989, -1.1358515574073658, -0.8345802305228552, 0.13231646393041435, 0.7724530131499951, 0.9277432307417257, -0.6983968426922592, 1.0837931659361384, 0.32102918989949436, 0.42946021946655044, -1.0399231133309899, -0.780785037726062, -0.5327991154398076, 0.9008875842410083, -1.083662663927095, 0.7800238074618918, -0.2968885559686607, 0.8497608438960187, 0.8189566009278882, -0.6540982303617203, -0.4323802944594984, -0.06929435498080624, 0.35216464682347937, -0.9660360582526311, -0.22139524091315071, 0.26422923267097237, -0.5931063207633559, -0.7148360453676781, 0.21179008468293628, 0.4141066845210449, -1.1782582534232164, -0.2193258738766962, -0.977421710782938},
    {-0.7609710728017774, -0.023314828059810964, 0.6024727962765031, 0.11218575587026249, 0.9128004249033055, -0.18153181311563346, 0.50494729098318, 0.3381259128218435, -0.3103495934980086, 1.1118529493450753, -0.8165469570609606, 0.31003036377946747, 0.02712115036656619, -0.1799045355056401, 0.04088636366736258, -1.0407062885749436, 0.37776124725677146, 0.5666313020833319, 0.39125342247704026, -0.40194891404722705, 0.2688906683600246, -0.3035587943543848, 0.189457956579093, 1.1373324849652486, 0.519526914780006, -0.3833412597956732, 0.8976999029532481, 1.037291790669953, 0.3044368410706948, 0.04956288773774649, 1.2930365813522546, 0.29284232427988766, -0.35376727435822936, -0.8432326558393468, -0.135787308690497, -0.7827978712353483, 0.6784124873585436, 0.915213344505452, 0.6101563631082153, -0.13006279762219364, 0.6424920994015086, -0.8933433682683621, 0.8812676171705838, -0.2408157551275994, 0.5912383947305037, -0.40031202372171254, -0.01791762052819497, -0.07078131734173049, 0.9249813865419728, 0.4728161177490215, -1.055989447765712, 0.32563663538594634, -1.0009872192080567, -0.1003634889992367, -0.5279539169113141, 0.6336457948869444, -0.014560967819275726, -0.9833949220322218, 0.018151604676143098, 1.0607129036406062, 0.6316779457352593, 0.46834104322971687, 0.2732911331340942, -0.7882794101791497},
    {0.9174204808065153, -0.6587658132064096, 0.5977419239512236, -0.85432259384308, 0.9283124451782777, -0.8279912470057101, -0.7588864952823976, -0.7685154412655293, 0.10878008802676302, -1.2088092315538819, 1.2347030843030744, -0.6891418048138552, -0.754844103088318, -1.3699060929842553, 0.6626503742353818, 0.8103368021255762, 0.6551935178945815, 1.1157210808701923, 0.4187040312547186, -0.7360135547877001, 0.22385840241018015, -0.4240780676692401, 0.17049356844325808, -1.0845767453159099, -0.3103066466217628, -0.7907895393779905, 0.2501408477607248, -0.1691342866539595, -0.5432386899035209, 0.2606027012929027, 1.0922516209144744, 0.05715722771792659, -0.5299973999397563, 0.9832865913315194, -0.9297428439988534, 0.17026561845549507, -1.4097527910973549, 0.5912448865656935, 0.1494067870911516, -1.354741181776044, 0.47564765540508824, 1.1175124951315454, -1.218164140383885, 0.021513159361796066, -0.31464364838265485, 0.9689793737082643, -0.37817550141396533, 1.1196795283627243, 0.9650212071876357, -0.304299787455026, 0.17556252611449963, 0.4949975385444559, 0.463123512304506, 0.6808459242770133, -0.25093557343276995, 0.9135319751364513, -0.1868188483250689, -0.7150554251683647, -0.634268158634022, -0.3149150789638129, -1.0092438786631428, -0.8449057407701056, -1.104607407963756, -1.0435456951249076},
    {-0.2666460387881, 0.7741981361784348, -0.8813233460705454, -0.6593429510379775, 1.0485632773384137, 0.7478775101897895, 0.5800691937509026, -1.0307381531428252, 0.11776082084905884, -1.1655606189414502, 1.1347147777222588, -1.199028002828615, 0.5992663204301893, 0.7152882874315984, -1.2612796550614542, -0.5678006593419147, -0.4157016364886608, -0.43674478237770575, 0.46892323481433484, -0.23008097594169216, -0.7048460587342985, -1.1903503026984081, -0.43261378147591717, -0.0035270730365725748, 0.5819712079088318, 1.10791480532552, -1.3818830957751853, 0.06245143414264652, 0.6247142567128436, 0.6021315740348345, 0.5063122196765624, -1.0677181068057144, -0.2910759100608387, -0.8294709193931387, 0.24193666231084365, 1.0868434365974022, -0.2771424400511067, -0.2310988936898311, -0.6977687069879429, -0.9547646961627392, -0.6150371350715519, -0.35410526264719855, 0.923124834741685, -1.3647711940586658, -0.01091345770414231, 0.7995996259363375, -1.2220639700346427, 1.3766317443592853, -0.26903279971285604, -0.7625982428749843, -0.27001988244226155, -1.1294303804953025, 0.9311391172832582, 1.0748041161745638, 0.4442644130228787, -0.969736220025561, 0.3823055975244458, 0.9412671725107201, 0.8654661504008073, -0.8819859348342017, -1.2050299140181635, -0.20981512777105038, -0.5590637835333004, 0.12850706913554333},
    {-0.13663756206934066, -0.9668918617907584, 1.2814111334430798, -0.07782729107836071, -1.239973963255329, -0.3818311066242754, -0.6691697901625089, -1.2479379755447706, 0.02553480295775471, -0.6235918227668918, 1.0373488791106968, -0.24166824670575768, -0.5422725075899006, 0.7580240821893701, -1.2286009020078832, -0.5277186350428063, 0.7568267824380429, 1.2861131536036248, -0.92654512902753, -0.04288327568990562, 1.23885448335763, 1.015074943488792, -1.1614133938314541, -0.007192345553041308, -0.6508968518254318, 0.3020832932264271, -0.3565028190468431, -0.6984554272090073, 0.0669159876786678, 0.5394461583372943, -0.7468325979738685, -0.38766843358756775, -0.6604467763349492, -0.8204157273653854, 0.599383579069823, 0.15797810797921877, -0.994795088043004, 0.6460386200739987, -0.25107890911514563, 0.9447284399765274, -1.0520091646174012, 1.047521495210896, -0.38220026887124947, -1.1093777004976229, -0.18355036611262857, 0.957236199503931, 0.5448725786493692, 1.1114733898419833, 1.0360180997258266, -1.042552379471492, -1.4037215958183855, 1.018896900450519, 1.0870301937053082, 0.4317178562670391, 0.8305761273542942, 0.34307594752949067, -0.39638258976957597, -1.1412620274205003, 1.0874089120964179, -0.6150562330498914, 0.26834502120174014, -0.5129896065397692, 0.0419724531527235, -0.07102701261669589},
    {0.4839120411549898, 0.22806486111595664, -0.46983178007602827, -0.5015236423247151, -0.524735007588756, 1.3127319622865203, 0.9665945422469914, -0.8258066296501354, -0.7047669223815071, 0.49978153638001904, -0.47335664527648064, -0.8299569486692938, -0.48923765252328516, 0.8449412074353275, -1.0889716130658376, 0.8084125294962242, -0.643303167217415, -0.2075955394319316, -0.6110849031449376, -0.6423216712657474, 0.49860781353374645, -0.5905068343854407, 0.9453008932210208, 1.1310406448638206, 0.24798328111816656, -0.4463202950954234, 0.5270582032765769, 0.10014901582903174, 0.049654933949784985, 1.1267033099297257, 1.0948179903065436, 0.32883662565439437, -0.09344250495811507, -0.1104961680870398, 0.6298749419588783, -0.5485956251323949, -1.1914748321610695, 0.9262817543573122, 0.3288354540436076, -0.3436588883183114, -0.11950021603567891, 0.8251741964003676, -0.24569121149954337, -0.8348634512523786, 1.0788677580031076, 0.997419149040621, -0.5639966128271423, -0.7102063655971231, 1.2522747456372465, -0.9403847149832719, -0.6588820470892107, -0.7991663429945479, 1.0103729688417913, 0.6133724484683446, -0.4235624419177318, -0.6757098986920991, 0.5495661436439528, 0.5399124819519886, -0.6224794661975743, 0.567461647530553, -0.9698354543878762, 1.0149933794009893, 0.8984141190382903, -1.0245462570066068},
    {-1.2811141832479924, 0.9183842400822471, -0.5001745796540943, 0.2661473862999225, -1.504066646899813, 0.764213192789464, 0.2722104676766392, -0.8065683977546596, 1.2492471327966939, -0.6499729310654457, 1.0416396237205048, -0.34698680274913357, -0.48264648242903274, 0.40608619315693745, 0.74433093676845, -1.0649760937763626, -0.5792931000514425, 0.2599900360200835, 1.0973054641650282, 0.5952449890019261, 0.9461302098568142, 0.543920796714086, -0.3789024659470501, 0.20365153048993076, 0.2724782911156479, -0.16490483915366771, -1.1882656143078356, -1.1920030349301425, 0.3900446327871572, -0.42522151936913016, -0.9392936998871164, 0.8514319919024995, -0.12862781685983346, -0.24609654827016972, -0.5525746420647026, -0.2168106157178183, 0.9494289451591064, 0.080729885940569, 1.1408524536008515, 0.6651941650452698, -0.530945747795952, -0.4317536601082061, 0.7710014703942294, -0.7101468276848454, -0.3303734233390389, 1.139855861909563, 0.43920666145538734, -0.631428732268155, 0.494162108944757, -1.0404025312132594, -0.0450148798462082, 1.1213654753241362, -0.41766746207018796, 0.8742836703585642, -0.03342913235552578, 0.7674327488706821, 0.22721965284717305, -0.4394012186282582, -0.7901233267767067, 1.1678989375206907, -0.5716698878714008, 0.9930722259945678, -0.38083329538467753, -0.24319633479111058},
    {0.8697709381041728, -0.5532380959875024, -0.9231757238832032, -0.42668630978598815, 0.26794557077907744, 0.28927535302734997, -0.2992952342075845, 0.3348872066695135, 1.2475602200486924, 1.0268779556067076, 0.37366332804624225, 0.7575255418276616, -0.7557191374012056, 0.23749704933686624, 1.0072372102354399, 0.33652380506835206, 0.4881069172783258, 1.347812613913869, 0.6382663007182992, -0.8911546938270353, -0.23266478604044827, 0.18599379336489114, 1.0243942725890327, 0.6306669507911136, 0.4701473782590696, 0.05787122002904792, -0.3429128255236226, 0.06093933803354161, 0.14623382756748873, -0.10675300927219863, -0.6958939175635424, -1.1490761112172834, -1.3031613246944407, 0.9662096466902844, 0.3139096864433852, -0.8243055689179621, 0.5745749854321721, -0.3324843415157316, 1.0978278343616434, 0.15982933563211724, 1.0375564581880365, 0.14184030369643283, -0.5636162324671129, -0.05385496748578042, -0.8224305101820902, -0.7374045009754966, -0.44479278239443076, 0.46043577427651616, 0.006898449019353868, 0.7422242428132432, 0.09755291166137588, -0.19269630167308602, 0.2777190015698622, 1.0565169541152837, -0.433498215766225, 0.991855794674797, -0.5013456681573056, -0.8337821241326636, 0.08654959327218119, -1.08743295582446, 0.373631313005965, 0.8283893252077862, -0.4440368054596801, 0.5280333860182891},
    {0.6400225369484142, -0.710516467006711, -0.06830635364537645, 0.6087848319126818, -0.03217096933318476, 0.31061286696913015, -1.0093003018122795, -0.9870832277067663, 0.7437532297932975, 0.032325216713363226, 0.3722952450861599, -0.839425320252026, -0.9917986553709692, 0.732069759157528, -0.36521383964389104, 0.9710783303099992, 0.7303235833456284, 1.4856621966329808, 0.5107045627605796, -0.4937822190066969, -0.04469105899154512, -0.4370362943267041, -0.8758789350837908, 1.0577660195182943, 0.5325942372578034, -0.846194383547217, -0.8430863524933561, -0.28051715039621533, -0.06834480404872709, 0.2592001117212173, 0.9566418581552503, 0.6861083612990574, -1.0053289758557162, -0.9554020208074805, 0.858406015115874, 0.48973748444771587, 0.8929894996918417, -0.6957048054633009, 0.6642847250152228, 0.0197204982038423, 1.0449377880841342, -0.7427472083245021, -0.8947852392657785, -0.5484932081781153, -0.6239589015175124, 1.1363771064891728, 0.027800831910062142, 1.116575868924448, 0.04345610387554681, 0.5130491516369386, 0.7079987018493801, -0.6741391260981536, -0.16242091258847796, 0.3500191934971758, 0.9323627075711072, 0.715611360570817, 1.1317211226833606, 1.3077023983063334, -0.015581605533281037, -0.8482367058510274, -1.259463319179018, -1.0831299511565953, -0.2518536585980289, -0.030892719611096374},
    {-0.02247488792250915, -0.8150899736135049, 0.46590834704783124, -0.39831762058557246, 1.1138040543165764, 1.0232225266541355, 0.22910798567093754, 0.11420764649266273, -0.04200843559169793, 0.29593335305738566, -0.6773461487653412, -0.3501646729966056, 0.8565045816553167, 0.010738538142434681, -0.64964497012112, -0.5285988781004399, -0.4322874352089141, 0.3504092898242835, -0.13011323591218144, -0.21500106138162775, 0.17418989983136138, 0.6771356706536001, 1.1071293789160956, -0.14699663041518227, -1.1435027542849734, 0.14569210648901132, -0.09873112964978797, 0.28583880263457, 1.0981202196937094, 0.9207232730472055, -0.973938147528455, 0.011607648078086792, 0.36962975630425327, 0.4668400252491734, 0.028438290634703357, 0.9127384021857703, -0.6963390099228702, 0.7612245947442536, 0.06500346603132662, 1.2721772134145162, -0.1765831401889543, 1.1779825375033535, 0.0411455731761924, -0.8139086359959745, 0.7158102044448434, 0.19216075552612155, 0.12829244187022384, -0.8812884268416716, -0.7173695086608227, -0.115623405693829, -0.38575336058517595, 0.6434461325256696, -0.9339261219298496, 0.9251349093510643, -1.0133138593212938, 0.9119235899955952, 0.6727094324846271, 0.45377851457783286, -0.5606474360043833, 0.1020801910590052, -1.1910404954382372, 0.3323854620514801, -0.8621851720603296, -0.3993704373724654},
    {-0.24184241589733668, 0.8451891171989568, -0.4400742243125929, -0.3869039012982216, 0.28003457528371556, -0.8522893050104302, -1.2289702943029994, -0.3939602880832154, 0.688843884664289, 1.0828024372414884, -0.9086069264081544, 0.12916404568349635, -0.29864528509548105, -0.2137565536688963, -0.39173250061359044, -0.22283763899076303, -0.5527398140308254, 0.7744200188495306, 0.8149807183177488, -0.5832865910713078, 0.546661654181198, 0.5573309345042028, -0.1673390602413451, -0.6056623761325699, 0.8960679185655491, 0.2347790963940784, 0.5042745312942669, -0.08067124719894433, -0.387776256481778, 1.06080193007689, -0.5089308153380572, -0.657867656802319, 0.49335076394258903, -0.03248336717587992, -0.35667032561301737, -0.22958406610759954, 0.46922072540877985, 0.2620693870492444, -0.7584072118963442, -0.5236847097133681, 0.7494667796388532, 0.46947888386482883, -1.146066071431019, -0.17450695059818863, 0.8430594306834083, -0.8056063526166392, 0.3224460132040681, -0.2429870675645705, -0.7264305581534252, -0.8331710690663954, 0.9258391490783869, -0.21082270370273, 0.4955219859234484, 0.7217545917507082, 1.032442423998689, 0.19834723091380835, -0.4904397365761196, 0.7319984169323831, -0.9135244913985536, 0.028555077165415076, -0.1158981778787108, -0.2165726353299286, -1.261304863842055, 0.16325137240683243},
    {-0.7613767432697917, 0.9056386471761444, -0.8903619202290152, -0.10850950919235001, 0.20523349958490494, 0.932679124292274, 0.56373544397233, 1.0575380185177774, 1.2420658081514446, 1.1721373535779762, -0.7357570288558952, -1.2017842519183501, 0.6346016096593515, 0.8656349404319562, -0.16388664770084382, -0.680516522080398, 0.12659265754081486, 0.1479336720395774, -0.7253268605104136, -0.1160329166314273, -0.7190410839652462, 1.0633664842459178, 0.6858359806061429, 0.6811112871205466, 0.12510397748642044, 1.05020836210191, -0.2187956128656102, 0.6882245484966835, 0.5891543222545237, -0.9244569679737767, -0.5268867063061066, -0.6980861755753012, -0.46113612424063594, -0.3318876540820928, -0.6064255142098461, 0.569273821894986, -0.08790160599844263, 1.1238897170656181, -1.2014975379426136, -0.1474906379656156, 0.705687016193944, 0.2187006420066114, 0.09379150713390667, -0.04003531279046813, -0.18444878227151015, -1.374835799405561, -0.31511298312045577, 0.7137315298892353, -0.6839232203549579, -0.9347170676840844, -1.1225959590457333, 0.5396155458827, 1.0345103028395892, 1.3977862727596613, -0.48887833279278103, 1.127530669390503, 0.7138993815639988, -0.7048442581668058, 0.6922507077028754, -0.7662592755112467, -1.0189112982251614, 0.6138768641362371, -0.49712331689804723, -0.8450943814292976},
    {-0.6457086633837902, -0.48434197889276215, 0.9572705191345418, 0.7753206006843762, 0.010202885135755008, -0.5292020931183489, -1.2018609650268701, -0.02236361352768002, 0.2694482938775393, -0.7842211355266221, 0.7854073857420361, -0.10686106358595032, 0.971956761845906, -0.186190270415042, 0.42151705908949966, 0.5889473403439482, -0.7923122900790764, -0.8801331645573414, -1.2557590871222202, 0.04450029140214208, -0.13579113195630843, -0.5938891477053714, -1.0124928383853173, 0.8267364369575537, 0.6827048452008877, 0.2975141098344214, 0.31483856908407126, 1.004808898800631, 0.4599900599858635, -1.3662751665609207, 0.5162812481892498, 0.3000687258483066, 0.35568959902011976, 0.8278619340752421, 0.7864355094487445, 1.1541576907347604, -0.363242991346968, 0.760582860720138, 1.01336483061543, 0.31398150858609164, -0.6800465073539561, -1.0288711369744081, -0.814422872146119, -0.6997071737969404, -1.0674233958664452, -1.212499557224205, -0.8300995485827092, 0.9073725389062274, -0.247768096632619, 1.0661627081255225, -0.8678370833272506, -0.23718648157600927, 0.7787749063580638, -0.3535398618999855, 0.5009505016736274, 0.9218423287870865, 0.13229364232157018, -1.2677146488015114, -0.7661049245507912, -1.1636341064761353, -0.5543252018507627, -0.7936395140293011, 0.7469679160843812, 0.8701773678920938},
    {0.6838457141237574, 0.27409861099575206, -0.06599290817720513, -1.111242945103199, -0.1906382298461992, 0.23335350593075774, 1.1673224789407737, 1.187738880466595, 0.20726234023019832, 0.017787970960250036, 1.1435743293499643, -0.9852563312845597, -0.6020879895502333, -1.14882641808199, 1.3921050409967453, 0.46994333930280313, 1.110246965247389, 0.5090907341533911, 0.860864548706134, -0.47936117281040264, -0.6714945763121553, 0.746976668445846, 0.9529390852078551, -0.49017095480925876, 0.5194279948715276, -0.5508185938577295, -0.7719593073838118, -0.7493969777697775, 0.40415550574485, 0.8188305001884817, -0.7208288784569282, 0.46415296934151007, -0.017104976424974397, 0.11389711694065154, -0.808578552541655, -0.5245756963585941, -0.7717964675739872, 0.9373007506802707, -0.5811178882793128, 0.6765463340589495, -0.4193930188133725, -0.8654595210090615, 0.3747428766769442, 0.9347294583351762, 1.29048817135882, 0.24807366528326305, -0.8261551865218999, -0.7610407240709606, 1.0723961788142287, 0.9457119062813464, -0.6010891882549878, -0.17805512804037432, -1.2707527299556314, 0.18430407873293744, -0.9126752222437777, 1.191606979151755, 0.7117226586769263, -0.4239811453841034, -0.8810828687819487, -1.169559654339427, 0.6021865848865676, -0.6181135629779809, 0.588599832065241, -0.3398525192277548},
    {0.642051444639802, 0.5752377467429836, -0.9454432064285705, -0.08880340363777679, 1.3326402418381584, 1.093628769673034, 0.034455399704876044, -0.25763450054298803, -0.33727465272791063, -0.10918355492552878, -0.0943797665446119, -0.4533428139578215, 0.6967941889869711, -0.5925002042826316, 0.8437708534062857, 1.2985633436957558, 1.2795636449080403, -0.4584666361770939, 0.3695630964310162, -0.11182738658960309, -0.17591205580472613, 0.7065132115662529, -1.0510340980610364, -1.222732355688128, -0.28270124579569694, -1.3540329748844504, -0.17464922035139954, -0.9866590181568217, -0.8274623614767529, 1.0704455108315454, -0.4031969230199991, -0.9623877949820707, -0.052197003341695476, -0.7186033503959427, 0.3448261027607121, 0.9385001973854263, -0.660351361886431, -0.14794987326293624, -1.0376240751538597, 0.20547022486359365, -1.06507017393434, -0.3004937985480364, 0.8043528203278829, -0.6996968546710676, -0.6395391593607477, -0.23958377652126098, -0.3854050665170542, 0.7848191168452922, 0.255267332597506, 0.7099412461535867, 0.2057047207974045, -0.6547673843764015, 0.4747855746364569, 0.6486476569795777, 0.45383910504814073, 1.1020072836787926, 0.4899017296121045, -0.5416358951046697, 0.9969680401880433, 1.30393653240133, 0.6995386777422323, 0.3584531273965152, -0.39587275315090487, 0.607633433702898},
    {-0.17062701622830134, -0.6276411289517666, 0.9775734611427871, -1.156971046870106, -0.5782390461036735, 0.3475963108143102, -0.9592188846180517, -0.8188640092001934, 0.5562182098975883, 1.3256550017626048, 0.4784279894841797, 0.7731245991845699, 0.11349999943322345, 0.7017396653370241, -0.6293181217749674, -0.2810493272592552, 0.582668196276826, 0.8270105494013145, -1.2085380119793476, 1.2027530604521477, -0.893406867834217, -0.6285861107961884, 0.2043606613799399, -0.2878688125059504, 0.08408022195680025, -0.31051695285665054, -0.9237051818201935, -1.2796096524459395, 0.45666019306292577, 0.21430971000170435, -0.7939721078163281, 1.0999834282339593, -0.9333199295111188, -0.9156152386471631, 0.9797525369078277, 1.1155534188628875, -0.4937385892422994, 0.48840651938284396, -0.9518993569295883, 1.1501882103252505, -0.15479998412332538, 0.3274123951258585, -1.211776794503007, 0.3673043597089988, -1.1199078942404435, -0.7484755090800567, -0.538316858729216, -0.7938275539468106, 0.564173918886403, 0.5757313226796925, 1.1730957134921807, -0.9329752736280992, -0.9577244298077799, -0.01198803695747915, -1.0612968740970066, -0.02086522194852382, -0.05480589007137895, -0.5183915603927542, 0.6434898939102435, 0.579335952851382, 0.38959154537713997, -0.34353834301644953, 0.27319677810893217, -0.9592835649871115},
    {0.1205118007148923, 0.6352853922842785, -0.09134998983684771, -0.12346223105695804, 0.38226718350619554, -0.30467198293580955, 0.35516491919803045, -0.20389379965740878, 1.2540359612680196, 0.1292523412376146, 0.703026405826971, -0.4039566762819199, -0.9886399302494153, 0.28547171966339824, 0.010746511176886148, -0.6271236659138113, -0.36492578957145216, 0.8114525426036394, 0.2127963354396195, 0.782952409858707, 0.9156944354720746, -1.02630633525731, 0.028385102900074663, -0.0870903342058359, -0.9361072095449319, 0.9264267561224284, 0.0877284540286369, 0.7276537960743272, 0.0391397133978372, -0.18779024435921057, -0.9909389190658509, 0.532871009148509, -0.8415031489852538, -0.6338789795611784, 0.3389515743339903, -0.10380851231269153, -1.0227117863443151, -0.732656023394705, -0.6806682281502408, -0.36319046565250757, -0.717781340185495, -0.40704722076436217, -1.2253457448256129, 1.039217487591846, 0.017631357485655468, 0.13669370826231583, -0.7605257105339072, 0.42302720934388593, -0.4340103357680199, -0.8851749576646476, 1.0316937151882082, 0.6865953733925314, -1.124744733190096, -0.44893910579339036, -0.2747424203633444, 0.5218750758222666, -0.2527209578649039, 0.8696408429854212, 0.07350249940777327, 0.8915638519968226, 0.442121226375386, -1.1646255668987702, -0.7225643594234038, 1.1026414402378248},
    {0.42788268193673107, 0.08362503562167592, 0.921900387231874, 1.137844244187584, 0.7016571034434279, 0.023457429995963744, -0.09513681006499262, -0.8033463604525815, -0.6848674262411414, -1.1704666640728643, 0.6936104062896452, -0.9702787081261581, -0.18845634695370347, 0.28906436376177796, -0.12155340650836279, 0.5989919424956235, 1.046694578496705, 0.775306711318864, -0.11676978689427206, 1.0129725227129784, 0.3387838785079825, -0.23860796620953031, -0.5271501245060204, -1.1834060364276615, 0.8135640167602242, -0.498915342053516, -0.1647812703140237, 0.030042817434805212, -0.559559332113113, -0.4838078768437847, 0.1703511856476495, 0.4442027769602048, -0.5948057215045092, -0.5679654221214484, -0.5744035551344402, -1.1129897506187256, 0.7395969005468723, -0.3979352275344113, -0.2899425469190116, 0.8941716710732714, 0.17038149231054553, -0.42523010233067077, 0.559490475280825, 1.4198818626672784, 0.23869607156574588, 0.33093598885736303, 1.017446787521511, -1.1225284395868467, -0.1058243134363922, 0.07450244892837099, 0.2420124549332714, -0.13692380850983377, 0.07053519957548716, 0.416869844771277, -0.7651614841796239, 0.9510139606625214, 0.9889544790783844, -0.8310041054240078, 0.8101208211263492, -0.7815818233011564, -0.35286424968460184, -1.094571781600548, -0.15819776419203332, 1.4443382359984476},
    {0.08467196957449089, -0.28788379445549966, 0.7001227221202327, 1.100428150659143, -0.2893001541632294, 0.8582932065032383, 0.1287938132809661, 0.4415763651247496, 0.47861930729754426, 0.49056920187422615, 0.04373164171319499, 0.6142206806587139, -0.7483832065676225, -0.7039074558088687, -0.41465992591399775, -0.5031624300357391, 0.9166100291358377, 0.9393066081130192, 0.29959247435753356, 0.7701696946125541, -0.8415913184788799, -0.3406762379566813, 0.31157500881824857, -0.7468284855666518, 0.7902734685137481, 1.1671387620347033, 0.013955808580424616, 1.3367075096352314, -0.3310646386872989, 0.8685089397450889, -0.5591574392039687, -1.1566260578381498, 0.20274960447148138, 0.19291850664140794, 0.8861195150770682, 0.12151864493477693, -0.02471173482310087, -0.4468601964634739, 0.7966911855543743, 1.2254575744837144, 0.31052228230571816, 0.2897871911544618, -0.8902342791505805, -1.0282834935596827, -0.14678889847996146, -1.004224111815708, 1.1034686907005613, 0.7878280351393717, -1.029930972017582, 0.04498836988094305, -0.10428421367996468, 1.1230747719837935, 1.0513660225672736, -1.145062731688657, 0.20413867305949762, 0.47593170985082706, 0.17329724718908548, -0.16361437834159184, 0.5109728575881931, 0.5048140383017727, -0.7255959680450045, 0.9087170126897022, 0.5615321429150575, -0.0019040707255817584},
    {-0.368608744521473, -0.4124518394111976, -0.3668191483940136, 0.04936300485268969, 0.6567546329809063, -0.4518784705929223, -0.051068356370917056, -0.10045533472212886, 0.11638067078088596, 0.5736880698806273, -1.1452932340484083, 0.7213066444321394, 0.22026763550169431, 0.43543872173239007, -0.9633976812284947, 0.4432912410582751, -0.9145468511122111, -0.2499010655918677, 0.7663949418536884, 0.26335186063930827, 0.9635338056906168, -0.9368690691998804, 0.9268695370740664, 0.5333041147901978, -0.715844059757375, -0.4317063560701266, -0.9360380632949364, 0.8223324364527522, 0.4527563095072052, 0.8894782736972006, -1.3230027514560738, -0.5647851491448034, -0.13204158501783655, -0.8318333994371041, 0.3002822580834373, 0.05366438949912247, -0.6654488473828949, 0.35560354810925526, -0.2957743785634419, -0.4729782767557363, -1.1604274957568208, -0.3255601969776727, 0.5425245559613554, -1.172000818406765, -0.32512273389567287, -0.6170781589309473, -0.13193891580890288, -0.22678436124368387, 0.8282784638515296, 0.8970658770158958, -0.0051144058328238635, 0.8520004747145655, 0.6299474390260956, 0.6990587841307407, 0.25650249999047436, -0.3722668313300686, 0.8614405297145656, -0.5959333330961407, -0.6036937791863445, -0.743629876521058, -1.2432544151180198, -1.0947225303230106, 0.5971658700931964, 0.07059996330547953},
    {-0.6044696514347833, -0.30551321839635986, -0.17457166476739522, -0.8482298951696275, -0.5262867632628281, 0.846444264212857, 0.7993066899701561, 0.9586437901928927, -0.5218777121849769, 0.3931331803173575, 0.3151396891863936, 1.2378816712174503, -0.4895187033786657, -1.1836559249734704, 0.612318492914989, -0.42453699431154385, 0.878713663466981, -0.27210450810377684, -1.254307878042867, 1.1716161988384195, 0.27566039343093857, -0.7970866374248716, -0.7782964294229288, 0.6449092339049505, 0.24775043305754216, -0.4463794789036028, -0.9736806587316683, -0.11072400834663602, 1.254696746584144, -0.5270949244489955, 1.1687370824950853, 0.256453932548735, -0.0004616139914846521, -0.3338244117339253, 0.9273081320495954, -0.7753741443235086, -1.079028548859556, -0.09094060750114896, -0.26715424193737575, -0.9543407810248874, -0.044108554754389885, 0.4501603359856109, -0.09869751014487466, -0.9779373715667061, 0.36049748314272706, -0.6037506890401287, -0.13067603377282622, 0.37479070412164356, -0.8649080010702577, -0.13284263183155462, 0.6957888586695136, 0.11511721157086158, 0.3153159312277181, 0.5476377207792426, 0.8628406616944609, 0.3588871361131475, 0.6771741026387205, -0.8919842318469009, -0.0005059815686632595, 0.6183733289607611, 0.25288824335014976, -0.695706976638728, -1.056950638876544, -0.4199840100642108},
    {0.5552022685134963, 0.7215187307806491, -0.7982101183337316, 0.3780416316969996, -0.16154998950696445, -1.1412382414787319, -0.913726007712112, 0.24618775102680707, 1.0195601500350053, -1.0910073508322304, 1.0624326251827807, 0.6102896369361764, -0.46026314212803643, 0.45327418867027675, -0.5987125632578748, 0.21671011530747908, -0.779524816680626, -0.6751482773690198, 0.08526418147850234, -0.64383816731305, 0.768861690255236, 0.6200244979828764, 0.6652176310865932, -1.0311668102958123, 0.5206032381578558, -0.1112032798439341, 0.8461885313144802, 0.04524835351631192, 0.841632468027318, 0.4271053237448447, 0.3719570513047773, -0.39820990581936166, 1.1512419667705964, 0.33003399926033633, -0.8657248402368203, -1.035078297099056, 0.8539100342108052, 0.29307575153351756, -0.6526191720125196, -0.004581680569791684, 0.817555663018705, -1.2252993971028354, -0.4482315187352049, -0.38295658169114993, -0.9577670135934204, -0.3444390565423699, 1.0043582384153462, -0.5501628305907825, 0.12345632911289404, -0.950498447831989, 0.20869105676904282, 0.16391892952714948, 0.10490707703272244, -0.3666100600865689, 0.8907088057636707, -1.3642356488395129, 0.24464855736926253, 0.8514862378523684, 1.0202398320439532, -0.25009817115867267, 0.9274452128757702, -0.4366546459936847, -0.161294416004658, -0.8652251180663831},
    {0.7162906392405576, 1.4680352092193742, 0.3197023241813729, 0.06699482301041569, 0.771900916220922, -1.0413547728138248, -0.3141709743808341, 0.07703784525361705, 0.6032884924304655, -0.11146736689851285, 0.2524992792621923, -0.6451424420933973, -0.9563185883663267, -0.9691033214158383, 0.5734048264992286, 0.43996871019669453, -0.5377580545536815, -0.29413966744366127, -0.5357900064033914, 1.048140198666932, -0.23156194539664135, -0.5829672610078244, -1.0727133499772663, -0.4905182703218284, -0.5303835575686776, 1.0771007920459872, -0.14690594205613497, -1.0543860132612906, -0.7629793509402477, 0.44936414308895856, 0.10694071203699254, 1.0152263050914931, 0.5016194663371123, 0.1925421214869805, -0.1713471139377593, 0.849597614987945, 0.7464841640255006, -0.750744799508634, -0.09371761122679514, 0.6605341764993548, 0.36371838036547693, -1.0898572483474553, -0.8268745631120885, 0.27881058850857093, -0.6005443425765882, -0.39946549500301304, 0.7561068271618211, 0.15096614782886006, -0.1682730124973069, -0.40082280906869455, -0.26792861796379613, 0.18385388787327386, 1.302861784847948, -0.05351626267273491, -1.0096403939731236, -1.181789864215689, 0.12558962637661866, 0.13572898909336267, -0.5751803250614874, 0.2504918538848784, -0.9547073748150657, -0.9994408725497598, 1.0077273068710804, -0.5698476350577517},
    {-0.7146392556616571, 0.5643301418484012, 1.1069860897567887, -1.081658003805306, 0.7646952698441775, 0.6623375364376627, 0.10937773256936147, -1.0105536622947704, -0.9309514669142555, 0.1244135014910949, 0.0010641490153772233, -0.6144433535405077, 0.9323462038046098, 0.16755564223530917, -0.1437115262736514, -0.47113480461556684, -0.010244795095128765, 0.2112965235828782, -0.013274599013539322, 0.9716801964636379, 0.16032478736438552, -0.8967219385181369, 0.4146508516515199, 1.1409703444513044, 1.1456378522808481, 1.2581433786032876, 0.06474074633516377, -0.486273181726083, -0.26080967237722247, 0.8810561194472011, 0.1149242773420033, -0.16076290585725794, 0.5660389670521162, -0.38873267417335583, 0.6964838561096683, 0.6393469796150222, -1.0504046659371797, 1.234524635466579, 0.38496690156886404, -0.20637363988650398, 1.1809386359927576, 1.320222099686187, -1.1866020990586796, 0.46624399385464, -0.3401705898305583, -0.14271429063043958, -0.5861569393334107, -0.7485349271220614, -0.3093124895912461, -0.40845816406950414, -0.25322969494808084, 1.1400006144054733, 0.6191226843168258, -0.22067812011595378, 0.661073280912397, -0.37336067150353863, -1.2280935364057628, 0.2394526682764354, 0.8118912162066795, 0.965654576857033, 0.44209207454458715, -0.4214588420381723, 0.4192984008851447, -1.1806920073766913},
    {-0.8464823890227924, -0.025033025839786907, 0.6566035354622396, 0.12087948380692379, -0.11762005933902635, -0.7787594591683521, 0.24372697031756912, 0.5823777319773159, 0.645292469286038, -0.673869445476564, -0.9889417335447657, -0.8170765311569581, 0.6772901487588132, -1.0619898146365856, 0.3797382806661745, 0.8037400600067695, 0.7292573755096259, -0.0538604113602396, -0.2739548363550163, -1.1172994928763937, 0.9847850131310896, -0.12182226647009341, 0.023675360179075646, -0.5097765509760518, -0.41217111221819314, -0.061652006503400594, -0.941865796820877, -1.153794757946484, 0.8029655685107335, 0.16076588527672453, -1.312207780780814, -0.8133715053970032, -1.1001273277756112, -0.2993856108665508, -0.17758108358171135, 0.75621724958317, 0.7173334422692073, 0.5539321160639628, -0.5422304076772163, -0.8217772298467083, 0.15364940017922113, -0.8344783840187472, 0.3547407197103407, -0.5673728815171856, 0.5675625593327482, 0.09951241017324101, 0.12843515933041327, 0.9615048295047488, -1.4246368633571438, -0.8412566753194808, -0.5610757464856077, -0.5731643649398057, -0.37732314590522414, 0.7022688641485315, -1.3803535238038924, 0.31671612761433665, 0.10168184787220767, -0.8301038876772912, -0.3218236357977132, -0.07275503595081843, 1.1932376532260112, 0.3321262153965263, 0.06819649330420419, -1.0142089144349058},
    {-0.1546157358169269, -0.1638529370637031, 0.31767185275921145, 0.44694434006610245, -0.8573180465947796, -0.7786139926404753, 0.3521689413453751, -0.1799417685318528, -0.9995566007449775, -1.4435379412001144, -0.3919130010147376, 0.3113637344786751, 0.682750469020267, -0.08153389708019516, 0.161977936405034, -0.7950433962259047, -0.15335869753020784, 0.1787738794764806, 0.2324856264176999, 0.35250178707962726, -0.1858399275906773, 0.6871484689425894, -0.9425686167148856, 0.35822672971701813, -0.09056888207280599, 0.9454921518760616, 0.868541187188545, -1.3424936731982264, 1.139273778294083, 0.269839283166051, -0.6166144786963368, 0.4911617492113517, -0.13260930509306423, -0.4076610399761664, -0.40626060522367247, -1.066824652228708, 0.16789181332430558, 0.865059929632816, -0.5354165474764537, 0.5330216263653483, -1.2718320136086214, 0.6667030264414808, -0.4188845751829725, 0.09681109707923755, -1.2830301245981357, 0.643074627919214, 0.049625228308446435, 0.3679832123653533, -0.019719940009558724, -0.7554354359059379, 0.39800891441852615, -1.2518252993350993, -0.77760488226749, 0.7393911708183122, 0.647268135058934, -0.5077543870704797, -0.7753103401746141, 0.21477711008557537, 0.46726122024513106, -0.7759018113130153, 0.8392678985735936, 0.5021029179031881, 0.3262921055231715, 0.3902294977346077},
    {-0.8343603735258429, -0.5239317485849098, 0.7312655512980601, 0.38962825817769925, 0.9955334581406784, -0.09096676021313771, -0.6085373055424425, -0.8404654398202882, 1.0641525297874785, 0.9687351409036021, 0.7935814094042358, -0.3245595196347748, -0.5876646317583666, 1.0638668076052513, -1.029451951197783, 0.13807174611504935, 1.2096267079265641, 0.44675827616028935, -0.4173565067711921, -0.8305676314778196, -0.9520487051963197, -0.4324567437157897, -1.0053067980763861, -0.02505235391286998, -0.1879871493065775, -0.06652319647503173, 0.7914918713431087, -0.9033599513025451, 0.3343874421172558, -0.6833038478330424, 0.2742586516885918, -0.9471449153155461, -0.11524650803621311, 0.4364833199314948, 0.07871423050939563, 0.7638006157565733, -0.35322342650090716, -0.5835153755193269, 0.5934419262123454, 0.7403779736161835, -0.9104366475194485, 0.2662990545917526, 0.18857326880617414, 0.9088128946101247, -0.5977347248139414, 0.5540976037046494, -0.9860684061225836, -0.9395087312375622, -0.16322082392593265, 0.6597615445976259, 0.464099897192884, -0.9234275810579781, 0.15647434739662036, -0.8760551624755892, -0.19552137569820327, 0.27822510957660684, -0.3049302279637689, 0.7041713340661199, -0.4588596970857574, -0.018691094503763016, 0.09631761467792771, 0.6166988006256399, -0.3392768962588647, -0.6160482523930936},
    {1.1549978457941659, 1.3489330779319493, -0.44050743043928847, -0.5350444805969828, 0.3935875945775721, -0.28731363939912213, -0.36916617631473253, -0.12662198379972844, 0.6730741376209852, -0.5237434278853268, 1.2049357464094543, -1.0643310354332765, -0.7964596078738205, 0.560719690917242, -0.18515779426046206, 0.4859707473997537, 0.8580011911600096, -0.8457752394004407, 0.8845362603684742, -0.5120325901973238, -0.7575032558173617, 0.9324956477720795, -0.39996982414061916, -0.9265539114095847, -0.38963928321851454, 0.9360316619858086, 0.1561264581839369, -0.5167348922479278, -0.37560597230169185, 0.17548814294290788, 0.5944555325125009, 1.1242536152845688, 0.298713932823821, -0.544829639136229, 0.9775689546493533, 1.1614983398092555, 0.9740910596222463, -0.7014478355552419, -0.15250963957390107, 0.20330699918980427, -0.580766526000089, -0.9616187523683546, 1.5494275343113812, -1.0896022992209187, 0.6695746882007182, -0.15552338585366332, -0.8443570149492945, 1.0650421896114333, 1.2352259627311417, 1.062143348782857, 1.105017502815026, -0.31129796001738574, 0.5722783333674312, -0.8473340834700391, -0.9719159212462921, -0.85060764984687, 0.23518954694790148, -1.0186855170578208, 0.9086014003773369, 0.34264967310826466, -0.4424479095564119, 0.022426378793273184, -0.9797406413582832, -0.9704736366419394},
    {-0.5971785346255163, -0.7181217320818006, -0.3695016092705946, -0.8712277264577984, -0.7753800713147249, -1.0297672811973022, 0.801961880881702, -0.6736640328523495, -0.7652682159965895, -0.3321986258882566, -0.5879110646311501, -0.3764524548379905, -0.5456114934804105, -0.005931000548246968, -1.0985380699888068, 0.5792377937605273, 0.9327597894417793, 1.1646498783554673, -0.5663859155733226, 0.7804581820101191, 0.13637591972916577, 0.7066902436321469, 0.7168214635206612, 0.2688766529145169, -0.7315725924492845, 0.2992090257978482, -0.27113993670491526, 0.7457172185288564, -0.7679150373158895, 0.39455752067687777, 0.26862993111061617, -0.46845698498018495, -0.7592736327247812, 1.0741081651616204, 0.17007001976640704, -1.0872940811242602, 0.07709422926589567, 0.8088343570528295, -0.9707982106483791, -0.3333995841268927, 0.08899390182163137, -1.3096201005911419, 0.24812521728962733, 0.21707720009659015, 0.9275346375650289, 1.2283477901619064, -0.8561692815425546, -0.5806206461150466, -0.13614546087262233, -0.24638515578288472, 1.174289818551561, 0.19282610786989718, -1.1195827845900572, -1.1287234955244403, -0.24315842592322245, -0.5064038180192891, 1.1627321330534381, 1.0578247911309486, -1.0633221904297931, -0.7508370269307901, -1.1236220791479026, 0.7431433200774186, -0.32539394886942974, -1.1955244474777613},
    {0.6794701561646525, -0.4582513242357785, -0.0714181746537217, -0.6372869977515369, 0.28312838258235284, -0.29360404882022184, 0.9535350917948707, -0.656417484897143, -0.5885343030486458, 1.1760298136795384, 0.536666271128091, -0.2708356673893686, -0.2133222426753877, 0.5235490191684731, 0.9504901675047894, 0.6776101504276048, -0.33215029530666323, -0.4321836776725711, 0.921997677332717, -0.26875996981139383, 0.02387179305916768, -0.06084398405239564, 0.3573673525769061, 0.6090128786849045, 0.8479307223356246, -0.39131620165604586, 0.6561090450225279, -0.8916432624255455, 1.0281467679169072, 0.25730658910045445, 0.9321985500433423, -1.0614550866522943, -0.798092071819597, -0.8487779612705125, -0.4104997989874539, -0.14814683780907698, -0.1566670077819826, -0.4553089410422267, -0.499916337329344, 0.08196647775664397, -1.0303354743456805, -1.1616173140192858, 0.02804199414677066, 0.7776792897065316, -0.3341206680596059, 0.8590304007877044, -0.12327844828719633, -1.2788456633697853, -0.6615923648965176, 0.8368732399882763, 0.08411000343131872, 0.5810646514895459, 0.4715389360101568, -0.8871650182093632, 1.0907116979945668, -0.6978713528553457, -0.6124821891857153, -0.6244440633920005, 1.029066971114767, 0.09842390467846149, -0.7076701740876125, 0.714305325124861, -0.09780568668584158, 0.490815701918742},
    {-0.35616399319407355, -0.06681277972309133, -0.27700878910562826, -0.5431379001756119, 0.8899840551079763, -0.5426320941557458, 0.20551043647873318, -0.04290934993298551, -0.7218073634411948, 0.7115954243026275, -0.06688690729464643, 0.5430358708774538, -0.685503275382119, -0.8208024463723474, -0.10064590926530177, 0.664806914065023, 0.09488553211325981, 0.7838499202676973, 0.5447398252068041, 0.5084661809562553, -0.05112366055779173, 1.179654961713246, 0.875973998684557, -0.44720890465601176, 0.6890405308971779, -1.0333015834014772, 0.5604446806136623, -0.08915736475080296, -0.15319130719892976, 0.9873731484722762, 0.2850194734747798, -0.7770046474038674, -0.53308162767205, -1.0364164870350339, 0.2328620205297574, 1.1684564041987258, -0.783625069672539, -0.67869871543062, -1.12081279551278, -0.35756325548216966, 0.4115106013612294, -0.1819819309325612, -1.1481536798633474, -0.06924523516743802, -0.5557584994148359, -0.2963990586699607, -0.4581516484129017, 0.49087860235654385, -1.0521352291390265, -0.15851380607017976, -0.38307513310742247, 0.695084066543097, -0.008843855205599044, 0.5393763981755727, 0.7655085538874925, -0.25303311001047735, -0.5275038838516022, 0.32087265000007953, 0.5480369409635573, 0.8715030000401567, 1.2250275233816337, 0.47095734080017304, 1.0741906746217762, 0.8703656230605317},
    {-0.64636760848632, -1.0728526946175907, 1.0814263994400852, -0.7324417882703959, -0.021210821166473638, -0.09490933636232493, 0.10260411964912795, -0.23366417601909348, 1.188741987341646, 1.0290303732075963, -0.7084870233809311, 1.131581144828736, 0.6447951369047029, 0.43660684898740626, 1.1520205670288803, 0.20721497145937956, -1.0152652421937984, -0.1839369289408408, -0.1442350113727846, -1.0379700712533426, -0.3761953765117104, 0.5537523866952286, -0.5004837335659672, -0.2244510921940894, -0.20050445406842088, 0.5340537639681194, 0.16368885555444138, 0.6673759864942536, -0.11000183558035997, 1.111532365287655, -0.8019053974171992, -0.8088897251271124, -0.02910041194801177, -0.9608766748586983, -0.23096471139736668, -0.7071857404227864, -0.9783755381457444, 0.9325219089595351, 1.0115637109202573, 0.8687625088950898, 1.1931240955337532, 0.8666386677196842, 0.9355839779394005, -0.7082567602087497, 0.9604405283924884, 0.35232903797243464, 0.9186321940322411, -0.6380652006125748, 0.2069683021812157, 1.0631840467498557, -0.6762183902189522, 0.7201612123330288, -0.25581830881191003, 0.8903964001344651, 0.7216170160321156, -0.9540937650759312, -0.7848578184264154, 0.5417663215531687, -0.885732860760963, -0.9695511303414399, 0.20876577518680242, 0.7508396807552843, -0.08961020917612644, 0.8070736873344344},
    {0.38200797365831524, -1.0432639140241935, 0.019078549932761937, 0.9645122424049969, -0.3122393578653033, -0.5808382758050005, 0.6566297295940055, 1.1190541815718726, -0.827665629926701, 0.7906946024242858, 0.6555430241045764, 0.11904972835729655, 0.23969570653212932, 0.979232166989186, -1.1909398222288752, 0.28571653975050415, 0.04644781336387952, -0.870478516025468, 1.142676830024014, 0.8289515829575674, 0.5274524833234759, 0.7436833508257241, 1.1257123591982543, -1.299471439415335, -0.9416820736634611, -0.015516250520258125, 0.35830881292371597, -0.767315403184609, -0.07009714626957703, -0.036123727206481354, 0.43430156134322795, -0.3516618468134142, 0.25919537810806254, 0.39051745477195765, -1.0842288537300955, 0.7794763509822238, -0.13828434573664805, 0.383371778192154, 0.5163802984892751, -0.7902303300622354, 0.8550563309858306, -0.5570182127540844, 0.0072910682469851905, 0.6475139705520621, 0.6956083959791962, -0.41200993108139705, -0.6053885827550528, -1.22302558998516, 0.19241801681545914, -0.26027392331319144, -1.2125467367280294, 0.8086790727348571, 0.9122232769512091, 0.06542193920147453, -1.1291721594468387, -1.0948864868438288, -0.6596208711445013, 0.5919303167875983, 0.23193234468769924, -0.5301913591468824, -0.41615454713880656, -0.8576567358701743, -0.02630023347796623, -0.4352484958724181},
    {-0.5292562230604219, -1.0158729108656692, -0.2750998483602337, -0.06164063066364631, 0.12120414371922393, -1.074072167118014, -0.3601179845645355, -0.7995867193473463, 0.1124635842721753, -0.9437045542857014, -0.5022716199150565, 0.2892119013808493, 0.551721321057332, 0.007477525818103912, 0.2874621113316281, -0.6369397978834315, -0.16193179617842254, -0.9262399726363323, -0.9420069386107733, -0.4776377236588007, -0.055056194410025586, 0.5504221896701035, 0.24128256125683928, 0.821670293189394, -0.9006166678864382, -0.7344381307913765, 0.4911311782291845, 0.2327880185545477, -0.0067938344985095855, 0.7069535355901047, 1.2114722633988508, -0.435361848858981, -0.12444265247268302, -1.0893585036183182, -1.1991846435611333, -1.0879217869085815, -0.4526952367803001, -0.4912288405604804, -0.5167146199349676, 0.5534618213751995, 0.41368843323332155, -0.5986475733395787, -0.5281393519139073, -0.48106205166918486, 1.1501371328952028, -0.35241701408328713, -0.897615667491019, -0.1622627332389352, 0.5893186271662945, 1.000190167825786, 1.267161832012598, -0.06322824884957563, 0.7883425461382674, 0.39160599211156755, 0.7574873201074334, -0.30023033837538315, -0.7906878637278013, -0.2003298681513474, 0.5660204604129679, -0.8074580235446557, -1.2989261385839268, -0.1587302435849553, 0.7593234278109493, 0.8541895389755964},
    {0.7374293698153788, 0.3663631036513703, -0.8174440858217288, -1.1737009254385213, -0.263041638664916, -0.19400503360289495, -1.0889298588361576, 0.13926057232375275, 0.16919721302251267, -0.7028407156345, 1.0855674027705327, -0.6984367042169716, -0.2795631201136427, -0.43213542885187406, -0.5415044407831333, 0.9840537551111777, -1.0519398723810078, -0.9165305348229463, -0.9689172586100263, -0.7303335869098783, -1.1043488790124043, 1.204585363107176, 0.3065283164927548, 0.04663238888308105, -0.850898944477414, 0.5053885256792681, -1.0309802320548507, -0.20805218902344358, 0.006701849722159499, -1.016178966154364, 1.0419440501765296, -0.6717514721820296, -1.0271158281772035, -0.34198992979348053, -0.559257514073116, 0.003409480155039184, -0.7516915981180334, 0.35693658942745676, 0.05567877588152346, -0.5091423316232491, -0.8833331052265295, 0.9940853141326699, 0.2027315255166158, -0.4479866567029405, -0.6157870718622087, -1.074666111800442, -0.7512221978735505, 1.025066180404011, -0.7280862911489766, 0.21499843955260498, 1.2677168191856192, -0.2661749929589002, -0.012027479342122928, -0.46237609669077234, -0.9404687224080808, -0.33655613725506606, -1.116745085338405, -0.06097035245321818, -0.8475146487779456, 0.2214624332562345, -1.007411129627714, -0.23262462267457532, -0.5702036608428486, 0.9171847074533221},
    {-0.49992530923029727, -0.25025567383875463, -1.0938377859965938, -1.1418983667493867, -1.1013530625221952, 0.4356186231131182, -1.1635562544581806, 0.7124731055985399, 0.386944947272398, -0.7276964854827301, -0.103178451142659, 0.6629816139462704, 1.0682532973943082, -0.16543960473630984, -0.46082699737319827, -1.0107311536134336, 0.27727896884616926, 0.3903749769666667, 0.11767369265982834, -1.0361045252447285, -0.19895976011298425, 0.3322607866432363, 1.0849594021673814, 0.8553402782219378, 0.5702339227550742, -1.273677387823365, 1.0856019708994553, 1.0719013704447722, -0.0029944356523609775, -1.1484646810141463, -0.8029037323725131, -1.0684005776181682, 0.3447006405602926, -0.4976270133385654, 1.0146223583133236, -1.0656212290265665, -0.6803427345345624, 0.40930005536145886, 0.9519942559073098, -1.0775423344331678, 0.19292590378670302, -1.235566125084977, 0.9550511908135001, -0.3467811653628255, 0.8651466259696503, 0.9017082244593071, 0.9103899152770325, 0.14075167239960454, 0.5744860068543458, 0.15573654426933875, 1.0199877497034213, 1.077824890919372, 0.0178849380491874, 0.45294772058069493, 0.4650890519294964, -0.694681366933969, 0.9123126928360293, -0.35556355556597047, 0.6251912979683786, -0.10627028638694895, -0.09678405474407512, 0.010089091447375102, 0.48041394733540427, 1.1229449634722524},
    {-0.09471849003864384, 0.7591429019584466, -1.0206325937101408, -0.02360803736602496, -1.0902158546423126, 1.1560970879285983, -1.006220580966359, 0.9777505000142008, -0.4098394513970638, -1.1408034932182067, -0.0176349182089641, 0.559597554080502, -1.154607664615324, 0.5505652876018815, -0.07888232740339152, -0.9032435387335204, -0.018314046592143102, -0.7005273529989241, 0.10443738406656425, -0.5468146022756684, 0.11342159957838567, -1.2027871237982701, 0.9607944165461562, -0.8174310373479606, 0.1083858341667947, 0.6668345924194156, 0.09176956456066984, 1.0830307750776562, -1.1345307280524433, -0.14756272839940102, -0.6943730730712359, 1.0736537664455281, -0.8921837835104504, 0.830864944589152, 0.10670984389135955, -0.0884287867557663, 0.7103770632087364, 0.5045007242900806, -0.7005461230072401, -0.6160697152425937, -0.21411199952525678, -0.7701110590513296, 0.9192058040606343, 0.6183813440409387, -0.13709921656076143, 0.5996858590764799, 0.18922919037301122, 1.0951996604073853, 1.1480229030973064, 0.5430740362576807, 1.2400715466565504, 0.4233673573770931, 0.0018743920761633355, 0.09150281410878199, 1.1699664019611316, 0.48418380514669196, -0.08963190238938137, -0.7676900860871784, 0.4950984664861078, -0.9606031956843867, -0.49571781058719994, -0.5816901199016794, 1.011773976544936, 0.6872109018706271},
    {1.0763749193973715, 0.48550960061315973, -1.1254381737054857, 0.42586110058921584, -0.9626126264075504, -0.13353364393509778, -0.7776728837662743, 0.37571516764739943, -0.7819477923373815, -0.5611789799163329, 0.3337073704442903, 0.6247016224872587, 0.08822126523497935, -0.29588042448717095, 0.779067714152546, -0.7551305789381862, 0.04663193949305122, -0.809247810573727, 0.9570480022122407, -0.6423993744970005, 0.5326451499065589, 0.6994118155556105, 0.2932835273375465, -0.172213294250805, -0.2218824128985546, -1.120200991591299, -1.0342293804237703, 1.0808873961806473, -1.3266680263830668, 0.5927403229259266, 0.7414860508423592, 0.3471259313609575, -0.6391516121246315, 0.0669274753078543, -1.0711902283192765, -0.8704298929189223, 0.08355552538202574, -1.0453055884867934, -0.5977399055055704, 0.4373704090154875, 0.4863115013448724, -0.13266308557359283, 0.40256139848751604, -0.9707643387503239, -0.42528163456675, 0.26001630578797547, 1.023091271040787, 1.1270741064543373, 0.2016556175616419, 0.07396083755759088, -0.21201803601653568, -1.0770760952039573, -0.4881125527106227, -1.0051698958971613, 1.083789363215736, -0.813926874749993, -0.9517181557348825, -0.12428893049724783, 1.0387559905141375, -0.9098916860290369, -0.05218494361877502, 0.018716181254041835, 0.03518193850228839, 0.278369703377615},
    {0.9764440276501816, -1.2516064416335633, 0.8164416665851391, 0.7513666892237358, 0.5367428464239911, 1.020029209846985, 0.14557093001412158, 0.2859465343163396, -0.2684671256721325, 0.5964419768946216, -0.10928162848114809, 1.0763309245743555, -0.7890844630808714, 0.2642990530936979, 1.0104096463849488, 0.8013347598307959, 0.8504376900376329, -0.5951628981808395, -0.24036924771373275, -0.639978299009783, 0.034408286254628453, 1.0958051460857297, -1.20199404208697, 0.33590618898489, -0.5811432059189247, 0.0927479340219054, -0.05693835691413175, -0.31299054011087113, 1.0001125195432876, -0.8908575957127727, -0.8234150753557086, 0.8262276382197363, 0.021384257059728844, 0.5121381152152702, 0.2343900844069719, 0.4909062492784002, -1.246984134320341, -0.3600674465005844, -0.33489042994588, 0.5698707370203555, -0.9585098341342033, -1.2424629037345907, 0.9018183520380837, 0.7738538860455447, 0.7603456275535794, -0.030306626214813285, 0.49891229602997034, 0.21733527794957955, -0.6818898216624031, -0.9227675044632337, 0.07408937521077136, -1.265035339343548, 0.7806786837657074, 0.4606224985097438, 1.1092546492380044, -1.2198715739155368, -1.2243903603609119, -0.4016106734872987, 0.6562627487564485, -0.8379560012874292, 0.09141067567728525, -0.4474064958706957, 0.4019031885813156, 0.3767197996323787},
    {0.9021432905809592, -0.6165230214507345, 0.38136661308985725, -0.190807705694733, 0.811792514134123, -0.860532587899625, 1.0068047647177636, 0.5619146331188295, -1.0900598274479778, 0.5256655168078986, -0.3838720687502128, -0.7189719842727882, 0.672611045882939, -0.8324816970564923, 0.18905791786968218, 1.126374347493644, 1.024771621036675, -0.8324738594552549, 0.3579102895581607, 0.15449166597833724, 0.18370882919751635, -0.09736117464088168, -0.5990630968651756, 0.23803023665147544, -0.33427413865634087, 0.1661923804339983, 0.7707080545659553, -0.26669428183683885, -0.41754489833752395, -0.7034593087688468, -0.4269477477995655, 0.4168281746840617, 0.8076350897164057, -0.7041648094837626, 0.1738925294556262, 0.9972332479430526, 1.0882640925174352, 0.9519510766486078, -0.8463602174556192, 0.353553988775249, 0.6480879964169719, -0.6609418398008247, 0.533495926823601, -0.20207911117385607, 0.40064730495027, 0.9713694888099722, 0.06236665917823732, -0.22493034604408227, 0.562696147426538, -0.5182273490752243, -0.7386820877399229, 0.37055970420733747, -1.1751660579252001, -0.9547904334520376, 1.2123689135861482, 1.273760475450038, -0.6495495069910949, -1.0060943189733877, 0.9951451031014719, 1.2725038242883944, -0.50173568118321, 0.6273088018853682, 0.527333370320424, -0.10204323787484418},
    {-1.0903600931300537, 0.19782340562186523, 1.0829663101616713, 0.9820565267070696, 0.7150275670501345, -0.20064906914979433, -0.10873272844344882, 0.5781053585053799, -0.3953392111315864, 0.7393214329626222, 0.5405843743614623, -0.8430587707435642, 1.0659865254624779, 0.9669165040994573, -0.2650798766491388, -0.009645445063002064, 0.2192318927639915, 0.8391992659426782, -0.6918916885161794, -0.9878579295344734, -0.2005921538147598, -0.6326819907532009, -0.6613896832752258, -0.35255407519341553, 1.0783544602821127, 0.030656982115895643, -0.8519354681607699, 0.6670967058004239, 0.3026041476363268, -1.124606465775191, -0.030688801240645262, 0.11951111796241463, -0.8530270396579841, -0.7866470880079979, 0.3466567107849447, 0.967908310887169, 1.0367731845067345, 0.407973577343042, -0.43600231277639817, -0.277887852884312, 1.1201886699495558, 0.407957690176314, 0.6111451144686129, -0.9743765324536399, -0.876633020174916, -0.08268727817460614, -0.8508028370261884, 1.1844288754842516, 0.7918373403160202, -0.537776743918939, -1.3038881229689743, -0.07282929611005202, 0.684564295593156, 0.05200110085301063, -0.1513077322778646, 1.2944467671079294, 1.0786394533693786, 0.5625602408026636, -0.6994952302390742, 0.38267130545060074, 0.03936139739782449, -0.9187863410458489, -0.7510970691164234, 1.007990640284127},
    {-0.6640937415339735, 1.111389399383601, 1.032881952232344, 0.7988512721890532, 0.6262061109618487, -1.0031857824826056, 0.42933109757760113, 0.0011100256764275847, -0.37049049416041463, 0.4974250651974355, -1.0627610270892398, -1.2387974874545782, 0.6758742869128611, 0.8009274592119047, 1.078148480377664, 0.13998612235793081, -0.2931444493259204, -0.12341116745974465, -0.7649348632817181, -1.114027191832828, 0.43725452787506575, 0.015861201730640647, -0.17766922946014505, 0.5813340771433322, -1.2058873976036004, 1.2350677945644906, 0.34110625846902654, 0.6720111774964537, -0.07236552291577342, 1.130845171241976, 0.8522447046989701, -1.0483551205535848, 1.0664232014174055, 0.4568215689533027, -0.9231593400795564, 0.42009691588566433, -0.1924155578259646, 0.3510043866990454, 0.8555059794213907, 1.091425844153247, -1.0911401294937089, 0.17619928206816923, -0.8053800987701626, 0.2150240521913763, -0.21887146388244727, 0.3521782891394304, -1.0631094214517474, 0.09432965705640922, -1.1377139671234016, -0.03715852974237667, -0.6285761863240427, -0.9470178288749629, 0.3123910009161381, -1.1235205555579566, 0.20613416122498435, 0.719060302024848, -0.6915779770217171, -0.7351118139869247, 0.06840447466324896, 0.0422002469831905, 0.04565007982215985, -0.8175860085223227, -0.07784038307837764, -0.20439743231505544},
    {1.277889075487813, 0.9661230485731633, 1.0724808969200366, -0.5320988567239288, -0.016074010758813026, 0.2311797824879736, 0.8497628576784468, -0.824681568887939, -0.3809843479746395, -0.9800831507553164, -1.1077188343819928, 1.1063891000036659, 1.122055153440475, -1.1573992446658314, 0.7863028675190363, -1.0990612324629796, -0.8267027112160883, 0.1743195567492823, -0.2863363499795102, -0.6507603551717542, -0.3638610617814952, -0.7875237065351894, 0.05078203202355675, 1.2944047212254206, 0.611976738742424, -0.8243304995948113, 0.3517168219096109, -1.1473494050091584, -0.9371820231247058, -1.2373937452851231, 0.16096986822954953, -0.6012334061183117, -0.03296653518007024, -0.3889507434998838, -0.07217133449756229, 0.9490639073532207, -0.5886891469074153, 1.359564857097744, 0.6169280178766003, 0.9180806606552813, -1.2296312019290179, 0.5677967686017036, -1.0932874026245065, -0.4716035388305213, 0.21815989847502656, -0.7767777229242682, 0.20079415108889853, -0.04905273427567974, 0.6563025253338172, 0.8302070730606724, -0.627080390266695, -1.2192195387984486, 1.105420244264697, -0.5505227426422501, -0.3376825597637588, -0.03019508124164627, -0.6277262219400982, 0.09365817830100301, 0.8837818500757337, -0.3777630126201132, -0.6251461027883412, -0.08980548919990453, 1.0778010978408843, 1.070370135124836},
    {1.3514782906478413, -0.948046630742039, 0.014353905451073817, 0.036710800149895265, -0.9871357944697058, 1.3685045180182533, -0.2813628392935456, -0.5812287882548193, -1.0854739009599725, -1.073999127367732, 0.5517562743080784, -0.174318959299343, 0.6248052414834534, 0.9023061406569082, -0.1973901085990407, -1.0479409270671491, 1.0673565298608845, 0.18418974675885652, -0.703687399006819, 0.46310958286507864, 1.3173287761684878, -0.8577977313031703, 0.973339913039917, 1.2243937448198634, -0.10331972441801686, 0.489944785216927, 0.09402240438364402, 0.7516906417769565, -1.0864348012982803, 0.1428066079405021, -0.6031166353202398, -0.6058507375368454, 0.14385360759026194, -0.5941998032088022, 0.9388248289025278, 0.03756893042971827, 1.247464702723813, -0.8715267304866263, 0.4205357220939036, -0.5694463152325582, -0.8337658696142389, 0.20556820594755887, 0.7311694597510919, -0.2342862874137683, -0.1781831861805079, -1.1350748317605874, -0.08034882822966297, 1.1716306099461704, 1.3000722482050249, -0.8693443758699664, -1.2354894797713498, 0.17119030105868266, -0.03851308642252234, 0.6802460065592084, -0.13993043954325607, 0.3653049782215558, 0.8584068005088346, -0.4701971394663239, -0.2605810114275678, 1.0907152456901368, -0.49311715193262257, -0.6952704245911584, 0.7764782764288374, 1.1402432280126378},
    {-0.2977037356712132, -0.31852529262959195, -0.30115906625032424, 1.1197353631422553, 0.8947024519533905, -0.4011159360206981, -0.30796420423577997, 0.031546907980379714, 0.14326049132688845, -0.9128267307389396, -0.051932303116356764, 0.038801376798821195, -0.005091086690459039, -0.2582564421797069, 0.660013409292837, -0.5572911454313556, -1.2412486097542295, 0.44997746892157225, 1.133204621715457, -0.7705908937956555, 0.8766338826645667, 0.7056310452977503, -1.2092344586377024, -0.5343942319839257, -1.100389253230792, -0.312249668053543, 0.7887383538548324, 0.4761129540167562, -0.07143056955403698, 0.958021382120769, -0.30140819406000185, 0.8106335172299817, -0.9445701331702195, 0.9030339205763588, -0.35849815155472664, 0.9789950159295718, 1.1044334956708872, -0.9335251192879245, -0.3887800833462209, -0.09214946984240774, 0.9262013675331803, 0.013306041798566386, 0.10717212355563066, -0.25873189127049906, -0.9622365588691717, -0.595307727482136, 0.010613500266897802, 0.5613098220381068, -0.13182461742066534, -1.0542761314638678, 0.1565097323395729, 0.45861718822201725, -1.2170312549618414, 0.36422669382471806, 1.1251876789569117, 1.0667879454562015, -0.7909059953295657, -0.17920096023417356, -1.11077244987911, 0.7006378931899812, 0.6150944977754512, 0.1389945307408628, 0.4374310911686379, -0.2208974633227246},
    {0.497699018699475, 0.7164959202502272, 0.569957246313907, 0.14550823564302634, 0.3010737914258081, -1.1862610121952428, -0.9887857977024385, 0.05906994529905703, 1.046537237176794, 0.9528708958778793, 0.08840767658977462, 1.0596691317167384, 1.2170787737192619, -0.9145199355756486, 0.6536226759958319, -0.2717455590982603, -0.6266222286598191, -1.1893511183823982, 0.39296090852302235, 1.0522405649119295, 0.7743628349140961, -0.9247455524660223, 0.8078582571910419, 1.148509689645051, -1.0171690844834638, -0.16023534827567681, 1.0140773903694722, -0.008761438045150161, 0.31735566392359815, -1.1679402464026525, 0.10111238753889007, 0.48660245183182327, -0.6318638976309068, 1.028079555532651, 0.6684037548454256, 0.15697523272778266, -1.2248106963614103, 0.4241577303481643, 1.1933083450633974, -0.5795395664136911, 0.3033223381174201, -0.6424139318409144, -0.15910225253482105, 0.7185767534324788, 1.141735097423145, -0.00984058978634615, -1.3341370702864872, -1.0718380470805975, -1.1775618367429597, 0.6756864328545064, 0.03877212507835995, 0.7331236893905044, -0.9931662075993508, -1.1459297355128952, 1.050116095468932, -0.6241707782126678, 0.6648247215718882, -0.581758118518203, 0.9314001758517021, -0.1893246104986253, 0.4937756163027768, 0.03605968714679997, -0.25042333001409467, -1.1478959313638522},
    {-0.22030534102047802, 0.9503792646898064, 0.27548896814582424, -0.6579607995538231, -1.0076834360986584, 0.5382147135830124, -0.4999124904046076, 0.5970500804187284, -0.5888092190150398, -0.9412453244381569, -0.8269446156297433, 1.0264553726195633, -0.4280077810609794, 1.3064306944212867, -0.6470399753050555, 0.684358567342312, -0.3580585486665053, -0.15050842704064138, 0.16563225066221263, 0.16406862082870863, -0.5050525984215235, 0.5416449205035007, -0.013066468487679363, 0.05072008133179407, 1.2222840899076433, 0.19156061217641326, 1.0738072416202122, 0.5190375064053205, -0.05519026690793588, 1.069045079054624, -0.7258216126424717, -0.0569312590976193, -0.1819970025960043, -0.3123447757584784, 0.5922986801727423, 0.6452309458326002, -0.9014904541008811, -0.9527644870048738, 0.10360657529575597, 0.8132551662670805, -0.8039552716208822, 1.05989636281651, 0.5395029721629513, 0.24588563109494424, -0.43480415893524155, 1.1445774494583674, 0.5491085957178717, 0.2940870341920561, -1.1050713595427193, -0.413513923503528, -0.6199986001617949, -0.1817366986109486, 0.03700104171876316, -0.780271286666873, -0.5525977482193735, -0.640968873164374, 0.31727772619240635, 0.40215154171493106, 0.9967391671895213, -0.04144874226890901, -0.008741731995278392, -0.3949041064210934, 0.11144446486321802, -0.6857787631608445},
    {1.1099210447335457, 0.5396480586302959, 0.09260521499480714, -0.34512471538531697, -0.4083719059970153, -0.4478281028259072, 0.22433347742423015, 1.2284088545891492, 0.7159231649335323, 0.3230963937586348, -0.10096966870980213, -0.6877487725180166, -0.3726062101295199, -1.1197183207985184, -0.31682283867994554, 1.0638383739374053, 1.1100219835081426, -0.11590040621960264, 0.41058819598109303, 1.043511247367591, 0.1202307741451953, -0.2640940210368873, 0.48421024996500217, -0.6581282493192409, -1.0013878174844564, -0.756570558361175, -0.3339532164427672, -1.194879716101374, -0.8030275981623181, -0.5350561969738001, -0.3529063604101126, 0.8932972333006421, -1.4964481999734585, -0.13321231504936468, 0.08214930813507741, 0.40678776281621515, -0.2325032711041412, 0.4899851773181463, 0.6484658463897369, -0.9103349142912349, 0.9119466830438908, 0.11511240915273838, -0.6571669660474648, -0.18136212080520384, -0.8857928838884436, 0.1869299353085607, -1.0602073040101356, 0.9355900073881431, -0.8821991253056752, -0.49588014859802554, -1.105340509809767, -0.2848832338149007, -1.4006356444217007, -0.11117627335882645, -0.46967517685374166, -1.3118096168018545, -1.4256622554847405, -0.08922768029537106, 1.025231897090729, 1.071644528741079, -0.40956314748243927, 0.748418271052648, 1.0104126333086025, -0.5892739185166789},
    {-0.03775718430286099, -0.8599087801528454, -0.7572101612575822, -0.6386669582412978, 0.16408339530628002, -0.510685210304021, -0.5500977115358938, 0.7684991675631443, -0.6467747657007918, -0.9942974806535694, 0.3990958252601283, -1.2415901406862995, 0.7442458955860025, -1.2049193474037874, 0.09505088480429146, 1.0736515185338267, -0.15543372240329, -0.5824192410889967, -0.7115334415670567, 1.0126759010626316, 0.45526574002237385, -0.1481616852300828, 1.1204677196481976, -0.30594508701207457, -0.4467385930004546, 0.44740744678208366, 1.0400962767689284, -1.309528245700557, 0.1336992597919071, 0.2368856921181699, 0.3479567197653684, 0.3427109680519689, -0.007406712626647661, -0.5317365720797723, -0.8119621228610517, -1.37324876129238, -0.10226834890088414, -1.2862797954764473, 0.6523003249657436, -0.29826392915885824, 0.6059637219273644, -1.346872254005906, -0.6269998771024303, 0.8170847766140289, -0.1414613054263209, 0.6864446881863041, 0.46959326771426113, 0.881038646376325, 0.2413176258570812, 0.5702284085188972, 0.22655102622908105, 0.23663467658588008, -1.1736787798002724, 1.223905607864782, 0.7793595837117784, 0.7771410061580503, -0.7109576032053636, 0.7223840581265096, -0.7935066278144788, 0.6093103313561433, -0.0004347444384092075, -1.0361087130607018, 0.9205561942964912, 1.0814381859500237},
    {1.2780645761478124, 0.5605096508538404, -0.18434822872972276, -0.7433709036682375, 0.12776014757276394, -0.9414019441522072, -0.6867948381948593, 0.3446077183588796, -0.5218018632318201, -0.5291645579366141, 0.9930181733048524, 0.1778423628213854, 0.9952156640994186, -0.50737318954868, -0.06518048070546298, -0.40010339339947015, 0.11868758166162784, -0.7817081643825385, 0.576578193615946, 0.528572602924631, -0.6848392894106162, 0.3426258463014614, -0.5279247310908013, -0.7305386802048031, -1.2596035158849828, 0.21630065352457478, -0.4520620274985228, -1.3624462232619694, 0.43850917187428295, -0.04107959064086312, -0.38263279620842555, -0.7364702552754656, -0.011484323818614464, 0.3168667220225831, -0.035482758393061024, -0.8058560607442441, -1.2221608734551621, -0.42662232871027034, -0.6712680770228847, 0.12385131779041914, -1.0090531636839932, -1.2443260164310748, 0.4610890305355532, -0.6874796749129961, -1.2551477457567377, 0.6836675898729824, 0.36520382503439974, 1.038632143521228, 0.28344461145613564, 0.42346659071102966, -0.5684317650360726, 0.8517743699527436, -1.1457082843065356, -1.0485484322616534, -0.8191660195843388, 0.9491316646466815, 0.1495795413246999, -0.4698191909409943, 0.2569592044616789, 0.649237052160737, -0.4276895846944641, 0.18747359699790006, -0.3805381043356811, -1.2229201830993144},
    {-0.3411229121332847, 1.0305933397534304, -0.16514674133726057, 1.0580919856100437, -0.20152098770340682, 0.7113908134887006, 0.10475345266976131, -0.726213908179886, -0.9597891026626412, -1.2122119312229425, -0.21633304816909024, -0.28901462958529295, 0.5927954937457215, 0.3240166175516488, 0.5567775059073373, -0.8374255578137594, 1.32207836096549, -0.6289492150783267, 0.31985905189294545, -0.2261658032316104, 1.1880740660192697, 0.4741959939053553, 0.7006857929224182, 1.0289627956201484, 0.21270901123179206, -0.5803827412718925, 0.14791098524287563, 0.34039239627361007, 0.3948674751424463, -0.48404554351634044, 0.10282507756021003, -0.5760988359127355, -1.3643727460651849, 0.6678256839322075, -0.6075105095339399, -0.3972079289582434, 0.33300043138114827, 0.3045934271605837, -0.8355049762085681, -0.29353135017002485, 0.8109928398446942, -0.4418236305726624, -0.8848745923472706, -0.35736787035050077, -0.4391687733044656, -0.1193588233787169, 0.14101775523293314, 0.1730320687078609, 0.6872523466817438, 1.191885498883173, 1.2632313319762065, 0.9352333845619932, -0.5396795313340795, -0.6194768081840767, 1.2670791048307526, 0.158499801782123, -0.5573767488520861, 0.3746197988909853, 0.21520083358153866, -0.6308024420590123, 0.11377597132636795, -0.29860811797454734, 0.42763294141879016, 0.2902324605783413},
    {-0.76992948964526, 0.13562420288118093, 0.529586429844543, -0.5557110661183733, -0.616898097679205, -1.1249343625703014, 0.9702029715525808, 0.6705577609213723, -0.10716010766549182, 0.04720310170800454, -0.3060822422230013, 0.9945804042952007, -0.49168220727392714, -1.4875359022357946, 0.2814886136827324, 1.0974524476976923, -0.567861302793541, -0.959864909521964, 0.9149258971106949, -0.4433945714723969, 0.9162545984813466, -0.6777873893789204, 0.4836063605194197, -0.7340346348152152, -0.9463746725086708, 0.13490118947271246, 0.4065495237909639, 0.9568653745104849, -0.6828036115218366, -1.0231636130731576, -0.2917652686704434, -0.9792004656259187, -0.38264659747378765, -0.08595345351239055, -0.7923603584639951, 0.5090707372966187, -0.7308285411509265, 0.30316483886784457, 0.3619388682205026, -0.869078809116006, 0.5951900179052737, -1.4003807756833069, -0.6416015526941139, 0.46119576825563063, 1.004998012086098, 0.4352633851837586, -0.20745873610667828, -0.4560963951606805, 1.0145080491523946, 0.08969945401416561, -0.4097386608381829, 0.1818245601386599, -0.2614357016056976, 0.0313092783615983, -0.08876204896927667, -0.07198708673265204, -0.3711657050850973, -0.5191693928683647, 0.10065373205802387, 0.7835189978238244, 0.17886390492640164, 1.150394075771962, 0.4967050194755704, -0.12921891952111036},
    {0.16374567779215335, 0.47444353967693625, -0.9736853973331093, -0.5300933506594093, 0.2005013283408178, -0.06895840296812358, 0.007171022453589229, 0.5712882922505732, 0.08212572525262837, -0.4469907935978735, -0.6898553088328614, -1.0195619365892274, 0.16650902438751888, 0.06149055406583349, -1.136979494231869, 1.0119621155561513, 0.8122697090317429, 0.3670898662049808, -0.9660225374806624, 0.8297905687310875, 0.8069567178417769, -0.06935232329720029, -0.7097521116671962, 0.7279786035869324, -0.4089134702922763, -0.5770952180129776, -0.8555917489163513, -1.1684017134528146, -0.9750056777377718, -0.22281631757370238, 0.21847392152399442, 0.8831722758434275, 0.015412477513733973, 0.3989275757497318, -1.1265983110825037, 0.5643141344546313, -0.9042273182765278, 0.7876558884394453, -0.3597557220936746, -0.23062041142625064, 0.7378687553230037, 0.13988201978351897, -0.9128306943894139, -1.0453311100308815, -0.2675899801215687, -0.30825467888423363, -0.005208875044784328, 0.3396092005194629, 0.13091481716077524, -0.1234365137108285, -0.6795610108587051, -1.0334807012046099, 0.7015185911814553, -0.8729946384557656, -0.11341144772141977, -0.12892648871041903, 0.6792080183652471, 0.5245267071455809, 0.681941352172544, 0.4576904235616882, 1.1269157344828413, 0.5097558614454237, 0.18809141661701734, 1.1078364531251703},
    {0.4746708584483922, -0.7041014794052673, -0.6644876429860548, -1.056632443271993, 1.092913289443723, 0.2829654609993494, -0.6528290911065715, -0.9109742317315063, -0.42428258233603094, 0.01358137812024731, -0.2438258152292344, -0.11152708714676123, 0.32197870533366385, 0.2341359757969352, -0.7905158970483711, 1.0225392313634998, 1.263277434289489, -1.0418789482336046, -1.05703683209554, 1.0827841320807898, -0.12167761421074828, 0.9125607514475941, 0.43378772539414834, 0.3753386193825051, -0.7031486394910339, 0.2734531869462754, -0.4490763277210194, -1.2418439034272661, -0.9280661830701077, -1.1594902601974386, 1.0305368674997692, 0.81266573067297, 0.6329755374666344, 0.3477041431443646, -1.5767294568631933, -0.026904829792096335, -0.07090352213793158, 0.9844108193772096, 0.014213812673580567, -0.2813360237290853, 0.6415250422222641, 0.6682637306960312, 0.7098033864351059, -0.7131490832964058, 0.4534927071708181, -0.8968150115284831, 0.8593207557118527, 0.9031289979342609, 0.38845957011933097, 0.31437342986778843, -0.18378779143227694, 0.38006753754492106, 0.6449262917194859, -0.28142790388947836, 0.4593442694250271, 1.139339483378871, 0.42245660399254736, 0.9202385626905532, 0.7070680223844136, 0.7743897018566298, 0.028620444125038527, 0.6501806015604435, 0.010276000483161369, -0.3193073741416751},
    {0.5670023773449677, 0.12262084531282695, 1.010703807861498, -0.48064065815761586, -0.572531375044615, -0.9009940072413009, 0.0019635519335004293, -0.36494542739288555, 0.460696088422631, 0.24864748989755842, 0.4463454359987754, 0.6435399648411633, 1.026236485448985, 0.2585481238701468, 0.741254043755552, 0.21150844082952247, -0.9496801153672836, -0.471992359415236, -0.8075725765429311, 0.6379589989008273, 0.37752564264200555, 0.6350433715680054, 0.3703664344843373, -0.825764494137727, -1.4894840349463287, 0.09501383040506023, 0.5248486177145609, 0.7132101515931318, -0.6059298977006087, 0.9947274804834021, 0.8000831084854414, 1.0889265716944776, -0.3278891704088774, 0.6053106655004206, -1.383373691056333, -1.3288514953603083, 0.39544398423921184, 0.41725904539666653, 0.21561309279696173, -0.22760141740959217, 0.3112334354119509, 0.6932315868652998, -0.644488906038213, -1.0265342027761386, -0.7409849132144672, -1.141254343245029, -1.411736184627469, -1.4855089064628868, 0.9143684786478015, -0.43773204759825274, -0.9864208563684655, 1.1625915642669133, 1.030991618458464, 0.25082454289923156, -0.02034793461895957, 0.33472165750632676, -0.22809297792147057, -0.9112745033699127, 1.1262025465681575, -1.0394903206822055, -1.3296757639983725, 1.106388138276974, 0.760132522812807, -1.1513652855647472},
    {0.7183001745484651, -0.36242775741822625, -1.030877772440028, -1.2780307568376679, 0.010770949356521361, 0.771421170694236, -0.8717138797135218, -0.8570139292545569, -0.5901716840840668, -0.9387352939477973, 0.8706504180425528, 0.3589029105620384, -0.5257897341629986, -0.9044543856041654, -1.1575982245210648, 0.49580916039224815, 0.9679131828674642, -0.8048313732848841, -1.2779844245321927, -0.42650131234189537, 0.6407219026604277, 0.7399095462366787, 0.19765794939858772, -0.4837028021836156, 0.4087191099517146, -0.08041421535374393, -0.48268073083419183, -1.1293438162663345, 0.596402483481375, -1.0165146220256143, 0.38695866156097625, 1.2132014045491244, -1.2003694884437908, 0.20952124484408113, -0.3576721536418712, -1.1689749807401302, -0.5320074839325252, -0.5433750785207079, -0.3499761293119622, 0.4203100837422335, 1.077929266397997, 0.24274313288823302, 0.3678750122643436, 0.046837504779450076, 0.999947707017189, 0.6595925672408521, 0.5971513644364546, 0.7189848875101004, -0.1330164112660864, -0.1346406786164284, -1.036685218295041, 1.1720300643479875, -1.0882902396289578, 0.24618353981980176, -0.4504046902134009, 0.45480398942981004, -0.22321077744077558, -0.9277801959122579, -0.07684252502337005, 0.9814875454921691, -0.6480073550870299, -1.1972510592080217, 0.6352482194153553, 0.7182018675698456},
    {-1.250688676141104, 0.1851989134239011, -0.1827071667017542, -0.6163611188161798, 0.2789812070930834, 0.651699846365274, 1.0475136303509733, -0.7068687943318175, 0.8683265231140794, 0.4079379239868922, 0.16646289525698282, -0.3250383891942057, -0.3469508677441463, -0.7815074004902545, -0.7420988309488709, 0.23781778598459846, -0.11359344780893837, 0.53170269186621, -0.9657462268363829, -1.0685997296217755, -0.8662354291563283, 0.3653419949361617, 0.47627969240118867, 0.3817124179500848, -0.4949817476067345, 0.9825749288693107, -1.108994426472398, 0.6935969600664481, 0.6959982191997459, 0.4988470766497263, 1.0343662333375567, 0.45292499660189806, 0.5573714416135741, 1.0772826784602945, -0.7217966714277613, 0.9653410115992407, -1.1693144675104845, 0.8067007006080037, -0.04978537292791607, -1.2321596160346668, -0.5004004452666168, 0.014210000233152052, 0.8402613274445245, 0.2900945968123043, -1.363107103456626, -0.003668141922584478, -0.8540146796599558, -0.6807070264440735, 0.1424142107503135, 1.167971801670081, -1.3246363193317818, -0.19255470661529053, -1.1138060114014119, 0.0782620967742171, 0.5930079098732116, 0.5576317037573576, -0.5720276808709671, -0.6648209788449491, 0.007546886052607783, 0.8626115976299923, -0.5782419879301889, -0.571417871907084, -0.018925611540168533, 0.8278769107734457},
    {0.8226099660639585, 0.06350346777118696, -0.46297865907515606, -0.21867137133787215, -0.81932159277407, 0.40658803260092385, -0.0331692622942039, 1.2394898400963301, 0.07147221488297638, -0.22218614281607643, -0.6523358725250057, -1.0332700877724177, -0.6944268300207723, -0.2717845397294971, -0.6089625205526188, -0.3516690155308422, 0.230102620917294, -1.158634925183337, -0.5637821479502352, 0.9131107256154988, 0.4926298996166743, 0.8417802669623453, 0.5084930130139965, 0.7088142850322485, -1.176263435095514, -0.8023289610836866, -0.46319812410316463, -1.1525596633279733, -0.9259010569291292, -0.13302591736506378, 0.03622717400597948, 0.8070490398242736, -0.7735931007367804, 0.47573150074857445, -0.4646183915236144, -0.9744998497400775, -0.5767464623512346, 0.520532614630295, 0.5764571530748478, -1.1718249117326327, -0.31053045327132844, -0.16106805392958537, 0.8941181013151452, 0.10833518297707527, 0.07802454477876528, -0.16232389503193942, -0.3292645073803691, -0.5061824639123469, 0.1776756025954149, 0.924011944304416, 0.145668558689973, -0.7698376784444632, 0.18617748805089787, 0.12156237878172724, -0.836326818044668, 1.0416443535686946, -0.7424487676003093, 0.167900016026639, -0.19932328589433418, -1.1379792521415564, -0.9328791533423038, 0.9638535201948122, -0.3341895547296395, -0.5198465855613379},
    {0.5226317545629724, 0.14835089783608138, -0.840030106717254, 0.08697299652009954, -1.0238338529760338, -0.43411983444038726, 1.2119626472378837, -0.6068029661014659, 1.2580887575599393, -0.19193025829811455, 1.0096426230001918, 0.476937926502998, 0.64011550004227, -0.4429288500219252, -1.4105133105476932, -0.23687401167112804, -0.6574771514338312, -0.05126990669297346, -0.13019972813709738, -0.7431262502149109, -0.29253379541736835, -0.5247703352636925, -0.06133343085843247, 0.5906172961814334, -0.21685688761771346, 0.5812921550132989, -0.7369506086752096, 0.9725214069104395, -0.13016810160601908, 1.2388820602823378, -0.3957181468348077, 0.5497926135202399, -1.1182907565232898, 1.0040382555057943, 1.0722737650649983, 0.45482631485905367, 0.9889466019227815, 0.6865952911091706, 0.5744927003903815, -1.0930454629831754, 0.7819092797712704, 0.796037561488405, -0.9852634460347965, 1.1961156407820062, 0.7874508954870081, 0.5605101225623915, -0.12715278069690847, 0.7957604790233875, -0.2871805301180141, 0.6468821207358849, -0.21609175675208273, 1.046419183669875, -0.5480390223787531, 1.1119475190787067, 0.7330019125346804, -0.37415359242992907, 0.06406054776075178, 0.49210867570412814, 0.6351271737573257, -0.5287502960177658, -1.2595599001540565, -0.7703642096256857, -0.8977889543905255, 0.4068949887441485},
    {-0.9119374193181725, 0.24583142164801408, 0.45979561061208407, 0.8892250971428539, 0.7537624556959579, 0.2764909232382922, 0.8089019099594096, 1.3857485376259553, -0.3815139196373163, 0.08355119969304037, 0.37314729171602457, -0.7076863507319063, 0.05661951991330957, -0.39729315447232333, -0.789770309290135, -0.36223333525366286, 0.3171028368728858, 0.7624426818930586, 0.3733292765526264, 0.06846141678516145, 0.7995030952055966, -0.6656457550187844, 0.6899253012511629, -0.3383542242221616, -0.49662533949299964, 0.71897026263435, -1.1899131066330295, -0.3321933365817289, 1.206087112868226, 0.5197588407728643, 0.22587459221176062, 0.2670798209920633, -0.6588700430963589, 1.058009849127713, 0.5400332545897994, -0.8880898506053437, -0.9020503516896936, -0.8183391495821265, 0.7600420684708639, 0.3728354177172043, 0.9189399615802814, -0.6264208953926609, -0.6673233313622293, 1.1233032316356741, -1.0981513362995454, -0.9647249782505619, -0.8048496266111124, 0.062157089277153604, 0.7559774481081483, -0.5063664473196341, 0.8764609928009668, -0.2220211934364653, 0.2733004348269199, 0.8858280960079535, 1.1332896282280123, -0.92848375811589, 0.5900412686879458, 1.3937028022434372, 1.06101395494431, 0.6989488153054333, -0.492568212891145, 1.1917373562551619, -0.8279593528575852, 0.062415297849008594},
    {0.9629385144544341, 0.9146191882323503, -0.11654916326512625, 0.24430117080316896, 0.5074159550833219, -0.6651232355135703, 0.6114612777955654, -0.7389522106592762, -0.7016851272876544, 0.0452454445550865, 0.957752221802991, -1.3123812107908894, -0.6151638034263218, -0.49268682267540886, -0.7378010952132953, -1.0599921736629265, 0.08846594326126492, 0.27696690642586896, -0.11671535054796577, 0.007859384484899912, 0.6276840566431148, 0.6613080865179144, -0.3156192176238125, -1.0823366354659203, -0.04194138309389483, -1.1300746889340247, 0.7925504102035508, 0.4535155945219586, 0.4607725493543443, 0.5532374542038011, 0.14286142907893465, 0.25042093932711, -0.4127245901577586, -0.2655760955084535, 0.013477423980833035, -1.1590580207934686, -0.3887413170603998, 0.05122890623071011, -0.6449826025474027, -0.2996499388895498, 0.7323435913938151, 0.003460649398394643, -0.9414149648526026, 0.7851226437164973, 0.17946136073343202, 0.2325161052545421, 0.9819806747172977, 0.23374026160589786, 0.6949469333467272, 0.3291447394630241, 1.0080518537718532, -1.2138226916548747, -0.6043174296367432, 0.7016779315470374, -0.31969771554649795, -0.83821874099085, -0.29786576758782823, -0.3389407659868765, 0.19166107957565107, 0.14545952018002994, 0.7505599415308633, 0.001353300302774866, 0.22197071989211545, -1.2124260235064952},
    {0.9370631820044701, -1.411837868849219, -0.8783784048066265, 0.48507353556102695, -0.04157833878688161, -0.45106353744749705, -0.5740269281066022, 0.3294414860079956, 0.18462689553285583, -0.5274597620357695, -0.982342415263626, 0.638538360381788, -0.6062616656404539, 0.43099029579921266, -0.445847862815518, 1.0383086693214774, 1.0122016864905654, 0.644162762393082, -1.1224802163035448, -1.2095028800635945, 0.6832951873867368, 0.8332354841995724, -0.42188028270114886, 0.2748916129722791, -0.9011209933402774, 0.07283791167279911, 1.1160200912727518, 0.990439727493849, 0.4137393942632284, -0.7562403844484824, 0.6556794428389611, -0.9698759517274309, 0.3584401339619735, -1.1106323327672836, -0.7524321135765287, 0.6269770320149908, -0.5519150817351034, 1.1381423465647464, -0.09542707237481479, -1.1100463718107085, -0.3910754841295923, -0.10022811620699623, 0.39337923708157807, 0.5661101088607614, -1.104244968314804, -1.3312463214424861, 0.5574526138615139, 0.3881380202443135, -0.7593414130233863, -1.1139926647605862, -1.0860779937409488, 1.020950478787946, 0.15937151751073195, 0.8131322890602565, 0.18742431133048093, 0.842804828338585, -0.24739601968004457, -0.20144147617379393, 0.8291858790265497, -0.5508292601792265, -0.8381590757707716, -1.0773556220636265, -0.14068617466839944, 0.05279687090271292},
    {-0.8210690021229968, -0.47498157049364, 0.884753253362149, -0.36227191077735715, 0.7508555145320823, -0.5478205899728393, 0.16113363552701518, -0.03995094494730531, -0.3987854584582598, -0.9143077927259359, 0.07874681519546779, 0.7857706897886056, 0.1837045858402823, -0.12625552467810577, -1.1289054453517513, -0.06713085522267503, 0.7256858431271715, 0.26773318426599385, -0.027169624487162217, 0.23204497784548203, 0.48930666636348225, -0.7512985767511369, -0.5604149887980215, -0.23475868790884216, -0.9030243756689069, 0.03837427407835707, 1.0667526980834106, 0.9707976545171764, -0.13669514244825773, -0.4151556719596203, -0.43767635596758564, 0.9662798536224132, 0.7101546049398132, 0.257813548870584, -0.3932827379178773, -0.6821413771318876, -1.1406908687986455, -0.977923901630514, -0.9090571417402065, -1.3675037365499707, -0.20418624522621442, 0.8325401402325089, -1.2507333890617747, 0.13212101006999113, -1.125970345880976, -0.4663638977775192, 0.9262202614731951, 0.3589710942307298, -0.26878634225031084, -0.8875198532021794, -0.2546869397505609, -0.3803985814821592, 0.6902649656321619, 0.4066323036948399, -0.9322782387560553, 0.92144530538449, -0.10058966541070063, 0.23213138413603454, 0.14575756815884913, 0.9801735587675278, 0.7564961567101077, 0.6810053409916785, -0.5648934650984755, -1.2456008699987282},
    {0.40826752382665815, 0.60978471030938, 0.956545215454285, -0.598968046195586, 0.6064853397295598, -0.31122306985420906, -0.5143831184311088, -0.7302994120229451, 0.5794139219210126, -1.2005118625176112, 0.9835664137249851, -0.5719520188984699, 0.43250917982334364, -0.35465079431586266, -0.0887673492393549, -1.1417574314535786, 0.4411831577759114, -1.2828314837080887, -0.0016786424167381398, -0.3934478586018103, -1.1229614501696552, 0.08270404595150663, 0.7437211923194829, -0.0039595574722613896, 0.5546174077038568, 0.3814263790300049, -0.8721598353626024, 0.27000447730173427, 0.6050806810329071, -1.0721038107517626, -0.6284458204104554, 0.22377412437328756, 0.5830311518633313, 0.41287781319219813, -1.424838623569797, -0.31959739943423066, -0.637013037112559, 0.44698186636974124, 0.5265388018039933, -0.10817672760251748, -0.04735336084807874, -0.6435319916542896, -0.7663940405665097, 0.1928947154144466, 0.9268567342308434, 0.13357711455016866, -0.6876207237895613, 1.2418926969814483, -0.5753478537797461, -1.086766449631755, -0.3311883765349051, -1.3673440386281557, 0.006090404792814982, 0.8232585589404618, -0.8739391774797443, -1.0822950014556005, -0.7303939926716077, -0.08735553023341575, 0.822765112894734, -1.0450068651304802, 1.024017955754938, -1.1676812492775812, -1.2506271093181478, -1.2725664365158826},
    {0.9963066823134513, -0.02265227897064538, 1.1329247992471978, -1.0315940870294629, 0.8118202755771171, -0.2012718806745839, -1.1959680434080382, 0.1443212795776041, -0.8121603841202727, -0.12290123365852691, -0.8797680032152149, -0.6867079368618927, -0.118975589686251, -0.838993838019691, -0.9419770715859485, 0.8784843533659206, -0.8520898161942739, 1.1487107498195295, 0.6741957812794986, -0.9606578954554895, 1.1496747275431125, -0.9250865920708489, -1.219624671806247, -0.03561074525293914, 0.6833907969983289, -1.0367236082281646, 0.251136259279844, 0.6204212208230013, 0.2806234157014561, -0.37780778496866696, 0.39820430033121157, -0.6341971118911336, 0.01605473333808676, -0.8616206883312123, -1.1264086788116403, -0.45354376124309265, -0.04533244966832281, -0.7754997270406864, -0.4727949956264291, 1.101889821336326, -0.5154696408321897, -0.3350269535625038, 0.018483265733690836, -0.9755415624386637, -1.0575129792142934, -1.11245159150353, 1.0317667631713894, 0.12057485759861547, 0.7483683885983552, 0.6351409226663958, -0.63926174767586, -0.029110076500337312, 1.0472735103599813, -0.736123792650371, 1.0226765448659094, -0.722803196440686, -0.3312693854070297, 0.23105391311598064, 1.2439789526245049, 0.7098027795953282, -0.39433298966653246, 0.2354342672960935, -0.2989536513770295, -0.14442370199389185},
    {-0.8153551222308123, 0.7275336273417176, -1.2171103763652236, -1.233977471171264, 0.30648274085993, -0.02628840512442677, -0.054348704619141056, 0.7367320759741114, -0.656232252518494, 1.1937560424047935, 0.07570190803693924, 0.8250451873657976, 0.4688970448674914, -0.3191267709219482, -1.4830305381693667, 0.09924534136831455, -1.1790898313220146, 0.3961592793442693, -1.2643334229542718, 0.5801279763229825, -0.2140264573463188, -0.45727468572582936, -1.0560992548585897, 0.5232324636888792, -1.0775213636209682, -0.08662627844212942, -1.1467199659696274, 0.8568348093005732, 0.28640092441936915, 0.14228046260987426, -0.60371539151522, 0.32984189767697947, 0.46805595473890443, -0.939078447095651, 0.13649955000752895, -0.9773556600442336, -0.8487003362219785, 0.5349760654276865, -0.9345680803775411, 0.1656109276043962, 0.6954139985020144, -0.7134963619871992, -0.7373271895140068, -0.40634875920735225, -0.8395091162555347, 0.3661014900644651, -1.148937275863665, 1.1621968492189065, -0.9072720302168281, -0.5996369048652602, -1.3358372461811507, -0.2807708520882295, 1.3418612829275143, 0.16785082588316622, -0.322161845953861, 0.8688253039600652, 1.0822113305532315, 1.0381272292217232, 0.3857183060715193, 0.18723208357608787, -1.4173750310983044, 0.8108424467054755, 0.7640624903324136, -0.7362557766473643},
    {-1.0864347206370666, -1.0102505087414109, -0.23220255895661787, 0.6897251553337974, -1.2553628905787984, -0.546279388884745, -0.171524127066822, -1.0767872893900132, 1.2313303592667393, -0.6044463751045697, -0.42100713248983473, -0.3436545602968641, -0.9983870050955589, 0.7117297924367864, -0.8725740413010884, -1.2974678682015965, -1.1368084951270017, -0.8013225891278951, 0.9713293325438552, -0.32882875327839356, 1.126978957496307, 0.4199038239079067, 1.236796448018112, 1.0829829472311645, -1.0009350177724579, 0.879819205547242, -0.31908041573989054, -0.10535364607320238, -0.5724581049119954, 0.23373211779363182, -0.2317891558917208, -0.9164337431674735, 0.3780511803510215, -0.46369395608926167, 0.6341222623149066, 0.23133435619570022, -0.060670910846849516, -1.3376078966527833, 1.269241321073049, 0.3623733473491482, 0.8966915616831544, -0.7127237154665977, 1.0267848329534415, -0.7153606531691976, -0.020889085469040947, 1.1377748298352248, 1.0384744537998802, -0.5773388484551442, -0.7275334982187412, 0.8262057562163055, -0.3770789115018258, 0.787337808501982, 0.4448665633098553, -0.09453468675831153, 0.8961798113765488, -0.830839757728108, 1.017867253079074, -0.13212536487640594, -0.46284645595596074, 0.9420544431645422, -0.7941433262266417, 0.21294579772567704, -0.5046581054518544, 0.26725765862836864},
    {1.2752405511264302, 0.056146234725918225, -1.1574838878999472, -0.4592986182248578, -1.2815066337379886, -1.0536449648258908, 0.23124145213214603, 0.6439578504256025, 0.3292495103421038, -0.021886937989202482, 1.1717920083332345, 1.1730083458565064, 0.42846772498410096, 0.20475809936135606, 0.5463899152451046, -0.25983238152892324, 0.8339327164345242, 0.697822175904078, -0.7143779811678015, 0.33545272931477504, 0.0881640514649497, -0.4604544694996947, -0.36606214569572154, -0.3874149937383186, 0.34570655692133884, -0.25632585485557846, 0.4746244328549728, 0.44341589135765935, -1.1934672366817742, -0.7123765693513769, -0.2731527405346735, -0.9677783319829213, -0.1883353665911723, -0.25748263031904717, 0.8263967985616296, -0.6475138042225619, -0.399940990737326, -0.5670423091746629, -0.6477771967192935, 0.5663221375107874, 0.7091708335024213, -1.2056402608417027, 0.6490899530298264, 0.06726296782288017, 0.5443704053214892, 0.7982969517490484, -0.35932394392798045, 0.8510915192017919, 1.2361755259693148, 0.0815439153773095, 1.1272259166814271, -0.12786121966475775, -0.9798422020163237, 0.4679703876218671, -1.056868331810294, 0.09794942080054467, -0.5167061020931863, 0.45540150990637435, 1.1507674353515522, 0.5228787964398228, -0.6472715335745118, -0.7305802021597811, 0.1729819143002011, 0.6021575170981606},
    {-0.49831085652994733, -0.6774294917052105, 0.0054383608595439375, 0.26806181691731545, -0.9935484621065399, -0.016953332321513068, -0.6323105668654496, 0.4293219880066552, 0.07845207969223938, -1.2679534558876795, 0.6628236550966712, -0.5691674535703669, 0.6553610690272792, 0.2517806165195873, -0.967917468454625, -0.942506436127983, -0.24775028401307547, 1.1034997247341962, 0.5480734298164281, 1.1594407970679024, -0.32782243082521667, -0.0917946891115275, 0.20778787497542153, 1.3816450850874045, 0.9425984214686166, 0.6839471793324673, -0.8525185282153253, -0.020859024486617517, -0.04134225191346958, -0.31237220985565894, 0.4773021751594313, 0.6897463413589865, -0.15306688337122187, 0.304766525831134, -0.18500476413995434, -0.10733704217152676, -0.37119832980775463, -1.051347638079002, -1.0750399178839976, 0.19543061846989349, 1.0027286230731705, -0.24330502175846708, 0.5045876021248011, -0.009914972873808199, -0.9869449400114142, -0.3549400690201593, -0.7940295096739403, -0.7777972078116275, -0.8476122358852217, 0.8250167677539804, -1.052610371007198, 0.1656771810253797, -0.09823742698963382, 0.038229391345168486, -0.781244821919772, 0.10418076576237408, 0.42556306997436943, 0.8725457906496032, -0.3779534799573699, 0.9384892696721205, 0.26456501940211963, 0.5355980742984993, -0.13936564881881885, 0.7643500869535284},
    {0.7734156128705525, 0.0036756249177753676, 0.9758906849108866, 0.5184113457453338, 0.5067814533142996, -0.9939166253333906, 0.3695709834861875, 0.10640847825692626, 0.9498370919725168, 1.031467248197077, -1.0793173868254513, -1.0178696126570945, -0.8096949398445962, -0.23260483730286363, -0.08264217029327112, -0.1334581548627227, -0.10207313379101984, -0.02255583306718114, 0.030389609317051, 0.1085064717389488, -0.7105260051376959, -0.6081007035263988, 0.28951054167273654, 0.23287822025229182, -0.6086395394543895, 0.7521928226089392, -0.9681410372339018, -1.148150284112637, 1.35107964309212, 0.5468172650197711, -0.9579544887627978, 0.7297484087280863, -0.36540420193004386, 1.097319111927125, 0.42142319144807805, -0.0402571453036733, 0.7485870850140414, -0.3198021553982674, -0.9366537064484041, 0.7780696678017065, -0.17160913301573424, 0.30199303121068444, 0.5133738249142425, -0.4540385426607014, 0.0444816028185659, 0.4578598950550798, 0.13466055865362653, -0.5825193781975055, -0.8171692176505171, 0.07625067910888887, -0.9366801204827438, 0.46083650294754935, -0.0058914876537672235, -0.5531765672457981, 0.9993456086654922, 0.8809246459637892, 0.11856616808231497, -0.7449488364586204, -0.8007558569635406, -0.6425415978424892, -0.38274899871510487, 0.9219904159326249, 0.0986810244067543, 0.6788514484868647},
    {-0.5669755215111367, -1.0532008147191485, -1.1499445819321699, 0.08785061518922747, 0.6168491757118579, -0.6532966195777002, -0.9996020484891958, 1.2741075691554529, 0.9128104482693786, 1.3371630338207317, -0.45113952738263313, 0.22174732507817965, -0.7552720255479713, -1.1401280151121018, 0.6242647868376676, 1.301251221686008, 0.06361678809767181, 0.993316347121843, 0.31847657411744607, -1.1624988306727881, -0.9940775748183719, -0.3994045775973672, 1.041126727679863, -1.1747955532564989, 0.2615089259669554, 1.0867618437025441, 0.12167299452391711, 0.5188310047227706, -0.9255135649247791, -0.7436694882378585, -0.7219272705391852, -0.17857465704796832, -1.0263364791766174, 0.044146867053443374, 0.5861546325126828, -0.7441494218597531, -0.5751578920724593, -1.1023033224785639, -0.28290896885574807, -0.5135259316296256, -0.7484404858959364, 0.38071765109847105, -0.8884023545780405, 1.1978241837076447, 0.514258308195486, -1.3140745059534755, 0.10256425601949128, 1.1091287272938404, -0.2807969911011539, -0.24160808527743208, 1.114172203676908, 1.2216053490428793, -0.9443690008316181, -0.06335692101378307, 1.0597593787628878, -0.10410142822568519, 0.10020272735179096, 0.579628747822398, -0.06286600764734136, 0.8274773593486497, -0.39542528082092765, 0.9315267307112679, -0.6395640306992001, -0.9279405494389079},
    {0.875334987187753, -1.0031281071877878, 0.0841127852842697, -0.04096345785668843, 0.6532378762651436, 0.5164771419977566, 0.6738127085150646, 0.7760249341990608, 0.8838925158213757, -0.04349229424527142, 0.9599972192764941, -0.9329341557106315, -0.2487194733191833, -0.0984623285152149, -1.2551053319707746, -0.9893634115664918, -1.0626497341667387, -1.0689340862855692, -1.046146908350852, -1.1586677721004905, -0.3486717487985543, -0.6213456052694055, -0.9850684861578947, -0.11602326122977535, 0.03632326279170518, -0.5375695715433666, 0.9943056007656422, 0.8927404984421271, -0.7971532889264592, -0.6682096008181959, -0.8199681561469983, -1.1282840498405535, -0.7295315206710578, 0.7823047255704486, -0.14496232122681546, -0.33261746727321784, -0.10214762131526746, 1.1702580767393043, -1.109564434879189, 0.619193476664668, -0.00926320308866676, 0.07871052355333157, -0.8909070915738115, -0.8993636743873636, -1.054080151002472, -0.8901548016454652, -0.9835664444570095, -0.9644831143247943, 0.35192917414406205, 0.04754015662856021, 0.8523623394791677, -1.0428744097708145, 0.5037797833314808, -0.2386001631538395, 0.16155050150607958, 0.456998237238653, -0.45062513903185886, 0.01481422452409819, 0.09013161999291511, -1.1253135504254494, -0.47628517625055966, -1.10661174486331, 0.2984419696005875, 0.32872942088212115},
    {0.007781507041106135, 0.4059847158081396, 0.9640302306452826, -0.8951144505288903, -0.2176670567332452, -0.7052383162462236, -0.13814478447155473, -0.9069755363501394, -0.16462382032805914, -0.01106880627997437, 0.9302072930515012, 0.6401621480560611, 1.288880733180534, -1.3260636255715645, -0.7941467540322857, 0.5609427949653543, -0.5741321829764193, -0.004672051667667281, -1.030733103714859, -0.5872916150842334, 0.7627106636041371, -1.2355297749065126, -1.185367466367221, 0.7664744995024367, 1.2571510536052635, 0.3857685716626709, -0.07906651121471403, -0.5598648497065076, 0.20389161569808315, -1.232516928532583, -0.5103756336762416, 0.7362999612881546, -0.5417060913147357, 1.2840011247229601, 1.0599655882605192, 1.0122091513211493, 0.5844940156542299, -0.04289258314792666, -0.27949253965207965, 0.10107616538165091, -0.0016244475855435457, -1.0670356962585896, 0.9798674495923961, -0.013256536573405635, -0.46946741453712826, -1.2919079786404168, -1.154650717014764, -0.8543916628273505, 0.6109510199815059, 1.1693117629162308, -0.25686603498443444, 0.42834999571353755, -0.7053839975638387, -0.951070364496356, -0.7936136886669616, 0.01946972186884235, 1.245397574832058, -1.2986196598289248, 0.1804102739596289, -0.2120538486192481, 1.233886387278974, -1.1163765416182285, 0.4927545489632122, 0.8468300850446054},
    {0.7245541230828767, 0.2706725880751286, -0.33877769200566965, 0.10718068885799693, 0.6525684618565071, -0.1014488381783953, 0.27699349834251136, 0.10512021990554707, 1.0452414756999457, 0.17044977327354294, -0.10548203609903711, 0.808894360251056, -0.07565358264823151, 0.25236373226983216, 1.1809408660095784, -0.09551982018072312, 1.1856531364513305, 1.267160728254479, -0.908150399492821, -0.5260680675082868, -0.3914025377339022, 0.2011745998193591, -0.3607264650419114, -0.03937215381525777, 1.0481679358213325, 1.0133758376237851, 0.524537057828784, 0.36091795503233093, -0.7162144088390572, 1.2608808638173077, 0.542275704401377, -0.49749031327923116, 0.6046851767791895, 1.1629682976890428, -0.20660345086151108, -0.6540794353418394, -0.9897176712173575, -0.6888203136316368, -0.8787042954643619, 0.3453283455739153, 0.35495789778152714, -0.25790144540870785, 0.011868443025000426, 0.8690670354680144, 0.03592895245623467, -0.5737983206146554, 0.9976489452645796, -1.2364638166965642, -0.16066968884817065, 0.49875990956471716, -0.2676428593174665, 0.40562418614789475, -0.6409263184217171, 0.6408761020375207, -0.8590571324157452, 0.7839443935670762, 0.7128999817342919, -0.06492748500909848, -0.5883982610480222, -0.6169170452996874, -1.045935353656096, 0.5980946727797403, 0.9275504805562719, -0.9751809494169147},
    {-0.26637812559781004, -0.2896639080081227, -0.7490524462098838, -0.5528316231921669, 1.2949838950778767, 0.6917851075273914, 0.22818630823370586, 0.9759722909340786, 0.6252282913352464, 1.1911467374770695, -0.422477403395983, -1.2161217067035954, 0.22077595591910054, -0.28375393204365834, 0.10156746079227018, 0.6487233937215443, -0.9297621887406773, -0.539259856955202, -0.866090795908613, -0.5370137635724185, -1.1295525504272177, 1.1864235378856418, -0.6285317498285612, 0.48838561067921255, 1.174355887468062, -0.8509267289901113, -0.7362929809838257, -1.0061941744562584, -0.9332864412233874, -0.7444978321858796, 0.9378242793748973, -0.9735045487876719, -0.23890571574837072, 0.833981745187198, 0.36797375671304905, -0.40382150441379233, 0.8534348219946052, 1.0085787713804502, -1.0231827689232058, -0.7624382133309761, -0.5275619198528079, -0.04878936030785486, -0.30294118850924295, 0.2621196161872629, 0.5969665067884821, 0.5175532038238506, -0.0996559477934471, 0.8909766272990736, -0.689103604293136, -0.5165773073177905, 0.7858965010398248, -0.4095781121545296, -0.6117010958168203, 1.1876520407372297, -0.4743181676112824, 0.13945275883293132, 0.2600937913288618, -0.7531044847376345, 0.41837351268740225, 0.34260098275996503, 0.6329209974556004, 0.7934392248010836, 0.8128043102283395, -0.486044114329261},
    {-0.2355356415634145, -0.809456846152851, 1.077514049975063, -0.8684065361124201, -0.024560516571290242, 0.008361681797148178, -1.0653935911532935, 1.0673339232396377, 0.7025948126482344, -0.07829972277066267, 0.1545892538009032, 0.7934174867508815, 0.7936878820739297, -1.0585619889187454, -0.5960048614541049, 0.5010110782963031, 0.29839337487380735, 1.461213282500848, -0.8549973101255314, -0.16517829658807479, -0.9392723873333736, 0.97164089363694, -1.1119300873026088, 0.8720939391223971, -0.8027950236542677, 0.7464186161522997, 0.23708526846902, -1.18372902780428, 0.8212691610112752, -0.8089021532272533, 0.4262007487873697, 0.43704135269544025, 0.23859540560135592, 0.5039381042761282, 0.16170580802796256, -0.41139864687729577, -0.8017394378413616, -0.3543850968528163, -0.6972418235031347, 0.3818319405325674, -0.14428140266369643, -0.7196541173777959, -0.14368330658456857, 0.25422054870931776, -0.9617371475798361, -0.6841118814213494, -1.1859868246445973, 0.5408889828592579, 1.0560069330495958, -0.36061872879311996, -0.6989546236716261, -0.532726654961743, 0.37227132403198226, 0.43368547221328935, 0.1357820281239902, 0.49957213785070415, -1.1082427270751551, 0.24067175129850688, -0.3263170276765216, -0.03685948108947008, 0.014567925413970013, -0.7757524089242646, 0.9699650300167175, 0.0037904058640726604},
    {-0.6262725785228372, -1.1641454678164955, 0.17396676934405297, 1.0366227781301103, -0.9099035456267138, -0.8535884817033501, -0.30112885155769037, -0.5491746213423927, 0.5829705855627522, -1.2394811552952991, 0.854963864990455, -1.3302186676456198, 0.22477086449964268, -0.5191869968214149, -0.9113141818843631, -0.3196481847706534, -0.425755960147242, 0.6963909132416035, -0.851695429568848, 0.1916220789421358, -0.3754432539140033, 0.06375075135946098, 0.9409717026593108, -1.0372698552455863, -0.05257065123505263, 1.059198519078658, 1.1424196088329437, 0.29460290172901077, 0.04866460194640592, 0.7364455701466792, -0.839429675449077, 1.1645388853958172, 0.4929928152184865, 0.6899740341931819, 0.14834265052688075, -1.3913292909230948, -0.536544824562191, -0.8709348404952275, -1.0336505366648185, -1.111235621125714, 0.8987213574814636, 0.9219133562149839, -0.09486379793563689, -0.6564820834241427, 0.6487789417078177, 0.3896272814281571, 0.3885020436049609, -0.07504869042936745, -1.1233668691348506, -1.0655642652608341, -1.025750247455307, 0.20447823355525716, -0.8560688876467448, -1.1541394486177559, 0.17269080664965394, 1.1294591130157348, 0.012795127464059886, 1.0830924142803826, 0.8486397191625753, 0.9660999618855011, -0.4884233341658012, -1.285704463075025, 0.46557003014580584, -0.7035029712080237}
};

static const float b1[64] = {1.6331485970531685, 1.4202306586837827, 1.4960227675769797, 1.5424350602444428, 1.4016771902081255, 1.796798931079328, 1.1521577624732686, 1.6846100911901634, 1.3672225624544336, 1.546042253528995, 1.4589744050790325, 1.5093884563949298, 1.5955254064389413, 1.4944963267518199, 1.7654884477818673, 1.6179347500681773, 1.6365413450912083, 1.586067501103288, 1.6297284090772188, 1.4262492902179442, 0.9733843301903193, 1.6370138954821785, 1.3608920769788866, 1.715984858648632, 1.4185189261794142, 1.6724941333135401, 1.2894539355400225, 1.5912126925575634, 1.3453840283535523, 1.4105147188062241, 1.4984358858827898, 1.4669120193604437, 1.1722260607506378, 1.01415526686988, 1.4157747683241326, 1.6545982566755204, 1.6095006276233297, 1.4535696071947937, 1.6126266985649793, 1.5830154467297577, 1.5423613250092365, 1.6444734228250624, 1.5888242617562645, 1.2500318394273096, 1.5135535135921432, 1.4448744948421557, 1.6380411817974045, 1.58020196838108, 1.7570778904220223, 1.5864876040534557, 1.6480151467690067, 1.5571004727613003, 1.5918195819458183, 1.5560989268331393, 1.4001239610924503, 1.7747271937096298, 1.2661662153545408, 1.5268708294629492, 1.5211494988886272, 1.6561304637536325, 1.4615996535833586, 1.5351329348962108, 1.4591076321485763, 1.509902040938709};

static const float w2[64][32] = {
    {0.3025796957674785, 0.8701807713575641, 2.0831339988214888, -0.2121867658374104, 0.7857933464693232, 1.0468547264746202, -0.9455208499994385, 0.8784477888112238, 0.2634906797186089, 1.9492898928652562, 0.6818921241547825, 0.1148588139435905, 0.1589877270400765, 0.6510184549057025, 0.3320783828310321, 1.5973079050119354, -0.014689138218068618, 0.6504279831556027, 1.905511372016848, 1.9292170362994026, 0.9760217551791175, 1.8354212882320493, 1.999146596176571, 0.273121541559779, 0.8960940636532705, 1.8678904023811207, 1.2267032957864656, 2.2264709981713926, 1.6402722091946227, 1.9650430832171317, 1.043653231880455, 0.19005799066783122},
    {1.8499035624666316, 0.02643767874806453, 0.9453882940097845, 0.2114019571192184, 1.7066979994958364, 1.98938394895636, -0.3841632434330375, 0.6048630617439074, -0.2083114067277373, 2.068498301320659, 0.1354985374445925, 1.043239318121295, 1.4798392857412848, 0.44869875102275303, 1.4998179123509803, 1.4132479636391648, 1.2822395057252072, 0.5945224370741842, 1.4946280739160496, 0.32471136373046705, 0.9459754765325051, 0.8236028139765104, 1.6161076479627245, 1.0915494052224068, 1.301077633617169, 0.5394784564027018, 1.5187457034581764, 0.38388691863794455, 0.8271115894472685, 1.8764513688395235, 0.6332438014276213, -0.09153353874335712},
    {1.6148954153700084, 1.4141398966023238, 1.866311124022657, 1.5679985555227853, 1.4702756441851759, 0.9825809734474367, 0.2696117972871842, 1.6773544540224705, -1.1097167364651412, 0.9246825486468546, 0.16794792416915547, 1.463384596198673, 0.49267650762418413, 0.2881310453402411, 1.14558319976832, 1.4925195262154716, 1.7568425517641397, -0.730986469447789, 1.1744229318166945, 0.943246902940043, 0.4543930264188144, 0.1997287475641254, 1.2590565601111476, 0.8044622106442374, 1.171647574017849, 0.606013987198344, -0.21767879551569566, 1.456364386041304, 0.49623687309073794, 1.6898700538254865, 1.2366088091916723, 0.5347850910329325},
    {1.3047154526701574, 0.5087523527831985, 1.487050408806545, 1.5356760479240918, 0.2513878281614335, 0.8907982230769705, -0.07314820685274545, 2.067615646645736, 0.16223351997122532, 0.33756837028469766, -0.04153264149979723, 0.8459714486537177, -0.14809424467613883, -0.23891352010020175, -0.015046256014531759, 1.6149685079982035, 0.1678551338016645, 0.810762438811101, 1.781374916744119, 1.2619040638761712, 0.4181142586355103, 0.6528842536620757, 1.4747245618278113, 1.8775712371634568, 0.26559795869445, 1.6060349176826518, 0.5634284744064414, 2.044199018789133, 0.8681317207654959, 1.174426532501003, 0.5162530383508943, 0.7591365030829738},
    {1.1882824881990466, 1.3876301807906535, 1.4624096758332024, 1.6890621463867208, 1.646422914611029, 1.7565152114703253, 0.7969542954047875, 1.3810338062682657, 0.1693203643207499, 1.5332298342084882, -0.5747928702579025, 0.03042457664406263, 0.8987712929855722, -0.689690143112113, 0.3262042992053777, 0.7295158276890806, 1.0203587729465793, 0.12856516136436918, 0.781893832781586, 1.5679103790658664, 0.6128756619898706, 1.7038546871103963, 1.2752010775823661, 0.8675480499709669, 1.0595117176934887, 1.4341794925079527, 1.0158470073484678, 0.26356671152978, 0.9611274108150507, 1.1817096926314972, 0.7337308390730027, 0.7297542661218005},
    {1.0553719216912356, 0.21895028180671952, 1.531839651230859, 0.09272192168758457, 1.2998393516709508, 1.083955247034152, 0.03489990707488745, 1.0290855314372904, -0.5164000462635315, 2.3011442657600263, -0.8669515943787304, 0.05919934169551825, -0.026012922607994503, 0.4683197962090309, 0.5466010210801595, 1.8456439196036192, 1.2720309276993393, -0.2543824509455743, 0.7856072817969223, 1.1019019505227357, 0.804037239644717, 0.4252476039300371, 0.26384515111760776, 1.1193681161431692, 1.747402741549636, 1.255188507356055, 0.71995977330684, 1.1251304100375548, 0.7341308851234835, 2.1977285200471974, 0.5649675460545348, 0.2022851526701588},
    {0.5799406182255271, -0.12823517702496462, 0.3881705821985132, 1.1529109777019577, 1.5506731520485493, 0.9126556606922571, 0.08829019698816172, 1.4399910733433223, -0.33865901168492674, 1.3928211928376302, -0.4828645867654026, 1.14237387395713, 0.10443465362501955, -0.016286737142123076, 0.7820085613851567, 0.4181080221546023, 0.7278476926737382, -0.7305667056720517, 0.09116164382838962, 0.358331274208826, 0.27058108485270665, 1.1350123317031933, 0.638958812773171, 0.534077313446627, 0.8766324339232667, 0.35797943002655597, 1.384007409096135, 1.8732922139297337, 0.8635062401581655, 0.978588932204494, 1.1442565578719992, -0.3267684324650502},
    {1.074556556103774, 1.1923089871446386, 1.3696258112989226, 0.22759535699495143, 1.898955584490206, 1.3127198531521918, -0.648853790197756, 1.344977727698091, -0.9527409432680516, 1.777293369576525, 0.18875428523220977, 1.428716814362986, 0.534112207539952, -0.37440844630936093, 0.047723973611820944, 1.6689191553831741, 1.360508372031219, 0.5927585514827313, 2.1493664990003714, 1.8307528716920958, 0.4537489022460884, 0.47959812060971063, 0.2809937534742307, 2.0210176616464928, 1.32829221276213, 1.8297448046549116, 0.6068959231343037, 1.9784408079374765, 1.1987863060186903, 1.329947580568584, 1.0510400870457632, -0.3209754529799579},
    {0.7498277373915161, 0.2660155575869845, 2.059173502059639, 0.27409232936351946, 0.27496337830488715, 0.7160954324768295, 0.09574842097428186, 1.2660260113033552, -0.7088536716872972, 1.2156529598029493, 0.1310747164360942, 1.4175907290127328, 0.26398776956159015, -0.3674122286960752, 0.5878621201683795, 1.1830572367491345, 0.46552689350487336, -0.8299389310799873, 1.4700436560668309, 1.6804998839106937, 0.4664694767711699, 0.7296677265408128, 0.5436002016993932, 0.39293813390632576, 1.284298386021461, 1.1777221952689134, 1.3027740958717446, 0.38720085091788614, 1.149793654170236, 1.0271716088728027, 0.3516543008832503, 0.7237067228750772},
    {0.7133529632745274, 1.1915159111211568, 0.48114199936787266, -0.12473511960453494, 1.8249892043817306, 1.4639948123825526, 0.5967152712234814, 2.068068943320075, -0.7428272619089337, 1.3976006367856872, 0.36797904329620834, 1.2457027386285555, 0.6419682107471412, 0.41138045504879595, 0.06896275395650527, 0.8194755483477963, 1.8477244917276956, -0.9056988672716493, 1.2369435041899146, 2.0837748652155668, 0.9693314829626005, 1.2230418152720273, 1.3038104279285352, 1.8665352412906193, 1.7062310637480587, 0.7526642001142714, -0.08918619117688872, 2.287941605004128, 0.5826042260842251, 1.463341032027636, 1.5415362205560137, 0.4954751756304904},
    {0.6436913395334324, -0.022160055556440995, 1.4524656034790655, 0.1621446804215292, 1.7323165244986614, 0.9323881530866389, 0.255149716618453, 1.895327747220414, 0.47528579911713326, 1.9833348481517787, 0.4853056537817423, -0.22213671516459535, 0.02449737611880335, 0.7004027195006257, 0.9330448031342633, 0.6044139818800673, 1.532234421057006, -0.7892186395255715, 1.8978792113489864, 2.0315836005429007, 1.0975115222123202, 0.8705436988423673, 0.4545206898527439, 0.26197802658160857, 0.390744148909264, 0.49637212143133486, 0.6888852789782881, 0.9205469209138699, 1.7069218465436518, 0.4210578395045465, 0.37019838723856896, 0.4368552379767951},
    {1.8055106631724085, 1.3371676040730711, 1.0019084563627505, 0.38584840648851926, 1.6465513381376309, 1.5042232042075947, 0.04643371846751718, 0.327832809495686, 0.4131986843416545, 2.1630843614492354, 0.40925414493117657, 1.2914061007509452, 1.2324995995485923, -0.14653643541525202, 1.0231945889878167, 1.7833357461879822, 0.5657011389776554, 0.8832137045948935, 1.939412340825486, 0.624894238707765, 1.0504091932679864, 1.80194974711239, 1.6160980559498912, 1.6400663450984623, 1.41286303909123, 1.4679129814406195, 0.4527511467179753, 1.8569459884209345, 1.2018811327292362, 1.6216160920452296, 0.3359635836254297, -0.04657274941995441},
    {0.8043919942229163, 0.5911259054346056, 0.6352676822068195, 0.9071275219623393, 1.4802927978007505, 2.0130124635051083, 0.5226028141204382, 1.9805059560046747, -0.17530540248433563, 1.0702445819103734, -0.731790968154971, 1.1579677309720977, 0.6060752655619809, -0.3905201960283657, 0.4004138207346277, 0.7616111592857644, 0.8764684964739733, 0.7177005065163966, 0.5600648551644819, 1.5561507715810503, 1.1030992631981211, 1.8340904410708956, 0.4371968080964297, 0.3615915852012887, 1.9004420535607407, 1.8301838942482938, 0.5711582089663175, 0.6506116451630517, 1.2761940466498916, 0.1637595320735995, 1.4323783860215673, -0.8451790435211421},
    {0.8391656491555269, 1.6347927887203282, 0.8895104163630545, 0.40796167193570815, 1.7985854648305568, 1.65712673579606, 0.4518936687153256, 0.37991537475224046, -1.0066788085082734, 1.7709585175474791, -0.323894859969846, 0.3073024744905199, 1.2356426954104123, 0.7726343944893919, 0.018145903993414758, 1.0600530977715608, 0.033601671728197696, -0.6109004872212831, 2.1168069183215112, 0.24666404052686416, 0.30092783254355737, 1.0159106125556474, 0.2849392153980657, 1.0218616215735472, 1.5944159084580583, 1.4941852099479336, 0.06725137121156599, 1.4974019467411144, 1.69499507152385, 1.174958446381841, 0.59956070647869, -0.2547707428954259},
    {0.4928626870689159, 0.656794517067435, 2.1901438542137392, 1.0714917909733206, 1.096573613734189, 2.107089061274717, 0.02918193557489926, 0.40506847396209417, -0.5590728519025201, 1.3376195314193178, 0.6480112721350725, 0.7493416009813897, 1.182515656024741, -0.9358295123482452, 0.3625019252701157, 0.6741793280378829, 0.6740404930562808, -0.12140970735400361, 0.7419432004262216, 2.032293893022292, 1.0218732704882032, 1.9674434392706814, 0.9744739269620682, 1.6237564758942815, 1.619510363768509, 1.2421726408225406, -0.24326989553485184, 1.3929804632921081, 0.9551911624951303, 1.8278257474677988, 1.9885968650211503, -0.8123142465740997},
    {1.2880223098444255, 0.07492326680748619, 1.7753973964606846, 0.9715108524627647, 1.5829121009800282, 1.9678408321189667, -0.8198473649820855, 0.31627886160368224, -0.4302684898209179, 1.687745649349027, -1.0027996902776035, 0.008881082970145185, 1.2500175291968654, 0.06201104581102292, -0.2533481044340933, 1.1784291238740463, 0.08613652060372813, -0.7807565571182928, 0.423817970476264, 1.9733960674578863, 1.587273043425274, 0.524728058711356, 1.2529866846120306, 1.0286332659175057, 0.6976914018371492, 1.11554227186551, 1.0237526546273454, 1.303789621404717, 0.8109613468287231, 1.7420447352507547, 1.333382342877584, 0.5352632280558165},
    {1.2325846658960358, 0.49069423896088127, 1.5673971855583493, -0.007196685414141024, 1.607355612254253, 2.2678670749889847, -0.06957568889411847, 0.3635623891783697, 0.4269332937288614, 0.8697894193828622, -0.7310341452459729, 1.6226499984353515, 0.27328143248181913, -0.4044931880236471, 1.4333583916435018, 1.8751046860075653, -0.020577449514142355, 0.6890742158173283, 0.3907116079496929, 1.5317741038313628, 0.2327130168555917, 0.45558600409679717, 1.355121698027822, 1.2068910206775507, 1.9210393206611054, 1.6465008679386757, 1.5126881139841437, 2.180356561410022, 1.1080967638025698, 1.812212110634119, 1.1627047216824091, -0.2138067141993763},
    {0.8560585924620114, 1.2559212999987859, 0.7699823782249603, 1.1309009282419633, 1.1701463190720798, 2.2283614592849497, 0.26064233502102285, 1.1920587004886165, 0.00041341070698143034, 1.1087335832110765, 0.6502852534086538, 0.8724404000177123, 1.343814989689001, -0.75312678817746, 0.8703133955403674, 1.9387884879275756, 0.9260702718876145, 0.5374295384569762, 0.2180307788502005, 1.315105701515441, 1.0584245817422673, 0.13193312467103313, 1.644630205216953, 0.671597270603473, 1.4327503581513104, 1.2587795273314746, -0.0737506047604595, 1.7645893439983193, 1.4873501700716072, 1.5550679096032811, 0.5200158937917416, 0.5730880421936163},
    {1.9409025165764318, 0.10303274408738736, 0.7681463694035358, 1.1097252763786705, 1.579429571413422, 0.35978462912176457, -0.22567177714549422, 1.2779612135610094, -0.49714266687764685, 1.822554358113255, -0.49894705392735067, 1.1751165727440873, 1.3930220329829113, -0.6481143155513631, 0.5945853469984023, 0.7285964318684661, 1.3538757604984797, -0.44188865185088655, 1.8895050902529047, 1.5079026795899617, 1.4478726306871736, 1.7233350701551244, 1.1010617090436297, 0.9813956841702645, 1.3238360661166662, 1.676960727711987, 1.2580666558535725, 2.101525290157125, 0.4204015470650589, 1.5549417448461134, 1.6453959445002253, -0.8649450487825088},
    {1.8807556326179529, 0.5678882131068844, 0.41083556213006117, 0.6408358497330673, 0.25080599571176604, 1.8742516444083217, -0.7974084704139108, 1.168820164344509, -1.126494292672075, 1.5074948341923016, -0.021641829844316143, 0.252708019816892, 1.5078050021953402, 0.7735098316878122, 0.8495916094017948, 1.2738602183212906, 1.0798295895705639, -0.6817362375305198, 0.3031902832966132, 0.27637265133981775, 1.158558789184043, 0.4900360875405355, 1.5993405739489455, 2.083510330993062, 1.0088079345340752, 1.3931217896614962, -0.24120281557418494, 0.46107071992383586, 1.2352027930759317, 1.5361993557127283, 0.48206375483753, -0.48000707477470506},
    {0.6324573799566872, 0.6683096449836109, 0.32418369324268814, 1.2279517158697861, 1.0151733917059282, 0.651693496861288, -0.6825521232586977, 1.878634962596764, 0.11549911483955753, 0.22236194636446685, 0.1854747647982134, 0.28885505060120387, 0.708172399942274, -0.5066816270883195, 1.5609354322871742, 1.7533326527786113, 1.6659383360782543, -0.2855458201274531, 1.4456459916799393, 0.39413385802109646, 0.955601480765862, 0.6619367686894276, 0.9746030941701842, 1.0247763074856837, 1.3681189913530478, 0.3110052756064188, -0.229257474014521, 0.7984997848344692, 1.4705903110844372, 1.3804814188683463, 0.2245400797018327, -0.37850441140463587},
    {1.7309343567689446, 1.3227610520199469, 2.222811005676346, -0.1645925065216506, 1.6115520901520428, 0.5617269480247085, -0.8143476807309539, 0.7508559923320862, -1.0411021184259637, 1.9462407223314346, 0.22817633172950577, 1.0985088912374301, 1.8305455156075607, -0.32160147030785713, 0.43071662949894785, 0.23485218587249204, 1.443246298288143, -0.3094790223425008, 1.9253173656766887, 1.3893577184462766, 1.6270491373679745, 0.1927751665691591, 0.2081719457190929, 0.3835218239481838, 2.102900059324499, 1.7079767074472365, -0.29666420536219024, 1.707049608609504, 1.7693748211436633, 1.9743622388641406, 0.9155927420877988, -0.32776471919245337},
    {1.6845177600777597, 0.8194465011053064, 2.1214829273618405, 1.2058107515919514, 0.6514799327689476, 0.37718828317028885, 0.7821314497317068, 1.7837821023432023, -0.707423442736473, 0.9449031613574861, -0.7178006312066875, 1.444774592395962, 0.5385628149162138, 0.45465576627795284, 1.3636770820860373, 0.24423415376042262, 1.5761850267680466, -0.36803551949857694, 0.24507165249344226, 0.313112840877586, 0.48039937291777596, 1.859844316878432, 1.638639721307303, 1.9203474384237815, 1.22242172587519, 1.1502891886728142, 1.175328676893934, 1.6787764279932247, 1.6359667468537873, 1.1404195572134295, 1.035782650145753, -0.939861598618537},
    {1.8461406208851134, 0.7761181209545122, 2.0332238303657593, 1.6488093692522279, 1.2154098733524783, 1.0312285441970086, 0.724591086987907, 1.8582340592802282, 0.2853312529294176, 1.9547566669166911, 0.18998018995952634, -0.019435253087301162, 1.5195917878334675, 0.47982058707469305, 0.6868234512704011, 1.5951201803198134, 1.7994696540632493, -0.8588696329397295, 2.1686134336671703, 0.6941014521157048, 1.772307567243862, 1.3972956979760018, 0.4245811976207739, 0.5416228266288128, 1.4587980096794804, 0.7517555669616055, -0.23215871987250292, 1.9360128908951262, 0.6138703808020683, 1.0598058369712702, 2.0612950706291904, 0.11353377792781441},
    {1.8657988625618784, 1.009275095453438, 0.3632733868379178, 0.6981764675671676, 1.9233036362181501, 1.1389531391052259, -0.7941884394521104, 1.090930031763619, -0.4814338593527108, 0.39277655544771867, -0.6479289037741734, 0.5103218137049149, 0.8254440431924092, -0.8323454169910748, 1.075697577467642, 0.32055986382127666, 1.7082548078196722, -0.3052718676460507, 0.9919731711727358, 2.141384415060464, 0.9905076880722653, 1.5031314076226339, 1.6598083521865552, 1.6989261508131865, 1.2410716364866192, 1.8947974979135522, 0.2677297124499527, 0.8665580354203953, 1.1750906914541985, 2.061028212150333, 0.7461628485971695, 0.06673060029022393},
    {2.265247918790372, 0.7182355540071979, 2.223541734429012, 1.3660887222043863, 0.7747403678795056, 1.3900385548765029, 0.43765588555061274, 1.9619540765401269, 0.7352304042773427, 0.9108480574629301, -0.3922907738351171, 0.05167178041017686, 1.4236393145555248, 0.15661852637260323, 0.9162257507853844, 1.2693312923744378, 0.3518781211225978, -0.9043753345024678, 1.872299960321412, 2.050693269163428, 1.8911417968588247, 1.6421600950343016, 1.9201352802707898, 1.6657364372282988, 2.0017970527510798, 1.809209317690526, 0.7401880563788067, 1.5208434288319332, 1.262671576891506, 1.3470390002612949, 2.0921178772541156, -0.036379940952099475},
    {1.263928625545453, 1.5883279507510015, 0.902363970069647, 1.2368372775934495, 1.4762943163832702, 0.6402138778783677, 0.036253958416877584, 1.502427976038475, 0.47822145708215225, 1.1062054314663419, 0.3169868647062036, 1.1146870915000053, 1.198641615430377, -0.2509447634731306, 0.3047987984571406, 0.3958155532919621, 0.18026793643302688, -0.9691836896465691, 0.6029613810943768, 0.44386358130330145, 0.431565490866522, 0.6917184485424926, 1.1395139064747906, 0.6998781349276662, 1.116966942057924, 1.1325326051493414, 0.6262180682598117, 2.1950891140932316, 0.4285724426705806, 1.5214723312687441, 0.25101888590807286, 0.39920719339870087},
    {1.8271107042953831, 0.28461433867348873, 1.4601045772625523, 0.0546526874099774, 0.6188050904343841, 1.8993721879403778, 0.1708586207042457, 1.984201201693485, -0.8444338707362758, 1.1586216711434836, -1.096959811052007, 0.28613786695433396, 1.7847482500271046, -0.019431929640781907, 0.17938528286952593, 2.083359029984288, 0.6053511471414653, -0.8756708375810335, 0.31886510964272474, 1.966455408191717, 1.4670700319650658, 1.5880877654855508, 1.3950367917190645, 1.5060600329483935, 0.24670220291353698, 1.2448548902378818, 1.338274722617402, 0.23269530396591484, 1.5487820753557142, 2.047877053153584, 2.069760177718457, -0.7292884587910302},
    {0.6174280189271781, 0.507870490826063, 0.3192286648408522, 0.8474677082902439, 1.179162731355752, 1.9631956650839149, -0.2044779921982532, 0.5679869289881426, -0.10539791671321341, 0.6470662039258223, -0.7192561386843401, 0.6682614252750718, 0.8511110445030524, -0.7614865787891008, 1.0531114261896772, 1.38585955323735, 0.727750933433655, -0.22242969271737648, 1.5548530056569956, 1.1976602915180854, 0.24966103994678307, 1.3854591876655782, 2.04462180146688, 1.1252756638674593, 0.3418686842409187, 1.441986305896684, 0.11364076457690252, 1.6316299894733075, 2.0526941525637423, 0.5835362826223727, 1.4554804635233471, 0.17672475360304873},
    {1.7153647599883886, 1.0481672225475305, 1.1273112323609211, 0.054687073149996476, 1.0141966042499986, 1.0912901839375038, -0.9200735279333896, 1.53427717574194, -0.6997788279747332, 0.5395945111324806, -0.3922376763912842, 0.21189368509510662, 0.7641222824289504, -0.7393355567812369, 1.094306205402533, 1.2746615326523874, 0.8673070117986892, -0.28712283655106113, 0.6558534644537989, 1.44778138285362, 1.9541609611069928, 1.0961897299098946, 0.7639413627880631, 0.594005449291901, 1.7011465162289858, 0.19478700994236767, 1.2869234352681265, 0.29063205344853255, 1.3198989560136178, 0.962536760245328, 1.4487748116743675, -0.5736563389067605},
    {0.8593798304988076, 0.38615693788310956, 0.5781886018335404, 0.5749054230365399, 0.69966191450837, 0.8794582575969702, -0.2004338234416564, 1.2741399662628996, 0.5485360331277924, 1.7831069230091694, -0.2625080271581413, 0.7688701316323363, 0.9537407295157925, -0.4710752246391549, 0.3198328451470743, 1.2351837445626777, 1.8073906012837277, -0.5455771504653476, 0.29351525044405485, 1.3238227083736265, 0.5504984064869912, 1.5364264398200604, 1.0353833222978008, 1.2428540778029178, 1.9912727433327782, 0.2729836190088365, -0.12959319870478564, 0.8924712102515614, 1.255409439279187, 0.7922796466789368, 1.0405859154800858, 0.5666285108951008},
    {1.9859436893846514, 0.810366563616625, 0.6660458597327031, 0.8248368402252513, 0.0545706112524466, 1.6002330629918424, 0.8575606676971537, 0.906549452557554, -0.9987674691594012, 0.5733336543083207, 0.8668790369715563, 1.6374367004277874, 0.5853249551540523, -0.6855591779972496, 0.7650978980329158, 0.892429480375721, 0.8986381236074494, -0.1094497538394423, 1.590604245601453, 1.3809067650389757, 0.24038998476886206, 1.6916767881135144, 1.6539545771713435, 1.3319645775804385, 1.4536993958441493, 1.23467794197093, 0.7421710548312057, 1.0175419555759855, 1.5069500244053307, 1.4153603618334147, 0.9828242284644289, 0.17130918413452476},
    {0.34211205576330106, 1.3709906372682863, 2.2163160431262723, 0.4891470998686763, 1.0417067942941067, 0.5022805600274264, 0.051135219270692235, 1.5636878526210787, 0.34375326251785326, 0.5938384555347938, -0.5337842012798218, 0.7682538757585171, 1.1961415459704885, -1.0317254604065855, 1.25802093814985, 1.2106896513092698, 0.22971432567404804, -0.9040326125715079, 0.9168274818087925, 1.055388509052421, 1.204773960566069, 0.4339963455925329, 0.5669969361081528, 0.9749691542833961, 1.198117592482332, 0.7209606422000231, 0.2875733399719488, 0.8459292108138885, 0.6896839879618175, 1.070457059580138, 1.6057922087517222, -0.2911215194008918},
    {1.3275792081571143, 0.4906656647463578, 0.309588778602189, 0.7581634910624978, 0.4939429087272964, 0.576968165025478, 0.753526381516577, 0.17690995070422283, -0.31514219577164876, 2.119941797781183, 0.22879639255978002, 1.1807953202789958, 0.8664716842983218, -0.0008222066856186013, -0.11310094793279517, 0.4676863120134089, 0.50405740317461, 0.27306431759655936, 1.41277443589422, 1.312371133811996, 1.8673151909973058, 1.6316442679966867, 1.2766007588602777, 1.2497409045141832, 0.16784625152396912, 1.085823094902331, -0.26756753020196145, 0.5976334478675273, 0.3384749652290111, 1.9416970768213557, 0.6108425754680787, -0.019841951915033153},
    {0.3635066069915144, 1.2209471480328533, 1.7416384203771762, 0.5520023840239197, 0.2807276713761406, 1.304387790102041, 0.540112476826625, 0.1451520452525925, 0.33579794804745056, 1.1297660915850893, -0.14886047376237008, 0.9158726535069118, 0.9860111326999917, -0.3877668957416679, 0.9875276867665047, 1.9287291601784073, 1.5971107535479647, -0.9447570031182555, 0.5392832090618003, 0.6271864112065877, 1.3399455775796107, 1.6747586309980844, 1.293060505749335, 1.3739683697879663, 1.4417869485745338, 0.955491616251949, -0.13189220738969462, 0.9018220967015044, 0.3683491559937405, 1.250526444133172, 1.6246824440385992, -0.3016819400149861},
    {1.658858834001691, 1.2096547889680316, 1.4155268164810848, -0.19287015956445208, 0.7193830189285713, 2.066451116165259, 0.1339036932063016, 0.19690682472022542, 0.3711847726026244, 1.0234146088756102, 0.4133900012719741, 1.717947226388844, 0.04927823913980903, 0.41804183669949774, 0.552526988132064, 1.460266814210368, 0.42308791880155266, 0.37088265857936364, 0.9005212251538111, 0.9027348577097652, 1.6718793906090519, 0.9838426931831785, 1.488692333757062, 0.27900595335529416, 1.5518618941889524, 1.8156389775638138, 1.005988046169572, 1.994345143945545, 0.5587456030098847, 2.0847310114109083, 1.798949570602238, -0.8209210643119662},
    {1.8595646989802561, 1.108900214383128, 0.46770660298778594, 0.5029966538910082, 0.36255864499861207, 1.5330793811131516, -0.10257828942745528, 1.0517371219189084, 0.27405107205362006, 1.6382850218518312, -0.11975864289420281, 0.20183264361281555, 1.4179412279967556, 0.5876956111132994, 1.1913356359072962, 0.9212410764073483, 0.7294531356070161, -1.0303833756877558, 1.017811952836371, 0.45905680405233024, 1.1694507290359646, 0.2749580105082447, 1.3298043254515501, 1.1436055918446464, 1.9771160177044453, 1.097688052683452, -0.40739276494209314, 0.8569859966565264, 1.30357992297999, 1.1287202589894356, 1.0906959414943, -0.3138694601289471},
    {1.8299032790353553, 0.40741047986699275, 0.6840354694325248, 0.6821695046155959, 0.7570470303264828, 1.543929913031187, -0.7612393872315742, 0.4121904593178729, 0.42538442324401937, 0.9596350170328357, 0.8593424513500689, 1.2015993061496022, 1.4608558183419873, 0.10077061478635566, 1.1589602235766931, 1.4604371951990172, 0.5791611544182229, 0.15055491508257673, 1.1996634667965655, 1.7101270413936, 0.3034419630045523, 1.301891901706322, 1.0431890661179644, 1.2600653016102632, 0.41022827939449513, 2.035073615595052, 0.5112445120227718, 0.8171641189895001, 1.4476823478400107, 0.2738614624587272, 1.955796433822583, 0.17031067422429683},
    {0.5046404730174695, 0.20719857173338055, 0.7885984243877396, 1.678399162231573, 0.302699310477313, 1.305567562977838, 0.5591108773713119, 1.3768877306764824, 0.7130977754037354, 2.1141119170661913, -0.47906321543236163, 0.4651411654633055, 1.4444500436970606, -0.8471466206673514, 0.32616609899781757, 1.7221804770659124, 0.04970626615737568, 0.7135592996499115, 1.2400009281202797, 0.9704318901889604, 1.7055463166308986, 0.811131971295449, 1.4771263258885399, 1.5414473633696129, 1.3857448503050325, 0.9840499823263266, 1.0650556463132812, 1.274780618218804, 1.6600487583681391, 1.1683141453041657, 0.7773563837828892, 0.13924132297727423},
    {1.3552242225310236, 0.953615071092292, 1.6748605648979025, 1.1982803025706676, 0.4114508602681622, 0.5566594394127053, -1.017313742960224, 1.1493392991560971, -0.587481213420064, 1.983566742636003, 0.5265774793588983, -0.04336689886190716, 1.6443226513844547, 0.8057063760131137, 0.15432212032191356, 1.8468956910451713, 1.6519199837029273, -0.3284264705856439, 0.6513581705655956, 2.0647335215194973, 0.9433512310332774, 0.25499793274031074, 1.303157536634124, 0.9867522975692707, 1.7292284231905508, 2.109879019614821, 1.2852619026954717, 0.9302028693880903, 2.018478955452849, 1.5476673184414327, 1.810465650744523, 0.04586880541068732},
    {1.7390666803827828, 1.3802852214427281, 1.1927629032010398, 0.1584992001647225, 1.187193334691367, 1.5998333300796632, -0.33234444444657624, 0.32666407551217774, 0.5015236496757881, 1.3368482133905197, -0.7545489297508163, 0.5273287053996275, 0.20413581028676728, -0.07003126970012678, -0.09070757774298598, 0.785993598214962, 0.10668098554180527, -0.9709136002341331, 1.7834013103441944, 0.7883568681100123, 1.7385889700381751, 0.7847327201412178, 0.6508735187960664, 0.669740864657517, 2.1180893520519244, 1.0249220791927025, 1.4139273270381656, 1.2726263661808621, 1.483099363560328, 0.9151146560197171, 0.8083116449773091, -0.16472985277033994},
    {2.1418612060928783, 1.5536329264056796, 0.3378889090747164, 1.6617948038489785, 1.2011460105698268, 1.8409097168372646, -0.7337646519660755, 1.5128568445793813, -0.6545381786990987, 1.9917520524006578, 0.6140047051741838, 0.5155264401046511, 0.6224578599841474, 0.3201972739887021, 0.3076117315722759, 0.8937914323153644, 1.7406188480414015, -0.9967805769347917, 1.6404852966118317, 1.2156292274401714, 1.3239112090275917, 0.9020538389939887, 1.0950903048788776, 0.22627736764603243, 1.2829473504458, 0.2864505623044899, 1.4624148296222717, 1.8226791961031505, 1.023935561742465, 1.3178431593334374, 1.2420838384919999, -0.21543246678169686},
    {1.1534119356466377, 1.5358547733239825, 1.8056897449918496, 1.3880713119352346, 1.5565040833815154, 1.6675625429099805, -0.25308023111728273, 2.09906987356648, 0.011212249449096398, 1.3433819257939037, 0.3101452463213435, 1.650494520220798, 1.5919918890581704, 0.29848515746850185, 0.6615174236480661, 1.4699172428592586, 1.6705098608174638, -0.43682930689679766, 1.9385978197707867, 1.667581876568137, 1.0097333996306759, 1.567293639756964, 1.0855814391469516, 1.9843864685333132, 0.3267130064138347, 1.4982403627843899, -0.1339398424010588, 1.8463077577199423, 1.8940828616569132, 0.8837849699278216, 0.5979370420579947, -0.755594013706181},
    {1.112231132943943, 1.4787073079746293, 1.5173878430628347, 0.06557640183454595, 0.8596422230072168, 0.47199206330329635, -0.4140865959646637, 0.16896179930997207, 0.5454447720135539, 1.7283866418877063, 0.5144812243240672, 1.2620241677533612, 0.14822985511541378, 0.7710515152119765, 0.8527001473539153, 0.759410283404336, 0.8263536937592465, -0.7401928809909822, 0.2776011196481705, 0.3740716345107851, 0.3059007564037772, 0.07214424243943829, 0.49872012407318483, 1.9325270985892102, 1.3008420668138714, 1.6215030782717086, 1.0625766882943404, 0.5386660662640131, 0.7727983273907009, 1.163107759102218, 1.9812199573622005, 0.4922721697738838},
    {1.6840109965540853, 1.5183142825373528, 0.5305573459317902, 1.36755933804491, 1.6514639091479333, 1.3671924341425865, 0.02937874541106626, 1.5780618083944018, -0.7577124051833806, 0.5637693428358959, -0.2640232071726186, 0.8304992207417917, 0.694605291799529, -0.3568874400379156, 0.7056904134741298, 1.296309529803333, 1.4877650374694822, 0.49663472596476144, 1.619498123471898, 0.7919780285971858, 0.6782873347857804, 1.2344032750801628, 1.1329744067731762, 0.7972598500195168, 2.0188209531737242, 1.5862954970626746, 0.6244945317386807, 1.0552928639210784, 1.4670310715653272, 1.80242633455741, 1.762052331843259, -1.0022507682407213},
    {1.160588334289647, 1.7010965685486619, 0.27084191511525785, 1.1255800431768206, 0.5724142655980825, 0.2722793828460866, 0.536826151743168, 0.5044734070615279, -0.536953252043148, 1.6855823197263247, 0.39484873881404114, 0.3916312923000265, 0.9078992395033375, -0.6936299157539924, 0.26557503991712966, 1.2028841836240352, 0.6432925405529354, -0.19688178453499458, 0.7678251892482546, 1.358156709913846, 0.9103855343504274, 0.29058756532588825, 0.5985344149353657, 1.4045359873021415, 1.0461627317975057, 1.4828670239558426, 0.07630595376407091, 1.7133969798071422, 0.2758202766302759, 1.399563103220139, 0.6123455904955192, 0.11702146812353925},
    {0.6724437167842743, 1.1360911625504089, 1.4441767785194286, 0.01779099082243944, 0.21015787611127604, 2.2749944117267784, 0.11082002893876468, 1.7615254674275513, -1.0691128338983624, 0.7921407668975594, -0.5064615465467892, 0.1284162290264617, 1.051363202438924, 0.6348708997109898, 0.02690143929156965, 0.6069597196694188, 0.6696992045990925, -0.0013820212040596255, 0.534699173739175, 1.5144361009720715, 1.4762918183369425, 1.7396920001652432, 1.5931510028943323, 1.675198881074631, 2.107768304074548, 1.5861661991812026, -0.40170359715668746, 0.8957922524878379, 0.8527222295680454, 0.6978395164779916, 1.5119815272067139, -0.06150128876843051},
    {1.1661080204437142, 0.15871416724194792, 1.3073952905810529, 0.8347807578103168, 1.3570641824698018, 1.5343786785239244, -0.5868650568854676, 1.3461114265388383, 0.1267552466198306, 2.0440595411382088, 0.049285237313071585, 1.3543568155412775, -0.17100068471592397, -0.8664729599970954, 1.2442091581262458, 1.0791262715308112, 1.7145275585072788, 0.03783815880496326, 0.0943332719292458, 1.0869969414774132, 0.3528803500172221, 0.016583729209823997, 0.9894810547872125, 0.6790127430799755, 1.6318271446258565, 0.8637137770136811, 1.0631648092181416, 0.620587119050439, 0.8932208240389704, 1.9726553408234573, 0.4313908333443686, -0.7633384282834014},
    {1.84920353861963, 0.11054491236915384, 1.9204801424469444, 0.5182406225908668, 1.5890013554786246, 1.7123085510496412, -0.08949113485708508, 0.5528096651006444, 0.622242161986243, 1.3774180913197591, -0.653556613615158, 0.710720858801994, 0.7244213341387672, -0.5872373098840724, 0.6775034205816556, 1.3678150607515531, 0.8297239212785159, -0.4819498799494858, 1.5845746996000063, 1.1243523654543113, 1.2422958786225913, 0.9486495883966909, 1.0156032816212814, 1.7892996222100568, 0.5127663848231968, 1.0017856338577402, 0.23772960455291212, 2.02341942202111, 0.3334395736333667, 1.4673116146991645, 1.7041835166072319, -0.1919459924712522},
    {0.9443199883382101, 0.9011239548731839, 1.229087601471686, 0.5441130449824352, 1.0779745595165982, 1.459674880414262, 0.4260884383639918, 0.19604848289390545, -0.3066067529051223, 0.981869486544666, -0.0847199993990368, 0.0749571352018556, 0.9428939204417496, -0.9857377110919123, 1.1004451721107855, 1.7414300951820103, 1.8682143305218164, -0.25307368658833485, 0.2058056258581175, 1.1212849925445543, 1.2604147168503814, 0.12706475310336404, 1.8331044420172238, 0.3103793185883238, 0.4795281039596806, 1.61231600800053, 0.2615071630206046, 1.695199474683032, 0.7551913783889714, 0.19261391142622566, 1.6028364434329458, 0.06376995650064146},
    {0.6715188760665173, 1.5919975375644269, 1.2920351659500267, 0.2829951973982768, 1.0670693338379524, 1.8976782350836343, -0.0030628421759994347, 1.3462752382086414, -0.9380896601230507, 1.0173454506654478, -0.06618358340134838, 1.1306247724244483, 1.5378404538901975, -0.9532455735082215, 0.8442818275239092, 1.111760323670597, 0.554807980176279, 0.3153082100382604, 1.4072387328485931, 1.8885088672539314, 0.13061888954332548, 1.968994855613486, 0.13581272856347887, 0.6306085237771001, 1.1336294876461908, 0.5370127809470282, 0.13187486405044005, 2.1734484447337903, 2.093360146585288, 0.8730358194951978, 2.0784664694697073, -0.5845182592902779},
    {1.4690805287841315, 1.5350194285675867, 1.0143267415926949, 0.42892544021008716, 1.6178049803932797, 2.198970777465616, -0.9537978127333394, 1.0905587928337666, -0.6046135573600233, 1.3222218988844128, -0.15177293652719265, 1.720173151966644, 1.1620315648071, -0.5336451172946813, 1.232547420293884, 2.108507248268032, 1.5989791337058548, -0.5044664742264229, 0.6301826597933606, 0.411479047550424, 1.0751963860626823, 0.17939152196160724, 1.8011397680485746, 1.8660580508620888, 1.8318640700078768, 0.5542560033924143, 1.459813101670129, 2.0650604261680323, 0.7247039177589457, 2.0436871720861554, 1.5977254986048484, -0.740072623962698},
    {2.2070850347809112, 0.8090786794469774, 1.2841926424735546, 0.17201133668573343, 2.075252126512581, 1.054870046631995, -0.751244598894886, 1.3215195533324848, -0.03502122840762977, 0.8036570918643008, -0.6421833044263213, -0.11814458705323633, 1.4609801003599074, -0.6798669151367579, 1.4454740127069639, 1.3290457565113403, 0.3210290637329676, 0.4315449851712603, 1.484232825311015, 1.4866941302028165, 1.7785579391663422, 0.7264752671562767, 1.1154922636421243, 1.0921890376908223, 0.7523263927158534, 2.1769707872921242, 1.0090561679943129, 1.366483943853112, 1.8948240661195437, 0.9407006887706038, 1.037759461673943, -1.0557573193639982},
    {1.8337737766498716, 0.5636192954397907, 1.288646269811797, 0.2859546096431641, 1.9257852859332139, 0.95436504970646, -0.5933932700774838, 1.7391129599262418, 0.07270965941890095, 1.4738051268887482, -0.4579890123721505, -0.12302197968015538, 0.8193705035140241, 0.0824283754251578, 0.10587593016708349, 0.573448061068232, 1.3564950429117872, -0.4060054029971969, 0.9275426896065039, 1.6462362372349448, 1.6128003902812762, 1.3050170620705583, 0.42833438869881507, 0.3925312495521547, 0.6549536124539654, 1.6209309757112762, 0.9274117841424425, 0.49508351759579, 1.6024751374235882, 0.7200419554883989, 1.4201979378764966, -0.13669143013303597},
    {1.2170918518668452, 1.3094396084102013, 0.6975501297637777, 1.334700343151112, 1.493959741633474, 0.8592994030759157, 0.25108809771501245, 0.7301077922971378, -0.018253165108898014, 1.36207629717356, -0.6626861999286603, 1.1136352247283303, -0.11868115801422387, 0.5765170715335212, 0.3451799737026857, 0.8483767515563189, 0.318604446332849, 0.39053148752693145, 0.6081249827064876, 1.8177759771538988, 1.7452209106644903, 0.25738944695915894, 1.909013717423444, 0.6431204684685538, 0.9969489702628577, 1.9474118101196705, -0.3556741163998413, 0.6912464033787922, 0.4224191850384215, 1.196360972653225, 0.7142249098779789, -0.18605441384054613},
    {2.0542070303590902, 0.8491749605428442, 0.4980540537292717, -0.08539326577979921, 1.1106812944509772, 1.5501381138863561, -0.7261303501199894, 1.0740069610386833, -0.7410435469258699, 1.8315301378958155, -0.8065825625852476, 1.3247417007636573, 0.2571479257743567, -0.6938902520665128, 0.2600341400294037, 1.432768134289214, 1.061942358094757, -1.0042203369679878, 1.23114886098518, 0.9552016065847005, 0.829896210342817, 1.4037634487410782, 0.9870892684537645, 1.2921416919819413, 0.37030808102753704, 1.6508745409257037, 0.32027701282142407, 1.4139782941070078, 1.2121766824732507, 0.4554756838597444, 1.7010107258718796, -0.20319908252303545},
    {0.3274075766357979, 1.6305565012320704, 1.271651834259811, 1.159145913002431, 0.17706962730646691, 1.051938655832314, -0.4903025051299626, 1.58671515380197, 0.2144636824628854, 1.5316701180416705, 0.14479299467557175, 1.6676984488663553, 0.3635110735605358, 0.84078577131405, 0.0351357631154808, 0.7504939473916938, 0.9340403091036492, 0.20585941317729523, 0.9233279198629649, 0.2698813183072904, 0.6051658901930272, 1.7938381183212329, 1.7890289089425881, 0.8283600992224516, 1.1055753901586094, 0.7927316475885191, 1.0524933406072952, 2.01167963501712, 1.7005443101065427, 1.254145477310041, 0.5077006306460777, 0.0710893970867662},
    {1.9190420745087635, 1.857024735533403, 1.3062261541454336, 0.7080014882480085, 1.9216058084097893, 1.109723801743385, -0.3272893968631385, 1.401910900927831, 0.22924021165062552, 0.6744546055884479, -0.26035810778444907, 0.7636463512309923, 1.7050621623061115, 0.5154153129001353, 0.9966078249868633, 1.8818498523870784, 0.1560284272649237, 0.18932580864536921, 1.9666845343938946, 1.890371875497219, 1.6113165574158648, 0.6229016458199618, 0.5064602101611352, 1.883803259523485, 1.6725241449281554, 1.1266241685109428, -0.3383806847737288, 1.423347719383707, 1.1820396447008437, 1.2033259539744707, 1.6651831869370959, -1.0024733797249672},
    {1.6696421159026038, 1.4985325715183715, 1.973941318800143, 1.436688344196637, 1.7747528724747434, 0.9445858986559164, 0.1830001475664104, 0.47410345862174963, 0.7357079849325567, 2.0975454306941197, -1.0015534048943746, 0.38436571817276693, 1.763393928839418, -0.7294554479608489, 0.6310277183250335, 1.1168921828102136, 1.5389145041439498, -0.21439504463391473, 1.5022452956116832, 1.1862635562012196, 1.708810818661427, 1.8755010335463587, 1.1182944684383027, 1.8101510732050883, 0.24625155856902395, 1.6721612330022504, 0.24875739549671275, 0.5243469210044001, 0.11730851094791335, 0.20863919270142922, 2.0113577469215564, -0.9242908465606386},
    {1.6918214021724731, 1.1357404771119877, 0.7266586813838756, 0.6612777335582322, 0.2584123863581429, 1.6586140238992348, -0.47153408740881303, 0.9504437550730325, -0.8860166778404732, 1.048037377367459, -0.07422017868636974, 0.5090937345153694, 1.2515060166983143, -0.4540805719808441, -0.07262925794580163, 0.5603304697567415, 0.14091410463563328, -1.0476980026293463, 2.0387994963271083, 1.5215308651521133, 0.8364341061727937, 0.739170203826029, 1.5600052697355884, 0.8270505162372295, 0.48284800471188954, 1.3552282135849945, 0.030798083290442205, 2.1801934234612217, 0.5584587666503389, 0.5517594088430954, 0.48838950169534523, -1.1337360944428179},
    {1.6596243010345506, 1.7683975884627154, 2.115838178930213, 1.2025660548232466, 1.5165815472163997, 1.751959848166544, -0.8062551829236977, 1.1717918741639384, -0.48353247044512, 1.0959815524656789, 0.5184712904844575, 1.239807729146337, 1.2992466903248412, 0.7028761179285187, 1.3267733407277529, 0.1975313780839597, 1.4869136955374176, 0.7298781564639367, 0.33127833918962185, 1.984107568338129, 1.5074906395006995, 1.642559597279441, 1.4075795369101762, 1.3012292089462079, 1.006021098853931, 0.6535296105289505, -0.08148778528187879, 0.8017302489272041, 0.26547948824782847, 0.4718222126222099, 1.10424061633462, -1.1505638716803743},
    {0.4776994986856326, 0.4003020310217194, 1.37840588667169, 0.06907260068085001, 0.29621288893497066, 0.6521228863167614, 0.005372631432963584, 2.0022155728262256, -0.14592054863505513, 1.1964363874586181, 0.09832296512247597, 0.5124744501997829, 0.04932164347764735, -0.778652475183599, 1.3496768391993683, 1.883659592093749, 0.352428084943182, -0.9288761529843869, 0.5716960544632657, 2.1741662104782633, 0.5127739305624781, 1.9665683942655172, 0.2487624295092047, 0.6739156006533799, 1.409859148456115, 1.7747987599211843, 1.425974290558785, 0.7597347821965783, 1.6750364996789031, 1.3717436705183343, 0.6394233801886997, -0.07502872346897178},
    {1.2455651743929474, 1.4412674037770083, 1.1974100224608568, 0.396126037958112, 1.1853404465861643, 2.171811266067787, -0.004545857279393385, 0.7496231459355313, -1.0797395879771026, 0.9419097994120643, -0.7923628505230248, -0.014796274747494733, 0.13033006271172728, 0.10926956177958505, 1.3471719390108978, 1.5455411094599472, 1.9358615803133357, -0.7929748029288252, 1.2058090150695255, 1.168036816482042, 1.5437001650840327, 1.0012257752625264, 0.9336311818157418, 0.7916309037835049, 1.088319192099458, 0.3114138825368514, 0.8583635144334306, 0.6828691907279336, 0.6938553631347617, 1.8959007564641368, 0.4034369052005448, -0.7730549881794339},
    {2.17591859918231, 0.5742076699570434, 1.106660823392768, 0.12425537619479397, 0.6679594588773946, 0.9019491430160234, 0.24012639371270977, 0.4128936641736741, -0.110077033595965, 2.106251180196747, -0.8196421599819067, 1.5387396052753692, 1.213055931794538, -0.4129940635268845, -0.052487950996766425, 1.474740678897272, -0.001871805264591069, 0.5807764446038255, 1.20220370429262, 0.921348994501895, 0.4275051195162491, 0.13232176840519844, 1.4089773559843513, 1.9443076633674572, 0.5910325400569669, 1.4762374293160827, 1.5101671174882203, 0.45064376140510987, 0.6691716378209385, 1.4035121357169444, 1.757248064490508, 0.6343060457666674}
};

static const float b2[32] = {1.523767264425169, 1.0699730739068414, 1.5714355512272473, 0.9812050079514454, 1.3182921460198218, 1.5702023911608916, -0.10232238119590409, 1.397715906309998, -0.26613170344306203, 1.5816860220724738, -0.12808089853417803, 0.949382764721972, 1.0372580115288723, -0.20432794778683572, 0.8268954948005338, 1.4401491113555362, 1.210712122353367, -0.15691826837492664, 1.4536747840297621, 1.4882522665992208, 1.3830030217247573, 1.2912419432939561, 1.3123033150667918, 1.4302166208679525, 1.4803067624749993, 1.4578344790478606, 0.7024109771631093, 1.562883282889399, 1.4145021114762684, 1.4200121058390993, 1.4684957455166616, -0.30492530264973994};

static const float w3[32][16] = {
    {1.1211246457624222, -0.4119805828729651, 2.380386466414594, -0.5181478867332225, 1.87921540091093, 0.5024984945859128, 0.21542116833466926, -0.10315881585611078, 0.308733311743104, 1.8347362107305694, 1.4736599236803694, -1.0884087555005266, 0.541577970536074, 0.060640624355479227, 2.08026986991218, -0.8635306442803917},
    {0.7976257078762063, 0.26230726406015104, 2.509420709896791, 0.6864706943422886, 0.7323877918706684, 2.211501504408767, -0.06765983714613741, 0.6994659935271023, 0.4841406329792498, 1.6404345532352562, 0.9948602573766352, 0.9014611228222278, 0.25270401917755975, 0.3378514789330419, 0.5202330364654322, 0.057212629706136706},
    {1.9933859713606537, -0.7651575087935674, 2.1262951165940005, 0.7975749216589475, 1.4978715165759677, 0.98841665791615, -0.5763541179264334, 0.4681888366967228, -0.005703908006527023, 2.5994893699093984, 2.4519750795495727, -0.3074371540748765, 0.9570491143734715, 0.2633592489902791, 0.9679298098943353, 0.010789608125612964},
    {1.6874071557134047, 0.7439327828544771, 1.737508341879143, 0.5090271962964911, 0.06682178131036638, 1.0117990365509928, 0.9032271172622798, 0.8021074488664333, -0.6771986177914348, 0.570999974461777, 1.13598737802378, 0.6947420671965845, 0.27535723242227794, 0.5826605361984081, 1.0886509018058061, 0.2634147303244734},
    {1.4955962855180465, 0.5554006081716772, 2.2083258322500163, -0.2873635793447588, 1.615349043150015, 0.7387297791610468, 0.6490885258107715, 0.6736026807627455, 0.6669022064158353, 1.9652867971548376, 1.3204116314145775, -0.0016292206365273929, 0.8962778943760018, -0.42363216638290013, 2.254713979183427, -0.4560824804361371},
    {0.9935184993032926, -1.110311619327468, 1.7885434255463297, -0.34185785079845765, 0.5368124894540361, 1.2728668319717897, -0.6731443332351187, -0.6039205359987595, -0.21829115023930798, 2.3981109242344756, 2.0742723139279757, -0.28652231920857685, -0.0020612066642040025, 0.11902892071984941, 1.9955182252558303, -0.13470053432200657},
    {0.8731122617815209, -0.8414940250648861, -0.42364375877892646, 0.4329408632881324, -0.7062810289401354, 0.5530740640840168, 0.23489975533634436, -0.538155376278967, 0.018991370655357383, -0.4858960391907295, 0.3933400396367938, 0.07282106878748165, 0.1422742668909833, -0.39880978313899385, 0.5827669077593403, -0.42476163634357983},
    {1.7389452228168507, 0.11249098198706274, 2.253835318025262, 0.33353393272609944, 0.3320458539280654, 2.013843422741349, 0.8897680930821944, -0.9147190076510092, -0.27073326958243804, 2.160026359889051, 0.6520059724139344, 0.4040670479168615, -0.8253350902426101, -0.11738502782507552, 0.7411282572367619, -0.5665946766942141},
    {-0.4645592658564204, 0.2657191327694939, 0.3473021421522499, -0.31358666158715987, 0.08645722885814615, -0.730689676099384, 0.370906789819697, 0.45113168342577153, -0.361238727152261, -0.28728656569159794, -0.4690097226561631, -0.9013228547949903, -0.7985837820817031, 0.6039085755186567, -0.563257842453692, -0.26847210362243346},
    {1.9931657266768767, -0.35423630095974973, 1.8504653776844053, -0.433123558697802, 1.0095571588728411, 1.7443713323483083, -0.4358943547243522, -0.6980299871845685, -0.21886424327673312, 2.3963065824561345, 2.127657592511556, 0.38784236639455905, -0.6256994604834626, -0.04453465897607934, 1.402636542301194, -0.29597206081404076},
    {-0.37429605753777595, -0.8114695764703692, 0.27760989309732215, 0.33460072339499575, 0.6650598395427826, 0.6040246424698031, -0.06724105172759902, 0.09681896279743325, -0.9682117575192257, -0.04929156142623666, -0.37500533894663846, 0.7333378273629545, 0.4379933430663734, 0.2952243631611989, -0.009225591463719849, -0.9832473864227351},
    {1.347342067680552, 0.8595984564137115, 1.5543395700545377, 0.34001315339294463, 1.2572965299409613, 1.3800757391538212, -0.35636165349299226, 0.4172986842426814, -1.004069186368136, 0.6048816359813377, 0.7670122563918569, 0.360008741496795, -0.6183136771946737, -0.6319270944480945, 1.8502397043719367, -0.24712254745378814},
    {0.8460438135540241, 0.8837891540016796, 2.396892982083558, -0.9106445038831441, 1.5467635058431743, 0.7035875624705971, -0.3935216919753382, 0.20218427857250632, 0.6452328986391433, 0.9761103309887814, 0.9432208059461001, 0.21192065571428123, 0.07726235987464514, -0.37378310296320716, 2.029228274876517, -0.5291209696621875},
    {-0.057406537901847125, -0.10709445648847471, -0.1952713581786892, 0.1876995813636279, -0.3695506561717688, -0.7345990541876404, 0.4737321155094013, -0.40673397935979816, 0.5677834936326651, 0.9603363474442637, -0.6347222747663438, -0.7080676968907359, -0.22411217082312107, -0.07739337736744277, 0.6959153428538127, -0.6698536513831319},
    {2.182723366290397, 0.7544830246901832, 1.562744629142675, 0.2521639062013014, 1.259154969262978, 0.7966047283653619, -0.025815132668445758, -0.6098282580503609, -0.27447254455926157, 0.387045585656002, 0.7227983161149893, 0.7699568279562379, 0.08296839025405364, -0.15628901779848564, 1.2674228890001622, 0.353635035675933},
    {2.1038402630584288, -0.3218299735044979, 2.483529982116842, -0.6002081453832852, 1.7622526601093098, 1.9348668718157191, -0.8457998548359003, 0.7125332449009091, 0.795016290627666, 2.309424043749312, 1.0184468825847235, -0.4027813548442685, 0.6013848907208944, 0.48342025653005893, 1.4659800439476671, 0.024494493160199717},
    {2.5216286435055975, -0.5329455443532478, 2.1598766562480987, 0.2411943647063756, 1.4079417940922336, 1.4132631886041538, 0.8376537180451719, -0.3158680426413911, -0.2282678706460381, 0.7959109830199532, 0.718510554750667, -0.10863244808818573, 0.5485369097176591, -1.0161060972764282, 0.4766596476858947, -0.4534767657714224},
    {0.5468548542866822, -0.7739844031239175, -0.13732037070381747, 0.14699004540095667, 0.6862096139356444, -0.14839117131722523, -0.5597772744319153, -0.5915765189258, 0.31380921718076354, -0.29045657576676, -0.6444998592112008, -0.4797550020067096, -0.9585407225243227, 0.14863344227247355, -0.6102020365233328, 0.8416326353371654},
    {2.3711390677483695, 0.1374545966104276, 1.0787135811631905, 0.8627783964971444, 1.100531971799795, 1.8419177100358628, -0.5003774120619633, -0.8149591982334088, -0.3791388244259345, 1.4755018894031169, 1.6451128311368752, -0.46197015877022335, -0.8663732060583598, -0.16272251752591488, 2.1724217516879283, -0.02700360175230122},
    {2.4874915181217454, -0.721532609994768, 2.5236390400812216, -0.4509798746446387, 0.7504769462582376, 1.8954785305540633, -0.6878855382851199, -0.4455120168887883, 0.5491199665839775, 1.4362438619869815, 1.2946758125154862, 0.24236648641449327, -0.0619830747100955, -0.6326626781285111, 0.8665594557274248, -0.2639502928816264},
    {0.8267914609476983, 0.3352820492520576, 1.1660128173703892, 0.4820708632389825, 0.7078502374192376, 1.1403092451133068, 0.134185422550785, -0.219507488998832, -0.8459783841498723, 2.5306863075474455, 1.9191025142241038, -0.8013502913944053, -0.758476837651631, -0.4326447470603923, 1.0896315959903424, 0.9098017666769199},
    {1.0770918725356666, 0.4502603842962515, 2.0065251275996765, -0.8914020838782315, 1.0669419686818007, 0.9377881311134874, 0.5358802345981922, -0.4017264033072255, -0.8117547339709559, 0.942832828962375, 1.9129151936185331, -0.494863069104479, 0.04925373524902155, -0.31222563353625093, 0.9709003500761099, -0.32913183023595505},
    {1.1010747432843127, 0.14477728567037765, 2.323013764420877, -0.10771039231234923, 1.064839407489414, 1.3500468886639447, 0.5082404033601147, 0.26200508854737214, 0.5903717874911933, 1.6271893972616431, 1.677782806897314, 0.33797342364616306, -0.7027177075494235, 0.5540086865521859, 1.6590619035204115, 0.14353803375822297},
    {2.248925468768645, -0.9177896644817245, 2.277311067184682, 0.6311504360691969, 0.747918053340004, 1.2442796277183745, 0.5429535765658409, -0.1189691571286446, 0.4871629965953862, 1.3046506464257188, 1.0168027538395963, -0.6541236311186638, -0.5014283760340417, -0.22493689959073063, 1.4492796600264481, 0.3943987573277765},
    {1.5468676995113708, 0.0004586203005006935, 2.466363993501056, 0.6143289699426552, 0.5317162714401026, 0.4892148082796046, 0.4690830832473132, 0.6490034856106647, -0.8825354279379607, 2.1617533094760724, 2.2515181760479686, 0.2798125546548122, -0.37494697689753703, -0.03688228846409439, 1.7916147277402228, -0.16983436786842854},
    {1.1575704025489657, -0.08984554360593662, 2.450118397653847, -0.4776325020177674, 0.9063257075477721, 0.39900882732619963, -0.5924855927208404, 0.30943675218280053, -1.1331599773712513, 1.4941356101017398, 1.5876107112322104, 0.6495937031123236, -0.3212098481360898, -0.046861121133170175, 0.6422280466814358, -0.7980468673723985},
    {0.38730440875562283, -0.232417906953509, 0.5766023641298279, -0.145108077428279, 1.025752525683094, 1.1525516871304387, 0.8408919415622212, -1.0238689665331957, -0.20109675986063189, 0.7199482968797875, 1.8579536601103224, 0.0026250192240356712, -0.2870024933632855, 0.49021382175926703, 1.6577829545999918, -0.8940326753224223},
    {2.4657749965634004, 0.7752379827035351, 2.017109386986175, -0.23768257215138627, 0.7908617145180364, 1.4229526188677155, -0.22192014244086367, -0.9448047505265732, 0.10717096307365138, 2.725611869643006, 0.7889476229940482, -1.0037008331343589, -0.092934308991609, -1.0290027611624954, 2.235521476891285, -0.6059407165007041},
    {1.329499460964872, -0.9076355155103597, 2.332535809074347, -0.3363968146467458, 1.8599789544220429, 1.3044205151831973, -0.7462845840581713, 0.8029931943798027, -0.12454589536538012, 1.532959121664291, 1.1398065108484394, 0.26321018842457955, 0.3589378424029851, -0.10382525120760619, 1.0632886602079579, -0.12943847689409393},
    {2.013700241272528, 0.2745326651494683, 1.8758001818808043, -0.3984061525036401, 0.18614529381866537, 1.8579243576399322, -0.8171703977166592, 0.6696382540161195, -0.25450429146632436, 1.0379490430054534, 1.4179813169604298, -0.03475558812846379, -0.7234622335271972, -0.03419220763112767, 1.9941860256087236, -0.06671534766856753},
    {1.8256315070363633, -0.21346766513696963, 1.0152441677585209, 0.3797296524386844, 1.2730396905997055, 1.6978454796063265, -0.6501032089300486, -0.4526064229287003, -0.607910616775503, 2.722447866343235, 0.8031862367478477, -0.7830283467519566, -0.919760391556751, 0.8382352064174381, 1.952123642183144, 0.5333381093139532},
    {-0.23695524742104776, -0.0009553555611809508, -0.20576527184263016, -0.04583893870238312, -0.44274613670272805, 0.5875217744068028, -0.8641849750924085, 0.30713550972315656, 0.03332411136743835, 0.23284396736006863, -0.5219565897097054, 0.17445319917036978, 0.2670517650764363, -0.5701606978821234, -0.8400813800046597, -0.5934451613227731}
};

static const float b3[16] = {1.1909813599900962, -0.16121350492964395, 1.1792927018894543, -0.15147059154375228, 0.7060008895192165, 0.7788777880097386, -0.09951948536515677, -0.09586408042129932, -0.20610746613722072, 1.3242094983681123, 0.9437489583492824, -0.150002755637389, -0.0963369593015909, -0.1291997597013665, 0.9393414636933197, -0.008937702394373023};

static const float w4[16][12] = {
    {-1.7769385443603691, -1.5767744124485947, -0.975894425451192, -0.9161606101590797, -0.6078398736538468, -1.7109216389984139, -1.5595329122332178, -0.2478187151432183, -1.576556568126609, -1.522489142785461, -1.5578865893919727, -0.542664274404693},
    {0.8865314176467572, -1.00893164768619, 0.5818080391506641, 0.7272595008171516, 0.8410563881494771, -0.0668207800712007, 0.5759573156458918, -0.7034515129971557, -0.5106461492220382, 0.22090808211195895, 0.1963174476783362, -0.47670661571074846},
    {-0.3587981849914329, -1.4935036976157845, -1.7910012743701822, -1.0733152924445244, -1.4138152577248608, -0.9446264105231904, -1.6791128630438945, -1.7781899045254108, -1.5609614929278472, -1.3457352111415646, -0.9881494321744804, -1.2930495553645422},
    {0.6171211663015713, -0.21077016432996, -0.6767771247029498, -0.29307665337324956, -0.9967767052446982, 0.2135068217666262, 0.6110009156144439, 0.3832506942145186, 0.06994673386153018, 0.6527715785807543, -0.6297253992338671, -0.32070025714251277},
    {-0.862859181544859, -1.5807021620147013, -1.1039881468462716, -0.07657779300462732, -0.12518137565842788, -1.561557507714331, -1.2082251716758616, -0.8441220599594416, -1.6600732339103368, -1.5004726911341222, -1.326530430802392, -0.27426029576238026},
    {-1.3676256478648683, -0.27096345802678623, -1.0938598946512323, -0.477980808257198, -1.9171531193697984, -1.8471371019976384, -0.4314034925409751, -1.3471507507071823, -0.573375679217244, -1.5307748490613586, -1.6481904515554147, -1.9956123192298745},
    {0.6009504982289916, -0.5268333815021796, 0.10665107396086156, 0.33670951449183706, -0.8670252172602257, -0.03072054781142633, -1.005703778990159, 0.9666187383550536, 0.6614335808974796, 0.10464048905505882, 0.3784898597586125, -0.47501821945988104},
    {0.5139476302216752, 0.3519448249304355, 0.4586008041022067, -0.811551283168354, -0.40819187331164125, 0.668865230223346, 0.42442665051909095, 0.22782488938535814, 0.0817244210613805, -0.6890453173146571, -0.20580275603709494, 0.28578162380072225},
    {0.5386265978969794, 0.547769611355029, -0.9100997034533006, 0.7922565123684993, 0.4452422510366226, -0.23162655060021478, 0.6637955428843444, 0.14611237701498492, -0.5288321493845715, 0.9077719005669307, 0.8446973102755312, 0.7433579880541624},
    {-1.4777488341210656, -1.6423663532407293, -1.2598516543982965, -1.5698937438589897, -1.306723525476966, -1.955012460447029, -1.0443985131674274, -1.3485951750226484, -0.9901706377932552, -0.6489872105876882, 0.0021971452201046066, -1.942229344518564},
    {-1.9061819895061758, -1.294628499269632, -1.0240179908303955, -1.8403990472646317, -2.055963479051231, -0.18254180359095268, -0.6642419315896781, -1.0667188213421852, -0.6915466959812415, -1.7092756579442052, -1.7667372537971917, -1.0280422785823997},
    {0.43957350123204064, -0.11807755674324812, -0.8436677902354229, 0.6775262181524996, -0.10287204917019027, 0.9072113839232238, 0.751169186446391, 0.767558999122808, 0.18355493738886125, 0.7955925093555716, -1.0549929555518214, -0.8956689395802355},
    {0.21058686255467532, -0.021577734820535828, 0.5341926381288901, 0.38458097025855553, 0.5801677555019307, 0.4285090604147796, -1.0013562204340594, -0.28643205041534103, 0.5789735878391628, 0.5564457855088801, -0.07761433330104583, 0.17452958838921115},
    {-0.9432819875591143, -0.1815308893527164, 0.42452197100428, 0.696688764528453, -0.47336160328091775, 0.6815010825184671, 0.8609528479653998, 0.2915822561639082, -0.35788360655918955, -0.385574867975002, 0.8054743023464086, -1.0065454938478071},
    {-0.8853400285852174, -0.36240537647269855, -0.9350696394886056, -2.144395118947479, -0.7856461017078056, -0.3195181464620909, -1.449465067871974, -1.5946995010763831, -1.3174212677905195, -0.4644115761665486, -1.515215769617797, -1.0788125335505032},
    {-0.08604171318439008, 0.8471387038226353, -0.2548381617121428, 0.04378948499626277, -0.34531748352253544, -0.4478672572539028, 0.780899360787363, 0.5852664088641006, 0.3674406248415, -0.7001771581972983, 0.6211265194362824, -0.4184218726624451}
};

static const float b4[12] = {-0.459202400872646, -0.5945695752547588, -0.7046343308323608, -0.5720628179702034, -0.6108554514619478, -0.535592786406144, -0.6684998114577589, -0.5985236034152169, -0.680528821108896, -0.48121046284892566, -0.43688024576593465, -0.6383579718123096};

    // Input Layer 
    float z1[64];
    for (int i = 0; i < 64; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[32];
    for (int i = 0; i < 32; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 64; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Hidden Layers 
    float z3[16];
    for (int i = 0; i < 16; i++)
    {
        z3[i] = b3[i];
        for (int j = 0; j < 32; j++)
        {
            z3[i] += z2[j] * w3[j][i];
        }
        z3[i] = relu(z3[i]);
    }

    // Output Layer
    float z4[12];
    for (int k = 0; k < 12; k++)
    {
        z4[k] = b4[k];
        for (int j = 0; j < 16; j++)
        {
            z4[k] += z3[j] * w4[j][k];
        }
    }
    softmax(z4, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
