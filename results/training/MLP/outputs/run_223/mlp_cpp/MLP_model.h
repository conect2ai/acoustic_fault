#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][64] = {
    {0.5041991542780663, 0.45576134650768235, 0.39506447586717514, 0.2679910178131452, 0.5843962308602931, -0.4928533676494466, 0.5717414096154171, 0.050817617151012004, 0.681370069972538, -0.08518736329387713, 0.2575082426985543, 0.10354146321344457, -0.28734931214354337, 0.5718377991505215, 0.1492522140572999, -0.17355330440414268, 0.5113173401250104, 0.5031963200346333, -0.2886627157460685, 0.09839236606558095, 0.449259479806372, 0.5681773905201837, -0.3562114811784302, -0.18738476365589038, 0.5773089926147337, -0.4351885766909464, -0.5142886073387668, 0.37042151232786213, -0.43571463401275334, 0.5236633406962193, -0.24822787463835974, 0.46859417637898343, -0.1966511594961558, 0.500505569644209, -0.13097329753842554, 0.30951075660316607, -0.5414554787585223, 0.6567720171940599, 0.33688339089795843, -0.3636810716116088, 0.36297750551708613, -0.36363237941493226, 0.026471333998230547, -0.31828861155885946, 0.6325939699034567, 0.987640731034689, -0.047856998549415546, 0.5652204050727371, 0.5944975963381594, 0.1569977642830863, -0.026283207182554197, 0.07255614542286674, -0.0014285107289046608, 0.44059879543991926, 0.557285219906009, 0.1412056961626708, 0.3732448162620616, -0.12907369564377694, 0.5411985542077913, -0.007884052025851554, 0.5267011134317492, 0.27105838978711505, -0.2700834726177772, 0.08983922276201046},
    {0.6688012715715246, 0.6262962697775007, 0.9208409960304653, 0.6629515842131318, 0.15576168304236862, -0.21881606706438358, 0.5132111035112521, -0.04840566362887917, 0.6408440574243517, -0.3372988678710651, 0.19553070000578643, -0.25996490928446747, -0.503303522596272, 0.5366172336291279, 0.14690920743055508, -0.45995576190370036, 0.40142919177464825, 0.4601888076521941, -0.09437717407382237, -0.2651358388735917, 0.5430526465901847, 0.6632889390714238, -0.4249091787405579, -0.3966193249655218, 0.5193517082615382, -0.4326571753930087, -0.6035037514535265, 0.8794773907816751, -0.25074163347526696, 0.5381919924321369, -0.08903234300905355, 0.22037531114038433, -0.12892274691234798, 0.29771521108886007, -0.338291122332604, 0.35396303399871176, -0.6078141333509716, -0.4161436146442891, -0.27447198666746925, -0.54996563914595, -0.009476940499811884, -0.7550192943050711, -0.31441874154783533, -0.5781432375606356, 0.7418061658236746, 0.4710111647979494, -0.21693089992537665, 0.707438548606054, 0.7157091456283697, -0.27602057228765564, -0.6054599145101266, -0.02362487586237156, -0.8268930408057333, 0.7047935986114003, 0.6144860636993489, 0.06699520033257926, -0.4503005344748447, -0.5384473274238547, 0.7686250723951948, 0.12632880424795628, 0.7304516697239649, 0.5459672073001199, 0.05866121687905333, 0.23466568095787246},
    {0.9558943006973608, 0.6346997238118371, 0.9491450706921233, 0.7628465062148169, -0.08715609185244538, -0.46974529485264516, 0.5961774706372965, -0.007883056661466355, 0.7274665439664659, -0.33831105670273726, -0.5393644417646548, -0.47675818086725386, -0.6867853445912765, 0.8826285679803494, 0.22541347693537755, -0.5602702670895569, 1.045579533538972, 0.30875361477035496, -0.19582551968503645, -0.5343546553415464, 0.6064662003167512, 0.7994677905880221, -0.5424035209075884, -0.5768573474729769, 0.17608745726967515, -0.590559565510208, -0.6203851852753199, 0.8760406772845037, -0.39382045932888776, 0.5317175255797721, -0.33090370225366905, 0.4390019400798417, -0.4836077479181603, 0.8036007119591115, -0.6665831571317016, 0.8290659608281814, -1.0201083914289566, -0.5397385382850829, -0.35161970468173503, -0.6511061804374729, -0.48211378680433037, -0.8412564245210508, -0.5020979089538874, -0.636266595135446, 0.7587696653173526, 0.9744063196965591, -0.5325816369886277, 1.0041195454030785, 1.0631338745906187, -0.3939677950387601, -0.5434336472853558, -0.21890050573344974, -0.6808383609435795, 0.5922874075242377, 1.0113034323521604, -0.2313180256358871, -0.5577381244961431, -0.8447205915090509, 0.8121470265281293, 0.5531818518679471, 0.9620895347834771, 0.8685232331496823, -0.3158008858176426, 0.10728456987377312},
    {0.7685081848384464, 0.7077484770736098, 0.7726209423004166, 0.7631040337376425, -0.49183098228460975, -0.33397293363135594, 0.830199788245912, 0.27544109027519226, 0.5578695621061441, -0.8993020305078724, -0.35525215276678995, -0.6087817330978735, -0.5329979706303042, 0.6549919288969981, 0.6895649104452038, -0.4616878281663201, 0.7713786895491815, 0.7426986232107804, -0.10953018829432984, -0.7039043826755563, 0.7912657640891801, 0.6359113491342621, -0.40451722122533224, -0.7312898207731027, 0.38851705923769986, -0.36906482672161434, -0.6259259595020573, 0.5902626416407074, -0.8890149990342613, 0.49839039226857107, -0.1430955717501243, 0.5549211154524991, -0.733455610483122, 0.4883985809593539, -0.582233016291519, 0.5849943281241748, -1.1921512713936822, -0.3416880974386644, -0.5579576383731495, -0.7444635419521443, -0.6615019011970933, -0.8783485839978259, -0.6284161049331262, -0.7900251802382608, 0.48493667598840046, 0.9262114379200473, -0.47435240573024834, 0.7969529709676814, 0.7034230541458536, -0.5029793818868499, -0.783082751032498, 0.05938406415464307, -0.7221048511261794, 0.7001693698055508, 0.747104871281597, -0.3695614110004519, -0.40423530215425096, -1.060820264532683, 0.5781200035667975, 0.609810619434883, 0.8349961936906602, 0.6610862990809246, 0.014854159867132954, 0.5239737518510562},
    {0.6579353049920698, 0.7162827288643379, 0.6364055065840432, 0.519859232597182, -0.6084826758751356, -0.35336058028433676, 0.45429589351859434, 0.16709156503575512, 0.8602207136777553, -0.9949909283716725, -0.6710577520693115, -0.6509663960779994, -0.7612775861859623, 0.4716909821123782, 0.7270383382923488, -0.6996496172041246, 0.6975068887483027, 0.4293548939479111, -0.008735296572792919, -0.8181464399326153, 0.6234924187390676, 0.29264053390629635, -0.6832859526061721, -0.8396993077760895, 0.1027086535328395, -0.34954424409925006, -0.8150856544809175, 0.5640878053241976, -0.7116774456043734, 0.49015740288730536, -0.19673372586014226, 0.29624398747776953, -0.6918905250730509, 0.6456372382009149, -0.7605976884875875, 0.5501174700293577, -0.8359109346983914, -0.6821946735636288, -0.869116873305558, -0.8396498687109241, -0.6882548864826528, -0.8521783853343431, -1.005129650540862, -0.9159943281953387, 0.5842990210126654, 0.8395226096009422, -0.6664574087820064, 0.8066605431989059, 0.7167889056438856, -0.5236932264748204, -0.7621466085179518, -0.16721706990724153, -0.7609415787080358, 0.742579882898472, 0.7682254706366611, -0.36717179152760204, -0.8838415151209404, -0.7637636025463747, 0.4982165852855491, 0.45135981777887363, 0.8027329669729432, 0.7837274943204285, -0.48593069176398807, 0.38128377447321554},
    {0.7262602418035079, 0.3873140074100235, 0.4778760964723093, 0.25748066324930846, -0.6063676035645594, -0.5271343170863911, 0.4017281180841789, -0.2327906543988834, 0.6886442038472959, -0.8403453448694874, -1.001685124871828, -0.6030022324151638, -0.6197331599432316, 0.6853137569579331, 0.16701466152207994, -0.5486579935996202, 0.5273724268073566, 0.24999637140500702, -0.3775257425589159, -0.7130495576824524, 0.7193085269140463, 0.6896640516196313, -0.5972947907353182, -0.8206472759934365, -0.14877618313703847, -0.7592415425652521, -0.9889238690818647, 0.6619415294498814, -0.47378206081720853, 0.24344415282500156, -0.4107357623553007, 0.0024933989377210674, -0.8381674030396942, 0.5023246780053594, -0.8965589857544435, 0.6161806147962047, -1.015937349446955, -0.8382520720134373, -1.086151209233209, -0.8084046673509245, -0.9461414394152328, -0.8376399732262207, -0.6418497079054483, -0.9996351737636316, 0.5104484203186942, 0.7021170183133165, -0.6019277380611633, 0.7832153212670131, 0.4638888253445525, -0.6238007553286999, -0.8081107337001664, -0.19831447928873913, -0.8815503061989125, 0.409835519778229, 0.680479564588977, -0.21160205598189194, -0.8194633210111876, -0.9338542130181465, 0.4029004611199127, 0.045933411240627026, 0.5473210590961245, 0.28340307168369533, -0.09902299582048787, -0.23657156766746285},
    {0.4468084686488556, 0.803910662106831, 0.3811465836965052, 0.10467143251773149, -0.6255125321397838, -0.29125274638935894, 0.2972029225681695, -0.06702735377042804, 0.3323033999579665, -0.751286612789008, -0.8654358625786158, -0.7692542300184789, -0.6557948621343522, 0.38773046876158657, 0.2586979259986287, -0.7137931185724472, 0.25480099245725346, 0.20336945715345253, -0.49114102261888315, -0.7503435463332307, 0.3937295259479577, 0.5161911700359052, -0.6212295138989289, -0.6395826363501269, -0.36375407858033115, -0.7820235035382509, -0.8520067597971088, 0.5067244742837448, -0.6006516523758133, 0.7203050993801146, -0.08007368144767707, 0.41139767607366085, -0.6061328186566767, 0.32152929666417635, -1.1053562964089874, 0.544256753790215, -0.7580060504663327, -0.8717591567149034, -0.8061165353693385, -0.9135185283577915, -0.9991082678055123, -0.8526580528859128, -0.8163119188167651, -0.9897950463154278, 0.36120120439622244, 0.5551954828755762, -0.6245196322459516, 0.5778991476391191, 0.34313849529610224, -0.7884771036550308, -0.941445324854896, -0.28486668713031965, -0.7417494336774509, 0.27853102164367194, 0.7594402972081231, -0.32768572870419893, -0.7579732401372327, -0.7795931005870048, 0.30714579278977355, -0.14321577744734504, 0.7147708313761963, 0.023780296289681695, -0.3131171330215256, 0.02233534361792875},
    {0.4928458755585042, 0.361482464509486, 0.4050755869791595, 0.1371074898900553, -0.5207724719813142, -0.14206685910301395, 0.3040917127756732, -0.26878804954420105, 0.3328947631381908, -0.9388077932807443, -0.7049093854906512, -0.6387911695850527, -0.5344118037814691, 0.7076682723167026, 0.3676605763523135, -0.7560613542131491, 0.4713722304170049, 0.44166146787687055, -0.48985730302760166, -0.6046230831197634, 0.50313363255499, 0.36442753354009, -0.55852478627769, -0.6191653520694286, 0.010972615136116417, -0.49007368951816427, -0.8247237862763277, 0.46788450675758303, -0.8229833246676378, 0.5381384894713885, -0.05662221681356423, 0.3532765462261644, -0.8500040290571278, 0.30555472462821937, -0.853767688366797, 0.2765064271628569, -0.7262585619358202, -0.5095247958181617, -1.0246836058449929, -0.8568655595828553, -0.7152485654442977, -0.6863426400912911, -0.8915276347215503, -1.0172354211258348, 0.8235883786510519, 0.3539183449426721, -0.7336193941002525, 0.6467950968169617, 0.25118059863933284, -0.7760278592349624, -0.6442391367394738, -0.17003336270516187, -0.7563803572833045, -0.015731623429690787, 0.6704574490082345, -0.3783164014116379, -0.6913470984325458, -0.9683714491118148, 0.2685953646386532, 0.2459035432399457, 0.576729958504134, 0.23556199413066053, -0.39157664819103827, -0.14348564532416994},
    {0.5450064102286739, 0.6104572306879705, 0.4431489227145019, 0.5243170610664842, -0.5410113352058376, -0.29583751600396196, 0.2435315097063046, 0.03469124782862094, 0.6152091285104766, -0.9240930511138444, -1.0907937534320868, -0.8032776249782267, -0.5061951418624221, 0.6170705006959826, 0.4993474148225861, -0.6561806887449871, 0.6681217599373911, 0.3962042056588438, 0.06398882589835506, -0.6250078028307424, 0.3738023654592888, 0.4240417945128196, -0.6875512490128404, -0.7350230874542504, 0.3913110815019334, -0.4790785414908024, -0.8445656171911408, 0.3739664699517018, -0.707898824130499, 0.6752441854437697, 0.0961586773433753, 0.44293615105791534, -0.5409823364542001, 0.19375097961957266, -0.9690828233938615, 0.33817467508743926, -0.9270308289382129, -0.9632797891001088, -0.843885425116761, -0.6050972007250904, -0.601994556865151, -1.0531486693711942, -1.1329437223061842, -0.6817001239059213, 0.715507265077257, 0.5143421209326284, -0.7789562518906264, 0.6278256839745622, 0.5698495991484757, -0.7269901080313352, -0.7879261596983385, -0.13524401452253676, -0.7206609581913036, 0.2691993844111353, 0.6511362550584329, -0.18446966892689523, -0.7235415219335928, -1.0441369678005794, -0.0036526143152590673, -0.04382488863233407, 0.8005318873109387, 0.6170930602124511, -0.32782796234744593, 0.20325402516696098},
    {0.6275762885210777, 0.4960729222201595, 0.6529559730570206, 0.6133540170713079, -0.5093554101603773, -0.29926108088767583, 0.1050368665661427, -0.16491294734783943, 0.671000342764392, -0.6006103448141419, -0.8285927745171922, -1.001499315524607, -0.5256744555754712, 0.6739243586261323, 0.582163390588564, -0.5266180817943101, 0.4532362993557893, 0.11988481319122297, -0.14569824600413223, -0.714776341285435, 0.2354819222410902, 0.39265842110561244, -0.5038935591481368, -0.5864202030981238, 0.2812170101378072, -0.8382873703679611, -0.6439544372900546, 0.8417326511721639, -0.9051437830209896, 0.6176559667074232, 0.14027606682512786, 0.4553456177757232, -0.7178470084154784, 0.6657381843245911, -0.9858494533211469, 0.42835658379060015, -0.5838323630433666, -0.49347491034847907, -0.8943012412275236, -0.8874329638078562, -0.7930364251174091, -0.94259014313048, -0.7449877349935231, -0.7956094628101723, 0.8000455473208476, 0.5355715097203846, -0.42203550122341527, 0.6751034938952961, 0.5169261988048811, -0.26060821416258917, -0.7903023660352111, -0.15435391607744645, -1.0494812944024141, 0.35892139371598575, 0.5102842490908799, -0.32418954045914006, -0.9685495430996309, -0.7991818391329651, 0.4244666644883777, -0.11770436926380566, 0.5968312879795289, 0.34203126081646884, -0.4139704694770564, -0.002919577330226103},
    {0.403694668713771, 0.12053821050235043, 0.5878665352747833, 0.34362606332193674, -0.21166346107567716, -0.48120858295756774, 0.07646720623730535, -0.1902716860341706, 0.6809988678610729, -0.7222270141408794, -0.5147034978215315, -0.9552203709719282, -0.5581380780525427, 0.48323057751972337, 0.33759861630208343, -0.6684909037923279, 0.4703009135233754, 0.12023867561933793, -0.39078412038426236, -0.62974834816833, 0.4651800021596969, 0.5740742788015156, -0.5061528726907952, -0.7282372836500306, -0.07354459245731729, -0.6430362437234521, -0.7257447615996531, 0.6596401335001544, -0.5182699371635732, 0.5917565335905288, -0.12892348784250388, 0.3168781271925627, -0.7044480836249821, 0.5019446595336018, -0.7612652965424395, 0.271279690112689, -0.9173299965514574, -0.7700123630428819, -0.764121182960428, -0.8641784303837424, -0.7026787892696765, -1.0101237366066154, -0.89619480579908, -0.856942989670505, 0.726582249801529, 0.5210150880431546, -0.7967722436177822, 0.581975953377991, 0.7716258901192213, -0.522216326436833, -0.6805023512894166, -0.34699517197366364, -1.0608872584320015, 0.40701684255372894, 0.6885569287220821, -0.031081695558770654, -0.7469579424732288, -0.8406722775775693, 0.671298638914465, 0.2927379586690869, 0.6271183445186437, 0.556191991736391, -0.351410832988595, 0.05511320196113771},
    {0.52766508518405, 0.19713382899346804, 0.6409102492726705, 0.35571626049684724, -0.7469058586738494, -0.5156749424254539, 0.1889003383178045, -0.0005089964077480545, 0.6110491890821467, -0.8293672726082405, -0.7183861279775445, -0.8300949091170093, -0.6245387742171314, 0.46573550223645727, 0.254117896833276, -0.7483791953506335, 0.39139540053334876, 0.28353151441110075, -0.02453307354773017, -0.6714927699975601, 0.5751713494737328, 0.3031841775955412, -0.7719647697225, -0.9397784125546241, 0.24021237123626815, -0.6262637101161498, -0.8617673969982182, 0.3936272251653522, -0.8182705660179278, 0.6545662391918879, -0.029372074745378146, 0.19564350258160323, -0.7782384764271976, 0.37779141357195056, -0.8620367574185016, 0.32558963756031223, -0.7600154830028355, -0.7739496394316118, -0.738248076565875, -0.7269202770845749, -0.7074836798955899, -1.0405387957963108, -0.5674556877985182, -0.5785600899025773, 0.6710364229415123, 0.24103035690494537, -0.7645023602934102, 0.6743540133039563, 0.524840340577466, -0.43174091559334044, -1.1030846842920914, -0.1501677494803287, -1.085262487003439, 0.502163011526939, 0.47494143683183815, 0.018562063040148128, -0.8599557685521013, -1.0407975364322068, 0.5188279534726282, 0.2483484690166317, 0.5848092833599148, 0.6267129664253743, -0.23501522745874184, -0.004331094155827338},
    {0.43575402846442995, 0.34807598151679453, 0.6193037517279814, 0.4174990059281408, -0.6828534207943432, -0.5716110138053309, 0.015080535039498156, -0.17913127838340806, 0.6072136543417507, -0.8352053252426415, -0.6358114787873023, -0.8449017331410901, -0.5100782011564919, 0.16930462907205976, 0.4528403836107084, -0.7664661424254593, 0.32175838223078485, 0.4050940856034195, -0.043675639835383376, -0.6508323007369686, 0.3236665289895554, 0.21311111036718997, -0.6461095298779622, -0.7800265501175465, 0.28682753361811325, -0.6929060753890973, -0.8300577511600499, 0.5295970269566826, -0.6586647759164237, 0.6884676256831161, 0.08865656088094837, 0.23352346561742085, -0.7556293625757095, 0.24415457009411604, -0.6528692967903702, 0.48090404846696544, -0.7152362876658847, -0.7866395393935053, -0.6616171503903632, -0.5653427599051831, -0.6713223018321866, -1.1545218542519196, -0.6899728207295033, -0.699034075773661, 0.6824886833505498, 0.22897469719036184, -0.8267783829777723, 0.6846056800015833, 0.6647806719684375, -0.7001116936275129, -0.6033306545188596, -0.35602562675687516, -0.8353185352396413, 0.16888153075591095, 0.3693426681302512, -0.24969401206233122, -0.8403570659494878, -0.6457604427622915, 0.25755008592142065, 0.041914276583304294, 0.6407748634253218, 0.41314030258433926, -0.14661323649213726, 0.07423147531558688},
    {0.3886633085528004, 0.36872499292102795, 0.3471167065202697, 0.32614557970421815, -0.7815852879350768, -0.12970861872039818, 0.11874678439857352, -0.07731513161289232, 0.6103796412582218, -0.8904679490581138, -0.7240294323923314, -0.9500552777734886, -0.5938694219956656, 0.28349316492405013, 0.23772356674860867, -0.6414469009290024, 0.44381942146474374, 0.20978378705013953, -0.19941202764840618, -0.4918281914978042, 0.42007362730987735, 0.6397162827721297, -0.4599267373475523, -0.7870839490059438, 0.27160251424081105, -0.7091522476145591, -0.8800288141001162, 0.7915665323339659, -0.5759422101935627, 0.517561047172912, -0.1086796828222108, 0.4057131804460834, -0.8698062834500778, 0.34889871533738176, -0.9460618182564174, 0.37241725164865763, -0.7167528314064981, -0.8813921765896621, -0.8516773806378382, -0.46620983859532256, -0.8523929287437871, -0.9672196112779917, -0.6630444692592751, -0.6887408822606068, 0.6022185941794131, 0.40113953045352657, -0.9306120299794193, 0.6283967480479026, 0.7414099133647571, -0.513573902342659, -0.8073776518565181, -0.4219144768486604, -0.9690641264565781, 0.2742376309715701, 0.35267728219235867, -0.3659978332502978, -0.4724556127759497, -0.8119285451634729, 0.4849163735868616, 0.44567435346940665, 0.3646365094120479, 0.5952336619020833, -0.24748770416900892, 0.23079988365209847},
    {0.7117459019730852, 0.3345486982972129, 0.6173982847540297, 0.5219690332454378, -0.4401935763200232, -0.24219175764248155, -0.056628061373520416, 0.01075919227377804, 0.6952097104320683, -0.8621868737267496, -0.3965434390364879, -0.9192899605858212, -0.6758137054034861, 0.6013137212927125, 0.3206470279617313, -0.623185063263238, 0.7146817133225319, 0.47420047658454684, -0.13870962546806054, -0.5094839546516731, 0.6035268971010594, 0.5285106500635585, -0.49046402510558673, -0.5096074076901819, 0.008901388188480538, -0.5292110459830071, -1.007409812150749, 0.5847594630835947, -0.6058854022780037, 0.7718028593586816, -0.20964344869011164, 0.3268842191706998, -0.7000540838609598, 0.6828109964886993, -0.771412939202358, 0.30801436472134824, -0.7599203571145878, -0.9813976075713978, -1.0925824358145333, -0.7563939118412087, -0.8399028837982218, -0.9412277668349326, -0.7685001094541838, -0.9242482524667672, 0.8630029159775762, 0.41946636578668556, -0.8447763000118762, 0.8614914268057947, 0.7965891607368116, -0.6060487781049783, -0.5745045437309801, -0.19398128177005522, -0.8576584888108305, 0.2271878016006651, 0.5333447483475408, -0.26421936938437673, -0.6193431467292762, -0.5658381144708815, 0.3080958179519968, 0.034302690101112386, 0.9072749550408663, 0.782155394885459, -0.47015816876547023, 0.13257179537942446},
    {0.28408769378393367, 0.5866237987880467, 1.0602628176255438, 0.4750261154305579, -0.5980270040769586, -0.2015917296619088, 0.4094852243666374, 0.002334486620194599, 0.7348479724142836, -0.7743248909087523, -0.8299886379014527, -0.6454555886541679, -0.734429294277779, 0.41064847315270303, 0.5650429551384707, -0.6429828358414172, 0.594205360420676, 0.42494061763154767, -0.1494014836342102, -0.636978989811289, 0.66284912523414, 0.7498092129092987, -0.3851258501371799, -0.7841378636716893, 0.15116685228188154, -0.5463352020167674, -0.8696443560408046, 0.5739225699843324, -0.5257118478915644, 0.5482643831097197, -0.15928164101785905, 0.3718387750906672, -0.5909817969376949, 0.42148770147540227, -0.7797797212122101, 0.5546079157084991, -0.9622147371499129, -0.8747599511394426, -0.558401520825282, -0.8413866211466187, -0.6695616676192022, -0.9421378950908672, -0.7464052653884165, -1.0150693036977296, 0.5215154037470916, 0.6070539991278217, -0.7045290113179534, 0.8178942211669954, 0.6028415560940082, -0.39999313371504475, -0.9335456818584998, -0.1628322098884753, -0.8719291197671184, 0.5556053559238426, 0.8004536760148478, -0.49857917409721997, -0.7492540219758642, -1.095462237347838, 0.5801581047255091, 0.1894411689945414, 1.0342441297937393, 0.7095465871141041, -0.30212500512362545, 0.2927837626036276},
    {0.7508753439133149, 0.5036229052573875, 0.6343620546361849, 0.518258839643229, -0.5848119922918384, -0.03902882953903198, 0.43188431906083563, 0.2705200462359711, 0.6973882771661419, -0.8729074602705368, -0.6376434301098104, -0.7282048331706905, -0.5230131977757422, 0.5208393825801232, 0.6329231265679571, -0.5867254487355987, 0.694404364278549, 0.7321694930982503, 0.06224669820617795, -0.6152100432970533, 0.48737960708614053, 0.7551287056921582, -0.06240582343148816, -0.6996798958522694, 0.3663446964696312, -0.5498356294282777, -0.8727962716471224, 0.39359003228759115, -0.5570712710482797, 0.7978343978602337, 0.036933367287760956, 0.38226341861625934, -0.675376662243034, 0.4817784275715496, -0.6960674783836003, 0.5101142263566103, -0.7402510015951249, -0.6414540239650581, -1.0058377019608857, -0.7566801994893444, -0.6974839424653368, -0.7529110568677706, -0.7367727959561401, -0.5858209791148457, 0.5239096006165077, 0.5147198003770883, -0.6286470574519036, 0.7764934511195319, 0.5804881320215559, -0.7334730949196681, -0.7847082915904633, -0.1695957584914226, -0.8058155949712498, 0.44023910779678294, 0.7530920439283634, -0.2728206758756761, -0.8853804277152186, -0.9990196716549546, 0.6001463724064935, 0.3325460591065548, 0.9219633997537812, 0.740093729553127, -0.2300018391150162, 0.19011513329278845},
    {0.8865768041561798, 0.5984375652311481, 0.7768072421156899, 0.5767293641039364, -0.6775222913822807, -0.13692618414503802, 0.47068971468518833, 0.39470304383978744, 0.7284165559267262, -0.6482710123730202, -0.5209101100882043, -0.6451034081025276, -0.5258971598545532, 0.8772105720923423, 0.5281651943136616, -0.673724876626277, 0.7009718244730947, 0.2107429131311931, 0.024588981139905278, -0.5881085358678357, 0.8033497208480777, 0.8095755207560347, -0.2646329734385039, -0.8067086164007523, 0.42222645781727136, -0.6886724882147834, -0.7023074092894892, 0.6749335466105063, -0.4715987233014351, 0.8433843129761992, -0.04718169683610978, 0.40129813151935606, -0.8052415364859811, 0.6174612356723115, -0.4748712837039726, 0.6995131040400556, -0.5984312453311005, -0.6054023653661192, -0.5079515381208404, -0.5169660001224009, -0.6089531746584982, -0.6334634938674477, -0.549889946519059, -0.6917550384882466, 0.665834667887211, 0.7642918056607135, -0.6907005932120495, 0.7058973394661539, 0.9694563830585772, -0.5990438033308813, -0.647218828958663, -0.08916675311638653, -0.7551363419179714, 0.6308584685700536, 0.9417798296983739, -0.1678515396104867, -0.5276875711213332, -0.9357217795261892, 0.4090793342217858, 0.5256062230015042, 0.7787735835045808, 0.664771231867626, 0.14033298864144736, 0.41861468029589854},
    {0.7123117357187586, 0.6184458492236387, 0.7093029484438884, 0.5344280306132375, -0.5065541593055903, -0.21055464766591442, 0.28110346507343853, -0.014756799054254276, 0.6330145720018785, -0.7699466660570322, -0.6630990282494293, -0.6544257290515014, -0.6571918246367122, 0.45313748498745093, 0.487619722665934, -0.7210900888124333, 0.933613859724375, 0.4003991222489537, -0.100836204416559, -0.7075656925497981, 0.7720306576820152, 0.6378250661606968, -0.2721438862009659, -0.47013752958133864, 0.38429469082211126, -0.45236329626294214, -0.6532613889549115, 0.6298429768159739, -0.6881941675463752, 0.8032706723179336, -0.2536290896149182, 0.29653871306979274, -0.5083165492715577, 0.8359772304115781, -0.836408266980856, 0.5120262524781768, -0.6370102234559353, -0.5786705675322986, -0.6395436196650274, -0.6026256631506821, -0.7943593426347207, -0.7596911095075535, -0.4450791218500229, -0.7597365296420675, 0.6136016635352497, 0.7354389857642163, -0.6074551980697819, 0.9293564070565667, 0.8177867025824117, -0.49783833359557567, -0.4931823735432203, -0.13256477693001698, -0.5732629803283361, 0.6835195451650402, 0.49380422964383186, -0.3903693874288543, -0.34683147205665704, -0.8312859972973575, 0.49130107912530635, 0.006915688526251227, 0.6176302142102771, 0.5778356599644784, -0.3894509640334959, 0.40996524826796965},
    {0.7392598529730822, 0.5984813154337606, 0.8442426235779036, 0.5074020204223405, -0.45292049243784754, -0.4394096991440081, 0.45982357705964644, 0.03653882473947166, 0.6455718016262065, -0.5707499574456546, -0.6805478313235429, -0.6386026726553293, -0.7284121335140926, 0.3730979341251224, 0.6778941699003771, -0.5040031283474004, 0.94561903978833, 0.4199502732399179, -0.2435782708748315, -0.7680488323036115, 0.7463532068811114, 0.6892715804846964, -0.7518567995334168, -0.8811716315084775, 0.22668851247337252, -0.6353474447645668, -0.9525794686834199, 0.5209286005784364, -0.510222383496279, 0.8524539433014995, 0.054249330918876425, 0.36939308464955223, -0.49215936986303627, 0.535387706554298, -0.8753748533859929, 0.5627081485848078, -0.7993243873529284, -0.737858409236579, -0.5981295552917028, -0.7947019494096724, -0.8104596976794753, -0.9447527141008317, -0.6731858368728262, -0.7471916245354188, 0.6195003134982722, 0.6834277245774641, -0.7183655691834732, 1.0928385620154595, 0.6062850708176817, -0.5636848712752764, -0.5383418039528677, -0.24086270166461968, -0.6734002664507116, 0.6375332706927017, 0.6130814019413872, -0.12270941322592935, -0.7033698156175884, -0.9479166585180344, 0.327034509473567, 0.13898715083091448, 0.946180310522235, 0.6802820103118459, -0.23467626545748532, 0.2355293835574552},
    {0.6707713891288832, 0.5415686458284488, 0.9993918386394348, 0.7451494574531693, -0.5543898983174641, -0.011667313858196042, 0.2858943825772842, 0.40177504163969996, 0.882227225324329, -0.8674281197412305, -0.6620391729306461, -0.8256160015650621, -0.6862310208874405, 0.780993020287068, 0.3855484870804614, -0.3910266046633063, 0.9433080638991093, 0.2749386191685903, 0.07442910250771954, -0.6072528110418018, 0.6673584993773216, 0.8342542956466032, -0.524253401648048, -0.5837964599336336, 0.2631924319848407, -0.4487003926335421, -0.7678904967540583, 0.8361759162292138, -0.7910186839115253, 0.5735566339512962, 0.12702853991714166, 0.40032793036538805, -0.7590325305662128, 0.6908699646575307, -0.6329152881691724, 0.3821396421968683, -0.5830209078316257, -0.7361072396803672, -0.8412490947330846, -0.7493337159587924, -0.7335932401787909, -0.9574731377574343, -0.5080689960607605, -0.9404060696271581, 0.4801744953068631, 0.6880055041235466, -0.9115454438757113, 0.9610979749453444, 0.8911225333894267, -0.6642243869680937, -0.5436171385615214, -0.04313710422456814, -0.6662463788259317, 0.6624030272364729, 0.8398388481759143, 0.06451233968051602, -0.8891799103457937, -0.6354600299513536, 0.6815322404768194, 0.5262464120572803, 0.8342311923247481, 0.8757729552944804, 0.020561108907578687, 0.46026411868797285},
    {0.9042471217585629, 0.7560110074942049, 0.9247757519450202, 0.48393985716028964, -0.3490525618483523, -0.17000345568641848, 0.2519844017239995, 0.2250264888607194, 0.7828178126035317, -0.9225217405485896, -0.05970457718743696, -0.4719846575144607, -0.4781272907231029, 0.7256908710243327, 0.3844531440989156, -0.3541717093279526, 0.9905163505571126, 0.720740515602034, 0.01191894687643746, -0.5728397389334072, 1.010492408085421, 0.8135164818047166, -0.515877645748173, -0.5555623686130452, 0.8404964144098795, -0.22537601536837035, -0.7401682477088158, 0.8311193033201766, -0.5610424670368063, 1.032123271909095, 0.2364203375964988, 0.3135714291199431, -0.6390521731083214, 0.9599680759282118, -0.33394303677944087, 0.6757167353260213, -0.7349666417773458, -0.22395913260497435, -0.31840666261942124, -0.7693045387776384, -0.7448385738080494, -0.9364242974087602, -0.704512224706738, -0.8308672968246765, 0.8087361456737426, 0.7168250105078249, -0.7744100400616417, 1.0130679630070991, 0.9110026073569464, -0.45901221681981635, -0.4633727725068232, -0.020489513627905444, -0.6008240472738042, 0.5918195509272339, 0.7879580421215561, 0.02001495593017379, -0.31258628564779073, -0.7591794672123995, 1.04113964421156, 0.42948777791212833, 0.8004528332034414, 0.7534615162430564, 0.21682734121500682, 0.4771581143623566},
    {0.9679986780102297, 0.746644458625912, 0.8166897843815896, 0.8493896185782867, -0.03985118922919324, -0.32298335618774154, 0.4700209053818973, 0.26344834160850383, 0.6861454225059491, -0.5346383781062602, 0.029637453884502046, -0.5818780124091346, -0.46152391978322593, 0.8108859966414821, 0.7406886230932962, -0.19393380088959153, 0.9723969705328535, 0.7589107555953172, 0.1728546085800698, -0.6658496957238691, 0.995131267804724, 0.8209940182172507, -0.30541710205965245, -0.5886078829569711, 0.6667942196197699, -0.28507880343944686, -0.3135031817912075, 0.5141281500567612, -0.3507721659201107, 0.6795629896923556, -0.1985405164293179, 0.3870894705700951, -0.6069313092364224, 0.6459196043345365, -0.24315841552690684, 0.45762590908515893, -0.5629829255772015, -0.2989560488865972, -0.4689115425860917, -0.5656411396312492, -0.35027641831753903, -0.4497830305407033, -0.4446194503603292, -0.532545878453147, 0.900239856138622, 0.7595681400316062, -0.3036556922589865, 0.9103706678645084, 0.8281482191746564, -0.1597553359513018, -0.40586976435593086, 0.07781075315254465, -0.32176441981380083, 0.7123281316434608, 0.7314539607004786, 0.11644729399127657, 0.0030159668662076877, -0.7105323898674113, 0.9579814561193866, 0.4154243372819658, 1.1195439770282904, 0.9100232386876332, 0.037838652297688055, 0.5407747044463094},
    {0.5586635232863382, 0.5799564441268442, 0.9964933296808027, 0.5739086838515618, -0.16456045205857323, -0.22028343702338166, 0.4927710806030527, 0.1962566728825078, 0.9240163421461012, -0.6035918668048644, -0.2787211776960272, -0.6132534100538235, -0.4627242262024929, 0.6416476016932406, 0.5561260893722871, -0.4151277404686305, 0.7281875863691992, 0.7348189249169629, 0.02086730981708572, -0.6629243728086451, 0.424980031479517, 0.9263977740466182, -0.417151568765523, -0.6558394681574582, 0.4527575487584878, -0.2620650166432174, -0.6043189295241783, 0.5863652269294437, -0.4931777056164863, 0.6621279336019039, 0.003055288808554809, 0.4709330648931356, -0.7932816322776745, 0.6014100107368614, -0.24692534122264306, 0.5447030086567444, -0.8080864166377958, -0.3968263109631279, -0.8176387570422133, -0.7125801907267098, -0.8675857900545048, -0.7668711357485705, -0.42794916765491525, -0.5759112629435398, 0.9303257321743705, 0.7504696198690406, -0.41986619731117725, 0.8033392848399123, 0.785370056298623, -0.5098626368276532, -0.7099348540469712, -0.03195676483588965, -0.6750371921927522, 0.6743268401163809, 0.6797296675840276, -0.1839364449535563, -0.45316322254757985, -0.6305714611106396, 0.6372759225246005, 0.37225121876418027, 0.8881927897047428, 0.7874259802210272, 0.15205007558804712, 0.671076952240159},
    {0.7085575341524062, 0.4757984738183901, 0.9646893726877745, 0.6180908173903614, -0.3586867993378396, -0.27542519428335555, 0.473699003254542, 0.20862076798078802, 0.86703229719458, -0.9089727305778178, -0.5718900516799932, -0.4896738334198842, -0.5536902221594444, 0.3805904446661212, 0.4620338557713258, -0.4843733255309211, 0.7782963526994852, 0.7271756075737449, 0.002717814569996823, -0.5307032808017362, 0.4615771345385463, 0.5229776349269136, -0.3297114366333083, -0.7147408648082955, 0.46089069249824527, -0.47046667981199947, -0.6683922034739961, 0.5756223833365982, -0.7096229161498373, 0.7629424747298142, 0.1139845103075902, 0.5636332746062798, -0.5853376502209998, 0.9332314252725374, -0.6875527762513866, 0.4438006344162194, -0.6715025137669361, -0.5988300997643364, -0.645515785843934, -0.7289636605846934, -0.526335569122751, -0.798958225221546, -0.4943926718845687, -0.6842305179716394, 0.5861528252032423, 0.7141814391656273, -0.38527075272888345, 0.8530348845147144, 0.877247984432936, -0.5291615259026243, -0.7276415235959841, -0.052304775809230895, -0.9057892095934692, 0.7929811938590329, 0.6785120117581942, 0.04917693914380803, -0.5182058847612121, -1.0362172086389396, 0.72069322531821, 0.2878815476302095, 0.7978760496139581, 0.7881386221909397, 0.04913190338780833, 0.4262043063281658},
    {0.4533001111377074, 0.48809572454580913, 0.8203036495556133, 0.7236700866217931, -0.5727600293213903, -0.18686749328652053, 0.38208481083446116, 0.14871294896009504, 0.7677057111336837, -0.7046548509421003, -0.6875524827539417, -0.49725689136710793, -0.5093924223292022, 0.6791478478955261, 0.37770445712623707, -0.6124743563890873, 0.7605558561737582, 0.6114001488772861, 0.16623753718079856, -0.5487361580863945, 0.5608106937942889, 0.7695393943991451, -0.395784691397567, -0.7062191541550383, 0.7460508960800175, -0.4138877838781662, -0.7156420367833266, 0.4499516406204592, -0.38142498100116773, 0.6288126553138335, -0.039381556424541386, 0.6701571136221797, -0.6655876718371294, 0.3795697876990665, -0.44606371531333944, 0.36822355777568994, -0.7312880879280065, -0.7145312845599602, -0.8125928993668544, -0.8239336176703019, -0.5769347021231209, -0.7316461510351582, -0.834928511936515, -0.6106146990795118, 0.6085350507063549, 0.4757360851082423, -0.7704956667586994, 0.7286189880323168, 0.7215814128970973, -0.4646300963654419, -0.6247203104636634, -0.24541086715577326, -0.7020607238795801, 0.4793279598512615, 0.4099346264381095, -0.13624340211884522, -0.4762885179095189, -0.7250110327773186, 0.6667286395852895, 0.1394743340539144, 0.7454058198062687, 0.6076243403703658, -0.15707343562891563, 0.38274309236381565},
    {0.8333298373441951, 0.5317041170176938, 0.9771825816086004, 0.640285283850449, -0.5195656736484514, -0.28325644867455824, 0.5086358866463215, 0.0324524988579926, 0.8655081611111758, -0.6852458311399637, -0.32551416722302645, -0.6159912699270498, -0.7499385482184011, 0.6457234913263515, 0.36974258148267136, -0.6376507844279079, 0.9809134248733447, 0.6693253311933026, 0.04850553372209786, -0.5115018803332383, 0.5241429728920494, 0.9480858775158492, -0.5155408637816948, -0.5025555672261186, 0.705977506855088, -0.333846072820402, -0.7965261701879885, 0.7611021351725575, -0.5099492641502987, 0.823098927453083, -0.053929338407918616, 0.5678486915693775, -0.5184814116542052, 0.7264832787682148, -0.4561554003082692, 0.8172167773984926, -0.5393366035449855, -0.6226183987657163, -0.3787211610151071, -0.762899491794576, -0.8427189063219811, -0.7022836411128912, -0.5135570947487568, -0.3626144991176243, 0.6143243503734577, 0.6488035568308778, -0.6945241617492548, 0.8563263104322216, 0.6187847734689612, -0.5526626313163714, -0.5839932403308782, -0.14095660857506961, -0.6936516652365763, 0.6601789383897148, 0.8469816598606105, -0.05872668536135823, -0.38564095855457475, -0.815314801696371, 0.8007190878271606, 0.03871158416603685, 0.902078186660767, 0.7125341001977196, -0.021157949791878374, 0.4004330887776046},
    {0.8382862219488202, 0.6725139585611583, 0.9799215787304094, 0.32439590189678236, -0.44753782100477824, -0.3240887554141289, 0.5393021390326755, 0.42083182001215774, 0.9009864610500761, -0.94747751069593, -0.3413501565784326, -0.6427671650377623, -0.6646155987465465, 0.6976845018455935, 0.38807193236903814, -0.6503165898037941, 0.6828109813318437, 0.4863589365460026, 0.09971179465140556, -0.3211425483758506, 0.7027047061496255, 0.7741942716661794, -0.4162461542787021, -0.5839532607517922, 0.31523384702943963, -0.3840410863779816, -0.763034332277477, 0.7601776037378758, -0.36921414806441394, 0.8663950434995776, -0.021920769937206628, 0.6565409192740206, -0.5025863484104879, 0.5621890530193985, -0.4261567391874792, 0.7712012855561045, -0.7608044797241301, -0.41806958245776, -0.4328482798137814, -0.7691296628631548, -0.39692144387051587, -0.9797886779617349, -0.629406584218222, -0.7878757575635051, 0.877392685927992, 0.9374428417900866, -0.7070723215125305, 0.7857628585428581, 0.8490038623141495, -0.49397826047884774, -0.7760963740068905, 0.11403592888052493, -0.8296274992611329, 0.7459915795497161, 0.8009959323475515, 0.015562200649781243, -0.5306901264059675, -0.8222286655424867, 0.6702948419936114, 0.00545028858098716, 1.1762905440913227, 0.8190232030511237, -0.08214936300031284, 0.24271456002095265},
    {0.7898659178475024, 0.6522306426852612, 0.7671841253761119, 0.5399909490421578, -0.3141252521452605, -0.41108429987617473, 0.45456182274987406, 0.04548825543862309, 0.7586655689367531, -0.6488629913371228, -0.22382324471260387, -0.5436430744259796, -0.5778270404145981, 0.649974138809632, 0.6836427818177814, -0.609986420078341, 0.5834529383877235, 0.6061482658952658, -0.164299834617498, -0.5082143799955626, 0.8301422421267513, 0.7981658861925092, -0.6227544232395971, -0.5993246384313472, 0.7012280752770893, -0.5567777463725058, -0.7640154853719693, 0.5079048236235483, -0.36355355450306864, 0.8499311545335247, 0.021150911303533474, 0.39723136264892606, -0.46920428096213646, 0.8571003975851502, -0.7661948445669043, 0.6920959559426048, -0.7637748265872225, -0.5518807458622784, -0.7756063194745817, -0.773360786343151, -0.832079576920942, -0.9115774261494419, -0.9596053211325932, -0.7653444227403338, 0.755625430269221, 0.5709807990448246, -0.7341406268308935, 0.8956723724870733, 0.8571117169758115, -0.39571823189196337, -0.8413300706647454, -0.04301754391884214, -1.0244887569914607, 0.6266413609405737, 0.583602242549688, -0.07531835674634516, -0.5937879404466826, -0.8132816912264202, 0.7898601710342041, 0.6172326592630485, 0.6714650340582707, 0.5503421477035478, -0.1585527824265969, 0.5594286399457764},
    {0.7142231042942493, 0.21997862337352955, 0.5394801525780712, 0.6647329880518097, -0.2768534688174504, -0.42844270193470985, 0.48488759927087516, 0.18901110663073645, 0.7722821789529177, -0.7955227870846356, -0.1774258503454245, -0.7026162211569403, -0.37496882434180984, 0.6847815383199022, 0.5486557239013863, -0.3193135885053899, 0.8102333664095274, 0.4879458792047725, 0.005606547469271974, -0.5210826001379538, 0.8907194250526868, 0.7729920744559715, -0.3475906840342958, -0.6258504958458656, 0.5907283955681317, -0.141737042552222, -0.7726079785950799, 0.7670155868044892, -0.4679068527707815, 0.6615576873830833, 0.0024096251161089244, 0.3842522213479026, -0.5222049234833249, 0.8183682493338739, -0.23078997442309537, 0.49449356799857597, -0.46151203892033005, -0.6853966024370528, -0.5556865884273858, -0.7100049082787454, -0.4944434742877472, -0.9171967912878276, -0.6571463659716416, -0.9577250809562599, 0.4794880458100701, 0.6416675179699302, -0.39272992608436263, 1.0236589600346375, 0.8445445850283824, -0.4058697008353625, -0.507785544788651, -0.01325076007072918, -0.48491763249462794, 0.7916835061707019, 0.6680326188000805, 0.1603107336140573, -0.5560154054682335, -0.6855217023471498, 0.9290358790544094, 0.10624420265400474, 0.953551816395284, 0.8823678261152885, -0.02313229374446381, 0.4053560628797851},
    {-0.7841660339723524, -0.409970677117929, -0.4025402934087331, -0.46778374126108313, -0.3936932007076026, -0.2296190679296774, -0.8675594128626307, -0.5352050173033593, -0.5815770212460838, 0.2917595466801867, -0.2152274385666457, -0.278653886777839, -0.4504035083499616, -0.42513148421985564, -0.367804614119952, -0.2966820735894307, -0.6396892717091384, -0.5729790559711634, -0.06009774659734488, -0.6765089331046591, -0.5560238262898294, -0.6229339110446718, -0.762266166618972, 0.27360455819854373, -0.6506703300072595, -0.3334655428220914, 0.1938386294052849, -0.4882520072987054, -0.0635062814853192, -0.31118393418376405, -0.3004667175017829, -0.22939519811649886, -0.19471017736564086, -0.5002910605628557, -0.3553076103385154, 0.18278850087385215, 0.0067354606185957, -0.5119868610576283, -0.48930949970544474, -0.5270988230984315, -0.47017805352297365, -0.24785175426608738, -0.1715528258512995, -0.3212408756766885, -0.6304450092156249, -0.6392424951131777, -0.7057898378524957, -0.47420294006056146, -0.4668517161750626, -0.45918102331785643, -0.4694903157137526, -0.5092831948378215, -0.7559528499840351, -0.7768854079750743, -0.43396455011399354, -0.6401302232891873, -0.12617137110532162, -0.31047544711363917, -0.29598374208273504, -0.7592162188565404, -0.3713648767520025, -0.5346265008748406, -0.5161361338222616, -0.8751371490338287},
    {0.04716005539420517, -0.2658044788321202, 0.3267223014578999, -0.3731562670961118, 0.207386104951875, -0.21300667409810217, -0.07386187378512529, -0.31189082777601934, 0.05601156467652716, -0.2777253839440178, -0.08467909766682477, -0.6022097334936046, -0.421076706920458, 0.2413372325990239, -0.15347374304927375, -0.055452325284183805, 0.1801001632022137, 0.3156085453786707, -0.40967717054391006, -0.10331199965643194, 0.20198994781045426, 0.2550384909610938, -0.643174460121689, -0.41748431286298165, -0.10930018139537351, -0.5235194187746014, -0.39585813491361715, -0.07216762577327794, -0.5233657810940102, 0.20567690209021705, -0.36918749068979767, -0.10368226140482585, -0.2864470043964757, 0.22684768956239265, -0.24191579622053122, 0.192454291323644, -0.4891903476548427, 0.0470682755067187, 0.0698939820626252, -0.3483180122281756, 0.1820691320602313, -0.47110640826631645, -0.2314872651967965, -0.5501721881164123, 0.003292026895942858, -0.035990666366880766, -0.3845865230068002, 0.45061945103495227, 0.26380871494260844, -0.37922907926441424, -0.7402691340027784, -0.14034769045769657, -0.3553837114994978, 0.16904045984138474, 0.5475383491990787, -0.29566269005470514, 0.11421301091857347, -0.6955193647997479, 0.3428073707128118, 0.09270889127679273, 0.45201043309586425, 0.42651720287908984, -0.28449189683915055, 0.09281915063218403},
    {-0.2691930436632694, -0.05449689753328738, -0.6920510248039162, -0.7289191417577272, -0.19269015034020526, 0.02950742246203333, -0.7687051905066945, -0.2557098044050493, -0.5602110702271456, -0.5723801574219176, -0.49779596504963197, -0.4409209567539815, -0.6215546690579978, -0.23566830301415342, -0.34602969826110813, -0.32225143232707937, 0.10904363080846943, -0.039078159961302386, -0.25784500237656116, -0.29949829776536474, 0.03019733733385086, -0.3802252271576921, -0.4630832692359913, -0.023368826816935733, -0.290628257846105, -0.48223007777750365, -0.5394027133400883, -0.5452122133115552, -0.23820240861648598, -0.06727354295950495, -0.47495546751923245, -0.21027478408240025, -0.40482906909619254, -0.17743454399756492, -0.33550633775645994, -0.35714467436584185, -0.12348219681310442, -0.5512638535437574, -0.6691680980737875, 0.03385442487325303, -0.3770927728299578, -0.20623724480064304, -0.3890693778782313, -0.23839954841535385, 0.037698050430127916, -0.2052719204607435, -0.7130682594231624, -0.2857975495908276, -0.5767433128711984, -0.34070601679737533, 0.008499747335481535, -0.3274304440969722, -0.21531985549585497, -0.46347318480416094, -0.1126441114672204, -0.46577131874868033, -0.3525547662576489, -0.363408916065158, -0.3386423701737523, -0.5881273261392035, -0.20902487393360414, -0.66658774809873, -0.48863947304584876, -0.5722415809774234},
    {-0.07102045943449269, -0.2763404623696549, -0.1597554014429732, -0.580036119461281, -0.782504766898555, -0.4034543107681135, -0.36102065653664817, -0.4964833900499291, -0.3286137957506565, -0.29834931539910686, -0.19325885593071482, -0.01745894078979307, -0.20214195199579046, -0.17444334704110104, -0.059226311915855694, 0.02267296960093786, -0.3254431856579067, 0.1914880423246216, 0.06566414969148525, -0.43511118554792366, -0.23724408108845738, -0.16168081508627152, -0.12079183802697305, 0.07320567292782368, -0.010292046571859812, -0.4962099532421867, -0.11858259416347619, -0.3401312560153475, -0.7162695579217806, -0.007734282722717387, -0.7947700042572092, -0.43036569340231756, -0.23700897487957234, -0.2548780496226934, -0.4488218228839632, -0.1313228290362248, 0.08792551366656784, -0.6343109212134999, -0.31890204506895853, 0.20648904479815014, -0.5011044766360717, -0.30193120203944473, -0.31018229192854124, -0.06636341575150324, -0.0373170998067304, -0.18522395939497435, -0.7170776117533877, -0.4496941630899177, -0.652152361000906, -0.39134026053668647, 0.16685912999375307, -0.4876020254834566, -0.005800999302076945, -0.13156873675785807, -0.3466340422049359, -0.009882384826261512, -0.1700977394891271, -0.40018691478197876, 0.007713688347591031, -0.630608766421276, -0.4938579162831383, -0.28718164091395026, -0.5556844300601819, -0.56331119743381},
    {0.059408478477678474, 0.11279682887732412, 0.1000914979632982, -0.2893251911538024, -0.5053800611790069, -0.5822198157709089, -0.23230876026420477, -0.5478617667402567, 0.027139165119083507, -0.5612431412258878, -0.41210391100930843, -0.40428424263837137, -0.41798075574774807, 0.2334244932099418, -0.1579925397724227, -0.5745165163569916, -0.3026125406683446, 0.33868414148319664, -0.2207022458915033, -0.4877795807702327, 0.06290106056684523, -0.1889028917277085, -0.20604473381328958, -0.025802905686487243, -0.12904343491793763, -0.4145301584636136, -0.3672961900709332, -0.06265202896119008, -0.4189671999173338, 0.4565791420444493, -0.6067528103881422, -0.5881625345607522, -0.6895646025941075, 0.09765070141468572, -0.9112006569008192, 0.19274537788818077, -0.2997291018045083, -0.7953888738425636, -0.7606392945140434, -0.5045236943158725, -0.5020837757073711, -0.5409907814755384, -0.41899775980686377, -0.29863720793719245, 0.4315692004315404, 0.06292686195910686, -0.5335148610672853, -0.044774170580626466, 0.030152614976666606, -0.5682883223739661, -0.3014472271852517, -0.6251221586028162, -0.6635847272664585, -0.07863758222384766, 0.4177779080571246, -0.5458596046714289, -0.31826629388401234, -0.7731554465874231, -0.009650644715253315, -0.5887807546563708, -0.04737176909729914, -0.23600457819758225, -0.48589156070492057, -0.55156452364227},
    {-0.26029795285379514, 0.05111020072477251, -0.2525478831627815, -0.7094071093385332, -0.49777706571938246, -0.5612906390464018, -0.6616601418869039, -0.5972953041520623, -0.22926081091439718, -0.801616246434027, -0.33468272948131705, -0.34065912767991047, -0.17965923635438383, -0.2244917606517909, -0.2383611715483281, -0.5121653049179271, -0.5852925086739393, 0.373976460098887, -0.5721593692975158, -0.3737249983935151, -0.4679124045223936, -0.4814740059777591, -0.4051674830341797, -0.28024338542888827, -0.4805123541226792, -0.6936361430877216, -0.6455496013017368, -0.3354306362351508, -0.4167604338286465, -0.039221010028038, -0.557148826611828, -0.16668260422033435, -0.407491129536677, -0.1710129992861447, -0.7772217792813799, -0.10252295540481572, -0.4943270509592949, -0.6082767956539646, -0.7290024534502139, -0.19889036369435104, -0.6243195491841714, -0.5004764220989293, -0.3936578187691477, -0.4415140013380739, 0.2110933594744652, -0.23203257783883488, -0.6124271132547506, -0.12865495112713216, -0.5526144832697031, -0.5449126247831242, -0.17561274153559703, -0.43997390417237625, -0.3608208079349806, -0.5608946347182625, -0.0014320063973242358, -0.6531986858269445, -0.5669363312591564, -0.7125417778686266, -0.011992924910832982, -0.33231776190209167, -0.23667037088357296, -0.6138014033769751, -0.6642454542339195, -0.20324032492926314},
    {-0.43283670636295085, -0.10793555518903175, -0.0495565361102816, -0.7676249204742883, -0.31709135673290784, -0.5508212137921765, -0.5008489126602057, -0.7928393143322062, -0.47524959226975866, -0.575984765523805, -0.4481968677512009, -0.2152852720587436, -0.36252319993527593, -0.14433968381938336, -0.24274422457452152, -0.5603442852162013, -0.334230945060751, -0.130895421543643, -0.9005914933774567, -0.329957964073259, -0.21331206885548268, -0.6701701847592582, -0.8268662906216999, -0.37377075723078557, -0.5112861287436319, -0.8656553826404974, -0.418235129507443, -0.24476261516778472, -0.5577497390954285, -0.10260222087821763, -0.340460458492623, 0.04167337331262584, -0.52070629682133, -0.462747142828688, -0.4928135270208452, -0.3545204605512067, -0.6765997849122749, -0.696603759426513, -0.6047479212608009, -0.5444574327493018, -0.617687083617232, -0.5727152293655142, -0.5279653912804461, -0.4877180985623106, 0.11483103876986468, -0.3382790188940746, -0.6163701584011833, -0.22437866059024827, -0.5181611203637918, -0.3128309607547474, -0.2324175409230764, -0.5495198193422736, -0.5354331958162892, -0.3857958972664569, 0.03891615733662914, -0.6130456773053212, -0.2639986482649082, -0.7122120074777128, -0.10393407999343245, -0.5999249109223074, -0.20713737930346496, -0.3662164621322916, -0.5505719772959555, -0.49715106988024876},
    {-0.030908360951405773, -0.16564359176903712, -0.08617467712161812, -0.5938912584869233, -0.28915543525809306, -0.5653985386878954, -0.20070901206394934, -0.5279074770294505, -0.04682738251190669, -0.6018058761445253, -0.3136693380223349, -0.25728795647468095, -0.19088399077375548, -0.022121747745544786, -0.5173387419355004, -0.4516180319933765, -0.42022204954411707, 0.2534680483464064, -0.5089398915964541, -0.1055691367698038, -0.1284899277809602, -0.31316757316797245, 0.05454833033624975, -0.4991976198754657, -0.10089774445256643, -0.37855420204166534, -0.15779588199869563, -0.28913403635870466, -0.45527382942479305, -0.12363694561284339, -0.17850647332266634, -0.1458811225773382, -0.5549390804761096, -0.22890077933196587, -0.8409087919117015, -0.22651954390414603, -0.5372100807068609, -0.46804385156746237, -0.4316644959706119, -0.12035230935580847, -0.4881494252875864, -0.06204699737212045, -0.14560413963491012, -0.4571149988796447, 0.08807864203903959, -0.2053253933979545, -0.4448012946553339, -0.01137933502300235, -0.4294820209065136, -0.28520284469752544, 0.06883880062441904, -0.6471820462151172, -0.6448389230247036, -0.43786983210655056, -0.017118925304666275, -0.6239111035933557, -0.23152865084727794, -0.2777426315558235, 0.013788920849610935, -0.7630703770245648, -0.2062450692745856, -0.21334269216139584, -0.2676933088941185, -0.32979902457134636},
    {-0.07903326944060798, -0.020471197696124963, -0.10008672764652202, -0.6508537196797922, -0.14852785506267424, -0.6978274202054352, -0.23285895452248911, -0.663376878588242, 0.007234064546021432, -0.7931572229769585, -0.5946952973773906, -0.4436355305926827, -0.152933479279135, 0.3583393889563064, -0.16253540285322177, -0.45280004883074887, 0.03487396753228967, 0.4608077260069553, -0.337311923592315, -0.08863170817880037, -0.12455237162574408, -0.4774894349756784, -0.4543278853102845, 0.08535856669420738, -0.18923115130762347, -0.4661429413561688, -0.7143802064536084, -0.06424661353755838, -0.4917436145893588, 0.14991898951047272, -0.4642432833673901, 0.017285100416619296, -0.8078460314491295, -0.26983682623459493, -0.6389270053004432, 0.06121540100261688, -0.46161187222718675, -0.8165144636636448, -0.36014914592981045, -0.03292930480475638, -0.3126982810024518, -0.24166980260678075, -0.1717821531149388, -0.4393215865517347, 0.22619026485356755, -0.14180460317252166, -0.49055417382807354, 0.0986694238625334, -0.21376029003277808, -0.6801791572635401, -0.13003442551452812, -0.7389405571718743, -0.44048363463056023, -0.33603069013521414, 0.20072345121463256, -0.6995050955877383, -0.12895594924641277, -0.9387178025149913, 0.1656726198758456, -0.5965085130861493, 0.018632211755857338, -0.3710196138673693, -0.4214050357334924, -0.5146445506368711},
    {-0.008620129287449287, 0.35368130002844633, 0.21048010958491342, -0.2955329456387648, -0.37984162177698777, -0.9914290967744557, -0.46010008090417825, -0.8086281546890658, -0.34677664507939415, -0.4450364713142859, -0.259861608336385, -0.6675623913713918, -0.1338063527623446, 0.1232464880323205, -0.43622356805862683, -0.4687249247435534, -0.1099421634321103, 0.25654987090076997, -0.5335093991443469, -0.2645098210430147, 0.10797578468111395, -0.32802714913316694, -0.660264079655146, -0.3597047762731457, -0.43855788577006827, -0.7807455518241257, -0.7673697234110755, -0.20616579741761473, -0.24041328909949852, 0.12460595505251507, -0.7525514058461827, 0.3296233380015941, -0.36105198362771673, -0.35942782951917623, -0.7706211603129893, 0.017699427286247425, -0.9820673491062052, -0.8131984369886747, -0.7122988292326088, -0.2857227178379228, -0.4348757121219353, -0.40730430695580916, -0.4509421217216937, -0.5631631478705523, 0.26566104889321485, -0.011398818486458304, -0.5437250520459448, 0.055439790286854314, -0.016309594175760434, -0.6979391101954504, -0.21505975635954544, -0.5002864738035189, -0.5343894402822535, -0.35274171329572906, 0.21968163061642842, -0.6127253037851939, -0.38252301430240854, -0.51149676241925, -0.1387332011327687, -0.34579727965938484, -0.2566050851687324, -0.1421943661360661, -0.50963330995656, -0.45676096441933484},
    {-0.21204090018393265, 0.04077984342054978, -0.3098302794245321, -0.7515931725286935, -0.2759389493379036, -0.31684058965018513, -0.5997603111338926, -0.7997249681963623, -0.2107313562407306, -0.40640080338986617, -0.42489341653501084, -0.25739035485454387, -0.0931769747323942, -0.14666979035396618, -0.22450132103210418, -0.10279774153371112, -0.5139932244419905, -0.2546383295566741, -0.3155858218507597, -0.31908271718616504, -0.1982898291640227, -0.3701026853178864, -0.531725294565126, -0.3683534391812629, -0.21433566966067008, -0.6395371977993918, -0.4823347317690795, -0.1672814436329743, -0.5602675730783067, -0.06944736510384482, -0.5207614666277448, -0.4820830116000423, -0.316164558741686, -0.5107134434015728, -0.33433191093244824, -0.3026875789744635, -0.5305936158283574, -0.5332518821383625, -0.3642070622931928, -0.0995753319976957, -0.20067256957782187, -0.6143422104592954, -0.057063630345880086, -0.3243851040154832, 0.02639897575950873, -0.46418853220649364, -0.3777310748743686, -0.3613827706468438, -0.5020215807564737, -0.5222398776002347, -0.06306970374276752, -0.6639686955353058, -0.3454022509074342, -0.5857722275218409, -0.26454302714996347, -0.5268099813010542, -0.3342512873984987, -0.5112040383842806, -0.1579650407529163, -0.687228552008719, -0.47577734318516024, -0.4675153333997302, -0.5759598018623886, -0.5485741903384082},
    {-0.005944256064073223, 0.3224854700550991, -0.1871109578246793, -0.3991504867610519, -0.4505232494620587, -0.6252363698087652, -0.17311751188243474, -0.8428706344327934, -0.15486953001328255, -0.6334473823793173, -0.5139598322437186, -0.6465081939025917, -0.12733386633297397, 0.08087761864210129, 0.1495026814253102, -0.46600966412270606, -0.37763423057539686, 0.1774696460263379, -0.4097789308424777, -0.5313988040312808, -0.22731792599608097, -0.7069829529076863, -0.6049200055122711, -0.37790145360481037, -0.25530456149207476, -0.4541379277287423, -0.7962770148476217, -0.2950302853992999, -0.4082978881184168, -0.034782929679439245, -0.5860133311046949, -0.0291977857339641, -0.4147128107091461, -0.5120608718926948, -0.4691500406937986, -0.08304320321466901, -0.5116537759169518, -0.7274910969476209, -0.6069975096717333, -0.07327500818773494, -0.4757256641144521, -0.5026766071902061, -0.33059063320144577, -0.27970568032306137, 0.4192960625409969, 0.0007158421493370537, -0.5366894091527541, -0.07819319903721826, -0.2861203783610108, -0.7810350719212015, -0.3791204746341375, -0.5043240630438719, -0.6044678947533829, -0.5186598884344354, -0.1728239228733893, -0.4008979952567992, -0.6530666862025729, -0.3565379622560239, -0.1106485508889728, -0.2980740326802912, -0.33256452507879136, -0.2577067819589431, -0.779576046817933, -0.21955213751341407},
    {-0.019011675351888867, 0.10581666580704026, -0.12698591396530123, -0.3305878630388096, -0.42573354102436195, -0.33921858842085106, -0.6829005318911241, -0.8707800405544422, -0.4014304928844344, -0.53165015494712, -0.5065416137575628, -0.4334109099894557, -0.3394368510644786, 0.045140526565988486, -0.3468731503367709, -0.44538532340537035, 0.02713371674314517, 0.20639934943729732, -0.27796707873831233, -0.4744488154367394, -0.05410118955864419, -0.2961577439093085, -0.5671448406350977, -0.37196952966454366, -0.4741906755277576, -0.4537052838978475, -0.8432929729305472, -0.22170860366079995, -0.5543159236845828, 0.0347878026736902, -0.49533256591268326, -0.3122608184948056, -0.37064324792900627, -0.4256143917686973, -0.6648827995250481, 0.10631999629947304, -0.5895212100121333, -0.5507330253716566, -0.8647275559052146, -0.5991364595427193, -0.40366718235723287, -0.14273165538314622, -0.2663718396311004, -0.2631818323522318, 0.3240307600251465, -0.12793472057783725, -0.3881712073243174, -0.18730546822580965, -0.2967291250204466, -0.3501737258363508, -0.5918214564740232, -0.9000064746079586, -0.7637927985467959, -0.7974290802028732, 0.03416879256551361, -0.5148436839350442, -0.3983109758168044, -0.4721507649194482, -0.13445430307332537, -0.5424103025967524, -0.13122954327668468, -0.6016738227100766, -0.5932611285888989, -0.5429638404402274},
    {-0.15753577499446716, -0.06493327388351708, -0.3150752429125308, -0.4694671602305391, -0.4800495671904578, -0.8594935125707236, -0.5557506590468563, -0.6127790732180135, -0.43498354812056433, -0.6047800709582135, -0.4711196976335323, -0.33663669216331976, -0.4846511539112033, 0.1570769308380992, -0.31102215604519656, -0.3844523330109376, -0.3680982693103183, 0.30735800548313014, -0.2687088187503949, -0.4904292690081609, -0.28196783683780696, -0.6027972518959135, -0.6900124535358677, -0.13215437359592558, -0.5888810994136674, -0.5179730006284419, -0.6045263001027942, -0.5947452494789717, -0.8133062017223431, -0.19787125405386669, -0.8506890281896463, -0.2331955496740012, -0.5387610551901517, -0.23330858387500805, -0.6253333985167907, 0.027796776374844463, -0.6297264142591048, -0.6015080166921382, -0.8272642347607264, -0.5408139702668903, -0.6086271186653648, -0.270441782037806, -0.3325989603794329, -0.6588663925303724, 0.062215193577343925, -0.32549302765874377, -0.4704671101596345, -0.45669026011940045, -0.36683745282835994, -0.7046697646329431, -0.5026491168432882, -0.5879100315853011, -0.5971149114898582, -0.459780315354955, -0.022608455914117087, -0.6373192976912514, -0.35528170833942463, -0.7548293670611875, -0.13950302187229768, -0.7352719649993948, -0.24110380654922103, -0.3958631932089117, -1.0490724392562694, -0.6381603525110917},
    {-0.13581064985332503, 0.13143667167334117, -0.22851474769023228, -0.23579571711848277, -0.7618649995121677, -0.5399017675539892, -0.4987002650733543, -0.70980106508188, -0.5229959085436342, -0.7648784315326461, -0.6466195651130138, -0.6668900275233688, -0.29268479366405237, 0.16947947296629085, 0.06960162553951621, -0.3477863089518538, -0.4457896654433578, -0.059907387242902684, -0.7465111303213989, -0.5028164801219543, -0.10603725456775477, -0.4917905981875416, -0.6581000261491955, -0.4203328705632072, -0.50208726788741, -0.6404556528331069, -0.6885667289263465, -0.30169044333373385, -0.8647799180039899, -0.1485581267222523, -0.47373769020876993, -0.2960294026896033, -0.4929670994752488, -0.27123116202796976, -0.7309437445541607, 0.014693354807484314, -0.48362101851594747, -0.5934053149992248, -0.7327674500555258, -0.6608651965794923, -0.31865814977277956, -0.497060449747549, -0.2939777732831466, -0.35226873961677746, 0.355764598730304, -0.06694185803884997, -0.3857336202530769, -0.470720918250162, -0.2942330690509589, -0.7395135658524866, -0.5483362767846449, -0.3021647111213283, -0.5251316105337805, -0.40740764241742383, -0.07673094375171104, -0.6645111914057918, -0.4459863867681827, -0.9645092585455112, -0.4834709610113579, -0.5367774707302164, -0.41268704052465066, -0.36830937505390954, -0.6095870703225644, -0.5659006297933605},
    {0.060241284007324994, -0.15053282190771505, -0.2150509978359565, -0.5009056216923259, -0.6453387702046116, -0.5299047388409661, -0.3022892694382473, -0.7077127138862628, -0.4002911090453795, -0.6556738325528747, -0.4379535601897125, -0.255574110309587, -0.3914656111503449, 0.24334503222935278, -0.2268878433893858, -0.2577982311986805, -0.4334825017523101, -0.10924442443645471, -0.5425000201875805, -0.5283081650621, -0.3650708423756724, -0.5169673139430742, -0.5339201177911095, -0.18530758070005748, -0.5075595435516695, -0.5164442035072758, -0.5401132487513058, -0.21037202320615306, -0.2751592453188499, -0.15588275213692956, -0.7652132730547568, -0.09664540873809886, -0.4804518390452311, -0.48458987916402346, -0.6497076802288141, -0.17988228889641464, -0.4759384071009638, -0.6328158667374266, -0.353234705538799, -0.16384664751925593, -0.6517961048471407, -0.27858387479716096, -0.07142270787081997, -0.08582249081257122, -0.15632151610164174, -0.07793554129193034, -0.49141505709894634, -0.2336891605110549, -0.32230551800574697, -0.41808007370837097, -0.09730346296546652, -0.38488478102667906, -0.709893967162164, -0.4026666295702529, -0.12935571874091067, -0.4990803397216807, -0.23717934608320784, -0.615162205760739, -0.24576065850599965, -0.6847903071408672, -0.6076038104927932, -0.40691328225000845, -0.8934626798783708, -0.5114986310363621},
    {0.10558383766206061, 0.1703450254484168, -0.07202383384166436, -0.38443736357085945, -0.34292811155878394, -0.3079562905364147, -0.09102599199975869, -0.5077293517103912, -0.1981917128002459, -0.5239515043663497, -0.1658048916464207, -0.22483910541028962, -0.2694183764728164, 0.3392810632221321, -0.35772338214634847, -0.19996781905858124, -0.3028733517171801, 0.04567997775134521, -0.18376077117161269, -0.43878884724629497, -0.10926581833865433, -0.31993780028123947, -0.2984756126622063, -0.21889347534578593, -0.16394252858580854, -0.3380257417964761, -0.6477814845874296, -0.17851538961530447, -0.33597267487263527, -0.03955186654729878, -0.3827339625041943, -0.04769777066104201, -0.6895170343570448, -0.31994742396002357, -0.5554660072954575, 0.1618323425281993, -0.3481254163882413, -0.47466058850631304, -0.42012256229322853, -0.2566914139847943, -0.41531539733771167, -0.28996627924039936, 0.10412445773052448, -0.5156743284875116, -0.17890641883425232, -0.4142455702757187, -0.28746199996148086, -0.21673135030678342, -0.46030193363386995, -0.24208386148571723, 0.10108995948275185, -0.5925692418236742, -0.3957340851585384, -0.5792705051919562, -0.460150156979005, -0.20682040314674174, -0.17790314129026896, -0.4684701675405501, -0.15888455910632387, -0.6052563118385061, -0.40273639504942177, -0.00796729653746159, -0.5627957014780554, -0.34830975324028307},
    {0.43076896995140657, -0.10626173857045838, -0.24737717243961518, -0.20322785040989244, -0.3002235564253613, -0.7887298360378042, -0.022813324099416207, -0.5130791892574826, -0.14598887745003633, -0.693710707694787, -0.10695041953663642, -0.04990726477475702, -0.4752216802770325, -0.04284274288748853, -0.1878080531698392, -0.25520502066087886, -0.12619312979952527, 0.2807758016369708, -0.17542420823848143, -0.4838988322688046, 0.22367656540017003, -0.022395148900610305, -0.5095150717417116, -0.2689558735158631, 0.0705888826338391, -0.4585595829747001, -0.5025938236979911, -0.02586725209954474, -0.31167920306374747, 0.2587707575338467, -0.6710108791951093, 0.12737536247779813, -0.27846979518135095, -0.007986110156860179, -0.6701681942183085, -0.051955092462566785, -0.14988906728662577, -0.5776505525097246, 0.024719767031246186, -0.08267712963941971, -0.4782316005539712, -0.07765547869629157, -0.2844661485639493, -0.143450367392633, 0.19851867746987226, 0.133558426176913, -0.3058208092563875, 0.02172810167240368, -0.09601419379889597, -0.5388935942962474, -0.21970596373008947, -0.2152291640201172, -0.2924160716837875, -0.41960102989122877, -0.14595943287513524, -0.42341640424957444, -0.10499951092453366, -0.027430837735338602, -0.005581587272488385, -0.6286222580927391, -0.06716246907246468, -0.0989592907259398, -0.4488538122960778, -0.5159699943640861},
    {0.09146136574747675, -0.38421246447898266, -0.23207506337951497, -0.5543267679308872, -0.19970922046095765, -0.3981359727238, -0.36173987330042434, -0.5244076530103328, -0.25387989415695644, -0.7228616341690374, -0.3301588064630643, -0.3808476720987081, -0.24680831882380166, 0.18707446916412343, -0.47706920395058355, -0.5737586102343437, -0.2570428106129542, 0.23579705575991403, -0.6500113728750543, -0.4263881094512256, -0.4720167299201449, -0.37059143884478785, -0.6743234316506859, -0.0882527803114101, -0.677858631632249, -0.6182160915624766, -0.5603262519188636, -0.5134228445220125, -0.34629087710572193, -0.20768649018666754, -0.8821915720491684, -0.2602939345882725, -0.6118540537283567, -0.4518733211057243, -0.5416393867502988, -0.025024799841065856, -0.5025140088713967, -0.6313205413750608, -0.38082927743726497, -0.05787131641340308, -0.4902304743008942, -0.11930522831858471, -0.1451784766324927, -0.3364062700846534, 0.34916998531156285, -0.3736811975177215, -0.4463790607385018, -0.4414085986809191, -0.5994656649747206, -0.6717844578619068, -0.14658716038939587, -0.363791655777354, -0.2773624631605129, -0.5994686585362422, -0.2039121735853321, -0.48894537319540415, -0.5981903637122243, -0.24451018574128058, -0.2572028761313096, -0.8693502273108494, -0.4478748822404623, -0.33997208080172975, -0.8567429005659281, -0.6560057516816612},
    {-0.05924497415969123, -0.14844113778990162, -0.44785726752067095, -0.748164976936249, -0.6981138845299991, -0.5223381606850827, -0.6486356338483323, -0.5072298737902483, -0.3616959050259391, -0.8841629162849416, -0.3620016845026849, -0.4631156095871174, -0.5549617071482009, 0.24544865998130458, -0.745070857316412, -0.4171405164747788, -0.5985842178531685, -0.12256037736572231, -0.382200170244278, -0.39158800851337905, -0.5025692478195359, -0.4828016220353253, -0.5424602062820356, -0.17650775413265465, -0.39929108118747236, -0.7931993682785431, -0.5133020798517727, -0.4758111346347387, -0.5064254346023328, -0.41533424159524845, -0.7382582273108803, -0.039818590515693274, -0.43927131132347647, -0.3861806340494016, -0.7090063660214503, -0.19971570009831477, -0.766871933157099, -0.8105657871605874, -0.6140585195041675, -0.12323563359265591, -0.6446834232834577, -0.45723192029688337, -0.40178940703382193, -0.3424949452792427, 0.2416042798995345, -0.20563844226656866, -0.6796381586947803, -0.35013569028505037, -0.5870888769345944, -0.6600100331787346, -0.11256957579353111, -0.8561079571853326, -0.5607003020660671, -0.8482846837986625, -0.12518009386321635, -0.508265388073155, -0.5101097325122994, -0.6222941260234083, -0.4666909321434516, -0.6148542267812502, -0.42564601171666605, -0.5217581430798685, -0.4482357808586205, -0.8043914610849369},
    {0.1762238851015342, 0.20593120324108372, -0.007620541478024226, -0.6250343317295376, -0.3567633387461944, -0.8730332989304589, -0.2714641066073687, -0.6530410235153493, -0.014208396740310478, -0.787960448557092, -0.6526582997013036, -0.6868345939573346, -0.28970999780211837, 0.28684230890526224, -0.2452093944723249, -0.4528529885569666, -0.21963274997266422, -0.08192344541260849, -0.28059483501414856, -0.7013756102731186, -0.11751821037345941, 0.026000415591538296, -0.8134462056778339, -0.30771880389033174, -0.3098318811176428, -0.2559973690780516, -0.4396836598175304, -0.15314041629140634, -0.7308147044947692, 0.020894382180595944, -0.6370966111528824, 0.2599890474480637, -0.3817598192823899, -0.1207960885592871, -0.7528236187570994, 0.36956852319512323, -0.46872980452851426, -0.6339631806767707, -0.5839491771328422, -0.11313673869487074, -0.5655351995830007, -0.4333766677175285, -0.3311786893147094, -0.5573364385723701, 0.5155939936341798, -0.13825856657972918, -0.6363177246855285, 0.23908957075494658, -0.22576294227483368, -0.8510487807619653, -0.37382883723114196, -0.47345530764280347, -0.5941425686702182, -0.6230477630743517, 0.205515954430881, -0.4970415605123695, -0.35510626671329015, -0.8039146358837903, -0.11669556856219208, -0.6865669301198344, -0.2870379451871015, -0.15801146424399415, -0.711562910736036, -0.6389630415503282},
    {0.0005585939284907733, 0.4104794808684674, -0.025564266606367004, -0.2189730192943539, -0.3382589463080976, -0.5692661425837957, -0.16550915062114724, -0.6012125904907702, -0.054719003550535265, -0.5005987301545701, -0.3916920582469505, -0.42212347096601943, -0.5643678320500539, 0.2772173650510185, -0.10829090287360883, -0.4529513903631894, 0.15737236885680522, 0.4040158484730361, -0.4295384082606766, -0.5730834262095295, 0.19474130881386137, -0.19105670451284873, -0.4544856556967778, -0.22696070471083, -0.08127267425711296, -0.4822820993623926, -0.5203005414081353, -0.057499736963945704, -0.40296459349370284, -0.1003934997324235, -0.8682539878625785, 0.07519451120445542, -0.5406310468150125, -0.11132437363679394, -0.43308022360325316, 0.5564106820961736, -0.6035334595320542, -0.17248684073479853, -0.45551040011348115, -0.28361520732132384, -0.4608310316022075, -0.5654121535153729, -0.36502123343197335, -0.5253914113962667, 0.35502275674157613, 0.44744622935499256, -0.5412649420873296, 0.16997554318693894, -0.22329762650448462, -0.5443551050565982, -0.3701695175912913, -0.47002401714347153, -0.4338308530051993, -0.5388336163451104, 0.047441437115354375, -0.7143061168992041, -0.20378766395614412, -0.41078391372916684, -0.14224708514060994, -0.5919947942777236, 0.25603955124847766, -0.2522026410409182, -0.6598528413230755, -0.7553110976862268},
    {0.0017992775260935565, 0.739347194101614, -0.2203652709594025, -0.44627251193238804, -0.1885760228179502, -0.8064856326099601, -0.13058059311808237, -0.3794305215025305, -0.37854362316315215, -0.6431033619521204, -0.41538700908074183, -0.18926741598664376, -0.4407447109499973, 0.15032254325829753, -0.26284517398268864, -0.546088746688713, -0.3512406950783759, 0.4737733483955426, -0.47004211719012434, -0.5376249790062676, 0.16152434646180422, -0.4038223290045947, -0.5573723253348668, -0.2578821913165533, -0.18216524482602797, -0.39911459813326755, -0.5060775676688833, -0.2686725793065994, -0.3217494336872051, -0.014354352423259852, -0.8067643645642895, 0.08341844065450879, -0.31068781855306304, -0.12876714943791817, -0.6657251652524676, 0.22459435728018973, -0.4563550177884818, -0.30615267990642686, -0.09612994328698907, -0.13449187951012628, -0.27777600394596613, -0.28432263919849055, -0.3479406821865319, -0.4015874043907439, 0.1791033564152337, 0.006756487334325272, -0.2073637132653323, -0.21162133617997816, -0.5878900421333725, -0.41637187350189325, -0.2336645377233692, -0.5292991625684199, -0.2517545210431796, -0.7874801467574605, 0.02837723330528402, -0.8055689729567783, -0.1277448739226708, -0.3755801949552666, -0.25741049461786, -0.538574843287557, -0.3472795866011869, -0.46845355370469843, -0.5826541550044158, -0.6565582407758496},
    {-0.06929075038649203, 0.23867092427267986, -0.565408784551044, -0.43676965767101017, -0.4438692197864502, -0.6934446992493374, -0.31569618799991706, -0.6610635463722992, -0.41075208071208646, -0.4052408501450821, -0.4874672462227366, -0.5964366110732812, -0.294079136989156, 0.15470086346698977, -0.501860037679219, -0.5042244571969879, -0.4792516300262747, 0.020684090087701563, -0.14288017409987117, -0.5619716586139483, -0.32870424204007376, -0.5602607840711131, -0.7107213699254714, -0.26600458468840843, -0.26409032466727844, -0.8516689424018631, -0.7719319342756823, -0.2758099588272816, -0.5101187314642754, -0.21549231920092743, -0.5853859328513566, 0.12574396110508557, -0.6887908605448959, -0.16119381828413418, -0.7580315139503796, -0.09756760394981047, -0.4781304376485651, -0.6355247279542242, -0.7651236123353164, -0.2692195155221175, -0.6009157683459434, 0.0584306407132382, -0.3177573926877331, -0.5197972078997777, -0.1036717772525514, -0.038611923111206675, -0.5093695824313611, -0.5901608961302786, -0.8033625542717133, -0.5132894030629974, -0.36574937351183956, -0.5137930590393607, -0.4301145869931587, -0.7223131748197781, -0.11820062476338061, -0.6933305662420054, -0.2105679870547514, -0.25292279595004097, -0.42898760835057986, -0.36546904303687444, -0.45421046892980976, -0.32187910396942776, -0.6214717064158338, -0.9409971330196517},
    {0.0489988416775225, 0.03135426750362306, -0.353419611912322, -0.775213807019177, -0.5060206798474524, -0.8512045169218709, -0.28633221164083655, -0.6271545037608172, -0.25150735676378305, -0.5713530131275458, -0.516003380467676, -0.6439321837489608, -0.5039017631125036, 0.03082560703715727, -0.33596662454170634, -0.43553035838081394, -0.4581977706716476, -0.13833742033720572, -0.6300045773147063, -0.6087295407372761, -0.08266826259391429, -0.3429224136198753, -0.7702831651364975, -0.086153203578179, -0.4398428653656647, -0.5328281730760894, -0.711373473012274, -0.45742609980254983, -0.6193481896062887, -0.3731548065381622, -0.7540238728633986, -0.19499333454287712, -0.525427926233235, -0.3987228772413717, -0.7194929936858959, -0.15199990680504363, -0.3310191728435519, -0.8346231676285804, -0.598939191184254, -0.3760200119719876, -0.5871390141238505, -0.5989525765010306, -0.599092114589017, -0.49791486456943757, -0.013929989994797082, -0.3434655446933417, -0.46832871365750034, -0.47400840273273576, -0.5376682377600188, -0.8839347238111159, -0.05545206195537856, -0.595622934775112, -0.49969621077565685, -0.468537967559048, 0.002899421376699105, -0.7172654253470305, -0.6248879990389409, -0.5635928015437192, -0.24963523086585462, -0.6236043693879616, -0.3558093258517488, -0.5730011503418342, -0.8608611116519537, -0.7870749594213687},
    {0.08226053952774945, -0.1396103127111483, -0.3171762075300376, -0.5254248979101822, -0.3474459927172334, -0.4678992996940002, -0.24868318865935066, -0.4822206266706006, -0.7635191957959968, -0.6645438768233701, -0.37794213094437723, -0.529941617801915, -0.46793671668174225, 0.12991297596847493, -0.40561104504972756, -0.3673865637194105, -0.7712945017247836, -0.03323882122032102, -0.10978256435416728, -0.7070082602467205, -0.2444208994001132, -0.7223977013586497, -0.6797675386337633, -0.22307019929630317, -0.5944237180292112, -0.7680368951901664, -0.5715848577932083, -0.541090736682379, -0.6345254781704215, 0.01900457820492251, -0.8706843244109839, -0.13245106934801681, -0.41648770591085144, -0.25508356053489284, -0.55298555914364, 0.030425569311883775, -0.2790906727269285, -0.5080893726221394, -0.747909500767968, 0.01592357272801983, -0.4691438799770788, -0.3040539559554715, -0.36645971419038975, -0.21412820141837602, -0.024651167389748027, -0.30855234420591277, -0.683308635030929, -0.40970528169148934, -0.8696222537609499, -0.3475149811700696, -0.06897517597077052, -0.5990329688682434, -0.3581599218941369, -0.8272621973811349, -0.522820736380629, -0.8665093037594578, -0.24668988477135, -0.4887303198403549, -0.5242071100562674, -0.6408100681660728, -0.44805421989297367, -0.5004916301724458, -0.7027562421397152, -0.8544368504417746},
    {-0.11882289273572726, 0.29336675506397103, -0.46280502910317456, -0.24305104787645593, -0.4676913447390172, -0.5221956699889446, -0.23524139282314532, -0.6535896533995639, -0.48957766958380655, -0.5518106557863558, -0.6336999780317218, -0.6446323884179199, -0.5651772410120975, 0.2716841240829027, -0.0477857803810133, -0.6619969437451618, -0.5238419010437301, 0.0817031758346209, -0.39728244416687086, -0.8679062145234164, -0.04520609989010032, -0.2700835566670101, -0.6400413531274955, -0.06198636521068993, -0.48548263945376136, -1.0317417899962604, -0.8200372922144097, -0.32356375062439907, -0.5574042925030009, -0.03332301561037883, -0.7087860244527354, -0.16621078575293566, -0.40970269761517214, -0.1895490933698337, -0.5439596951400825, 0.08256304772093115, -0.2675560313407482, -0.37280159777510574, -0.6372046850166804, -0.040270311210074974, -0.45829185328547706, -0.17188322771198078, -0.3002231212303476, -0.5385247326240534, 0.22927904569454413, 0.11736396042314108, -0.6561857467131857, -0.29852805056156323, -0.6199534396460606, -0.5758558845171856, -0.06321940927045525, -0.7866410965645675, -0.4725618659077414, -0.5981421696441789, -0.19155812712167872, -0.7643976605933934, -0.4407271870339522, -0.2958998615610782, -0.4918753322196568, -0.5339465687997947, -0.4481268944146036, -0.6067393502323906, -0.6664807304240739, -0.7453909390129131},
    {-0.13818485524451699, -0.027351241510332993, -0.34646463077599393, -0.7887659105596645, -0.41576331764915475, -0.5855649127439849, -0.2436173844600192, -0.5644876616671233, -0.4095247220290863, -0.6475635320990254, -0.3476082069330889, -0.25656806000396887, -0.49401263151005864, 0.24725304934754877, -0.4456667358260263, -0.6536284039453812, -0.4345887522865467, -0.10297622345412799, -0.5046785655838972, -0.5763265739358643, -0.21378529489332346, -0.5978684613357976, -0.8900914962374263, -0.24833858016285143, -0.26791617962407294, -0.549835305530046, -0.7116735122891834, -0.40753739686370977, -0.47288874662958685, -0.09659178543975523, -0.7485934417832139, 0.010444409158527231, -0.6364779926906453, -0.09912878221018977, -0.6055075680808069, 0.0476148644540681, -0.40456467402489565, -0.5000316303574962, -0.821692425670338, -0.21337805347447603, -0.7532037361667318, -0.0011181662745743815, -0.22534267346504905, -0.46873190196495146, -0.20245692075142502, 0.18073523620468213, -0.47841788452674716, -0.43495483023140386, -0.3567807526543946, -0.5987571688295347, -0.12741978637856277, -0.39930818103792687, -0.4645514881445067, -0.5773093154154846, -0.030166224314146433, -0.5968023866208106, -0.321107600169498, -0.4402309180128577, -0.2811157355137995, -0.5099818708259388, -0.3585212604047472, -0.602116011576994, -0.6637509012881119, -0.7581391547421399},
    {-0.10105711497046244, 0.15573264481000376, -0.4768183203738933, -0.6079718200486889, -0.5028501696912822, -0.6770195407673159, -0.34703007431989413, -0.6191495147953545, -0.7630975744525169, -0.842678609777706, -0.2383989722581849, -0.49015302725107945, -0.1878335218232839, 0.33470817980342343, -0.23294187216042178, -0.5534533901112744, -0.70928666705354, -0.15325513541209893, -0.5921800323352762, -0.4397396477172439, -0.13729363808843636, -0.24241414615112986, -0.5316046236157815, 0.0736192953843705, -0.3489922858316738, -0.8306108355389525, -0.6762511434180825, -0.17539848530771235, -0.5870020769024765, -0.20146858765585837, -0.6932698540443943, -0.12171470767137833, -0.3639671966054186, -0.6792896545663214, -0.8446567217261726, -0.07783962008164018, -0.5335999040695197, -0.15275434302258406, -0.45279907318252405, -0.21427236294661686, -0.8437286241366889, -0.25523088055839716, -0.2253273986566148, -0.5139528402168334, -0.1635449226298063, 0.08424671025068374, -0.36599636467412366, -0.4193886324789911, -0.7639279360595927, -0.43824863018815285, -0.0933094437113301, -0.7117470743746884, -0.25500948894846753, -0.6893187661414316, -0.2800965042663918, -0.819969297330777, -0.348852722227083, -0.3107128907344191, -0.4510832133422536, -0.6678088620622475, -0.22066065580781305, -0.6146610312285705, -0.7569185817227609, -0.7832127376159052},
    {-0.11218466380662467, 0.22293052255205736, -0.5556812719917825, -0.4102871917338224, -0.2535003145786295, -0.40856365216280127, -0.16948743636882482, -0.6771519271650426, -0.5306605825619245, -0.6149423950867354, -0.5229511706394276, -0.4376916444613912, -0.585257665657855, 0.31811090108640067, -0.06442049357556517, -0.5375428184648443, -0.46588661160307515, 0.40533063576910494, -0.36358501044868513, -0.4046706943811809, -0.008043586641689632, -0.48291172960214884, -0.5993866415221135, 0.14517340098680268, -0.059004321389081446, -0.7103277058778293, -0.6620116726834717, -0.453422300553729, -0.4288606563591488, -0.16424045777590018, -0.6430278803893599, 0.16035036540960787, -0.24006341213744967, -0.5241856202288693, -0.5059910282835427, 0.12401194455404779, -0.24161556086831004, -0.19575255546989503, -0.31185339243046356, -0.131688161470128, -0.42692754107413355, 0.03736387551431622, -0.28739925313778414, -0.3404475628920985, 0.12706244487693072, 0.1387739949331101, -0.538155467776699, -0.4968391586051547, -0.5552771892864665, -0.521231848655493, -0.018042747630721702, -0.6692129389036098, -0.614098105666452, -0.7556914552787719, -0.011930452233703733, -0.6957267702065711, -0.24211666226197007, 0.017650659651623452, -0.48785009487025804, -0.8348101479283129, -0.11210268137423617, -0.48341903181266427, -0.6559208159964844, -1.0269517753058761},
    {-0.6106582170256755, -0.4639955632493276, 0.045580808206301754, -0.5811557020340757, -0.22991122625647695, -0.10041305590678043, 0.40758045499529605, 0.11737504828572676, -0.06648856987832838, 0.004094706043288054, 0.12044046768031187, -0.6720691223659043, 0.12286122614468022, 0.23408870995022013, 0.580857068659884, -0.2116800953843472, -0.5561724672502275, 0.5314702171748863, -0.3884518953914822, 0.32819895973145374, -0.3065459127667628, -0.00863853398951713, 0.5677613094028398, 0.08858559162338456, -0.2496897937415417, -0.5259125496383303, 0.26885923138650886, -0.4915353677985044, -0.2554225763267053, -0.2017025344084445, 0.20379422745304096, 0.1402331610058706, 0.42749871873611867, -0.32922045929578975, -0.5156412790178161, -0.478216681214729, 0.2092411748468968, 0.5202450305469336, 0.4923582085978797, -0.06469406922584822, -0.3654353202413377, 0.32941466444969525, 0.27822687038837796, -0.3220579345282887, 0.3446677555606559, 0.5624156485397283, 0.20867632426949714, -0.10951627086750867, -0.13021319451554703, -0.3884495791095134, -0.027010115949478632, 0.224913968506774, 0.40665530306620595, -0.15539384184756608, -0.43536931179786925, -0.050403426305680024, -0.5075033429808706, 0.03324706418837341, -0.18872448445735387, -0.24623252137673, -0.3947024175422799, -0.025074947329898144, 0.09533631132227685, 0.0855922624986834},
    {-0.23628449394896192, -0.053821033624255395, -0.23515464046998347, -0.6109089755765154, 0.30576399361769013, 0.2659509938672347, 0.2086397674972387, 0.36613419930096824, 0.2642648636694826, 0.0451446379283842, -0.17335300404014298, -0.34444919163640575, 0.49402169082287195, 0.1061355226211543, 0.46450179368813527, -0.6652255080748688, -0.007391796063656561, 0.2451085612988817, -0.6747559693207631, 0.47988641127825765, -0.09738796724658756, 0.049663776490069846, 0.5383544811971192, 0.41282847726907806, -0.8535397311523054, -0.051146077194592444, 0.23709559094652907, -0.07278679199449611, -0.2930924258277092, -0.21959255962226354, 0.14353189349279163, 0.26801291937435134, 0.4879777544092598, -0.21687165836235098, -0.37455859457934926, -0.1507425950809613, -0.2426608895938799, 0.30905206354309045, 0.4601497287601465, -0.046792776408824205, -0.28704511769007357, 0.5211059157676184, 0.26079277958750346, -0.20505294115450287, 0.40369741339094883, 0.6154275842870689, 0.2968932122995636, 0.34204341000689104, 0.11775152674149893, -0.4033680898492088, -0.02592861131359537, 0.21451213870255345, 0.01903338486119966, 0.1120154680776277, -0.19510074836085717, -0.1357512626564052, -0.3020035713163048, 0.214918317013965, 0.20079142182505083, -0.2951406840656245, 0.18782266902372638, 0.10136695693329607, -0.04059338088488581, 0.3139564690665349},
    {-0.6320511495293532, -0.2977473581503979, -0.22397109900127096, -0.27679032711577223, 0.6052755291844044, 0.6681619871910074, 0.09476787827946946, 0.8307146800461502, 0.44620305311183317, 0.030456696964043375, -0.403120012845213, -0.8631379978340227, 0.5093322231595961, 0.025658577028846403, 0.5131099305312966, -0.6284342242418763, -0.15405861309990945, 0.7522266120896971, -0.525969374771525, 0.4655392303971408, -0.03759922722014008, -0.06673155433606522, 0.5342771866850411, 0.2780855753434647, -0.6394960003113539, -0.2844410367645274, 0.344618489859509, -0.3870151753740796, -0.4308013212262247, -0.5298152058321394, 0.3866233570009919, 0.5244917969518287, 0.5859962878344928, -0.2355583941016217, -0.5892045910324594, -0.5685442201181563, 0.17483733137618215, 0.5493093812960587, 0.6362173767026756, 0.20997040047469306, -0.6343009517707605, 0.4705362657318496, 0.6639816278256806, -0.3263542043552018, 0.4918940617710175, 0.3317107925224725, 0.66601023437158, 0.09515383898488426, 0.2878546364146904, -0.4270761923307233, 0.1800960683356619, 0.7012890194034886, 0.3494102944536016, 0.19473655229325149, -0.2259536379043656, -0.08680389885783514, -0.6390489706687476, 0.2795314944717311, -0.08435172190235918, -0.5676145535857159, 0.19232081285288466, 0.12375749287178889, -0.20523268646933945, 0.18952462749997045},
    {-0.48179996314780427, -0.07465953128829231, 0.15406495941370704, -0.5921951874937186, 0.5922393639980191, 0.5302218367595282, 0.3908640105448902, 0.6071614531796058, 0.1668263929463381, -0.29595834237346197, 0.06462769991510434, -0.2929306927707706, 0.4430975643918837, 0.47857952681180665, 0.5245445481608032, -0.32167918487808744, 0.29949299978947713, 0.6118920359824983, -0.8005136421999952, 0.3960338872323161, 0.010274168530318815, -0.061725727020561574, 0.6521121945280114, 0.602321020974052, -0.6860684571917156, -0.052048529024742066, 0.33827411272910096, -0.12314612127067831, -0.03207077842863477, 0.012114367306260835, 0.3302366943836443, 0.6849156731709484, 0.8039825335963295, -0.4285914119489763, -0.33185712414255764, -0.07863899075578969, -0.01033481486653792, 0.6446038217455689, 0.45605345390502344, 0.4954885789332919, -0.459362932289637, 0.5829878001602592, 0.642693916315854, -0.04848045526164375, 0.4929722918137916, 0.4201746066694724, 0.33285917438418855, 0.15117554818617618, 0.3520658346448942, -0.049564733380046994, 0.04540941668775234, 0.3810503970975407, 0.4504670975198457, 0.40344055622689956, -0.1483390814214127, -0.07443919185226264, -0.268331957111223, 0.5052886148008618, 0.07760206130931195, -0.32834488947085777, 0.07938859167746887, 0.38751498224436387, 0.23504377280083147, 0.04603033191375353},
    {-0.5976215579508443, -0.2930991507774843, -0.006748942478387125, -0.322356358845573, 0.6503297907451695, 0.6557504479513039, 0.23759596516675988, 0.37547854278926607, 0.4039886002280368, -0.2589639657879995, 0.336024078860107, -0.5293057626937292, 0.5174002127408123, -0.05275661273742094, 0.42389766332242723, -0.27192873873825063, 0.14284032766293328, 0.3112524884735715, -0.697068459757041, 0.5199247772032831, -0.05839656998322677, -0.09908184633947774, 0.3493175710960451, 0.6173943312237156, -0.6959069001788977, -0.001940384466556659, 0.6092557380057031, -0.12263500999420264, -0.15537702745526968, -0.16853639040928478, 0.6919198723483279, 0.7063592790130623, 0.47715647850386084, -0.2524908194346505, 0.14760965676539975, -0.2066176667056001, -0.07592662667203069, 0.206820527387792, 0.6021334835845933, 0.3589729149500631, -0.270391585774543, 0.4423352003752308, 0.5022582917498811, -0.10959746736240748, 0.3024849552251992, 0.11391079417163616, 0.542865908622881, -0.10880389711257878, 0.21340844777288465, -0.02945562423168984, -0.12414079644714744, 0.1475348105213977, 0.33352139100485106, 0.20574479351709188, -0.11195767956422022, 0.04884993924622923, -0.35297156824215864, 0.5640217952737949, -0.12374980846504323, -0.41290770532076604, 0.5030881782308299, 0.24556635548732486, -0.12571393133473613, 0.23268679601325012},
    {-0.5899665183881008, -0.5063747875688527, 0.19063598654581257, -0.411650935428266, 0.6114890754179237, 0.7369435506495915, 0.5091711021606046, 0.3259874533446328, 0.2935436598085758, 0.09528311704531613, 0.08535418218768004, -0.651434069008778, 0.31789006768070543, -0.3179426247026215, 0.35577240271540156, -0.5458166460280535, 0.061480904087082566, 0.17731536827045785, -0.45026481149657194, 0.3300414410865045, 0.014297748298540412, 0.20373816088766533, 0.35991953468624577, 0.4398128214739283, -0.3918897729730718, -0.007828235850418131, 0.6390383510580456, -0.13644622062157047, -0.32198001477537536, -0.0857571253459178, 0.12248072601402776, 0.6827431154924046, 0.43096008518878814, -0.3518202801468818, -0.33878256552446645, -0.3404182205483559, 0.033265182257361775, 0.18087772134948307, 0.6916466282392958, 0.13483284633101958, -0.22196722312951278, 0.4375144703127235, 0.38502830655535925, 0.38457001612373193, 0.33185219620948514, 0.21252197109010146, 0.6281812628136128, 0.20965304365578644, 0.16002967434657012, -0.33157041172768853, -0.35087405765373136, 0.35118016251169487, 0.3726378263791606, 0.008964959372901782, -0.44104996230759164, -0.11094069074008643, -0.5678969787665851, 0.24372058909934832, 0.15393485279575808, -0.48680375821755656, 0.42452113248758006, 0.22669573453579303, -0.010128373437727586, 0.18689374919060853},
    {-0.73852837598038, -0.580043349527259, -0.3519287884344559, -0.5602240292399858, 0.42991363227839935, 0.41518466717536273, 0.3526364856173599, 0.3810894989017602, 0.1959776901219276, 0.1006017319799199, -0.2650469328472473, -0.6928938569217865, 0.45430858024676385, 0.10101748749955891, 0.6121744844739804, -0.530439268051653, -0.37291047240740505, 0.2870394687913278, -0.564909986980403, 0.24181908939149685, -0.07373788925339711, -0.19115916761779916, 0.3662303977477459, 0.21154807559549102, -0.5806047382451145, -0.40136794676214765, 0.4912017800661898, -0.30189510615880777, -0.5340974465114361, -0.20045905632825647, 0.3472827563712635, 0.39247355503016534, 0.5295197298376427, -0.7902174535645821, -0.7188690398070066, -0.17655741170130335, 0.12529336008689448, 0.19445967739980213, 0.8233764244064574, 0.1308761703099576, -0.6043846176097829, 0.11211139520328198, 0.66103988551422, -0.11800701962300034, 0.5330324890285616, 0.07991087160122941, 0.671808117226834, -0.13845969108179934, -0.014697060472328884, -0.30132035728120465, -0.29120629000128645, 0.6264804719191529, 0.1887830562422968, -0.0576800900162761, -0.5236331452482818, -0.24640089712472976, -0.4165993007885101, 0.46583247335481287, -0.2350574174300533, -0.7218123302020112, -0.018527365616950696, -0.12591548691418175, -0.0153074132846348, 0.043810771634303164},
    {-0.6864879924146926, -0.529766978570192, -0.11201006310653319, -0.6729638286918701, 0.5714973406667707, 0.48456048339547236, 0.2099424167607251, 0.645773099625404, 0.09600154830391384, -0.15520816633701934, 0.012841659980450278, -0.6144156118952657, 0.5103634865224919, -0.0651817929301215, 0.5112504666425904, -0.4652951785315912, 0.10550325305925985, 0.44769711543202045, -0.5359966144778224, 0.09823918042379857, -0.14587534083288964, -0.28700186648324416, 0.49962359515632226, 0.3745007718940153, -0.5981681179888764, -0.34563030677172196, 0.5358494479044235, -0.5721428572463472, -0.5198641260610123, -0.29494311757667085, 0.5226821722492531, 0.48275442975340743, 0.4700216099319987, -0.5757850049356826, -0.7060438466870869, -0.17210935176341083, 0.0761441584502686, 0.43017314499964804, 0.49127139304953377, 0.26706948975504224, -0.6291011312171505, 0.09802896911604253, 0.3813744314533998, -0.25251921636511276, 0.4596343374773479, 0.27208073566133306, 0.4982866205005352, 0.2095698225244184, -0.29002425146525496, -0.49048435715234057, 0.1624270812818263, 0.5128038696775458, -0.1184746359084028, 0.2603258176838012, -0.07814917031043252, -0.022481492141536556, -0.48776488401163237, 0.12124784524103863, 0.0235353480246917, -0.28788825533523693, 0.3654291763779973, 0.4186049655012389, 0.04588468142401126, 0.13649388310997063},
    {-1.238958555738384, -0.15420090243978943, -0.22997213865750923, -0.2515257058723676, 0.31594948071290296, 0.6092653340011748, 0.521684535214177, 0.5692138976530188, 0.23674378142204336, 0.008452156601226802, 0.22860572867955245, -0.6437866672053066, 0.4263393309491666, -0.022031350459717977, 0.6046900797534775, -0.594153011078066, 0.046694789428062246, 0.4440429831601549, -0.6683673681456539, 0.4941716302924291, 0.14799334810846135, -0.0352534339954418, 0.5794384965878397, 0.42253883172090945, -0.434611048261662, -0.1486325582908613, 0.572578709297459, -0.15675433435150138, -0.41585095535485067, 0.046232476099591524, -0.04044397359268852, 0.816818587108276, 0.6130691548919759, -0.40765771458827194, -0.9273986874906369, -0.43669696279930464, 0.1080878351233205, 0.4814595189472832, 0.4769680197825543, -0.07842646938720238, -0.8425877344347968, 0.47611508630068655, 0.6514686481774206, -0.15809246909943805, 0.18729011846210003, 0.33703039178688, 0.30637073815699817, 0.31293301382809713, 0.1380767198849529, -0.35015220785350964, 0.2178836047898729, 0.524608933240587, 0.45423844561343957, 0.22140979998969448, -0.021373786782483986, 0.23720024835033823, -0.7492289916772706, 0.25266506564019, 0.06545394415550361, -0.4835302167890403, 0.2600721925607141, 0.35864111231827067, 0.040593971719744625, 0.27592323332940843},
    {-0.7476898365681971, -0.4159355784483853, -0.26837055641638, -0.46171173627646844, 0.6310189660359914, 0.3685815355310908, 0.47403579615525065, 0.6760731770624123, 0.42664532729553045, -0.22177439199606883, -0.07620164305182156, -0.5355671972402636, 0.4789970720606603, 0.18820265959792845, 0.6877399299592293, -0.8369417490721058, 0.01549588285675829, 0.3128377841225059, -0.8995652091283849, 0.27365033721692467, 0.14933264809051308, 0.16980361112745063, 0.3570215865916624, 0.6636578460926497, -0.6476616656652936, -0.6155865489842204, 0.308232625512968, -0.596734474793847, -0.27648594988152403, -0.3082355666506671, 0.2521536714833153, 0.620669134954515, 0.6076776829069717, -0.4134405604061238, -0.7246914228723043, -0.47795629231482556, 0.39912830375219766, 0.36699896609001414, 0.487999169478899, 0.11390919482180896, -1.0224701840073032, 0.470801097562442, 0.7971987959150749, -0.4063367939902976, 0.30789527974386494, 0.21277617837066182, 0.5935105370337208, 0.05764560169480241, -0.0006663033956343766, -0.1955147956313942, 0.045306552469344764, 0.30091157104079175, 0.40635755612784563, 0.34488955838330976, -0.3504247706909794, -0.12480976441281662, -0.6584019595682765, 0.11545218074736048, 0.07359229881690979, -0.5701167069023068, 0.19999057960505026, 0.08949627496808393, 0.27397653982545206, -0.2782005088881671},
    {-0.750432133185486, -0.37056219459296497, -0.29910886874011344, -0.4653878210862706, 0.33385631625468826, 0.5942405420962518, 0.45098253264258803, 0.8295799264744548, 0.4999554025131918, 0.06725144371305018, 0.38643928630501684, -0.6221554402651, 0.4801217768501335, -0.08615743782395334, 0.5708481537593283, -0.26584936400075154, -0.240663107767851, -0.03193674449687596, -0.5955726506404808, 0.5608852447387126, -0.12276129558279414, -0.2844040825576573, 0.4035639281696387, 0.562786219385887, -0.6767886610151427, -0.37158137629824717, 0.40386559601651, -0.48891089195627785, -0.013990949933790974, -0.5754120538044095, 0.047064322646952, 0.7865411749239826, 0.6930838068591357, -0.6201182490120816, -0.2344784307982104, -0.30090517228459485, -0.0017462423207097338, 0.44547352792367395, 0.35240376547139807, 0.14298501248027298, -0.6438871870633759, 0.30532607853360394, 0.4691933213132284, -0.2072983957329398, 0.3830118552701425, 0.2720653098596771, 0.64209623408945, 0.4901255061526867, 0.029525065771874085, 0.2121043494338059, 0.13356879191273519, 0.26864282163726627, 0.04905086525647822, 0.11599024866160695, -0.3119827991927573, 0.14851195599231143, -0.4665445831104085, -0.1633283170623431, -0.2092949019766605, -0.2708527832366007, 0.1737421076390881, 0.17345201019651446, 0.10699032027675372, 0.02175817896242403},
    {-0.6707892115609058, -0.43139793455684916, -0.18607507632216677, -0.4878002806227354, 0.6173539281907316, 0.4242508166022167, 0.33733675541685415, 0.4929175185854392, 0.32866756568173544, -0.19555734859803922, 0.10671666996477698, -0.6554290639953706, 0.6355024361948283, 0.1268270798172163, 0.36734691861646696, -0.4191006935820482, 0.009673371950488297, 0.10323558939733782, -0.6642086389951386, 0.5079442544407978, -0.37974831166794504, -0.06104523374922677, 0.4017294945948817, 0.33786489776897005, -0.8046579010090023, -0.4964777941793834, 0.648802575603179, -0.5440550397197499, -0.20363781106277523, -0.4779660844532357, 0.08133451490759344, 0.29735806534128445, 0.39322688159460994, -0.7076102242020292, -0.40655983697066994, -0.3771542457600644, 0.15002157531943572, 0.37313717578167493, 0.28527824275020425, 0.13974681576840242, -0.5861225668887755, 0.6164260226890216, 0.5335645875027787, 0.11284246834527079, 0.3389662221284271, 0.1803896387412199, 0.36719817262278187, 0.0058688070410782694, 0.10435412941626997, 0.044638216794217735, 0.19192831536793165, 0.7261862061197006, 0.28529468403778663, 0.2080745139410884, -0.24096379618765498, -0.2713405327286903, -0.8943596093564555, 0.014397078740389015, -0.1649810824810571, -0.7299938398692009, 0.03827607377811327, 0.09947500531073186, 0.10413392329026801, 0.28580681169478883},
    {-0.603183662544712, -0.6691948579705309, -0.2137817320305554, -0.2765367544068372, 0.5630778786711607, 0.5663325649993232, 0.6357790619840527, 0.48375923880228716, 0.3835863816236944, 0.16421450551835903, -0.018283311417624824, -0.5913406424438533, 0.5849250066895707, 0.224977092481708, 0.5526837868167985, -0.5271836030834562, -0.0847138071521956, 0.4136466797565266, -0.6735044390069669, 0.17391257735045731, -0.2599926885221431, -0.021669226513983203, 0.3887632977758639, 0.4794732974287649, -0.7068154341414145, -0.10615698598322987, 0.19624434943966979, -0.3502347589076995, -0.34412210925120645, -0.4100635139555208, 0.27024280573943715, 0.7975658583102728, 0.6523979959820607, -0.7985530075829087, -0.3922228495058702, -0.44335307231788074, 0.19976158155637527, 0.37641598326486786, 0.45259763188475155, 0.16615470805803295, -0.7879416927816014, 0.4239169523597897, 0.531829879615802, -0.2641567083264745, 0.681242017053283, 0.31012027072942366, 0.6122579102280644, -0.08997144586304195, -0.08711890053553954, -0.5164274705359525, -0.1972842792226633, 0.4685906795382801, 0.4105396153181011, 0.5493672578929675, -0.09825422741220169, -0.3724058621018244, -0.5379398186148815, 0.1596921632095824, -0.1321626676031421, -0.8530805486850835, 0.14692151737741171, 0.1491484374606262, 0.2631448330986672, 0.38211413728484345},
    {-0.6733029344191089, -0.33345060327968695, -0.30476807163456066, -0.14484088079287447, 0.583168617630751, 0.7234749104015272, 0.7571851430631446, 0.45251868562493025, 0.1539382097967266, 0.48942077676295065, 0.09297628964539449, -0.6582045868872932, 0.2702873663086376, 0.1855499089162778, 0.6132716270580774, -0.3568971091577165, -0.4044609284214619, 0.18993253300351107, -0.777480767284983, 0.510516038353341, -0.3821336108932, -0.3058510759376967, 0.5802803494041066, 0.641155450208288, -0.6724316730150998, -0.19610731338319257, 0.15026850683202617, -0.5835191468554243, -0.014073076842408237, -0.5984476084436147, 0.3034280411777857, 0.4341404521345156, 0.673191608932486, -0.7586645226210796, -0.20305821069062632, -0.31524219074533544, 0.11444592642399434, 0.46965881957084166, 0.5308685754620243, 0.5402021644559029, -0.5047756112127341, 0.26082946097650184, 0.847096406805892, -0.19218550272937185, 0.7057479472628899, 0.1704603950143856, 0.6706626337612122, 0.1723717134422407, -0.06181007893300331, -0.25892484340693034, -0.2194581752613602, 0.5055127948778398, 0.5872980100969413, 0.12812946196751912, -0.21027533849496693, -0.1669257470763192, -0.3409741249176023, -0.1899267564821696, -0.41648333094074463, -0.6184279128204666, -0.026730992070443087, 0.045400819448336134, 0.545393028083566, 0.245080315527643},
    {-0.5606784017821578, -0.2716357066638913, -0.2660780959618073, -0.1619773618579225, 0.1523624847224745, 0.4856241466319763, 0.2724573906036139, 0.8006124719804735, 0.04612979008245789, 0.27488083914309797, -0.38765672837668136, -0.5426956718185824, 0.7070189231201347, 0.09533557345024418, 0.6164833097924705, -0.2849359852595742, -0.4403775951685883, 0.34751052478972394, -0.9906329664806528, 0.5490869225493894, -0.32805662376513073, -0.21787761541738712, 0.6259745788749995, 0.5640350907002785, -0.4666387047695376, -0.21157621953198824, 0.1111729272659983, -0.2850075618713718, 0.06654773640454552, -0.13007389212049672, -0.04011082625485989, 0.3356044559060369, 0.3738227776190267, -0.4915032856098275, -0.3835449854570996, -0.6325621892591077, 0.32067176023605404, 0.5198770528745177, 0.437677697272327, 0.6155677660046193, -0.378561667330182, 0.29702705351089753, 0.738210291531135, -0.19769410120308956, 0.47592713820531385, 0.21702923569063298, 0.5143944264781091, -0.21268267421292505, -0.039144396532698245, -0.08490977485416808, 0.23732057015618102, 0.7224439948383433, 0.33669594194271113, -0.16972178445783284, -0.4909308240603953, -0.4075072511333624, -0.5459950140598535, 0.14519306520837588, -0.09540528057075069, -0.5599276234894239, -0.12853801916066251, 0.08000190585852292, 0.11101544376421864, 0.1708509872226472},
    {-0.7744835678441175, -0.5756537781418237, -0.14204671976289127, -0.4179818857852208, 0.23293583109472601, 0.470381311280378, 0.8952741228976202, 0.6318896564720913, -0.18764769001495046, -0.3446969156001058, -0.25538181442791025, -0.43690989558489696, 0.2685080358144395, 0.21259507644918393, 0.6809793223571011, -0.6003255730185122, -0.37823359478106494, 0.5311606898764182, -0.6626073723159073, 0.4787607885177307, -0.25507832980914064, 0.11525965851795238, 0.610534200441699, 0.6220413311698625, -0.329474355759497, -0.5560925835937818, 0.42880157799596863, -0.2516290227570077, 0.017693878391803114, -0.46909368126656786, -0.23540597843963812, 0.7101244063923943, 0.672320014407821, -0.10762371925818233, -0.1458868058076838, -0.35924025770623086, 0.04507262051217178, 0.2371002235366309, 0.5430562921301411, 0.14241132014144972, -0.7263816243011338, 0.08469997252436942, 0.6046518561797903, -0.44037274583811076, 0.7165954398072948, 0.29035423314397024, 0.7594419658433175, -0.3432665004923821, -0.05942470857915047, -0.4149927146266097, -0.0557381178206964, 0.6734474731141019, 0.5338877104962354, -0.0028586875766492587, -0.4966626101902322, 0.021676539983270262, -0.4288376518087324, 0.07118651207669911, -0.3406422877760294, -0.46392970489458873, 0.16500739912695064, 0.14381567803940948, -0.15678957984420255, 0.02981055369050177},
    {-0.7784751367242669, -0.26995116181543516, 0.21312103438170038, -0.39196467112846795, 0.4552654286813227, 0.515996511809409, 0.4989779679013059, 0.622272020881517, 0.31931457183486367, 0.23534904944933854, -0.25965050329019806, -0.7718605241987538, 0.391020052894333, 0.31258246746493307, 0.5671732802825857, -0.44877205542741194, -0.1243587310798725, 0.9485299809500349, -0.6684231932816097, 0.3285648404404465, 0.07151418166771636, 0.358548571087941, 0.714406380439427, 0.12820813181096818, -0.7341217390606803, -0.33968566587726307, 0.16556412627201553, -0.2843273321536257, -0.2999290091437848, 0.040798931744819106, -0.15175810893948952, 0.8568182005240869, 0.5427570136223151, -0.4706325463967803, -0.3180177744061281, 0.023506079730821302, -0.08685726610811939, -0.08424349877733925, 0.3260926579783199, 0.14232032752222237, -0.6238735197462133, 0.2793348922106303, 0.38745415337137684, -0.2446353536075527, 0.6954796768274315, 0.7953584793293575, 0.8295238851891872, 0.20113601626228694, 0.2846626500685986, -0.46880172355626815, -0.17483248920081013, 0.658421850442279, 0.4243783526526356, 0.08569574980073442, -0.12533882262933815, 0.2843001720397197, -0.6048166236177006, -0.09311262972514643, 0.22134714635204256, -0.0897896456924485, 0.10696498628202965, 0.4241439923554995, 0.26820066111423724, 0.169229036702185},
    {-0.5922907235036146, -0.4875661645446691, -0.1217428503554662, -0.6642715583709098, 0.6015809116411384, 0.4188330377298433, 0.5321410291126416, 0.6888501060281869, 0.31236312067199995, 0.28043326954290476, -0.27064470010817215, -0.8637968211009476, 0.18386751879090688, 0.4300746467659, 0.5454500804633585, -0.5663956941253794, -0.32502922959740793, 0.3733664709680473, -0.7847452200222473, 0.3934168572539998, 0.10070412961358137, 0.03026749697252013, 0.44762250480611365, 0.20104818062419025, -0.6051969377431224, -0.33242748268200006, 0.16789371740248926, -0.24007280403478323, -0.30554838589106065, -0.24443445875274053, 0.14543541899257517, 0.48861876398935167, 0.4446436642485563, -0.6863144697092958, -0.2927818828429714, -0.4539385915603625, 0.11936636916257282, 0.21115656888374415, 0.6311971656588372, 0.07899922749465306, -0.8670739126099827, 0.14789602793954817, 0.5055655150465963, -0.16937343648193948, 0.7740008059198182, 0.5435731696406532, 0.9154324682901981, -0.10673494172587734, 0.16903712423302286, -0.5349392041949974, 0.10224881908395574, 0.48728569510031494, 0.20117430660703942, 0.33236070236141513, 0.032681931107596075, -0.27284999045615943, -0.5813073948685702, 0.3867981729124183, 0.05675668545184698, -0.2554852734711417, 0.3147742536565793, 0.07928768174114605, 0.07517892523513561, -0.13980064752659682},
    {-0.681748800923451, -0.4117617868101758, -0.1125171092451971, -0.7216454169091038, 0.7708737451191938, 0.4863632172501162, 0.7270496243856923, 0.6845660179793506, 0.2624906955555314, 0.08696784733689605, -0.022894276691369692, -0.8950667307116748, 0.5770193496277213, 0.5482774511761382, 0.7192821670924098, -0.6038030155085647, -0.19797954685928976, 0.2827171809204496, -0.810959490318688, 0.2863943984578173, -0.12715514571669412, 0.16866882725300364, 0.7286768555467714, 0.15127787924420427, -0.6880170827331087, -0.18144262071781636, 0.2537711628379662, -0.09034827063713267, -0.5887836749065015, -0.23990038263623806, 0.18136223080739855, 0.8030739712235824, 0.803095017302554, -0.48299310606401136, -0.4285961995901939, -0.4299989838377347, 0.15240026590712047, 0.4751974623639313, 0.5917098570923106, 0.05937322436469078, -0.7328884556745757, 0.34958368702820447, 0.5060623598670956, -0.2730164284242638, 0.5734516213297894, 0.3177388939703424, 0.8425866183801706, 0.25594008601200524, 0.22562059159826195, -0.1666457673651586, 0.006318436501107154, 0.6551184624962874, 0.5196835972025381, 0.21648786384301497, -0.29440225450474095, 0.18484020235719278, -0.6553601885775615, 0.5031668199793594, -0.2370849654151986, -0.09869267335529651, 0.049646813485908645, -0.025428039683986266, 0.19110720510845036, 0.2947405660129674},
    {-0.6299802098059026, -0.6040457648375915, 0.15014171570023663, -0.4523395109694189, 0.3862761321936174, 0.9664729243732388, 0.7302418528376399, 0.5907362933669112, 0.30889636631299855, 0.24242304318323665, -0.11054214890201108, -0.6276891612238538, 0.4931624264027695, 0.37843159308638263, 0.4516509252847384, -0.7226039369620605, -0.15834136701292, 0.7813711473452619, -0.8050654757853066, 0.4086467042010541, -0.16589841566433383, 0.12915068153480985, 0.6965928932533102, 0.4403738994952034, -0.6871293514966856, -0.47619072932167006, 0.5316837078365706, -0.7059125535358477, -0.19780589643784913, -0.19668702602453828, 0.32017965958519023, 0.42262846990832686, 0.7967098796895418, -0.46250135916317514, -0.37355618243994027, -0.49285814599632266, 0.03867804796882688, 0.5580282218746877, 0.5845003152901502, 0.3581961596181965, -0.5825045045182176, 0.5546004256715823, 0.8001560709969269, 0.2754903682487491, 0.4588874173170217, 0.5436035868403606, 0.5956812126163865, 0.2861239069270631, 0.009361892557718469, -0.21788531176383422, 0.35401503774084275, 0.42472991336851046, 0.3177871048922789, 0.15820663011807137, -0.6378392477627366, 0.38934820994563574, -0.5807632942149775, 0.0822071276670015, -0.018469346963501207, -0.33802493287206953, 0.2963366499504758, 0.069031389612274, 0.47247042505605136, 0.15574120041296013},
    {-0.7084661150431377, -0.5092647238464609, 0.2138159965503111, -0.40514956546107156, 0.585462080124185, 0.6465129772044721, 0.7012460987421711, 0.44118662492765026, 0.3401631403763452, -0.20876828913407974, 0.12986319499188306, -0.7530700777156666, 0.20608525833232208, 0.17182981113681337, 0.5701285535387608, -0.48083375072308143, -0.2524109100826063, 0.7330871285880177, -0.868340376583324, 0.33537873362444304, -0.05199743486712655, 0.06911169158824099, 0.7330382063646647, 0.11879019593691136, -0.7904504006719101, -0.3288115949087814, 0.38450670673389187, -0.5610627562165741, -0.2710803660319186, -0.28301888033657124, 0.26454728861185006, 0.697042272856565, 0.5451697544077841, -0.2606212698017648, -0.7763866147194168, -0.8394291473859155, 0.07920759312040242, 0.41222874012749666, 0.47539857676131947, 0.32782637227698824, -0.6478614944097906, 0.222243953209451, 0.7090810394032453, 0.057649725432855625, 0.35370547424193066, 0.5541211951432712, 0.63280850785063, 0.24470926184349545, -0.06859491360785441, -0.40563094710129416, -0.006430775615422097, 0.5354739961945396, 0.5340800897274292, 0.24023891730971986, -0.5515032681661983, 0.015527500967436991, -0.4631948664789978, 0.09658916973185384, 0.28742337862100853, -0.3120581381993292, 0.13128469360249045, -0.021160696878393212, 0.19082127781556044, -0.0900644758521413},
    {-0.7512588696335801, -0.47014721918246466, -0.003227073913997171, -0.6706836588885204, 0.47824953307943274, 0.543137999879097, 0.5751654496130559, 0.7084151045943329, 0.11231542704309662, 0.2098593935900535, -0.09903836562844955, -0.4971297441997523, 0.27944252701051375, -0.06037883882487945, 0.7148734798328995, -0.6226659332442148, -0.562456175837671, 0.5778864229421126, -0.784107045843921, 0.5094459658918018, -0.03997007258521051, 0.12989983665695995, 0.4620880153069741, 0.3242353628297061, -0.5675959864358023, -0.08825789294445445, 0.04753692434662952, -0.5287660252388316, -0.17943433987306232, -0.44138241905489844, 0.36588513268746015, 0.5085834062866651, 0.6974367778710967, -0.5604445171778677, -0.794208815339436, -0.4798925552370894, -0.2646547365628769, 0.291560585278555, 0.5995520320695614, 0.37299621407044664, -0.7342828942030154, 0.1390951294099363, 0.7072792994029781, -0.13232180709757202, 0.24155887173910012, 0.5166718751686536, 0.7282726966437383, -0.10548123488592107, 0.10022696994079376, -0.5664994461683351, 0.4655080512316263, 0.8459616247483591, 0.08157829371455051, 0.12518446194657168, -0.4416086483573907, -0.28018083202309396, -0.6385654369829601, 0.23476901533419153, 0.15626740137639686, -0.17869239899661685, 0.25819161146039016, 0.19454807278169425, 0.07677258873502821, -0.04532317563214873},
    {-0.6190755896634522, -0.665909180976686, -0.07908771925537908, -0.780999525726672, 0.4743215889809546, 0.7793664386784346, 0.3769956425798625, 0.4609371697841927, -0.20443781546413078, 0.13333509158223777, -0.06393377499817662, -0.8452046666630469, 0.2612842108439416, 0.3298760019972327, 0.7784439858996592, -0.6452564841171957, -0.3114518179854522, 0.6529493204142758, -1.114307342580728, 0.5832362367046549, -0.384200183714584, 0.07570390057091668, 0.8212467563878163, 0.3864558294707117, -0.5291504831912139, -0.40847879345948757, 0.24386667868230216, -0.5717045783772584, -0.0177070915402872, -0.5447809966551671, 0.3269494703703112, 0.41034250137351835, 0.403675746976922, -0.7658136562935278, -0.7057866619873101, -0.572691372557012, 0.08722102737083853, 0.3606128324566573, 0.4451482390494453, 0.5936546567634301, -0.5208240206017369, 0.4276096388315177, 0.6056322973841862, -0.13333817059535158, 0.4874928913573382, 0.5108570700013552, 0.592933873951121, 0.1496380267602908, -0.2576425313049827, -0.635262788445901, 0.4131096259148165, 0.46422969097392935, 0.4726886917784248, 0.3828409943125869, -0.49859124901873775, -0.5716445085548041, -0.8658397477572808, -0.034238702468049116, -0.055932935658316904, -0.27312890320527283, 0.11135461189797033, -0.04086092134453537, 0.14012045850604168, 0.0448991553594297},
    {-0.9565370945538304, -0.5757058675609403, 0.26194121675731313, -0.6768646226453092, 0.5290118478466033, 0.5316206699408409, 0.574869832405986, 0.43215199419628364, 0.008869187297250206, 0.28989232057927755, -0.16753464403581245, -0.49345101930303026, 0.2776920047877615, 0.4201021183775396, 0.6050713235525218, -0.47533997161220093, -0.41584489362064714, 0.5429185482839086, -0.8958626078743624, 0.5634577636606074, -0.4096790081308899, 0.40917158330827325, 0.7068679521070228, 0.3374016810844435, -0.4721366033923452, -0.3981570454239474, 0.011675903052044138, -0.5395992565844443, -0.20773453408373158, -0.313626198669729, 0.18728601269229295, 0.6343775941572364, 0.406834088510886, -0.5405086704081264, -0.819809481147116, -0.417492683398439, 0.057826250849095755, 0.4244507169966649, 0.5943899434950173, -0.09425691491276597, -0.5231381900710871, 0.17472424104768852, 0.5801623609054336, -0.4631429071247084, 0.7429343696468078, 0.29991241033011007, 0.8719599740577323, 0.08363183827339021, -0.0955815033501719, -0.5664868370904038, -0.12194638177737924, 0.4601670065179099, 0.3843530561882444, 0.18963920911904933, -0.3531305615229477, -0.051233170392549855, -0.5254737664031999, -0.14676281112272066, 0.17909222882471995, -0.6961601639033365, 0.12515058944958726, 0.025017312753406396, -0.09644969360867679, -0.20464302094588785},
    {-0.56536669698946, -0.3724821414361217, -0.06798890442750634, -0.743611574448924, 0.5679956478097216, 0.6553364445883701, 0.32939134873149856, 0.6701120161064337, 0.293628070940725, 0.027465568927394015, -0.00768552971461528, -0.6380415183352429, 0.15114233241345829, 0.22944629000315728, 0.5895491952177209, -0.6937344391134254, -0.34092901725122066, 0.8424496744798862, -1.0566218040056679, 0.38232701042173145, 0.20228230295583868, 0.26020534415679114, 0.7162398645598972, 0.5635244692726843, -0.43456784706398194, -0.5470880673720242, 0.11619995108029205, -0.4088357512046422, -0.6259493832451309, -0.08290293277138214, 0.21014487033774226, 0.6529428217670616, 0.33010398076132774, -0.5754824073278236, -0.6788453358899164, -0.3846406208217888, -0.006091518011094766, 0.5779458424327576, 0.545594612554191, 0.3080337780690727, -0.33929659974597737, 0.1032076498066982, 0.5087662727612241, -0.21977449337184005, 0.7200002298000281, 0.32168622704645233, 0.5367652655989459, 0.031827191624230804, 0.059971341808287, -0.3654068491697112, 0.2522899270209268, 0.3308779815921693, 0.32725341045455686, 0.41140565627704256, -0.139693354960673, -0.07134708979834654, -0.754277404544306, 0.04323533354604789, 0.12063483222669316, -0.440298364898239, -0.03487970107764405, 0.21146757650569525, 0.2703109048032241, -0.011687544895690242},
    {-0.6761855027142989, -0.6206914161150817, -0.08739158453655636, -0.4698055055775432, 0.48498598666336823, 0.7568268399060321, 0.5471879193703958, 0.774908410089714, 0.30552597312851, 0.07998419955363716, -0.125793724207582, -0.7159688643957828, 0.359279373760578, 0.19246300224623403, 0.9703983624396951, -0.20391862464642996, -0.4990974443616795, 0.470181564442376, -0.8256833434382863, 0.5270259694994412, 0.02693725649034583, 0.010290110233447832, 0.4362272455653204, 0.3460125590903466, -0.5813899088726466, -0.5673046809681821, 0.5056712489545974, -0.6723738786685881, -0.3926733136789148, -0.41322949273310805, 0.10427022440266906, 0.8141231096500889, 0.6666257229980405, -0.7285696080718411, -0.6194515264090009, -0.5411225917089931, 0.2767758010243838, 0.6075530076629077, 0.8818786698616075, 0.18351772243867204, -0.6442154449465308, 0.6233233188220431, 0.696244855962207, -0.20146092631627394, 0.5245929587433511, 0.4139571685102007, 0.7667510122173231, -0.12254501890040756, 0.12203906211600579, -0.3612407686856046, 0.10964996446579332, 0.43227490862680334, 0.5478774520024838, 0.20665078787344984, -0.29195225810996583, -0.5223881302365194, -0.6580905247161799, 0.16881580589649287, 0.06222917978933597, -0.5100893306485179, 0.38165495978108904, -0.009160234909917334, 0.1621123740514749, 0.07391793246336185},
    {-0.758460775693663, -0.4024722465999981, 0.1872200640426404, -0.7084840562944213, 0.2592841016335737, 0.5729854096826892, 0.8097584284328229, 0.5036455259253388, 0.18230250450610225, 0.3176985010475893, -0.29969081741057596, -0.8384300234198466, 0.32645805345689216, 0.25673571909973175, 0.8485754898272857, -0.817462703731148, -0.26339345893043814, 0.6665828171112033, -0.684404897973976, 0.43597614951404906, -0.3584934409196859, 0.10715047047929446, 0.9238226959279913, 0.46573819585361564, -0.7559430540796305, -0.2773752087060642, 0.6225497696395927, -0.5436702853321712, -0.38538081805260005, -0.39721216201687276, -0.04372352837781052, 0.8539872917573899, 0.615295123598161, -0.6053263739757562, -0.634507906965126, -0.5112362937750466, 0.18137781661595756, 0.668244568070028, 0.7044585078170253, 0.29943090233482184, -0.585614499252092, 0.2212998706956577, 0.7667947389083236, -0.17163138419913612, 0.4927598548639435, 0.33332468909782886, 0.3970137336283414, 0.0319854987792874, 9.551218992245285e-05, -0.5264371995531617, -0.010156856958754703, 0.7531664215985938, 0.5218118489875916, -0.24152099528860546, -0.38688441908998067, -0.3565497283807414, -0.7928907419304665, 0.23268459701311459, -0.008852256707912908, -0.8135279327790264, 0.1837778662689328, -0.1090057711170799, 0.2865720154936829, 0.00014547778354972673},
    {-0.7129314473230809, -0.48812046663373665, 0.133354346960951, -0.7254708544302663, 0.5687517288459774, 0.38056545542329095, 0.4815056411228207, 0.5319984948912635, -0.038239739082605174, -0.07422642340081034, -0.27903555876964775, -0.6258858985841785, 0.3241914728097752, 0.49513491819157207, 0.6017218069991785, -0.5973972652875752, -0.5116455519084535, 0.4394748708162619, -0.6525593012062185, 0.5438477561103844, -0.22128294333510992, 0.12034624035927491, 0.7126819067946512, 0.4437859294245641, -0.6182637593924818, -0.7031402607563652, 0.23874853572737617, -0.29371345824826245, -0.3891108683514941, -0.6656591602059199, 0.031827986575023094, 0.7925342546161668, 0.8806271050078166, -0.4318842183820436, -0.5392028044701114, -0.6943287793958847, 0.020842250554356304, 0.3841981659067333, 0.5956459496091885, 0.33953904141146135, -0.7829425239633621, 0.16641510300513634, 0.660318137737692, -0.49197344214513433, 0.6965618203355121, 0.2908323335281875, 0.5943078818969012, -0.07479612401568034, 0.04671109717440386, -0.6047736299576164, 0.4736175091873308, 0.7217183197551925, 0.5022546156114919, 0.1001577411632919, -0.6723216845484962, -0.48629609205086066, -0.7615499665030159, 0.24417232503418437, -0.2115852392401014, -0.6888438638689858, 0.18194011687889325, -0.040543876123248876, 0.0008665920538005675, -0.12455059624867297},
    {-0.7959579426337681, -0.5378899488033364, -0.027082633984623735, -0.4102204281038893, 0.7528387676406548, 0.6208348885715288, 0.35760105246287577, 0.7597897761571651, -0.006381994793120184, 0.43025984893234825, -0.14880765384855513, -0.7051597548371875, 0.03234887496692523, 0.5491518207256679, 0.6222220332476397, -0.45781386708168775, -0.26199180542416195, 0.5520123162590419, -0.7146960568193379, 0.47074440982291527, -0.27393225335096205, -0.18805742136968837, 0.8807009513055508, 0.514084901595208, -0.5763791870285329, -0.7211963610515227, 0.16379520046275736, -0.26878929773824256, -0.44995296446516875, -0.17977643697545065, -0.032608686001525986, 0.5809505856968994, 0.4529849605474481, -0.6924468575651047, -0.6232610279241797, -0.4353797678938208, 0.06566312097120941, 0.695995400732486, 0.38527344945940917, 0.11711582964875003, -0.34001263730624776, 0.30048499768820097, 0.5532071242397416, -0.49080824097613135, 0.5627818861376563, 0.12827118233801157, 0.6650867859173923, 0.058693087339741885, 0.21985150874399043, -0.5255218045202027, 0.19774384765168262, 0.606212213035117, 0.4128362899574806, 0.3189271611661405, -0.6668175252429036, -0.5149920526102549, -0.65707444017547, 0.05705665610323465, -0.022525679770238675, -0.35776985176223514, 0.23976732990264113, 0.26343438686377496, -0.010677298354220445, -0.2299839593744297},
    {-0.9298061521176288, -0.3736927149239841, 0.28559879831800516, -0.5293012598419432, 0.4475650257182983, 0.5086863732091413, 0.784104772906668, 0.654840380632709, 0.24048834486253934, 0.20301344517747538, -0.2433813284749633, -0.8856041658696927, 0.1474559400982626, 0.5146806422145309, 0.7973790392256171, -0.5914629305830958, -0.4624401170974879, 0.5089877768911727, -0.46645446320689105, 0.5576043751826899, -0.3024208197095768, -0.027649256485190777, 0.9762979086579032, 0.37101249101962624, -0.5775054463374136, -0.6797035394497828, 0.36577458884395575, -0.32931195570720007, -0.42415316144224763, -0.15782874211068998, 0.22543896465998534, 0.7290992304404177, 0.4679142442142361, -0.7731183474693533, -0.44689752271200306, -0.4356668417392881, 0.22932701215087808, 0.5108809698854403, 0.7202274273536535, 0.20125614790486918, -0.7406657628438938, 0.5052156826169165, 0.5499991215502587, -0.254634248411534, 0.7343116649267307, 0.5147343892982496, 0.6956569543394518, 0.09262556753724638, -0.05102915620018221, -1.0090817687685423, 0.2915814020174618, 0.9712875827942802, 0.14671892571854692, 0.18337290712333038, -0.6076252696520161, -0.49391774506383185, -0.7643089792036154, 0.0851263604393465, 0.2144974448154101, -0.5690298940463193, 0.08238789994213111, 0.26260375536142383, 0.22327673220457234, 0.13172055936677485},
    {-0.5516429605653667, -0.275581998945562, -0.8058491024041798, -0.48865563832507725, -0.22640364819199177, -0.10995942873008051, -0.3659244410984716, -0.09699803078959952, -0.5921003771413889, 0.179173252634842, -0.5523421214154954, -0.09153978907049268, -0.03623433541789759, -0.6342120050872667, 0.12998093257426396, 0.07622247616181746, -0.49413940633425485, -0.5168081462590867, 0.14827359619679653, -0.04978463420533797, -0.5471987507474323, -0.5294863216464519, -0.5108696795715509, 0.5395456912617526, -0.35462764229933247, -0.2825561437552105, 0.006002416761674967, 0.024713401524293577, 0.18579249521956728, -0.2692762696222972, -0.34786450499163557, -0.04481277384193192, 0.3772309973403924, -0.4508922886215577, -0.07950644188221828, 0.27949430884915716, 0.12952310804683745, -0.3616355220026338, -0.3627497347690286, 0.21163438397916326, -0.25281813933269903, 0.36382498894706516, -0.12528357472579094, -0.08424047249835484, -0.48159120818353557, -0.41651941450447116, 0.020229869991237177, -0.5037384836755295, -0.5791136523481589, -0.21852755332861368, 0.11631671694787592, -0.16253599633192453, -0.32774305392424036, -0.6207698586017697, -0.3633037358572269, -0.3494036833907517, 0.24819797603153707, 0.12633784342531995, -0.681880753978229, -0.7114850135574238, -0.7829423186343686, -0.6869669728448724, -0.6833616290516624, -0.5633576023246906},
    {0.07183625121322117, -0.2910218093436972, 0.07558561398161336, -0.45887642083730423, -0.03592658335196382, -0.3487485406856481, -0.46778660955175355, -0.2179553629413374, -0.011449921359106698, -0.12590174043992425, -0.5157434042649863, -0.2541059054888879, -0.6412666844902536, -0.05160369055195636, -0.22717920146471923, -0.4412494505195959, 0.1684195607235796, -0.3671507921509452, -0.17397072974526934, 0.23472149689755475, 0.13189217842819115, -0.19205385524910273, -0.5624005601755423, -0.5048822690385697, -0.08489341676233325, -0.4631736931030206, -0.3516911008229767, -0.37972271953988607, -0.2857753555565027, -0.006623600574420855, -0.24252722739585186, -0.09065788391141198, -0.12829557106932424, -0.22599804868538012, -0.15425371345072766, -0.06510058139556185, -0.1454117626382778, 0.07869898359850953, -0.3151278700634946, 0.06006531942642176, -0.29074586367245114, -0.23303773755290524, -0.09916561248049424, -0.08097204048471154, -0.13565481881188948, 0.005230978118918448, -0.2012518388939921, -0.1968911857885585, 0.28503216086163435, -0.34339992218017595, 0.06286390506596636, -0.2317263605021408, 0.038956903798074254, -0.10141502777261124, 0.4345786820438037, -0.20461746315690793, 0.3201491189579582, -0.30526395083014646, -0.0036744396677545494, 0.02036377287063481, 0.21781304633061588, -0.06182263346870114, -0.01567442004743339, -0.04196430934090892},
    {-0.13140583373981374, 0.015472010451975418, -0.6741741684375705, -0.5690229172688418, -0.724124839117854, -0.1315252054072348, -0.16551017443737104, -0.5228297071036315, -0.8251167238497032, -0.5892058765838569, -0.48225233508391707, -0.17335587196698957, -0.24354171328837665, -0.6138309170551308, -0.10687409426869379, -0.3986338562223625, -0.48057509739383336, -0.09181781149319065, -0.19214968827708026, -0.41987163252563614, -0.3670835114737898, -0.7171828803408795, -0.5651473650429095, -0.1152408638160196, -0.3127938511411452, -0.691999646677142, -0.5572961585936916, -0.43672964389448954, -0.42211095677276567, 0.02716439601273394, -0.5473629115475236, -0.20271762739030963, -0.19275271096353222, -0.04608745040327224, -0.4757340447443301, -0.45985671271754297, -0.49965081902381936, -0.5642726516239148, -0.3570393535221545, 0.2805456722192448, -0.7060802615205233, -0.12480915336163424, -0.6035924287429378, -0.45301005579105236, -0.08914741401476442, -0.20216198915155784, -0.6065545632997327, -0.36814359300962707, -0.4084390425709479, -0.3484045736670559, 0.26577411276566276, -0.10904626796959954, -0.49716146911043757, -0.5045388312717577, -0.010119677276783243, -0.3613350406103424, -0.23400189440427874, -0.5997453861324346, -0.30743367614684325, -0.7131128802959031, -0.3588628041111803, -0.4280460913122022, -0.6830214646733089, -0.3604448835684205},
    {-0.19423079078460104, -0.14398874914549661, -0.5065276287602961, -0.9584753590796984, -0.3617868119445598, -0.2581488521315769, -0.41257274398990784, -0.2990731676746735, -0.22894562618254788, -0.27273776366326846, -0.30692330171061216, 0.03979187662512504, 0.013999373815141134, -0.3229977920749272, -0.46978403024291293, 0.14131564375949127, -0.4669787101048012, 0.19761636673499955, -0.19196340309899482, -0.4176343971474289, -0.15219727322338858, -0.2669849824862218, -0.2638296634219959, 0.08917406649941463, -0.03959166042649273, -0.21206249805152455, -0.1657926356694426, -0.2742298353865716, -0.488975309377761, 0.06800416099094832, -0.3600660431414337, 0.037038038975351545, -0.1675557678765929, -0.20905277114353915, -0.6204957388685722, 0.022291149753264114, -0.02146004163062683, -0.224106652852187, -0.21175230913878143, 0.4127330480261551, -0.4799500092554923, -0.01586892145851797, -0.0693778026618846, -0.027513585478462263, 0.04129608474377477, -0.2516299178731977, -0.6603441917970719, -0.4340896174191695, -0.5066988322191901, -0.21163542089534199, 0.37688576428191195, -0.34838482664314857, 0.05453341111528217, -0.21331863323658956, -0.4913689281030573, -0.04764830928172323, 0.06886906139455778, -0.1711586643610617, -0.4721726803211554, -0.5364077444238612, -0.3935007697726988, -0.44493760824908496, -0.6086227163770422, -0.6559410170719906},
    {0.3242754534092552, 0.1925357825112264, 0.14983044023436368, -0.3853309897905167, -0.39355973814894174, -0.39853576658550227, 0.04454442440614367, -0.1613905513426596, -0.0037377537018987747, -0.6580200353864637, -0.525916315430505, -0.3939524996734971, -0.1230023770529271, 0.41925040322782964, -0.2228441904767515, -0.18268716703178986, -0.24572706742370334, 0.3266487247573515, -0.34960572274707613, -0.31990940396074624, 0.15898493642859554, -0.35636836992747817, -1.0014790039453219, -0.2407677115165225, -0.06274490115242515, -0.4515302884903274, -0.30338086902961287, -0.04022293818256443, -0.22498586390482042, 0.5678998402037956, -0.31702257264351646, -0.35386535576887324, -0.632821609421223, -0.14808237238591468, -0.7985503737884058, 0.21271386640607698, -0.21527033230213888, -0.18903756193808088, -0.3154046270744538, -0.21460065830057762, -0.360809940570262, -0.6266414428536239, -0.4534466177546162, -0.39432892140986897, 0.4946872814715732, 0.07091499719798965, -0.440272959699912, -0.25508076385830064, -0.36412875009910894, -0.44994160319082627, -0.02287894187446751, -0.7784472734379178, -0.4248542031871743, 0.32106793084058644, 0.12962030965773202, -0.31064363757415503, -0.554031293003776, -0.5091555662153738, -0.037494923199113274, -0.4899445077093131, -0.1978024128970422, -0.292763386897101, -0.6524549416763946, -0.3941543126823232},
    {-0.2678840172238685, 0.051455741797240065, -0.07544489868166782, -0.49988997528642204, -0.6463826947368749, -0.5928378867466829, -0.12367144247395043, -0.24007750347111512, -0.2111809478789666, -0.5008744452272785, -0.33657166335276334, -0.20913504262715485, 0.13484537497757415, 0.18299749443972418, 0.06609829014645727, -0.10817168856767753, -0.25251192330420824, 0.3266095342615656, 0.01897010702055236, -0.38884970870106067, -0.13989176484775195, 0.005249684967996962, -0.20919197981201532, -0.14222088874855085, -0.5694739168407122, -0.6424656813496948, -0.34614706986339205, -0.4090557951200057, -0.2536334826944688, -0.005270501816336609, -0.4028656258235275, -0.08121039305985878, -0.24942706084667898, 0.07209860150698608, -0.4987248473821092, 0.16987769555372426, -0.06979594470161926, -0.4133199573206292, -0.4716622958274012, -0.10390528696107953, -0.363942742503417, -0.4124681609654757, 0.06527621709857137, -0.39678819352312744, 0.2142265326464211, 0.20776212720969886, -0.27898555491565724, -0.2071739117832037, -0.4844286331896299, -0.4516946936610596, 0.003723846740323087, -0.4465802060774099, -0.1812361934077863, -0.2751482250154467, -0.09249689710606962, -0.3129934515906837, -0.566449621116767, -0.5274814577459846, 0.00036533338551216995, -0.20700507669585466, -0.11111839879102864, -0.3654329560403956, -0.25614619565410673, -0.49095939229027025},
    {-0.412220511738397, -0.1248837000288954, -0.2864033510334735, -0.8968237862293728, -0.39160234806336824, -0.7051686877196924, -0.22084499877889477, -0.1984091017941675, -0.006162958371926505, -0.6850760837523523, -0.10531042840169844, -0.30858928471629404, -0.20263901130431144, 0.3550251582999982, -0.1146382152024502, -0.3596480405466331, -0.04297461209704567, -0.024549138106546322, -0.4814804584114029, -0.23819749638515347, -0.19152440216263117, -0.597038248302326, -0.7652636391162618, -0.43639012738628646, -0.026421349514882477, -0.7394926079637534, -0.1504731318713686, -0.3971679978176203, -0.5893899329923035, -0.15414452935292072, -0.30080607691910405, 0.12017067694172841, -0.2964267480016324, -0.026398675806832576, -0.38617150446439336, -0.11351573425377276, -0.534050064686248, -0.5088473299759215, -0.5187417675320728, -0.30161584111920986, -0.04050879012949275, -0.3816607802966611, -0.30380649476664584, -0.43393170924956453, 0.0993445666876232, -0.3630315489230585, -0.4143908679061815, 0.0352191590394808, -0.4823846271664981, -0.10345606035846074, 0.0070099663799957435, -0.6128509196591108, -0.7091904216570902, -0.3082144621148789, 0.0761043367494899, -0.4289159608918981, -0.4116541775183242, -0.4977211071290271, -0.2344468709910074, -0.42286356924334384, -0.2017717963284078, -0.04152964376263198, -0.7741517134106404, -0.4709874950580139},
    {-0.07084584199856059, 0.15906066085128587, -0.16553282657967192, -0.4829269876417969, -0.14146272902050977, -0.5945878787125616, -0.33223711100411724, -0.3788784103036615, -0.27030624378483614, -0.7192867867489581, -0.4869040481320539, -0.17393739028714456, -0.0843705743347233, 0.11543133228393772, -0.32220891280113995, -0.0507627121345155, -0.2265052785471583, 0.21693749433217666, -0.25756805875864164, 0.1559363357176491, -0.0003331400251132426, -0.5046462202556637, -0.037895659835006285, 0.09877595055247897, -0.0763372667116203, -0.32509270457155964, -0.414575592122472, -0.016638599678119138, -0.16670856760964015, 0.034888964345014414, -0.3219157890964057, -0.00905350906128045, -0.19747805824972214, -0.08330606221122233, -0.37606812678748547, -0.11231265017107389, -0.2658999841348828, -0.009676946637620963, -0.33404181346633055, -0.1078906302290917, -0.46930320510464313, -0.28543330090785685, -0.0031504038033291454, -0.011660856467400388, 0.38595085069156515, -0.2561388794936688, -0.19847730216053022, -0.2576013705584112, -0.4717058145125572, -0.2287715840302855, 0.05983219446858585, -0.5366868900971382, -0.3568627212818216, -0.4245125860755004, 0.13165981741893773, -0.37123675233953196, -0.034875127543196646, -0.14002143884519774, -0.15210794813937123, -0.4606060488321151, -0.27209868332423887, -0.11925725125938157, -0.30680067924627397, -0.5285050582736465},
    {-0.06227666745990375, 0.2435307374905852, -0.03312236514582394, -0.5524959587840395, -0.09858418620019584, -0.26998264123470445, -0.07212659364693375, -0.6358969695729156, 0.01938989505180161, -0.31989971590348304, -0.37796629452714403, -0.3702403498245491, -0.06925020999558865, 0.5048319788293104, -0.3886767586847178, -0.3628600589292058, -0.27376662301618915, 0.2895284127237524, -0.387206277278279, -0.11325617004111198, 0.14057140816643549, -0.4377582270046196, -0.20138023994181153, -0.314350852850439, -0.10341411884114007, -0.3778579946626464, -0.0526551139672575, -0.026247035264213223, -0.47912100060180024, 0.0016566495358570717, -0.31170366348848305, 0.17220445022928207, -0.22406244988680746, -0.22663142595498686, -0.6964870016627537, -0.11664812861883653, -0.3493430339935049, -0.49120500508519327, -0.3698464338116398, 0.0271604478914865, 0.08865668162462155, -0.12439946430911719, -0.20226570084171006, -0.29238101743478845, 0.01467083794945053, -0.3109782099133902, -0.09526831283778989, 0.11065402407825634, 0.060458703548492455, -0.3512174576461594, -0.18412613800848612, -0.2988568652550432, -0.5882373740831656, -0.4846326038634945, 0.10980025423606773, -0.3928301718611535, 0.1780877405759264, -0.44696680830274765, -0.21034329871775037, -0.30827480147692815, -0.16785655807577954, -0.3573738576224562, -0.23979566804803082, -0.2212056413587559},
    {-0.20006032014634115, -0.014629114819892543, -0.37593183742919256, -0.2537613775972442, -0.17125529196594372, -0.44841301023127067, -0.12684726483027872, -0.7051142373660444, -0.22068385248450142, -0.3247662213555657, -0.09216377559846403, -0.19406226031639356, -0.3155413938918305, 0.532854441230601, -0.3686767476547675, -0.41446861506469324, -0.3345183798565434, 0.03436438505004305, -0.3417360201434431, -0.14133582589693658, -0.030990767932130108, -0.3299357392811592, -0.5759660798511896, -0.21682373456771867, -0.2272576523593994, -0.5940709691909447, -0.7154038589938325, 0.008910639202822338, -0.5517537612076273, -0.15667628289957142, -0.4452423142776353, 0.2124983764376416, -0.3510769699186148, -0.4390239770576369, -0.6622847537975963, 0.15181160219020617, -0.5254429020444409, -0.4691350670247747, -0.36786197352742084, 0.26699980503959025, -0.17122049130311567, -0.3890845218914039, 0.05448867118539913, -0.4376861001824965, 0.2328855563554863, -0.12417468389907704, -0.39079860977009195, 0.0629341034992012, -0.20975878757713654, -0.6195067069653176, -0.2559233297227635, -0.6840474950194004, -0.6761722319917495, -0.3465121281447907, 0.10540234578950591, -0.4636818981792137, -0.05506379884409792, -0.9156337950204614, -0.16720269827678283, -0.3190332995022285, -0.4167592764160157, -0.5721492476052132, -0.46773932890435405, -0.6944104462048531},
    {-0.044013394243691155, -0.0815548339826231, -0.3034799986559528, -0.5235995744050957, -0.17533685137651436, -0.3565441485949575, -0.7600918683749196, -0.42557842502159426, -0.291242612850283, 0.04120278626810699, -0.35581876121994854, -0.01803787157922545, 0.021206914832457024, 0.20990467892260267, -0.18811219468783297, -0.24187904601497295, -0.5697357375772469, 0.06537625937512455, -0.3207871745396148, -0.3080406790869921, -0.08776943189354791, -0.2942763877422153, -0.31350571059565163, 0.1438480359375835, -0.3630145081571219, -0.5958153937176675, -0.06269374987601935, -0.04249396644343596, -0.5517079544046493, -0.18070913464827387, -0.2850274474538834, -0.41526845473140184, -0.09546263898812021, -0.48877150000943853, -0.4775320857724059, -0.29259356730509184, -0.41062734461230893, -0.5202803535704464, -0.31243196484497543, 0.2492545319139831, -0.24652839772103666, -0.25025120405463397, -0.2638309213078765, -0.06812252312685539, -0.3200687056714123, -0.15175067119065164, -0.22870045086833343, -0.3517616547080785, -0.510663934859116, -0.5337971270735038, -0.04678876485608766, -0.5659907679332978, -0.31990507064089874, -0.38794054992209925, -0.10803941225871602, -0.5246499913236312, -0.05240907810762115, -0.2764490537131649, -0.08023815900097439, -0.31828784682320366, -0.5180105537694623, -0.5879939078537497, -0.6158393606249241, -0.8840151196169095},
    {-0.06083949098715006, 0.3884867626649781, -0.28613378929123706, -0.4057202349982912, -0.2602463277324181, -0.006048529439001825, -0.1437364831907461, -0.5935674700925785, -0.5571402323449601, -0.04840947885115198, -0.028307378788670595, -0.2776896397734092, -0.08787950562911304, 0.04040177075685962, 0.2602981010623098, -0.16430988723749532, -0.37918486154312114, 0.009477879237282664, -0.3338244699015965, -0.06439966246634504, -0.17031044309450424, -0.12593516939361968, -0.2907354311513409, 0.024610105852776506, -0.2935777183739047, -0.5416520394501732, -0.5442051952128791, -0.3028056381414714, -0.35056967710165277, -0.2540980361680172, -0.5725966222184996, 0.04560642612227048, -0.17127425964807053, -0.3771319608027716, -0.3918612039758253, -0.3132801777510578, -0.41785621525030286, -0.5429403760344365, -0.08598620450905897, -0.24629336436107305, -0.1291211852556621, -0.18389484116670932, -0.2788343416740009, -0.13849245273734664, 0.3048558693678332, -0.28068401821948963, -0.28262351456488927, -0.34186277623772837, -0.3546788245845152, -0.5091176196068403, -0.47090997931635553, -0.6289819937655987, -0.4031086380338041, -0.2824282003137501, -0.33791492335650186, -0.515977956611393, 0.004423470980874344, -0.3870779514706683, -0.32717558346849135, -0.3739643747025853, -0.41243585829075874, -0.32149753582295526, -0.5130702545354241, -0.314465766530834},
    {-0.08756151217318897, 0.17810070751632692, -0.22672502039297832, -0.08363748848909805, -0.028138104082315263, -0.05589853949082296, -0.3755736041054063, -0.6168828271890767, -0.4096949787658442, -0.3970769221317604, -0.44382908100081897, -0.32427630430324555, -0.37938245153791467, 0.2733731948575819, -0.5112158138233907, -0.41467432103840207, -0.30589925130286016, 0.22491964834569025, -0.4469335031844926, -0.3498791931286944, -0.14526851759456472, -0.5936313793705724, -0.42833139411125976, -0.14805515496561406, -0.33699459213796173, -0.03608388766136272, -0.36717536034202986, -0.17121507988672516, -0.4339300702041186, -0.1731535976580772, -0.2489400679324981, -0.3242858325592307, -0.11142629705322595, -0.46827372518469756, -0.6039945883066592, 0.06526701784331128, -0.24486426138910078, -0.49810834733822296, -0.5972918215609497, -0.025929007625019027, -0.3306311597991874, -0.05917468578931891, -0.23313975774547582, -0.11601563828303518, 0.15264319434384083, -0.40643616613031175, -0.014020767875112602, -0.22464641517501877, -0.30595186960415055, -0.2748385602973669, -0.09549642661876681, -0.6382316036089148, -0.8289027505190701, -0.43673686535360046, -0.00869206744776069, -0.4429118700068288, -0.4082736902985834, -0.6413542935164721, -0.516264446339755, -0.6204661082964509, -0.44604383207202697, -0.3831276998834773, -0.7777507868954864, -0.518992269189875},
    {-0.14260133735394803, 0.07258899811426331, -0.5183687591898405, -0.4533641010906225, -0.16823282682226112, -0.5541016304697702, -0.5441206636853338, -0.8264654845660713, -0.6242274604910529, -0.27363397705383524, -0.6087299093285182, -0.4417317149575023, -0.2704750457802678, 0.05637665903399563, -0.407509411326268, -0.358585172380947, -0.31532091018476704, 0.3919441183145398, -0.35858724771008815, -0.27096196985802407, -0.29557283184192795, -0.4825319750513909, -0.5454968052333411, -0.3972285392746055, -0.3698149566848543, -0.4598401916564648, -0.7062206578006207, -0.5199160811272343, -0.5337679576286417, 0.09707101006943862, -0.49692699298045584, 0.10885136800251904, -0.5526583515083553, -0.40833854431856376, -0.5523969880836421, -0.038056468814906465, -0.5369141711594073, -0.3396294202930714, -0.5733779120075838, 0.0091972264791842, -0.4639733715800487, 0.07389055156519832, 0.05050822401483395, -0.37576671762500524, -0.09445921444387628, -0.136430388653216, -0.1658727527434545, -0.14522639240393131, -0.2647428054345567, -0.36733352751403986, -0.3363498295695495, -0.47013172378475954, -0.6931732365476786, -0.3990000885667231, -0.14306817537137093, -0.6127872750503484, -0.31137044389727137, -0.2639065035891133, -0.5123152880316018, -0.5188320903888949, -0.2942687189792532, -0.45250407580253527, -0.7683689907654078, -0.7268268220840358},
    {0.18390267224929863, -0.016115008628828763, -0.4449482950495078, -0.31477857142538906, -0.4551010142805074, -0.4512800266055159, -0.38264345654922766, -0.5308362894169741, -0.41334167327468235, -0.3123829577642852, -0.560424967620244, -0.3825385746924896, -0.5122367841862768, 0.09259252337429313, -0.0851570930855828, -0.33051626926934896, -0.2880513372474189, 0.16578635175376397, -0.3506055669073107, -0.3399243044653619, -0.09626669203535865, -0.49567749743336387, -0.33658174050050826, -0.3222378475293259, -0.35917274829684387, -0.5718041737987123, -0.65481904169928, -0.2716407278229225, -0.4732102535800026, -0.5932852326032972, -0.698636151759033, -0.039232909280077215, -0.3882432107920962, -0.22597589312915195, -0.5127985852272833, 0.4005359651017298, -0.20656618508708707, -0.7183050506231068, -0.3774058214353436, -0.03699670723850789, -0.14570979649537127, -0.26431847275101195, 0.1596531051922815, -0.3359826238406985, 0.06855128406691692, 0.16139267326459092, -0.5506891260879095, -0.09934401056549114, -0.5933982973807214, -0.11807387196324555, -0.11142147289547771, 0.0006200773163896078, -0.4859906524928558, -0.7853141085897344, 0.14682608966243677, -0.3623637428286772, -0.1140980215668089, -0.5072042630455579, -0.3423554849969267, -0.7145086751144246, -0.5564622756345166, -0.4156458535265894, -0.46237993851903275, -0.46183405079155937},
    {-0.18281169091820304, -0.11381161100379365, -0.13525280089148928, -0.6080640638812255, -0.2870671438365515, -0.6936619136325259, -0.06807519472812794, -0.2564104859398163, -0.25907904356955264, -0.2531609252965174, -0.08234512411310568, 0.013441548815495077, -0.31780388215070077, 0.3425708666966281, -0.11572342971768791, -0.20547787424130343, -0.3981839335538927, -0.04945251141443535, -0.36046117115021836, -0.37645942211130995, -0.0712035882992419, -0.5114713004341294, -0.39529378708629614, -0.29242942712651643, -0.4825762444500948, -0.4192587452508137, -0.5595866500520544, -0.24136084972230087, -0.5458431225621244, -0.22618621695054697, -0.6844784872293365, -0.2800784768270444, -0.30496681493737504, -0.2601569393278273, -0.5246069729106216, -0.07493848602042798, -0.2963210790657595, -0.17046347926629957, -0.33029097605239116, 0.24639118827274778, -0.14717290882946743, -0.035807407715581274, -0.3337182767016525, -0.2728817964377267, 0.02740800566864732, -0.3892594927748908, -0.13158238912963316, -0.4458714379210696, -0.6753960746002908, -0.12241721415146842, -0.25575063434029527, -0.6537620203877624, -0.2726940809365152, -0.4040375070828087, -0.13742513663644126, -0.5817414609664716, -0.27225191006211935, -0.2568965044725653, -0.0564199873179843, -0.8150699518081576, -0.28127314590794894, -0.4868617082827812, -0.5474988704004133, -0.48585408231839833},
    {0.1949144805746086, 0.4700703891768269, -0.21171533382847488, -0.3565573158269933, -0.08663129977848812, -0.31356412978199805, -0.38347555151280804, -0.2901954404361838, -0.42788513437715264, -0.309378605300283, -0.24535875478369767, -0.42106439601709983, -0.5316515518102136, -0.041805901888789625, -0.007852869817393008, 0.07917277108332697, -0.2480145308119589, 0.15354220796132756, -0.0497715365459864, -0.045679234049403335, -0.0976543944744215, -0.390703920968253, -0.10997058996436594, -0.026277534840440642, -0.16038334872778615, -0.11088963742776464, -0.21124656425800936, -0.14991493182407256, -0.5291875412543701, -0.2526301872102173, -0.37723998785097257, 0.21395548722734756, -0.24502098150759413, -0.16346028688369144, -0.14783334262833972, 0.13914449072556856, -0.15495131015768157, -0.3470592925581078, -0.3836788502269247, 0.37803138707031014, 0.09400815740408434, 0.20980871153010455, 0.04752652035940656, -0.13339669741469704, -0.1605618631813935, -0.028235547744602355, -0.07487679454647533, -0.15468896160862342, -0.5969759267580292, -0.13340679654335016, 0.25900355154738147, -0.35428701631313003, 0.12799888401709858, -0.24464055313555744, -0.3335074808431683, -0.25985990047368873, -0.01800906123210365, -0.12636150566598056, 0.049195801751492296, -0.8847789977238635, -0.7313386019861604, -0.16275235822331643, -0.502890333332956, -0.7352148024500005},
    {0.2701462791168662, 0.34686405476943255, -0.27471080288079675, -0.03283411028004999, -0.24053557645847928, -0.4449013235316108, -0.10366007755031012, -0.06818745163334457, -0.5292408576746651, -0.4572388555659242, -0.12886015488520308, -0.08855792306450079, -0.5796896171057576, 0.2957602820516196, -0.18758545673113, -0.431600110153528, -0.40858095441214304, 0.5307258648203407, -0.09055917439423751, -0.4042160516374994, -0.1623116519063691, -0.7728226385988216, -0.28902641464018364, -0.08313950466382136, -0.007997038451024783, -0.35288002499186133, -0.36637380811065734, 0.06713839322293669, -0.6283232765102299, -0.35417421871332666, -0.7215396830113129, 0.2964620947099339, -0.27690480397135914, -0.14533683559623836, -0.26858258639874494, 0.038371949521591356, -0.2679259740924018, -0.39958600747302303, -0.17257725000318935, 0.20729653520859695, -0.3299255182505172, 0.27535219219970863, 0.024561961412912302, -0.1305559721419751, -0.015471318351999483, 0.21879492635572192, -0.1840178012965825, -0.11087137619143836, -0.35812614382907776, -0.2871185646190588, -0.2348074356587446, -0.49499101348064967, 0.0835616444293796, -0.40120493341642827, -0.43173357697517484, -0.40943032623760034, -0.17365952594291198, -0.24266077200954236, -0.14226273583059415, -0.3691733570425174, -0.46471992674933876, -0.20087719610304783, -0.4578679492098471, -0.9841512850987973},
    {-0.1697555025946886, 0.2494670141105108, -0.12435746987681047, -0.44400000141956597, -0.48788638275970114, -0.301017462174712, -0.43086901918969017, -0.3171435150796755, -0.13931911447352663, -0.3539259622347428, -0.5273541169205495, -0.3140212485829354, -0.4454367051440851, 0.10764287116134699, -0.1499793877967854, -0.7189967417631057, -0.332795661158395, -0.05818855683450438, -0.26867919108032334, -0.3872099153041482, -0.03501303879455046, -0.32435065836508814, -0.41522113787425247, 0.20931493076329524, -0.6420868591731427, -0.2992088593572446, -0.22371358882007802, -0.4049901140149368, -0.35219920750484024, -0.2989627302824566, -0.6481854173122854, -0.23458401874761173, -0.1910495325524781, -0.30661672245146354, -0.21095383566416767, -0.08659520878635503, -0.2605635494482267, -0.36262222487834317, -0.3262641424632408, 0.4756860536469148, -0.08939471529631783, 0.2403988464292501, -0.0007536838923777691, -0.05468286438470704, 0.325510737033873, -0.20163646177222866, -0.29178153778376975, -0.2919113152832417, -0.5095040309281575, -0.48662425400824305, 0.23367504996745714, -0.7068580792254399, -0.18758790882566428, -0.37739978425768855, -0.09971572429219097, -0.8276103205682113, -0.3394980144587953, -0.1757054161889171, -0.41037030024194865, -0.408067756896493, 0.11856811158285882, -0.28061266564194354, -0.3107825704488595, -0.660780108498215},
    {0.186148705437652, 0.2894934602001014, -0.5744275417705963, -0.6037074145866653, -0.560182719524027, -0.7926492192162252, -0.1787211147119103, -0.7605370066843633, -0.6472511489968211, -0.7239877150034801, -0.38806887973062937, -0.3539286536742059, -0.3108675849654479, 0.27829119760375953, -0.2839029001377234, -0.06622816975551352, -0.6229902874347022, -0.1622987179026386, -0.3659283083889171, -0.4390771888896221, -0.2558866421555143, -0.41846539826529383, -0.529569759796984, 0.12790537978625854, -0.6018065715128905, -0.60750545313197, -0.18305699907389694, -0.44252595354372826, -0.4459931322925831, -0.17832585639234616, -0.5814502195609539, -0.14435523454419238, -0.5964218971564187, -0.31025119677328983, -0.47138004499455305, -0.12542475195895353, -0.4363167468855814, -0.33796424903396854, -0.7026126579724505, 0.26945429197727994, -0.5782467841985808, 0.2170197223914783, 0.07194053467090937, -0.28148996685465594, 0.13896747633301562, -0.43362298060196397, -0.5781424586526023, -0.11337727991312914, -0.6097029744045509, -0.5477061839063145, 0.24766853095733427, -0.6210731567996964, -0.4080465758674474, -0.6196566733505535, -0.33077763453959197, -0.5506523300757806, -0.3397922713607162, -0.5372106284677061, -0.4058549847218254, -0.6464249703455796, -0.5769746166570483, -0.6464023500382081, -0.7434148290622741, -0.5887405514166342},
    {0.17887040694593306, 0.3444438471694221, -0.5310742165196973, -0.37103682076057226, -0.5031377662972203, -0.3822310136927333, -0.20293410035743423, -0.39108185296590303, -0.5121291245227058, -0.534354939222134, -0.3241329419071846, -0.18361887696499132, -0.1882985457048477, 0.19308784242898097, -0.16792347851442765, -0.2629266364667694, -0.4114508863374831, -0.011337783831271094, -0.05855285200522922, -0.5312502284039795, -0.08162824484925309, -0.5130547609464323, -0.48671786276518136, -0.017603149531702944, -0.2727937566301652, -0.31016228118819156, -0.17941916645793168, -0.04337419526773928, -0.4255369528255857, -0.17298043156858575, -0.49666958007217693, 0.07464681831809453, -0.3514769007123447, -0.19643869546462386, -0.49070175686638423, 0.34293604557154883, -0.19403702726642957, -0.428258044523231, -0.2516041320228941, -0.06758870942390256, -0.5765097710813964, 0.27336743222980814, -0.22017740040952147, -0.40576523810767884, 0.09737265462105736, 0.2803581293701201, -0.12222540093227158, -0.3056833348137359, -0.6624166223119549, -0.4779774399114216, 0.32938487460162946, -0.28870501309507085, -0.4304333503838068, -0.5095610139906123, -0.029856782275235062, -0.23391917317567015, -0.21372255337425056, 0.04517408861064147, -0.3701766767512784, -0.5064920364485271, -0.4771462942479767, -0.32941338168367384, -0.6270863370089093, -0.5437589777091285},
    {0.15339105069000308, 0.27273901193122313, -0.6697851843535875, -0.4290301755688406, -0.37028409212031266, -0.2483042101072965, -0.11378099302742481, -0.21492043736280766, -0.48580789916579903, -0.4319637658173417, -0.5006572620824725, -0.1987268414786903, -0.5001455825848871, 0.08218420948982737, -0.23446470488006566, -0.33325552093593785, -0.5338231217720426, 0.15118291781421714, -0.4231401710447397, -0.6389916621187418, 0.0651818940745266, -0.6885311059831175, -0.6143506116808729, -0.06026105549597507, -0.354594851531142, -0.49475042300468414, -0.3030092609601845, -0.3788291406728448, -0.3790658427981009, -0.529362531572852, -0.9922987221668936, 0.25236497346814957, -0.3218819070855461, -0.009327071898340495, -0.4005551560311261, 0.23906320370105663, -0.33562424946010044, -0.11658420386178381, -0.07154903008784365, 0.1383051390406278, -0.30070581118910217, 0.1809255231609951, -0.2774961028661763, -0.12372683361848315, 0.19794072461203677, 0.2796606784519289, -0.15668883928237856, -0.18563256811800913, -0.6032469162575517, -0.44613446059033157, 0.26093163290800014, -0.3418201670960507, -0.23585501416985036, -0.8084563518016099, -0.12935704934526143, -0.556021064734987, -0.07055402787764453, -0.21537186483909734, -0.763323788657944, -0.6242974387870993, -0.3273994406717146, -0.2931521222310474, -0.8816285787644458, -0.8768180144089512},
    {-0.5055621123786526, 0.2345858071026694, -0.7223769581515674, -0.3173571663693155, -0.1331465069072999, -0.5164920366467951, -0.17273241938445355, -0.12319041538936853, -0.49964407359556123, -0.29113487943810146, -0.34615461527924335, -0.23838971489152683, -0.19207408882322569, -0.003878141394915154, -0.09603028149494552, -0.4442427370476008, -0.5508520436230865, 0.28966217738355043, 0.08881178089231961, -0.3448480596843554, -0.08239022403515567, -0.4118673533421036, -0.6092032191233526, -0.1239334179318939, -0.22815024615814788, -0.38505745316422624, -0.5039102862522741, -0.47077561152742214, -0.2938284732482827, -0.6638347737115372, -0.7007209315753972, 0.20311063229434115, -0.44696771634488364, -0.5793920281554047, -0.6073055163254454, -0.06107239697916994, -0.14471582101150784, -0.4144836198093841, -0.1934747555199815, 0.3334760929973176, -0.21646650715398397, 0.569719844292033, 0.18553406532707972, 0.06698252239062621, -0.10023325524732826, -0.07916965927296914, -0.016731223722455512, -0.4902823535506509, -0.9994814893905594, -0.45897788475387963, 0.5094057920475171, -0.0474397338296705, 0.06651152238831687, -0.5485069412128839, -0.1981634611134559, -0.5903974773424049, -0.012062714147068236, -0.18266433859898096, -0.6749813114492944, -0.7338852124702626, -0.4833967072313331, -0.7102200526052805, -0.7939669667939947, -0.6394297898602568},
    {-0.10688038653632835, 0.506025005846168, -0.8811533794592931, -0.42564754909978003, -0.36668294314112393, -0.5197322104139667, -0.2489159107459019, -0.4524709188372631, -0.4795413165174663, -0.11546681521282032, -0.4558723265473782, -0.04110535749651452, -0.4535109141345307, -0.23397954561716092, -0.12759203246784143, -0.29849782434066696, -0.24136248029453752, 0.2522576790800119, -0.15441735757159455, -0.5967603341119209, -0.2505281083379942, -0.7400310953605472, -0.8009337902687809, 0.11216804630621638, -0.5077213569796474, -0.767669769450825, -0.4241544094843242, -0.45360492263373337, -0.5615313176699165, -0.38229415485782936, -0.7821838165511772, 0.22911228399733027, -0.45121178096327785, -0.3773352541073818, -0.147824457073564, 0.0887439275658217, -0.3648069869180001, -0.32827896660772476, -0.4977012123433825, 0.365871438327563, -0.30309551853687994, 0.22616019981376229, -0.26401089216216606, 0.008359744723103121, 0.025231568055590473, -0.030220146495994697, -0.2287250124859339, -0.6031110379265707, -1.050680662205603, -0.6078670003976744, 0.41571947423825795, -0.6488611022246423, -0.17882533045643367, -0.6305373706303965, -0.4468969070065983, -0.9163592007537809, -0.24416907302111623, -0.36703453867992214, -0.32295193369011205, -0.7867629030020249, -0.5604823979766731, -0.4691556066324883, -0.8028238442611734, -1.0142347149574027},
    {-0.32122694351872383, 0.06777662168075885, -0.49566526658632293, -0.8269173276839052, -0.3917253924846041, -0.8202574885779603, -0.5431009899397716, -0.30292539257458073, -0.696115459189657, -0.4022631572210229, -0.26077025557249195, -0.20198976324650333, -0.4945884856858184, 0.019789672507908848, -0.2247229680885824, -0.5691433371799999, -0.36969207178158575, 0.2653890884720179, -0.44392951274900466, -0.41500049858406196, -0.17008057795925702, -0.5585013857285976, -0.4711513740073878, 0.12330889126373279, -0.4981444720005705, -0.5175664633711364, -0.5651943346419354, -0.425708763832943, -0.44072552998571995, -0.31795688165411967, -0.7716820749720179, 0.20053488298035776, -0.1796299794115035, -0.5718134324912202, -0.43215494484211536, 0.12548744158563707, -0.16556669264479804, -0.20462345424317238, -0.4049852541770084, 0.01092976575001819, -0.5020980857850869, 0.2967318014290433, -0.37894538630520586, -0.33337488134987764, 0.03768012960957038, -0.3232081973446236, -0.3183734203366526, -0.8521822870296195, -0.8195412733676737, -0.6375304780608161, 0.09845892982631382, -0.5895704533501668, -0.24304538709293813, -0.6520726443916094, -0.3222153806452714, -0.8028315219707615, -0.3011068218901247, 0.0557159239928355, -0.6864158140151351, -0.3882996219924666, -0.48693457803506784, -0.48018937637409087, -0.8412971993136446, -0.8668134942873472},
    {-0.012183144451453954, -0.17381319928763836, -0.8379150948742536, -0.5841345873691045, -0.4597424191222737, -0.4946867170921114, -0.5038307064760555, -0.3341375767341983, -0.8419835827119541, -0.18824998317336952, -0.3763213545588753, -0.23938109492302626, -0.737215040222201, -0.046299097126766275, -0.1620094238402343, -0.3048865712227844, -0.4165581060030907, 0.37620163906434634, -0.322901019718885, -0.6608389414926362, -0.19693324559341294, -0.5567135290196148, -0.5930864443242084, -0.2709178890514785, -0.2862536539620521, -0.7023996245901482, -0.3917472884825497, -0.49594187251505556, -0.6860849271411402, -0.2724191004808436, -0.6328185248069734, -0.045034492723624545, -0.20273091189645698, -0.5515018045502916, -0.4327626708075509, -0.036368088715720774, -0.21351503255494916, -0.17421892513612106, -0.5011482736654879, 0.23816131295610898, -0.3215607162436313, 0.2679839134655263, -0.038201412306028575, 0.0514823152368884, -0.14241040341758185, 0.030103382727811438, -0.21791760230062954, -0.5845500116491127, -0.7303376716864601, -0.6584817881109407, 0.1397572759752162, -0.4333755321822106, -0.17233286097352915, -0.9294987425790445, -0.3846812849656442, -0.6222567782745363, 0.12323354827611291, -0.3545346651957607, -0.5064560851173016, -0.6911534491277441, -0.4293785692641984, -0.5583037801041262, -0.9427713181621682, -0.9878295972606518},
    {-0.25385090039213987, 0.13931160216821764, -0.6190741153575052, -0.3566081111445188, -0.37077488748873366, -0.41448242430318116, -0.3567963497265208, -0.30625089327731814, -0.8439674612554005, -0.5124061081057691, -0.7795463276341218, -0.22835639744727856, -0.7131459409155391, 0.2733490873485197, -0.3345518310940188, -0.40796596830004206, -0.40792546697014087, -0.13178186558914537, -0.36102073365821746, -0.8019255343494058, -0.5003427993080942, -0.592204683383837, -0.5810947828343688, -0.12059935711816532, -0.3747556992066691, -1.0026296438084896, -0.28870898838975095, -0.6617762992739246, -0.5556047150474127, -0.525206400385957, -0.7792249628447697, 0.14893261422171836, -0.049410677506371625, -0.32904566190879436, -0.6547363519836094, 0.14430133939247597, -0.17932084709850907, -0.24029932134622328, -0.4422355736047683, 0.19967360025791633, -0.41517200726295495, -0.02756282871603678, -0.1517591596174357, -0.30204089633834363, -0.15600939558943383, -0.18659165962761348, -0.27193137607380885, -0.44750475443295407, -0.7956575110414753, -0.3139565363235978, 0.2678072278703084, -0.7201044224742175, -0.31069579927650254, -0.8418294791757617, -0.4421810907030672, -0.8639725514388503, -0.3813745088751556, -0.34176498680578765, -0.5292416887205913, -0.9193857513584114, -0.4543199382529299, -0.4371535852665331, -0.9274931683047148, -0.8210588916285149},
    {-0.07902341714098053, 0.29828642972247876, -0.691535154126541, -0.6631697061560574, -0.6663779251602059, -0.3148814022227883, -0.23724720136252705, -0.7289705267857617, -0.6023026461394827, -0.5235644050712303, -0.5891506346213295, -0.1428888501204255, -0.5418683747957224, -0.1532073029995396, -0.3338455397648328, -0.3936277684160522, -0.43971368415857304, 0.13452783891331435, -0.28479289113601824, -0.31837307304894014, -0.43564168600399994, -0.8572240939028998, -0.770553421471934, 0.02543221015976227, -0.30804209666425036, -0.7857458006085147, -0.4112049223676266, -0.4960688274220647, -0.25085805958704976, -0.5022873707684395, -0.6198505178796428, 0.14754723561960517, -0.4037213004217313, -0.3217089434878737, -0.593433437111571, 0.08007798232957207, -0.2714942275869684, -0.4825350292062782, -0.4696517191589278, 0.038256681477088265, -0.5498809958805297, 0.14849694135347485, -0.3328887466661081, -0.34047762365219775, -0.2902290295773195, -0.2742667011527388, -0.2560131383898959, -0.3601618864892003, -0.6573908853255974, -0.563659495813253, 0.1614405379342829, -0.7666138781365893, -0.20999324590260876, -0.7656679416503962, -0.2961295423584698, -0.8311234023727406, -0.12556756867217952, 0.06174081754267717, -0.5232069439679826, -1.016936932206191, -0.5697619626517993, -0.9349858501004675, -0.6901490301068126, -0.7728257586058135},
    {0.021846173724331192, 0.3067965962407193, -0.6553899367135178, -0.5092415581273345, -0.21407166829210755, -0.8556990973815143, -0.10585846787287057, -0.660685895249857, -1.0109111666707218, -0.3230392790497968, -0.46879919711637624, -0.23852949693418332, -0.7242444193957406, 0.21610785787287703, -0.15681339385027612, -0.3808396824672109, -0.38562814603360734, 0.22671362168448195, -0.5154594262495225, -0.6547910850766527, -0.5213316359311562, -0.8083027047214144, -0.855377751966427, -0.10602580862218146, -0.41706883955170104, -0.5521260719474163, -0.42774812211250735, -0.40294353558185614, -0.3957978330093397, -0.57008866307688, -0.7635261990293241, -0.028129868952453153, -0.3526250981393488, -0.5405106565551917, -0.6670111249439081, 0.17963237090795514, -0.45815752676037363, -0.28811464242749774, -0.62831352515735, 0.09062059450080659, -0.35018164186431905, 0.05560745349905547, -0.2255341774382684, -0.010531067775470146, 0.24527634811517376, -0.12185268710749293, -0.04272565039650424, -0.6254000130983203, -0.8361403509449985, -0.7142105894964997, 0.15900030958780767, -0.5269187413232431, -0.17141994061355606, -0.9220439408339035, -0.2167594503778654, -0.9848453412096273, -0.22205686632293598, -0.1784103862623257, -0.6076324729170516, -0.8280609283315393, -0.5912262068238151, -0.6077721445757176, -0.903161609763079, -0.7747598568506513},
    {-0.0352955392545068, 0.5081419788544942, -1.1026347534812238, -0.6758960426129159, -0.23118784091467065, -0.6854828203064371, -0.3131505405778014, -0.3334217152411246, -0.8378326574815426, -0.2404177232197692, -0.509435719416772, -0.1485541122187454, -0.42604322587878374, 0.07475491269464946, -0.3684211466259485, -0.18979527672126137, -0.5446507315644797, 0.5881458739879886, -0.1143716573461897, -0.4159999091566635, -0.4239355710159138, -0.5953491508560584, -0.6803141923822268, 0.10602801604364447, -0.25110683020920166, -0.4652989130286073, -0.5465839372717509, -0.6347326125574818, -0.09244879603672283, -0.6518835621723141, -0.8160724804325769, 0.19635884912810825, -0.3036575916855922, -0.5593502413189279, -0.2660086560691438, 0.004666572290837568, 0.0064430313395318056, -0.10483261974741341, -0.33445560172784816, 0.3359412862473856, -0.20652776720024685, 0.1431772217277392, -0.08091271654154684, -0.13491080335498573, -0.06434985841361526, 0.2120039930079763, -0.30545568409846774, -0.6165198436447222, -0.9482245711451527, -0.15785963387802834, 0.2820006745394767, -0.8589752256821136, -0.0866958589343447, -0.7875409498321014, -0.1534859302368303, -0.6684139351861124, 0.07026642603701895, 0.22298836629999233, -0.612203086185727, -0.3610139419983778, -0.2858285265373107, -0.5330340861223445, -1.087282168727342, -0.7924744642011898}
};

static const float b1[64] = {1.0317285764868527, 0.7956066924440317, 0.9533431820644266, 0.9710554516322546, 0.8578972814415406, 0.9118375344436119, 0.8793486639319517, 0.9948904745259117, 0.9512810796775769, 1.0044074484741639, 0.8028929799663709, 0.9844116197535819, 0.6990152855190491, 0.8861005877426649, 0.8288736623430707, 0.8190548405079763, 0.9368541049347169, 0.8887107302185645, 0.9958259895254146, 0.7363327081495322, 0.7634550536716888, 0.9129850088853146, 0.989657255408789, 0.8258568770424144, 0.9718930168182984, 0.9295522532014252, 0.9902660739549631, 0.8228367053061936, 0.9431530518237227, 0.8611754299519454, 0.9787828501800421, 0.845696026287201, 0.9339446045333382, 0.9028379285113034, 1.0280012202036612, 0.8328822072213219, 0.8919652833047719, 0.9853053077231471, 1.0009732411142525, 1.0108271792425478, 1.025834991756093, 1.0471852460931503, 0.9789777289816404, 0.8398264309747486, 0.882100454825485, 0.9886665481113124, 0.9980836972903475, 0.8860459420093314, 0.9219318867684261, 0.8173743454415755, 0.9217147018992744, 0.8598012242015564, 0.9503103004407045, 0.9772425398080474, 0.8597874254148306, 0.9653717910091041, 0.9321727790858809, 0.990821202061633, 0.8213050617037725, 0.9564207780720106, 0.930801022159431, 0.8430208220543688, 0.9319975454637204, 0.9760097857607496};

static const float w2[64][32] = {
    {0.16336412002651446, 0.5216066538035121, 0.7882347221568843, 1.0968319273314011, 0.6585549512038625, 1.2794751656314398, 0.8866314435422847, 0.8346567441987882, 0.33550167127421365, 1.191234786683441, 0.5755625197826282, 0.9033099644334587, 0.8575702258547925, 0.8085711651147861, 0.006734535816227959, 0.7507978868826273, 1.001155449237881, 0.6773068575086815, 0.22630111769459718, 0.7146668602298013, 0.7980397327469565, 1.1302274034507418, 0.6640872676491348, 1.0891366239398443, 0.5714535196025715, 0.4543443492191066, 0.5742406780383227, 0.6255034656009018, 1.1568340109237747, 0.9475030605158716, -0.16259465147806804, 0.7822310819416338},
    {-0.028663368486264468, 0.5969345190860976, 0.8676006429330351, 0.6687588434410698, 0.7183362562317367, 0.8588262130557174, 0.5772538200722684, 0.972779595822973, 0.290873875787877, 1.0100216121157872, 0.9812692067538554, 0.8254576675348042, 0.571326256940847, 0.9142919406957537, -0.005211629261410586, 0.6434425778807326, 1.0071443722543851, 0.7625530278026691, 0.2579354128201786, 0.22654789606724904, 0.4482492079151997, 0.5091348231922366, 1.0001964781433352, 0.6540469553423329, 0.8395070830784691, -0.04025206840317194, 0.434149843144357, 1.0383815426405478, 0.5582306755222248, 0.7377889556344265, 0.18960116372918503, 0.8838601354134844},
    {0.018240986677487317, 0.9613237078217862, 0.6701455388702068, 1.0080110312424442, 0.914659915491297, 0.9385111671963334, 0.6187188848739625, 0.7459161715068813, 0.4619718101190923, 0.8670177393842223, 0.6022443798429298, 0.5456918366829815, 0.47337096829588116, 0.6564201210150097, 0.03699571505549643, 0.8179104193156994, 0.8720644755271816, 0.7894715411743294, 0.25895234402244593, 0.8391862244451613, 0.3323010130929526, 0.9040526734481726, 0.8906736558490688, 1.0960135151760486, 0.5721313557461931, 0.1743046192214834, 1.1624569777914813, 1.1571913308271118, 0.884696702520335, 0.9008425139708387, -0.04427184173031205, 0.4016655152350908},
    {-0.04832121070951261, 0.8168744826405647, 1.056444308018303, 1.0578293573862185, 1.0961930172889573, 0.8929847329073217, 0.634126690916746, 0.6810076400655185, 0.23843132263851335, 0.8030441604634918, 0.838193966175666, 1.2980691249811083, 0.573569057976512, 0.9066775010190533, -0.20082199199695863, 0.8904969853764153, 0.6780924782514421, 0.6919257302109991, 0.6113668434862198, 0.46860146036811007, 0.5005894355764967, 0.8109819388113657, 0.755096256535468, 0.9440167117541138, 0.8921596071305944, 0.19103247355153974, 0.7912888111692667, 0.5679547703028315, 0.8943581219438954, 0.8192103121729561, 0.15710033927691316, 0.7403821799869461},
    {-0.15181957344531297, 0.9304109248697147, 0.83165434568708, 1.0366398763388234, 0.8546630104093672, 0.8844050310598183, 0.7349474080435963, 0.7231864305355385, 0.32833452073854746, 0.6217242417067175, 1.1933602465461708, 1.1170985371218525, 0.7485594361120946, 0.7764520613299188, 0.0906339706743924, 0.926463022834099, 0.6860461407521056, 0.9162349366139109, 0.21597190634914692, 0.515150500208845, 0.7556778922400432, 1.0370956566559735, 0.540355202836454, 0.8302346056369105, 0.6383673322314858, 0.13568518474891986, 0.8800940205476869, 0.7199276185991441, 0.909283148878637, 0.7745644237714, 0.07000807543724415, 1.2194634381887293},
    {0.026986387504185767, 0.5950765098330509, 1.0971062575962658, 0.9524540417778403, 1.138282357062251, 0.5038922359316743, 0.8461756673566792, 0.45330524878106454, 0.3570912598333405, 0.5737670248560796, 0.6821214827876486, 1.046736372991668, 0.8659431769193732, 0.8068978592651359, -0.03749800187545209, 0.9593715368523301, 0.8386250267746098, 0.9056685091947055, 0.2631519116037575, 0.7080450779023141, 0.21849316874421995, 0.8549631994284731, 0.9278576600167507, 0.8639699622923783, 0.6700473538397118, 0.4650141311614467, 0.7359726405942401, 0.7495586012405957, 0.8502021152084089, 0.5873221770442612, 0.21006487930523593, 0.9695665629098811},
    {-0.18212996334086862, 0.6717537737241828, 1.0031155348095668, 0.7310743557569324, 0.6914462935791266, 0.9633478524609616, 0.6199127907761636, 0.7500335377120886, 0.5284018566429401, 0.8378351251894112, 0.5468791019484963, 1.1087969567784968, 0.5349585229249068, 0.6582469886234523, 0.09885526707006007, 0.5718166052624145, 1.4182780351320237, 0.6468023787283175, 0.23794828208925467, 0.9687764235507776, 0.4196941695540679, 1.140811764098109, 0.8476990241556946, 0.7979050460524978, 0.4368810355221297, 0.158455288976221, 0.7105109873796953, 0.4934794410948622, 0.6160676264169862, 0.46014864439164826, 0.07915553412469406, 0.7636736962730994},
    {-0.1639265758466436, 0.6167009756183359, 0.813208239338363, 0.9048316266081995, 0.5708658766124287, 0.8572196213862429, 0.6393492988583762, 0.9487183752875308, 0.5765721133957236, 0.7717070712062396, 0.5034023506230975, 1.0028884382437795, 0.9178679564996522, 0.6450385889953468, 0.05381909193078744, 0.7938413425029265, 1.2287483324147577, 0.8092060302112885, 0.37495192936367777, 0.564521247884904, 0.5788689951883893, 0.9933026256415375, 1.2603066016955813, 0.7811305730700446, 0.38854526735100386, 0.5018696882222368, 0.535649086078462, 0.9121395503745646, 0.9885497836803994, 0.97381127463624, -0.03130265550709857, 0.6827063244120528},
    {-0.03378258968618526, 0.8900108752520902, 1.059116451610331, 0.8994881215168176, 0.8423381964209455, 0.7814899939118174, 0.8135690513887023, 0.5132763788726084, 0.32391394681865915, 0.5986526402040812, 0.8929275573625161, 0.9888430042380664, 0.7405510859893097, 0.6827435569141554, -0.3669565650358142, 1.1697837831587796, 1.1545140594572183, 0.5356159793282607, 0.10263054058956313, 0.7511083603293931, 0.2501097651057477, 0.4776979606225742, 0.9916987432389963, 0.659244542086322, 0.7365804399030185, 0.009687293423382941, 0.6627694590341792, 0.9857453835035027, 0.8171364383988019, 0.8829090483685553, -0.15871479501006433, 0.5870739970149306},
    {-0.2350426727880885, 0.8325317507728075, 1.0607963526565787, 0.8874845973711858, 0.7955403501963185, 1.0481262094550157, 0.7596316996978183, 0.7766332370021412, 0.4823237186523659, 0.8928872801626242, 0.9756002450663113, 0.5941792568593938, 0.6274515335117207, 0.8148227887870938, 0.06784790000647747, 0.952039301299805, 0.6980114340018536, 0.5067003355352503, 0.3487312500884013, 0.751743296361841, 0.5570194217808849, 0.9160865065036732, 1.181434056051975, 0.9737011500720645, 0.46929703679886225, 0.07199782431152575, 0.8770008656955006, 0.704101130235963, 0.6458150184698688, 0.9865030813341306, -0.1889232204074472, 1.0350387180969494},
    {-0.30211854627247825, 0.8049428601381431, 0.9129828995289198, 1.0790734449902566, 0.8653974872380962, 0.5604576984063185, 0.8122822006549183, 1.1936531393593695, 0.1761340618661901, 0.8170222544964417, 0.5583511584357391, 0.818361469492621, 0.5266333227238735, 0.8440922592380725, -0.26593818041346906, 0.7678277088783385, 0.6455621576641752, 0.416582844153091, 0.6331380472325754, 0.8007279747656272, 0.9834854186940547, 0.7775754468573383, 0.855571416199034, 0.9113602191424458, 0.6832545764378812, 0.08963126724813424, 0.7582139526784547, 0.8538262890083951, 0.671416668589839, 0.9128966247124606, -0.1755855552892321, 0.8542261784583843},
    {-0.13802040708247007, 0.6969988976714194, 1.0287310641041896, 0.9425264349109246, 0.5938560424834523, 0.9158081281119811, 0.424773243431492, 0.6347920203228531, 0.12869622015599366, 0.8303905928366667, 0.7407638517087412, 0.7202639811686272, 0.6633366547914447, 1.0460398928163628, -0.16861915125042232, 0.9674455542736677, 1.1062854547719065, 0.9110865653538264, 0.4921087431946766, 0.6475794650060523, 0.45185175155959734, 1.1022941289614987, 0.6569266317526473, 0.8845876729799704, 0.8560351033109488, 0.37330812981392225, 1.2359280633288583, 0.8643138289528637, 0.984450169941672, 1.0229764371654009, 0.00822503220626054, 0.64785973715313},
    {0.1018430329272374, 0.7639408279006901, 0.8361790096597855, 0.8380982700047442, 0.6849437694162359, 1.0245488873261388, 0.563617591751251, 0.7617279283610581, 0.45135235246281175, 0.6301204866348503, 0.8559414026637168, 0.678550704625803, 0.43413321538097677, 0.7689171901789686, 0.021598549085073773, 0.548810288838604, 0.5739272601837939, 0.6210026916561568, 0.10613709522296391, 0.7368443618414152, 0.6129541599033926, 0.8281164042751897, 0.780171179177066, 0.6652038225544211, 0.7210157493009766, 0.018268475990245527, 0.7201992205401719, 0.5361418277573461, 0.8315793827236432, 0.6364599493166577, 0.02878098907408741, 0.638808333912782},
    {-0.08456107295592309, 0.8775602508531658, 1.1641290554193482, 0.814517958808685, 0.5878233859396288, 0.8510338262058099, 0.9766595311396495, 0.9054780847696107, 0.5841450897934513, 0.6775138305512257, 0.8099996798222677, 1.055712961903195, 0.5344270123726963, 0.8349823880427178, 0.22424179794097293, 0.6855499863310747, 1.0107568534121292, 0.794374858089927, 0.43427009379236436, 0.5388714720017214, 0.4674659572631457, 0.9277071431697109, 0.9288280377547096, 0.957606328691164, 0.8231094712324004, -0.0650038099543425, 0.9175745227250243, 0.8248872950085367, 0.5187788064753082, 0.5007044739797167, -0.16171911792468238, 0.9938787054091957},
    {0.08895230854589832, 0.8806228293313785, 1.0817294563613493, 0.8198389405766816, 0.6031796797853501, 0.708233967754004, 0.5382951553806962, 0.7532773431843429, 0.36960041033780183, 1.065447126928874, 0.5424450363949834, 0.959830835448353, 0.2992659727087274, 0.6723067383014991, -0.2973605420064542, 0.6368337361609787, 0.93315319032032, 0.7617662258034076, 0.1579470486671906, 0.4352020894754205, 0.8136677348078541, 0.859884162280486, 0.6333794672794698, 0.8304703944367546, 1.035601060979269, 0.18777215058830263, 1.0022296182737482, 0.5778356108726448, 0.9759204284705716, 0.5195774728991982, 0.20926321821312352, 0.437238461471213},
    {-0.1536545929921895, 0.7408703730711976, 0.6627013575357571, 0.9462169066024183, 0.8750091318980391, 0.7138842637389846, 0.480608203552349, 0.6428365340309012, 0.32561641840717237, 0.6636961177343866, 0.8411745222488113, 0.7223595010883189, 0.4882851956784197, 0.9872809574158746, -0.027524899965712533, 0.8993935781028433, 0.9997350832207823, 0.8238611309982843, 0.25551694001722547, 0.42736004768175884, 0.9059337241108485, 0.9954038519550993, 0.5583595781369378, 0.8735950152097792, 0.578137019740535, 0.3052681856158856, 0.5984024756780838, 0.5901472032099709, 0.6545078231950155, 0.9650498775985119, 0.1013304494550923, 1.0663511026662102},
    {0.04562777203348529, 0.6791619295338547, 1.0190055028021696, 0.5961277843905634, 0.6886935655369449, 1.0464715441912769, 0.44378925790475493, 0.40435438293095094, 0.3129805256608302, 0.7485922706988106, 0.8619363574904693, 0.927488514782492, 0.6454357086109429, 0.9311485886284206, 0.07318209529545566, 0.767872468030174, 0.6405229608248063, 0.8356440767409777, 0.393316160669728, 0.7162874626103605, 0.7225826271065413, 0.807253959214807, 0.8009996357108525, 0.8009049234750114, 0.670318683086045, 0.22069120980088588, 0.6617034003175918, 0.9068151615431198, 0.9101048327244334, 0.9093616659467312, -0.09755026770322035, 0.9890171630029344},
    {-0.27989145703751783, 0.7970656795162397, 0.9380474602411429, 0.9587940628646784, 0.8963963167963044, 0.43743784368742483, 0.7185219159938576, 0.6603341073041266, 0.40478096062194985, 0.7383130127869637, 0.8265537988643672, 0.8765642649544308, 0.6870312577472887, 0.8637132565463042, 0.007145089831367, 0.6735381239247971, 0.8891702896622304, 0.9816063281971139, 0.6502991791293523, 0.7019452984840209, 0.7250790278344543, 1.0960240006952757, 0.8794725025049782, 1.21968909373717, 1.0799277622671677, 0.4114668395286062, 0.6574797820039994, 0.9788400814403221, 0.7058145301334101, 0.9506022373360444, 0.1346081427741726, 0.8716101410549647},
    {-0.26458659262190115, 0.8230592457351585, 1.2694689500890146, 1.0230024271759066, 0.8624936171487547, 0.9704135070603501, 0.9451690811995576, 0.4122362186663967, 0.3792232584647079, 0.8360605810175559, 0.7670744722265511, 0.9595351728312035, 0.6300839152010395, 0.5663087189553703, -0.021912394049406297, 0.94870755436019, 0.715530856267223, 0.9516021051771326, 0.6550506131363287, 0.513543984948689, 0.6146480547619518, 1.1324822927708613, 1.2800536454957874, 0.7226825488815115, 0.8070936904753964, 0.2683397647842726, 0.6311287456816154, 0.46378660879913014, 0.9433100976155405, 0.6655957185165126, -0.13817054442167606, 0.6809692297576765},
    {0.15736928848310813, 0.9754096102105383, 0.5714101624035934, 0.8411852951560091, 0.43127675859228126, 0.8274528463418978, 0.5060978219407908, 0.42052832040315, 0.35323454501416995, 0.6206879723445982, 0.7652831202133558, 0.4392444403388278, 0.6328999152591241, 0.9167611027648693, -0.10267394061108563, 0.7478322472596456, 0.7444054884603442, 0.7843968254266523, 0.397915677480886, 0.6697532099142558, 0.5725845771354123, 0.5292723986652766, 1.117097551310152, 0.8033426789529051, 0.41524434266599797, 0.3700399767574639, 0.7293311624283274, 0.48472312240572674, 0.6856327243726498, 0.9439272644783486, 0.2981294209923399, 1.0262009165481347},
    {0.09374014939985087, 0.5054267707441383, 0.6674350753772095, 0.38938628329092956, 0.7365855177368048, 0.8249229788114912, 0.28433870862811356, 0.53136836527273, 0.35696724211593656, 0.6227855567219333, 0.9658170338405025, 1.014569845243185, 0.5364583722559046, 0.5202519252615425, 0.0852762913010738, 0.6620841530938711, 0.7999407287894063, 0.8225063721354035, 0.5455225363863705, 0.647365099095255, 0.6855943358777087, 0.8116304262689631, 0.6452034769922148, 1.1121117100739497, 0.5239436581251616, 0.41523321495223026, 0.6954641845635188, 0.6947731144861196, 0.977059620131936, 0.6622623347193095, -0.10610014452331343, 1.096012305787828},
    {0.17178955340534396, 1.1189036292438606, 0.8209755422471745, 0.8825042098256245, 1.049440147217373, 0.7630475736870921, 0.7359848040324788, 0.8432503585939003, 0.1725350891426878, 0.693931821283045, 0.9822757964254535, 0.9625840708814092, 0.4042811193094852, 1.1808466295639035, 0.21686419065437093, 1.0717598029458522, 0.9757887638959971, 0.6462960789805096, 0.0853672319842312, 0.5963050973258082, 0.565881696530458, 0.7602780411844816, 0.8400290605032902, 0.9184912077713344, 0.7367182492554291, 0.12801923236584198, 0.2691945803978647, 0.6226589355777399, 0.7840925660959555, 1.0940076908811092, 0.03185305136450225, 0.5929174776291964},
    {-0.17261972163620173, 0.7823030655917184, 0.585090104813934, 1.1227491014005249, 0.7368568778630997, 0.8833328405586993, 0.8288826349916887, 0.4967498102878551, 0.2837993179764564, 0.7845883599556336, 0.5731524464673718, 0.8281383805362608, 0.7621678038669827, 0.6881547337615759, -0.2225965757657973, 1.0634757483194028, 1.0307210172724184, 0.5219672216408711, 0.4488366418733123, 0.6005811278967196, 0.5169860546367688, 1.043783347208227, 0.8861817265877673, 1.0762314209257502, 0.6211411288016101, 0.19415667652368576, 0.8646967506815567, 0.6678604007390906, 1.0305758714250752, 0.9840948043403965, -0.041760849614635005, 1.0285265129175871},
    {-0.10995485381406823, 0.5669634363350698, 0.7786636401488294, 0.9324103387208318, 0.920267919706551, 0.9054928866812644, 0.48469430902296085, 0.5975263480209888, 0.5410511719728502, 0.8283708834675007, 0.5695889719861351, 0.6036071079692659, 0.4979715391028601, 0.582580088898815, -0.1528766338818059, 0.8771524771399081, 0.9250197917969012, 0.6244254754654077, 0.4265038315790043, 0.4010593556974172, 0.8164686599112418, 0.7033547561107278, 0.8271377166720212, 0.8039824239422196, 0.669922293089966, 0.043324936682386704, 0.5614395215762612, 0.8844027485324565, 0.7556138786384623, 0.6345275954695213, -0.009991575104994157, 0.9553359109291001},
    {-0.14362857095541284, 0.8333863933735951, 1.0009986212505144, 0.8630323394025314, 0.9294304771762925, 0.8127592513050854, 0.8664156829565854, 0.4444095761195956, -0.008263151326291894, 0.7180560737399695, 1.167280062508598, 0.7028962751972831, 0.5099853724390504, 0.8815961035406993, 0.08665198055707188, 1.0422900731849765, 0.8015270698919175, 0.8419834196978525, 0.4240070365420835, 1.0584290531739065, 0.7659619066885407, 0.8544542389333544, 1.109596255258813, 0.8266766356147865, 0.6083834831283735, 0.2255050659350627, 0.6188196469324325, 0.7315114094630187, 1.0473741712299705, 0.6386408520719734, -0.05589439816014277, 0.7250577803071819},
    {-0.10186669598048594, 0.92819265849088, 0.7957671693793009, 0.9935628920569833, 0.572131602287263, 1.1473410718151316, 0.8945476897058898, 0.22093206052902062, 0.12581853380410044, 0.9868559327581012, 0.6849085632266577, 1.0344469326138528, 0.6500646417851688, 0.5900290537353501, 0.29620182836222375, 0.6283478363925146, 0.981327761467757, 0.610637965276273, 0.14289143305812663, 0.7015066648113626, 0.594582442655871, 0.830799511873183, 0.598286864926123, 0.9198882808690785, 0.7149104386891092, 0.11021805359749837, 0.5650604551262911, 0.6950263639769535, 0.8674612734033019, 1.1385891981690746, 0.0034869812110109285, 0.7597364539813144},
    {0.1079994314761876, 0.4591442801099991, 1.0929473421981926, 1.1450363870801623, 0.8436547172873395, 0.9128678749777257, 0.6791972957683383, 0.40795797048529286, 0.5282901554782596, 0.6850704017612113, 0.8863257139051275, 1.1652722552931338, 0.5484241657946873, 0.8581785609778124, 0.21886036869006392, 0.6135089359341599, 1.1202294010529104, 0.6457464350646374, 0.2473595605896093, 0.447003300177626, 0.9128330047417426, 0.9930709765451177, 1.0063037614243142, 0.5699711976607156, 0.5260711665584261, 0.1672773148392535, 0.5866231687556468, 0.6328225435798913, 0.8326660948013606, 0.6268224791768531, -0.2934409645954555, 0.6300581145098146},
    {-0.34625766224484755, 0.8661613793481807, 0.6859682077371366, 1.0011809902988356, 0.5739262746412769, 0.618755013597375, 1.0636625889769533, 0.7545725264966588, 0.2793656275957751, 0.9597300301023439, 0.6970208825640372, 0.7749903012809858, 0.5823120571719038, 0.8455187110701792, -0.046226569784560856, 0.6364547175307574, 0.8308771479571073, 0.5903036591256242, 0.6419715466717534, 0.6177219382149102, 0.5832534349942884, 0.9458416178339063, 0.5921704189269973, 1.0073135380738674, 0.825860151573761, 0.10538056443387957, 0.5402400610693371, 0.7100128176899285, 0.8285310762706007, 0.645549918288058, -0.25778858713721514, 1.0350717739396895},
    {-0.06558150954389107, 0.7196127320184992, 0.8520381671679789, 0.6624659097531623, 0.7289044447544838, 0.8093987562763981, 0.5872056838037005, 0.8591819735510134, 0.3992604026476668, 0.8621057987702578, 0.7287137146666757, 0.6832727896351587, 0.8272553322573473, 0.9310074887665484, 0.06044365958578495, 0.9912170943374403, 1.207149821892641, 0.4077211751144948, 0.478450351610772, 0.4907616768193665, 0.5355982201743037, 0.7404594480317286, 1.2322055729813808, 0.7240063768293256, 0.8095456039974754, 0.17824802288273311, 0.8087954879140151, 0.8368017375768131, 0.7587917125114679, 0.8600589989925783, -0.2938648736205508, 0.6004716904183866},
    {0.1688718502797945, 0.8101971752797847, 0.6442638654041891, 0.7314999802851432, 0.8098092162451299, 0.9838955430658796, 0.6826433869771495, 0.5133601097756261, 0.15303191561724752, 1.0480501583829462, 0.5660049682696265, 0.3942420996526544, 0.8125638001909631, 0.1285096954471362, 0.011242316615768227, 0.8532640662609706, 0.9258151948078481, 0.6950342728808997, 0.46369114576295106, 0.18114080465763477, 0.9200100382851255, 0.9114592600996626, 0.7869679354388304, 0.9633426970861737, 0.6324298160707844, 0.151573832939736, 1.0112936425306425, 0.6166829263474993, 0.6766087981480997, 0.9697206865097374, 0.03303383915674642, 0.6424499957277132},
    {-0.2776666673346363, 0.8710309273090179, 0.9805327321232192, 0.8338940339588178, 0.8109881678751336, 0.6448635034749223, 0.9245848261345445, 0.6029261748892438, 0.3651884708623185, 1.008301681224694, 0.7410614831846081, 0.5020252020735663, 0.7449563823738303, 0.8034477290909847, -0.20426742237055875, 0.9369698464899653, 1.036282563636669, 0.40826779931636753, 0.12891661832071638, 0.9620689883672165, 0.6561707398876419, 1.1693787094356625, 0.6998817409201459, 1.0352398111685481, 0.3144220682876657, 0.4673525554854834, 0.7408510076485317, 0.9528480323805771, 0.8425335634057577, 0.9370959658290753, -0.1523322817702437, 1.1189341639463084},
    {0.225548295073742, 0.6460742142743462, 0.8786153544617977, 0.8871408583933698, 0.94086171284216, 0.8397099607905703, 0.9326361176357008, 0.5063490716422809, 0.5389724117056782, 0.7575904777869029, 0.7728429882577701, 0.8694906801268794, 0.42859848948388857, 0.501580009379062, -0.10439320189170277, 0.6984920703481712, 1.0013677655771642, 0.8700347252353496, 0.4301143195341118, 0.7439488081904869, 0.8499856753052909, 0.7185870284569998, 0.7796591288356443, 0.995889408362846, 0.8796450521917297, 0.5102958850029664, 1.1267544308804611, 0.6312641035432525, 0.5474798277005855, 0.8840437665611297, -0.006759606867204587, 0.5482742903685717},
    {-0.2810475886116236, 0.5376404070907875, 0.7975760632900676, 0.9960535947545227, 0.8808646053845772, 0.7963266310268649, 0.7003781836976051, 0.6071848251284582, 0.12607904448513815, 0.4984961141750121, 0.9054291565376194, 0.726312130522799, 0.615102569707278, 1.0172167870879583, -0.04721198157223392, 0.8461449101496812, 0.9350079621229789, 0.8601978868838039, 0.2914393360609041, 0.5386740030277403, 0.4982428204049338, 0.6703914959486054, 1.1093371837945194, 0.6784531907696649, 0.7636183281962836, 0.21168492312520257, 0.6201768420339118, 0.6328205529907898, 0.4999085159512829, 0.9808641366903003, 0.03757504567451891, 0.5661143948283609},
    {-0.05184726541930335, 0.8993240301976748, 1.2609077177626367, 0.821245226460866, 0.9541535062470903, 0.8586693423466398, 0.7125823690111903, 0.6147946758316224, 0.19211098091910805, 0.904987307221272, 0.9283176934089853, 0.8784892393811575, 0.5595547317684312, 0.6558407286590121, -0.20907232266921932, 0.8905633191357955, 0.7740561353415755, 0.6787716023941687, 0.25996889054191097, 0.964807442043876, 0.8565892773603582, 0.6428601017855747, 1.0520172597370157, 1.0040958482400475, 0.6185232717050456, 0.24152714432002756, 0.7213632464863247, 0.9716499714940545, 0.7064900001058492, 0.6621550634231779, -0.2029749839006392, 0.8049792123009796},
    {0.07371773425253908, 0.6782313370415692, 0.9664769532114956, 1.0023702977195565, 0.951825929926723, 1.0877160604607505, 0.8388483814284795, 0.811525692200869, 0.24852123930829045, 0.8941351140144133, 0.949411705416242, 1.1999549041436472, 0.7608894483665063, 0.786664991426973, -0.06382239842742211, 0.7549359897527682, 0.7647424809671135, 0.7708070184885738, 0.2749019873152889, 0.5035732594291635, 0.7826553861735864, 0.8208563664832157, 1.1106936459970218, 1.0081435188606933, 0.5656488709480235, 0.24515910306629088, 1.0084693670426665, 0.39425539457734854, 0.9776736317065551, 0.9172034618033023, -0.3240379620302108, 0.8562767639842864},
    {-0.4405847168345086, 0.7077966575629354, 1.0426553744934504, 0.5315663831089956, 0.6401644202863589, 0.8111355893817651, 0.8150314783780515, 1.032136940541876, -0.15394376581684366, 1.0436069433456876, 0.9840742046640715, 0.8504257734786543, 0.5619692911158252, 0.9307277019659953, -0.09230257856921151, 0.6774878536706598, 1.0639343472229073, 0.6842003886093561, 0.3724650466594751, 0.7700013920612758, 0.4409352351388417, 0.6448769642648822, 1.0180448880503616, 0.7908407944899737, 0.5261447666637509, 0.28900647380692746, 0.7182417332147375, 1.0362757711300503, 0.41973941708611606, 0.6315010500044345, 0.022955550603523993, 0.8417388456298596},
    {-0.09441038070938963, 0.4738141141890792, 0.35811896063056975, 0.7390562919669423, 0.9682415183204662, 0.5438362887054635, 0.599547575383759, 0.48514385613086836, 0.34190801934465154, 0.9329297490081329, 0.6969004394420769, 0.5006150929473201, 0.567721731102545, 0.5517356709083217, 0.028218313348740285, 0.8659879641865346, 0.9799606882618421, 0.7096995003550665, 0.4911432876001322, 0.5032213017374192, 0.5971074338029253, 1.2871955164621491, 0.8441026091450916, 0.48222533618751157, 0.983188536334305, 0.14189431627520124, 0.6242171913451575, 0.6136547270781161, 1.1708029060644998, 0.9639304146741514, -0.28802374551003906, 0.6846785549166027},
    {-0.2297981287413413, 0.802716036396794, 0.9947560173680038, 0.9670124481847926, 0.6015585869314541, 0.5930933080082174, 0.8671449876550031, 0.41711468654233125, 0.2614359854758691, 0.8729650334044109, 0.5774128650872126, 0.8662667028250465, 0.25250936904564886, 0.6186695455140502, 0.09420348493336822, 0.9237523110196846, 0.8249960845161651, 1.002505797032013, 0.2645034241800245, 0.45820036523199603, 0.463536676351018, 1.246472268254994, 1.119297318592527, 1.2775932738749514, 0.6123833615431064, 0.22719800713695423, 0.7982732497404694, 0.8097422421005247, 0.7655839911561448, 0.6730846627662638, -0.26745763662408006, 0.9547808794684808},
    {-0.022411063718406767, 0.5863929433926242, 0.8709930774421684, 1.123130527821182, 0.7464257638497124, 1.1120822655257332, 1.014000934920744, 0.6905859837324752, 0.3740005588589509, 0.9307944461061844, 0.7998466250289076, 1.1428040336073892, 0.557990361362917, 1.0553619976629902, -0.09626714174795253, 0.5770658573813484, 0.9417601060525932, 0.6600198103349667, 0.19292858034538934, 0.7838279123926878, 0.5645307092649141, 0.9569644243375165, 0.8404280668021535, 1.010449486645888, 0.5719108053245855, 0.31912036596049476, 0.5780634512888629, 1.0971026766459184, 0.7913437896585171, 1.3539653406892482, -0.27618284197791126, 0.9108901773499916},
    {-0.06297266301433695, 0.6896862808622626, 0.6960438747672866, 0.8806466089726297, 0.9532345329491355, 0.746552735504875, 0.8484574453951749, 0.593391030256718, 0.5676784932454306, 0.7797883317081702, 0.5439501194323975, 0.6757991568383092, 0.31784380816898933, 0.6902243122466938, -0.03789162833793021, 0.8318654209641382, 0.9540356564315847, 1.0592304037619458, 0.3245565170945863, 0.44746053146181886, 0.5311646913849503, 0.7214805082063366, 1.0783397612783545, 0.7413067782478869, 0.7625152637235469, 0.5496352779284305, 0.751196295864749, 0.8089424197716651, 1.130531940155728, 1.090352380609849, 0.0483752800398322, 0.9904612633296744},
    {-0.30263562000340866, 0.6082227306238894, 0.8988691192931909, 0.8670784099459915, 0.9046249925643266, 1.0142383408460147, 1.0682531236297923, 0.5054367404143216, 0.7094468479444906, 0.8558479629256706, 0.5653069377884166, 1.1470955762189388, 0.7714354612402935, 0.957111866614093, -0.2616549910995442, 1.2270429480315814, 1.1114974176631294, 0.8217810371359131, 0.49067005198180946, 0.8564177761333903, 0.7089263174298144, 0.852027251949455, 1.0317532236302263, 0.8599287344891631, 0.7672097842219898, 0.3385210360425714, 0.7882066358605011, 0.8119946931359266, 0.7974424398964042, 1.2405513680002531, 0.10823778813393706, 0.6953555446125596},
    {-0.14826364674702303, 0.8467073510227878, 0.7554908976975789, 0.6921669529978735, 0.9531731145571276, 0.6764172789873818, 0.6484208239425029, 0.6333779042279466, 0.5712082603368879, 0.9767113319504145, 0.8314114536267734, 0.9088391829919229, 0.4686228407933914, 0.8440343407263131, -0.0029653038317403904, 1.0457780894208366, 1.1195976904100802, 0.904182980396417, 0.21809870303498147, 0.8845451115719627, 0.2934440569724321, 0.6937664548418946, 1.100379331430018, 1.162513652854053, 0.8849624431355241, 0.3329069432552883, 0.785179733778489, 0.5241307725948312, 1.0900074739358487, 0.665094402366705, -0.2862948990595163, 0.6823502949578119},
    {-0.2867901231919288, 0.4973329938916026, 1.2353587603178184, 0.5462736431468237, 0.9916651711068364, 0.8434751983663218, 0.6696971173912194, 0.6604590694721499, 0.33579691859927263, 1.1873391024306161, 0.61229083846866, 0.5955364188660993, 0.5609291507477647, 0.8750288774085017, -0.23869270862942146, 1.0433050172171916, 0.9550363466359599, 0.6632497534037954, 6.564004340393568e-05, 0.7684239678720554, 0.6282371351875217, 0.9417911424049678, 0.9743651417914558, 0.780762836269191, 0.627685323102105, 0.45847473317813103, 0.6941825748985823, 0.5108277413424166, 0.8415120032267229, 0.8797882474995127, 0.03940961707083223, 0.7806180938656202},
    {-0.22585748656321192, 0.5618515860471297, 1.0265146908749803, 0.9181118176920586, 0.7233549851603748, 0.6257145190945123, 0.8856687443392127, 0.771289100131284, 0.41779609179518185, 0.4703051466720262, 0.9067409671231091, 0.7328293743201857, 0.5885578544111915, 0.6669221457000339, -0.06100432759914164, 1.1217065536559556, 0.7506640165824675, 1.121338723128658, 0.5273274562016952, 0.7579662269444593, 0.5938327008965499, 0.6884378807167488, 0.9358252638155473, 0.8128106158206291, 0.8698798672015847, 0.34699905210338666, 0.7992547988292239, 0.8974875474951209, 0.5822268969330522, 1.001843260897053, 0.18937510840957747, 0.5924546715742632},
    {-0.05404065012838808, 0.4473575194262345, 0.7774546346684695, 0.689586568559123, 1.0175847413398302, 1.023169142820354, 0.9644392978650494, 0.9965309055228054, 0.39845410242686546, 0.6709897378942407, 0.7324940039290351, 0.8661010818327168, 0.6496425773806102, 1.1140597060953563, -0.3054612915762171, 0.5960627668896619, 0.751674864617486, 0.6533337053671959, 0.1692214025488292, 1.0486316788989354, 1.054454876183716, 0.9748788763114006, 0.7978657604839337, 0.9358783918620749, 0.5804081548533785, 0.38446234093736137, 0.809702420229812, 0.974595227395284, 1.0172656300375438, 0.8330554263168066, -0.036404770738466076, 0.5776270184039227},
    {0.22284092277943368, 0.6433810958325051, 0.8622772962039471, 0.9241084356002464, 0.4674347520109466, 0.9985541539103111, 0.7653520279803677, 0.5839290125967491, 0.5015074590576393, 0.9580554761176625, 0.8573987508826576, 1.2197788565570304, 0.7865559860382251, 0.507522521436815, 0.05700327011960199, 0.6965622488056689, 0.9112412224276445, 0.7741297516470111, 0.5034569616939077, 0.8393125523426246, 0.6678986684096178, 0.7993406219954521, 0.9108314719666494, 0.6519665636504534, 0.5759564705897097, 0.1478489549244514, 1.015151921435948, 0.9977234478493461, 0.9568134563444171, 0.8890590260988723, -0.13026771362528525, 0.8017797425745692},
    {0.16564110437960394, 1.0435065665031134, 1.0206451878707412, 0.9558450467275099, 0.8638165674962713, 1.1488308465639199, 0.9365773283398812, 0.7199153771309084, 0.0752526242705904, 1.0656546803849112, 0.8267456812306277, 0.9170457598786186, 0.7898899702718518, 0.7736257813259664, -0.2774083234126765, 0.8197465748658584, 0.9859706657255721, 0.8866848883336151, 0.6779784449480492, 0.03697088376740677, 0.5947921605358172, 1.2522171119430376, 0.99342019378496, 0.9299830681615368, 0.5820029051447361, -0.036183653172645366, 0.6851556133756839, 0.5796735395220103, 1.0371359116545598, 0.757434892767181, 0.027893889557252714, 0.7913157759081119},
    {0.0006472849096677952, 0.6662753471898706, 0.8734999922334147, 1.0263495314510718, 0.7960606841022878, 0.9267717099920064, 0.9398065655012616, 0.6145220199159827, 0.08856544328736403, 0.8503501750445902, 0.4898476761603337, 0.7889672710220038, 0.581836368529114, 0.7442868143984996, 0.17308380210324828, 0.6547391701451304, 0.7992302057103323, 0.9665957202619252, 0.5626466557580438, 0.6503051142388232, 0.7864674285374607, 0.642316153241158, 0.8603902725669754, 1.0160831089231401, 0.7154713952286214, 0.22191784199226067, 0.6989811385468109, 0.598345486450603, 0.7697183061151189, 0.7335461386802793, 0.0011033656707210406, 0.7226946914923876},
    {0.04562890896891101, 0.8582119194432897, 1.081093507214337, 0.8346315041898503, 0.9473972709176245, 0.6229307579744117, 0.6282600051209655, 0.6435833744654368, 0.4363924773628976, 0.7467141480905404, 0.7076877830142188, 0.9343263357200761, 0.437847835624583, 0.9146726299183044, 0.2541223065261676, 0.928351337299124, 0.8815619967029417, 0.807032137785248, 0.5736646456989627, 0.6882226006385587, 0.6173667937520119, 1.0653258511239143, 1.0615315809703092, 0.9202176117247765, 0.7155829691452167, 0.12751002901077912, 0.6883083997724646, 0.9259387796546519, 0.545042742822613, 1.24481364135306, -0.16493495350531082, 0.7149679636622177},
    {0.03929543907983283, 0.9564236629991192, 0.8313951390032496, 0.8334537843323586, 1.0097237751741206, 1.0619925665399477, 0.8338199861372578, 0.23242009323698373, 0.7389756317782218, 0.7354629658764968, 0.5868903951598285, 0.4071572798467616, 0.36787046715360816, 0.7074465293340292, 0.08496066813389495, 0.6115147788117307, 0.6961308917989334, 0.8631230291919703, 0.2528062638532676, 0.7007754403911238, 0.5949062499935468, 0.7906563726919618, 1.1496333477415615, 0.8230546233736756, 0.7061647416460047, 0.1847298911585488, 1.029598143339628, 0.45502551328972757, 0.8457694479191232, 0.6921022411609178, -0.04476387561891225, 0.9971794748344879},
    {-0.2274165084169704, 0.6737166462182701, 0.9340358902785117, 1.0470161568611585, 0.9248297095667253, 0.58122283587984, 0.8280778651103886, 0.6460259217404876, 0.625451882891493, 0.8493351498333256, 0.702329934278867, 0.8463145857309056, 0.7149516239498688, 1.0107723412957914, 0.16847367444018482, 1.1978170787798856, 0.6479593403126287, 0.9732432939519909, 0.5419742013581568, 0.7501253961618584, 0.7468234644993714, 0.9367976347070588, 0.8287739388143435, 0.9924309029904572, 0.8456459874989035, 0.6572265083742949, 0.7392038390936084, 0.40191107105255214, 0.9015158354450138, 0.5552644070382684, 0.13220486592857766, 0.43502092642544127},
    {-0.26294146394155704, 0.8179548111584243, 1.2122528108408173, 0.7764382536087802, 0.9546728109961946, 0.8530909002064186, 1.002318406720833, 0.6082055121499418, 0.40992401611699325, 0.7502605584451174, 0.6497777571939368, 1.1083803186783374, 0.6588996916790082, 0.6667369242984811, -0.09131684089396139, 0.7085806814738607, 0.760181582032477, 0.8775598227080732, 0.49236288562580716, 0.741875034816462, 0.6051876040261361, 0.9610954231020331, 0.6088599785283951, 0.6866704498882779, 0.6175043996565127, 0.30238106259714587, 0.8444356489155589, 0.5698193158834387, 0.8134335858793987, 0.6919100957505578, -0.20166012342323428, 0.8014412738752441},
    {0.3061071236598104, 0.7931367011458251, 0.8013018481093919, 0.5055809903460434, 0.6082127730079491, 1.1775939826833142, 0.8461488672959916, 0.7236563566759853, 0.34137106765934616, 0.6177034269335426, 1.056684807132896, 0.9936551783034114, 0.8245122917675171, 0.6860437765820566, -0.1531651710747907, 0.7704697073882892, 0.7767544654356587, 1.1126422066004191, 0.22302178921799098, 0.3940056993359726, 0.6334241055482553, 0.7256536266357198, 0.8964645252132201, 1.039329458617989, 0.7479429367638798, -0.03607939218550976, 0.7112922659260575, 0.5675638630522231, 1.0652289299896767, 1.0443751746431196, 0.08685171567832892, 0.5187421860530262},
    {-0.1679421738353183, 0.7141906709384982, 0.8282402144993674, 0.9858587276168094, 0.8131632482821373, 0.7619802121144447, 0.8476724842432051, 0.5105066112946787, 0.41194569267048364, 0.7147056104581225, 0.7457302054860572, 0.9318232487798666, 0.5296892787228428, 0.976734264115593, -0.33149249736205116, 0.8507441853147175, 0.8624715179594329, 0.5870648498982799, 0.4149395240213371, 0.5419150186776199, 0.6010724603534243, 0.8636245645520078, 1.0341258886821134, 0.6148423185987436, 0.5838004161832181, -0.0015274817815376304, 1.0711269139990356, 0.7519962058343174, 0.9398415941622806, 0.876826093767018, -0.15034650610955938, 0.6803364746322262},
    {-0.0022979089016306885, 0.6807696334092884, 0.9156030915278188, 0.9189307855692082, 0.7314103981686797, 0.8650920893034493, 0.7895438556864879, 0.9713416285654907, 0.5267502008124848, 0.8173006124132426, 0.6617664487063283, 0.9992850467115669, 0.5533428196236312, 0.8259776572480466, -0.13663519686206277, 0.7559958679934521, 0.9157757368094345, 0.5679542033647059, 0.12664994030142854, 0.56966439275089, 0.6947532317890054, 0.874130881253884, 0.6400705466767893, 0.6420074165140615, 0.6731997985629423, 0.10343986208525222, 0.8849121854159396, 0.7957739903823959, 0.9411980111434572, 0.8452290569071662, 0.3535852542975288, 0.8308807009383476},
    {-0.06960631792892304, 1.113985529639881, 0.920332865346673, 0.9591668070922165, 0.5822563321625284, 0.8526197113022906, 0.9045028435234298, 0.8991313820398512, 0.41138259635992475, 0.9080630593881068, 0.7413850554482219, 0.9368712794988062, 0.8991853690175381, 0.7947264097717371, -0.12282535748270106, 0.7442632552953826, 0.7661039074423834, 0.6982593166491613, 0.1598960705339583, 0.5452612969471465, 0.8077135146576123, 0.84286909621392, 1.1444201167232637, 0.6500315877369569, 0.5102584074066543, 0.3559140254282211, 0.671855080022213, 0.7326202964180544, 1.049648276597451, 1.2888005108840814, -0.018042886810086308, 0.6288802866308599},
    {-0.027103484614109347, 1.1212190703199965, 0.9933061288081126, 0.8220918459568962, 1.0770549027438008, 0.5450307607366618, 1.0218802446867417, 0.7933527885312363, 0.05133682800423226, 0.8259145712154944, 0.5878132630733494, 0.9717245570669157, 0.7429410923956326, 1.1324320608906995, -0.459797251224774, 0.8894814664099009, 0.8526537242173091, 0.9656529883632776, 0.5656551287303709, 0.5182763072804243, 0.6888083526646015, 0.558727251397839, 0.8440766979090369, 1.0754493265785867, 0.5635574824695343, 0.11201274691064349, 0.8811440228946169, 1.0932056721340877, 0.7583474159073887, 0.9044376040527319, -0.4839023375274309, 0.7405107363828961},
    {0.12415092660830361, 0.6674157010783337, 0.9986414173708078, 0.9587262553357739, 0.9245068361533292, 0.9388454801211252, 0.4978349310037712, 0.5939935951125375, 0.3503652992663688, 0.7218916870282122, 0.6804393680361911, 0.8183814246607972, 0.7647084853258701, 0.9747820678403686, -0.2485367090929368, 1.175795660594573, 1.0555929525863639, 0.8237855549093798, 0.340779520574208, 0.7344010648759836, 0.6363834422811696, 0.9206991188713146, 1.08444662019951, 0.9520275664347884, 0.5969741436125164, 0.2049361577043075, 0.7552736069570614, 0.6661579271984983, 0.6821879374452711, 1.2756093766088146, 0.20620262086590668, 0.4439147653847862},
    {-0.26502082848143416, 1.085426298783822, 0.6072186411565367, 0.8791362596629817, 0.7583208300522603, 0.6089099066485039, 0.42602336797146706, 0.8820094361741789, 0.5931351008388981, 0.576101676192392, 0.8957870299810728, 0.7086910205579271, 0.4185745414466934, 0.6190264986882222, -0.313894242708411, 0.7822760115887997, 1.0310350558526027, 0.5590631827841512, 0.2442627032719755, 0.4840252684305346, 0.7808662086635124, 0.8325145685426661, 0.9142612751764495, 0.9893763499946557, 0.7827223443538462, 0.08007895029092839, 0.6911859311147548, 0.9069810828588256, 0.7607521554173468, 0.8533438885676321, 0.10925723174916777, 0.9858745131388279},
    {-0.4654465712253683, 0.6886844259147556, 0.9968530220810831, 1.0725647055623004, 1.2113494741625304, 1.2762229711012432, 0.5110397140691705, 0.6010283531012376, 0.2015100083592501, 0.7751799500001434, 0.6533448434313616, 1.109229095073334, 0.8363905291451897, 0.9453295647586438, -0.04810979857850837, 0.8437040256762661, 0.8120348765842574, 0.6815258500520923, 0.4139389000993227, 0.719774622044007, 0.6656902643629693, 0.582889520986589, 0.8227757908309588, 1.0318755297486495, 0.6117090458229185, -0.04184571531015756, 1.0346728895006643, 0.6765314209931835, 1.134404187885249, 0.8443396701525618, 0.2638582876068436, 0.9115497935349913},
    {-0.02809876399886203, 0.6193176894427963, 1.1451385768563187, 0.8930518718971737, 0.6800570204524679, 1.1014880071358777, 0.6938567961211766, 0.5938049326855795, 0.2195109407814275, 0.5915295362827178, 0.6880754495008536, 1.050017921669025, 0.563279084050583, 0.6981227920115709, -0.43410025335813723, 0.9139493526082447, 0.48467512920788114, 0.706236893752489, 0.4546209523955753, 0.19831049307693524, 0.7536237386543245, 0.783149208116882, 1.048725401180383, 0.7713888932558431, 0.5729198727302562, 0.12229729116076266, 0.6290486305625382, 0.7870090395565645, 0.6178214990801079, 1.0594919344984615, -0.15694140982197152, 0.7116817694240846},
    {-0.05922821314064441, 0.7780981756493368, 0.5295842724583567, 0.9731639845971455, 0.7579547581571401, 0.8996578331136769, 0.6388969807062709, 0.8069381166892389, 0.3141300894786159, 0.7441748133540648, 0.5303236395109815, 0.7001717727118288, 0.3854287089151488, 0.8539201299098649, -0.13505516027941858, 0.9133616656833771, 0.9732353831652651, 1.0093730340386118, 0.028837889400264757, 0.8992062018282998, 0.8296244236315068, 0.8750818169493251, 0.75473025842513, 1.0048694354253742, 0.4785890477895733, 0.41080920657081904, 0.8428773883028872, 0.653047134683109, 0.6894117614240702, 0.5872152095280093, 0.05736706409792251, 0.551733530393395},
    {0.11217994793438277, 0.774268836203693, 0.8606175369012213, 0.7894626905402782, 0.9973314325595868, 0.7223403690707844, 0.8786632916094582, 0.8902221058863561, 0.3158461953969767, 0.6876185542572821, 0.8261833856515897, 0.6349505164039149, 0.6841942458910465, 1.3013436721038638, -0.107211116559714, 0.7158325523051982, 0.7177359078909626, 0.6293076454421944, 0.45588757938352764, 0.14542090906875257, 0.47008320371767814, 1.2648539700517554, 0.7116240914285635, 1.0318289297856487, 0.4443391303804401, -0.008359075454365586, 0.9010621701636515, 0.7178109403641867, 1.149647349045167, 1.043980460875428, -0.01618923033122875, 0.8781380230427672},
    {-0.10728736019122459, 0.7408293831659448, 0.9457206145306949, 0.9806017423068715, 0.9092461270750423, 0.7696000782075337, 0.6042829952638583, 0.37171867293459643, 0.147248589825123, 0.9435889707329347, 0.5923654145309634, 0.943919131427142, 0.3898481266084765, 1.0890691422809018, -0.057281877792279584, 0.8491307552741039, 0.7241934926155167, 0.7244505535133522, 0.5021310756083587, 0.5318197186221133, 0.6879030546009274, 0.7144807670732226, 1.0838614097481172, 0.7582934879205161, 0.8469322719606691, 0.11629260257058763, 0.7723719782882718, 0.8548086736273713, 0.845241814820919, 0.9164790979810848, 0.15670693404198963, 0.5609837503085422}
};

static const float b2[32] = {-0.1185495913151759, 0.7471045454770405, 0.8766258165277652, 0.8772968483937086, 0.7467532338846788, 0.8233910518033879, 0.7344503672513432, 0.6730047347844345, 0.4669755993508218, 0.8779361790235626, 0.7913278455681814, 0.8750190030118508, 0.7061398053223938, 0.8423905047271729, -0.10243980346097466, 0.7973561032326028, 0.8768304574082362, 0.7830775943366123, 0.53781875764105, 0.6786255986624791, 0.6395548671214938, 0.940777660770576, 0.9134532312040528, 0.9146147462158495, 0.6592526823513188, 0.37593052992819753, 0.759740700528863, 0.7516186087005875, 0.7971820248251372, 0.8268917939578706, -0.017526464832813247, 0.7055824049128726};

static const float w3[32][16] = {
    {-0.26006785244991515, -0.4968714370421327, 0.6065103177618764, -0.017237346775917255, -0.7978920387819154, 0.016861561267041233, 0.3150006699901293, -0.2362918450206913, 0.19075331040170054, -0.00041694852947898815, -0.5143562343027541, -0.1488997983323221, -0.04222777297987489, -0.10793432767182613, 0.3119055461619496, 0.02745473359630175},
    {0.4739172887858697, 1.5876067966782892, -0.19993053967727428, 1.241891439901223, 0.767005088769437, 0.06931902417209022, 0.5328611373732124, -0.0064209038040085745, 1.2646736132738283, 0.7384969451771743, 0.6670404626754753, -0.15362741473700586, -0.034349417120796935, -0.013041574156425262, 0.04163945196751212, -0.17114376462578446},
    {-0.2488636053653359, 1.2107330228072408, -0.2649046420402995, 1.3839649394230302, 0.7053044364802151, 0.21766575198915813, 0.8710999398817896, -0.028427653869258936, 1.4642922383054373, 0.7581184019681126, 0.47973363703178157, -0.23900493674486695, 0.4059316669103855, 0.1167048078558418, -0.15401495069453078, 0.269909887959995},
    {-0.3054850994519763, 1.1149233257454125, 0.1808586675829746, 0.8924977483332854, 1.2666438263237423, -0.5283943887759401, 1.099985726202103, 0.4887133377915443, 0.8599123152776513, 1.5505333571979698, 0.14791639829856087, 0.3238601784221811, -0.4827985160646547, -0.03290571696035698, -0.1574424009839787, -0.0334945715194154},
    {0.34482900630909596, 0.8161832837413037, 0.013073213672387871, 0.8813299037622341, 1.2602867840185812, -0.033596440503863866, 1.01411732761997, -0.2901327303943642, 0.7338010415779275, 1.3378256645385864, 0.7545649647846142, -0.13940804074104832, -0.4618273194247123, -0.2098566068000138, 0.3547790377829809, 0.10788432371449057},
    {-0.17120630592849026, 1.1815015474199833, -0.17954049344284043, 0.7623738292120513, 0.7452918664433594, 0.06378711096134453, 0.6627571895572021, -0.4095679683198222, 0.9395787757034729, 1.0485913832972338, 0.5147828223964802, -0.4001234975698335, -0.33404888406618294, -0.0010005422864945769, 0.137576210156918, -0.3060758434744265},
    {0.04790947506391133, 0.6390504647440786, 0.11795452456483968, 0.9381139593704976, 0.6206633443504811, -0.29318643863389593, 1.1463048310373423, -0.37433572803269016, 1.2848040823325029, 1.0700795369858966, 0.6370950807354309, 0.06312645449776771, 0.2538699158413922, -0.1041603799635435, -0.047645433257975836, 0.15964392827777674},
    {0.42059891064252936, 0.7356041388891549, -0.009312980959668751, 0.9485955722738564, 0.8159364923850576, -0.30917693510409966, 0.9416429411719186, 0.490946514865535, 0.803998783627619, 1.1024768694143952, 0.31782459418518355, 0.11098459365724515, 0.23680429383330678, -0.12713666027359466, 0.20354331537540538, 0.2591093740370573},
    {0.09831569299598385, 0.5671969365598689, -0.1300067788411472, 0.7537894987546103, 0.6381756454439452, -0.2661909102150129, 0.5671590382878865, 0.22111699705798046, -0.02616643342049778, 0.7545535795076926, 0.6706087912565221, 0.1025199401995773, -0.04672765705762842, 0.09732106489107045, 0.10388092108687287, -0.42853830205208965},
    {0.24815257585606101, 1.3845776646016106, -0.22038952909264636, 1.1105160725321743, 0.7740324044409302, -0.18544630085334846, 0.84076548463351, -0.2907181994724098, 1.1752956400257946, 0.9161766368001975, 0.9618081791546027, -0.1829410236372135, -0.275524746734216, 0.15067022921248344, -0.3447746494421188, 0.14086814967221906},
    {-0.5789694614650895, 0.8607667010465623, -0.014623245401991024, 1.114882218166922, 0.9655798188175105, -0.29636700117059284, 1.1173162754989086, 0.09713973371526809, 1.000332824972405, 0.749797274863423, 0.7456127386206999, -0.9589024471486914, 0.43288174729574863, -0.46877751149638053, -0.2986251564117143, 0.3091654910235341},
    {0.24246682398685532, 1.3749538945595916, -0.23783263625292603, 1.561658231276292, 0.33529489130093365, -0.17330614520717857, 0.733502238343175, -0.02584165840859415, 0.7480612219293218, 1.1709755873298353, 0.3779134989568879, 0.24230828966824552, -0.23597869699935886, 0.0625606318652618, -0.4844753402927951, -0.1770844572940011},
    {-0.09430838439454199, 1.0471982548414775, 0.10404007452389481, 0.6026202459988615, 0.5970415481169584, -0.20821047982110347, 1.0328670528753296, 0.046351971402734414, 0.6120323877922623, 0.6460663142371026, 0.7540469211594372, -0.24413616304361976, -0.17011633600784892, -0.03873145213923966, -0.1293137555151623, -0.03473597405971035},
    {-0.25513322442389685, 1.2041733902177696, 0.19913770066762998, 1.3168633766359832, 1.0058599450593926, -0.022409358566442997, 0.7591087929732678, 7.113757652549895e-05, 0.877825219190867, 1.0323749729409166, 0.3287352312865777, 0.05366412426127339, 0.08349315187542057, -0.24104250367163918, 0.4549711122444975, 0.2368570840784394},
    {0.18354467130592206, -0.08505804777639024, 0.30151071718830696, 0.3405077774137834, -0.15577066456447025, 0.04362035151488053, -0.15266037393894483, -0.01383124191102838, 0.05585628808011468, 0.13478594882224557, -0.08279388595176972, 0.19559568411186426, -0.49845527734778483, 0.15172479624621787, -0.11086951106177857, -0.37814343666863137},
    {-0.08511924025835915, 0.7478459000200297, -0.15207531111356434, 0.7648938345598807, 0.932153053765134, 0.14348896942403386, 1.0039594023898508, -0.4671604070672878, 1.072347215780107, 0.9987087915651542, 0.7039930122383693, -0.15805385548159157, -0.3732284699902545, 0.24652949913213593, -0.5780736553467237, -0.03334489530832735},
    {0.032498876306543495, 1.3097484705833529, -0.253957940055783, 0.737405343437749, 1.1054380031649482, -0.10461059408224942, 0.8695801387984262, -0.010199086597024258, 0.9020294112058046, 1.2684399783468685, 0.5685626837024087, 0.11446643836063637, -0.40707347169611474, -0.14408299203013852, -0.0836391941113275, 0.18604439719207522},
    {-0.12106598766687514, 0.9860293839532109, -0.25602467005210083, 0.7497811130232649, 0.21801767701684321, 0.07781471171308808, 0.6499343368667262, 0.7248194926316327, 1.2700036083848545, 1.1681334543657027, 0.47114532733638576, 0.14582891943516582, 0.10594020183852881, -0.022169434204515164, -0.17459589004491927, 0.040013229353465934},
    {0.3280453304561193, 0.5697979898710088, -0.19742858682252307, 0.6552123239831084, 0.9848867400989294, -0.13767821366796584, 0.36629430182311584, 0.030447648777329674, 0.4710056441997573, 0.7511093137185235, 0.6273956801432639, -0.06845546417812044, 0.02987613718493593, 0.14512676459360208, -0.2130259919317037, -0.18765256468282993},
    {0.18797487698877763, 0.986404474352946, 0.47316553497091246, 0.3396223106779303, 0.9821315817134934, 0.3258409610756774, 0.7826272592176349, 0.38111541533151827, 0.6935149922285235, 0.8444004013540836, 0.4437475694142616, 0.01606767548000221, -0.05445164193308104, -0.14931745982168926, 0.43551509243367037, -0.8501485202477737},
    {0.3755620449380112, 0.2465620232633896, -0.0018859929597382795, 0.7326570960481206, 1.0225275362550188, 0.041623500447956804, 0.8358484703289867, 0.09984796622899443, 1.0085711624490308, 1.1012369082088331, 0.4585424180920759, 0.04606289206824679, -0.08179540415360552, 0.09247317526328329, -0.06619357445860155, -0.23841169357833666},
    {-0.04879515078872813, 1.216760018661778, 0.14519026738442456, 1.3557650685336164, 0.9754068227182908, 0.528712018663179, 0.8853924544001013, -0.06341808703242224, 1.0211946507453697, 1.1587494073363012, 0.43304097928938307, -0.02821638865270277, 0.37170545703256463, -0.29557484848997473, -0.3034283103944091, 0.03108272324101631},
    {-0.30347652562629895, 1.012566544219001, 0.2514817665995984, 1.1479932723942474, 0.8860267784552794, -0.8005168305918945, 1.1125846212548298, -0.058258043704301266, 1.1714323310674004, 1.2132333703170308, 0.6668030039866134, -0.24399680880736874, -0.0002796430909825355, -0.4171603996102999, -0.5133970963719137, -0.11556940397097736},
    {-0.14087424127067374, 1.0578248711785028, -0.06889154942783483, 1.348907898542197, 0.6423068330722608, 0.07099872914439977, 0.5717677046791205, -0.2541087208065458, 1.2168762164563458, 1.289335877964117, 0.3292870262420018, -0.09445459023177326, -0.08670485414055401, 0.09198045592943214, 0.09018761515353936, -0.194934540858285},
    {0.32329574820743, 1.0122557070008043, 0.5603920669412991, 1.1843383957396043, 0.9817723058872225, 0.15323603991497933, 1.2533757133447918, -0.3730987632564837, 0.7568735540432506, 0.5400742136116443, 0.5045016575196076, -0.10400640067141989, -0.0703992291357937, 0.20437617530425015, 0.011978764491023954, -0.15933936098099857},
    {-0.1879519369458314, 0.22003806530187303, 0.1991244268088039, 0.7941392286688378, 0.4042860298328521, 0.14703561664638815, 0.5744798107455203, -0.27870347151598995, 0.2747336013811902, 0.4181539812130701, 0.11814716760070842, -0.18315392088228588, 0.08852310489849521, -0.37189794488612743, -0.239505264447519, -0.10307263384986375},
    {-0.23168762640250518, 0.9525305048404211, 0.27730325568325503, 0.9468169698568568, 0.8733445597613394, 0.0025604559278126294, 0.8062068906861152, 0.07790792971036897, 0.9304419091431713, 0.9838465022619242, 0.2644168987384417, 0.05298241611729648, 0.36055350273223163, 0.2671386230901357, -0.011098860533576943, 0.10985145111201472},
    {0.135709171525832, 0.8011121373130805, -0.11827340677237148, 1.1491847653861391, 0.6272914669985699, 0.08909776207655414, 0.8282978723265914, -0.12450043568300756, 0.955865518335049, 0.8216971194261157, 0.3900527020977817, -0.1599554837614491, 0.049965377381421226, 0.08530094377968296, 0.08989811978083069, -0.1573182528231967},
    {-0.3043489959789532, 0.8337588585468597, -0.1605071491868784, 1.032263683016136, 0.5708047772249536, -0.4842809999620291, 1.1501001277333807, -0.1610344836761241, 0.9514155051377371, 1.1967107182727734, 0.01705045110632703, 0.0319252326572168, -0.0012583823527397597, -0.027595385284450415, 0.25247211796608426, -0.271828814278448},
    {-0.29203491845459617, 0.9743374976406654, -0.5052112088673103, 0.9118781603879911, 0.8343125995925383, -0.4713189973685104, 0.9813466242650132, 0.0282625585377737, 0.7812299058778, 1.366235195505005, 0.04000090118259537, 0.12046529487638309, 0.06057636423471821, 0.15435477141698756, -0.1600648117958675, -0.039994208136558795},
    {0.2804991769342742, 0.3880942223724627, 0.3004795493109849, 0.0013599721644125499, 0.33259442164303793, 0.2739770629911365, -0.15857469003511968, -0.05436798150570254, 0.013365306245501425, 0.07231956312300121, -0.07787581993508667, 0.39194542108155567, -0.27901041632162976, -0.099120598840542, -0.2756053570645195, -0.2794453071396327},
    {0.2626231541819819, 1.2538286298631387, 0.20482722949895646, 0.9230103932738701, 0.5938995379314003, 0.18077629627360592, 0.6733536775911789, 0.3436073981756916, 0.43739226610311355, 1.1830157649780972, 0.5426852523002308, -0.3132476274881819, 0.10898497405563419, -0.08944465686368672, 0.13759724235463608, 0.07567035459304769}
};

static const float b3[16] = {-0.02126835106005308, 0.6364050865691583, -0.04097449604041495, 0.6544472645473247, 0.6159708716320863, -0.027981785799300676, 0.6259695373622368, -0.024884813850366883, 0.6463468785623888, 0.6838352934250992, 0.31322104447352145, -0.04361586642380744, -0.04534386555953777, -0.02851698715630098, -0.030630797674175314, 0.03141756987190985};

static const float w4[16][12] = {
    {-0.6337847050800479, 0.7388274165456206, 0.17062471120680975, 0.3989390224310509, 0.1858432103478282, -0.28648510300356406, 0.46228690759061664, -0.58101942270062, 0.25257137823661, 0.14364737106507316, 0.13415813758146367, 0.6396695087154628},
    {-1.0925865433565811, -1.2982843655270675, -0.8807486025912997, -0.29041564933520964, -0.8285081272986481, -0.3717157958224225, -1.0839050154158882, -0.8350810482571287, -0.45784851221953227, -0.6200650259242186, -0.7145795290941437, -0.5754695598666654},
    {0.0933703992123467, 0.016998710744222528, -0.3463658764680622, 0.5143426443731918, -0.3550139758558046, 0.3667972408183706, 0.043795060737424056, -0.1983002267748515, 0.6209234863413662, 0.14689203985722327, 0.5816828725708209, 0.2799656073128528},
    {-1.223783501233998, -0.5589451868659608, -0.5659397843502901, -0.8968315937403208, -0.9536756126170035, -1.0366570555860168, -0.4230545469975518, -1.2864150543545918, -0.4858633942182474, -0.7803562251770835, -0.8411374128475194, -0.3112391787089094},
    {-0.6664548197255546, -1.4137911286048803, -0.7508865556409644, -0.35995506718488024, -0.8003048498710468, -0.6895092261576361, -0.20298870494870833, -0.5485134845751711, -1.4717394798197905, -0.9361587375437256, -0.48544274949561694, -0.4273771744944573},
    {0.3763239623427741, -0.03179802820043268, 0.02995202192830436, 0.04602431945484504, 0.17538893343473216, -0.2250430998048541, 0.041514169748157824, -0.36631913052476534, 0.44541732984976184, -0.020095214009724034, 0.04413994271748785, 0.0241933302447203},
    {-0.88412135834798, -0.2640122761165487, -0.6138920404653909, -0.6578933514563585, -0.24820851790062756, -0.757466869759071, -1.4610701324602395, -0.3585471654200052, -0.878718679820205, -1.0996750148877341, -0.6385002045979847, -1.3584632011367233},
    {0.29051773423612337, 0.42904535320420045, 0.1264558204151604, -0.5089463832561261, 0.27642538895007135, -0.46330989826352115, -0.10368221729881019, 0.36764244174978605, -0.12834149141601836, 0.7650213324693111, 0.16275426863883308, -0.11462178461126155},
    {-0.4053760356137734, -0.48619070498020717, -0.8605050026198753, -1.2270516325895189, -0.5299937656851866, -0.9685100573191839, -0.44192248044862936, -0.4377745403063892, -0.4965794482318275, -0.7019748661608185, -0.9369874644468991, -0.9551938676090055},
    {-0.4499258264138413, -0.3736738684039018, -0.44694297739977995, -0.9372457865119913, -0.9506584496786534, -0.41167845829818306, -0.8573925596772825, -1.0051063292348472, -0.8597250883365223, -0.5768521903262867, -1.009195434767735, -0.9476904881602375},
    {-0.06998600703275915, -0.44256119952306905, -1.0147192791470776, -0.6044920228995689, -0.7148734051113325, -1.2933712284319885, -0.6469796103178416, -0.316474890310449, -0.5152144694348849, -0.1757756791178421, -0.01911278031157638, -0.38320688121745017},
    {0.36630832581569184, 0.4436068072719881, 0.42536700114810105, -0.025662643259037245, 0.5457418480331758, 0.026981018412693618, -0.3949444204954657, -0.13205350065428104, -0.2117788771524636, 0.00709906509288636, 0.07837945871453442, 0.38621861693324316},
    {-0.49076806820203184, 0.42221058337578626, -0.05129011858787763, 0.28615101198430754, 0.037863369190155746, -0.01562604440455283, 0.10754968235093329, -0.42355343648178656, 0.5065185592773028, -0.6361344889203667, 0.40263126346374895, -0.37402119488631724},
    {-0.09614929042222405, 0.4652768356742914, -0.1596791799893482, -0.11207420856885114, 0.27861146467177716, -0.18645564180574406, -0.4793033106160437, -0.28844544723838267, -0.4930862459350306, -0.267751352718509, 0.28481844467211576, 0.10165803234976263},
    {0.173763478900535, 0.11787540713104713, 0.21666674080710893, 0.62557626985124, 0.4872512807627543, -0.002488367581123473, 0.5011976495919626, -0.2307020083467177, -0.06413157607762203, -0.17677900718525769, -0.3002373543998517, -0.0825216973999946},
    {0.08764099118535008, 0.21850378742738877, -0.28122132852461756, -0.13929646409461924, -0.33282470824361815, -0.31206898874317, -0.43835398158542194, -0.0022854942025419384, -0.22085418054815537, -0.6003665563988824, 0.3733275813121252, -0.33705584207556016}
};

static const float b4[12] = {-0.17340165345450714, -0.24860044609663842, -0.2725299399921832, -0.29273928185904086, -0.34554639841632934, -0.20634159919262274, -0.32767227973329277, -0.21450089707735132, -0.1917957028804793, -0.23786789363653696, -0.33057466455501017, -0.2857152861094743};

    // Input Layer 
    float z1[64];
    for (int i = 0; i < 64; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[32];
    for (int i = 0; i < 32; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 64; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Hidden Layers 
    float z3[16];
    for (int i = 0; i < 16; i++)
    {
        z3[i] = b3[i];
        for (int j = 0; j < 32; j++)
        {
            z3[i] += z2[j] * w3[j][i];
        }
        z3[i] = relu(z3[i]);
    }

    // Output Layer
    float z4[12];
    for (int k = 0; k < 12; k++)
    {
        z4[k] = b4[k];
        for (int j = 0; j < 16; j++)
        {
            z4[k] += z3[j] * w4[j][k];
        }
    }
    softmax(z4, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
