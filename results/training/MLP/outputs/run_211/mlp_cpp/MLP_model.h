#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][64] = {
    {-0.5197629796675466, -0.24558044199959683, -0.32462680074211075, 0.6478058902322079, -0.6044335864264617, 0.3498843511143963, 0.17060459793265195, 0.373135654775985, 0.41858030891449494, -0.11089546233594541, 0.42101748957257157, -0.34954147695988586, 0.45537080080029835, 0.7480583944159351, -0.026876203489211613, 0.4069278608231309, -0.46018265444775486, -0.22142017502476793, 0.3170684284100249, -0.21479871462253497, -0.44525878063559016, -0.2529634140668658, 0.4756185764874802, 0.5128942766006034, -0.13357624296715023, -0.07046474158081871, 0.610528923570579, 0.11026294119746945, -0.17154917399199907, 0.46983319046733213, 0.6847391512370082, -0.5375963591943455, -0.3712625075446433, -0.16675041075389527, 0.38223864129069846, -0.3123170534336864, -0.5989297767203794, 0.28817739411804927, -0.3855994413888041, -0.4089085889331455, -0.3717865376500926, -0.2894576659083449, 0.3448963423071, 0.1672971177395753, -0.3580025324550177, -0.24804033484420226, -0.35722173738459395, -0.2103680462135274, 0.7740273612755084, 0.871235579442421, 0.49380565526261444, -0.35681376967058615, 0.49986591371819666, 0.6792007193407616, 0.034626284391526256, 0.9143050193636565, 0.34149306604604196, -0.04785971196433605, -0.17473447711375428, 0.19930016201980041, 0.4203486055705843, -0.30767888065269383, 0.5632646305753818, -0.012054021898798534},
    {-0.755083914545769, -0.6995772470521534, -0.911832977084584, 0.22574905110543714, -0.1871011644033723, 0.6696631909762242, -0.17158821203474597, 0.6138400461364065, 0.5874109355091124, -0.5578463161953718, 0.5750664832268474, -0.5877958554999737, 0.7761381302396925, 0.6552532595857443, -0.7628430940973786, 0.3366584946964418, -0.9241234470105631, 0.04569993160568555, 0.5214652866262431, 0.22118258922369216, -0.5896581424907581, -0.7723660761600153, 0.6929250290513217, 0.6208845406054847, -0.5680928880868135, -0.09776889345931206, 0.5087403838820991, 0.591408440972395, -1.0273787391551257, 0.6538318901969788, 0.677215942566686, -0.5596141146151523, -0.16810029731232043, -0.3643317112171501, 0.2500877113636494, -0.5146913836464022, -0.8324253478590777, -0.19197389838669404, -0.7791958945324086, -0.07930813280264867, -0.4930507179266512, -0.5522924598818285, 0.47049224703768006, -0.00913920819104994, -0.6755552774577075, -0.48844904839316894, -0.5893795734663569, -0.037076743107424516, 0.47584959668825766, 0.6611135529324015, 0.6661916081828758, -0.6220563323760843, 0.6520675575223828, 0.6441255606009756, -0.12181626015996255, 0.6511516638290643, 0.29981316018094467, -0.4931702330511654, -0.019625281948633725, 0.4308092563266837, 0.4408258126156841, -0.777047116278025, 0.40094894685002197, -0.40961069503276115},
    {-0.8373184627664471, -0.34670809062740365, -0.7721131496094592, 0.7599873428294854, -0.5915150737058468, 0.4938373616511249, -0.12237171494503248, 1.0547030308875918, 0.5946270741498033, -0.27039511377546205, 0.9576168695386564, -0.1916105871393187, 1.0141618785856954, 0.8241146850954048, -0.4842733194960939, 0.4853804220657182, -0.5806906132652291, 0.11057462454987554, 0.5968868212089854, 0.2578353883930499, -0.9249959848937586, -0.29829978989213746, 0.8325065986322417, 0.6899444367062082, -0.6027114479949963, -0.1285834112252808, 0.7222847838288531, 0.6643051255654278, -0.8495435873415216, 0.7978576355898683, 0.7955402787471226, -0.5350527447548756, -0.2692661777071, -0.41001112629649833, 0.24197531634922403, -0.5090025028958897, -0.6448593028730867, -0.1039139082106045, -0.8239227054269355, -0.22277000990637463, -0.3764444879976471, -0.3375625754078533, 0.34728432497575656, -0.5002217884554655, -0.0843130693584753, -0.5787756968055107, -0.3134024257363712, 0.09624954673337414, 1.0120596773631607, 0.7595247231769663, 0.7334763868249764, -0.6943135949240706, 0.7591850062267954, 0.8501687803839596, -0.4639310681548045, 0.9862707937749117, 0.10689492430282849, -0.5848252788199826, -0.0011970114564225744, 0.7060872133048949, 0.554025447070989, -0.4765046529315041, 0.7451744185445298, -0.4868313673607281},
    {-0.800564740338451, -0.7406196745992278, -0.6710102290576585, 0.5181005464602768, -0.7289419365934663, 0.33589380133982727, -0.45765996361402234, 0.6022131779218679, 0.817024940333163, -0.7409598075849751, 0.7300769897090489, -0.6643032359341537, 0.8445649950744412, 0.9220390702498151, -0.7405228185663287, 0.3019333020170086, -0.785341850570468, -0.05607442677146505, 0.7815422634467935, 0.20907293476944458, -0.7484458320001404, -0.7189822993864315, 0.8323301838961522, 0.7488682872974131, -0.6635320524297021, -0.6943533079539728, 0.6611997977774732, 0.3037239358084806, -0.738986550360163, 0.9649749333926566, 0.9181894378691543, -0.39572549994746675, -0.25317798684160064, -0.5439342715449793, 0.5079968335430206, -0.677004266248959, -0.6938672303816518, -0.5798373721242132, -0.7229927368853656, -0.20328837601540628, -0.4816050222069738, -0.7107988888689736, 0.3140048401327715, -0.706160228038385, -0.7473365845912879, -0.585095814054579, -0.6216082494388255, -0.26547018314304494, 0.7150282520471407, 0.8722567101676175, 0.9346812831000191, -0.9259324642027551, 0.704068967379925, 0.7434974624118099, -0.4010061369539043, 0.6578141867710465, 0.17835255407198516, -0.6753768908393569, -0.09689995609938977, 0.5131214940313186, 0.3900460937822696, -0.5035261775828189, 0.749332999203364, -0.8885688059961605},
    {-0.788404235074516, -0.616039081173985, -0.519317337645476, 0.4729633259467544, -0.8826341209504813, 0.6170064624362094, -0.47963153399486097, 0.6193049988715993, 0.13096573949265541, -0.8415765633530919, 0.5469334575194328, -0.5165435000323376, 0.8578306779879818, 0.8188264193280292, -0.5977881313520478, 0.4325259068461749, -0.7929936691568561, -0.2735078428708269, 0.7203792740122129, 0.22043325720463441, -0.657388234806509, -0.37478079036773165, 0.698789436542656, 0.5607414792895897, -0.6742456899256976, -0.45535198241068237, 0.3849046397128575, 0.2903585571930209, -0.4810564050887176, 0.5474133741271905, 0.8360582658650889, -0.6465927863665363, -0.6081743001416385, -0.4925525976941073, 0.21635704341000944, -0.39695755928471604, -0.5602213715617046, -0.6550063514250034, -0.694124936227878, -0.691467132469717, -0.895799400866506, -0.45216972908564035, 0.1958093460824157, -0.6952728456101036, -0.802617540423993, -0.5523700683921176, -0.7391874254096428, -0.2817348093568614, 0.7226580668162135, 0.8482899001844852, 0.569566678469681, -0.550112425947681, 0.8509364260932217, 0.5994773932068506, -0.7295200233444493, 0.6488892117640416, -0.08467853823736346, -0.2336603402971671, -0.350139308473991, 0.5344056163340984, 0.16116509200683007, -0.9525075021437748, 0.41000505427062034, -0.7236571137771421},
    {-0.7519758190598057, -0.3947838764301659, -0.8298047679504141, 0.26562488599928213, -0.8640723331774719, 0.6895664404573842, -0.23680973668862043, 0.5984438982200536, 0.40271582076126894, -0.6741226949180753, 0.7906619864490054, -0.7827404249730295, 0.7481195494249816, 0.5638568056583256, -0.49945953497470247, 0.22450709842885727, -0.7318901953460627, 0.01276935069710225, 0.4620627710417564, -0.0634485614073591, -1.041162746895181, -0.7383895026752635, 0.40477375805825333, 0.5757344111023244, -0.7326650716996801, -0.8919833917082591, 0.5921221653574494, 0.20630014231614072, -0.6251361455177615, 0.5002022350369757, 0.4572651283151858, -0.6277900403667267, -0.5293734042227465, -0.46442994163380763, 0.020513474344128216, -0.5608759928235503, -0.6433153034656881, -0.8828083590329688, -0.8664075561675246, -0.4006247732294644, -0.7049220272073129, -0.7213311647451442, 0.23489650865766967, -0.8740051918107787, -0.7800695247101739, -0.5881509033706741, -0.47228066379863315, -0.19628272060441415, 0.6116468548519289, 0.7897695370392903, 0.4082394243041515, -0.6936121927909104, 0.7808706260080379, 0.5792497922922213, -0.7811408773782431, 0.5183463686683516, -0.008095582023830802, 0.06267330890731143, -0.6358414183618125, 0.4341707638433442, 0.1744082313436918, -0.917909343804396, 0.6347823564282209, -0.9350393300732781},
    {-1.0302517410810477, -0.6261957491661984, -0.7916880933256374, 0.6638934868810678, -0.7017665623629136, 0.26827367373751554, -0.19406105329892068, 0.2691431056441217, 0.2915250102907067, -0.8081665682650794, 0.2816795326950564, -0.6172349665424997, 0.7551916289925413, 0.670546556536271, -0.6712225380618544, 0.2948113875815811, -0.6841977379850448, 0.10271153852482713, 0.7362757555569861, 0.1335556428435973, -0.71817627216903, -0.8540340876396288, 0.6149854201711423, 0.3840139082660654, -0.8717286974123477, -0.6126283954471936, 0.43791042433395944, -0.03955491406766679, -0.6337359684809433, 0.44927124449770295, 0.42189777511932725, -0.86308405632548, -0.6526359640802966, -0.6256212342781737, 0.06256519049832784, -0.6759090603151144, -0.9321220963190767, -0.9226347026839894, -0.824360137787195, -0.28610259948826433, -0.539464437100024, -0.5092496052091289, 0.27416091706792056, -0.8965955874316179, -0.5188790036988142, -0.5573671674812775, -0.9069748414930053, -0.0696143524751381, 0.4000334682373094, 0.5400615230100154, 0.6407079942145036, -0.9332936152984707, 0.664137496513969, 0.652589653294687, -0.8039051760595881, 0.6502732687112407, -0.19455659241385104, -0.38760239243219663, -0.3962414402269536, 0.39993424818011736, 0.35021066307102094, -0.9522503345503406, 0.5161781509760202, -0.7718419660636442},
    {-0.6727727771929193, -0.8749436844678318, -0.8905969832273444, 0.604172886329106, -0.8153975346403081, 0.2750632262343701, -0.02783067560233167, 0.5407912873497563, 0.4046921205734808, -0.6364005305086227, 0.33111478105927694, -0.7051631337198312, 0.9606160609174687, 0.544212080632292, -0.7944868958081509, 0.26319475116172647, -0.7897161309629167, -0.09657918326854745, 0.6148726026450143, -0.009967102345071263, -0.7049921388426172, -0.40239811142591325, 0.4548420344284966, 0.7663244888027506, -0.8417529215053717, -1.0510861300068695, 0.5836081317076643, 0.4275330188626625, -0.8932906305806839, 0.661631486995968, 0.7178098613891786, -0.6486983833834529, -0.6173589152138644, -0.7182481808024243, 0.015217185546747959, -0.5843172416590815, -0.9736839899949458, -0.6098380589952047, -0.7059198406216066, -0.5079998124820019, -1.0342461558990772, -0.6077396874424003, 0.5221950148702457, -0.7636794337909194, -0.2297680208075467, -0.6051614489099918, -0.6765441791618476, -0.09511871744494797, 0.6270162985141408, 0.6260167213158319, 0.5083407478532906, -0.9505073006757067, 0.5187888410927555, 0.5612393555028232, -0.6949871188213281, 0.556823529285965, -0.5116156840872689, -0.3709903568266563, -0.6430469157449097, 0.47439565727352273, 0.720663291761152, -0.7911801869619155, 0.5618374919501297, -0.7161505678470217},
    {-0.77687621015847, -0.6696537268247627, -0.6309758916830015, 0.5076528921553427, -0.6026234639597877, 0.5501764609817809, -0.33593702280641846, 0.4015326645942117, 0.5170093248128085, -0.81379850237212, 0.5118421527762693, -0.5539502234319442, 0.7523941868193726, 0.4483765633750243, -0.6703085888363178, 0.3282041390212884, -0.7083533644127626, -0.2780281044074923, 0.31288829149960795, -0.0066363256200302825, -0.8355811654795102, -0.2326416592273373, 0.4587313832530569, 0.8198188911726262, -0.5993741779535037, -0.6506027300079307, 0.21669471819579283, 0.2454750275590763, -0.8828192311228557, 0.2241267799209828, 0.9097785558374064, -0.6968082349771025, -0.5436324002816967, -0.5585037386097248, 0.14650968460020794, -0.9383251427707968, -0.7998278993816701, -0.6608402066526349, -0.820089671930467, -0.43844306650088993, -0.9556974887861, -1.0411573720090175, 0.2043485847981511, -0.7573884769167994, -0.7375160612006326, -0.7103579622902246, -0.9352882259714269, -0.02245192814748807, 0.6883771494528921, 0.7675749313890184, 0.7502483630864099, -0.7969955953912986, 0.6571305598594076, 0.5193511850720417, -0.4050686886347348, 0.8295748247553952, -0.03705174049772528, -0.6468916523566944, -0.40168959387992464, 0.41108767086250353, 0.27317257755354674, -0.8719791006074853, 0.5189336678665349, -0.9154731414079003},
    {-0.9179468351739718, -0.5545164767444747, -0.7593869492005197, 0.4771903965895069, -0.490291372671193, 0.3474141012973374, -0.1828565507889004, 0.5908997217482421, 0.43495163826861605, -0.8994549526820912, 0.40722035428880804, -0.44392720245161044, 0.602730439548566, 0.8886806847527075, -0.819072761904392, 0.07754682573703482, -0.5728436321385819, -0.151372662047497, 0.22431302041676887, 0.1960177300539137, -0.7518946026114023, -0.8139725599625217, 0.5116622882755248, 0.5809640261989348, -1.1277699009989584, -0.7590701272023825, 0.34218240825856727, 0.3082906222780042, -0.8721471697052359, 0.6655934773005795, 0.6724060405602309, -0.6654484727585096, -0.46228472538353743, -0.908375610653539, 0.10574126254853326, -0.6000063160496066, -1.039366742399286, -0.4340398178759477, -0.7112809385668857, -0.6010897152768205, -0.8870849764805648, -0.4296064525766868, 0.39923137316548823, -0.9173615625046143, -0.4545725416606431, -0.8661232182284033, -0.7673350137394062, -0.008646043355390156, 0.5866644900583465, 0.7607021505686319, 0.621827352856878, -0.8819872909551632, 0.41287546982100204, 0.6585079976781756, -0.3993979494136619, 0.4550005836528869, 0.13089115439820478, -0.7675013780628923, -0.6121806192193394, 0.2725182855684159, 0.5199549070587656, -0.7227953591406151, 0.5685309886204049, -0.6395173338574373},
    {-0.7041091289546236, -0.8487862778742775, -0.8288767391869156, 0.20494332017240857, -0.4602353234064112, 0.44121862870472367, -0.3992014852626811, 0.43048126581449614, 0.547377403269174, -0.9913724143809757, 0.6036386707590679, -0.8828020726985554, 0.5998784896443571, 0.6576403185278219, -0.778257719197466, 0.19563492305268082, -0.6649612516113678, -0.1258882922932009, -0.05058726228592856, -0.17796987556037536, -0.9404434674108365, -0.8662212439383342, 0.35245656946220577, 0.5055968103591152, -0.7332097564309362, -0.7070969846463635, 0.33326843349726576, 0.13540352585482252, -0.8792906082437044, 0.21208318487283942, 0.42919784269481226, -0.48907276022357515, -0.7317153961050005, -0.543729488676415, -0.07110886074605678, -0.8989329309961571, -0.9369804037502826, -0.5649305399109393, -0.9530838296774143, -0.36502092267392755, -0.9260771327041033, -0.6492665970574867, 0.2252801063840593, -1.0002193869867784, -1.0555130180808086, -0.4986132841863821, -1.0226608954465917, -0.2701235510693103, 0.5748882008765182, 0.8691349610383936, 0.4243372876437856, -1.0626348179960545, 0.3819929320693509, 0.5331688248109289, -0.779309108001172, 0.6918042284678528, -0.11708765040749922, -0.7502034868602976, -0.4660299746902961, 0.07789568561413235, 0.2809055853318191, -0.8802980091214109, 0.30298973869109624, -0.44774491492664525},
    {-0.8840101903005745, -0.9526401771118863, -0.8219336784965705, 0.20492857274308776, -0.6946155903595034, 0.5393830797031232, -0.445645353366546, 0.24402741610276746, 0.37310958060658544, -0.8842923736638276, 0.21728623659803722, -0.878531727213546, 0.5865092741936827, 0.5580378899487433, -0.7871602336142796, 0.30497072366927136, -0.8398476455730429, -0.1787348506264521, 0.11132797717734963, 0.04747753867563238, -0.7916558682731929, -1.0420769987757794, 0.21368073260222187, 0.2481787328865008, -0.6868130066308261, -0.8027563575991387, 0.24070694467895354, 0.1897767508941026, -0.8796927714057494, 0.2394761110407885, 0.585006088647423, -0.6862399779062308, -0.559761832576365, -0.8525360743667049, -0.14755699000469774, -0.6115297851801862, -0.7170806002199536, -0.6303722749551651, -0.6220457219424017, -0.46240518720112517, -0.7559786881019022, -0.6997121961754402, 0.2351502810924556, -0.7945309249767292, -0.7223797301257414, -0.3784706624747572, -0.7160101248091904, -0.26657169372620787, 0.7466667313217626, 0.5894360529754082, 0.39857635091791344, -0.7664296732889706, 0.23916945053110866, 0.6774249627693509, -0.6724156885748234, 0.5150563634728688, -0.2997548005363449, -0.7738279599635958, -0.29954676302545274, 0.3306052147658006, -0.04064033314381625, -0.8628018779786674, 0.3481820965345236, -0.6819079887766332},
    {-0.8335373059777201, -0.8674036890749298, -0.912461216314957, 0.22893763730583727, -0.6544073971674041, 0.6803731117340233, -0.36368491566770894, 0.5283833984217068, 0.5024804220194447, -0.8161838442074654, 0.4158442414014419, -0.5440459618390542, 0.3452602603893852, 0.5703149641780415, -0.9093326397676502, 0.34041245808133286, -0.8073524578341431, -0.12703897410403586, 0.10010801632018615, 0.0356044414308813, -0.739869331714351, -0.6880529351891073, 0.2604508801013229, 0.3325471974415536, -0.8182708696100083, -0.768379371510767, 0.5662681811112208, 0.46155179393019435, -0.8100340422202449, 0.5172827548368749, 0.7923652346518799, -0.825113885833924, -0.5802673903026723, -0.7282142441199937, 0.07378452429924394, -0.7504551894003115, -0.8483039059218173, -0.40883887879924763, -0.7098408409175594, -0.2423765927427797, -0.8422708711602273, -0.7471797541967752, 0.5356826531735549, -0.850628984540125, -0.7903971718045514, -0.8005038730301383, -0.6633186503790585, -0.4332132632164577, 0.5250459487693574, 0.7567908801203066, 0.2061095433962268, -0.843895238536661, 0.921821259423968, 0.6656444803922069, -0.6201482543562394, 0.6375692235476667, -0.20636151097440444, -0.5651040240473734, -0.4232867323718211, 0.2130990590541898, 0.08862874773833412, -0.661142320071523, 0.5995427598972064, -0.7621999238119184},
    {-0.8228004112566109, -0.601748675892929, -0.7219526517508105, 0.45254320437711876, -0.49272337760665835, 0.2868799322610139, -0.5526702442213183, 0.5051257100792526, 0.7147273425845481, -0.553275055927774, 0.5198414834435302, -0.8078879331391536, 0.686900073872363, 0.7354496231692456, -0.8310992378707761, 0.5020347164267932, -0.6082723865261503, 0.0023512227324328466, 0.349682605336819, 0.23614557951447193, -0.8049320588736723, -0.6537796426867152, 0.4267128353963397, 0.4752184249892912, -0.6091320153031616, -0.6293759078960496, 0.6007339661994019, 0.37487031633883505, -0.9276107913733965, 0.6093247980494934, 0.6795871808840036, -0.6151173874623903, -0.3393178388626314, -0.6834019998329477, -0.0450146334000486, -0.62117883574715, -1.0022072144057512, -0.7019296531552734, -0.8313475501422668, -0.2822047882829012, -0.7325618471284093, -0.5620525166090062, 0.3745915902137431, -0.8045605287994935, -0.6609968605616452, -0.750530316979651, -0.8724329146976724, -0.007547282421579993, 0.7845354171009702, 0.7179023407984766, 0.43773933096935763, -0.7064632052431283, 0.453591820506244, 1.0014823121261363, -0.6647865017702903, 1.0246933363911928, 0.17842722639145733, -0.7754677814856438, 0.013086695295051552, 0.38316790830911757, 0.07485501832357126, -0.7129844404657393, 0.43293380894011674, -0.39206079239803543},
    {-0.753896338035622, -0.6199715706620392, -0.5707014249565471, 0.5284161418381986, -0.6449491148217086, 0.591043447036623, -0.13887244028615156, 0.5543931118509591, 0.8672832532925088, -0.8125710496997092, 0.4817635534840378, -0.6196520578544817, 0.6713908591682609, 0.7677054866149906, -0.7774193844657338, 0.6416749693844807, -0.9079767420287923, 0.13061778249992742, 0.690721105235395, 0.14909309192220596, -0.8221148391789396, -0.9833840441048025, 0.5254436336685159, 0.5999660171866641, -1.005501772873549, -0.5674400084832437, 0.5280831466755852, 0.3584316617407204, -0.6289524899679705, 0.7208779800544243, 0.8565131561744657, -0.2767742149082412, -0.31815039940391115, -0.6832477043925026, 0.22084914351938648, -0.6467028305159812, -0.9106084120816218, -0.39424793298662075, -0.896901940424512, -0.23317105092434715, -0.821180873242525, -0.859532518347849, 0.4219101259473336, -0.8723288443788073, -0.29307828302111916, -0.4996028915961621, -0.9427740012909523, 0.12723020764158013, 0.8094284548890275, 0.5998883047113441, 0.48053066392925636, -0.9988337294491908, 0.7080300217371559, 0.683160381863923, -0.6093590496687543, 0.8255978771090562, 0.015108429338644837, -0.8881859361991045, -0.29803390597515483, 0.5290197747912225, 0.07466802031261945, -0.7666338377207135, 0.835463881942171, -0.557917787289335},
    {-0.8576305400455965, -1.0211028131899056, -0.67664904239599, 0.6225056419363796, -0.870410463685071, 0.459624089932421, -0.2161563526595763, 0.5247274463290271, 0.5121352743526221, -0.6396825920213993, 0.589140007439561, -0.726122756866349, 0.8841161212342173, 0.5254682793872214, -0.7590287993441529, 0.4371796920011982, -0.7638328688180919, 0.2966093751219074, 0.6174383007823588, 0.25389520629182283, -0.8060184272129639, -0.8033506934829778, 0.6671059114918607, 0.5772256778655875, -0.7178529587172398, -0.4925970686579448, 0.5643202386590126, 0.36095963821553934, -0.8008697457682606, 0.7774493372788602, 0.6656553746032862, -0.43700344065019564, -0.419204062150784, -0.6499210112967314, 0.15161919393258472, -0.9519196600140463, -0.8674983650688374, -0.6112937367699034, -0.5395331165216907, -0.19405194523258115, -0.9786486163882883, -0.5144955243864604, 0.580195702072372, -0.7421138847839425, -0.8328548464616264, -0.7418937822043236, -0.7701577658850112, 0.03553040039876149, 0.6855148313796432, 0.8578622177468735, 0.5431904537361641, -0.9354521731129393, 0.6409687885996552, 0.5193828774476411, -0.4460576011588798, 0.6349038484206995, 0.17453619281230148, -0.7395190311062338, 0.06930205662170452, 0.641265963866098, 0.36107311990462626, -0.9056230864982502, 0.8189016318290042, -0.8663737058423272},
    {-0.9285374597822458, -0.3751059369021074, -0.7580544147751065, 0.6777811683630306, -0.661836259941209, 0.7388873893544993, -0.381609896935842, 0.6760989865713186, 0.677475744266239, -0.671102053849806, 0.6201458102422863, -0.6333458043337639, 0.5912529177157971, 0.7376207060711452, -0.6886462801642427, 0.3801969902393416, -0.6102707931193138, -0.17385184664609746, 0.6306673811405632, 0.2721469627919774, -0.8530203299439858, -0.7563354522088034, 1.003201581034879, 0.5547935921850332, -0.8626239702066817, -0.4311050747378878, 0.5147817778390954, 0.6005035287455586, -0.7363695863285165, 0.6726040143800092, 0.8335740884805223, -0.31683866722325466, -0.3894984119650622, -0.5779838994718486, 0.3890196619254448, -0.5265378604269892, -0.9830560238235692, -0.5551919731565107, -0.9221532008417184, -0.3085318586008157, -0.6917055642131209, -0.6547766491067362, 0.6165479788216648, -0.8137225332439956, -0.5917961221512587, -0.46991366851420036, -0.5111214824601242, -0.0548808838956942, 0.7205576075420866, 0.8116512318884037, 0.9061700903171552, -0.8541791190629616, 0.71187556324935, 0.7421540321602115, -0.533450704975483, 0.8929674961926054, 0.26736428411373975, -0.900979791681715, 0.014539675372656862, 0.520700413235421, 0.39933735537462056, -0.7375404621327307, 0.5308964158616232, -0.540860566946066},
    {-0.8384287376901929, -0.49601663153098036, -0.43586099358126185, 0.48672377061152133, -0.8045830969392818, 0.3457150701537924, -0.20897892760751002, 0.9269448064699116, 0.5692035367802747, -0.6547386851955488, 0.8640481862412838, -0.47012637110175753, 0.8580786249513719, 0.818815649490177, -0.47689083842280133, 0.7294836765713585, -0.521954539054956, 0.053977428737080155, 0.5380909099576511, 0.5590277860621847, -0.7403935543083408, -0.6480180070902644, 0.7985445648244489, 0.7432553346195452, -0.6748625948874921, -0.09909114644024708, 0.8380347105086515, 0.2753879409102104, -0.7222399051770437, 1.000717529384498, 0.7835958368536023, -0.12537526994961037, -0.14614262087846808, -0.48589353994515977, 0.40381659026062683, -0.40648759361214615, -0.6643013695630114, -0.18232233745267332, -0.5452638382900674, -0.3216514673067682, -0.5792298937861001, -0.582222195624882, 0.5969505391500833, -0.5075021589816693, -0.5399950309701496, -0.5887752013506958, -0.48563000067554085, -0.11489738030552368, 0.825419047441497, 0.8991089064909844, 0.6229312374853032, -0.71966581352661, 0.8818367973985201, 0.6464006098829561, -0.4770705693735729, 0.863818719409783, 0.1356696781895046, -0.9459264046588891, 0.21616618850163125, 0.5380513443868509, 0.23459613869008428, -0.6457254167345173, 0.9946834197787635, -0.5172086305732929},
    {-0.685378061817877, -0.45632461446770733, -0.6210223517698219, 0.6666592386770448, -0.6985095283335311, 0.5128994316804986, -0.25832308932010334, 0.5955086407886522, 0.7432465854436283, -0.5709728485077084, 0.9404863575820042, -0.45215547782657933, 0.7642250481042172, 0.990319584873212, -0.7684217258567793, 0.5757016420650901, -0.8808327063041163, -0.03014389741807241, 0.792587431976502, 0.4330839167154185, -0.5772030061949801, -0.517286031393445, 0.6394067140939738, 0.8225859665290649, -0.6806537744019804, -0.3127524975708254, 0.6830470789747254, 0.33952866246287516, -0.6403006750177899, 0.8806233048214221, 0.9861178463526307, -0.5356234672986365, -0.372570387314469, -0.6812111137377431, 0.2265362581955272, -0.5084130190227686, -0.6858403527869915, -0.5475837336898032, -0.6392353373424703, -0.3840280916974392, -0.6735207794749782, -0.6466258517033554, 0.6259559111501458, -0.440154214707934, -0.2174904689133217, -0.6229094115484336, -0.8056285459628262, -0.2627613877858089, 0.8151338818853202, 0.8086367448562797, 0.5817137928038328, -0.6237807366375989, 0.9208562028805372, 0.8930992955727404, -0.5819384439725158, 0.8759295077204877, 0.1696043720581736, -0.8827234356596914, -0.3232134834551297, 0.5394820978164734, 0.5954126899985319, -0.761386685619314, 0.703594672216357, -0.5820789408689393},
    {-0.7325393448801897, -0.7041875670381427, -0.575707051269609, 0.47324178757600815, -0.4525258455272446, 0.43649547172571584, -0.6327530501426207, 0.6647789390770296, 0.721518211660317, -0.6209571254562863, 0.7490426499240069, -0.454972521168588, 0.9189956860071419, 0.6952508456934713, -0.5629600221781911, 0.5740922667676109, -0.6272143262106937, 0.000998002024815267, 0.5793801500754835, 0.27711497046640576, -0.5894347204504184, -0.671938218905422, 0.46554857232299646, 0.7256588024477408, -0.565632911466646, -0.5934876503480524, 0.6384583955174518, 0.44530441598163795, -0.689372644025991, 0.9656650371205993, 0.7426971474845788, -0.7349098898660836, -0.490289125149914, -0.6529408144575239, 0.08221294049024305, -0.6978657629451857, -0.9151147155371943, -0.595556989383803, -0.7248040705031897, -0.5539748718363946, -0.6108184257800279, -0.5486129564455744, 0.4494915173964361, -0.5780044655906698, -0.5324080761571598, -0.4401673740051452, -0.5220517422926552, -0.18726083066452684, 0.774302487187077, 0.7981618907305735, 0.6598927013319036, -0.752457191912627, 0.7626353071509965, 0.7672222539599047, -0.5237399074369465, 0.6762296267664832, 0.04207534779871835, -0.7190757140455459, -0.180123861191597, 0.6710611590616311, 0.27986376704709337, -0.8829915992197681, 0.7756545911485893, -0.8507035120239018},
    {-1.0060565760307274, -0.671117996545943, -0.7177806133154944, 0.7166888398634498, -0.6490396836829154, 0.6027550684182081, -0.643546765473723, 0.5568035532844401, 0.8213888599962301, -0.9473828801150025, 0.6518141633653871, -0.4851349143063736, 0.7247743319573271, 0.8032117107016855, -1.0860405487984752, 0.6443786941835068, -0.9519034464146754, 0.22993966548049252, 0.4978613420107946, 0.013530844573439359, -0.8099546139758603, -0.7355978317532406, 0.7358086788870775, 0.8539971351435963, -0.5836290034923027, -0.6164869800890446, 0.41288048486087564, 0.6086875104236441, -0.7678531611243381, 0.728131974913892, 0.584438919417242, -0.44462037754353734, -0.38263086149662445, -0.8732090646454863, 0.26028814032619396, -0.44452131684025215, -1.105383199207448, -0.3294437653547535, -0.8893531010583371, -0.14633899001841996, -0.9035360478492248, -0.8176779754517136, 0.46448366911766653, -0.9735294720669041, -0.7704640170326733, -0.8541396506563204, -0.8489789843951037, -0.3029849347941228, 0.9791957031807527, 0.7885816880625719, 0.987959659444649, -0.7772914071969504, 0.5208081991128365, 0.5042891958040999, -0.879060924039958, 0.7506841085492548, 0.07533005709507393, -0.6899774503297931, -0.16334338089428685, 0.5745996761977923, 0.021553766281143076, -0.9151107006067714, 0.7807041742269634, -0.4975345611689315},
    {-0.8143890507963452, -0.5399044333621806, -0.5350790150129163, 0.6020471716510722, -0.4234862107909359, 0.5549217489157348, -0.5348342010690559, 0.5912597858228605, 0.7501621678406648, -0.6784005063852545, 0.46997470571880295, -0.49789160852428954, 0.7007552565365989, 1.0333547823798037, -0.4259402626354963, 0.7388849329315883, -0.46524298141334036, 0.10001612547556947, 0.8466095599602343, 0.3403103422140922, -0.5769288795340644, -0.45498567584976535, 0.9007280778538751, 0.5581969843614001, -0.6129548040664764, -0.4947594280796852, 0.8468447267953982, 0.6586737221425492, -0.7860497389656235, 0.6109023145208965, 0.9521595799037064, -0.22595904628057792, -0.43673905387453865, -0.5952402882349569, 0.36528578535961526, -0.5490214851372688, -0.9092857187346376, -0.34963752477772153, -0.8314079189719349, -0.5232208515881184, -0.7110301656333192, -0.742055758473171, 0.6439778297982143, -0.6823759424916507, -0.4479075971543457, -0.383478312662965, -1.0071377021119734, -0.20573841554295086, 1.048617150697964, 0.7906263191603219, 1.0946398264053319, -0.7994273637491899, 0.6051545058785746, 0.8721190628127952, -0.28934207709317084, 1.0726696765907475, 0.43190336772249044, -0.7965711143067057, 0.15497497803717836, 0.5323710680722165, 0.2878014843931252, -0.78692058798459, 0.5614848547683281, -0.5186072464923546},
    {-0.709911175552358, -0.06187996098736043, -0.5669335303495032, 0.78515394990874, -0.40721503404286463, 0.5774043920325541, -0.35850171952700016, 0.9024610353887847, 0.9062428067413717, -0.5141880944380639, 0.9282364808170741, -0.5067495392819694, 0.6988471062379611, 1.0079008284223394, -0.49735419903291295, 0.8842600315268516, -0.7200051756248683, 0.20681152169409717, 0.9513545587680093, 0.37242369929583297, -0.5626619094465112, -0.765668228461176, 0.6877138143119517, 0.5714683894398502, -0.7439634173996968, 0.17016438575515816, 0.42881299973559295, 0.7227650617776384, -0.7147859402296817, 0.8392077705179865, 1.0176501905608784, -0.3286664908283094, -0.19408544834928104, -0.4312043154124364, 0.4342552026028544, -0.4043657067133743, -0.6128686340948055, -0.07976888607928884, -0.905052221484744, -0.2270668801054498, -0.14541268110628064, -0.6592346150401653, 0.547467008454536, -0.48874756890891313, -0.5712695480216544, -0.401885070829211, -0.8338520044539328, 0.09017836691800075, 0.8745552387924777, 0.905268158165836, 0.6403318252582403, -0.8412847453249773, 0.9807227068812912, 0.7783562723917667, -0.5150743741584219, 0.7470661786586769, 0.1257559560940155, -0.610859168987017, 0.36344791276546795, 0.5809847725292955, 0.6340083975391841, -0.49987507474064274, 0.8281199431662045, -0.24158703103044038},
    {-0.8387211831932908, -0.6360124852767693, -0.8295042012216713, 0.7842250079167891, -0.4048889946640842, 0.5439129505604876, -0.5028671988765153, 0.8878788239496705, 0.7831143109582638, -0.683665253268386, 0.8553626563316946, -0.6607756564866122, 0.7519349295630389, 0.8722858468117017, -0.9133972553572516, 0.6634912696112331, -0.8984555079338281, 0.07853870644200257, 0.6469931226518941, 0.45496891729673106, -0.7346388334163412, -0.7821248882156535, 0.6220894790594067, 0.885702366132292, -0.6384854205510603, -0.4999060550488712, 0.6184300191556297, 0.5196281628265844, -0.5832351308913882, 0.7637926233205026, 0.7552586536868713, -0.4259764405862026, 0.06037409055044445, -0.6663659629329459, 0.47945151322911916, -0.36400926405338946, -0.8835024333519576, -0.16722098217714743, -0.7546053043811051, -0.08836719923479422, -0.47186195649446316, -0.6237433084501381, 0.6054960311961652, -0.7601232673795429, -0.5407984534087615, -0.758053676953506, -0.7295528280394419, 0.07090896559697965, 0.9010332835020868, 0.7290423025322058, 0.7316442558709205, -0.8078351847097537, 0.9385298789515234, 0.7571810979865294, -0.4500061346091056, 0.859414074364441, 0.4002550492487375, -0.804592743324276, 0.16353980026018347, 0.5803567360608417, 0.46001835580978045, -0.6673255392761043, 0.8483643415563663, -0.4254372622172771},
    {-0.9572959302150907, -0.6500204485711418, -1.046366493224069, 0.5528053459821582, -0.554865844124894, 0.5495528381762653, -0.5094866172153492, 0.9104542890765007, 0.7985383843406165, -0.8300636368495213, 0.6499536235649219, -0.663415468944673, 0.8738517681964211, 0.7176152707692157, -0.7797551230315629, 0.5071716316396634, -0.5927224446965372, 0.3038255246859244, 0.644284913164263, 0.11106638465830909, -0.7366233648891162, -0.6484812783084841, 0.628706529530322, 0.7623337863030547, -0.8760898908394771, -0.5996762522333763, 0.7443979902064948, 0.6811159348543243, -0.8241256211768485, 0.9624985147915431, 0.7245584003882922, -0.5680943222282689, -0.3500389612734904, -0.6520419554187467, 0.12363862446508492, -0.6556436158366307, -1.0156386660390586, -0.5714520891413417, -0.7405033699964277, -0.2828684650547772, -0.6680604658441219, -0.7724068927625228, 0.5694598501655342, -0.8959559753611178, -0.6405895390584916, -0.5333771143563077, -0.5815717336468448, -0.4204872624276414, 0.7870045881432842, 0.7389010155672784, 0.7558277483066425, -0.9734778204334918, 0.5079116931643335, 0.918780056131874, -0.24366492100398693, 0.8561941573123754, 0.07442383211889173, -0.8436882202689541, -0.13162029194250238, 0.47090868495773136, 0.08622778602880195, -0.7698013620526903, 0.5885283269946848, -0.4340979712674831},
    {-0.5917045544730497, -0.6496345357954153, -0.6889034549819062, 0.6421176656121717, -0.682387571555402, 0.4006641568999612, -0.2478639521907467, 0.36095517812843664, 0.5482046204358564, -0.4856167805483145, 0.6178878501446424, -0.57755312135991, 0.83147169685406, 1.1141914713749974, -0.7431308730680934, 0.5555005655678634, -0.8644503355586168, 0.08586787138734668, 0.44478058148978256, 0.06930645134752414, -0.4581594907953396, -0.6243280422638626, 0.9395725263772621, 0.5512056706468614, -0.7381995721473589, -0.6121404840580131, 0.8047619728362991, 0.41083826166196424, -0.8533045099210467, 0.6975973594671004, 0.716776696529076, -0.7169899831125366, -0.24566518405344548, -0.8818044163080636, 0.12213632811290052, -0.7619780149276127, -0.9285161033669241, -0.3172168595168945, -0.7945223596469513, 0.03512762414252549, -0.7682569183487561, -0.5238129188640411, 0.6718992874965878, -0.6827326506669283, -0.5865560272996797, -0.42420827043055725, -0.8453807192491264, -0.07965997025463038, 0.878141725307944, 0.7925629421237143, 0.7864721563665523, -0.8183357395595486, 0.8537622098126391, 0.9487263526753693, -0.5590982972138671, 0.8449962286072035, 0.3139718603398964, -0.7668560628567653, -0.14935371640459696, 0.6420325877565055, 0.19288771582317885, -0.8159124583792499, 0.6870785966026063, -0.4255370449432649},
    {-0.8606693792827459, -0.17429660213376835, -0.7611769556040328, 0.8856160764893904, -0.5850083843970578, 0.46633040139709403, -0.37168316088810194, 0.9279133709308364, 0.8850644299013408, -0.8538586652738489, 0.7415454167166077, -0.7845756306618441, 0.8211286354188174, 0.9925181606884825, -0.5491252982281544, 0.6374602982130863, -0.5563529857862443, 0.13552502383530476, 0.5246292041230466, 0.13098940458086056, -0.8559546909710049, -0.5409742792090568, 0.8585222875519066, 0.7781377814753261, -1.0252367782457827, -0.3783866692672137, 0.8658664942121664, 0.7144773821819234, -0.8624062409673814, 0.5706153902398312, 0.6843967018336737, -0.23029581098923707, -0.41428884172331465, -0.5695454026728026, 0.20269135473546065, -0.8601930941989157, -0.8307062592621612, -0.5769209545967344, -0.6675848750548454, -0.2505656597411433, -0.46074762560188914, -0.4963691032768852, 0.5985925200765856, -0.7850316767028028, -0.4535082184543152, -0.35738142973294007, -0.785779001802782, -0.13093534457080547, 1.0564883772209122, 0.785418771512271, 0.7003391119563223, -0.6570009027248335, 0.865847291116092, 0.807319903690424, -0.6427410280872168, 1.207162458530005, 0.3469609828262962, -0.806513649854656, -0.25827931647590324, 0.6024961055711837, 0.2385971217747798, -0.8861360699420896, 1.0848864548100736, -0.6642379841800478},
    {-1.0740671820310828, -0.6564282876227198, -0.5931845090219019, 0.8095438940465708, -0.7338525776988507, 0.6397949115449039, -0.4953295476831931, 0.7805906530336276, 0.6422102485475752, -0.549890704696904, 0.7013085185943776, -0.5612761024520078, 0.9346868340087057, 0.7326638333561074, -0.9880709893193613, 0.7450210596874896, -0.6755882015140648, 0.1931254194314588, 0.44592272244428494, 0.3233241202438168, -1.016503224686586, -0.6838213856827211, 0.6749008951498268, 0.7640867765956707, -0.6470950112140543, -0.29062530966669853, 0.7078878868371359, 0.5112323410064976, -0.7355569594787601, 0.9374112486014579, 0.8935577094361996, -0.43615804268370406, -0.3254411819779887, -0.4951933263505295, 0.4748644858537212, -0.8868451732583789, -0.9372865060849352, -0.5195447140458255, -0.5804786923449147, -0.2904966197541499, -0.7603803124756531, -0.7053138569227811, 0.6369370779406985, -0.7365553417582972, -0.5606533559410398, -0.4207113653465736, -0.9517832517418698, -0.03778115868633562, 0.754491121263209, 0.8438909486078078, 0.6790849254586772, -0.9058090125914399, 0.7222061991906938, 1.0731467114873212, -0.6498538399143982, 0.8121691551470972, 0.23517416098508026, -0.6543092509226699, 0.09466055848718836, 0.5195569801165635, 0.38160738406600203, -0.9074308535792318, 0.7607007054682081, -0.6744593910423659},
    {-0.4563566452471116, -0.5949020622542865, -0.6300163014996883, 0.4254394476868599, -0.6740298864349552, 0.5778511756150938, -0.4471803856998037, 0.8191535114304391, 0.6910355229589685, -0.760897299912638, 0.7358438523749894, -0.7360125733617213, 1.0175709995144913, 0.6965164467136048, -0.8529086046945934, 0.41947643217879066, -0.6499325554094726, -0.03379355369301407, 0.6638034900212905, 0.4799853944024392, -0.744017487753524, -0.6016031809688265, 0.7893515859555917, 1.0005086374621879, -0.7393128136380676, -0.5075633663449255, 0.5657334723226459, 0.7391887187826478, -0.787945534540496, 0.7791782687375437, 0.7530503406694073, -0.5872646917843736, -0.25733388413095637, -0.6788548410603219, 0.35172136337438026, -0.6937971179060368, -0.7638295764628031, -0.4837642609735973, -0.786128420662324, -0.23399928072741744, -0.4341194874800335, -0.618483975036792, 0.6764833361040409, -0.8637899284148838, -0.5985277703803922, -0.4679132957633202, -0.7681384727179058, -0.23533436758921408, 0.7010839654458619, 0.8197564543841971, 0.6638172490391072, -0.6215146717986316, 0.8469640852880118, 0.8991394697336001, -0.37222990789883587, 1.0481237293964554, 0.06834980058421214, -0.6987187400329701, -0.08375075985841073, 0.5405504214580191, 0.11389462753343155, -0.8499604928403147, 0.8016433674297869, -0.40815919782156884},
    {-0.9393403512060547, -0.34202808625259923, -0.7617282883219018, 0.652022786290029, -0.7020073404496731, 0.7013577549511245, -0.5199750001499256, 0.643699897344739, 0.6095467078673849, -0.5741372464046156, 0.8030364756228193, -0.6996873984959634, 0.6875835301210464, 0.8763871787379206, -1.022986001066133, 0.5307183988425229, -0.8093314987978207, 0.12226697908659055, 0.5684812784687993, 0.11159142891565087, -0.688445173852253, -0.7768199771228442, 0.7748602096959021, 0.7829638270245044, -0.7765757750670865, -0.6447394071466507, 0.6992939234934563, 0.3899288473491487, -1.2031710996494096, 0.64993462410311, 0.732784511795446, -0.30624116727830697, -0.23928348409836986, -0.5923129503675675, 0.1858307279757936, -0.7438273577796585, -0.5502516091732534, -0.47065203581523823, -0.8853671367027555, -0.07954155653346702, -0.5809393786173997, -0.4256096389311916, 0.4311992343764632, -0.7104736374142608, -0.6409448143262132, -0.4139381174816656, -0.8686898759662217, 0.09847739777079616, 0.7090280760770167, 0.8936424221374722, 0.792125894018545, -0.6962072981196992, 0.9654139818921927, 0.9252472420984668, -0.35425738580480987, 1.1056482270379253, 0.1956278303765517, -1.0719444087065628, -0.2503662954506649, 0.7597731275545208, 0.08319590401169491, -0.7736261001570965, 0.8570230800241988, -0.43612477352709816},
    {0.1558439125957082, 0.21717524182596357, 0.3948349989539784, -0.37449212118246644, 0.2634482203241949, -0.8077746753942985, 0.012078615671234989, -0.666688936073761, -0.6144333465960937, 0.1878871687916311, -0.26554007428620596, 0.061974734898423936, 0.2035269588014111, -0.7447618548410516, 0.22246209736617145, -0.03141294616442437, 0.3555367127600314, -0.3627277286820089, -0.56012672691758, -0.35531289151323764, -0.059674218578982675, 0.3423114627436984, -0.25695133979093726, -0.6351036223926075, 0.6352985060372898, -0.29995963657525926, 0.0026100669963117864, -0.7736850412449917, 0.08183537948645961, -0.7848998643408605, -0.5460123166680655, -0.2988577825084345, -0.29152329337691296, 0.31749541320816344, -0.5526318988971105, -0.022913616800013924, 0.2628579573852103, -0.655250804477669, 0.33497848746018066, -0.42787621694703043, -0.17819499263251484, -0.49019008565469335, -0.31099833157203227, -0.48345056449770163, 0.4409028505573229, 0.13071566870976603, 0.08461492795675858, -0.4983712658875966, -0.660723764029317, -0.7413334480478727, -0.4539903660403192, 0.07556903308216226, -0.5375738373286875, -0.7260366602133552, 0.19489308301872332, -0.5682782080838359, -0.41052436383872976, 0.3965308858512317, -0.10584712728393456, -0.08873269967345468, -0.2812247109119324, 0.29225149899500535, -0.596843230961411, 0.17291709691702412},
    {-0.5210807247378243, -0.1661475226468754, -0.5899031841881469, -0.1345714758467386, -0.3321625486526683, 0.45819913933899603, -0.21308259413170894, 0.4437866823684864, 0.138084920936216, -0.2365188265828544, 0.2505641578324023, -0.22500514494624535, 0.40686892916854, 0.05172959246988264, -0.4857863978605636, 0.22926993640950022, -0.5584516006167691, -0.17733782366753661, -0.3141750367200486, -0.23868910631847473, -0.6935007521221668, -0.3354546032946178, -0.3218492131630039, 0.14243890325241507, -0.2317249266598548, -0.0449849487445831, 0.17212445512364424, -0.1581341568892387, -0.6150615670046629, 0.11837002539149176, 0.13580214283336114, -0.37984192243481696, -0.6123720803019627, -0.1426354192333026, -0.06590459844160576, -0.2826158805004176, -0.7194826906283381, -0.25606134783311596, -0.7038747163117364, -0.4724314627899398, -0.3787614516152054, -0.2663046822998299, -0.20703153902293284, -0.35413206415040993, -0.5470404339617583, -0.08082851810249754, -0.6758643010642185, -0.33597466634016765, -0.0686352281406504, 0.2439188563531393, -0.15405880998555863, -0.42928008624069425, 0.15925453223673777, 0.4085459791426552, -0.30889598675077096, 0.30896553115351233, -0.2239787440221514, -0.3391470300678344, -0.16904719676420782, -0.10183149505023194, -0.036462002364739024, -0.345617765862199, 0.24918524700944514, -0.6606085857645171},
    {0.29186143293254463, -0.01118092957807334, 0.24865916474940872, -0.15344012368752427, -0.43876723350577707, -0.4719066999928846, 0.4103620275692715, -0.4834912219276944, -0.47041281249220646, -0.23798747024589853, -0.4406179771064949, -0.2890718833763236, -0.13051523239827392, -0.24279833576047455, 0.2938578405609449, -0.1216135847073357, -0.10051357314065258, -0.1831001698567324, 0.19085418737119217, -0.5236536247283395, -0.08692155229598499, 0.02159578102004459, -0.7254996342796131, -0.9199510772975056, -0.619549969265935, -0.37399355571613824, 0.019054425899188394, -0.4214401964697133, 0.1967512873480139, -0.48570283976694495, -0.08027345197111015, -0.41204525961170774, -0.3839695356818286, 0.37434658854940644, -0.4731189052888307, 0.017881341405276086, 0.250222199921302, -0.5508437165817923, -0.10513384324993508, -0.5295418015619692, -0.28690756221024666, -0.17005461748607484, -0.39594011906336424, -0.4235523888444949, 0.13529070785303454, -0.2069709131765916, -0.10627527096697864, -0.541494253679105, -0.16650285431674694, -0.642524967101963, -0.48051330080137405, -0.013735064144373877, -0.17348585099810837, -0.3695119219610903, -0.2836885243473907, -0.3803170871434614, -0.751502083998863, 0.1412256721821083, -0.6357545811745469, -0.5531008432844534, -0.5150686822097373, -0.08249787128956207, -0.2954150385390066, -0.3201024264697288},
    {-0.21078340068635648, -0.37214078115528276, -0.29565406785687176, -0.1274632278285564, -0.48636340265984174, 0.2618959902805059, 0.04227799026698031, -0.9085688747543809, -0.3508253640872915, -0.5565560808220467, -0.5936368578883897, -0.570162665663945, -0.22113171262829195, -0.3419545175931534, 0.15684710934242116, 0.20441985895095074, -0.5706983723447782, -0.17725745201793872, -0.40605755691660983, -0.4485542926217815, -0.13015077412306844, -0.30489863258292405, -0.27570130323258685, -0.7858459305252654, -0.7069548474744595, -0.3899406521090147, -0.32050344464300873, -0.4706143414644649, -0.2102205055439287, -0.3772527921024823, -0.40221947278911396, -0.10979796476287187, -0.686034200934597, -0.2083322907714585, -0.44899047831570915, -0.3295866563692268, -0.537102535224425, -0.6648996116095107, -0.33570650404668617, -0.6357539829517154, -0.40656228511575443, -0.039601571072154444, -0.39139810676086845, -0.5005583265207045, -0.7176783760160623, -0.534808930607759, -0.5872825928187405, -0.7918500194247788, -0.18640269032886045, -0.4481555877064141, -0.5063046304740113, -0.6082109748531859, -0.21100669456289073, -0.12048119433269247, -0.501384775368292, -0.38760648643988704, -0.5294801833587457, -0.2639832918779821, -0.34367488434840726, -0.24171762324728238, -0.22928628117683902, -0.5179368599163804, -0.13822733619868569, -0.36886510991948696},
    {-0.6643343445742468, -0.5519782887527096, -0.5609845551066701, 0.0008372168679831688, -0.888345221758332, 0.6365745908383078, -0.021938333079535247, -0.3052874028893768, -0.08075424974319187, -0.6242709462820432, 0.12465229459550678, -0.46149416335543164, -0.013797579829322719, 0.07751933105560609, -0.1477963843257168, 0.14725679148850246, -0.4346797857155303, -0.4632729871463197, -0.19933068726524067, -0.2611470944311001, -0.7108243183069441, -0.531615632663899, -0.18110212258218297, -0.22898883440385892, -0.4641349894867806, -0.41451552298408273, -0.014022816556323692, -0.4268413967026163, -0.8479698716480966, 0.32046938295779914, 0.3595993946697059, -0.6252822238321131, -0.6680895973049996, -0.3649876090438896, -0.44129816620490236, -0.20792986723939913, -0.6120172518316197, -0.6544044854189859, -0.4219106975553089, -0.5812330220365234, -0.7671328805725353, -0.4775931376028254, -0.22519197866778495, -0.6767442319902315, -0.5810142617630155, -0.4891797282610393, -0.6375805520711719, -0.5197801924429676, 0.23372731256086718, -0.06481093600228402, -0.1735288695215486, -0.698609695047224, -0.030062267052310795, 0.17097682086310356, -0.631524755802331, 0.17162915500226056, -0.30804144240808234, -0.09843518522714974, -0.07676236860954441, -0.4063412053433584, 0.12738293255417438, -0.6970275432306445, 0.2332412554249252, -0.7647887716856011},
    {-0.4257137042026488, -0.3579168589206032, -0.1678782436035414, -0.21160548705025964, -0.7028918485545482, -0.004160958245793899, 0.2899548473758398, -0.39641994847551054, -0.48873939706389563, -0.28294554361091434, -0.39961911977205017, -0.28231106650905424, 0.34030192306358054, 0.09201699954749047, -0.19635523434554208, -0.19793176259112677, -0.5825747548234725, -0.6504928225066245, -0.25652028687276274, -0.42909250739457216, -0.4608581288370278, -0.19485465480659492, -0.4252776919452099, -0.26131831926140153, -0.7324906932923867, -0.6348435238445422, -0.3177698544029035, -0.6251227809534976, -0.496594625633233, -0.15638103407472903, -0.08854031942803267, -0.5069566289014773, -0.6333360755062752, -0.11924571265049395, -0.3022343270882526, -0.35210271548842126, -0.69568647562094, -0.5337434183139401, -0.8569243633212517, -0.6807392660727443, -0.658256554258975, -0.22526471896393835, 0.18368314649247713, -0.2818875815925848, -0.6464421427591711, -0.4931229155875374, -0.5959376956331318, -0.5915233528279341, -0.15139284505491565, 0.1804531001462684, -0.34961485349292626, -0.6139491598102277, -0.16481432593527348, -0.07671786930661562, -0.6839924888771364, -0.15415835256700344, -0.44978359406234714, 0.003762617274528066, -0.6304845040264802, -0.2945946706715859, 0.05223522473046828, -0.6003909464625926, 0.18341616642600667, -0.7153407892627911},
    {-0.19088016931873944, -0.5066265260961363, -0.62769022817828, 0.09285609832458178, -0.3503885972866822, 0.5048990629661207, -0.0822015166895246, -0.42920913053714926, -0.3255127286325867, -0.8680672364825405, -0.3964821219347222, -0.34149117691044906, 0.1135468772214813, -0.203656890373163, 0.190732475571706, -0.05057545188459317, -0.5323933767339223, -0.590699139048599, -0.2675264441480595, -0.6353912615565168, -0.29782911738110673, -0.2897570427111944, -0.7692863141477421, -0.4286176518253466, -0.6481764066367157, -0.38119583731857193, -0.015529101068337096, -0.8045853039615479, -0.6784847719486288, -0.5045382643392077, -0.02258353682730428, -0.5892969481581469, -0.558001245150493, -0.05159660055267377, -0.5530425593771876, -0.2495587527575042, -0.26991680450841704, -0.33495724080005823, -0.6379807441876516, -0.6491996546684378, -0.4850282939737766, -0.15646061119243654, -0.33937657729977927, -0.33730742000267017, -0.3660855680482782, -0.2625473218628507, -0.34939942699187815, -0.7324974748737709, -0.10599372053526691, 0.016195354465016774, -0.6156454294435628, -0.48899266291147997, -0.34727800889922017, 0.011550875418866145, -0.5794277534592241, -0.23897935134904713, -0.22580375608534783, 0.14224815897145848, -0.6029626104852116, -0.36538426394362766, -0.4697447169096204, -0.6491085918391699, -0.2619080049184149, -0.6972356234779633},
    {-0.4644709466606334, -0.38897317769742284, -0.17955279979267247, -0.31530170445176753, -0.5283135454505511, 0.30530420631274696, -0.12206583010958258, -0.14495093034707204, -0.09917625309931387, -0.6492252058923228, -0.5210536652722305, -0.644272241899354, -0.010807109832238267, -0.2888894654682781, -0.22846490895087923, 0.03934377563712612, -0.1226721398324961, -0.46428693047368835, -0.19426466221910302, -0.37294423607807536, -0.896991304073952, -0.37790847237129166, -0.6107456962590272, -0.21061796569763144, -0.6645849426964976, -0.3329198348295095, -0.0814234183788817, -0.4485548893271174, -0.35382028978984875, -0.12731141342676577, 0.05898855100927317, -0.7259566419250245, -0.45943652049815303, 0.035334929939406366, -0.6013486244605578, -0.24647649136698252, -0.47310698111474664, -0.3602808271139966, -0.35259261634419964, -0.7187151849612233, -0.37367951135526223, -0.3856045071900626, -0.15598127117643426, -0.3315574095538458, -0.5669591303739128, -0.6261535344425051, -0.47626684582084977, -0.4894676258153756, 0.13053763464553894, 0.07747331760944809, -0.3765532359035009, -0.5065101484863689, -0.19423406029366574, -0.10554976035297044, -0.3773244753429462, 0.16201227522057468, -0.5599279084564818, -0.18530162434283032, -0.5651863402863593, -0.03667527249932994, 0.0159060233586255, -0.7154521365944659, -0.03975204161627286, -0.6915574688262781},
    {-0.26175484688302136, -0.2575674323488074, -0.651832655224864, -0.15057392040628453, -0.4656908265169143, 0.17672420636791641, 0.013257708685911513, -0.46110739594316763, -0.00805836627547885, -0.6512005453590268, -0.19483616893348052, -0.6657368500184332, -0.08776105358365999, -0.16276978516641508, -0.1042060190607373, -0.18910214099449082, -0.3363592672932967, -0.5623419830496036, 0.01876737227814986, -0.3300742604176431, -0.618240827530303, -0.44002865753979914, -0.4129381810485191, -0.24341920253143234, -0.5617445440952554, -0.5411632771976356, -0.18150688414586774, -0.4655909783856251, -0.5118506378075744, -0.12585496254506268, -0.15341976178393002, -0.4065419012255698, -0.33315904625905, -0.3895350456953887, -0.5587374464213334, -0.19807969151716634, -0.16337915414570095, -0.80668704192584, -0.48687352598452127, -0.5316612612954263, -0.8039118719231693, -0.6459538298844172, -0.08127525402213538, -0.5335656716325233, -0.5363443747667626, -0.7351741162779556, -0.34621569746366176, -0.3639809677657741, -0.19402204603530518, 0.1888498201525975, -0.3976791884907197, -0.5659467737949943, -0.04735245842837677, -0.09518371808019022, -0.5759028105555912, -0.003206745337753069, -0.7594067997644587, 0.012199799489582363, -0.7264519519591109, -0.48014425813041917, 0.45461890318303966, -0.7223254680102118, -0.06252138687611267, -0.5686502393316041},
    {-0.330466544929575, -0.6371709385127023, -0.5508071664345346, -0.14981413818186912, -0.47522937611212557, 0.16459993914019241, 0.05888123396040472, -0.653491791682216, -0.22112181535935807, -0.5383109082984213, -0.1192282972583247, -0.5357250534297487, 0.5617563483645509, -0.1440346246330263, -0.31808911624668146, -0.1663042728883918, -0.45716569028997367, -0.6484670408591608, -0.07809216247270707, -0.40844905815766347, -0.8102055822895229, -0.2325344844806038, -0.07226137687410072, -0.040359035257171015, -0.570100887055548, -1.0162441722539917, 0.13746697572474903, -0.5031047720446463, -0.5593950321089111, 0.18584148736373465, 0.0858270617384777, -0.3717014507969176, -0.3426582648601979, -0.22020123519591148, -0.5542317214792267, -0.47015455035547504, -0.5817728993171405, -0.7542870427512536, -0.5451747393596604, -0.7826118774643064, -0.5400096724024249, -0.5542907198141819, -0.05677314167168794, -0.629629037266937, -0.6930746223573557, -0.25375036486834274, -0.6008362347835818, -0.6339656164849994, 0.04616139475410597, 0.07281057659895525, -0.1500261397241201, -0.6791137340582485, 0.08325279082106025, -0.14393387325343832, -0.5681153707833896, 0.016098995717241243, -0.602057244632544, 0.0014112868830504911, -0.5651142985704168, 0.10425819757040568, -0.2818069650289875, -0.6200015200724731, 0.04411437516353758, -0.5325707284719448},
    {-0.3890236696864415, -0.4648597857195725, -0.6403619647725404, -0.29985522899589334, -0.6691288092139318, 0.16530735228034027, -0.1933092448245007, -0.4004353267533309, -0.420015511033707, -0.6346230493443992, -0.25932050264144285, -0.5887404527462785, -0.1354243474500598, 0.034432993862173016, -0.06954542946209313, -0.10084296569630453, -0.2362930352642637, -0.5340010842371675, -0.4893810070321928, -0.3769985595896594, -0.49502949261150714, -0.47384380707657275, -0.4686222968815369, -0.3142969744939603, -0.5423798883446419, -0.6479548211486651, -0.06441471634396624, -0.5128799277448148, -0.45447374987486716, -0.10948865701268203, -0.10716151622557865, -0.8490113456576535, -0.5018125712450798, -0.1009381789632412, -0.643622848876276, -0.4145469306468459, -0.37239561142107547, -0.7064049205022839, -0.2501436051726725, -0.5682056461883495, -0.4677855499117301, -0.706404550419456, -0.26087552408431697, -0.6459763414149341, -0.5960285104713225, -0.4375936879273996, -0.28272867939654917, -0.6174067065357463, -0.22376235202473777, -0.20957509887265258, -0.37304085633212625, -0.80018622270907, -0.23200145542189465, -0.06996255489697611, -0.5386091260917002, 0.05664069883584515, -0.6830073673591129, -0.015322289067955457, -0.5802359074301535, -0.21382914475068632, -0.06566292204728473, -0.48932314215123907, -0.2791872468716067, -0.6394887532162274},
    {-0.3922436096539713, -0.6303034638966574, -0.3190647097931665, -0.10967269053191378, -0.47912793475407794, 0.10208731151904296, 0.1614107366284453, -0.3637445727441023, -0.48702393740998484, -0.7565788226798487, -0.5406872068228326, -0.5573039365203527, -0.1080332475273606, -0.0569035289152335, -0.25850965051925917, -0.06613568830101675, -0.45767346217236954, -0.5469506508819311, -0.5029420816584346, -0.22174814284347363, -0.5804563128575296, -0.23573089511067982, -0.45908575916158567, -0.502779645957941, -0.721046554689184, -0.5450754059057837, -0.3008186456618567, -0.8225517204472096, -0.5277251240375366, -0.40339674003483816, -0.13131383737901947, -0.5773486472721079, -0.4184374103759157, -0.051244021506976746, -0.5509456468006804, -0.5136215034739682, -0.5490406408189596, -0.7114686192808669, -0.24103144839913865, -0.6715942192339008, -0.9721883173184349, -0.3801988087460589, -0.05769938205137353, -0.638944953017337, -0.31838027789883167, -0.5979234794268783, -0.39563119960159004, -0.643936809902806, 0.09945852489403599, -0.047061908867234443, -0.4775631458518308, -0.7092319793177497, -0.24866610161039435, -0.16192869634262633, -0.6383409235542143, 0.4030642067983882, -0.570105599586477, 0.13606032937653803, -0.4748594575280803, -0.540871222144465, 0.15458550847131983, -0.29208861907578115, 0.24962463866800408, -0.4854865375192339},
    {-0.44294822713989895, -0.5210680618321136, -0.6849107981988733, -0.0669497625470711, -0.48213338750099294, 0.0476378795765905, 0.25720035704578376, -0.35907511888605975, -0.13986519079147952, -0.7676761855939901, -0.3039263472660328, -0.4475677483570497, -0.12946651779698268, 0.15582210420849113, -0.6210570904321886, -0.13583830137672542, -0.32379714298761697, -0.6304496022474314, -0.39137171880464466, -0.2542819812202606, -0.5876351479285039, -0.39732346557911574, -0.5695849193267205, -0.5765821533137802, -0.5645364416057879, -0.8791595799524764, -0.03400430359593009, -0.6103279079174562, -0.6869073435077323, -0.40656248138648493, -0.16471412822902828, -0.6104886826851371, -0.9138335434492502, -0.10571098933643748, -0.7423271056122152, -0.5431971831947106, -0.6404122455018557, -0.7744372926903271, -0.789157116320938, -0.4443638968753963, -0.6687679294063049, -0.5847520493618801, -0.37544135645367727, -0.8614472890592421, -0.4357878421067494, -0.5928222025319047, -0.6203849718440966, -0.49635530363980873, -0.4659307258584592, 0.1530310485577731, -0.2751803205047246, -0.7040198272220185, -0.164003885596098, -0.08243725310149179, -0.729868248483305, 0.33658496086300166, -0.6140646313196825, -0.02065835985742892, -0.5275066112516039, -0.1281636797741804, 0.23824368640305163, -0.54178630933728, 0.10037054200999901, -0.7618972376497309},
    {-0.6133982127762536, -0.6264015323349288, -0.45279071067303434, -0.17177838852283803, -0.4961952376283922, 0.253220383507118, 0.16772868332781415, -0.7264495085846104, -0.11886020636449382, -0.483106377320012, -0.43546451460792124, -0.5059352032128283, 0.17386141582574552, 0.13709702698812792, -0.38293783878930804, -0.5286530025404649, -0.48041533281527365, -1.0132325304401293, -0.34329520110507283, -0.4292198824416164, -0.48807097812197864, -0.4857690538647757, -0.6230566328584469, -0.7102781636296026, -0.35790596415773834, -0.637801013780575, 0.07415891123365542, -0.7777853526359021, -0.7853303701079417, -0.10298450005199344, -0.012306862794056399, -0.7173221466925511, -0.7254129015599445, -0.2152129708926457, -0.5239863262789843, -0.4109979415959999, -0.5571506002154176, -0.7239951834677084, -0.45840619631610835, -0.5181902363367956, -0.6648406994976176, -0.14531117586478734, -0.42663059139133086, -0.45969076221944205, -0.5515396495566695, -0.6098836293421794, -0.8262831058043654, -0.6631492625128109, -0.18764370555501356, 0.17057949948797876, -0.38722983164148883, -0.6436767970050297, -0.2669721263537881, -0.33544658071744576, -0.5493968405503058, -0.4801191518424216, -0.7994465139170813, -0.24911867008531552, -0.6820516862110629, -0.10016484478803975, -0.2026119779864175, -0.6107032364557425, 0.17600026297862037, -0.6466847860292186},
    {-0.5590880760641657, -0.42335774419259686, -0.48099064155343557, -0.23452394902125734, -0.706206321861739, -0.01723474211029105, 0.22439130017386358, -0.6390316214657354, -0.25176062434316615, -0.7335893177754272, -0.37763067685476565, -0.4148585592183861, 0.12252235904510542, -0.16302444142993364, 0.13750424203642891, -0.3222249065119789, -0.5866876969658451, -0.8337735307136994, -0.14027230371878976, -0.4206499319587473, -0.4819294223879144, -0.03719896571413195, -0.5680580909169364, -0.37901892813256677, -0.546372326675762, -0.5487235515783062, -0.10121705461869897, -0.7894003152760808, -0.5324804243038233, -0.16192314243337919, 0.0970690615856992, -0.5099766914934803, -0.5545542996168128, 0.0818157425429726, -0.5689544947002965, -0.39563417973991044, -0.6725391715705885, -0.6202390226169572, -0.31452240338691867, -0.34150939038867995, -0.7145734613669446, -0.4171702142766692, -0.3149462137244613, -0.6781964007204112, -0.5328558697785871, -0.4539648569223936, -0.7087058991021312, -0.655731534496631, -0.27918685633108664, 0.05560988637623418, -0.274856641058067, -0.46148756800029866, -0.15153714863347434, -0.07361115497257817, -0.5845603773632779, 0.14398576958694326, -0.7582950389823424, 0.14830660527188594, -0.6426591857864177, -0.4868361363611146, -0.0708802022009862, -0.5788106923694223, -0.33955951454076705, -0.5570298786519591},
    {-0.15435449318083522, -0.32080971799625924, -0.3135620458484352, -0.23658655365399076, -0.615734189608391, -0.35053474520843564, -0.07244757704001974, -0.6717097779014547, -0.36485487635906955, -0.5615059659083743, -0.27634400609229665, -0.10743926827401665, 0.012921642754576817, -0.0737556230897003, -0.015781847254606556, -0.42075503628637717, -0.3463413425332921, -0.7283653992283656, -0.2134412372000784, -0.409662104616691, -0.5482347926048728, -0.08702909893701466, -0.30467566006353536, -0.4152952716989353, -0.5601209347575968, -0.8533261035817027, -0.06556547077526118, -0.7686408572332029, -0.3640043098119635, -0.10079449646478841, -0.4393551231515334, -0.567396638474008, -0.9032112046493176, -0.19739479386953854, -0.6938701081065385, -0.24347746852273494, -0.6052040728822385, -0.7979710372678868, -0.41901410392762023, -0.7127138529739676, -0.4735661365490303, -0.43050241572938613, -0.5947752503231035, -0.5626399895006855, -0.5320336009579799, -0.5748989067028324, -0.7085736948215806, -0.7007726380416686, -0.26072010318382827, 0.15444477508111393, -0.4181718618322848, -0.49183893652930133, -0.10376464877146323, -0.14857922941083915, -0.360228220823566, -0.17962015471723275, -0.64812942831322, 0.1680919760460703, -0.7977496567943062, -0.3504083635180188, 0.25144826633729117, -0.4799086153454473, -0.11365272166552007, -0.25036029608957094},
    {-0.18758001051109693, -0.4565459064808865, -0.3276557015698941, 0.04456351001851202, -0.9313499366339768, -0.21390743276023172, 0.2120307544273502, -0.52610056498428, -0.38662627931167187, -0.256135083255332, -0.3605718025954364, -0.48797944287264483, -0.14537467646412644, 0.07177392461644846, 0.10857350842319913, 0.046778724372019936, -0.23481889369826994, -0.46308383268377545, -0.09816299619405236, -0.5772467046446207, -0.4508122999646055, -0.3315133589137705, -0.5202362298716648, -0.6026275855034438, -0.689751812679168, -0.6334595368719237, -0.09379691757937324, -0.561552836916808, -0.34335786266792107, 0.03945335432701614, 0.12189376254931399, -0.4931193202185676, -0.6292863270757801, -0.16823875137430566, -0.8311500915910613, -0.2207376746952291, -0.4252671269967942, -0.7637502559534541, -0.2592387902026377, -0.5292505656980296, -0.625867813365795, -0.45106022915269317, -0.04303310812700655, -0.7042400146650675, -0.5930227731657502, -0.5187078279971933, -0.5036676676025148, -0.5794989269421569, 0.07636086837012156, -0.12130642313115429, -0.3729491347842727, -0.40606428239702363, 0.05078925245589537, -0.11779083501064012, -0.3424243576471676, -0.12311083692831944, -0.5384267342756383, -0.25357254802609946, -0.5691408019628079, -0.05031375240899313, -0.03977452333209752, -0.24973858356624792, 0.1923176082721472, -0.41757226406705467},
    {0.027216234987187275, -0.18256131061206424, -0.29665078129041084, 0.060015314536512744, -0.7042034561024498, -0.03769767728088244, 0.009506376293487056, -0.5133124100779705, -0.2016067152212157, -0.21033999911172804, -0.0784888999046835, -0.19089925350571407, 0.3339601263728007, 0.4043936629144504, -0.2677470382219455, 0.07840421373735738, -0.37564750042228956, -0.1697300041677293, 0.25413529579103694, -0.2210339013409034, -0.5375551364211528, -0.009909632830016763, -0.16035601554253884, -0.3159849238595353, -0.5294738854358673, -0.5096129803483304, 0.3509992393746266, -0.6249412896020817, -0.33122098785948295, -0.014402987364511361, 0.15029643839689874, -0.2294463256251032, -0.3603920129597548, -0.20915100268350212, -0.5653616397942796, 0.02964800160274192, -0.3345446803102659, -0.2745851867222261, -0.4065085537806871, -0.5182853752196532, -0.2079826552618102, -0.22568935631806822, -0.2627321066718648, -0.3378455125004422, -0.16365733350289038, -0.4697085703338292, -0.20060494933529166, -0.3507050482630771, 0.22548562427114716, -0.049302679556719596, 0.2261800693887818, -0.5858217630541822, -0.04303842182570825, 0.2518359581583941, -0.3947283902794069, 0.32121362034282436, -0.2682798541996047, -0.08008000743280175, -0.31827928915208314, 0.11829510901860142, 0.1285069893259484, -0.07553899563745432, 0.027176970761389984, -0.37281786471194633},
    {0.011033803475550654, -0.44503337508559826, -0.30255566208201945, -0.375477826363305, -0.5488767809048172, 0.16936064212867755, -0.13290982229530285, -0.7498254846134816, -0.6268167133698159, -0.416559997528429, -0.31413673496765593, -0.2630457422631145, -0.17676359774309022, -0.019107165377492172, 0.07867391449187419, -0.2809221651159957, -0.440893616237955, -0.657859390437151, -0.16383494808506358, -0.22119010435771091, -0.5065764010999372, -0.0205849290849754, -0.47089315058991515, -0.6036401814814332, -0.30507622721198774, -0.7803777527243428, -0.01625808149479936, -0.6049059039796841, -0.3744812791923612, -0.20200424272288242, -0.28186038947046327, -0.6379894214741358, -0.5558249843807416, -0.09452558726237509, -1.0601043367349792, -0.28235749352742606, -0.08455560569096945, -0.44865621680008644, -0.37010089042933303, -0.6307949611585387, -0.5937772031013545, -0.42265183143113294, -0.26206703117406854, -0.4037236778769916, -0.3934133177656227, -0.4107720579027715, -0.4339763051941556, -0.5769911143303357, -0.11178334053155459, -0.010848640682210876, -0.5170859022084625, -0.5731462927649426, -0.07099199574768203, -0.25988712690314614, -0.413332796642671, 0.13645598761018632, -0.8518482880107161, 0.2921865296073694, -0.5719820088503748, -0.33456297263488544, 0.08601825438300606, -0.2856311221475256, -0.27069929257895264, -0.3709116801426169},
    {-0.4897582328756273, -0.8486825188365734, -0.205271097843187, -0.4468350503684261, -0.5826443829539028, -0.21938618644153224, -0.14556856922199413, -0.6947872295434964, -0.4815946247408792, -0.5602386085668838, -0.5944707355048059, -0.4733763686728086, 0.021093606606084506, -0.10724547395162852, -0.24595431510912252, -0.13438782420725845, -0.46564194674825077, -0.6538188856664361, -0.5170218758457336, -0.38750694676754943, -0.46387462990195644, -0.23717865281154654, -0.43511759065149636, -0.5905690748074787, -0.5232484873934282, -0.8066275459492467, -0.3514278647096978, -0.5812335011870708, -0.524213751714816, -0.16328229026101115, -0.2503383580998686, -0.5947644629420918, -0.703143552922444, -0.28759231392099105, -0.6443031270422891, -0.40862690101140253, -0.5531009116349039, -0.9007185364689698, -0.5745468476743593, -0.6168372308260579, -0.9547698994751381, -0.4041465568991961, -0.5029283405089622, -0.4184406027409063, -0.520269116770407, -0.3905492713102789, -0.6889409661123286, -0.40929152804939944, -0.06642360657826964, -0.1333153294245176, -0.5708351708723436, -0.3419530682932297, -0.2631371431361823, -0.2310567823262902, -0.766827918671904, -0.10306612866659046, -0.9113267357268385, 0.3053544192279517, -0.6812359633345025, -0.14609624865956158, 0.026500578276091452, -0.5389313265525627, 0.1423812356117631, -0.4992897962122183},
    {-0.29550818321602107, -0.8589799666878865, -0.4482189787257712, -0.2763605368602791, -0.9075212761742523, 0.21353922563903696, 0.1501070697964417, -0.42711983383872176, -0.38554004699709893, -0.8037668871841885, -0.4366520269274451, -0.43000234843793284, 0.26417716358208787, -0.16167149029385602, -0.5331819138707966, 0.09901246443959492, -0.6195388148959704, -0.5494118822804063, -0.23043493243402677, -0.807269168206382, -0.8787525328836602, -0.1662814058043789, -0.3728056945121796, -0.7059005245705143, -0.9534316055439711, -0.876724176473373, -0.09548603498654855, -0.5399858185302068, -0.8033229939753859, -0.2977802232393978, 0.15838107380434807, -0.4300451703471156, -0.758456080812251, -0.1814439050858266, -0.6890370874716137, -0.7005142555816338, -0.471609670613297, -1.0052852321429093, -0.3121844955067654, -0.8052473083997814, -0.8700571669945136, -0.17694797874874116, -0.2646898472534808, -0.5437253655063614, -0.6741858195683168, -0.7781582749586948, -0.789890650934867, -0.7704953108573572, -0.23413625865769197, 0.03403916108719394, -0.49415365083380014, -0.6941075989313239, -0.12177077104336251, 0.0012284629267132982, -0.7298690499194854, 0.0013200335114018967, -0.5776243356610713, -0.30227759610014987, -0.5814775816302775, -0.3646817485005267, -0.00030049870882477796, -0.6406427809299405, 0.24844577796830344, -0.5189709144351519},
    {-0.4974904592252948, -0.5802039837447717, -0.6434659066270614, 0.29813525625018283, -0.6091015563725669, -0.006120053470296013, 0.16995813199309198, -0.44747353851891297, -0.43708522405596156, -0.35157921192417807, 0.1359748880485813, -0.3670009335506897, 0.4851130334614909, 0.12337609068340613, 0.06563092722941294, 0.20825324856172972, -0.5583120232091038, -0.4737026151977299, -0.04852211629849575, -0.3206780912766725, -0.6942485658772956, -0.3798777866112074, -0.0949677662601229, 0.045848983760813374, -0.5176104691259451, -0.5810041829203499, 0.321413766443207, -0.6138529136998225, -0.24435539757237948, 0.021013093561508826, -0.06882862948984828, -0.6819680893082555, -0.6509165181278052, 0.15924880561540217, -0.1263382127486042, -0.3986401864132408, -0.6341631417717826, -0.5097158370635386, -0.37173499047783093, -0.8332591331609461, -0.7225968764680217, -0.39658482326775724, -0.18339013203159107, -0.28161059028594837, -0.4823655111190838, -0.4208244532485001, -0.46622148262151497, -0.6812064389255263, 0.18472043718893957, 0.37293575879257596, -0.11992796012242704, -0.6277613564528449, 0.23382615051984024, -0.41805033664267977, -0.34328968384800645, -0.15498801577464988, -0.6871012934893221, 0.21610465328243308, -0.510601717019041, -0.10144510539963619, -0.051812978580348244, -0.304751014105769, 0.008296083466758523, -0.3521825679144219},
    {0.14811198646731266, 0.13373507192598483, 0.12296922927970888, 0.3412373621777862, -0.3963954877301143, -0.1858800867020148, 0.3435050175846519, -0.5877237054502312, -0.5102715217135462, -0.08162943524600165, -0.21564917350300006, -0.07337559030791074, 0.45394805228122115, 0.23588973819958287, 0.4779246955122916, 0.3612929998994798, -0.22795281583698318, -0.46193845337617007, 0.15972441358802766, -0.8239255684131515, -0.29355001980860834, 0.1140496848198364, 0.013638186234800159, -0.3530377217323861, -0.21171943373956745, -0.48793532249104415, 0.2650277535617394, -0.7337476319359434, 0.14310094156761047, -0.22585671128888846, -0.07208740207554126, -0.4407401793629827, -0.6057058585920718, 0.7586059960874127, -0.6879945537383078, 0.07236404036590449, 0.2590043022808334, -0.3615485344651933, 0.37379536105256966, -0.7584536286523873, -0.25467991711069665, -0.3687374827439276, 0.10310533175997602, -0.12082032331251481, 0.023656777663089143, -0.09174669997886055, 0.11178965775829795, -0.5528289642023442, -0.06310726857894343, 0.07765863630563996, -0.3876328148978392, -0.551237032606702, 0.38623559805152974, -0.42608149237821386, -0.227991648665044, -0.052050740183560436, -0.7340783009998687, 0.7092617458892394, -0.6470324422812093, 0.13623377465809158, 0.38821525771903725, 0.27199802857847866, -0.04495651121804849, -0.24095279318044696},
    {-0.02515167927122821, -0.0064598564226188435, -0.1283598869044258, -0.05915861332986317, -0.6384074018873516, -0.18235362585845877, 0.33106050436483453, -0.7927954461244472, -0.7036096639284538, -0.26402783933579943, -0.39021813297462055, -0.1331690961173673, 0.30103315428587735, -0.38652805497166237, 0.41414430538081637, 0.02468723863685667, -0.3988766669141352, -0.509804706980907, 0.19921531716598656, -0.5510523599943936, -0.2967649476956276, -0.14141068445449095, -0.14541677645151352, -0.6436030536834498, -0.27457257838107896, -0.6579396394661835, -0.10586815155978278, -0.6587428228938613, -0.04501119554688651, -0.28659731056605114, -0.24183951605975015, -0.7191665878957789, -0.5929333060283116, -0.0006725930505142673, -0.719327068612238, -0.4189814394644335, -0.057908694610483535, -0.5952604872486205, 0.15721421151236467, -0.7378038305098417, -0.5585692305959465, -0.647693277511476, -0.35597474964804615, -0.4840234961612171, -0.45660422306118664, -0.6266459483396614, -0.3395870872528374, -0.8308733242247083, -0.16943678103375828, -0.4575166909647696, -0.7131348940298607, -0.7229917237243048, 0.057509415004674436, -0.37443716510864516, -0.4708523876631131, -0.23871664880078816, -1.0076477405445181, 0.5006776468829215, -0.8307350601912101, -0.05855025268469984, -0.027429053252606486, -0.12282696331223876, -0.20581520856324736, -0.5224356174337126},
    {-0.24075449326415005, -0.5298730440899462, -0.5946731519470368, -0.29021477052331673, -0.6673740944473978, -0.2736952210900847, -0.03271021413803841, -0.5538700320341213, -0.5628784252018916, -0.3739574547032056, -0.06379687142692218, -0.362371103211221, -0.03380333923736839, -0.237832774677013, -0.06425486782775663, -0.017914104550221212, -0.3683084267460886, -0.6994944724998485, -0.20607764074690274, -0.5784494808439522, -0.8096233127172712, -0.428384731129808, -0.6158493339540249, -0.6683484658753981, -0.47611366911339803, -0.6637328630800046, 0.11170313906300111, -0.6177418255994125, -0.6375971362632623, -0.4380061896773692, -0.10164206926526544, -0.7768809257162892, -0.7839355229782375, -0.17725969094486646, -0.6059779178746152, -0.55259065643926, -0.445945979174745, -0.8087169391619121, -0.19527571874967614, -0.838226795591904, -0.7252331266917961, -0.5286464052757234, -0.21817322084035487, -0.4783185636207132, -0.4948948090548551, -0.5517857486866563, -0.5821458679809295, -0.7052408126661577, 0.06932909685557213, 0.020087395150618352, -0.4318266253315669, -0.9908334871957335, -0.07600314529995209, -0.2831912166403139, -0.7261092216795135, -0.2695545822492593, -0.7035765297144336, 0.09422430841798106, -0.5619915723020774, -0.30108901928280535, -0.018114332208298767, -0.4980814941430019, -0.30652415369441993, -0.6836448876637845},
    {-0.06587886065078162, -0.10430397096242033, 0.07282992792545696, -0.21554053409775162, -0.7618265975563804, -0.5495305197613892, 0.3955147834840933, -0.8692595956469322, -0.4787207424337174, 0.05716174963306371, -0.33811561291769665, -0.07907844584173168, 0.06559502997997017, -0.13392851313648987, 0.47973828019254344, -0.05547035633605097, -0.24973929319842444, -0.666622508264586, -0.19929022773290964, -0.7676769874156658, -0.5390980401681, 0.057691663968927366, -0.44491852841712265, -0.6984615653693773, -0.01537578877711223, -0.8622354515738248, -0.28046263593075493, -0.6458776335071091, -0.009269383137901729, -0.4405257844350587, -0.22431108771269756, -0.5407997798178116, -0.43073065561452734, 0.1922964813892379, -0.6146074810330393, -0.1352299122220394, 0.1229064306838008, -0.7146222459301542, 0.2068783800113885, -0.6781469032214313, -0.4549593876567336, -0.40608182838002743, -0.32967938788163953, -0.5333352427709228, -0.1703659842593352, -0.3386373671661253, -0.3248436021163371, -0.472432865844787, -0.2348354209110705, -0.356020987828279, -0.48658223472142675, -0.3942722392539138, -0.11645325824450924, -0.28462441279409617, -0.5898212162962043, -0.45806702813995404, -0.8128033141696823, 0.31928211265068795, -0.7644692331552126, -0.16603562444484443, -0.3174242153231312, -0.1972464867339114, -0.42404300963026476, -0.4426579948638507},
    {0.35518712606731656, -0.15700725399884016, 0.04945802554792684, -0.14097813886951102, -0.5194692639233328, -0.13697017778255985, 0.3382925865624127, -0.5648965043001014, -0.10309559393039794, -0.10674566662122219, -0.149347253587944, -0.09386553989629569, 0.5501233328212394, -0.1267678682619734, 0.14396543481785354, -0.19065307939285023, -0.47463469004062425, -0.46036201016286177, -0.14126597060611357, -0.5950585708073501, -0.63605943880204, 0.3104438077799091, -0.5331058007534011, -0.2863527830507489, -0.2042670912104196, -0.7690380825309757, 0.05939489064317266, -0.47172202831245774, 0.09835688457610318, -0.4204276287173622, -0.2353004608118895, -0.7507504353600021, -0.5982328688553396, -0.025010070824133243, -0.41352416323671504, -0.22304743925275927, -0.1474668486255187, -0.7277413792609633, 0.21407017994307312, -0.9085433371889091, -0.5368769938843422, -0.3284674026100124, -0.05697973722722062, -0.7020163495543782, 0.03815710628038729, -0.10941635443620278, -0.21682886519559913, -0.6970862847540418, -0.2616351859378555, -0.1671689166394264, -0.5877865839597326, -0.714475950511485, 0.2183247712480305, -0.14864657825022345, -0.4015613979029709, -0.13404016668061533, -0.9846499571986644, 0.4248767003105111, -0.701681872434556, -0.07198432881202846, 0.030866833521499746, -0.2499373641951837, 0.37550685100295694, -0.623902868607913},
    {0.041331943651983616, -0.21087656033082094, -0.1023935826403885, -0.16911736851848225, -0.6752106045304068, 0.026410328472578397, 0.05814166689778248, -0.8824523889589392, -0.4930641479046954, -0.2914154809186664, -0.028688360103740783, -0.1541999140896516, 0.33622537429483756, -0.3432233445091961, 0.05591490602319098, -0.07886800940185151, -0.5863532923011996, -0.8272096397724102, -0.3042322269708926, -0.8699567870510188, -0.8985744129315348, 0.09330463712563647, -0.4765488945486819, -0.5438558050634819, -0.16605211760822836, -0.8742112198396126, 0.15776736891767015, -0.7501456626699926, -0.19533547881257687, -0.27414381102606666, -0.4538099360288808, -0.6849439643444354, -0.6325402572186526, 0.026021868185938244, -1.0262103654361054, -0.4149588681692706, -0.21412755749641385, -0.6221116596545837, -0.11709866691600489, -0.5332516420633135, -0.37912376464064695, -0.5764135807484743, -0.27714979749052604, -0.6235346040257689, -0.630200540040029, -0.21073550867692692, -0.8743317819289976, -0.6515068545095364, -0.267458618286099, -0.41392353832890827, -0.5862500596373671, -0.5616458657206614, -0.14867621665308714, -0.2354773859992009, -0.3349403840154869, -0.2533651809773395, -0.8146996808963316, 0.24606666165722468, -0.7321431060410614, -0.39139637132864163, -0.06553344180732876, -0.0842458594472873, -0.30029416567059897, -0.7831610730684577},
    {0.11011388996739424, -0.13767355903498013, -0.29422961367144373, -0.13957345357871867, -0.7218940249058439, -0.18765213652023582, 0.15968071618499435, -1.0257182364995245, -0.45881395788498763, -0.07389013086752345, -0.21271911425290135, -0.293463471241444, 0.47122951206782404, -0.10966302694581898, 0.16911468633854168, -0.03221756881716529, -0.3601264788680135, -0.6895621642184173, -0.15354683194969554, -0.6703037620163005, -0.4543489344915707, -0.002636413888957416, -0.5214343813051726, -0.6405364869134705, -0.3196403235503634, -0.7282061051624773, 0.2343409184138375, -0.8807819659541802, -0.10045585027866209, -0.39262893065322346, -0.18708112697597426, -0.5943331919961256, -0.6837534212803666, 0.179105695193489, -0.9489457537911904, -0.45516061024227245, -0.05974954696745381, -0.6553415936544215, 0.18851936627322133, -0.7664750530055544, -0.53618162649694, -0.41320222847634386, -0.3553723604745883, -0.3878866932768937, -0.14719370504260168, -0.05358997117836935, -0.2944666474345436, -0.71374554623296, -0.2700574932695743, -0.3939129691046479, -0.7278550598323291, -0.3280947353413058, 0.047992598614740284, -0.4867539264196822, -0.19930935193397206, -0.234588239124538, -0.814766278905815, 0.3036984653239746, -0.7922844986181287, -0.3295752323524551, -0.014762979679016982, -0.10614102744567448, -0.10895298828338625, -0.5220091594246749},
    {0.19355247440230952, -0.34919232189453303, -0.00028718439932905865, 0.12594628996782303, -0.5565513389468842, -0.28747715864596535, 0.2744723221852203, -0.6683658238486725, -0.37835484221474636, 0.1274082157414207, -0.22482487289425385, 0.004042254733393263, 0.3688153423605182, -0.13750512797402548, 0.4374273383676467, 0.17257192389185236, 0.004019513171284934, -0.6787790967437044, 0.19860614684078334, -0.584911061604592, -0.38344447501313406, 0.06478030637124596, -0.09315057479608942, -0.693404770062678, -0.1747196761456338, -0.7129792899538189, 0.03777117600870675, -0.7249070235984044, -0.055561676240842, -0.43332661008490214, -0.08448459607794837, -0.5139784401410346, -0.7942333849183313, 0.33979079579479576, -0.7612691570062123, -0.22565165281317218, 0.013071956057777601, -0.7683346612973488, 0.28485906304612535, -0.5807377841903021, -0.3263492595770561, -0.4373302100559784, -0.20814605413792264, -0.3540690884421186, -0.29143041896609817, -0.2433968971411323, -0.5214835476810586, -0.7635729924626657, -0.2064611813082624, -0.13560901629081584, -0.6169322847022051, -0.5847261725403371, 0.36899872524128696, -0.04895371086452251, -0.2088712247159322, -0.4452692126129023, -0.8548557803836461, 0.4714039852610719, -0.6856957999189857, -0.27532354093678346, 0.17477721868760027, 0.21010352345307634, -0.10621912048098554, -0.23968252709932242},
    {-0.048291196959225166, 0.5716584759005301, -0.03677226402756361, 0.472779024821665, 0.15301198368943655, -0.5347524658376003, -0.3301407499847032, 0.11928358749374388, -0.10059340363197787, 0.0036960307442339413, 0.14808849856581965, 0.3757005752851572, -0.1873366494102987, -0.38918889412404256, 0.2313091589386878, 0.3785791570527013, -0.4325975117231387, 0.406410096654222, -0.4705256624531727, 0.6680278663406095, 0.04832430025284676, -0.353870756011754, -0.1465345840824629, -0.03314075929431546, -0.5365857617696163, -0.6446946394359874, -0.7066558164326089, -0.12854793801772024, 0.18644756905255186, -0.43251673542644165, -0.5811050118245955, -0.06421589290935206, 0.5582483845706376, 0.041497734118970356, 0.03156252235094432, 0.15359083788125952, -0.16476742256669638, -0.40689029803042676, -0.20348104165688194, -0.42254008063388154, 0.22799698746112543, -0.09080381765133017, 0.6551043083017287, 0.17175851518372853, 0.13679543047154322, 0.19872790052363012, -0.4033959337855975, 0.6118065573707631, -0.7888849788679319, -0.018216687806674497, 0.052311418072981355, 0.11670720749627811, -0.6165466788735654, -0.3664254778502415, 0.5172825343665945, 0.23959417288418397, 0.5719716258565504, 0.034153534502063335, -0.5466552022159458, -0.8098742375806054, 0.5378175668272661, -0.3693682363929855, -0.36172822512912617, -0.15166329608227178},
    {0.026539995112263255, 0.44441112434501073, 0.4023404012736772, 0.5063563140467203, 0.3411312763645391, -0.2885654972397147, -0.5736552928076087, 0.38528670787680513, 0.13729736114233915, 0.25461966764146343, 0.38732606155769544, 0.60663394356024, 0.1852101105440019, -0.2698082331530533, 0.22453742595613777, 0.4333274253569937, -0.12873495403992063, 0.3533706327185156, -0.7052971149950664, 0.7926885709711446, -0.14536650092130937, 0.17537662646875046, -0.1689523981189653, 0.07154907263940709, -0.013165218315328185, -0.06347194348485567, -0.4177233587630482, 0.3091371982761083, -0.11861703720116108, -0.3916326596558267, -0.507118586882877, -0.027844403463065936, 0.308621734137316, 0.5910308712086375, 0.17638326488619943, 0.5738505906157424, 0.1658134715720672, -0.4086961952078155, -0.06803154169503264, -0.3635933235073269, 0.4302198814054681, -0.18633796479776793, 0.36757626654441755, 0.305779493559631, 0.19240018509175633, 0.39801621526959036, -0.3592424841287426, 0.2661123174120574, -0.5497370313484763, -0.12261496295953307, 0.585195945362565, -0.0296598746725446, -0.45497030154579204, -0.08429757262558461, 0.4225102917478406, -0.021213251772703494, 0.2055399357708288, 0.16097967571890867, -0.12194477269819737, -0.5966481722882044, 0.5358033565122612, -0.28803537126209855, -0.5576239913184268, 0.3015841458531356},
    {0.40442013097578955, 0.20694147036537075, 0.24871017023325118, 0.6726288172731699, 0.7037237906159302, -0.5378067410753534, -0.8455798260928836, -0.32619340164232524, 0.21456771974897593, 0.1604492583944645, 0.3773828722146844, 0.5166581018059326, -0.29427388932657533, -0.05915689702256131, 0.465699022884169, 0.80815101928759, -0.26560113402085184, 0.6412613205133328, -0.18873743470481263, 0.6602756568758082, 0.09531316494302451, -0.2018398875624893, -0.3755866124073389, 0.20465387474120172, -0.41462436496101374, -0.19040591554076272, -0.1810566563491918, -0.22980439082497675, 0.4343528838263718, -0.4860495192496719, -0.15815800351195675, -0.12183546800674906, 0.8216425043888254, 0.6180331482964041, 0.16805544242137363, 0.38509341888813825, 0.1475885909804649, -0.44165209807646433, 0.06504045059744995, -0.234546717007068, 0.5967742138755586, -0.6770569100980509, 0.3922239534293295, 0.5808294009428997, 0.4923822613265649, 0.5117680030591963, -0.2113601351715269, 0.3023179684978567, -0.4352552933340138, -0.0036541962222813706, 0.4489198323199982, -0.3914996280457554, -0.15925336653293862, -0.27891408727251216, 0.5434227160846345, -0.21154612733091493, -0.005942729380018809, 0.08180385733987158, -0.4093555418354989, -0.5139448876122571, 0.27103759232669206, 0.054822257516784934, -0.4339911964108178, 0.4065524496750512},
    {0.4418203378151409, 0.38917902335358756, 0.24666330603653186, 0.6991941381961738, 0.524893699021175, -0.34094600294870764, -0.7509050117855296, 0.05080178107742639, 0.185550488364519, 0.24722271851917293, 0.3210171258060081, 0.3716834557833043, -0.18467396506400896, -0.009013664240642552, 0.1239356002818992, 0.7057998884952493, -0.35571214248241895, 0.4675032137960881, -0.6062732908383505, 0.45591652276807926, -0.22929297091965067, -0.3888949558222317, -0.11378829180621403, 0.4839024501769569, -0.5219767177044239, 0.14977737343063663, -0.30006010628488006, -0.3074703001683541, 0.18291066073494078, -0.23071139236919613, -0.20895562344091595, -0.24128044651912445, 0.5070341057773561, 0.7861743121024833, 0.4987247134854331, 0.07261198708078144, -0.008055613096912759, -0.36982730152969273, 0.20183156002035657, -0.5500060262738046, 0.6250180930261223, -0.2921171831439196, 0.6118708468017713, 0.41565999436317747, 0.3694751288065888, 0.3703689850132022, -0.3276287267290906, 0.45455252596529744, -0.6404138387958199, -0.18119519064680337, 0.3676773918340582, -0.05411967989112775, -0.27628193203795465, -0.2271316317021932, 0.34617803966828553, -0.28002129944121185, -0.0028894626587321524, 0.2002017891493259, -0.12888684452588908, -0.8362095126177264, 0.6007821261708381, -0.1277145967256107, -0.4444484002266543, 0.32488301085221466},
    {-0.1371482822982451, 0.14638531770259097, 0.3993162191215842, 0.6389703340046744, 0.4558392429881615, -0.7317180463697417, -0.8414245062444438, -0.15561184425666527, 0.2593194479902672, 0.3173892295743425, 0.6468406907047469, 0.3956113341500132, 0.10327020937520628, -0.044400171813726005, 0.12450585492249494, 0.5225928972089466, -0.5469859696565933, 0.7139215938144602, -0.9516773791222083, 0.7552955092580306, -0.23216113204398897, -0.4506921141546, 0.011875158519645998, 0.7488764921615151, -0.5383445346425021, 0.18674942246007104, -0.285565922744362, -0.2933523029278878, -0.04528171013995288, -0.41603254115974053, -0.10474711089023259, 0.047600125392468225, 0.42830093611862, 0.6419071598362908, 0.42257703918182854, 0.15819766855297543, 0.2089301099739877, -0.04655453291962531, 0.21703907295934238, -0.4452649863542131, 0.4015551608236146, -0.4083904944636707, 0.23325594259503862, 0.10247739800576056, 0.1949782622194152, 0.4616001879857331, -0.42317108752071964, 0.4032179915250496, -0.5838671439043736, 0.04543575924601133, 0.4129409133376434, -0.2986972728428106, -0.4978961117398541, -0.039880896361101, 0.3650838555919393, 0.19097785180972346, 0.1898097296274377, 0.02162374265173204, -0.2753793404406717, -0.2992285167404868, 0.3844909551275224, -0.07718880177308579, -0.11622046602785556, 0.37912731014948603},
    {0.3369817307163041, 0.15802658676542677, 0.5605773990973807, 0.4540634228974493, 0.6891499980903151, -0.7706799601935886, -0.672067817235727, -0.14836445325292635, 0.21662393160327717, 0.12378817135947956, 0.39349502139874104, 0.15025067309468368, -0.02704484951154419, -0.05695838279143244, -0.05343115532623236, 0.5063288809049935, -0.5437404497628456, 0.27279115076335625, -0.754681848275753, 0.4594596248643006, -0.31814050426846824, -0.5012809547994089, -0.1962068509512289, 0.5476041626082996, -0.5757187211297786, 0.2531980618666642, -0.32268986854962906, -0.10567416405378943, 0.2349252260176494, -0.2990751731858882, 0.1406667713718988, 0.1840255578105086, 0.6992537762989799, 0.6162707408522651, 0.35127073596303826, 0.08437747564239996, -0.11404901037974331, -0.25338671341248664, 0.17523855865995655, -0.28851922214605485, 0.37864390847021046, -0.28471175188172243, 0.37928858474294963, 0.2932445371997981, 0.4265039973381026, 0.42691790420579456, -0.44669473892479017, 0.44747043521750796, -0.40962751958238935, -0.0053910510324015086, 0.37258655185408224, -0.4021010122480049, -0.6906456298264239, -0.040144272636328984, 0.4677627846459596, 0.023144139102911288, 0.2674185559896107, -0.06317722570255288, -0.14466484503899907, -0.4010150158936086, 0.5840844699546259, -0.47619135743822544, 0.14078660945053845, 0.2837508774137061},
    {0.3409780316749989, 0.5896145868315901, 0.7397965106449609, 0.3926768068175916, 0.6492754391028029, -0.6632822669696316, -0.557878831927371, -0.12000042749353915, -0.0818368324274793, 0.39698070103690014, 0.5923006047308093, 0.4504691813444033, 0.05029693868356304, -0.11055933479848835, 0.14062123620268313, 0.515274529777182, -0.7335061454210218, 0.8979708191184859, -0.8298188842171693, 0.46216280566946755, -0.7086235230798915, -0.5854936174048139, -0.2944189953659574, 0.3846011978355543, -0.5672847321948322, 0.30674539598024697, -0.3697750100546786, -0.1033846451024382, 0.276802855198887, -0.4791636966974717, -0.03178473242533584, 0.13150842628331227, 0.6865170138402644, 0.38158471751796674, 0.20375499208411899, 0.6078473315675444, -0.056636087984035056, -0.3844605500155561, 0.2863444180634507, -0.7940824669376285, 0.19754444554937367, -0.19514551554116605, 0.5600308657320368, 0.023058415933038093, 0.40601275985017643, 0.25252719306955124, -0.07153054976977626, 0.20302151360876422, -0.45809061084522495, -0.3135904928024954, 0.22906441549136058, -0.4435072139260657, -0.5389055189192079, -0.049686282576299305, 0.4442881408962945, 0.09873520456780233, 0.2238637207850261, 0.141070481798972, -0.3853906846187604, -0.8077083979076282, 0.5477361768807092, -0.19198188911207997, -0.3022431547472021, 0.4582211586831237},
    {0.4872203958647841, 0.7129968509361374, 0.48412537192374117, 0.45040154952918815, 0.360678658108409, -0.7185194041847504, -0.8334025260328769, 0.06503248710658803, 0.07555710367421876, 0.4547477715524923, 0.3716637460150865, 0.5054492394553439, 0.02483873025235161, -0.022019859933541157, 0.1497100265295963, 0.6092008180053461, -0.43214610372673046, 0.4963522402226731, -0.4657347023726196, 0.5115196051764013, -0.3226316130802279, -0.6374184070195925, -0.42218477528297865, 0.09102926700941136, -0.3279675767831054, 0.27862820009440087, -0.5094985472047697, -0.23453710341432932, 0.23406705023614052, -0.04207224567931619, -0.44019662578930707, 0.22044621319831467, 0.5274219512499729, 0.46355675975722654, 0.34990885194013277, 0.5451047353374776, 0.15704326366938726, -0.06306110213068064, 0.06740254488660771, -0.6219070753956639, 0.579533362303337, -0.13360456506391202, 0.7035058083054191, 0.3070584083928646, 0.5129828219361864, 0.5220393393546667, -0.5186617531783386, 0.3001906273500685, -0.39384166995797787, -0.5615371948199965, 0.24465154357278643, -0.2880586378391945, -0.783736846479942, 0.15947543686945903, 0.45850332531479926, 0.06691862510727856, 0.5841975821372644, -0.27344126279874087, -0.35941971538679846, -0.8204599352371331, 0.6831259506991486, -0.2348685848679432, -0.30007771627526386, 0.7022650288266191},
    {-0.06680742605912093, 0.4552872756143079, 0.7054158141075961, 0.8618111298221564, 0.5774578573614613, -0.24406196184346773, -0.8385736150172031, -0.1362744050316022, -0.14494103863722393, 0.7468400511849403, 0.5190384451368246, 0.5768739982589534, -0.1402294281671383, -0.26761980088705045, 0.21317361783519206, 0.45053132282645375, -0.280346216726539, 0.7984078248109261, -0.4875619706409761, 0.534148448326744, 0.27041818405680607, -0.47482003584430615, -0.2952305600445246, 0.2193055154848503, -0.42565382361001486, 0.14673897869761038, -0.6193907389202777, -0.3348592261219416, 0.36762595809601384, -0.08755206759450465, -0.24462129098053542, -0.05630343605967249, 0.4754364289361352, 0.5858638985156482, 0.16514070588032903, 0.4538047486293658, -0.21829096667579262, -0.08577071377736759, 0.08682071533161659, -0.20442307279188127, 0.6084404851019009, -0.24479277321246215, 0.5583403882322909, 0.4963147618977947, 0.4342106533308891, 0.29104348419693116, -0.4278190570936684, 0.26857439988009363, -0.4747675725521871, -0.17292541819276835, 0.4217553997157372, -0.1419797281485528, -0.8211869702886176, 0.18284666014826234, 0.283182831777203, -0.039540049880439375, 0.40509110111722557, 0.1113651696052827, -0.21322027703621813, -0.7310520920386332, 0.3365009963730481, -0.09002764935579384, -0.5854532924262517, 0.7514467636887108},
    {0.31529454713248783, 0.6252390357359192, 0.6055300039869466, 0.4040161173518951, 0.6562377552191634, -0.321035223039789, -0.8141022934492154, 0.09741892056111155, -0.14572954540455504, 0.4283711916219386, 0.8513531736472535, 0.8232504651418534, 0.22716655195028918, -0.3425441487681705, 0.270005340583144, 0.6206201978128384, -0.2715554678179424, 0.9582985078223475, -0.49982864725937953, 0.6649588741261994, -0.072567944017624, -0.4948302046800225, -0.473129769572003, 0.3060385963254116, -0.5424496100602574, -0.011792003885052173, -0.7144886201459477, -0.4507774340263322, 0.47992263502141297, -0.4046402857310996, -0.33494933461215187, -0.020581945269837313, 0.8485725769903752, 0.6822363765214908, -0.036017761410706915, 0.34302435534872694, -0.27865824248453963, -0.32378206595528775, 0.21397029092160927, -0.3975768748222737, 0.345175646591964, -0.09218941184467622, 0.38766607441643874, 0.48511716217382184, 0.731401373252588, 0.48300176515268545, -0.5261547679048629, 0.32756826516859194, -0.548030994045437, -0.16446055439198506, 0.5236712333554667, -0.478659841377025, -0.6379283127996096, -0.06402951968220039, 0.7396296255712691, -0.10520512492309102, 0.3606932038725443, 0.06918163269774597, -0.5574708344115702, -0.6696101736451266, 0.6785299634930647, -0.3248708277525744, -0.4022451722756636, 0.45602894382060993},
    {0.4935457949785933, 0.45877244633996883, 0.2832657278448558, 0.7248373551315815, 0.4972044352103226, -0.15981200728777364, -0.7026475289888968, 0.14522263238702485, -0.04365819959743747, 0.2853979153592626, 0.5362039461190341, 0.6056533473021127, 0.2682137922917487, -0.17574491713974966, 0.5269701787287274, 0.582395929875596, -0.4378979587963235, 0.4476049073810565, -0.5160005274528443, 0.5290106057875812, -0.10124930014105252, -0.8046371898204079, -0.436144567882437, 0.2932682019831045, -0.5932374331714405, 0.14684283756175154, -0.42595570485817835, -0.4575954753289049, 0.11691212247888703, -0.3137980433986444, -0.326474584280043, 0.04029419475634102, 0.7297030747699941, 0.42321247007012314, 0.15064137493776744, 0.0957855808372277, -0.36848552267236356, -0.31054374880016, 0.37945812165846315, -0.6097506746992238, 0.34554781276524693, -0.47909760054468026, 0.7127353949146846, 0.4533721174584768, 0.14291548820865227, 0.4435180678629293, -0.39705838143868105, 0.3486124752355821, -0.5998863524705332, -0.07949752416103763, 0.2966000609108025, -0.7006102400807513, -0.9755680823670773, -0.17966243277272656, 0.5640042502367657, -0.09113271781383132, 0.25295586539403114, -0.2627991849666654, -0.08302192987260842, -0.6856224929414703, 0.3439532921383135, -0.4005696876528036, -0.802419991663436, 0.4041706545023942},
    {0.6481430361217432, 0.4128489877833395, 0.22485872059588868, 0.7616597101537987, 0.6427908482971683, -0.2746732468014398, -0.8170863593975454, 0.049663468322386224, -0.0004592341229192389, 0.2898562233412532, 0.7192970344648402, 0.7437384504594335, 0.0035738490787758726, 0.04884595092339598, 0.3328511494070851, 0.3545718864736245, -0.7898445889330908, 0.5568206392575813, -0.576498494130291, 0.960066219085136, -0.5872499022350023, -0.567356645526412, 0.09820063562066038, 0.5300458587002894, -0.5138682321440787, -0.17273242722152457, -0.5565726258180158, -0.3396761823041519, 0.4435826414332256, -0.3958472605018396, -0.3770170817250485, 0.6663295472528481, 0.5905258813581052, 0.7187933067974598, -0.16373019980679562, 0.25535255649280014, -0.19714280387966562, -0.2833463352045264, 0.10974822196288046, -0.5704738370541785, 0.3310627905765211, -0.48824010463598316, 0.6370299427431892, 0.3697754947004392, 0.5184212875310864, 0.29006253763858864, -0.29807204046973645, 0.4830030731869181, -0.28358022799036314, -0.3841646194905003, 0.4538356627289087, -0.4087264330045277, -0.9677895694627504, -0.026506390401818975, 0.940407496129809, 0.0445547836927597, 0.5485099554775292, 0.13692108026858144, -0.4434982475744399, -0.8847391904782475, 0.6230429319305024, -0.3940292466696465, -0.5476332283966585, 0.4076732913851067},
    {0.3367308857816576, 0.6423065407998885, 0.7456208820070812, 0.49485922354033024, 0.7542637781548354, -0.27375047653443557, -0.5487511611368503, 0.2074705031877761, -0.2823215633565788, 0.41681013496408353, 0.8665280250118814, 0.9506444495178665, -0.5113416761947925, -0.06179566248331855, 0.13131062765056595, 0.5065583845962804, -0.535474680336326, 0.7998691670448307, -0.9474550655790694, 0.7243381280897369, -0.5337108537476389, -0.6590997681006711, -0.07689285428152284, -0.023195273609857955, -0.5416345004155977, -0.1192542979154333, -0.6058566525946236, -0.31101135770529836, 0.14217951300425058, -0.45642689771298917, -0.35721356394841713, 0.662886764878373, 0.6460202017347566, 0.8439803703403972, 0.29363625955944456, 0.31798846320194485, -0.11674461952285418, -0.13100366504329367, -0.10242203703201469, -0.5467374332370891, 0.7848413206735888, -0.28655584974658577, 0.31344548471304906, 0.8928333255056539, 0.7512716045665553, 0.41321030666269914, -0.7189311207673352, 0.7699338533488989, -0.5869133286998878, -0.40270662032044646, 0.38661236935061016, -0.05825438072604144, -0.7302660053349613, -0.06305473437997478, 0.5509314127677645, 0.24703824669690858, 0.04780722421614412, 0.4326796460901491, -0.6704757510227284, -0.6462318490948389, 0.5427907206571745, -0.4287577601617968, -0.2558716918030034, 0.44398320907260674},
    {0.3289246291934563, 0.6438974865423996, 0.2792081996388367, 0.6177669568469946, 0.4909916920656713, -0.4402287380958266, -0.571014023921963, -0.1044684014658573, -0.2960379102343827, 0.2156567558945144, 0.7242792113243273, 0.5579605700308777, 0.15889462753625358, -0.07507744218822504, 0.23669437452687753, 0.7108594598475733, -0.28936571870320604, 0.5074668761187864, -0.47145479068576795, 0.7200225777566517, -0.4291713353813303, -0.3934602952143913, -0.6053368648990368, 0.06903908465917166, -0.7698062083590163, -0.2736868142574529, -0.7299839622733258, -0.3497203631892576, 0.17830618335293658, -0.25706217288861344, -0.25189892730728436, 0.663155935097391, 0.375421400562658, 0.7725915916613092, 0.18971100607465333, 0.34954145557447847, -0.26882059013799203, 0.004034384626994031, -0.006665474403257315, -0.2926818477374177, 0.6762627045679219, -0.35158946575794203, 0.42108426292033824, 0.5280701492110155, 0.36745722388830254, 0.7063850594678173, 0.08319127879140328, 0.23208898491174357, -0.28217843228579415, -0.17208057278390002, 0.40122309769058356, -0.08642208402566891, -0.6425809153844778, 0.07082056956747644, 0.5740906132562106, 0.02162838051043968, 0.23215836594869502, 0.24940872183398807, -0.6504952869774139, -0.7053125544985415, 0.5438731592966137, -0.052077827731809155, -0.4320890599660227, 0.6533878825220427},
    {0.30257219182644746, 0.5270193589489554, 0.4522342710640189, 0.8755719021863707, 0.35430311601634945, -0.29745270195401596, -0.7690387266380685, -0.29810781276987575, -0.09708548961114007, 0.6907291385099014, 0.44638962777843105, 0.40795237822677133, -0.29794754526446754, -0.2816933749015531, 0.3215342095728549, 0.7231712150056097, -0.24524477165125536, 0.5633970104824098, -0.45681885641061903, 0.5701086252281512, -0.18252343740990926, -0.6676687899642859, -0.4510907730770445, 0.14952292057088584, -0.45670425463126246, -0.6141617069870572, -0.4970305161719279, -0.5231611564643804, -0.1191557041874884, -0.689216731468564, -0.38450349553843427, 0.13427442002850012, 0.748802457614933, 0.4499215200517447, 0.19113093932427563, -0.01747598730885811, -0.46880051288372626, -0.2617851744010128, 0.01474690960378202, -0.2621136198601015, 0.4527526617445929, -0.6200674966615703, 0.4102572699522325, 0.47324975455358526, 0.3638027867483978, 0.4606408156790862, -0.4418299988495437, 0.59751956642504, -0.743828992479349, -0.38426321433870025, 0.3077012624585271, -0.504587778074331, -0.8050462978134842, -0.1723437432478149, 0.7782071424832513, -0.102846548929337, 0.0992619328597174, 0.001174798100478236, -0.3802431281238246, -0.6319678097385154, 0.5842241942369933, -0.13672422578165103, -0.4686283904307461, 0.5385341826221416},
    {0.19857998537465982, 0.8352837692600904, 0.33936635369292295, 0.7826794103593253, 0.06518941441477077, -0.6078972394713164, -0.592339053803285, -0.27977508684354574, -0.3388769695696547, 0.39748038443788936, 0.6104228804567752, 0.6832625496356263, -0.07961772540364195, -0.19762251613336812, 0.14280556439213063, 0.6216007550088332, -0.549412515512202, 0.377713498945129, -0.7277280837266051, 0.525320285534307, -0.44335199010621484, -0.3885483033370135, -0.43871078738489677, 0.2930189398444132, -0.5543153115691419, -0.7524401919368117, -0.5856645299393849, -0.1077387127560879, -0.14204497721707973, -0.363382141260597, -0.4307099266859973, 0.22598779226546625, 0.6878292408228699, 0.6368025627168546, 0.38930303586639675, -0.08736207579764503, -0.3428501239268058, -0.5904842374480369, 0.05876494088868936, -0.2518346392270889, 0.32559397008241153, -0.23741206702156878, 0.6329766679246362, 0.2816448704018545, 0.24568772554876017, 0.8153449698743407, -0.36507619100322186, 0.14574073667064522, -0.57959745797491, -0.14866786873328972, 0.5094254111969642, -0.6903033420458877, -0.4941526608960366, -0.13376003138799938, 0.4242983488000494, -0.436919814224145, 0.1243403400237991, -0.005222173661710874, -0.6130275472368344, -0.5321055714115167, 0.4700207658619785, -0.1923846446271248, -0.25132384770929905, 0.5542988829886942},
    {0.15570015163752904, 0.7537290362556424, 0.6952538770970755, 0.7113945201697663, 0.20873594644068882, -0.027209582760751708, -0.9240307235457366, 0.10022470328150344, -0.1286843831360772, 0.30942664468336123, 0.2784519893579238, 0.15444550071951038, 0.23068384262048586, 0.06106403931823359, 0.183027954481734, 0.6292440817454112, -0.43535027661888676, 0.4588560275617024, -0.831271790294038, 0.6874901444942513, -0.6323723140264048, -0.4899953494367517, -0.34612879662635293, 0.38853748808196875, -0.5569178062421929, -0.4640074535877017, -0.2649987398182743, -0.1422595128087815, 0.27127340814159395, -0.5657971052401406, -0.5185594996141989, 0.19183333089130952, 0.9639627862737147, 0.7913174117752723, 0.25278529816163686, 0.16669914251095744, -0.3524329179854816, -0.5401455787993046, -0.11274494796060051, -0.2713447881219092, 0.6173805303870962, -0.3278922483433672, 0.64333185932153, 0.7251593031417221, 0.5787007637910064, 0.6016332685574074, -0.5977884230874494, 0.4605469585080066, -0.3985099636358931, 0.07086494611577114, 0.4379216911864566, -0.6952531197880042, -0.5371463646219781, -0.04559290327361162, 0.8666548063260271, 0.03612298827924474, 0.1771023082129441, -0.03480514240797826, -0.9132549251430206, -0.7103169898832883, 0.6483754240017587, -0.4173959537986843, -0.4448503513223348, -0.1290897358908019},
    {0.32541419401237115, 0.665173385872335, 0.8002443649008651, 0.8262307662778628, 0.058336775928482014, -0.4013575365077469, -0.8165451340456453, -0.17908239309859622, -0.5223324539547745, 0.3010151645214631, 0.45497791610654037, 0.6475730259339667, 0.0030087748450166626, -0.3050946417679536, 0.5389864968318586, 0.7597454145872019, -0.4112964673295646, 0.6445442082891704, -0.6037143144222153, 0.470959538768193, -0.44698203852716645, -0.5139539485233209, -0.5815949892821013, 0.3690363929878063, -0.42018273036161397, -0.37728806002419163, -0.26861144651798413, -0.3459456889626237, 0.15204914172472597, -0.5240502372252502, -0.7541952801688516, -0.13860123448400716, 0.7580113961595965, 0.8396231067779719, 0.05514093710096877, 0.3133771186151349, -0.2688582083216033, -0.17257542501940254, -0.14490687305607267, -0.5154324129045011, 0.32804388335252577, -0.630738167319514, 0.507033426719305, 0.47321412670820995, 0.611070439835371, 0.6457777816851001, -0.36059558198938374, 0.549175147279193, -0.3344600644640388, -0.29770650668317994, 0.35261519542764874, -0.5510860985610875, -0.4214106646947735, -0.012300423336012275, 0.8829131178193563, 0.250866135220933, 0.23695819686621986, -0.15486120521767888, -0.5955624786849845, -0.511908949848866, 0.36785190903352266, -0.43570068502694803, -0.3082635261459808, 0.28239239561858315},
    {0.5377944994835197, 0.5727598083459544, 0.5200045967788592, 0.8890646872123272, 0.21884518971038072, -0.5241773014126719, -0.7628202527251794, 0.03452220376684655, -0.12815334989046243, 0.221257683196467, 0.4358358496347692, 0.6724314867587972, 0.1916590392817004, -0.41539495340922444, 0.341239246896657, 0.823101736085357, -0.3225180768845408, 0.8257798939023571, -0.4551000414231062, 0.866516090330162, -0.3349737535586901, -0.47261040349998845, -0.6573154429124602, 0.31019110940939754, -0.2449985029813963, -0.19046057945843078, -0.51887918423095, -0.6545704784912756, 0.18227525599109273, -0.7553368876903886, -0.8368016603696747, 0.2645357755523675, 0.6393878560623746, 0.4540340962065322, 0.29268823606133265, 0.19966116411091925, 0.2053054475041428, -0.3887378240210717, 0.06442073541245998, -0.33189881147724115, 0.46662436939365665, -0.6647410473611167, 0.5043162185125828, 0.412594411524503, 0.5098450318429296, 0.8181094135624112, -0.38503563934025903, 0.4548013325063268, -0.653095519358339, -0.7645099843811367, 0.5765688818842463, -0.3310085513244135, -0.42629685571094883, 0.006421489376993915, 0.49716056418550836, 0.26450809016287913, 0.41218037684909437, -0.3268520443233243, -0.7409736118706525, -0.5655089436053748, 0.7049292633034915, -0.13775443469109566, -0.2713296280347736, 0.5142611559296683},
    {0.504477244900496, 0.5338986324185335, 0.8379139400437228, 0.638538866574014, 0.4302066991852031, -0.22705322390919658, -0.6141055022556196, 0.06939531384342325, 0.05888697096619875, 0.27358828896532655, 0.512763346120041, 0.5734406766037534, -0.046602759926263386, -0.3561025799860133, 0.6334543159020732, 0.7884709135528966, -0.4521630525962531, 0.8643280244116972, -0.566211575104101, 0.6886056989529518, -0.43039419385604427, -0.5563725708567971, -0.5435353491997521, 0.41552748950448926, -0.2626311661881545, -0.19480920306104246, -0.6077973143548633, -0.5276579210277307, 0.2192611423452597, -0.3092918509361747, -0.6890846757935126, 0.3420296063394876, 0.7838665594422185, 0.44914894605139444, 0.4982013171055965, 0.1364691134483372, -0.30500332143700915, -0.10793020163690488, 0.1466769408893882, -0.49472458241736134, 0.8660074476067956, -0.7034974168279252, 0.8848536439641533, 0.18080028245588492, 0.6656265169094961, 0.6661852045776122, -0.2925733617876066, 0.5975736497243027, -0.2147657397206246, -0.13961301504399845, 0.3772928384267751, -0.3535550560394919, -0.6667573368144677, -0.18446992070026358, 0.8033893202026555, 0.03592386158631169, 0.3997893785259363, -0.22398017039044113, -0.29958254325948797, -0.6881687509568248, 1.0207307964373338, 0.051370717286750155, -0.5871721172993146, 0.6954526973559292},
    {0.3708487782382303, 0.7353856975847199, 0.5912383284180118, 0.7867777587123264, 0.08446259238728954, -0.16848890132639893, -0.6949764156446243, 0.03456008018432793, -0.014677463666903033, 0.3402935097692706, 0.7450412706182407, 0.4348644318729733, -0.07766807710539231, 0.08733271913019891, 0.21898254543033654, 0.614127421261325, -0.12578817858392455, 0.7648467257253282, -0.5272876629408779, 0.5891609404655318, -0.4645077194936302, -0.8414540051858079, -0.6619052407432509, 0.10779588348157182, -0.3479156307340806, -0.2665155143767501, -0.5950604434225761, -0.1500091816467239, 0.010745046668492264, -0.48182588213894817, -0.5503754436603159, 0.1555967375982167, 0.7799848600407372, 0.3747754443418257, 0.3345982035623644, 0.16036045611144906, -0.11829641906044507, -0.4754798620119207, -0.04060805287722318, -0.6547302102667746, 0.6067505444364438, -0.4908298606171192, 0.6717238640179357, 0.7733764184169625, 0.4827648774000063, 0.7522455276236854, -0.28925829394188185, 0.26397332160893955, -0.24850750711410113, -0.3834255406129328, 0.1611891605033893, -0.17214809730846628, -0.45510980918904076, 0.10541430357989884, 0.8339718878153207, 0.12668057750545925, 0.36087207847484654, -0.1688993760635027, -0.2631559853786322, -0.6383659825934307, 0.641450491738496, -0.3436202070804722, -0.5730743196708027, 0.4494730166680057},
    {0.4048518801643146, 0.651059741408414, 0.605652804240103, 0.8243171755604327, 0.17053871814492616, -0.20224620255814435, -0.7661744784476219, 0.035576434136925475, -0.16541282262844306, 0.20220640465245837, 0.7798791208828884, 0.5494595933783396, 0.3461274632933511, -0.001162265394944473, 0.06761765473942964, 0.7001757213828439, -0.15298660474003964, 0.7112483202384211, -0.8238710445900987, 0.6783601148075525, -0.23314289901132423, -0.6856435493290803, -0.31154218767958874, 0.14646093105225486, -0.4892699392237016, -0.2263470957546156, -0.7144082482679527, -0.28148775438144363, 0.23212669686371046, -0.2235543477640076, -0.38282885284065077, 0.23069837864994205, 0.6406577795255027, 0.5307113958986719, 0.38170981527615105, 0.3840351922004065, -0.5602297294093201, -0.44114570684858573, 0.07181165260136017, -0.3780120100383249, 0.6013901222571056, -0.6938533251032447, 1.0453652107367348, 0.7165851481385905, 0.450981249746145, 0.5983615736850498, -0.5079875548747799, 0.30149217863942246, -0.44791708233104616, -0.4563827139282656, 0.46327925864433606, -0.25986322928907324, -0.48514550938176143, -0.09872421710131563, 0.7177271099865272, 0.3588979134600981, 0.473531913207522, -0.0978492250799565, -0.3466769849530974, -0.8116000244286896, 0.6434739756166443, -0.03204497517623224, -0.29873148593679466, 0.22869220320380668},
    {0.2379338941469596, 0.6156188243729741, 0.8131930993186802, 0.6891580046981883, 0.19998875741061334, -0.29487782119256684, -0.7737331853579517, 0.04311765543111768, -0.6467172644233771, 0.5291146070666929, 0.660052817098762, 0.42548809846227903, 0.1294883607154325, -0.37810368017653034, 0.20401917485767623, 0.6483160339648382, -0.4252683281697519, 0.663204487834129, -0.705080672991983, 0.7736609046902134, -0.08849313890156188, -0.42959875484096954, -0.6151022440665356, 0.3265588907671288, -0.40120042727748, -0.5199305214031187, -0.5205338094689658, -0.5289307641977418, 0.5860671531944784, -0.20396460754390205, -0.3275062048670494, 0.14350372622636484, 0.8109951305643018, 0.5306439676662288, 0.4127313601992236, 0.1166675020504524, -0.2713655394583352, -0.43502809478225857, 0.19435602934781684, -0.6182885580769933, 0.7016847130520876, -0.3725241819988766, 0.837397879488337, 0.4153769717359683, 0.15499272425564578, 0.6981650244559651, -0.10370478953096905, 0.5382360374404321, -0.4093479268401667, -0.5210464833919946, 0.365092159358904, -0.5580746559863359, -0.5628140564405315, -0.22889473900737517, 0.6643381459962346, -0.2836323175774216, 0.18061481442089453, 0.20556002060752354, -0.4029993729072488, -0.9793043281271524, 0.6993371174801646, -0.009412834009618289, -0.3010042847495452, 0.3387034365265553},
    {0.290093339751155, 0.5576295130130333, 0.5457830309048181, 0.7732278487580931, 0.34366285915653, -0.010562784633260762, -0.8642346283199056, 0.050230301493055324, -0.27467852083881994, 0.07439810401951501, 0.6012274091076428, 0.7255479673376557, -0.05392636524936694, -0.42628717653655157, 0.5114869615114148, 0.6056275259747177, -0.32649251844866317, 0.7734324167508889, -0.7925176052690291, 0.5796842712941803, -0.23272862269968922, -0.6376349498463743, -0.7540476760677612, 0.2504143534351258, -0.7545309727294178, -0.5048587265044162, -0.6262319216939664, -0.28167593817461367, 0.26523318867878576, -0.47787266437701453, -0.46414307935466526, 0.04685972901603083, 0.7296594918826144, 0.9556112397172704, 0.43991390333861946, 0.3677876041975445, -0.1624433371336912, 0.10175129031649957, 0.10031207336474156, -0.3887822554032272, 0.8873966970957482, -0.641451920715611, 0.4047255681686632, 0.6436309996379006, 0.3673093292388342, 0.7084648181783161, -0.2783618644082095, 0.6821057871733013, -0.5925400520734108, -0.48528412336002014, 0.5794860570556064, -0.6211031939040251, -0.4668843232416937, -0.0690833430574116, 0.7794586350949453, -0.2565780012366471, 0.2450942711961339, -0.08084640615465145, -0.2936010326235036, -0.7866461710216088, 0.48486330808043215, -0.274033108600802, -0.7689133970605015, 0.6298077065780184},
    {0.22283844125388666, 0.8028511828762805, 0.641604642896337, 0.6416207309459002, 0.1311308326680395, -0.1123932902859489, -0.6674174082871741, 0.17301248833076294, -0.3077727655954259, 0.2869888257594054, 0.7433702208801007, 0.6012688924252796, 0.08559572118560382, -0.2314605042985344, 0.23817617455547802, 0.7343115012405205, -0.39991674158597906, 0.6959335282336341, -0.8734124945701482, 0.8645775819859626, -0.3397873551490834, -0.5658837933474969, -0.4138637739833223, 0.3534452014860443, -0.9438657423820274, -0.25433996867383946, -0.7314001348537387, -0.48839757317411736, 0.3315533514802407, -0.542567950298377, -0.16695103341543233, 0.709738009548656, 0.7274012327066953, 0.6677189506563027, 0.3389394422827113, 0.31734627426773926, -0.3714148911479939, -0.001291407201941175, -0.2788648586322044, -0.5506933813423249, 0.4498410199778861, -0.5661262508495261, 0.5389001440963797, 0.7886495381458205, 0.44647455007448916, 0.5503345877100988, -0.24644156952510562, 0.7619963821027663, -0.33590039465657917, -0.13186148150033458, 0.40964155209786246, -0.4009167990251587, -0.42330324335445246, -0.2570420636382734, 0.7499537299845904, 0.13711865849670807, 0.19803158035313567, 0.047283843578797, -0.45211033034229164, -0.6791229873655675, 0.4470911944099386, -0.4327908315318881, -0.516821845023157, 0.3612250791261908},
    {0.18806922791304292, 0.7882103753353307, 0.6262790847857134, 0.8169709664871501, 0.5915073164982919, -0.5479743039568733, -0.706015114893871, 0.045252997334484756, -0.41039269061365524, 0.32972141260940874, 0.3823720896237927, 0.5942417963233798, -0.050324323269556694, -0.182490212856109, 0.4407361359950343, 0.8260333229642686, -0.400061090805789, 0.4773457454222959, -0.9390404327806205, 0.5111640143095684, -0.3761817236515078, -0.7497779283885544, -0.5873759310239693, 0.013082375811180979, -0.6391922038348087, -0.45462721246225396, -0.6426300151714567, -0.655236792190917, 0.30541313031943657, -0.7087473208894511, -0.7424070966812497, 0.1847726907382966, 0.7361115275678002, 0.8210140711498474, 0.37432668711123135, 0.38691886526654307, -0.31575031689439653, 0.0643301891389831, -0.20784881251113457, -0.4051348828399708, 0.5958909829974064, -0.5614500448814915, 0.4990169361931537, 0.4820203787128669, 0.597858393887356, 0.5664740251334136, -0.4740334849778973, 0.5243751450857025, -0.5443719559126488, -0.5681730457667735, 0.2664207796335946, -0.7874322598011871, -0.9658510243526096, -0.5502664182680704, 0.7362987696757536, -0.03742081859884497, 0.5301391646004477, -0.007197620307009422, -0.5108082552506797, -0.8079374483565983, 0.6189463151398827, -0.037184531804860546, -0.5804431748465925, 0.4989344200122485},
    {0.22848016197639787, 0.7826719879966884, 0.5052708569821425, 0.684434105936392, 0.20126844233732546, -0.2507709601947775, -0.5643037228813006, 0.09748868111768245, -0.33138918825569424, 0.32335244918469075, 0.48445154505836435, 0.6554201795952339, 0.06909164713739667, -0.3847152335864064, 0.3690314112014541, 0.9402455289393965, -0.5816757411718058, 0.7585317472323876, -0.6186643524613191, 0.8110030459326766, -0.3259844459253581, -0.71840151912913, -0.32686138666005715, 0.31826201287893996, -0.69556812295742, -0.5680418022662759, -0.7596313518668556, -0.3973882686044178, -0.02781704675704464, -0.656665102792921, -0.7132916271155952, 0.11790174440961713, 0.8666791102648995, 0.7123448467728095, 0.5172075541152044, -0.0437122447492978, -0.39643654648302806, -0.39873620487933453, -0.05915083551780416, -0.5407442703066974, 0.5982698178951535, -0.45781574387866625, 0.7077861392389416, 0.5123630936566175, 0.7413203702156143, 0.6920801216482279, -0.3818743506602165, 0.6473574643437197, -0.4975475749873736, -0.04804760037758671, 0.4008147083420321, -0.7426246148541813, -0.7833117514204144, -0.01433994834154552, 0.699701808973655, 0.006638737605082963, 0.28313380234672697, 0.05963424068136906, -0.6398010114267993, -0.9995235584096348, 0.7113383484797474, -0.15961278384657185, -0.48913222545799356, 0.7367251163712741},
    {0.4687111145844855, 0.6012924499646665, 0.634948507870689, 0.658868412118923, 0.30654739135315556, -0.2993493663328172, -0.7498724783811129, 0.05669676644638765, 0.17961333817114006, 0.037336630893901844, 0.7730290313594865, 0.7601467947405353, 0.16426307281351282, -0.26758194906182836, 0.4641912903173343, 0.6013600545581966, -0.3729456827998284, 0.6862057670792399, -0.8189951368221738, 0.6027476799868289, -0.406547525335001, -0.5977305458398605, -0.5094761187877197, 0.47294717810008247, -0.24605144013927174, -0.6454899506301318, -0.657380543846745, -0.2873964902944712, 0.12549860226186768, -0.41350360804921404, -0.6029488485962088, 0.5744428881306829, 0.4577367866818496, 0.5804536100039764, 0.6776007242113853, 0.21536101180219247, -0.301490362144825, -0.7381096299696318, -0.02990690891859786, -0.5121373628500165, 0.5772749400870112, -0.4640011011128201, 0.7563546914500574, 0.5625749655669824, 0.7454535935233785, 0.587299093678069, -0.6409034478101355, 0.6898386775729846, -0.5562391495857745, -0.4347655598381164, 0.010711384066736319, -0.40053941145554955, -0.7612086399384301, -0.16337671767316306, 0.939577371036578, -0.11106636006264463, -0.0011099074381030272, -0.005869235473015532, -0.5301722342429167, -0.8491735866093577, 0.7900569802494638, -0.2976461612575525, -0.7222643076625478, 0.6768641516422165},
    {0.40986486200334743, 0.8075815753386993, 0.7531312464996943, 0.8139849489814702, 0.4637228573677598, -0.33787879752375116, -0.5826194666968343, -0.012849983485126058, -0.30757169980089144, 0.09459987271922657, 0.8374887402698441, 0.5444844871944029, 0.01608851448790503, -0.3473751604173383, 0.2821850520625264, 0.570747801650001, -0.24755153748201916, 0.7967546022926063, -0.8500025671333293, 0.9194776346575153, -0.5097076090330295, -0.4636140265256349, -0.4554732476647116, 0.22393062544673273, -0.6526814616161677, -0.3803488399101062, -0.3480692323894714, -0.372620775498742, 0.14046650394970323, -0.6427377866273144, -0.48682281340550926, 0.43597113337019366, 0.4200209557273432, 0.5301823154267737, 0.36609923887714857, 0.10461929302332387, -0.1941671448205272, -0.38864885424620244, -0.024069591106320423, -0.4635413706296132, 0.6214651238882292, -0.4955937705928804, 0.6182727842643138, 0.48230290761360817, 0.5116935875944795, 0.43700657090170214, -0.4745359129453749, 0.4534249317707364, -0.6497668319057543, -0.13319832817356292, 0.3154344926171342, -0.31975461721601983, -0.6425301459487479, -0.4458666983369328, 0.9871681011002804, 0.07933307337332772, 0.3801773336553533, 0.07394009895199043, -0.39670032337674505, -0.8205469846243801, 0.766889003545822, -0.4057077113375208, -0.25650312837767975, 0.5542404700515801},
    {0.3951173299447992, 0.8222727603822084, 0.4796551374914735, 0.873279946458577, 0.7386269248386279, -0.5517875962519467, -0.9339915287060464, -0.23526714726797865, -0.29068384144062254, 0.4303433282538044, 0.6506341439062037, 0.43695686060722927, -0.28014223649154496, -0.5571326885607555, 0.16544611790607638, 0.584150242764515, -0.5146481150262585, 0.6188543843464975, -0.7534626927626094, 0.9037696598127961, -0.4702843052424326, -0.6394667675101803, -0.6330313785875467, 0.5197678173031471, -0.42862678192280423, -0.4178183372274337, -0.8807402615744696, -0.453893141056308, 0.007995015140252146, -0.4909524927696681, -0.5093356260332889, 0.27066850335332493, 0.7450071131789046, 0.6653824432573714, 0.6659782331028885, 0.024628457680968892, -0.530589343642087, -0.43663872747770893, -0.06610069374166005, -0.613569048392944, 0.7393665940557709, -0.643662683947968, 0.7833842670355206, 0.3631180492794737, 0.48734399940867507, 0.6644287442509298, -0.4380186845947173, 0.4530264503608945, -0.3000325440426332, -0.4977161240004674, 0.5063774251025411, -0.30625640650321506, -0.7340622423259541, -0.22952024346919775, 0.6179582314664105, 0.1757497026546384, 0.09653853767581912, -0.07274878730701724, -0.5588724102601197, -0.7299677696992909, 0.630243416139523, -0.47013148101802504, -0.44735486758541476, 0.6504052657887217},
    {0.3438604231451726, -0.07127355851690953, 0.5497891117842102, -0.00200894074768539, 0.17926632293692066, -0.4075615239701939, 0.10692730956984019, -0.5765835936414808, -0.6939895144179618, 0.13948207571115223, -0.37887639465474543, 0.4019164968840821, 0.09813601628219258, -0.8400651402428634, 0.48090021543115824, 0.01690590064490233, 0.7718062089648551, 0.18076584506289978, -0.4800274585452297, -0.7011796191962139, 0.1249983756062439, 0.5051654711255095, 0.291626366895151, -0.571811543086908, 0.4751277765471977, -0.011953279485929485, -0.36457900407380317, -0.6628618435936668, 0.6781980501098264, -0.7112848197959889, -0.5652713371315502, -0.5778541344908422, -0.28008327598731453, 0.47577066825857034, -0.49053526464524505, 0.3344190725866224, 0.6762417381345477, -0.5124917019736198, 0.6583691240950481, -0.4607943416779151, -0.006615380038179786, 0.07796573475219279, -0.5006645949666276, -0.23573013909456092, 0.5811201280097602, 0.16749934011405965, -0.017372489337974518, -0.29035748098521585, -0.3526294678648523, -0.6478317957065272, -0.5247848568530996, 0.2844092861079993, -0.15686346423445102, -0.603471006177978, -0.0075283285082708646, -0.7906622370559002, -0.5390456342265464, 0.4586689937807639, -0.34271374907905877, -0.04323018579907832, -0.7584454589235999, 0.554617103649027, -0.6019949387768336, 0.015126550518871166},
    {0.39956484815039434, 0.46816856323935235, 0.2072835704801054, 0.17930102580753857, -0.3599572193306452, -0.0003551183915809189, 0.08547126386956039, -0.06195224138020746, 0.12685306668434132, 0.12361546153984981, 0.14256404853874582, -0.05516274110512054, -0.0973597099299992, -0.17541955845056872, 0.2975417221209517, 0.431663381163879, 0.14559752158222636, -0.0639513359554064, 0.06162055666011114, -0.14906220223032537, -0.2786461939963046, 0.059061627492407946, -0.5695560058503305, -0.22771917286411084, -0.1880111561213351, -0.15489900481977914, -0.0990275292871721, -0.08511378099335282, 0.21197382787102262, -0.15728299528893333, 0.15383485461509483, 0.12659710833197102, -0.2314627125752729, 0.07742861104395193, -0.25254452689208184, 0.24098951600396587, 0.1340630745216135, -0.20997696930840024, -0.03451646414691902, -0.3903828125152241, -0.29716409965205864, -0.16509309601330766, -0.4835630658960831, -0.07474446269048114, 0.18225630081638255, 0.16732268584917157, -0.10226279766526701, -0.2765370573346348, 0.23746006761454203, 0.016042404600593373, -0.3027393427244809, 0.3010909231898002, -0.16261989509370386, 0.15652300253282148, -0.0640850572290889, -0.06119170598943324, -0.4099814283220156, 0.10354142192087383, -0.06393474517395506, -0.11448054757755084, -0.11296350919788395, -0.07856791171045935, 0.012809865479645102, -0.5793812895084463},
    {0.09924837582095287, -0.0603721042155698, -0.08586574978836653, -0.09833711357141584, -0.4929725343806822, -0.17037864528942528, 0.36728666338576277, -0.41879230182230287, -0.7579244966122712, -0.456157403812548, -0.4005899124838668, -0.21523766389659563, -0.053726244451569365, -0.4220762554198918, 0.13872241243456304, -0.08167255531718187, -0.45681240462705947, -0.16176517768578025, 0.1762029530938769, -0.6901191494698303, -0.42528101431487303, -0.186197581801794, -0.3015601698185436, -0.5041515310114869, -0.11694447042464994, -0.47652642626007635, 0.092870082938039, -0.6052876088535201, 0.00464520692256631, -0.2900580806736309, -0.28594624594976614, -0.3563854249466836, -0.2476135826913566, 0.23588481968426528, -0.4612023315480266, -0.12417913843108008, -0.07445384591278088, -0.654704706447123, 0.18658014052484562, -0.4906533893686155, -0.4472342740235536, 0.029076884106462683, -0.5633146059411451, -0.7767572439907602, -0.09880762791199328, -0.02741250890052175, -0.3083759643872433, -0.534170039597172, -0.16768839315636816, -0.3288510070225759, -0.5377883780815902, 0.2930234276371806, -0.38618036508235404, -0.2952050469566865, -0.32426780305604896, -0.3761838567389127, -0.45007114210320204, 0.5170939968895901, -0.3924899703123262, -0.15289368969630776, -0.09649589562175588, 0.2341792533564767, -0.3044484291557107, -0.3985956488869781},
    {0.37049592695496286, -0.2549603973203007, -0.24825576802244598, 0.31488197308468086, -0.38566853309419585, 0.1046212439923293, 0.0048885154896602875, -0.6291958985579389, -0.5041999150253752, -0.2735886175859851, -0.434202710571018, 0.10543599148369062, -0.2134021562005415, -0.47985985943239523, 0.4383579635119476, 0.23180931565776564, -0.1490086745576093, -0.19119889919981525, 0.11388612547641164, -0.4831483663902474, -0.3774013809133639, -0.1568716331097376, -0.13361965171478304, -0.5720548881618023, -0.16759543718294057, -0.8163061125223332, 0.09558111833282179, -0.623664230976351, 0.08203546195638442, -0.2217922548573809, 0.17490241459875522, -0.3317894839329733, -0.3484779237756515, 0.04070456577756379, -0.01972236973277461, 0.16795211416101702, -0.14544001571351392, -0.6036022100206356, 0.04975160800459932, -0.44426118071906684, -0.349117667427419, -0.06326137046389664, -0.4583310468402374, -0.48316544928258454, -0.44273871164960976, -0.11480772600930879, -0.31956323227318506, -0.588041530078943, -0.17856521093134273, -0.004452954849425979, -0.5788242408567053, -0.24070772874254026, -0.06687521776291504, -0.4180949433458901, -0.3316115124278829, -0.39472906431835275, -0.3443530655133691, 0.2815715590974416, -0.4316503404009072, 0.028193010594906264, -0.03155191757856953, -0.41176690485445927, -0.06379312415465925, -0.1535004178650797},
    {-0.10345203736546185, -0.5618689373476097, -0.0693482849816399, 0.14683504109939777, -0.7053383688513395, 0.5400516487035957, 0.04670159779781818, -0.22823161378778256, -0.0484600945369534, -0.6110447435078176, 0.19300310312039184, -0.30264692902310963, 0.24346342829791717, 0.1945580227170079, 0.0839176164218633, 0.15574009335427136, -0.5545167896368647, -0.6996852803620165, 0.12761286856758994, -0.5423729846601151, -0.38415865849466646, 0.15687489470341712, -0.21286219223787953, -0.6235696804970904, -0.6597712985853409, -0.4816012263701167, 0.33962078640347687, -0.29875355980920487, -0.32752110530523343, 0.11458924063824286, 0.33379914650345965, -0.6447383043442213, -0.5417596849997195, 0.26291497080167675, -0.20768139397256694, -0.08782007564798901, -0.47638799204039856, -0.5252623670533022, -0.4396282612849813, -0.663905632725555, -0.39218222091598953, -0.1998594379896372, -0.023392579735724776, -0.37059835922844037, -0.42296950754544355, -0.39779486492656246, -0.4217934565518244, -0.18808549800712468, 0.1810090169737815, 0.10012757526233178, -0.24515652586438674, -0.5002668072782824, 0.3079195582631252, -0.04570648692444803, -0.3319608869796153, 0.06932259701950313, -0.34820446097444296, 0.4343572952322467, -0.21085875908065058, -0.2964027436551809, 0.4082320145010273, -0.20778842972752118, 0.3005311102475726, -0.40970744723314345},
    {-0.2623468976598121, -0.3139921589030647, -0.027742512751805372, 0.04307636458172849, -0.1605425074411368, 0.39227432128484624, 0.00042016175742362735, -0.26369298612100744, -0.03095124456239691, -0.41220770810797225, -0.10824785471190647, -0.17605613236401438, 0.36931087658240475, 0.19827075397516894, 0.12685748453246393, -0.2839410084417523, -0.40593176585817625, -0.5731178977772361, 0.2197008948435477, -0.31560396807518704, -0.12230982874391957, -0.24835061919064869, -0.05275757486336314, -0.19282450398140702, -0.8154744130071102, -0.5632288473607228, 0.03963888832060816, -0.5453064646604158, -0.2961207381023912, 0.22416984715441426, 0.0010758838420324688, -0.3049264493265188, -0.4347364064027599, -0.3808679007391273, -0.3931923579760953, -0.3279000146654916, -0.2939976694895474, -0.5977207643173974, -0.4135958087160359, -0.7617960990944298, -0.2500266409643566, -0.12409705660276575, 0.014221209835813965, -0.2032872206643338, -0.3828514601513112, -0.30203325399275227, -0.4158491212318286, -0.6715333887257617, 0.11318892352526078, 0.20954464544964577, -0.02107776903133588, -0.5099079861509008, -0.1268164180476215, 0.41846708632914975, -0.4904159746985496, 0.24582644751803684, -0.5131318197247289, 0.3657264522341841, 0.023775959672295406, 0.03306194093060644, 0.2525467755901617, -0.5095848074095966, 0.3203905080115702, -0.5059469567384393},
    {-0.3002346045918855, -0.4159178095034946, -0.27303871704377586, -0.006638400407417872, -0.48043326142779585, 0.3447760040738104, -0.21436010869080827, -0.5027234728688976, -0.2624417117969215, -0.7441841491996225, -0.21662442578847346, -0.32789893397545533, 0.29032539544977615, -0.17903259365378824, 0.03628357539169679, -0.2559241526704304, -0.45335208887991557, -0.4187276196374945, -0.3509724664750339, -0.43964338608502745, 0.027526376344947562, 0.07340982581658892, -0.5056307070368498, -0.1240062690559281, -0.5112852036570477, -0.24840059728165345, 0.2377724950846903, -0.4702530165241868, -0.31033248893457643, -0.20597126005299982, -0.00015142423817153332, -0.4536063675118895, -0.7475032049690256, -0.10302159636452249, -0.5213090272826838, -0.2673052811641555, -0.20787167224216735, -0.4160484055395654, -0.11553818548920153, -0.6402411442785707, -0.5051493989036123, -0.17004394356345273, -0.18702285935062782, -0.7745567760029402, -0.7119865238152367, -0.25488059764241294, -0.215500608295132, -0.6224912475022297, 0.12531872524909093, -0.013292810864106032, -0.4416549106895045, -0.38643618016448894, -0.00018940999110526497, -0.04764516559818654, -0.6550447307891301, -0.028830127828837027, -0.486518858307417, 0.2685229766594246, -0.44409335301443337, -0.17210172090079032, -0.026296503522970704, -0.516277082107397, -0.10577225832205353, -0.5937334676363384},
    {-0.12394049208337495, 0.14633618516518337, -0.1755895297542342, -0.4633542900964294, -0.4798138431710963, 0.17731335147365226, 0.2049042288653247, 0.24120798982916533, 0.058441440472677346, -0.5051798994193442, -0.3589197838633517, -0.4338385337447464, -0.008894275798286179, -0.01806420623301489, 0.017172577597986356, 0.015640227767510242, 0.14063609433637417, -0.3346098773242016, -0.2713105199329651, -0.055360828779835204, -0.3807816295902208, -0.1430138466525557, -0.35429092697334896, -0.23935937739191102, -0.44940294837238454, -0.41282572050788946, -0.08951894425975655, -0.3769228339672366, -0.4146030119321865, 0.12672047046026777, 0.27630963129685276, -0.2032197653864766, -0.7020357052299404, -0.14752230666852487, -0.4982793737393868, 0.013715875766071204, -0.33022679051914267, -0.43493686422926553, -0.17371055668851237, -0.42261041413294165, -0.07383693216024058, -0.25416035168108164, -0.126236314133536, 0.11970657825802683, -0.32055623861958293, -0.5431164185425347, 0.1411511586740357, -0.2183838520873045, -0.22411869155177128, 0.031714179034184574, -0.2847594179363263, -0.30392516918712337, 0.12411599671546031, -0.15409842898335135, -0.5410305106461948, 0.4082765090715416, -0.38963461375594405, 0.00822107328214857, 0.02056790697988631, -0.17697710207725165, 0.2597402969267212, -0.32470789057175675, -0.16553560028785436, -0.2633723960333476},
    {-0.08039146380866712, -0.12803992841333578, -0.5052805862256343, -0.39609293693140357, -0.2901450772846935, -0.09862281036961691, 0.2148784920040548, -0.4234774452697462, 0.032361973652811495, -0.30300514947307755, -0.0026671279685542993, -0.41765092649298297, 0.19212000592511114, 0.15415122951197688, -0.21699413555658326, -0.08416887066064146, -0.12170039546100095, -0.4972724841747807, -0.3246849867242688, -0.15497484603914347, -0.5214581550297801, 0.034179238653681, -0.09162188126161772, -0.31096790702330646, -0.45631853518341886, -0.6473998148886035, -0.09026261090621884, -0.43083871275914154, -0.4191813879565292, -0.27915771134161393, 0.22828451701392322, -0.3788864729703814, -0.2606627758531973, -0.5560740053183082, -0.6166917008933915, -0.010862907869728227, -0.3153317680921126, -0.31365673579741565, -0.4920582097507571, -0.6184233182697485, -0.526870760219512, -0.5685987358418805, -0.03763300839592648, -0.43753305209590804, -0.390409633216186, -0.8049859670931626, -0.2241096477745519, -0.5386309234860387, 0.03837937634366804, -0.10741474919874523, -0.43031555956978956, -0.5494120515062414, -0.17953041626459076, -0.162195437510352, -0.41132229623344, 0.009214763455605988, -0.11944793507089571, 0.19872297628589755, -0.15131698354740794, -0.14286995461137317, 0.41764264704708576, -0.5119952236794261, 0.18144723301724264, -0.41050037276346046},
    {0.016872200001137243, -0.27181491706040556, -0.2554273522526642, -0.24564213871276208, -0.33440407519308474, 0.08021247171513674, 0.008429724001219508, -0.45446769223054184, -0.37004220998357773, -0.5891778338457898, -0.15219936734772277, -0.2183173610856133, 0.4845925101249288, -0.036810022923416855, -0.1604888337912551, -0.008124254601538714, -0.22026042770525986, -0.5045326658592593, -0.4696512481418558, -0.1517400469759473, -0.6243637490834751, -0.10856743513515307, 0.13997535858035054, -0.2626137865347763, -0.26495725124865316, -0.7327095709605476, 0.45010424211215727, -0.5462114407832499, -0.2224503152304731, 0.1256321718485129, 0.20746732329990422, -0.32029931793880967, -0.4286971596352931, 0.013838499095332543, -0.5006915349180118, -0.29936342939395333, -0.15443800593751425, -0.67611403647426, -0.2401963072347235, -0.34142164142888576, -0.4993835776229166, -0.7160455246356321, -0.06021455691334963, -0.5189713776449023, -0.2198028633065509, -0.2718301422267312, -0.2571320726677275, -0.5386624755112024, -0.11935887634284437, -0.13985109397188586, -0.33311738256372203, -0.5476984921587836, 0.21476400709373408, -0.22698479823123577, -0.4521555318664049, 0.09218674048443444, -0.7170752882397253, 0.3232777553353882, -0.4230832417605401, 0.13011450135496097, -0.039346094825023735, -0.2784968136485417, 0.470029493247575, -0.44606094599045293},
    {-0.35363856508334557, -0.13856888263044548, -0.3974074026632768, -0.14343602182024864, -0.36769263701716753, 0.2256629142836328, 0.11844019018444632, -0.4375566948443685, -0.5538790660416814, -0.6276976731538785, -0.14795802485392642, -0.3320858094713134, -0.07665324509246883, -0.24179008543716196, 0.31205954607028297, -0.18531159407285916, -0.3189031768168384, -0.6411275761818923, -0.5693604145552581, -0.32777859239737345, -0.3199053965069218, -0.36868733292989936, -0.3654782110763505, -0.40694251849760377, -0.28286722658441094, -0.40365782664523414, 0.12341784412403127, -0.3516938708977787, -0.031613586152363315, 0.06779663774811967, -0.3121135375329424, -0.5060858475575613, -0.46478136338227316, -0.04618570318150314, -0.902978644915877, -0.14919405255257523, -0.43527898316306596, -0.5821443481721552, -0.22764385645574217, -0.39234657618746643, -0.11630380593840028, -0.12862820593510493, 0.026796807300806098, -0.1304810492170858, -0.1571908096697619, 0.054696631551663474, -0.3630810211507663, -0.7102196494731127, -0.21719950889794698, -0.3626884180962224, -0.5139753435274079, -0.5049933493947204, -0.2143924982607491, -0.1319572810023348, -0.4592920238384342, -0.1908896772364271, -0.5634480451325448, 0.4307502403693392, -0.398154839171226, -0.21740351353614365, -0.10947061350410886, 0.23027629528929364, -0.016842667478599742, -0.5051690502584409},
    {-0.47570338408081597, -0.23926259071839287, -0.10704128856368879, -0.19227655048946224, -0.24963807682208508, 0.23336174904878398, 0.26370410681215645, -0.31107150422102414, -0.29151237306865435, -0.376425601381273, -0.04573570854965573, -0.46858849554087606, 0.039368533583104486, 0.07086776184140824, 0.16841055916763523, 0.03351304048422408, -0.43132248116484373, -0.4137686911239521, -0.24658821439623543, -0.44517806821920675, -0.4813624953111214, -0.026807974485246615, -0.31832667375488033, -0.3330413412131758, -0.45291364727234074, -0.5831976232611622, -0.02236131387443104, -0.6715211947591693, -0.47265947306827577, -0.38566329315569575, -0.0640798638239073, -0.5409214730475765, -0.2536078214133422, 0.11600519296156667, -0.6548359253011893, -0.305743894640193, -0.38584436938447286, -0.40847925812750746, -0.42260332176951365, -0.3918852088612644, -0.4948250398929072, -0.3944494832481449, -0.12706059883995569, -0.5870146559950974, -0.1969580584257909, -0.18225795096729572, -0.428059714293985, -0.7724595314438871, -0.23063307113203113, -0.20219433864159989, -0.2905950680161881, -0.19570819264380698, 0.06122539286069778, -0.32144897846644316, -0.28932902241377734, 0.2385546724316402, -0.6689283841230543, 0.4514344977919873, -0.5609629013879316, -0.00544266248643533, 0.2818590905638535, -0.18182662357023913, 0.0675012963768514, -0.2526010455754518},
    {0.020419867206416968, -0.5897672274939246, -0.5436258292041615, -0.09015658500769093, -0.5621421607949587, -0.029592749334353966, 0.25096451214787735, -0.2963265561058518, -0.2277376850902478, -0.4791529059840084, -0.46255251698857164, -0.20936409461220123, 0.050583747388472995, 0.12278483710138079, 0.04953322442392542, 0.19308371277002678, -0.16930699658642318, -0.6310219970679961, -0.1814292049743318, -0.36592202801191376, -0.5269627124983246, -0.23358375563726094, -0.6858566728701393, -0.5799812560437619, -0.28820808106449924, -0.3612556269008601, -0.14990304396073825, -0.6954977324641765, -0.2573149238428591, -0.14395299785008242, -0.25169616681622775, -0.06566334936659929, -0.5601410570948725, -0.1645168410556217, -1.0546828859428634, -0.21316585334030239, -0.32415855258091925, -0.5973522065374972, -0.10045421902761892, -0.49177635030064437, -0.23375522769554932, -0.13200920711886924, -0.34325476293810636, -0.5310825309795496, -0.1954258813135634, -0.56151676284937, -0.3018642848296861, -0.465134211519102, -0.003766988153633435, 0.2164409663661296, -0.5511757883440027, -0.6926057727531526, -0.30125394169432107, -0.09020646007463988, -0.7852813394423708, -0.11745431044159559, -0.5277204482298186, 0.2877350073399471, -0.35956828219968007, -0.12421769901641977, 0.5257208976350742, -0.36539071021348835, -0.04382161831878328, -0.19893017929678777},
    {-0.27858086744108235, -0.17909078298123884, -0.2656291007305461, 0.02024780836668494, -0.5046957424262504, 0.22382540223947217, 0.2838101860878345, -0.34854720962216335, 0.009492141172539327, -0.2673606369017749, -0.4265042559640663, -0.465462296479309, 0.2614326745116739, -0.27159181625898693, -0.16188920454437636, -0.2625640034372896, -0.1947497487801968, -0.4627731250994628, 0.08399498555678966, -0.4231864435402467, -0.3864387405860415, 0.21368652933650814, -0.23847068444328529, -0.30854627095910325, -0.3059431921446634, -0.335755158974383, 0.07590645543916429, -0.7477962133630374, -0.10201608831728594, -0.4099892120060134, -0.10021303980540307, -0.27886932950405724, -0.60429961758148, 0.14981828052565435, -0.3202043453281184, -0.14797876263232662, -0.24266446288770216, -0.7951618169077345, 0.1335559081459153, -0.4408594259168239, -0.2993331896420164, -0.09109891638756426, -0.2239063190939646, -0.1250689545498885, -0.26458846689172194, -0.36290389855283317, -0.5577998262386684, -0.36957865952835955, -0.21083242306439623, 0.24227308467231506, -0.390044423629393, -0.2693023012746275, 0.19210008970232328, -0.2615741401817538, -0.1542861787947409, -0.36866519172230006, -0.5449548852572327, 0.5871385620404538, -0.6278167821598014, -0.053189995230341715, 0.04935088784796758, -0.41329373895046595, 0.471342248876697, -0.0710383670148241},
    {0.22079971451705457, 0.0025725231255308034, 0.13529182941336426, 0.005420370847332909, -0.41319272229175397, 0.25355902122379503, 0.6588949778273794, -0.3946436822842244, -0.21377571609806428, -0.23060049029439642, -0.16551396389597423, 0.04303736461478289, 0.2455075627623908, 0.10612839514178227, 0.10467654664265168, -0.15073044207618821, -0.20723712037171527, -0.45756329538134255, 0.017534345875426682, -0.6772140313428545, -0.20508209744528372, 0.17237900898718278, -0.5762440337896911, -0.3522152999279231, -0.1698392384061506, -0.3619325187096168, -0.12510956943898605, -0.6526770013071035, 0.1404845366537884, -0.10205447767310667, -0.17619496156571682, -0.4093460410920938, -0.4384490285148015, 0.3410652213356304, -0.5614069451013785, -0.12506021600919714, -0.03859668027646858, -0.7387121939541751, 0.1753798868705204, -0.6050749928771383, -0.2165578783995389, -0.3376827220617719, -0.4968183188084668, -0.24281968811473303, -0.18843275833286893, -0.36812261835204046, -0.5912767729339143, -0.48277887475461306, -0.2844664924258311, 0.03021851331692757, -0.4851682797857088, -0.11698138376310409, -0.0264439529181568, -0.4383695858540079, -0.0578937950499293, -0.23745420268074469, -0.7397657581891891, 0.380052354762021, -0.33063987248264304, -0.13484136325438792, 0.1678570465748561, 0.07925740386931111, 0.19894832436461524, -0.37646936967249245},
    {0.2545162361441045, -0.17210946144597153, -0.05487894661372885, -0.282670071485, -0.3315236399211641, -0.2999205944385704, 0.11342800777585746, -0.547744379195428, -0.6276233657966466, -0.3873266608141857, -0.3657697683914319, 0.25467549792568783, 0.04016781555963604, -0.15212634361680127, 0.7271949972882449, -0.3255734287929012, -0.39522318670913176, -0.24519859557976298, 0.19681983792663788, -0.24575130026505518, -0.27569389994126614, -0.2817534924786404, -0.5463703717859044, -0.5767804760145246, -0.6939762231509815, -0.5847170681529223, -0.02809659500852697, -0.5938229415771895, 0.023032645303734035, -0.2629492037482588, -0.2603581120829914, -0.5332113240496719, -0.5354710311132289, 0.08295554216239336, -0.48539222150626143, -0.27771301833711926, -0.18776752906867195, -0.3630369595214979, 0.2197943479839555, -0.5570604677783698, -0.46361373715852877, -0.18933047604888426, -0.48315521776453907, -0.37963384329877675, -0.21186218333630172, -0.43120092720774605, -0.6314138166903855, -0.4330002232798334, -0.06538130446352933, 0.03611027346620976, -0.21815920494324742, -0.31840321761009055, -0.14415236034195303, -0.3903268916169159, -0.23700859715786068, -0.21411056672329717, -1.024288426612746, 0.18642799088693415, -0.5878612152357925, -0.003293944482009189, 0.046441412708926266, -0.1723088768331442, 0.07989714718801583, 0.01690495554299586},
    {0.056965707924635574, 0.01646041271096301, -0.17575386737352322, -0.007834729319406514, -0.5385391698036002, -0.17334561078952368, 0.6455158632714161, -0.30147621690251536, -0.38206896612821795, 0.2901100810630212, -0.16900296276915047, 0.04910191157272216, -0.021275423270314228, -0.12803684455400002, 0.4882183852850299, -0.14532806834833237, -0.35617043248728814, -0.4374341619330824, 0.04939426359963816, -0.38788214253464776, -0.08507884306936671, 0.17653796140441944, -0.23267052410480862, -0.43937557686025297, -0.1612538834856546, -0.30703375975168773, -0.07639510025622015, -0.5664134667746199, 0.4370730880891536, -0.008992619701977548, 0.3082369102304602, -0.11221802295466014, -0.43139377217591635, -0.2926946275218568, -0.6160135472372743, 0.11669112598889203, 0.1749177030860922, -0.22801966051196934, 0.12099001209407893, -0.45569488189251034, -0.4832699870520118, -0.11257076774715576, -0.02023609216952636, -0.25025260971802016, -0.44237879732062313, -0.05924009934631716, -0.29403630808866127, -0.5188054331262234, -0.08255257154684142, -0.16546040737001663, -0.5622531519008008, -0.19948405149564163, 0.4043695095326087, -0.6386787925084926, -0.2591728161559287, -0.20902077713450104, -0.7848547696932574, 0.48514273729750385, -0.6342209438865944, -0.19525006143447504, -0.10456588221027543, 0.1922590686847765, -0.11449197555791629, -0.2702013076625228},
    {0.16201828440267385, -0.24371168996902703, -0.1534656502819611, 0.37651285215411145, -0.5212972357847357, 0.15191380820787576, 0.2661137482824089, -0.9514759816579369, -0.48348175047904873, 0.07970451581874377, -0.21371332298262782, -0.029187418675036995, -0.0917267142648888, -0.0111102826127701, 0.370540632527991, 0.191685590375068, -0.1415953474220772, -0.28378525038913566, -0.024912406318757605, -0.3576903205846184, -0.40204332843429047, 0.06936083356101323, -0.17478791336189248, -0.6075998188152171, -0.35138914397625626, -0.6440459535820241, -0.004542201421075682, -0.6715685375055511, 0.24087661914817501, -0.16312208227959935, 0.15245768166270712, -0.15987376758554403, -0.3915341363815694, 0.08724822653373583, -0.7164295784940601, 0.27271184154628647, 0.1211177055473238, -0.4802412957352527, 0.32644052592748163, -0.6150685265955633, -0.23153211666241832, -0.3328690410874139, 0.04402881135383553, -0.19431091432751849, 0.12347239463053873, -0.15522372196615714, -0.037059732342973044, -0.6331482832841507, 0.2065488328925426, -0.11740367424350721, -0.3418366507542582, -0.2262156646557687, 0.18190798254279986, -0.23630581564427577, -0.0513922754481544, -0.4013862250630763, -0.5172355131586419, 0.585487784715411, -0.49442318325641127, 0.11340852639767322, 0.045054034097231584, -0.18582795361320611, -0.01940447292465845, -0.22887928956316494},
    {0.5936679370112438, 0.12584133252266463, 0.3136383655073835, 0.2506924957234788, -0.26580135126740084, 0.16746924880503472, 0.2791231401975522, -0.8669677063850815, -0.5098537011243081, -0.06661289062421569, -0.3053864756155354, 0.11722336179187613, 0.09926532777819579, -0.35627964288378755, 0.3727826488621941, 0.013159002517316835, -0.20361587101589917, -0.2931389090990938, -0.09005056649976068, -0.5696350598763003, -0.16762424673961873, 0.027999316556872985, -0.401434839156433, -0.6278911172972147, -0.19033932451967722, -0.6326726043870755, -0.03353209235357486, -0.5544722310238152, 0.233586305923838, -0.3459165473577691, -0.005696631351999664, 0.08145283686132597, -0.6694809631013305, 0.2558282902914273, -0.6146899714433055, 0.2550596655670999, 0.3605236682100021, -0.6532478933864377, 0.06283327688058521, -0.7901951780834802, -0.04923922916317038, -0.1840013889423525, 0.22748275619711536, -0.4160448910865144, -0.2270295254079028, -0.22439468605703108, 0.24158154975043897, -0.4585683065634385, 0.0292622663477796, -0.4009530994187762, -0.45542083501516556, -0.08213074678854404, -0.1034566606158302, -0.49563714446641055, 0.17636016688045852, 0.07803795406516999, -0.6668123685677453, 0.5729873802304528, -0.6393306491447595, 0.0963291747344592, 0.3617031451916258, -0.12787193735805177, -0.474871134716499, -0.22546511381417644},
    {-0.052781021659114406, -0.42603261158130157, -0.25728750276264095, -0.12825217693612323, -0.7628934018707655, -0.1837328167945034, 0.5658613598660905, -0.3892212583937457, -0.38831295282692396, -0.2673872018328923, -0.4079108200583168, -0.35918320452444324, 0.02061768705073813, -0.08224130776512394, 0.23123309689309662, -0.03449720665147956, 0.06879651855347188, -0.6883749610543664, 0.015839296905097073, -0.40311078062835726, -0.541328913447549, 0.1502621343221457, -0.44324241235254275, -0.5750786566706565, -0.3057986684829403, -0.7862484120566497, -0.19262151539915948, -0.69053833366074, -0.10398832312349224, -0.42135475380490733, -0.07709755369561175, -0.4173468718027009, -0.9705215734410638, 0.27372503837497014, -0.5562775547477593, -0.11115285132383385, -0.07208259087449098, -0.6166653932162076, 0.16565363815961553, -0.26051302960902134, -0.29509332764256535, -0.016790445991239498, -0.4336546423771066, -0.20689515151281232, -0.02079553549805945, -0.08193824603118476, -0.20949693979861356, -0.49546888654486176, 0.03415985290605205, -0.08758825986908404, -0.30703411329459657, -0.14606450311858907, -0.09226303612098986, -0.26307858539885576, -0.2845471225360856, -0.22829545194205184, -0.7325609457581771, 0.42655912095376414, -0.6141600704605487, -0.2757203683812555, 0.13645435675424092, -0.40557720775140943, 0.1176479265672763, -0.38284783708948755},
    {0.20270940967627682, -0.27883046464970457, -0.17955030391834934, 0.0672145986599411, -0.6936000139314851, -0.020262591443887108, 0.2881751548967633, -0.8970538799553298, -0.4812820867907989, -0.23880712798131787, -0.45858471722279376, -0.05763348074292519, -0.032775038298325614, -0.2550357133619105, 0.36346153608882015, 0.23804545608082314, -0.17635613526735566, -0.5414187988141148, 0.03957539948950303, -0.7332984568735027, -0.3903491877687961, 0.2306011579006933, -0.10079347666821789, -0.4211570644989963, -0.1807900441859511, -0.7090364751640932, 0.0760932400383168, -0.3958186302603997, 0.1275951256041501, -0.2946133869197779, -0.22611351265400995, -0.31553560514386886, -0.553149672466462, 0.5140380881947743, -0.5282026915092701, -0.19166715665387318, 0.06248814302269019, -0.85390358094771, 0.5618103344150255, -0.4996593113764888, -0.18180364819766134, -0.4707288399718349, -0.31114154919819953, -0.40442677179744096, 0.1422303156670467, -0.2609345875464628, -0.3512777117256085, -0.6768028580530611, -0.014992631104733024, -0.0433063702772435, -0.7898559191471133, -0.34666960008463765, 0.16243988804394613, -0.3605958977608844, -0.3292395983760067, -0.498558118357903, -0.8852084534875561, 0.512871502713513, -0.5045765444500759, -0.014448597990557916, -0.06155840004362654, -0.11087284583191365, 0.026190236222339812, -0.44910944024809174},
    {0.35467983990117985, -0.13921087565720974, 0.46767348371504464, 0.4120933641029216, -0.47114081367082516, -0.3133973418297305, 0.35779774730019315, -0.848447416010962, -0.7320593770185232, -0.20566873565321142, -0.3088880330688369, 0.40904014450556997, 0.5891447828206016, -0.3343465719659273, 0.7023637069184135, 0.21575478949015847, -0.20381652821219734, -0.34105268249882775, 0.1117342480248608, -0.7221058113048423, -0.28474747821303453, 0.18775064782399584, 0.11472514199953422, -0.712068150029241, -0.08502693938563258, -0.8911512034807438, 0.20646034354025466, -0.5147855385889339, 0.5628980545165247, -0.49173571342866057, -0.31332464020996387, -0.3835560326419592, -0.4380667789038462, 0.6499565530510438, -0.5444870458509609, 0.1255395207420882, 0.4667262780201211, -0.7318221809692468, 0.7692127792500851, -0.7887988896853761, -0.3287159255573245, -0.12667796532703046, -0.305776000618075, 0.1415093515335438, 0.0683408403512759, -0.6314651401511957, -0.010813378238747385, -0.5088628065375571, -0.29957375483768384, -0.3033526438591944, -0.7476788614386941, -0.3394130536600001, 0.16001886960485115, -0.6766908839641966, -0.20796037012030205, -0.4103109557057737, -0.7754136443293465, 0.8611438976988167, -0.7086557656111979, -0.01143934148569522, 0.12654402848088853, 0.25556730385582654, -0.4375463254686519, -0.37045513850674283},
    {0.6583080784606596, 0.5744514073300563, 0.596010294092552, 0.2566893532975337, -0.12690260373359938, -0.49166270347145197, 0.49571388176433073, -0.9058805253709734, -0.5371540634722289, 0.3221047893379272, -0.3047439557666004, 0.4187294419914349, 0.5414715197213676, -0.22552490314644724, 0.6883473782522945, 0.14763578404708466, 0.1573224185724447, -0.39297671373342136, 0.2232501429326177, -0.626761270319267, 0.22803714138901854, 0.43300798647273764, 0.03490287191505356, -0.44473135945353437, 0.2659089349115899, -0.5723620702643675, -0.26667161399098066, -0.5959596861767205, 0.6523666901629883, -0.6648915030442256, -0.5890173969610439, -0.46414168339712925, -0.24418768831938506, 0.7087429213250216, -0.564046252434563, 0.31378705601582674, 0.7182630735795832, -0.5913148253223556, 0.8677639185331938, -0.6323759746494739, -0.3923006949471318, 0.16659025468822544, -0.11560430148728522, -0.1267431557871823, 0.3123765584617549, 0.004548520422840142, 0.565637681000687, -0.6857378089739183, -0.11589342545414429, -0.45822017230617834, -0.8060177491930499, -0.06267003354192073, 0.09834667871272297, -0.6290009883452476, -0.11807916982498258, -0.3826411002471703, -0.9167307308991128, 0.8957174450845039, -0.744592135978774, -0.13117360212929283, 0.044510275490859806, 0.6826359180995017, -0.1787798951935141, -0.2966559997880832},
    {0.24770855898716343, 0.07455382828918258, 0.20110778008718336, 0.21905903327297968, -0.13324719356049566, -0.33435785557739006, 0.7308452488775308, -0.7576551579318546, -0.6283297178014862, -0.2624343056198186, -0.41131976591335306, 0.2796966830042753, 0.42942859526953464, -0.42434100705208794, 0.862159720125626, 0.4375304197477438, 0.29098517642494914, -0.6528800030300587, 0.131519790399288, -0.6871220745369466, 0.2915505544381435, 0.5268339745190431, -0.12543353356569562, -0.5489303289505639, 0.14646220562544285, -0.5695287442809744, -0.19775584035266913, -0.8653135467829978, 0.6203775457615215, -0.43285650126167324, -0.4658787342022557, -0.5612071537122624, -0.4867134212450043, 0.4178400805062667, -0.644848222630511, -0.03248089160670055, 0.4676375206017943, -0.4675703411171005, 0.6796158042810405, -0.7824715810196755, 0.06390075482609124, -0.06638360380899071, -0.4725680296924619, -0.33514862022172937, 0.27425982672657856, -0.14285329636251676, 0.11675826526253044, -0.6180718808673696, -0.6146695417389694, -0.268643779341714, -0.2689088310479549, -0.04169264729910205, -0.18946509103774004, -0.6048482798848517, -0.233354689008343, -0.5454560881592502, -0.9883295982428173, 0.5729192537609278, -0.7195403259129983, -0.255943063860493, -0.21219554410915104, 0.48909284704817363, -0.40870747048776346, -0.14661234525668446},
    {0.1466287181793586, -0.27291262810497663, -0.03000973931131658, 0.24546574036027471, -0.5759260010807449, -0.4150958034518887, 0.5649454407702861, -0.6916594453016327, -0.536278655233074, -0.34159295178805865, -0.5135694722826896, 0.07036098517581228, -0.049046927355103076, -0.6832633343146146, 0.4468054357258389, -0.017944564318726087, 0.0029103624126091254, -0.658774438925517, -0.12348753664004813, -0.676608164484081, -0.4515610489511659, -0.09773843040262338, -0.2746231642618641, -0.6690440218546626, -0.07230860825299948, -0.7715493704362705, -0.024103421644869408, -0.5329555299045894, 0.16943920998790762, -0.4735441934844612, -0.37823506699726983, -0.41394976934789096, -0.4380624834635238, 0.47810677702875737, -0.8629039135103738, -0.057696712703598545, -0.03423986963751024, -0.610523716365672, 0.24287562708310365, -0.763095020021119, -0.34952086664446447, -0.32999644814937423, -0.4285804139327444, -0.5561513401076003, 0.06075663236636654, -0.46632562621738916, -0.18545439497806535, -0.6222435358378209, -0.3628980019010778, -0.6415077135506516, -0.9626019238769954, -0.2808413428326494, -0.24030020006934394, -0.7246976967146441, -0.4665630227686125, -0.4200467719451011, -1.063327918308105, 0.821887308393082, -0.47847946418342774, -0.2733565943879299, 0.02983082598001143, 0.11352279614623527, -0.3793724488253188, -0.1674592730219622},
    {0.6635315324446727, -0.02118912519918331, 0.2960931411012648, -0.12024408798349376, -0.5532710500602277, -0.24051973571428042, 0.6661279943383063, -1.0580490102253706, -0.821231383756386, 0.09335096634783763, -0.352434280232964, 0.5551941086043113, 0.2678072705309871, -0.6684356225438229, 0.8457199212084943, -0.12090186552993427, 0.03127508136100798, -0.43772512932435453, -0.11587082574406332, -0.47222604501518406, -0.2929636592264748, 0.37889101156197447, -0.5625082352631502, -0.7252032334922318, 0.19665472744074614, -0.7092678578932837, -0.2548664805864064, -0.7366975238660076, 0.585544209643737, -0.2510990091488102, -0.3599673244344127, -0.6021576142441604, -0.4400679944414664, 0.5549332609966204, -0.624728123425125, 0.13024965327939025, 0.5575315111123683, -0.7794111845227818, 0.6884813126208049, -0.805484694404529, -0.3375123867820077, -0.5410342155076663, -0.10459940803430756, -0.46219222251627035, 0.19333882843570768, -0.3067772587400245, -0.058162704787386124, -0.5976851506124946, -0.4230553343140226, -0.4218574417877652, -0.7430429074037385, 0.06723192935024631, 0.07853300301689577, -0.5499300787847469, -0.32203348734155235, -0.4674306374865449, -0.6142422435092126, 0.6469062223224757, -1.0555939285306242, 0.04915470077179867, -0.23602372944854083, 0.052769092936276255, -0.5607166649307594, -0.1791781101056148},
    {0.5078028854374097, 0.16008116091043223, 0.48752829620070326, -0.009846771530074185, -0.2501754398858215, -0.15184852145434466, 0.6157888957251049, -0.9957749436776577, -0.5022477454118511, 0.27421237310827984, -0.24356228086845116, 0.15507684401110686, 0.5648750844485515, -0.45379393774148263, 0.8034702771975463, -0.21002853182548184, 0.20117168607170413, -0.29003853224448933, -0.030950837288409576, -0.6793940770527968, -0.05253860423541887, 0.3557709146623082, -0.4289954543643794, -0.6740500856864248, 0.4097320324562337, -0.6507894024216807, 0.12064464703744529, -0.8088924053209474, 0.6269715607800743, -0.5078187203231244, -0.5049679775261983, -0.5477955425495522, -0.4743778118480028, 0.4149143185911082, -0.8191079175832654, 0.25221812595747745, 0.5122758718884952, -0.6163174215847974, 0.7080178922816813, -0.467638209496693, -0.13420110756076523, -0.19824763478567844, -0.35158056565801743, -0.5148729551026017, 0.26747707268852405, -0.11361380217982703, 0.29313903168652594, -0.7155685757506057, -0.15889242085337707, -0.5765855397685757, -0.7546834447911969, -0.04136192090574612, 0.24842592565859112, -0.9752913373052873, -0.33000979188315066, -0.5612029056547667, -0.9262311823401082, 0.7276921473353404, -0.5201789866529914, -0.04103682538405718, -0.009519198045502605, 0.4435122947922806, -0.14718169928901362, -0.04024316182298303},
    {0.43516728495587476, -0.002462779426846839, 0.4105578192953675, 0.11375242520207991, -0.44062884609940717, -0.35577324526249254, 0.7029438489136732, -0.779795199309762, -0.5105878774101176, 0.10384584237731515, -0.45609521871129083, 0.34209652321466266, 0.46726317617078966, -0.446204591674364, 0.5869513929194745, -0.21929533038228471, 0.2310772508624506, -0.46797759833712055, -0.27452466303172113, -0.6463513975717435, -0.13151009251002077, 0.34522061493182454, -0.5765997436658351, -0.9047931806469348, 0.18312414835632398, -0.39944817792546056, -0.02223979827685124, -0.7436624437711911, 0.6670277614351103, -0.4044990923781842, -0.3876371326462652, -0.5137538821078224, -0.5557352409633362, 0.4820453528032301, -0.6996371968922916, 0.2270671797226114, 0.6197321265078067, -0.5408151080195056, 0.7607253312266603, -0.6996143904840052, -0.1258515517316989, -0.49177734157199426, -0.5143554019682735, -0.20175216489769673, 0.025591893520197383, 0.1145956825667346, -0.0030116379783546136, -0.6121824581249552, -0.595404648045718, -0.5934247463582547, -0.7228697968009942, -0.19105171113169483, 0.21118832818609656, -0.8048399964619095, 0.00029329059193901823, -0.6833887060583836, -0.7985636311672338, 0.48313835031330565, -0.8420110658398972, -0.0652639909064677, 0.014563872817888101, 0.2593034008450809, -0.30507643654658895, -0.05491134344731793},
    {0.7670386853891189, 0.07554840990357684, 0.289031351849296, 0.1658036109586677, -0.24597826371742199, -0.40583011035530375, 0.4386713419227319, -1.0380140222232785, -0.7418707766562692, 0.25937244721886427, -0.4834507899443384, 0.0813724757465366, 0.6066690075569646, -0.32714337545331973, 0.6392654775258458, 0.013333368327929918, 0.1657161564454605, -0.5066664753987707, -0.32379188954489196, -0.6918385504501889, -0.03167517561443918, 0.38977831703132915, -0.35638485409145115, -0.7498608419906667, 0.24070958464879363, -0.7027516541762331, -0.05278634132347571, -0.6631315470468006, 0.5915438948390985, -0.6669053047980086, -0.42313000993778044, -0.4024406143859803, -0.622195309940936, 0.49566356528203087, -0.7458827021136742, 0.2398297626328282, 0.5110518956533308, -0.7524506302729532, 0.5186987834749857, -0.6153918876209028, -0.24465282464657737, -0.46732324437065287, -0.32069929738372854, -0.25184617944495835, 0.133267357322527, 0.35060266244556376, -0.011757416249583673, -0.6564734537311494, -0.4077612958976315, -0.4938934848768673, -0.8516463384651272, -0.3847991983281251, 0.18875682446592454, -0.939188334488164, -0.39297461533920924, -0.6132262227265464, -0.9551828218942173, 0.7185053189537135, -0.561260841761052, 0.010219682269086552, 0.4567341167969321, 0.4592666816954202, -0.17492352481222662, -0.0060615746963669555},
    {0.5186424775733715, 0.23257317989092127, 0.3860900746053935, 0.12102953007276013, -0.2519090036646342, -0.5607652238277415, 0.8691446472327953, -0.7055418526647982, -0.715491348167213, 0.41878351582789697, -0.506485118736583, 0.40368055174900086, 0.1970680491781617, -0.2231055558907027, 0.7519347968515651, 0.15193129913118242, 0.23162162183354437, -0.23294830862055702, 0.03363526697934046, -0.6206307732581868, -0.14360524114458692, 0.6002855584880694, -0.450079809235653, -0.7078188950848832, 0.5663389177656696, -0.8248590949773541, -0.03746856336720394, -0.5604060736365415, 0.5133892778595954, -0.6106144432363515, -0.5979592124468915, -0.5137750840301883, -0.4422572508290521, 0.5249015433460723, -0.8106779548756863, 0.4185242720669944, 0.5460247622539816, -0.6772518370059359, 0.8044363747807189, -0.5752357929554553, 0.0034075481333147198, -0.2174869807424002, -0.4059530561350467, -0.1434322776583484, 0.4726153866836075, 0.056191948755404404, 0.21681179759300998, -0.728141666448271, -0.4766447930719771, -0.49062418885281117, -0.808497839720447, 0.04268880271535097, 0.22321362043065798, -0.5588284353082471, -0.11821487234923242, -0.5917666492837129, -0.9842862209760075, 0.7781586645356928, -0.5603408127613304, 0.16352165149929276, 0.023509130341426755, 0.4156926921191319, -0.46041610312343983, -0.017376726075283053}
};

static const float b1[64] = {0.9507090732868821, 0.8906089228423123, 0.9703496137758251, 0.9566496904973102, 0.9108804794423266, 0.8430628364315627, 0.9712765290915668, 0.9357000370357524, 0.8034022386386812, 0.9162671493151938, 0.8660005509223567, 0.8259586953434116, 0.9749830236839698, 0.9178572674038895, 0.9507017820978314, 0.8780985969608582, 0.9181684606875644, 0.9625449482539641, 0.996658057450427, 0.9379668703057805, 0.8716396772409551, 0.8878964408419959, 0.9325060147470866, 0.8982432059680568, 0.9344897470747644, 0.9136920818003568, 0.8424989342185263, 0.9238268547182575, 0.9125094995169041, 0.8891702726445052, 0.8879429841218187, 0.8592217558912584, 0.9650353057090264, 0.914642545932195, 0.9032168997309188, 0.6880154089917407, 0.9481924340148516, 0.9319341049650914, 0.905892415334699, 0.853333139527727, 0.9314911117334769, 0.8504346239761957, 0.7583687523918607, 0.9402183591319776, 0.8936248539052233, 0.8013131643922885, 0.8556017135121861, 0.7832454134422444, 0.961760714892728, 0.9552325183023366, 0.8006686504597481, 0.9464144205276551, 0.9762915210098422, 0.8688077893566369, 0.946122772355474, 0.9073618939547672, 0.9422561146337814, 1.012463609869235, 0.8260392301362295, 0.987552319547979, 0.7223532162208984, 0.9135058411796412, 0.9374788463345278, 0.8358473813927249};

static const float w2[64][32] = {
    {0.8338157967003499, 0.9187627739671366, 0.665691776723506, 0.39934367551882477, 0.7439561508233398, -0.13514524613049672, -0.20481621084839277, 0.8229651866716365, 1.0430786221329913, 0.8175327253712742, 0.7899104113426946, 0.9133436335948032, 0.8346835587836199, 0.8048197479129345, 1.2666053220757545, -0.3152299113346737, 0.8823534192037256, 0.9608110315894431, 0.6964121741928959, 0.5894341255233804, 0.6200799149132246, -0.3443004773871033, 0.8019021350086634, 1.1405862427187583, 0.649849584444672, 0.9047144240114434, 0.6301904052025559, 0.938087525687323, 0.9700081376358642, 0.9949150107863183, 1.0710400762888357, 0.8504767125483947},
    {0.5361068090191801, 0.9073565556533074, 0.9177101814299491, 0.6914848493049486, 0.857541095640818, -0.1767204545463624, -0.3847008255992587, 0.705163195993083, 0.9798518371590398, 0.8697971903889122, 0.4417787819602944, 0.677581313462394, 0.7872309259916567, 0.8002295538646627, 0.8121777134345539, -0.041370580950281684, 0.7648257005797693, 0.8971323023205859, 0.8967040007400001, 0.3510321417787579, 0.9658845482571409, 0.4705952461147228, 0.6984363487725523, 0.6101485917115025, 0.7147048148488868, 0.7119070666585445, 0.8113730324756273, 1.243147203324006, 0.49422179986784437, 0.8022478203919267, 0.8368388312625414, 0.2888653762595377},
    {0.911255677317637, 0.8237977853908853, 0.9058514548612537, 0.6286386986170356, 0.8083568914264024, -0.17297516618864844, -0.041144396241465916, 0.7483729570976192, 0.9059962388342232, 0.8223422765877271, 0.8589052683005612, 0.527620142631936, 0.9389343075221823, 0.7166068819395564, 0.6006805822267377, -0.08058281665615277, 0.7594117750416036, 1.0438298691883152, 0.8703557454418207, 0.5886563164309914, 1.058147184814233, -0.0690831481839612, 0.8499192047929027, 0.5435409789160492, 0.790265633994958, 0.9544587630271467, 0.9615648757252107, 0.8300649706613465, 0.8113697297026503, 1.2100508506604657, 0.9076513405891532, 0.9049336065214316},
    {0.6862441197569625, 0.8303013131729328, 0.6734618300573529, 0.43927248696379473, 0.8171269850648958, 0.14672003583042623, -0.018941721569685564, 0.9726209082417854, 1.1550359939182384, 0.764959304086354, 0.44440667675726403, 0.971287746863982, 0.6265019045233507, 1.2967764831507602, 0.6928421129945006, -0.1409010208628873, 0.641150616294871, 0.9434788336841883, 0.6435246493188786, 0.2818059165723254, 0.7983585980618096, -0.35366176919148734, 0.5965534357784497, 0.8564127317695682, 0.7497860473820633, 0.7370527877565181, 0.8462964506703234, 1.1655788539226726, 0.49525074664540586, 0.9626813554505582, 0.9072123094021501, 0.7449675474504303},
    {0.6463375581280285, 0.9499102465315934, 0.6156819861871331, 0.4687571478725728, 0.4518112088139423, -0.08734320170730968, -0.48972185937412843, 0.7113171761474251, 0.8967965705464358, 0.6877719806575298, 0.4172484279660522, 0.5270993394185208, 0.5001304540825917, 0.6928890163113461, 0.9856319454699457, -0.2716242245484732, 0.7447500318346584, 0.9046343280412311, 0.645520580755905, 0.1889979532121669, 0.488757385681375, -0.048714535781811744, 0.6806649211031589, 0.9017891473678921, 0.6810065968261179, 0.946719045836996, 1.2326661065353464, 0.8162868282773452, 0.6518680897817035, 0.9355520382919114, 0.8935106695516606, 0.6088318501080744},
    {0.8237385259200029, 0.8703392725783416, 0.7226600158424891, 0.5454909403680647, 1.178776810016133, 0.1155235079068508, -0.18044312096060475, 0.6294929352395517, 0.8781500832444515, 0.5624634723964093, 0.9088041025048414, 1.0047282050497988, 0.6479703258286083, 1.0916485209433244, 0.7709485756102874, -0.21514028208002683, 0.8196885848056907, 0.8171916210557911, 1.1798855029174176, 0.22061679202530166, 0.9782868235641564, -0.28470830739820313, 0.507195097281242, 0.4456178296452681, 0.7734097821888776, 0.7999706598685863, 1.09637610539563, 0.9660796894490884, 0.7202406891114371, 0.5972207078388164, 0.5354984650340727, 0.3629236181342755},
    {0.9659543524455566, 0.7107873424554225, 1.1605510281243796, 0.674327578200642, 0.7126793986061183, 0.15544175459803544, -0.22884646098926162, 0.9883291310703183, 0.808681971806339, 0.9382514649771713, 0.5400472501349991, 0.8076287651734743, 0.5871778057823153, 0.6992595899530676, 1.0870147740588114, -0.14137205884092977, 0.6907263434841996, 0.8600218959134615, 0.7029632635608608, 0.6154075822648785, 0.9055978950047939, -0.09191298389895179, 0.8073260754302842, 0.7684632851955814, 1.0024871543579557, 0.9824839264920611, 0.7703043809627999, 1.0939321490561438, 1.0368250183506875, 0.5580964662136279, 0.5565442782998847, 1.0014343955488325},
    {0.5779020116748885, 0.8560088638604723, 0.6690019061149792, 0.27399218253951924, 0.9407824582941716, 0.10847365231428026, -0.11359135400449759, 0.8604990233627607, 1.0995346473009846, 0.9098102276952431, 0.36536461708535833, 0.6929774321387775, 0.6508305397752965, 0.9416537606775383, 0.6607830091652315, -0.4037823220534618, 0.8410551848144822, 0.8742287970148676, 0.5450855739049606, 0.5131589553646021, 0.5730333094207951, -0.11253850781462245, 0.6965458204280985, 1.1048287731843613, 0.7724751881565215, 0.37849281741735163, 0.9862615922511592, 1.0519401325734565, 0.9545826836324521, 0.8505042782975005, 0.6511123831217922, 0.5343630702453362},
    {0.7683421719443937, 0.7139106030623988, 0.9636210761962896, 0.4398187057316421, 0.841276130341226, -0.05169338364852832, 0.004656899605850815, 0.5686884806883581, 0.44470788197683303, 0.8981369064489956, 0.8983787801427988, 0.7980818809523665, 0.882671639927507, 0.537653066656103, 0.7161373227013317, 0.082023641651397, 0.9472725143568674, 0.8456180126528151, 0.9212628083766279, 0.39773975783654286, 0.6475909215872647, -0.14680079677529045, 0.5244020785475647, 0.7841089980232255, 0.8804120123846831, 0.7789837081292147, 0.933981046304218, 0.9646157087631146, 0.6635917192757077, 0.6844826566578462, 0.8085982274305732, 0.7832854113702703},
    {0.6806211268174288, 0.45506515327357194, 0.8636865869425809, 0.5110869529001965, 0.21853508525626422, 0.39689134803486753, -0.12344256347174982, 0.8483001436620357, 0.8599859810074544, 0.8641061314119077, 0.6557978782881789, 0.6677943804562698, 0.5652667421811279, 0.7378600063170182, 0.968848061225116, 0.08422128091453586, 0.8019631571128389, 0.8427411362870325, 0.9794302672329145, 0.39566106246949023, 0.7931701584468805, -0.06499661417727431, 0.542898074790182, 0.9908550728393446, 0.9436054233123667, 0.8843673156936727, 0.9728134188741715, 0.787063901291771, 0.8602023689983562, 1.0245591033574097, 0.9245822725918431, 0.11349948556939236},
    {0.8772169462379387, 0.9991703964975224, 0.6971692545947319, 0.3919866970062508, 0.9446388661062348, -0.0755005879063865, -0.14397218699246886, 1.083648980011946, 0.6224780709192467, 1.1067041566643732, 0.9153767090326305, 0.8266976135950537, 0.9914678018499484, 0.983667925748071, 1.271700631717398, -0.014984388995068671, 0.9706363295168337, 0.9792834438317863, 0.9858180559828258, 0.4355447737406291, 0.7553708592382168, -0.11532754642088547, 0.9611571665146761, 0.7624009449238975, 0.8667567027723159, 0.7315643590972408, 0.8556549075779958, 0.9461528001375578, 0.4397573202579456, 0.7837447915328383, 0.7674768577137422, 0.7037684142984472},
    {0.554203501644533, 1.1691978143701547, 0.5628339730930032, 0.553152115728331, 0.8607463485940381, -0.3756820890567148, -0.11956921414876508, 0.828809938291564, 0.9982041188075431, 0.8502550739495276, 0.4108153558218086, 0.743892256787949, 0.939377487510048, 0.8549394299095806, 0.6454278523360492, -0.04343124989022102, 0.988491189477784, 0.6509272844394481, 0.8211605348128795, 0.33781988068719215, 0.8626950437195345, -0.05797841852253865, 0.8757365582993574, 0.7960932613758839, 0.7364483067116316, 0.913117801193955, 0.964765736921468, 0.848038457443743, 0.797785271638182, 1.130175745063032, 0.9092008317903426, 0.4457438736688252},
    {0.8753058162901496, 1.0601278149601643, 0.7148931597052366, 0.974102673695804, 0.7486261468775397, -0.09775289915343344, 0.10611500100993992, 0.7519102316034736, 0.9813740891540266, 0.547076016775772, 0.5482834006632528, 0.9287188868213243, 0.9367493176600664, 0.8996905402380956, 0.9344030561956453, -0.2187194538424893, 0.7451848969577378, 0.8369563929416649, 1.072132442907049, 0.3657627841617712, 0.8661310618409783, 0.13200195853770497, 0.5140330545810231, 0.9946645677422423, 0.6935745012561786, 0.6548700953140288, 0.6965019070741588, 1.1590895729241975, 0.8089615605840433, 0.7809743511711833, 0.9203750835780458, 0.7870142375220425},
    {0.9818891049108228, 0.9462865054367893, 1.0281872024505454, 0.5421463782464185, 0.9323941258967482, -0.2415843853114287, -0.08467813210762626, 0.9038745570982816, 0.8122150406874624, 0.7172424188006312, 0.608962164628545, 1.0071991768413218, 0.49498462567648194, 0.6812381532213271, 0.7342193898623695, 0.05090193909893864, 0.8040809419067282, 0.7455167379762971, 0.810705355264465, 0.5252870731485582, 1.0856237147849799, -0.03387525146639788, 0.6617924651115747, 0.6282297800102622, 0.7562464419581417, 0.4847850033151408, 0.7774326860000679, 0.9914716133716471, 0.6306303693965449, 0.743156928715651, 1.0973317479359077, 0.5589020911512469},
    {0.6781879090028372, 0.8399565677838269, 0.8795058375578038, 0.7642739390839948, 0.9570100524029165, -0.2740647596708743, 0.09018392629476268, 0.5289141097857932, 0.7568884470182998, 0.8938569473097926, 0.9152458521109803, 0.7836389509558916, 0.7694306082878056, 1.0545075117730907, 1.0281152835081808, -0.0813817838352938, 0.7379870120908311, 0.8739463886215476, 0.8014564034846234, 0.27452684551314704, 0.9386919034901868, -0.20855899949985096, 0.7212544897461437, 0.786539001441236, 0.916354790803286, 0.7061529222918093, 0.7909959919465548, 1.0426743438077306, 1.0336886725548688, 0.7265561911608515, 0.7847941999692063, 0.6946288500674651},
    {0.777312378504345, 0.7407353830170146, 0.7584505528347412, 0.4651979770747918, 1.1526676786477013, -0.2342809544421055, -0.41407370335320687, 0.8417676483118014, 0.9455432271507981, 0.8061888936586845, 0.9668461764659366, 0.9969649371213619, 1.0308584295394234, 0.7941558778067386, 0.5999266937741398, 0.11252637843738345, 0.9050800797547714, 0.9389904008630202, 0.8510370689395703, 0.7405926481438124, 0.8364712138952787, 0.09712085218688113, 0.5069001555041437, 0.6515647324804544, 0.8041293191930212, 0.9938694329821994, 0.9816297464594733, 0.9923428382952246, 0.5720137338143022, 1.1676032921949462, 0.9860102524416213, 0.7878889715815267},
    {0.8262484196941846, 0.8974700249760027, 0.7546036531175854, 0.6162000203094253, 0.807086875946119, -0.1355482636453576, -0.1188405371097697, 0.48882925005564265, 0.7725786314751129, 0.7071990475595031, 0.8742294423381255, 0.7086728003338888, 0.9283340003557827, 0.7501088898754346, 0.8388130478300925, 0.03427806879357995, 0.4583610203730657, 0.910493017134777, 0.8793714722702933, 0.15459155705498542, 0.5664793242730383, -0.23458151270719488, 0.48816196245527904, 0.9082420454416603, 0.7542646342166133, 0.8470354779705546, 1.1523142765925516, 0.33069742806203084, 0.7830657971355998, 1.0088696702986346, 0.887995049103919, 0.6035331043383281},
    {0.6239779666861942, 0.8599426894400589, 0.937649040764507, 0.28696736767348574, 0.7607380541834141, 0.008406641219150574, -0.05038705667610824, 0.9703836713526345, 0.8226350056595846, 0.5751024029061602, 0.7651138630435825, 0.7003715097172809, 0.9510266028784192, 1.1208714431805789, 0.6628230462667674, -0.3601422438336691, 0.6738204795527991, 0.9617259765427983, 0.9927331373880999, 0.5378239425905241, 0.42739140506828416, 0.05609851319783857, 0.804001310207145, 1.0986266015094892, 0.7554163422288401, 0.9187025052101533, 1.0234684955240252, 1.2044247419822922, 0.6568633045450131, 0.9071732682728222, 0.7163616718354398, 0.40206289303999193},
    {0.9994448079184891, 0.9628117834745127, 0.8516439442944947, 0.5036272095249795, 0.6249661517489212, -0.3050273891765035, 0.060636261110213814, 0.737059143626268, 0.9072909093195445, 0.8050413390102252, 0.6318306610323056, 0.9010380662377635, 0.601415697080465, 0.7300295399189572, 0.8670973625454187, -0.21326921582224706, 0.7352082246490873, 1.0692410843279907, 1.0664156658535004, 0.3013379572670017, 0.8422337081099771, 0.04762365670139281, 0.661310921270574, 0.7558033214296948, 0.6552114778971524, 0.7678618948317786, 0.7167159859680532, 1.0186233550019144, 0.8234635225359385, 0.8173831190630854, 0.9286726862972688, 0.7059896848898488},
    {0.6134129720623419, 0.6615957786662731, 0.9385361931947268, 0.5939393040233313, 0.802308009912733, 0.09074210582978832, -0.33580012435175816, 1.040382749804153, 0.7808954941874685, 1.1575678791022452, 0.9936893734406026, 0.7239587144830532, 0.6429826590072818, 0.7487011512436627, 0.6662284666523695, -0.11915766071302579, 0.8267180330666674, 0.8696079251136635, 0.910165328509467, 0.5995688016124227, 1.0230865490476286, -0.09940415820143081, 0.7114613065953092, 1.189621278476976, 0.961876757352334, 0.7995027877479758, 0.7642294108552585, 1.0003175434588671, 1.0779834779948216, 0.8091873809081169, 0.8172551900222913, 0.49535791228154064},
    {0.8078573791030702, 0.9258458845897503, 1.1652315183607511, 0.5251045148193376, 0.7303567036615186, -0.11675149686763552, -0.24007463429923054, 0.899863834808369, 0.7982924077327503, 0.8787034354102219, 1.2038235728365165, 0.35762550606365046, 0.7331542365618247, 0.8726117121658108, 0.6218039069682603, -0.15274545133453882, 0.8266890283449639, 1.0858939030840844, 0.9116951137195817, 0.400769382704804, 0.7298857874566641, 0.08538769467139166, 0.6367357365444827, 0.607562672917133, 1.0526258970541589, 1.2005542695249545, 1.1887001648768094, 0.9695568839466538, 0.6625581003213618, 0.9131138107469602, 0.6640673826995802, 0.7956745309820347},
    {0.3881070097948459, 1.0566869845570313, 0.7428902481811154, 0.6893598980661038, 0.7051772511206595, -0.10261496948053511, 0.07955129090864385, 0.9830413534877356, 0.47041195179254397, 0.96766047562175, 0.799155989105841, 0.8681656618189022, 0.4424688110392377, 1.102454811047479, 0.7012915922338999, -0.12514389061896106, 0.9805559925031416, 0.8881600974904021, 0.6381615347052072, 0.45676560314236675, 0.7505120626648191, -0.41878055228825506, 0.7266280517431105, 0.7682321828912644, 1.0753874915329111, 0.8244957054302152, 0.6862586419733965, 0.700491711141822, 0.9452707005587218, 0.9896498983589161, 0.7937132766634435, 0.7382960183523491},
    {1.1091819426746654, 0.8528319729253286, 1.1557045782207633, 0.4931523164022718, 0.5065757506518239, 0.03403713995910884, -0.20194598131727523, 0.8006173328343111, 0.7543645076719728, 0.8697916319391492, 0.7939311280843558, 0.853687476959818, 0.9505856075260751, 0.7842876440612166, 0.6628708828300128, -0.3299972346747774, 0.8924109375130352, 0.986710427343438, 0.9679179974862204, -0.07865096137538612, 1.011143296081702, -0.03765368091135373, 0.5153914222408353, 1.2251066459476307, 0.8045136244461377, 0.8277478038979666, 0.6939520994753644, 0.7984899440606209, 0.6824533673784946, 0.9600329873230351, 1.2094823770249514, 0.3935884541645093},
    {0.7138522394719164, 0.8804813743734764, 0.9326862468476532, 0.5641950712157043, 1.0413019618734707, -0.24411738130184496, -0.18154717497142583, 1.0288355370746478, 0.8311003981346391, 0.9617970435820902, 0.5525910855821538, 0.703612718116333, 0.7580200355759432, 0.6690477270119357, 0.5571971273737621, -0.204670387320375, 1.117608348667637, 0.5720806322746406, 1.1020865481303472, 0.7308291094700977, 0.6281013377063375, -0.20394199409674646, 0.9010465645908449, 1.1029122978129424, 0.868871964698336, 0.9905764884074545, 0.7574018813010304, 0.8788526029336903, 0.9889049812818863, 1.0832897653817863, 0.8628316340123579, 0.5778646408128654},
    {0.7485874476498647, 0.7299492512345288, 1.0009639256388023, 0.31488382895839606, 0.680856194701299, -0.10455258971722735, -0.17339056395935992, 0.795612290747553, 1.1615943493889287, 0.6229728554874034, 0.8313659651824449, 1.1848826361287306, 0.6797878279345199, 0.8438770733806887, 1.2036862109711246, -0.3969775182526111, 0.7956759733546531, 0.7146284126268517, 0.45303510677865233, 0.274092721401044, 0.7706254633705442, 0.17100461611442383, 0.5635720732567673, 1.0980745151260416, 1.063407242492844, 0.7269007678819172, 0.6680223619426158, 0.6029162770098004, 0.8599290761579114, 0.9591428615405699, 0.8511099860239171, 0.7042736448298751},
    {0.868188413780289, 1.0007740941675536, 0.6756032856164045, 0.6617656999806578, 0.7201074641359191, -0.19507134724470937, -0.3572761379853833, 0.8421008638796119, 0.8577677177164941, 0.7151783056017588, 0.7272917021827049, 0.32837058962170357, 0.8244899295656134, 0.7726964250637011, 0.9617833242769801, 0.12449667335351322, 0.8413553949797915, 0.7876467686544771, 0.8646946024608579, 0.47963457132327525, 0.6225271500213069, -0.08158468394737728, 0.4227900459585384, 0.8633834122087378, 0.9989452496533346, 1.0358823114583058, 0.8943683186880216, 0.9172132376850209, 0.5588023399871331, 1.1648252299941337, 0.7734600027011352, 0.6601353348114422},
    {0.6463103093785071, 0.9139857981364083, 1.0479366751987678, 0.3298451463019084, 0.886105657116293, -0.29770691940124594, 0.1080473679751477, 0.7066744116010095, 0.9814788566670664, 0.7895165470260377, 0.871355317374381, 0.7547348872847783, 0.4542760398792871, 0.7819996093988076, 0.49899150976966394, -0.21851408291563335, 0.7910564521740078, 0.6601149142083944, 0.7863307921576264, 0.42663667546929135, 0.8579605064890322, 0.15068194402115126, 0.7376831885806973, 0.9602613049050752, 1.020789039698777, 0.7654546419803405, 0.7582450012140545, 0.7824543721948491, 0.8113353238742572, 0.8458539083002921, 0.798268809613468, 1.0037483223774526},
    {0.7492915378262242, 1.0272855822517362, 0.9504088717481719, 0.5175943026347359, 0.8705107276227243, 0.21940632760761222, 0.03206705054373614, 0.9101194035319453, 1.072074133636597, 0.9200658724435273, 0.5567890638844876, 0.8358625110530654, 0.8229613734752086, 0.929418448316545, 0.8487028648421628, -0.0830511655558627, 0.7113895910379143, 0.8184123075217179, 0.7189341047127396, 0.5070500474309338, 0.876938284326276, -0.17283643848663696, 0.7977147753085221, 0.7674795181257954, 0.7331415477185536, 0.84451374760683, 0.7530431317841499, 0.7284001134453028, 0.7292738682358388, 0.8744890970402983, 0.9514436658405679, 0.5627489062820389},
    {0.6579548822923131, 0.8576314456110824, 0.69299235103362, 0.2925929545886594, 0.5774274590351045, -0.008999424384044663, -0.15116912942475388, 0.8230771813454248, 1.2210347597214959, 1.063250965715452, 0.7680442643915651, 0.6410717294468662, 0.5890527843666815, 1.0530170705101376, 0.9229872983812744, -0.13857138072551517, 0.8203739966542501, 0.8103333799618856, 0.817869441161307, 0.445919266282427, 0.750385839275468, 0.15566188769546416, 0.7810986275465804, 0.8936762518680449, 0.857408049230268, 0.9924254972676756, 0.7195816453007616, 1.287568389887698, 0.634129853406045, 0.6579944053799833, 0.8508040787240175, 0.5585461047406503},
    {0.8892228623838516, 0.8721016976489787, 0.9693290087130336, 0.541392215617444, 0.7076322021874972, -0.19284778852653, -0.32584239446282554, 0.6813813304450361, 0.6878144685834237, 0.6684556516125195, 0.7506362817345117, 0.4915824344427256, 0.5392554086886617, 0.8188959604038595, 0.9245351690035233, 0.21645128203082845, 0.8361730066803507, 0.6965792732070903, 0.9011373920014201, 0.5373607739143441, 0.5745804644536491, -0.0898822266844282, 0.563515984069277, 0.8885995188048983, 1.0227783567798021, 0.9212304754188262, 0.8459835671379232, 0.6412172556884171, 0.7319383074344683, 0.6995262268894319, 0.923191625964672, 0.5028231322460313},
    {0.7184648474412418, 0.578620027084862, 0.7119756377034779, 0.6923910616938853, 0.7707035915151415, -0.14817119557360536, 0.08952333506576528, 0.7130312948084895, 0.8064094873437777, 0.8886279958626081, 0.9516435474290172, 0.506156332899306, 0.6964381723356173, 0.6112479751326608, 1.185726422233946, -0.17425265712570345, 0.8325819550317297, 0.8239202270856738, 1.0045115529533393, 0.42906287033758167, 0.5742144764095138, 0.19509146466956598, 0.7468076447839603, 1.115768556018618, 0.7746080313444059, 0.7672474900184342, 0.772091029600946, 0.9990455894280311, 0.7638540255715486, 0.6517722790222314, 0.7562827822097755, 0.6743863761539719},
    {0.6565073920701319, 0.8858777730305767, 0.7499772409546146, 0.5503742799843153, 0.9725694677961664, -0.017769192827508166, -0.09200647285312274, 1.1112258493787894, 0.8346533037722462, 0.8390968600086831, 0.44461286299565017, 0.5511154892170322, 0.8590275480352839, 1.0556940228633496, 0.9056341349912467, 0.15008110625861154, 0.6651079303587756, 1.0943643895498292, 0.7574246813984551, 0.46430458692241194, 1.0915397879422868, 0.17677763906947885, 0.5229051928296967, 0.9753954894128494, 0.9070013150960484, 0.9123491824482836, 0.8494710093953011, 0.891417762293852, 0.8377113738776294, 0.6226660717638706, 0.9456562046585343, 0.32012983387201355},
    {1.082027015002772, 0.863797940394619, 1.3140595589226347, 0.37494721178517937, 0.6951197381811282, -0.2007813291450935, 0.06642611845341523, 0.8012236089455705, 0.9478180240392098, 0.908996843253677, 0.6666588846011577, 0.8360512696188659, 0.9453641211564736, 0.9520839920405206, 0.7834334140442077, 0.2935082269662946, 0.7595727666183775, 0.9607821876328769, 0.8539478119881639, 0.2844361764342111, 0.4426058014144412, -0.18523001145512838, 0.8506252565685302, 0.8201850428586638, 0.7731665126983756, 0.6866798235291928, 0.9968347809939595, 0.6115612515924381, 0.6066244461057868, 0.8791817606425867, 0.909564832803217, 0.7960750522904816},
    {0.7145176663445291, 0.7902643702739768, 1.0284350007118988, 0.7753002613172251, 0.9229251134559728, 0.2094885182278321, 0.18493717182517064, 0.796177740214651, 0.9589402607785241, 0.8380138092797073, 0.6765473120831785, 0.6527627670517185, 0.6395485022469649, 0.8505751973933842, 1.0407946176381468, 0.21666418302613422, 0.7274720460204085, 0.7296101560931045, 0.9360011359817355, 0.24034464286355797, 0.6633426988176745, 0.1961216732797006, 0.547252087716761, 0.9510024289345519, 1.260645686523508, 1.0910887657073924, 0.9046509799531044, 0.8090594559469849, 0.602246157067606, 0.731280095485754, 1.4059717530001559, 0.6021038288377099},
    {0.6209819829001159, 1.0667448821388112, 0.736346279197889, 0.3787679515111243, 0.7240869844098199, 0.3490976497326667, -0.1988652355184741, 1.054645895265851, 0.6983515615152905, 0.5900856793247167, 0.6150342125634026, 0.7876366136081399, 1.018031766326028, 0.9994569683075166, 0.8604683391373846, -0.07779215730040734, 0.8818574987220842, 1.0655331790717038, 0.9504378142243337, 0.2719454911944929, 0.3461320014592383, -0.19579660300893884, 1.2616428858966404, 0.7914335573472013, 0.8393019354246543, 0.7100650755428211, 0.5746143316385831, 0.9872658303806197, 0.7854120531935777, 1.077655577574121, 1.0106596921072428, 0.25584940574962883},
    {1.1619810095584266, 0.7400828186822032, 0.8181455790858915, 0.6439683296140232, 0.8309398194865463, 0.023986823177742277, 0.13973091785055955, 0.8186243944848755, 0.7561547018283724, 0.8716280402137366, 0.7738661209606061, 0.8507100324392537, 0.6537791813625775, 0.7944745145993898, 0.42558524903638195, -0.21196999202283962, 0.886682639509213, 0.5638283166676943, 0.9587358355567974, 0.19835518103570826, 0.5638959696448614, 0.14905069938467394, 0.7729015481499187, 0.6380727312455865, 0.749196342237131, 0.8991151317144849, 0.8779034702173019, 0.7842286710204458, 0.7606195077300543, 0.9050197246048725, 0.9913564436998368, 0.5317283569838511},
    {0.8930397990856145, 1.043448988215261, 0.7628695690496923, 0.5321929105780963, 0.8876691015940616, 0.06427794754947115, 0.09479009116931338, 0.7446935707706349, 0.794153932945518, 0.9166969159639908, 0.8017772888131429, 0.8186254059147722, 0.9368631045259681, 0.6052239013938097, 0.728636691394127, -0.005056059233076442, 0.8548725577016869, 1.1547449877464322, 0.8620853363107811, 0.30690620282630604, 0.6994356391593533, 0.09729129519742835, 0.7065718717493664, 0.9290890283294078, 1.0831256048422142, 0.7606773263716456, 0.9757506831417136, 0.8259003595970216, 0.7771400619751483, 1.0617544525086409, 0.8642679408925421, 0.748679522516881},
    {0.8261252579294902, 1.0484394475407135, 0.9482247178439062, 0.47006010943133564, 0.7072322204283654, -0.2595331986231253, -0.5312414261513204, 1.141623315296932, 1.2401890885347016, 0.8790164563547584, 0.8386605314343919, 0.7660209024701872, 0.7627199609929814, 0.8942656624019856, 1.0516813068483803, 0.04069323200972009, 0.9575750891605196, 1.215669343454907, 0.8150906067204496, 0.09657627978396245, 1.0964995093740368, -0.33376605630411027, 1.0120439796158178, 0.8039129221975994, 0.9524350977053124, 0.8715131412251192, 0.8498690630014663, 0.703759957934419, 0.8839903768151528, 0.7213354590339753, 0.7834753002785037, 0.788899911555285},
    {0.8638558316201509, 0.881968031941939, 0.8324571459271257, 0.3923593102063805, 0.7868700490072688, -0.21926665781256305, -0.22196315937790928, 0.7180727687018809, 0.8332644566068359, 0.7596648053776007, 0.8085156673057898, 0.7036977806703805, 0.9086508976620367, 0.6505154569998729, 1.007057833007082, -0.1653003882338103, 1.0476100776916408, 1.0158448751685087, 0.9233663861858294, 0.2856240004736377, 1.0107837434221243, -0.2504456384268796, 0.38740756367216195, 0.7150421762904005, 0.7799140557529682, 0.6827311422474833, 0.7521360719230161, 0.8770599542875762, 0.39212592569585725, 0.8712951018428547, 0.9289150863874718, 0.5235921991748931},
    {0.9103274363586608, 1.0202232411372067, 0.8174313609053788, 0.4854131044410575, 0.8304583292031423, -0.08077354721875354, -0.011786093860932646, 1.0515898201978306, 0.7414546852049084, 0.6466108883602799, 0.7945772764021554, 0.6741813848203807, 0.7934095567107138, 0.9173903825370767, 0.7303144952886705, 0.14731668564452527, 0.7965935811928357, 0.702805809967039, 0.6803032059293781, 0.5755899353940437, 0.9482724925309942, -0.1528759747813325, 1.1274775575808076, 0.8657380925648258, 1.0242751602547648, 0.9798141509203051, 0.8142402700259689, 0.7720178171446076, 1.0416195056707547, 0.8577696896262501, 1.0434191670094841, 0.8981511877685373},
    {0.7642036211323016, 0.7065360081776392, 0.9565929989035795, 0.5673683557557918, 0.6805666677946779, -0.17653490184419834, -0.03384791486815459, 0.6556149881547271, 0.9638609990217005, 0.7645877921545882, 0.6131050708833382, 0.8928372185776614, 0.7371635990924669, 0.7560562725555376, 0.8159636302297959, -0.11046273330476343, 0.7013377666407904, 0.7295536168983247, 0.8595156042660046, 0.3638311583739366, 0.49914734515697895, -0.07113076132998591, 0.7483273196869166, 0.8705806851130407, 1.1039227507289833, 0.8822745361085562, 0.8928208388648562, 0.7423877488903778, 0.7799545741067322, 0.7469182703159342, 1.1329614506756125, 0.2904991690497022},
    {0.9683586362889692, 1.1630505712572854, 1.0258606373405992, 0.5424480436412713, 1.0356861108024569, -0.13879313958736056, -0.046066323781008243, 0.8024934303559715, 0.5848881400399093, 0.7746992847534437, 0.8570443082555314, 0.36782762782204725, 0.6979155445491168, 1.0717891042105314, 0.8610334792979221, -0.14763875788292488, 0.7946914058696332, 0.5848286045867487, 1.0270479332725684, 0.41400619020830254, 0.9210639921201574, -0.33486228911055804, 0.8538612456234926, 0.9413815593726409, 0.812912184988967, 1.0614867877160181, 0.7134555752167702, 1.0157050990748704, 0.8702756017634562, 0.5531873408736502, 0.5781723712771112, 0.41795382182157037},
    {0.48724915773885247, 0.648994697450285, 0.6333800623961763, 0.13813267596958786, 0.7310956637599831, 0.07811662368375617, 0.22619180130588357, 0.7539296290933786, 0.8867815852936849, 0.745417826991378, 0.5500097587610816, 1.10148315497979, 0.4168483933449478, 0.8888630174893987, 1.1519578107928197, 0.05507340513393537, 0.9195801292008251, 0.32908132659964817, 0.8454434690373116, 0.7249824718367176, 0.7659300226782856, -0.14528744008913447, 0.8950671973979624, 0.8504857430530656, 1.0471668343029261, 0.42831569245531087, 0.8774660059812569, 0.779118122618021, 0.6021305085613503, 0.8961648791260706, 0.9683458467140383, 0.7962370825379911},
    {0.5671448771876214, 0.6371448321110113, 1.0041486548337177, 0.9787139712313424, 1.0761270733967536, 0.04308923055840023, 0.18962186280362822, 0.8796195057240848, 1.0022031331898091, 0.704622756744445, 0.7130501621164497, 0.5947851674158099, 0.4924357461334093, 0.8755320796697605, 1.037319120079902, 0.09202422280789135, 0.3879313657969084, 0.8055781482605833, 1.0202525588295888, 0.25411355352472, 0.8061805164437399, -0.1609195304383419, 0.8765718580973115, 0.7992473200625217, 1.2203415009175835, 0.5847395372950126, 0.9076360949480675, 1.0401931980377075, 0.45611486925203554, 0.9828862418768809, 0.9896112569456302, 0.8067924954293488},
    {0.903020400399675, 0.8755855276393602, 0.8788659205057505, 0.542596547665094, 0.8302754092479819, 0.05852175821612655, 0.35105408927020204, 0.9594840578462681, 0.8275227833370535, 0.8508269444393608, 0.6026795017870571, 0.6608568416310471, 0.7073269972948586, 0.9941511931695959, 0.6229576977608253, -0.17171918891571983, 0.5688924756608268, 0.92446808760657, 0.7982575702158063, 0.3852430396406041, 0.5144913236988355, 0.05459841628067723, 0.7156742320637453, 0.8885443061984873, 1.0504461945175652, 0.9562721007533177, 0.6584796378813798, 0.945471814467056, 0.7811328410642709, 0.9486601061199109, 0.620643533043772, 0.6464901244547177},
    {0.7984258593255585, 0.7491024053348007, 0.8266857537985954, 0.537953087238697, 1.0528039491098868, -0.04952611349912722, -0.4257295176595682, 0.6023142244971035, 1.0926234972386257, 0.7571470329768138, 0.3980133815024328, 0.6381830735296476, 1.0095288611217434, 0.9202280916605845, 0.5082692529610884, 0.022785309068426712, 0.7116116295617384, 0.641690166772997, 0.5906378665490883, 0.5234643551806634, 0.6522115511298489, 0.032530040227915065, 0.9817238712463737, 0.9839084061321178, 0.7255401946321118, 0.7923617934102618, 1.0821075096973847, 0.8308765593037597, 1.0150834057002491, 0.8493939966155236, 0.7849420847452291, 0.6529036730935154},
    {0.7939556390514443, 0.5933041472080812, 1.0431074618518617, 0.49191758048277007, 0.8894879542740438, -0.061206224552123364, 0.03182956309985824, 0.7765227038394698, 1.0134077871577605, 0.5878898470271844, 1.009330192435616, 0.7568150239784183, 1.0329901263198102, 1.1589487619826682, 1.12648819182617, -0.2818836603060016, 1.0043379884014079, 0.8946223885389941, 0.7677550421917291, 0.4117897291928516, 1.171524763620627, 0.2790869630878112, 0.595992027899365, 0.9956261318959586, 1.0542404859491241, 0.8496516474587565, 0.7841274747546901, 0.9808137977568118, 0.8092348365804148, 0.8907279044514089, 1.0492382869307344, 0.7255631137262714},
    {0.8792747829683533, 0.7916943232953976, 1.0010894468845322, 0.7441053176464805, 0.8556405428176882, 0.13091535539448879, 0.3402900459259881, 0.6147299391521022, 0.7171976113754351, 1.165386035224882, 0.8514378905614989, 0.7520946399383163, 1.0344281133292021, 0.8203671250569108, 0.8490857410180354, 0.006845890593680091, 0.837829282207491, 0.8089250508485711, 1.07773942595166, 0.42352375336568315, 0.8809201782629104, 0.27384946456162373, 0.8510829729834687, 0.9482368832337121, 0.7844459515151531, 0.876656868683598, 0.7385217042424057, 0.8368680123803631, 0.769233431565845, 0.6541384771010901, 0.7533733207652128, 0.18277559124706386},
    {0.6532158034552069, 0.7148573211066538, 1.0614623990402279, 0.510002818415773, 1.2054645210207813, -0.01987772578353482, 0.11249198007680887, 0.567264903055807, 0.9405041512004991, 0.6542037961619748, 0.4853510528371496, 0.6118657510144709, 1.131347757140524, 0.7448375044387606, 0.7426511668112851, -0.033738297667391046, 0.5030986071677769, 0.8418314760571268, 0.94153654680055, 0.7808823640914374, 0.7223916000265539, -0.11847763172896922, 0.6793824025902573, 0.8868280813412274, 0.7943194787629962, 0.8261479938196469, 0.8557837651995744, 0.8845861861740605, 1.028827667478234, 0.7077565153614789, 1.1155638666712508, 0.47877410148275246},
    {0.8091196121048317, 0.6979775850339922, 1.1972861322454116, 0.14383497475922488, 0.8295566589549376, 0.011080164881350274, -0.13610955098296043, 0.9992792295195552, 0.8772714711542601, 0.8947307979258878, 0.805527156249711, 0.26262461941870435, 0.9180791436302478, 1.0754284921583204, 0.8261023411046156, -0.13909249182702976, 0.9034343508895276, 0.9072161483610125, 0.7399809947906609, 0.5975108210280601, 0.627026523082058, -0.2229474423902639, 0.49527189006579403, 0.8863506889399463, 0.7796472620396552, 0.9281528813390518, 0.9369064526058518, 1.208174371206698, 0.6635203712681876, 0.8952214839504902, 0.6708612638734975, 0.8505447894031707},
    {0.6158364176955261, 0.793767711646924, 0.6454470920250881, 0.6784192342913137, 1.1123457735222393, -0.020070958510110485, 0.21757130301093952, 0.674574714743477, 0.7160627974560473, 0.5109612334639068, 0.8553989373206216, 0.7365959585532977, 0.7810350411132112, 0.9427183548000735, 0.676309793823252, -0.056899496679972975, 1.0546920086030762, 1.0797393932559953, 0.8599689344381161, 0.6000238980904657, 0.49859068819127816, 0.12266228703433313, 0.7708815489917762, 0.8754631802619831, 0.7372013752884435, 0.7531862931282238, 0.6150128129352703, 0.8712212110665816, 0.8168989411237056, 1.0490943359754947, 0.5386836802161481, 0.6046911575858459},
    {0.7213415392521193, 1.0679916833697207, 1.0646166241837312, 0.4791911477462423, 0.9675831725706061, -0.02082445609193974, -0.004688798115300594, 0.387677787218234, 0.6484963426168322, 0.6160342543200648, 0.5560946227610335, 0.519203397415904, 0.5248992062680279, 0.668630975554677, 0.8506919893261443, -0.17471898568872765, 0.7713339471847392, 1.0767595951386906, 0.5382180229420127, 0.7108994434436628, 0.5273508204003811, -0.21269071656681202, 0.7340880389965342, 0.9376836529615781, 0.773672820246229, 0.6740863388985802, 0.6065824858486345, 0.9144714844578827, 0.7924372525438861, 0.5559886424421556, 0.6762099260599507, 0.51603767590325},
    {0.9378384014045761, 0.6761664870321966, 0.6448082237557505, 0.3487445194030977, 0.8546352647178398, 0.06170816884497336, 0.10807667709453696, 0.7584943965116158, 1.1849924957371585, 1.0099146290396348, 0.5992221922132802, 1.0693450512972191, 0.8503688734015995, 0.967008389969008, 0.9873308362648207, -0.3178139419889557, 0.46522636882644175, 0.9500802558714118, 0.5439235177134876, 0.36076102270390087, 0.7449842182998734, -0.1295070626094294, 0.591075897371433, 0.7176943862063171, 0.8851538330419696, 0.7941506530075242, 0.7989290611384064, 0.9063955088318919, 0.6154230675307941, 0.8791632698822236, 0.9854077717592179, 0.577791597961928},
    {0.24980986615855755, 0.7409084283818154, 0.6115437790473546, 0.6088131951903307, 0.6910465963653473, -0.0008609382819460863, -0.08463860665636773, 1.0199352383426024, 0.8707145557081061, 0.9177892153459567, 0.6902772421506296, 0.5241731843960825, 1.0526906739096566, 0.6897950974667139, 0.9816926471166134, 0.07372609245048506, 1.011526493552891, 1.0021442195641177, 0.5933304824934585, 0.6490449315262273, 0.765316041792402, -0.45707132572241654, 0.9935619992219692, 1.0159295274942437, 1.0091420549484509, 0.8723700450105368, 0.922225339029786, 0.9890346150262236, 0.5096994000903267, 0.7067296500468964, 0.964093677877617, 0.8090999614728644},
    {0.6469582852746482, 0.44292392005940656, 0.8796415310814387, 0.6965384040782506, 0.5496933127000837, -0.12895659647297358, -0.11275038994807611, 0.7510759771440312, 0.8301262720105557, 0.5589253358545377, 0.8226011457877503, 0.9015656934121168, 0.7639979846986901, 0.8829935013626286, 0.6186939814550978, -0.1707551086337337, 0.9033066190633992, 1.031386118079922, 0.7911724801907977, 0.5384885153121977, 0.6981351619577426, -0.2454950859311225, 0.7438136114159565, 0.9095555011660512, 0.8809763983020586, 0.7841672304332504, 0.8982462454088547, 0.8443542231380655, 0.8643938197290275, 1.0473057513032336, 1.0193472665046253, 0.6363795065797799},
    {0.7769862815374418, 1.031918987656251, 0.7904681286652424, 0.44318897750265773, 0.9015444369988009, -0.02453694854836709, -0.12914454816503954, 0.5241094675791665, 0.7967492449756552, 0.9751988871756336, 0.8655424549619823, 0.7888285717506697, 0.7020295546307107, 0.7977824038970346, 0.7809514258374544, 0.03001764013710243, 0.9251028403516784, 0.9524607669876046, 0.698547140611866, 0.7757811774944099, 0.7544633699348035, -0.06326768691640387, 0.7470936485676262, 1.1255733270576251, 0.583983533311695, 0.7051896098017268, 0.787093144392039, 0.8135432961806074, 0.9312735846562088, 0.5936642214008654, 0.7684777654656534, 0.5854746909136161},
    {0.7997652466616988, 1.3941233972219407, 0.8248209956599449, 0.9025412105411873, 0.7920420089030068, -0.11848574971217683, -0.05319767471535209, 0.7214098857696125, 1.0265331318406123, 0.7723433929181709, 0.6572877237034839, 1.0257170143718857, 0.9710014872113917, 0.9003412735697143, 0.9348424816277336, -0.3705369837740304, 0.6301104214696872, 0.8218145169161275, 0.9251222888531692, 0.5221971224470017, 0.9271267936645823, 0.04876212491281703, 0.6428075933821625, 0.8157895188667407, 1.059732730628781, 0.9060752872301817, 0.6301721037808311, 0.9066390274464722, 0.812458658272877, 1.0406081345284262, 0.7846855061481031, 0.5338987243410359},
    {0.7088939892587557, 0.7455962812729372, 1.233217647271247, 0.8990280171432289, 0.8307356044371761, -0.1853406305208393, -0.12896858129364208, 0.8819269136140004, 0.7797461899671952, 0.8566902556547463, 0.9997259175342711, 0.9374779443318213, 0.948321229439007, 0.9704944242255894, 0.7858363374943368, 0.09657866324892202, 0.6850269452090034, 0.9916984234637605, 1.0151661529653653, 0.6926104434595814, 0.7230474903238567, 0.0490218358895453, 0.9971956437993219, 0.7408787577577304, 1.0606847906046046, 0.68504991221863, 0.8962181554924494, 0.8485022446182979, 0.8884955850189006, 1.0093990992590178, 0.7079758813463011, 0.8123174017884135},
    {0.6709512663726105, 1.0857263492982692, 0.739383203170834, 0.5760348069410098, 1.0122566093770193, -0.040888347242429644, 0.07042136994440963, 0.8312011850972628, 0.6584317614256616, 0.8481348281268202, 0.9076803672404449, 1.137284897347601, 0.7390433421910291, 0.7478235850735364, 0.7167797149026792, 0.2657327518901343, 0.9862264010578421, 0.5141557802465107, 0.9468771305388122, 0.819020728494923, 0.6131731099801504, -0.006652129234852161, 0.6776555076351124, 0.9429271344355179, 0.909179982059729, 0.9598774211092314, 0.9810813505611578, 0.737535689877945, 0.8489332698033495, 1.118805127308751, 0.9588462730710301, 0.807704034595466},
    {0.9150291659588633, 1.2476461874021718, 1.102567846038082, 0.4188829854111518, 0.723989865937056, -0.0875865879372684, -0.27592170282198564, 0.8818351624683698, 0.8798156363766222, 0.7227321040882094, 0.6452800884783788, 0.9126444956415724, 0.6074683269661175, 0.6921136323710548, 0.8762869958078058, 0.21310827017398765, 0.7603001941120098, 0.9637392980395181, 0.8918633689725641, 0.34848264366677, 0.574970939394101, -0.19102273117505694, 0.9756582897340775, 0.7125072762894363, 0.9263747484066857, 0.8685034424117039, 0.5782007678104263, 1.0678867525389886, 0.9979258750673878, 0.711727756788285, 0.7533201544652016, 0.3642360805079729},
    {0.7521706884886201, 0.6494145250724884, 0.6509834308398518, 0.4837144043799605, 1.1300475792193354, 0.01132814361214329, -0.0977943251994749, 0.6613272029301757, 0.6995701313654554, 1.1635902949777304, 0.5085441369819741, 0.7519824453663447, 0.7315500709554323, 0.9977531291049975, 0.774298540119125, -0.09577697086202797, 0.733170450930249, 0.7877534785437732, 0.939203296427866, 0.5696388054580248, 0.6114500429424813, -0.05611236823949495, 0.7623564815117847, 0.9881164318183787, 0.7139701217081909, 0.904120054007272, 0.5796369615860596, 0.8237687624584025, 0.9767944054734103, 0.6226258972293124, 1.0045373190790965, 0.34991102965998266},
    {0.5820286674201037, 1.053486349172596, 1.1718162036711153, 0.4618479107474078, 0.6323600789590449, -0.0730464945958706, 0.19573179223947598, 0.9604705130076071, 0.6839576592169792, 0.6421572910027368, 0.5720695357840293, 0.7463543990606524, 0.330414835297696, 0.7154100759439571, 1.1252411453870357, 0.10584489151862218, 0.8207683029784232, 0.8682983973389692, 0.6924378529219122, 0.6291761351146732, 0.9348056342997506, 0.16019993588480494, 0.7829678256104448, 0.6664296017705893, 0.8544620497520845, 0.7611497288106527, 0.9102571794237406, 1.100900731111632, 0.8152428886173364, 0.915009197976324, 0.7026542289905757, 0.7064331257246416},
    {0.7103494854147567, 1.0925001305122095, 1.0430414226774547, 0.6427913664633851, 0.7273224233551272, -0.06645738473214473, -0.13082315361753585, 0.5659637851827266, 0.9174975563084191, 0.6631420389370855, 0.7453036720518479, 0.6960907835546393, 0.48104176562374246, 0.8818123683872867, 0.6881075897495808, -0.22893585641680947, 0.32650335255670826, 0.8559831476034614, 0.6135387209811131, 0.603884023660976, 1.0778883369440893, 0.42466422502207873, 0.662537290457569, 0.6488093188690627, 0.9885871027365509, 0.9670327032139995, 0.7364552139090422, 0.9774451840067124, 0.9929190827301132, 0.6786211945862872, 0.8477252237752355, 0.8041086834013359},
    {0.8664940847404318, 0.7227694752732406, 0.964244182483388, 0.6972153280707205, 0.9568758044981626, -0.09384561694919367, 0.08508767623317215, 0.5057581256062306, 1.1955096735338, 0.7712826392301634, 0.7216682800051653, 0.18724659153278347, 0.6568461922167077, 1.0306375061564885, 0.7353138136580183, -0.10684681480452225, 0.9290198025333549, 0.7209753662730951, 0.6941656588412354, 0.5641058900621041, 0.752291429947256, 0.20061164863560932, 0.7745611360449919, 1.0103649488223356, 0.7573164401640636, 0.8402964561021807, 0.6781705503793466, 1.0205966675334688, 0.8413399264624914, 0.6011954254891254, 0.5727074965881178, 0.6385914527026968}
};

static const float b2[32] = {0.8139803982905333, 0.8411188067855601, 0.8195006116399589, 0.7204288938579535, 0.7725583896678186, -0.06446057862422627, -0.11220949920202092, 0.7672185848832559, 0.7963089958469081, 0.8319198982680729, 0.7005405963120862, 0.6892115097219738, 0.7287793780704098, 0.8323017580855558, 0.7466506953246228, -0.06940213156602301, 0.7185960455932748, 0.8056034239975339, 0.8591039309333707, 0.5685543697169885, 0.7028931065250676, -0.02207514607530117, 0.6988556402294107, 0.8046875018008337, 0.8417861227834953, 0.7392374588803556, 0.7426820890055659, 0.8823733318797813, 0.7746405278658705, 0.787670093447594, 0.798165250737968, 0.6648633406836196};

static const float w3[32][16] = {
    {0.054354717180630445, -0.27147952884442894, -0.14161629861849395, 0.6190810369970009, 0.973585642599207, 1.0322491544063577, 0.6661910471629308, -0.5488235105708787, 1.2800519466035774, 0.7946913654730542, 0.2267090650305069, 0.13893917710528966, 0.7578537306155174, 0.958677833849661, 0.5815584727115335, 0.26704835499414714},
    {-0.015392892393507576, -0.28224771093107387, -0.564294884249131, 0.872353136082874, 0.939982931788235, 0.8861279577378747, 0.9666064895305527, -0.08516928761511038, 1.1145583172463898, 1.138185605015856, -0.11467530934042977, -0.03164205237759348, 1.4882272434397006, 0.9025712062558873, 0.35012801630925505, -0.19513485022900454},
    {-0.33583701565772994, 0.24065373112037758, -0.19004236687938902, 0.6701000771930469, 0.9809613142843202, 0.9024468705584422, 1.2718656149297873, -0.12056418982212916, 1.456987512207423, 0.8966399457912857, -0.1120103155454332, -0.19169419447955077, 0.8991983093246846, 1.044874893410228, 0.5627067156017497, -0.22564220481492028},
    {-0.24454555220477103, 0.20354638953058607, -0.2434958980955378, 0.301745426797498, 1.0152739677571996, 0.8419999249725169, 0.9187042926960582, -0.13172887482933757, 0.7392059937767024, 0.8300300206447649, -0.1899376298945082, -0.04676027875631187, 0.9949977522632498, 0.40681312214278836, 0.8666336572540024, -0.05532109140016012},
    {0.06773783955926001, 0.18106960460456997, 0.18767523590655893, 1.0350273577263627, 0.9130726420119909, 0.9365439423513345, 0.9984911623965438, -0.08926561943720515, 0.7465889372070725, 1.1393529075046633, -0.2891765629421753, 0.1303546951668006, 1.1437528282281832, 1.2033640202278433, 1.0827427659783018, -0.27732577031490296},
    {-0.09667921973424753, -0.08375037828877886, -0.09569284995785335, -0.16198733005664712, 0.10324824748061787, -0.49627557109558645, -0.20269656403876388, -0.39052423751070686, 0.04338148192797391, -0.17219746877031256, 0.06652173296350994, 0.013543159440788353, 0.11246432258705417, -0.13648089642400582, -0.4410256458619168, 0.15106969293849018},
    {0.058882610324571996, 0.057835747026102294, 0.03273014230894669, -0.5122129838555706, -0.018000084036323465, -0.09803013407431109, -0.1263592386881797, -0.08034399975039029, 0.07171313757632058, 0.11905358820511862, -0.1797689444744515, -0.1373929729510254, 0.164622309354897, -0.3476291465831879, -0.09768718798750821, -0.2778202753107256},
    {-0.034499665768245154, 0.14898948676567006, 0.008464795211470623, 0.6735692356257061, 1.294376808870464, 0.8422816112940048, 1.1247751147039136, 0.12945843553435407, 0.8720611338291606, 1.1846268919259604, 0.08554256254913474, 0.12648912858902497, 1.312266729211132, 0.6979634266716029, 0.9959461917651093, 0.1634759596841198},
    {-0.7977784757040192, -0.07510807524082593, -0.2805415008406541, 0.9230544607353448, 0.6398392323286639, 1.2188999112932415, 0.37656320764276996, -0.5962807296541093, 1.4027766605888916, 0.692689448213706, 0.22216212008817862, -0.44750589307105065, 0.8037647298763188, 0.790395596084851, 0.3265363529833098, 0.1245898556051958},
    {-0.4704844360434148, -0.10156907957247681, -0.05499965396853806, 1.0886867074334958, 0.531486875921331, 0.6058185772523015, 0.9775494801090872, 0.08052825285370739, 0.9254116885332369, 1.26254952059696, 0.32141025063527534, -0.6549493421298471, 0.8948539620342422, 0.7906819590197008, 0.8295039311673132, 0.36503393883829116},
    {-0.04331592821292628, -0.11737226510336282, -0.1243176942605876, 1.35720864849822, 1.0157179508258674, 0.6318523677384655, 0.854105491713396, -0.09807427574556803, 0.6853288955144333, 0.70451103174881, 0.10755284664575801, -0.1289351503141096, 0.7145485729652605, 0.57202866723938, 0.6198180650763166, -0.07298608884312772},
    {0.07934881184345255, -0.668764626347876, 0.27937643533927614, 0.9447892258498899, 0.6017153943698904, 1.0162991399328838, 0.5025667252547047, 0.2636671599476868, 0.9637769650635818, 1.0656419418926737, -0.4979230753675916, 0.06132539727164402, 1.0386009345834175, 0.6980248032342687, 0.7483024628131464, 0.03167637487925717},
    {-0.16712104815368137, 0.1021472830125081, 0.24229636417982708, 0.7697701355116258, 0.8097586826397472, 0.9024256287255873, 1.1651500934481158, -0.5308766184812486, 1.020420353740168, 0.716114129005106, 0.24836263607442666, 0.1639016467282455, 0.7011694908592012, 0.9285092309671061, 1.0822550021268689, 0.053232144210799935},
    {0.16756106331317705, -0.053211397258595694, -0.013025270585789775, 0.7481793060469349, 1.3220753641217553, 1.0176912644374854, 0.8664894511540226, -0.07977141159710086, 1.2928169374068363, 0.9295912014847418, 0.011665745794221341, 0.07074062113087201, 0.8722609751454075, 0.6829258188689163, 0.868170486371889, -0.012463801743497068},
    {-0.06137703554676943, -0.16385732810053538, 0.06224920040006923, 1.161543907287751, 1.1129871767028623, 1.2696153399995957, 1.1241387785720032, -0.016158512205992716, 0.8645661855677711, 1.5121234057733102, 0.22982283168427595, 0.6190640838118392, 1.2219345892611928, 0.5770494796409882, 1.086819046945725, -0.1147161806836235},
    {0.24312393675892116, -0.06498258169987399, 0.42943756860304827, -0.15545384053467304, -0.19812299868884972, -0.008572462532529579, -0.2354109636948243, -0.2889117881635059, 0.11830394314411209, -0.0026689403413839245, -0.023994686202688145, 0.05182093806162616, 0.2506931194319748, -0.2567245688356017, -0.10082466572272569, -0.10251407494002888},
    {0.5187179367743243, -0.6541244015075807, 0.2626145297255183, 1.1019231722465699, 0.4677499355662836, 1.2876369253029127, 0.8474838892874575, -0.12626060294782612, 0.8121399180711978, 1.0019567786581922, -0.11974491747062403, 0.23696618192987642, 0.9893686799307783, 1.1564744444153974, 0.8769512186177827, 0.070190154498097},
    {0.7864135550988741, 0.07379448184368698, -0.23188778045385297, 1.2552129206413076, 0.8694051054927956, 1.616800781996943, 1.1211326405095685, 0.07619234455399343, 1.1796346925721912, 1.3648363659400973, -0.018522359717248242, -0.24548719215823395, 0.6737752226899182, 0.6208311106916325, 1.0711530436553822, 0.12729113698464412},
    {-0.2389472191274517, 0.021499543709710942, 0.11893621806321687, 1.0078880650164903, 0.9004956361798074, 0.7032977431295993, 1.1394105824582341, -0.45250137418655656, 1.289738860064011, 1.0807575897907724, -0.041571165133937125, 0.10002785283981215, 0.6233715399766211, 0.943377985239434, 0.739998244261601, 0.033790928909044386},
    {-0.11515087605744921, 0.14621498461015356, 0.2336764558324746, 0.6868324822384435, 0.6779916967232312, 0.11299435272199872, 0.5372936916987832, 0.42155119659298934, 0.9593400918362891, 0.61377438686222, -0.04138635021401482, -0.18462940458604224, 0.8815776339553566, 0.28092586481435117, 0.7296601634741096, 0.3582977063039533},
    {0.2829245485513992, -0.550526557622147, 0.12867616618878355, 0.9894910464047534, 1.0058786855664752, 0.822339931311861, 1.2728120902553852, -0.13109146816327488, 0.7800206517790014, 0.7920275674019516, 0.2611076594335661, 0.04423475558454516, 1.0545309657473938, 0.9916203108763433, 0.7735371071218398, -0.016371409521953},
    {0.08591633025898984, -0.2034346532186277, 0.07859215430555591, 0.018589384222426782, -0.15078180590309487, -0.19944246652760178, 0.031248486004945227, 0.04994610452944973, 0.40321564086055545, 0.16085582073951957, 0.11769463360180003, 0.37835582436529785, -0.47006364698670167, -0.10280829494688405, 0.3530469995452803, 0.6186255138055922},
    {-0.0327531538284836, -0.26420809462179135, 0.0334559793137292, 1.1401206779985626, 0.5663619894488734, 1.0174593875982894, 0.7726060588326661, 0.058254933341986025, 0.6514537255558246, 0.719713350466182, -0.7049231164093468, -0.21112822537328893, 1.2314961685026447, 1.095320558384962, 0.2660630013128882, -0.395291558405337},
    {-0.4136542329531889, -0.10342678681021984, 0.22608339667877178, 1.0974770879079163, 1.2455379349899707, 1.0850006983708973, 1.0249450146401604, -0.26878507834792775, 1.1285843666024291, 0.9058338300066849, -0.4357029951570889, -0.057532599186364816, 1.2031127230427738, 0.4205197813457965, 1.150707739659321, -0.3864738484622413},
    {-0.7951220439076192, -0.17982436224218637, 0.19769190492700656, 1.1386303841194119, 0.9121652127563488, 0.7684081370491075, 0.9338578757536669, -0.06486375211155938, 1.2661778193018405, 0.9337378911936043, -0.045115330924714744, 0.0960295147088771, 0.5249019535414714, 0.9944943993824904, 1.1347093725170772, -0.17702825579102005},
    {-0.45832912213622984, 0.032415399707576766, 0.1599640013707295, 1.1526527551203705, 0.9525684630250713, 1.2295830103599554, 0.694046155785504, -0.020119064662083515, 0.8587162576144642, 0.5636787717447792, 0.3040262282492919, -0.3155980402622307, 0.8441151551544956, 0.9826603972145126, 0.8216270231431874, -0.17533615139278205},
    {0.3442924587066763, -0.0007302534847475932, -0.0777689289287507, 0.7015652733984025, 1.3395738304025415, 1.2547902747896535, 1.4983945188636896, 0.6346574187096989, 1.1741909250065665, 0.8998151480208632, 0.3910636780825563, -0.28258124775832255, 0.9570749698160544, 0.7055511852021307, 0.850087793598847, 0.16232737150390275},
    {-0.2949302912658908, -0.01063060036807124, 0.12950581066264258, 1.0413232787435827, 0.734724964443232, 0.9558495869348232, 0.6635998716787616, 0.03011437650795645, 0.9190937443979559, 1.1645343123853098, -0.28243710800718885, -0.044848384924889746, 1.046065380855784, 0.9408800930455951, 0.7580523121189768, -0.11159899189683514},
    {0.5270354653052881, 0.021990327580733323, -0.3265300332933188, 0.6756869771192029, 1.1644380596444657, 0.7771561648871512, 0.601391433304701, -0.041156372467270795, 1.3073678766192882, 0.8684237699334069, 0.039786580353396085, 0.053264781206928916, 0.7574225301145887, 0.697845023955277, 0.9094487799725995, 0.32540883754584843},
    {-0.11423559969482366, -0.1517579129282918, -0.08857389577360374, 0.8626735889986427, 0.6495759120249361, 0.3305285961558338, 1.033764226734626, -0.0253455817624571, 1.1179575450383108, 1.2460217625258223, -0.5896321881251287, 0.2204486149008334, 1.0868190343927788, 1.0378771875237711, 1.110195806403413, -0.12493093050524379},
    {0.14489237446820902, -0.4897418946311447, -0.25112211244867594, 1.4444597064163178, 1.1978162535854675, 0.9367637694245607, 1.0875828617103995, 0.4492523237167366, 0.789268290497449, 1.1495337428834327, 0.20504020329057784, 0.12700924926875848, 0.6539467933673365, 0.7377912243745477, 0.9511073903440166, 0.184863637019479},
    {0.1547744363199216, 0.28312129781843137, -0.7030363591782326, 0.8155540495406706, 0.47396936668425305, 1.1433165943619141, 0.9420625940172548, -0.46697534038502664, 0.9349186085437027, 0.4323612276449133, -0.2993874319718569, -0.17534353966912863, 0.6913399187649786, 0.9480969962806841, 1.411463096376359, 0.06785558401782972}
};

static const float b3[16] = {-0.053245051582476555, -0.050709202419994055, -0.04821654764807166, 0.619028532804433, 0.6570038328102108, 0.5224571769900045, 0.6056191567227481, -0.029599503875207763, 0.5859277529907109, 0.5737389783809431, -0.03342386294750272, -0.057756038849535854, 0.6053051456689228, 0.628414472036444, 0.5345148684891672, -0.036381249259902534};

static const float w4[16][12] = {
    {0.5167519840299469, 0.22830313194762675, -0.4275063929678464, 0.3972018303403278, 0.2705531452919945, -0.3583087963038431, 0.07103040156197049, 0.41829556744031776, -0.3655362326860665, 0.21105560901383852, -0.6420437281777706, 0.990039873224308},
    {0.44302391730427565, 0.464004969384301, 0.28704681124530845, 0.2812294704426434, 0.22551161771061146, 0.18779622015212039, 0.32353861432048625, 0.0019207046897007172, -0.06776190884329876, -0.2849292731268062, -0.4692634292987574, -0.33988354768479817},
    {0.08831559958016386, 0.06758459255441439, -0.016973098452724454, 0.3360027806456969, 0.3158226183022736, 0.0622025931137802, 0.2900090517600085, 0.40268082027214, -0.13576121286742918, 0.7863849649915708, 0.24253219422392164, -0.4425684203574751},
    {-0.2811333893562059, -0.4901819690251913, -0.7887170656316531, -1.0892940013672519, -0.942361483579944, -0.01985884039091415, 0.00583040556373089, -0.9500818678357191, -0.9881852251159368, -0.7075617701427184, -1.0416035510405275, -1.1208300815262255},
    {-1.2595075257044903, -0.9514142279566012, -0.6291294224251723, -0.3985303714072656, -0.3757731911407275, -0.7266869370729888, -1.0593789632762867, -0.3441667078014287, -0.7190169424359756, -0.8790281814951937, -1.0814676681234936, -0.9169708464058312},
    {-0.3880613437198069, -0.4451838499045971, -0.5720745469051783, -0.22345485277583585, -0.9375191516139925, -0.7956614569485853, -0.8923586827071005, -0.6220810884838363, -1.064485068824268, -0.7204398617892609, -0.4975214332596017, -0.8563884100632461},
    {-0.06363083909246216, -0.8797487077603717, -0.2615412382048507, -0.8562865496562905, -0.6967127332553537, -0.642896725143636, -0.9010760610601507, -1.0021995748101955, -1.1478585844584122, -1.181615573417388, -1.1054147271723798, -0.37076807891472924},
    {0.33923614960959675, 0.03241098619803302, 0.29895388007561813, 0.48818411989287097, -0.05654842238689203, -0.016596376312952903, -0.6934562206129525, 0.6279468209735761, -0.2169192371321187, -0.1472498101660791, -0.08852092639543588, -0.06990783011811028},
    {-0.8022819539747152, -0.8541449444949157, -1.0798560343401769, -0.5679540347524893, -0.5207250775324409, -0.665801683623758, -0.4828371011455862, -0.8567251618607402, -0.8701639603560359, -0.9990131650984956, -0.7188840935614199, -0.8675988867584111},
    {-1.0931806160356876, -0.9499424531992889, -0.8859609374274439, -1.5067390452126956, -0.849292283724457, -0.9716154386376771, -0.7274762667902804, -0.4596008125483459, 0.032259866089393005, -0.8256647535574428, -0.49610633015275035, -0.392450026075093},
    {0.3686761777103354, 0.9734500697148489, -0.8620323083863206, 0.45621986732437275, 0.38947515743479966, 0.7709426376885082, -0.39024036893368064, 0.02268240661848956, -0.4014500864264881, -0.07604125483814604, 0.20001372901467762, -0.10384169799229485},
    {-0.35996625631548035, 0.15630283162728945, -0.1540263521609069, 0.25888520079601557, 0.4184811078925332, -0.15607898506070098, -0.1335014174455447, -0.24137608662897736, -0.5196782782248647, -0.021142374360643767, 0.28832243403919955, -0.42912032668867667},
    {-0.4308192045781087, -0.5383628645336481, -1.075731667541154, -0.9889327609932126, -0.7048812116551249, -0.9713220119071292, -0.7791070435658244, -0.4151342307375508, -0.8983607072718451, -0.4468149706376727, -0.9861040993390806, -0.17017964744016634},
    {-1.427546761203536, -0.9473828420397725, -0.5463631504271036, -0.9608967147590779, -1.1066733247258123, -0.695098692640369, -0.9847495572364757, -0.8797487315361561, 0.030065274410246146, -0.1037649541075808, -0.33265786472905806, -1.0641141715446367},
    {-1.0646821275679108, -0.5197764561097767, -0.6210805315310732, 0.01769134766598723, -0.5127214360323195, -1.2330819575850644, -0.8578311679278132, -1.1722134535693833, -0.8669006199046992, -0.6732752730718683, -0.1980956558822607, -0.7886806597054454},
    {-0.3591880984231215, -0.432782420201275, -0.4767880389576959, -0.6663330995099696, 0.41396549329356047, -0.5001497922643009, 0.18590550643481302, -0.27330278544153863, 0.06402561545800178, 0.4957198451943485, 0.417669816103034, 0.31503631637207374}
};

static const float b4[12] = {-0.2670753789051276, -0.3215793469072092, -0.3201995144350895, -0.26590392792818496, -0.28980211633442643, -0.24523606006396492, -0.1594241649599837, -0.20313267729745293, -0.25246488180739385, -0.3408363286041342, -0.24646047055057457, -0.20072335233905783};

    // Input Layer 
    float z1[64];
    for (int i = 0; i < 64; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[32];
    for (int i = 0; i < 32; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 64; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Hidden Layers 
    float z3[16];
    for (int i = 0; i < 16; i++)
    {
        z3[i] = b3[i];
        for (int j = 0; j < 32; j++)
        {
            z3[i] += z2[j] * w3[j][i];
        }
        z3[i] = relu(z3[i]);
    }

    // Output Layer
    float z4[12];
    for (int k = 0; k < 12; k++)
    {
        z4[k] = b4[k];
        for (int j = 0; j < 16; j++)
        {
            z4[k] += z3[j] * w4[j][k];
        }
    }
    softmax(z4, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
