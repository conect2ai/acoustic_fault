#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][32] = {
    {-1.5613564958050592, -1.763915067725606, -4.3709415290580935, -2.7962020225689233, -3.3343083585827697, -4.017174594045358, 1.9702711542515334, 2.4543105539794237, -3.587744509358992, 0.10030179030589158, -4.066445691043327, -2.051146385445209, -4.616013190568319, 1.3002775947185476, -0.6817630287831348, -3.9983718542603315, -1.5557094686511859, -2.104019695227381, -3.0180836267536133, -4.601690936734465, -3.0108654173306304, 1.7673738684474383, -0.6776231479722368, -4.768308588224685, -2.2627213152719805, -3.1410917698860525, -4.073032143609215, -4.156206307742615, -0.8941431409076007, -1.9131796917897872, -1.079983798749728, -5.35688982275057},
    {-2.4678447504177012, -2.075385347804408, -0.5749610508318705, 2.052319765716014, -0.3011832316281493, 1.6122030821911297, -2.07671702813043, -4.094139095299129, -0.8759929898996949, -3.3294054744727126, -3.7835095843417648, -2.0916779051334506, 1.9441404056024214, -0.1442880240332294, -0.5509080497327765, 2.229571149293194, -2.957113756429437, 0.2707286567378437, -0.8582981229258452, 2.541033959584432, 1.939907120198033, -3.68817016935081, -0.3100816226578859, 0.7130981849598845, -1.8459979824018864, -2.072096351664658, -0.9636377856857603, -1.5743846497764669, -3.5846804706954654, 1.612867885802282, -0.1821914748829146, 1.0172423135717963},
    {0.18704111515712632, 1.70548427913062, 3.4727888307358152, 1.7044563219487003, 2.8748461902120566, -1.400833766306433, -2.6279588187953693, -0.9052089837003571, 3.0114526269739974, -0.6695421067049009, 2.34646451058602, 3.6640414638067482, 2.5537514357940605, -2.0749307207561585, -3.385625228957385, -0.6753888987923694, 0.8906049674106746, 2.598038003888957, 3.4008841234972, 0.447289200263114, -0.6067545075800037, 0.4202831064232912, 1.0650969922630018, -3.1094924730178923, -0.20925151227726574, 3.7949729836742803, -0.039562843632011624, 0.9701892107372858, 2.7087059600972245, 0.5436031112059306, 0.8930949296665961, 1.8621950151924012},
    {2.6372186728254707, 2.9953445236367733, 4.997279143730827, 0.343446286999087, 1.4306758032638942, -0.5696384757571138, 1.6759460777540545, 2.9536033135524824, 2.6467544617636394, 2.307503399177182, 5.233291417900846, 3.5052653246408756, 1.6764708070146892, 0.07980492999181099, -1.0830864562673936, -3.3787539832580644, 5.753092594916329, 1.3224893600550556, 3.9516310429088524, -0.6355233666602947, -0.9596653158416613, 2.853379402923575, 0.8089900109932558, -0.616308290796114, 2.2831643579222507, 4.834138467302869, 1.7496052348244904, 2.584802854434405, 5.193433576125586, -1.8755965647305017, 1.1860428210102572, 3.049501119519405},
    {4.990849017472769, 2.5088475812167186, 5.358609110838156, 3.904490559770261, 5.291808661415681, 1.1539115343674393, -0.4166686041545008, 0.7562110241549621, 4.047628422675199, 0.09988619811673773, 5.6678807899673265, 5.033628113592243, 4.299242709265332, 0.6385313170369544, 0.8238986158687998, 0.9934940054780974, 5.083405863109858, 4.531132609327412, 4.041171872957544, 2.85184616089627, 4.313565011446839, 1.6255778846318734, 2.252047612098468, 2.3463080021414284, 2.7218832489504483, 6.513738212820007, 5.72556970593287, 3.337914426626778, 3.032897429035224, -0.23877130227582666, 2.011562182261415, 5.066230416997892},
    {4.467703607347441, 0.9068755402523165, 3.44932070061466, 3.6530933921581235, 4.769019313913003, 0.23622644699287024, -0.6246801273324981, 2.426886757308378, 3.7763304594958713, 3.862846662926353, 5.081182193886734, 4.420102324382721, 4.567095266400434, 2.4775860782734216, 2.534121206602794, 0.45428070616301236, 4.72332111362991, 0.5743372105835991, 5.754375886206625, 4.032169474838095, 2.829162069331928, 1.1113147691133831, 3.1261718664038063, 0.6109729538099367, 2.3614545490382532, 5.576425106161941, 6.273449417719464, 3.8360795539176014, 4.028466080311915, 0.1868903667832689, -0.2594245645949714, 4.230131899949918},
    {3.451626111985802, -0.015391860628639998, 2.8457457388637226, 2.656866237462796, 3.406233547222442, 0.48006714019717667, -0.7779281404356129, -0.37704949881120925, 3.1926254084511885, 1.5891732455677259, 5.14824009425328, 2.555876574222731, 2.9610105353325133, 0.7258858824450579, 0.1527952308888265, -1.1959845292752898, 5.0920662984967064, 0.11565743113243862, 5.057433788775622, 3.4883619969742683, 1.2278982432866183, 1.2373306060467153, 3.9762907341690483, -1.0964934469719188, 2.016869958104659, 5.8971822974496115, 5.085202543740472, 2.8045430599767576, 1.8350553744805613, 0.5612484516975741, 0.22069223404423347, 5.3687025950427},
    {1.3986422812569002, -1.210386321833457, 2.4675744813470977, 2.186280992606454, 2.0334161376908275, 0.42590942897329903, -2.5598361926388447, -2.8269572363088677, 3.4919993003017913, 0.560057010069393, 1.3937546298521835, -0.6304076730633824, 3.4698466087716917, -1.66559233479293, -1.0840228736365203, 1.6410790846582926, 1.6381708487193403, -0.015630530003686086, 2.514381764002319, 2.1185657512655673, 2.3590017196117126, -2.605370091112453, 3.733810759730548, -0.9724506502578487, 1.7247502958736372, 3.49793438618296, 2.405091862437392, 0.06374729725172174, 0.5832444357535483, 0.21041004686797105, 0.25249839935786766, 1.5421986333600446},
    {2.0161965826856045, 0.49882898908827067, 2.4149654445916684, 3.1149621244276635, 0.4031623033708172, 2.578889972447228, 0.3214043250206716, -2.02766868140072, 1.4925267181969264, 1.0255060552052935, 1.3893767827727868, 1.8708514747756944, 1.936653391139807, 1.0315206508064383, -1.2704038587691997, 1.0736207894920065, 2.9774345549953156, -0.1433756251804499, 2.581184800495699, 2.0565981143003276, 0.057043192371277814, 0.1654268675139851, 2.763938438462801, 0.6499265025075219, 2.6893051673031336, 2.3034475209880987, 2.1223391919040595, -0.39935436761247317, -0.3230677110610315, 2.1732551659561294, 0.15434744497597222, 1.150584007857878},
    {-2.0245541430346057, -2.910325577558358, -2.5478720180636496, 0.6015455576065694, -0.6236658615605273, -0.10158890376167577, -1.9895570178990105, -3.7907240078595503, 0.6862479356788026, -1.943534789038493, -3.9621226422481195, -3.0311739206935524, -0.7680054284572605, -1.3688527736000122, 0.6953790347789035, 2.708523280716315, -2.913742905735512, -1.6236658687333838, -1.3556524137622652, 0.6624241171279435, 0.04361914167344711, -1.8706473429538564, 1.6018510879023495, 2.940219586671738, -2.8720538181969437, -3.424205506889673, -2.05005372528217, -0.7736443779889358, -2.9045599636577135, 2.3230040774484713, -0.9883068959612479, -1.2470148340631528},
    {-1.8476768580924363, -0.149560297674872, -0.8335980552266008, 1.7668325358599477, -0.9707710495254728, 0.6069824358558121, -1.6291220367208257, -0.41199057333886396, -0.06304005777351657, 0.6356261914876766, -0.3764660278875106, -2.09734494244682, -0.6468096401794841, -0.7180555403838718, 1.212905021462755, 0.6567608802484733, 0.08799395616036938, -2.118610220826908, 0.6378088217657564, 0.9788511790970119, -0.09525816250818776, 1.1467003256541985, 1.560741664687478, 1.7779997653685777, 0.1869586146701888, -1.3910980542917468, 0.9378968136633105, 0.055794314432817044, 1.4710052009440986, 0.05246410332335539, -2.6747992894802444, 1.038454195193744},
    {1.4029828840774667, 1.1647869892014964, 0.7756406452763048, 0.07829999816923083, -1.7298851835689175, 2.7190171875785634, -0.023975863007017165, 0.30104499406889257, 0.5392584762961748, 0.45495949675132524, -0.6034312831308737, 1.8319751493639402, -0.24620428185668602, -1.4462256665040765, 0.011708306689143312, 1.5279649957219408, -0.5661513864756834, 0.9078641593337266, 0.9826796989475313, -0.20427689902317403, -2.374906476628239, -0.924408278092474, 1.637316103892835, 2.0828233635457183, -0.12162966748567475, -1.9544028892450154, -1.6947249505832118, -0.7837487793953279, 0.7789977430400715, 1.6031955240355225, 0.3010201017670306, -0.5359697219404713},
    {-3.6873585890202203, -2.794994715920172, -3.1731479208967914, 0.9988644528960894, 0.7014559778991054, 0.4960486948951889, -4.426409854125086, -3.716251239665274, -1.0521148726080145, -1.339709386735458, -3.413923663097166, -2.045071587460498, 1.071160414912777, -0.21128217224885296, -2.347681419391303, 4.071227060118662, -4.301931207103904, 0.10867346758743796, -1.7218479042073314, 1.5716266973348438, -0.7902114551688546, -4.41621654922748, -0.1174080450814114, -0.2773643537155185, -1.0788821098396155, -3.8370178137090174, -2.047962855987204, -3.611243313434746, -3.6616782204373295, 3.8144289853547733, -1.948308576751353, -0.7043052638222291},
    {-0.30092096394818135, 3.0115134330780275, 2.432715582012765, 1.2402516208062677, -2.255689612133054, 1.5638816931378954, 3.1382939315049545, 2.3028396588587277, 2.0044453429456435, 3.919730163095026, 2.939731245257908, 2.8504333672768674, -0.6491370999987774, 1.095585351667618, 2.296158641014414, -1.4221423149157941, 2.7976820135806375, -3.0083964175409026, 3.415293116789634, -0.5132274704409843, -1.6422842117916867, 2.9291380554731425, 1.704345470056903, 0.2223166166086866, 4.218882946201473, 1.3757917573181717, 1.8235104755897122, 4.606886401991688, 3.118117678550859, -2.1291977758802383, 0.13933482258934585, 3.0694714530193954},
    {-0.13891631138534816, 0.4628635867923126, -0.7348783547534774, -1.3997502065285967, -2.5218132295451055, -1.3720734264303482, 1.8914631120857734, 1.9590069633449634, -1.2042092831121136, 3.29298653166833, 4.49665038713537, 1.8203050569103176, -3.122772271587254, 2.1647939788072574, 1.549575233430828, -2.896952737391789, 4.031423209931863, -4.358038157592289, 1.7688562056364312, -0.18896857260435126, -4.444344047301153, 2.7456043524780034, -2.4268859241837912, -2.490024306928131, 2.60932237486772, 1.3028840321798405, 1.4391168159097891, 4.717499753472176, 0.8899384306281448, -1.9816790540617801, -1.3245806004457423, 2.1114604263579126},
    {-1.2091629736376532, 1.577654393933698, -3.085556517198546, -2.3827226777095434, -3.1467013917165456, 0.8176631373728304, 0.16708046780970054, -2.023130304859372, -0.9954409313278334, 1.2076665172495455, -1.5268926528679674, -0.2830641275823727, -1.406208853377218, 2.95524736079658, 0.3525134874187995, 0.22764870870494178, 0.13015539698762998, -2.4843423199581363, -0.0023348670168278603, -0.6046682858283622, -4.124484293923029, -0.1741408409917068, -3.323388332564366, 0.16569146293168904, 2.005705162469163, -2.2291601676702895, 0.0075114643360525415, 1.5363827760340765, -2.660547309014897, 0.8804931222696047, -1.3570398698942896, -1.020384089409329},
    {0.13923897747785943, 1.2778884330701352, 2.0626229557479006, 0.37013020383933803, -2.4879180661314906, -0.4368863528708482, 2.023346478030123, 2.271850260725575, 1.9025889673598968, 3.9311474563583677, 3.0770712011264796, 0.9256713308014972, 0.17537225531447642, 3.118439611928452, 2.739926300948951, -3.109738770948766, 5.886144829947077, -3.7194321392609004, 2.3321823607474563, 0.9198866036006093, 0.33175212339368587, 3.373897388972232, 1.8221778083804883, 0.39900955090026663, 4.577610421834136, 2.927881173501641, 2.9035380763820977, 4.626148738125672, 1.8742956505831334, -0.9003389034360452, -0.9934777572010282, 3.3934022636910726},
    {-0.2799234823085422, 0.009711651919132296, -0.6463994648330704, 1.6734847481103277, -2.112445824353594, 0.145056769757674, 1.5802733726963976, 3.262694540794572, 1.3753527310500013, 2.1917324518359154, 3.475460301299936, 0.1377024476421332, -1.6334632832618439, 2.082836703701618, 2.83566968158778, -1.2274003096242936, 3.7048499650755855, -2.205256825303362, 1.600301349935487, -0.38398056217781723, -2.3884737160498775, 1.5633114098860184, -0.3890865505593543, 1.6037947308269112, 3.324784870555345, 1.3698103530270092, 2.2181038047509003, 3.941559358961232, 2.2313849693721224, -1.8263832858490376, -0.5189065820170563, 1.792881022740232},
    {3.2274602676222273, 1.490552510080771, 0.5596040414725183, 0.36243748855280034, 0.6322200999687498, 2.4248594636034944, 1.0118221209677956, 2.6100974409797058, 1.4114590397394546, 1.8332690862064063, 2.6684057618573793, 1.647952835431487, 1.4391162751577704, 2.5925411408217247, -0.7727927838436423, -0.501154802038889, 0.7824728310774594, -1.3814766272210184, 1.9487856522822464, 0.423183090997083, -1.6234121463569124, -0.5356576648916354, 1.9944013150561077, 0.2868192466927513, 2.352755239718717, -0.4668524406234489, 0.29691865295615105, 1.9338680064203078, 1.2402615479028543, -0.419609365677234, -0.5611525826802465, 1.7543258957617378},
    {-0.5934563805866319, 0.7261136866378063, -1.1507725909636608, -0.27334773081395725, -1.5575333724331677, -1.9335813309472512, 1.0291976633124096, 1.2485848958354586, -1.3035898288810928, 2.148384514181124, 0.3891184447343636, -1.4420909228950587, -1.9672421620896456, 0.8886526625656438, 0.020451670152095185, -2.0990358824102575, -0.07255439356721594, -2.5064929184401894, -1.8271345913001371, -0.46296330890380266, -0.8052353046699074, 0.835407589244192, -0.1936525821856712, -1.3495622718255067, -0.4671675879508114, -2.4681227911516745, -0.13388981279158432, -0.6203249339683821, 0.4715406833640989, -1.4238176148914403, -2.979656733553364, 0.919521081681975},
    {0.4634981648373449, 2.3378888668810065, 0.014833529601895426, -2.7653150852775132, -2.7521278269471385, -2.790152589350491, 0.6787235304127641, 1.454494198283898, -3.2200946742510594, 1.4229175218068557, 1.354886486335569, 1.3655520982164053, -3.4265458896830623, 1.3985089408869065, 0.04304617491081824, -2.1485850302304037, 3.8372681496203294, -2.823400579553307, -1.3442381355017543, -2.6656769112960084, -2.05144431905127, 1.41016518380427, -3.453365060044993, -1.2959255081730692, 2.31242641026557, 0.5834649328445831, -1.7813953886796055, 1.6201320387012779, 2.283643321627646, -4.022144004691003, -0.9214134825151156, -1.1591038640023705},
    {0.26525189970846824, 1.0108555886271084, 1.0958515686130261, -0.04445542145579519, -2.1049127303480164, -0.5802322254535734, 3.2481400386344137, 2.0734992587880092, -1.745899456470752, 1.8101191194747912, 2.034684206551719, 0.2701170799406138, -3.3388767581109846, -0.49360574616380626, 4.354083050133425, -3.965391045375568, 3.6171868496077555, -1.5464489592060358, 0.10574076447292821, 0.8966737201033005, 0.334131186863787, 1.4409772298467105, -1.32235962173532, 1.8805858375279114, 3.074896163902532, 0.20942975420164728, 1.8890194668900833, 2.8242954985028934, 1.3482003924057615, -4.165024549569131, -0.2977610745519795, 1.8267570510287139},
    {-0.5936820577121634, -0.5025813345854528, -1.0715618233493216, -1.6008867661585588, -1.3551280524582676, -1.9091015953972967, -0.8048935182310075, -0.2417720936064586, -3.9144520023321796, -0.029707389302235612, 0.6723605028622539, 0.7520428324129129, -1.3068392796937827, -0.606268948365901, 0.04078101840621769, -4.286651271971817, -0.4695373073353471, -1.1215084913344073, -2.3025490559429, -1.4347131997832863, -1.2014854556620744, 1.9777534729200668, -3.7074386030595283, -3.176791502226591, 0.4438371548133926, -1.0172681768895728, -2.6097193506611824, 0.5349552164770448, -0.06241076070639042, -4.429468513222147, -0.9328032833019695, 0.3363938242334355},
    {1.2850954321788486, -1.6975196274946838, -0.4341213883460623, -2.6196975380481997, -0.6750559937153696, -0.11755993222909586, 2.063342834911552, 0.7660697711940401, -0.023429050615900674, -1.0993100167229188, -1.9878193280196086, -1.1540928469848808, -0.13091248682037088, -3.034494658870803, 2.5956457069572925, -2.2127561041649484, 0.06284142717837163, 0.7901069930648713, -2.744769741768589, 1.0031067531837201, 2.4484434939798025, 1.4558432694234447, -2.5844821209664572, 1.305292250446057, -0.6607876811398362, -1.10042818895054, -0.5883847146992143, -0.7469598250389912, 1.5390569175820883, -3.359969064890039, -0.3623686139679106, -1.0593209896455411},
    {2.36718163505908, 2.1165497818646837, 1.7862188295229595, -1.1990910947282012, 0.3476495847972504, -2.3600603049148723, 4.389371889315609, 1.5134532514495145, 0.4057766789548069, 2.1463058585904524, 2.319798845458981, 1.6991919650491367, -0.5806431101283025, 0.5885748118409556, 3.0132455725519174, -4.131715110721259, 4.034940373432431, -0.8729022666964766, -0.149080623673262, -1.5438205736137247, 1.4064042353077475, 3.8737177263832887, 1.473266052185698, -0.7936498340716293, 0.3863957712610676, 0.7885146403782212, 1.889461411454756, 0.7033342409341031, 3.344927752316251, -2.997701712583652, 2.4571432745322346, 0.29567316602835403},
    {-0.06384928766068261, -0.10849138705629296, 0.900503389014016, -2.0316975300582647, -0.6908489373151846, -2.518355552993154, 1.2705740290892555, -0.4184635731066679, 0.05719204116547055, 0.7255384917950373, -1.6538505079299328, 0.1871828725826835, -2.743512953620941, -2.9128883825232332, 0.5908353889203877, -3.6225334989875044, 0.13723390435447397, -0.5347070936896015, -2.675059197534584, -0.6060588977111565, -0.25715529814859867, 0.3917811318370866, -1.0123684022821007, -0.6410784672054823, -2.363540263315703, -2.4982253198335225, -1.1680974660043977, -2.505716411854229, 1.049937924063388, -2.7540266973787824, 0.22400065856365528, -0.6896388905257},
    {0.06870477716250445, -0.6788483137163334, -0.2647595718030535, -3.751153304885529, -3.3836139936272485, -1.896601693589381, 2.5189194064139278, 1.7072142312438974, -3.9400004716780908, 0.6779033619170852, -0.9685913400178087, -2.0622044596523588, -4.153945533767908, -0.760921144655684, 1.3163997187913492, -3.917855678056072, 0.751007603761341, -0.912217985160989, -2.81416815514147, -1.2808731957517943, -1.6449904878504464, 0.7826444424741256, -1.09239811368806, 0.41746133909571476, -0.9750680251743343, -1.6258952057290843, -2.1332762687561417, 0.25322948261696965, 1.7181724435042707, -4.106888887004171, -0.21736826052019462, -1.2161728077491862},
    {1.709819010464101, 0.5521806815868483, -1.0017973630779171, -0.84465660976547, 0.9768865647314269, -0.6705598954012282, 0.20291174223266667, -1.8540058555034384, -1.6183762211992851, -0.3381185910632883, -1.5758450457570279, 0.5773743508071123, -0.09632077843875769, -0.4273900374408926, -0.6818013013893048, -0.7108928846367931, -1.3668969128629298, 1.7906335335022328, -2.258334475678381, 2.1020398395501587, 1.4967620315997228, 0.010890995170978348, -0.490532913172498, -0.16476803567668458, -1.8422367722862578, -0.6742804338306971, 1.4960916166384015, -0.3845179747581745, -0.22049951749287103, -0.8914079845803756, -0.21099691922054292, 0.4593184221762901},
    {1.128537909167093, -0.7078211326945719, 2.726401149482111, -1.2355700316527753, -1.628156965699491, -0.9051608333332863, 2.4628538183725364, 1.4209311108078506, -0.962198028789911, 1.6465281325773482, 0.9778600985935326, 1.6911532975509793, -2.6107187519320716, -1.8878588986423872, 3.2901248022390104, -4.299496862231299, 3.806285422928588, -1.809837699546754, 1.1924547481159802, -2.0759618389406365, -0.4853214971415655, 2.672396930355237, 1.209276129521783, 0.6613251651161208, 1.8683525557359397, 0.5835322536653201, 1.595713235206777, 1.0205054031102567, 4.512356196291056, -3.3139987326361258, 1.2497886953656192, 0.8236431991306501},
    {3.078784937041388, -0.08126616486393333, 0.9110060967737956, 0.6534069986484994, 0.3316336381762132, 1.0867423919302197, 3.3370208606381526, -0.017195476289244865, 0.08343644282522432, 1.551913824119568, 3.5413113399047003, 1.2236985439397057, -1.1430749301905792, 0.7646474568089964, 2.7285199746912254, -0.7149966646021556, 3.275474476576956, -0.9758322920845717, 0.27670314865060763, 1.9663276414976674, 1.0464754858505727, 3.5109229398033035, 1.2427379245430406, 0.27907330047985823, 2.6936502439929946, 1.1342902893994702, 2.925423898325809, 2.7239816363447256, 0.9127411300602106, -0.2364648999910135, 1.1202339141065631, 2.7501099974315695},
    {-3.349496564417956, -2.7337681868714467, -4.48556156767419, -2.3474131114027474, -5.118311223727022, -4.307310934462253, 0.9861018917494615, 1.083930031838479, -2.063740058701494, 0.899311031499633, -3.4430007183395186, -2.3045555513258646, -4.955917932117879, 1.108458291384623, 1.3505085033112851, -6.860482596651033, -3.2004188440749424, -4.028238804511023, -5.5076603079055495, -5.154805465227409, -0.582150299491396, 1.5731313966664415, 1.1082287119414154, -5.780546545402872, -1.846885055154314, -3.427151012733369, -3.867475286260186, -3.282131958247942, -0.2858748559475561, -3.6843725685618796, -6.211980163433217, -5.3896246317154395},
    {-2.222421021419463, -3.00884136545895, -3.187010060253299, -2.795645102380535, -3.363095441789297, -4.189128155619707, 1.414125728175804, 0.90441004685764, 0.919660887955932, 2.01244893542819, -1.3830715156815159, -2.372263047741521, -4.860785026851826, -0.5901622405691727, -1.3925717058675937, -4.7947771141354725, -1.53560602536712, -3.654581715406468, -2.419206807596997, -5.072029495152015, -1.0008069584592474, 0.3914178961723101, 1.8513688697635715, -3.6338856131521533, -1.6193268270284198, -2.201862244244931, -5.020336449645849, -2.2028939926258504, 1.294042414613766, -2.306916157107576, -3.4693192663850474, -2.360557115299495},
    {-2.6846492650278333, -3.0554813058680024, -1.250268371681887, -0.07122485050863675, -2.0230810421566114, -2.765463742569723, 1.6099336651172973, 0.2492961305490746, 0.9026543886832288, 2.297455796645468, -2.852513851491859, -2.077984651987852, -0.879422388308989, 0.9725378733815984, -0.8672754431649071, -1.5042046895867671, -0.9095948932352776, -2.7470938718073405, -3.5389954775295283, -2.1589183061139896, -0.8380266122171479, 0.5635242037745042, 1.1009876212905259, -2.7014586802414353, -2.3449809185052453, -0.9002552792308508, -2.402702283638958, -3.1097563810751008, -0.32248801480156913, 0.307044472935095, -2.2953422938295875, -4.146353014342708},
    {-1.2629245355811325, -3.3280330852592583, -1.734463060343587, -1.6726022467807455, -2.502104426297394, -3.1018453281312164, 2.0134702809640093, 0.5102163905778812, 0.9480930337480603, 0.2869822351405416, -2.7022796719647046, 0.6225043543639642, -2.381726169797914, 1.504729998928031, -2.1837543295129795, -0.7898971896455566, -1.6046765017561646, -0.43172723818801745, -3.7194714528921806, -3.3449810056468494, -0.2944410792557337, 1.8624472494725093, -0.49736309350790064, -3.8670462331192326, -3.1462244029601654, -1.7472182094390116, -2.903876018508476, -3.482552569835336, 0.9785049704266048, -2.0039597777343703, 0.6427026161163657, -4.415878457665989},
    {0.27881355676312003, -1.660839343497024, -0.2701912449815937, -0.7335047251513028, -1.8309754590520937, -0.9045668350968542, 0.5875796705954406, -0.6974162475809221, 0.5341032277598774, 0.8633037503396215, -1.6334623433278164, 1.0389489124217197, -0.8962589258118383, -1.0695202733670301, 0.49401161075846134, -0.37074831142613485, -1.0018077811700505, -1.294104124555636, -1.5505779447873709, -2.677768993657758, 1.5738096193992765, -0.6014565737849366, 1.6050584944544763, -0.5323870938652424, -1.7844378429200187, -2.137052115044149, -2.587596796000132, -1.8647843710052363, 0.817647624532886, 0.277148977533472, 0.18977350259465925, 0.13882873820363104},
    {-2.7497825610797455, -2.3322918048230084, -1.8722651148573821, -0.5664740083164467, -1.3890849096883586, -0.87556568160687, 1.3020653289628534, 1.5939083294893857, 0.5492662572158767, 0.8807397732813331, -1.490391714182187, -1.7919948997269872, -2.9058456644564723, -1.6456785923934423, -2.3346278265065, -1.2349056916464505, -2.0558198697771557, -0.9535554495458011, -0.6432682839851109, -1.4157678661384927, -0.9823771728233859, 1.308379274435975, 0.86627874198857, -3.1438283813504415, -2.0423840148210686, -0.1765209335595679, -1.1961437416515615, -0.9787724146203913, 0.1368456303037698, -1.5713047584597584, 0.9089136319187913, 0.08593326353670849},
    {-2.273633551870211, -0.18101252360974354, -0.11989839942553693, -0.801799491925959, -0.888309736335866, -2.6107603465042515, 0.4235325502431049, -0.4016322932271595, -0.1722414378121875, 0.8085947694695133, 0.35962425926301445, -0.2942973469043353, -3.1382013591463607, -0.8133742812749012, -1.2825847047137495, -0.8551019814682472, -1.6513665699556568, -1.311825336132974, -0.07790852066208888, -0.0910779910128068, -0.6934349907677163, 1.2007564301816855, 1.0815983127889226, -1.5826835598574396, -1.0675050975719393, -0.006624978927731775, -1.3529969172242804, -0.8421153379155666, 0.56907734029419, 0.28251482663950545, -1.1767965263608096, -0.18754816738530466},
    {1.3228586018964545, 1.793526963240197, 1.5205704516036043, 0.7651233575082482, -0.11504934941160427, -1.0379992337474957, -0.3061711991436303, 0.14846398499227553, -0.5397787645227341, 1.540401004871599, 1.7434117282871497, -0.9464930321511459, -3.042650573094266, 0.43957370165162113, -0.47205013837605747, -3.4717550952347787, 1.0653856298576128, -0.37131147257551983, 0.2444854050832971, -3.435242529629692, 0.6731466940436751, 1.558508134638907, 1.111627967466956, -1.3762670983573884, 0.7395389080658741, -1.4019479634262833, -0.14766531038150416, 1.061331670606778, 0.8607160011000922, -0.06259941912137834, -0.900407602821152, -1.2248058099976455},
    {0.4610482020519902, 1.7569265803029546, 0.48860493019219625, 0.5869656540101609, -2.731245866364438, -0.867559124868956, 0.49868146563795535, 1.6459482585147482, 0.5241421338755127, 2.524630329238146, -0.0769904147038906, -1.2159827836753012, -2.9265104463330642, -0.8106619690882183, 0.9756362930036445, -2.357648931619474, -0.5044954311840812, -0.16618613898157347, -1.9008820752101465, -0.3371196331138223, 0.07529145222898652, 0.48388778505868646, 0.3593301882995047, -0.9210821088951271, -1.3187346619074858, 1.1347433554642699, 0.10370442947409143, 0.9806263371825907, 2.1548356989170183, -1.8678576694329787, 0.4495372932682934, -1.2626864313179502},
    {0.26546853173225937, 0.4326699385383564, -0.4831586170289753, 0.12370135094970011, 1.1348472434324082, 1.2305664417402506, -0.027372208363756152, -1.30778557472917, 3.0325677504209003, 1.1905265931252695, 0.08626015802196202, -1.476871566191298, -1.8419644538650148, -1.4684525625261944, -0.2872121783346987, -0.2877507155513878, -1.1253508390007034, -0.2346101051276172, -1.0074616278846338, -0.0741919703892112, 1.2276012537466157, 1.6731447200307312, 2.094201842319647, -2.001880481070016, -1.5363569382379756, -0.06772855749607345, 1.0880855293897491, 0.334379700837828, -0.6523646692251586, 1.4798770607102287, -0.22772394653885525, 0.34413828608384156},
    {-0.6713270679975455, 0.8948859405514521, -0.3986659261020117, 1.5529110026354778, 1.111479414592867, 0.5605485503958093, 0.725063238829635, -1.9806807729581706, -0.021533653311641667, -1.1318942385000073, -0.4812724303059613, 0.6910565825770595, -0.9513479577040815, 1.2803299352251607, -1.6923479992143937, 0.8063606037647797, -0.10767342570757152, -0.15294519456736147, -2.1510743307002693, -1.9113953314304457, -1.1428156032481505, -1.2636366411776645, 0.5841931572407116, -0.9883916018795602, -2.44889212229666, -0.7573669017616447, -0.9262031661844555, -2.4128565204929937, 0.22566347992692803, 1.5761057743445206, 0.33739337792181584, -1.4632137228539617},
    {-0.8257742318935662, -2.0404052817895177, -2.2853188515022227, 0.9669230887108431, -0.006342350692232562, -1.7483585419117917, 1.938896501629186, -2.406937839913624, -0.13139751681204878, -3.0040158637852166, -1.6817270392709938, 0.551757677434169, 0.7744713071436644, 1.2463070045117803, 0.7630904316401735, 0.4763256883011127, -0.8094911375808691, -0.2199912187961132, -2.2000820444363445, 0.5866255461435076, 1.248022044368516, -0.9670872183493564, -1.9168519939349264, -0.25905854616144963, -3.049977780565885, -0.5834299801630793, -0.852657201102147, 0.7009214539789196, -1.0987518790060449, 1.5843714724246716, -0.8456726210230392, -2.130263471436444},
    {2.7379967282242705, 0.06248062201391266, 0.21383822212756265, 1.8853697857167329, -1.1422840363098972, 0.31325144190004606, 1.2533153386769627, -0.6139927838023957, 2.3175285553748513, 2.0234978421681937, 1.6654511790486088, -0.6953379356443362, -0.44183275379794473, -0.38462679986700044, -1.002345094629328, -1.1679746986360573, 2.580915383397374, -0.1654201518930175, 0.9459421344389138, -1.5474206380488202, 0.32103505974408325, 0.8771004415726874, 2.9669460185268037, 1.7327538379566843, 1.868640147088225, -1.0389992598032205, -0.9685573141896793, -0.06432431675387193, 0.8910568997936088, -1.3436832467305506, -0.13015068137559463, 0.7573779469515968},
    {-0.7729049453152471, 1.232633777507369, -1.0988716609609492, -1.0461935154132607, -0.7839346195789675, -1.2526682065087458, -1.3322990250830418, 0.6063331131562875, 0.013903696596029077, 1.4274889712119798, 0.8331062070453192, 1.5037779662218889, 0.16632449774287508, -2.410766353736614, -0.25478535823811505, -1.203250831541646, 1.498286873796385, -1.1611704443272832, 0.2949971903511191, 0.28751246056649515, -1.131706707231341, 0.28029883758401714, -1.4855189515946021, 1.2252780452957963, -1.1505243992820149, -1.2901522553360156, -1.6652796630056141, -1.3162739661030558, 2.011375989593815, 1.599724649040135, 0.06954694352399163, 0.4752073832542043},
    {1.0244992511112698, -0.793413967335759, 0.16078440293699497, 0.29136942603387145, 0.6167607920932701, 0.5376144255007282, 2.9514174138411007, 0.9895126655485141, -0.6560390884512093, 1.9231509544834355, 0.5358371065980828, -1.798103044431694, 1.8266441190960525, 1.0473483925576978, 0.8738277305276406, 1.3830234119696398, 2.6647175739927396, -1.1130322284718719, 0.9509649638927328, -0.09964128359137259, -1.4686969548471693, -0.24715628267479595, -1.0487809145626326, -1.4319987640671707, 1.8425669750019353, -0.9482742194656739, 0.7911325735946738, 0.7396045725881002, 1.90724660826269, -0.604022676682126, 2.898861788179833, 0.17370681186963882},
    {0.38241244821890813, 0.017771810678751748, -0.08447052203879202, 0.8973836537573422, 0.24160187838318067, -1.8875955650698488, 0.9532675637948295, -1.2278687637938643, 2.186472788535218, -0.41088078796570926, -0.18334998310408998, 1.9021861851113895, -0.8320185134750095, -1.2683105010184512, -1.2029988632180775, -1.3637011188803572, 0.8728343895240248, 0.1852601612137116, 0.6320824215585288, -1.9334302332992297, 2.6645011710354343, -0.6025427292929231, 1.3823690506882123, -1.8618258212795558, -1.457966683872335, 1.7693513492950554, -1.3928342880838471, -1.2825710209185766, 2.700176558165464, 1.3012235900236906, -0.16111708671823932, -0.7632989128985336},
    {-0.7704077620390971, 2.1864147049862654, 0.13634897046204167, 2.185830027932489, -0.4049399138516572, -0.5669720335887041, 0.7370128688408852, 0.0664220174150958, 1.8374132538409307, 0.8898415018799524, 1.0237761978926514, -1.0922767207867674, -0.9384454193941384, 0.028497875610031607, -0.0513744308294612, 0.4454813706217475, 2.157030912591927, -1.6222630944551386, -0.05069423840786435, -0.8078471689649346, 0.9993145451075716, -1.9597661056464408, 2.066171900854794, -1.6472251634960187, -0.5574736476176068, -0.5453532589405384, -0.31516522881054715, -0.1736523467552911, -0.4236505688926624, -1.3127388935323197, 2.3562430505685126, -1.370162083143552},
    {-0.13129679787416323, -0.2560778008898976, 0.3846654957418819, -1.1589491514357508, -1.4102351162407916, -1.0900165472895433, 1.1165255026003147, 0.1114352691388271, 2.355597356319705, -1.9975335358409703, -1.307073852159297, 1.8972996479902013, 0.05624955214413642, -1.5446668956198948, -2.796130758201701, 1.3740872707840404, -1.6130350538208096, 0.16607511451220397, -0.019341160943220168, -0.5187386389683976, 0.7978584494074678, 0.9558982001260349, -0.8052619358773422, -1.2598823706554643, -0.2881458378187936, -0.7783759059827732, -0.9927603348124553, 1.1860164167687928, 1.7875629165847444, -1.9634995730125335, 2.988374086050829, -1.0570162879912173},
    {0.10313893623381822, 2.1934494898260604, 1.8492593396137935, 1.1225441598530725, 0.18820864233846532, 0.5222949715833464, 1.5593888539721452, -0.01457808309329095, 1.4421477341818485, 2.323803765504008, -2.351391369685419, -1.5936731775829696, -0.33393471377194345, 1.8457458606910981, 0.24650078077121254, 0.7511639831207031, -1.4295700786426375, 1.069520571440075, 1.5672358105206075, -1.6153709784492423, 0.27459339632045104, 1.4953023017351759, 2.1312216243334112, 1.8016278261181635, 0.17473616835885122, 0.4088944486468937, 0.7558823204629588, -1.953167680453839, -1.4346911561799625, 1.809242633316627, 3.1835464351985228, -2.036284972964301},
    {-0.3417650671477748, 0.2107361971509798, -0.07023931814021941, 2.0714456996711914, 1.3141133029622463, -2.233153884797661, 0.9911188596111686, -2.2236192335082845, 1.9588641062116197, -1.5067232341282333, -1.1223835646342626, -0.19473240689724647, 0.1530327881330305, -2.7864437498129178, -2.509636879901346, -0.43746877679909385, -0.5210210214894637, -0.07856481463995864, -0.68394663651312, -1.5623531247900821, -0.6389290020666185, -2.023859113072542, 0.6263495386558158, -0.9684819632425024, -1.9612037281881272, -1.4010551603476078, 0.7653233739842218, -1.8197912587806764, 0.4724637052570479, 0.93492192674501, 1.5206222534266163, 0.21231414096046602},
    {0.6865873683873599, 2.6006336926022513, -0.7704853788629353, 1.0496552345643761, 0.3734628755090658, -1.404489162306933, 0.15243539888838478, -1.4446377668322135, 1.7355813863669776, -1.4531400830662047, 1.173393769300651, 1.7823392861988596, 0.2709569112081857, -2.0523937161237975, -3.2129573977426733, -1.5272946860314736, -0.6346466418913349, 0.047595684076054474, 1.4741092830414384, -2.4286072233505016, -0.7809831519809377, -1.254595079580819, -1.3781291585011324, -1.6902704394837562, -2.2858854421674764, 0.16467159935333306, -1.219504439853806, 0.22564210449492728, 0.5627896213252672, -1.32292744771811, 0.3733955117538274, -0.29850399712685954},
    {1.2868871913053745, -0.3560601086262659, -0.6539037708701637, 1.1316816530135023, 2.0222852373022584, -2.1855526395399965, 0.19497470800853017, -1.1035053165854773, 0.1438336372828184, 0.7479433437826526, 0.9398426871070773, -1.216797910788824, -0.48654987596901167, 1.231338144740418, -0.8234974552005967, -0.8816535978748958, 0.6596204494685077, -1.5533470071119801, -0.4199523403781129, 0.442705184473318, 0.9939959204165743, -1.784262995110474, 0.642736529743463, 0.10076437569983027, -1.7255055177167553, -0.10120409195014982, -0.4794708278449155, 0.8487183844175235, -1.5003011024974873, 2.601521218076186, 1.5904761695712368, 1.0214735213598676},
    {1.8342269622497236, 0.9037999356447117, -0.5147957023338117, 1.869447437458421, -0.88599638955933, -1.3721734722822114, 1.7236309056912926, 0.10928351379440049, 2.0925354540526144, 1.609103726257715, 0.08568626662311124, -0.2775302738245904, -0.6415741507878464, 0.8214253637556583, -1.2955001416741763, 0.6090848133352663, -1.0357645180781618, -2.514906777029609, 1.020773659883444, -1.225769672654468, -2.7252350542331025, 0.5355542324089078, 1.4191206273986294, 0.199446545837203, -0.7556490610086454, -1.909422642566119, -0.789265027211604, 1.1555100981544784, 0.32184486564811865, 1.5056345769840402, 0.42389056596585833, -1.9138882382307114},
    {-0.9646938166217427, 0.9587783087883528, 0.8646277078668381, 0.7580990374303056, -1.729298438291736, 0.9293471660185076, -0.13556287552922755, -1.3086920338114998, 0.3245105030297901, -0.22526448725775108, -1.2328828286314535, -0.03051511773650081, -0.6497574429647376, -0.00829842128083396, 1.402002810242017, 1.2635258971264953, 2.0647882805248523, -1.1322922445729626, -0.5216538899064046, 0.976135422939386, -1.216626534472237, -0.1987224702030968, -0.36748335774742674, -0.7497624698890447, -0.614062968340082, -0.2523023884194591, 0.2505110773733976, 0.19714933869112544, 1.6146404160798489, -0.723552134058733, 1.1197989158327089, -0.7972466521727201},
    {1.2197510188912666, 2.069164238876182, 0.4253119642486492, -1.2050079989469211, -1.6621742957747492, 0.9926033694015629, -0.014605730280390234, 0.34399465226702547, -0.6858830512786555, 2.637580624897622, -0.9907069253892694, 2.199743755419771, -0.7561951112169413, -1.8536705700121832, -0.8821147193944286, -0.5178905636622979, 1.1810490812518912, -2.628273349736904, 1.515605010476836, -1.5790915340869165, -1.2946582780689035, 1.0062427715718043, -2.4103972589055127, -0.21620974241781019, 1.6951881457076943, 0.35084433084843014, 1.1796017339122797, 1.521450779490477, -1.0977769841580776, -1.7874179641394397, -0.6141012203314495, 0.6636278231393626},
    {-0.8315855215482136, -1.52081330802364, 0.7042227771371367, -1.0091116135926819, 1.531175495299465, 0.3033749625888737, -0.0725079067131652, -1.2289170514913799, 0.5247308092508295, 0.6363648249525193, 1.3085485838827586, 0.5701810331098348, -0.07998222530473656, 1.750351596287686, -0.10498543139261787, -0.005170579520065801, 0.7095867097341346, 0.8615104637103043, 0.24441782326279418, 2.40075717889668, -0.1894627261161774, 2.19408725366493, -0.8785943746071684, 2.020263294890093, 1.0752608876088792, 0.9819830152631973, 0.4708071874748366, 2.0420202807542656, 2.369232351250032, 0.39199970502215853, 2.7574406223080317, 2.1492352652955167},
    {-2.0469492131397233, -1.9443572052815388, 1.3962468777069268, -0.6342747383983025, -0.6813228496183357, 1.2528376494633053, -0.17040555760243603, 1.3177487343997987, 0.7929438976877694, 1.0523988331315317, -0.8936221142081151, 2.3749436969731845, -1.9374676122088068, -0.6515835565904481, -1.721092480570769, -0.7483148280697958, 2.174465047607191, -0.04290437007776616, -0.5024820979910929, 0.5258648637286667, 0.7909612123602079, 0.8455195251460986, -1.1720773940615157, 0.4911906379525556, -0.7902472187711196, 1.1067414155871835, 0.924131777328231, 0.09724130532876965, 2.0797177986772635, 1.6734236682945174, 2.2073905865265524, 2.026579750308277},
    {-1.7043256945294911, -0.40831702309310935, -0.012923210358793902, -1.0017518606632743, -1.5125101551313516, 0.8349723565069721, -0.4630666040073742, 0.7736719852116932, -1.0870337419760834, 1.8030388333799494, 0.7918901579547254, 0.041752308352810096, -0.18161052103868533, -1.0273035399365373, 1.2748127672474083, -1.6123914305321612, -0.047805685933855716, -0.034490773695047536, -2.4415971396076697, 0.8311634921650886, 0.3889025242542891, 0.5236778772756912, -2.186081418369852, -0.7267259395449084, 0.8290657874292332, 0.4208108112210599, -1.0019169611052898, 0.9423343598864043, -0.07173943936346239, -0.5765900061513217, -1.6451129771853958, -0.7244863330587255},
    {1.196612785198573, 2.804133521292234, 1.660964593554103, -0.05483468086643145, -1.8807770204689123, 0.5678561596373645, 2.4339300656886174, -0.07297741212651775, 0.2815664467736388, -0.5460946104213953, -0.1556326106347358, -0.12276794121352275, -0.370692713593844, 0.6670504596971603, -1.4251354788273354, -1.486539519230707, 1.2838116856145454, 0.4914689287958865, 0.2513031071537717, -1.7002937341845061, -1.5132513232610765, 2.3470964625154433, 0.21760685878518174, -0.7497010555329684, 0.9821684759610126, 2.3802486155303373, -1.0340357332788261, 1.5791967153060782, 2.969720836989901, -2.2108210921564684, 0.04789978864949589, -0.5446258764287352},
    {0.8748401685546419, 1.2015478193624674, -1.1241435941584896, 0.2717665176617908, -0.05042723231965187, 2.5789497578452, 1.6427538081790027, -1.7204316638170458, -1.6867665324148144, -0.9214596958633704, 1.6717407562971525, -0.1288104306196783, 0.12202189779496607, 1.5961085925999903, -1.6734300540300782, 0.4271171131281529, 1.0176429561664047, 1.6073714584478092, -1.2642224200361605, 1.6520632501008408, 0.7953190765425417, 0.7290630527609359, -1.1709459314221586, 0.23475794570743966, 1.014705663877836, 1.5814637660991735, -0.5762465490951503, 0.7985501576589457, 0.6264209794066679, -0.3141822792168032, -0.4271880934648802, 1.8373855190059667},
    {0.35553482941715614, 0.5808773551630654, 2.2493032800337636, 1.51546583654175, 1.2849703738892824, 0.3340778558682764, -0.8626581822204397, 0.7156769222251343, -0.7096257701533192, -1.459416800399473, 2.155689364795491, -1.4541707533815598, 2.1355023658622434, -1.0884603019145072, 0.19712487264014958, 0.8821358061318478, -0.11130431580661437, -2.0175107200373446, 0.6880506298962391, -0.6660550004128092, 0.06358838260317394, 0.3989582608477184, -1.1942154572327277, 1.9884510790256882, 2.061228165788332, 1.0271205744090828, -0.4398808550345417, -0.02329233330057484, 0.6191793774644139, 0.009396065181632078, -0.016182920241279364, 1.5699539027346474},
    {-0.9374508377424707, 0.6571596225852564, -2.35452189741697, -0.2018316950752554, -0.3454689736923994, -0.5765902880416405, 0.04371636552671905, 1.7882121844883634, -1.0820792976108984, -1.4856564128376213, 0.18056873165384194, 1.2519854426216335, -1.2295064490607255, -0.9801652849524576, -1.324022894806523, -1.751168155399769, 0.9345519716184388, 0.8324401298525589, 0.0029472405294101623, -1.5988565282448084, 0.8648968841129956, 0.18762986609272286, -1.6829472812139152, -1.290934531059981, -1.3540756703053545, 1.213303505866231, -0.14187942745478566, -0.6351083343276915, -0.21072013303739967, 1.0026168864057972, 0.3254277326144539, -1.6844988063682091},
    {0.7014491511870913, 1.6883040216699168, -1.0167191821186303, 1.2965647840757952, -1.067006019873358, -0.27917203257207507, -0.6490947707753436, 2.0140915755657005, 1.1712134108145975, 1.6379965785945774, -0.24536861457723294, 0.4842883703158227, -0.8537655802072269, -0.9576602107266268, 0.9618403170185871, -0.41644650330738164, 1.4942577728525719, 0.5750470674913136, 1.576232779200431, 1.0873974587949093, -1.9330489230368988, 1.4115028069490154, 1.3713019243300646, -0.5232432606651942, 0.06059833883384083, -0.8290903540064841, 0.8135889666172864, 0.5333830391340488, -0.7674270746823669, 0.0381228327873685, 0.41279331568647404, -1.858140283183353},
    {-0.906369987345484, 0.5373241775729435, -0.7949827602448276, 0.6746044318979629, -1.091434326409146, 1.9449227971442196, 0.7339276655848098, -0.479663550754422, 1.1078678883866233, 0.6194067408107622, -0.7788856071875766, -0.034596819045597284, 0.857438821801984, 0.03903462406241611, -0.8046627398288061, 1.183703349782231, 0.13713829613883852, -0.5470124087718092, -1.152608948525692, 1.018312959617096, -0.17851910529527654, -0.7819733470932313, -0.5266063653906566, -1.2887116401996297, 0.2540206867950742, 0.5411039218361802, 0.03081788898881613, -0.9953373325105632, -0.9251653690512515, -0.24977663687329832, -0.3065666147412569, -1.3826146430848567},
    {0.8192842304771766, -1.4366867901511164, 0.4832635552191957, 0.09175464935234591, -1.6517115164435898, 0.7128326512943675, -1.2776115005814375, 0.4828291529132652, 0.48959757244145075, -1.5647417280713884, -0.7799399560061387, 0.1456888296247333, 1.1442261497026132, -0.7986104151582312, -1.3336345782576773, -0.39073565181532105, -0.06099457844238782, 1.5579154519126321, -0.7998402518177488, -0.4117381723347972, 0.7246330072036467, -1.2524371689835658, 1.2010429712205017, -1.0460849372057874, 0.06825803848635316, 0.7621365038828607, -1.5942650473389413, -1.6072591403342562, 0.8103231977763687, 0.12105235510517298, -1.2428434074891896, -0.3491456076013576},
    {-0.16528745603007672, 1.3147436945482602, -0.4930223249661914, 1.7861471514719347, 0.09697187612149735, -1.6328253696094974, 1.4748057353083768, 0.09664203201976294, 1.795480947813221, -1.0130957028009888, 1.5020384938263518, -1.7279546771921572, -0.23560400417481683, -0.596831695941026, 1.8269104148497886, 1.0768526058295427, -0.3549166852126662, 2.008657014582035, -0.4277066080783658, -1.3154377382218216, 0.522593398406841, -1.0314036915693645, 0.6503158025622917, 0.5878046383618414, -0.8038396093492131, -0.847183554706115, 1.1592198730651186, 0.8164649133865676, 1.8964306600436707, 0.9793658906115432, -0.1395405559874413, 2.319299903802598},
    {0.841998713738565, 0.41944707463320385, 0.5423126851354775, 1.3315875834269646, 0.5365555351939449, -1.85740163668429, 0.3906637443941249, 1.6735711980189854, 1.5082154818405447, 1.651182588355239, 0.2625641271376699, -0.010229141917390154, 0.20762445290785805, 0.13175304606028526, -0.9539714782429471, 0.5067303634486613, -0.48211469623213765, 1.8077453122750573, -0.06210200103868797, -1.2146607203391113, -0.7575816873036596, -0.06992789764109238, 0.3121615225184313, -0.2062212258039599, 0.641853538659597, -1.2975034722308365, -0.32572416592991993, -1.3291699474998655, -1.044227088146434, 1.4028351371570542, 1.5232322321174043, 1.876125794586489},
    {-0.8172948609292277, -0.7242434625297224, 0.8303809215515042, -2.189590654953415, -0.7452826379600005, -0.7008329690315435, 0.7245351436272868, 1.5099470993371047, 1.2257167808891767, 0.772856295701595, -1.809349385428341, 1.7835916170503416, -0.3705286900214386, 0.3498269152409509, -1.7061378491331387, -0.7911237430808691, 0.842508690673886, 1.5597980355928438, 0.4672215054389961, -1.8714977665581976, -1.313277835692968, 1.4219494624631484, 1.4177339656364722, -0.6912733096848453, 1.463630445563773, -1.7160122930937707, -1.3160646372973042, -1.277117909572696, -1.7893037224305646, 0.17335289571712842, 0.7137078445142665, -0.9803785305436812},
    {1.6652237704867363, 0.5151769230535643, 1.2757394062379064, -1.0832730470963217, 0.5751036026317266, -0.21003591629494353, 1.1396690189794085, 1.0055517203601372, -1.2085091366756044, -0.004311737279638976, -0.049307651532981785, 0.7767471357797922, -1.5760042072141711, 0.6518225418881567, 0.05578152414650082, 1.4155547293194986, -1.4642293777656592, 1.0761506276147217, 0.8160584024760164, -0.976663559200255, -2.090118431893025, -0.4353932224635922, -0.7669543894685589, -0.12994027057894073, 1.3789329623965167, -0.33118731171610827, 0.3788791532548873, 0.3530050989079994, -0.19849918962499166, -2.678166119089161, -1.359621856891355, 0.42435251961791337},
    {-1.194111914291448, 1.6567575305902973, 0.2790363836015111, 1.1203148148318978, 1.20142799475937, 0.3691896008189261, 0.8837557660552275, 0.4859018410574858, 0.47855238060724653, -0.36177026894871495, 0.275240874634347, -0.8932905478251302, -2.007274579538317, -0.7600441623554212, 2.0682145349906507, 1.1549816676270268, 0.13490366388496075, 0.10874030294620904, 1.2836896232285988, 1.234398232871722, 0.19663808907992175, -1.622266852742157, 0.76352703007955, 0.024145273011825157, 0.11081795057269789, -0.47729197481637053, 0.5994550594852209, -1.1135214882509956, 1.6254059144503608, -0.8718116262763639, -0.3096732314778142, -1.4647865280328107},
    {0.7084055915667216, -0.23239706644339314, 0.619073249952115, 1.570708581962879, 1.5058275639916947, -2.43830993382616, -1.1892402811055902, 0.663581556983212, 1.2656310640045245, 1.201590023340989, -1.5131521148282983, 0.8376790494019362, 0.45301396527368554, -2.517409307855783, 1.2869870154335896, 0.95571141268905, 0.6711547765112124, -1.1560501987730416, -1.3099847726084075, -0.7360842969611368, 0.6288511552105481, 0.3580834534544325, 0.4845953990193424, -1.4650569377050302, -0.8046227334569767, -0.8415314334108676, -1.28739126928913, -2.1534996996228832, 1.8664468166999248, 1.5978423294676967, -0.43894648520741175, 1.1929375901239716},
    {0.0870247806481989, -0.42603898865018675, -1.8227618079710797, -1.2560878133771145, 1.0056995867933143, -0.5852776691560702, -0.49466959497520324, -2.066304109558468, 1.0843032027232549, -1.7426684103901107, 0.5626962441207394, 0.9860420122466133, 1.9035320365795327, 1.569150547875597, -1.0102600368824664, -0.47213939236268443, -0.5293614913599841, -0.7768479374560902, -0.20324494308161745, 0.1371409921833616, 0.8047060017980118, 0.3514132721786635, -0.3195025880514689, 0.786101270544993, -1.580964286193853, 1.876070125836618, -0.7949521601181676, -1.0987319932497885, 1.9947941043760653, 2.142533731485162, 1.0075296675443923, 0.7211959965241044},
    {0.7455382205630581, -0.47383194696083375, -1.602148541061712, -0.2976949209368217, 0.8622705288273287, 1.2669982217161464, -1.1223954562060163, 0.13567194034895444, 1.5553803246189521, -0.48553067923479654, 0.25018564087572925, 0.5975487004973138, -0.3650843122603528, 2.8144159766324544, -0.9779304157205945, 0.9443374058042369, 1.7157993541769265, 0.9616759087605934, 1.4537263023039295, 0.5447914658419034, -1.2954230321537044, 0.8298540139155974, 0.024132805065742478, -1.3997615385449753, 0.24705682287871122, 0.01334470366536747, 1.6148530594372068, 0.17356912279774517, 1.1220531238177445, 2.0654199343130673, 0.014528005047405541, -0.9549223897714127},
    {-1.0964563165206596, 0.50760740434127, -0.2033342412056421, -0.10955347302817657, -0.3018279925167294, 1.5023458789668434, 0.6343301430226428, 1.0611928166135816, 0.9242516414367243, -1.7385583147095482, 0.5944056372037526, -0.3774734189344161, 1.1154704299078504, 0.5159638474031925, -0.3601693990487401, -1.2981551284671224, 1.191793018932774, -1.103657098616447, 0.2243485854277244, -0.6860789333894249, 1.0042112578137796, 0.7473921300916145, -1.9747750663904835, 0.17439016929276865, 0.18390584126379822, -1.9644019466012785, 0.14165049064056853, 1.4072960890764146, 0.5308137811919315, 1.120143727831312, 0.1888163818057408, -0.2697848946777174},
    {2.121504785089616, 2.551896985927196, 0.5695823527456617, 0.6299243771425638, 1.5093330524263195, 1.750066462249447, -0.012795830378940023, 1.3484973110023417, -0.6543341017544235, -1.717633586409891, 0.023224445979851238, -0.25630508630297166, 1.80897337957662, 0.4670379472106112, -0.27985104331000493, 0.0898108315108511, 1.3007882442496361, -0.6202978824801246, -0.871678544403895, 0.3176884592190468, -0.4959434497837818, 1.321230308550758, -0.24960924083987013, 2.168920132199274, 1.4870873390632073, -1.1241327283087936, -0.11914813929546364, -0.4373974596382405, -2.2136023852334934, 0.1501797349510587, -0.4068766254802673, -0.9344579137742316},
    {0.27745098665932305, 1.9983653274129562, 1.5204902410039425, -0.4361041526896379, 1.5506900704124638, 0.053843055618515365, 1.9861092791207924, -0.8891354510992124, -1.0764510031443497, 0.6335006602970873, -1.443165661923734, 1.263250849645401, -0.5684249565935888, 1.1051502871278505, 0.664074546342064, 1.6313340861215027, 1.1829858288791377, 0.8869445251707435, 0.18711201897254645, -0.37232032413449334, -0.9214167076442825, -0.4993060924669112, -1.0498015044515532, -1.2004161599756338, -0.28302901504655814, 0.7763589188430808, 0.42875787443396174, 1.367785738836405, -0.37589131241410334, -0.55161034998126, -0.6390633170518277, -1.5913718513842947},
    {-1.2610157212477777, 0.9623928432737023, 1.42351101937327, 1.646753683903471, 1.7944634150536776, 0.2042431121606743, -1.0461001012326951, -0.16560071143534266, -1.3829317344201881, 1.515676962773916, -0.2785511988554862, -0.2576068268898312, -0.24285183010688308, 1.581980594455853, 1.1441826142928848, 1.1179143979402257, 1.52472207714351, -0.6604307819390248, 1.3646511856073442, -0.6599632650160803, -1.3247589311279455, 0.6499089747414285, -0.909819280547295, 1.5805686978824733, 1.3047789523849496, 0.9115817143087798, -0.03341096035785888, -0.38647766616331397, -1.004463560579938, -0.5114588747758977, -1.5241642006706553, -1.1296379616121934},
    {-1.6778664597432809, -1.4269717092190026, -0.653656028911915, 0.39044744714971025, -1.7278693251671107, 0.6370304029868754, -1.0122544302149243, 0.6734360994498467, -1.2327357655755045, 1.2732875891384128, 0.8432649335650773, -0.7624425930914006, 0.18710991983563258, 1.0165306111812935, -0.7958535373326203, -1.6691267966066485, -0.7257209724268098, 0.09348093159054, 0.9593710529748485, -0.2943471319072742, 1.0479755866658846, -0.17216982117925245, -0.6239592810523684, 2.3619868696090256, -0.4502221035872512, -0.3331773382182928, 1.3977298006747871, -1.0893004572123466, 1.5247201753412938, 0.4573697701478426, 0.10784531025989885, 1.0113555557630323},
    {1.399871242422203, -2.036349211831957, -1.2798928558821099, 0.02618062625658353, 0.6064539927867697, -0.7075812340956654, 2.1300188352642424, 0.4307630272403839, 1.9625841447587793, -0.4709329472243451, 1.5578205979841917, -0.27516301694249234, -1.437675240034834, 1.2613965248841923, 0.3066569849731602, -0.6234997131242653, -1.5306713618068457, 0.15094748763334684, -0.4866023699588903, 1.6318557118262644, 0.8266319915889767, -1.7207841872219793, -0.18225214459337435, 1.4652249510474962, -1.3491018041300407, -1.344337209226774, 0.09390556851848679, 0.38383120899112655, -0.2348107758712939, 1.3685583895049074, -0.40923714775447667, 1.8235458741573944},
    {1.3112229767620671, -1.0949359336998106, 0.6224682236966123, -0.6676503250891406, 0.03491263843320711, -1.4888438844055274, 0.45554926015109387, 0.19504391365364762, 0.12582319885601465, -1.5512672051010559, -1.052714619488397, -1.6169226846907323, 0.31998540611179577, -0.819325734202505, -0.08002367304755019, -0.19925532773146723, -2.272300567923799, 0.3129677822662697, -1.3337461075542147, -0.33023158991011275, -0.05590948004849309, 0.6589650107666464, 0.6525620890679075, 1.3162418951007053, -1.202440595624256, -0.22616854988558643, -1.887239305473025, -1.0688521284835424, -0.210252413640832, -0.7947838412056709, -2.06319875774391, -0.15714694350956473},
    {-1.5146304407537234, -2.0242081350078616, -0.17918372142126543, 0.3329075077675032, -1.012245265706955, 1.0551467603659688, -1.364622630392736, 1.1640243208714964, -0.2951129952850804, -0.5195667199160995, -1.634635794928822, -1.3059802256102455, -1.666843460984045, -1.7814817432077936, -0.9588990002085271, -1.2062298092504133, -0.7752604433202976, 1.1939326634406953, -0.9018904169185429, 0.697303548480268, 0.1178663106901564, -0.14476360407680944, -0.9750719682123413, 0.5370302489600861, -1.607750791497139, 0.531588825406228, 0.29956863009570045, 0.5281709997054406, 0.7236816263880446, 1.3247818471544428, -2.3194717540661918, -0.2797791533120718},
    {-0.8990701587633838, -1.5990529518064516, 1.8703379348371565, -0.42426916369967044, 0.24055440028650193, -0.02494226768687813, -1.9426332988465935, -0.33134625266851536, 0.2434787358883266, 1.2707615515363089, 1.11225871591293, -0.03618276040542925, -1.0683744524794028, -1.9820402368119312, 1.7717697389412355, 1.0050292316670348, -0.11036839611636486, -0.4118483318167431, -0.62664757682162, -1.079672858022168, 0.298675236650748, -0.4906182437381238, 1.1007225680745227, -0.9248445950193123, -0.7055407381801181, 0.7147700777053995, 0.4770150456601457, -0.8536389058904219, 0.6249959388769113, -0.3014532237184198, -1.3439165131760098, -1.1971960693221237},
    {-1.5247961777747487, 0.45084378960058524, -1.3013080409128133, 1.141549899521266, 1.0899165159797102, -0.8083531187438602, -0.7404302867289357, -1.6256496324021277, -0.7573349442233085, 0.0718458575814951, 1.1959126540022862, 0.360238180968919, -1.0061589991315745, -1.518740654175729, 0.8820157376304882, -0.07946281446639844, 1.348956622581301, 0.3323099326099924, -1.4817571176638464, -1.521440849789877, 1.5313061956230658, 0.2614659354010702, -1.1805113453381633, 1.0978954863373995, 1.3843223503108946, 0.5885278415496459, 0.17985572253170395, -0.09173029138964912, 0.9117831708159029, -1.602662837685265, 1.9377625083551826, 1.3939197737681077},
    {-0.14941976079073677, -1.9508939748955296, -0.9296613373826619, -0.7425713135046482, 0.9029812302203741, 1.2099447575646782, 1.5641265882892825, -1.5221588169465987, -1.2496972299528537, -1.6792654233457578, 0.7932383872848086, -0.8933508914538109, 1.1346549414843103, -1.4606208315460512, -1.5771542970934291, 0.5117294894117659, 0.7346989975461226, 0.8787317100147646, 0.3666732717930784, 1.7437439130632701, -0.7931539951189988, -0.5803021140084291, -1.0215373133190047, 0.07404984465992862, -0.09574895856955326, -0.9922456914228345, -1.4789588676439078, 1.193021829652263, 1.1647716865794986, -0.8331306067545712, 0.6904823405476669, 0.3689982312963024},
    {0.04251976457223925, -1.1782218603338175, 1.7196579136772436, 1.002276742776407, 0.7246804400269241, -1.5439082143502272, -1.5865229717644873, -0.2087205445233824, -0.821902902767965, 1.2019344080091874, -0.25232259341716673, -0.42528945878700025, -0.9244177273198722, -1.1492505782065607, 1.0305079074075578, 0.6954868437577647, 1.6096898443494274, -2.010308409159735, 0.7426360594238587, 0.38762279493208696, 1.3409582267103437, 0.5090645689989842, 2.006109428915394, 0.3600518063648309, -0.2651882666716748, 1.3284943513906111, 1.7334013327862419, 0.9497644465277473, -0.2282859449566738, -1.6593058655248718, 0.31992135218010465, -0.3262930258991005},
    {0.8748770550951446, -0.45294834595403566, -0.5526570711004255, 0.4620677925937046, -1.5810673236673016, 0.5004295234989402, -0.23374631910276894, 0.14059099401767303, -0.20099889101353255, -0.2203088886803775, -0.5116924585129745, -0.3722326529467666, -0.6125441820283812, -1.758068686408122, 1.181891692570063, -0.49113765206307186, 0.800550145173574, -1.596433321752898, -1.4446704987496766, 0.12913344475113012, -0.8658455561289848, -1.3885727873546885, -1.7673540539878823, -0.8963003979777322, -0.5274834245110498, 0.7395125317646138, 0.16849739132235983, 0.5227154430882305, 0.4465725826792193, -0.7377396598043214, 0.5031899084269701, 0.018353070671300067},
    {-0.6802556725452673, 1.4496571115250334, -0.05638851686953629, 0.18884628189736782, -1.1702200865543777, -0.042680682236465685, 1.8452143230609057, 1.3514128630775584, 0.6826158797434635, -0.938288888591871, 0.5868374210085807, -2.565408773856419, -0.9394051380961442, -1.079214387107116, 0.6285330588463344, -1.1026578257612463, -1.525633738574849, -0.8989321910933485, -1.033207010230971, -0.32023684997944646, -1.213589146678335, -0.757074726253343, -1.369891959036154, -0.27910112432886797, -1.3744249843747156, 1.0538262798323021, -2.212905295460113, -0.8458169195851329, -1.2967484482983747, -1.5025959462431246, 0.995089540064942, 0.7205488728243207},
    {-1.9451545277596958, 0.9287753783426926, -2.571576179084938, 0.2801324994768133, 0.8620238567119485, -0.11544318000478034, -2.2549709112952163, -0.40535194597997143, -0.0042900391130690115, 1.451392442633788, 1.1231116119192237, 1.139935146001411, 0.04126502104600354, 0.8613026081230589, -0.12412882028647947, 0.7182176956627484, -0.8975389681248418, 0.3837876307527151, -1.1176056744254321, -0.7198526632946793, -0.8813375733951222, -0.1975589090688807, -0.7558931006281429, 0.20674478641307564, -0.03073223082420931, -0.8032414835912988, -0.6734482315671367, -1.5902510936293048, 0.05007608983833577, 0.026239377525120774, 0.5373822111249326, -0.6796870551486787},
    {-1.9575859084893077, -2.060431502060408, -1.4028822117948214, -0.1412740846938538, 0.5482952702112535, 0.36904084094162604, -0.03837462817691257, -2.184801650128282, -0.8063784024581732, -0.08776488544494243, -1.1528102255030017, 1.1181888993009177, 1.2901380301073226, -0.22250284596390926, -0.20629565789188883, 0.5072233136374956, -1.95684701559564, -2.02601652912537, -1.1484687682285861, -0.29990993523529363, -0.3418919976671389, 1.1381117711993511, -2.7271481312496593, -1.2327349850458107, 0.3945441155539971, -0.48523120926292523, -1.4118274525145864, -0.5797124397566997, -0.21258906789604107, -0.6924024095633362, 0.5015408739262996, -1.3550082518256945},
    {1.7619958033515999, -1.7044552115663216, 0.26270205797737056, -0.4217072795470859, 0.19543383433182449, 0.8745339593860129, 0.17629851838515476, -1.2050759330027956, 1.3529501818963579, -0.5455344087085401, 0.8915433368692043, -1.746271836933486, -0.061212743700045286, 0.35372357469604326, -0.025522946025591943, 0.8138067482287588, 0.7549909628059054, -0.06621322859724088, 1.371605700529062, -1.0114788336449048, 0.19020711661932732, -0.6638917412995146, 1.9623567608285124, -0.4266742374804316, 1.3986918661088743, -0.6463906915925988, -0.3089453970489524, -0.21949299537620268, 1.1738287226199242, -1.4446142311842407, 1.2705743085394763, -0.9778855236494397},
    {-1.7016968423125418, -3.964223718841052, -4.289345034162203, -3.346261788531664, -5.644780402847532, -3.3592351637328264, 0.8200220132127956, 1.4556902113889836, -0.39444916755681986, 2.104065037677752, -3.1372710144871885, -2.9336210388380732, -3.916564306720922, 1.533579167828087, 1.0771935979610852, -5.858106447159664, -2.3567407059172156, -3.0292503349151514, -4.160051972984959, -2.7239937158649354, 0.7580413975575357, 0.7595047678505382, 0.43868484261257246, -4.605979818114601, -1.9512783343709683, -2.2430664241714195, -3.881019856470523, -2.328033006612086, 1.3884536273131254, -3.1062507811328675, -6.072359452415469, -3.911834908620441},
    {-3.1528292189120926, -2.5725197990570154, -2.29682018109468, -2.7727384793538827, -4.764765218208121, -2.70660412315463, 0.5458280102557732, -1.221953206730351, 0.5306919280123102, 1.5675707542662614, -2.831764086016215, -1.4673735029124313, -4.763758191291974, -1.6347943851791964, -0.8774485145448505, -5.367450633350599, -0.7053693442421186, -4.336083951900569, -3.870633878677788, -4.081316236674151, -2.5305312890621057, 0.7561934729867061, 1.4237694399356697, -3.324378886872003, -2.1800033635016356, -2.9575227261351915, -4.2540083340745145, -1.5779804805976645, 0.16423566663372427, -3.092490553011409, -4.6728004115626005, -2.5147518258755555},
    {-1.9627265618603795, -3.43017091479443, -1.8978957882131664, 0.13500171822222434, -0.11135413469693857, -2.013762616013758, -0.2333498080986617, -0.21967519472724448, -1.2688337423003981, 2.453469362037512, -1.1527321454671033, -1.4340608794400487, -1.3877877870074857, -1.0997275795743995, 0.04241869240363488, -0.7036575892180493, -1.5909021810882864, -1.2838074826141364, -2.482891535967142, -1.3890652695059755, 0.12253829864546482, -0.37320106193548047, 1.2728627817694838, -2.6244043105903097, -2.810360620826165, 0.13658353222175573, -2.4857855856790523, -1.8587394360444995, -1.0213733140604953, -1.8303119718085865, -2.751890351272, -3.1728819240342316},
    {-0.3371964898799717, -1.9368425910087228, -2.9013609576528627, 0.48359371126017076, -0.5616422403846346, -0.29635228910566574, 1.9802762305708124, -0.4771848279741713, 0.8151369552700273, 0.44235161829966485, -0.9466765334087615, 0.8362141893237327, -2.626282757939367, 0.6157477145062666, 0.020953096403962448, -0.32290984096219466, -1.3077569124198483, 0.5592315936967611, -2.9631375859458062, -0.8225309827542091, 0.50420085569195, 0.9339839772319962, -0.082729982071243, -2.916825478193273, -2.073654109746383, 0.07669677128249662, -1.8012895891374898, -1.739868106005741, 1.2669261983625995, -0.2689783092876047, -0.6379206865945427, -1.3041696085406198},
    {-1.2700719813949428, 0.7012882094725724, 0.7938364696204868, 0.6518002946295547, 0.004331632663576428, -1.1053427596331535, -0.647304641775285, -1.3055716243254374, -0.47443093658940927, 1.6487893055791127, 0.05472235741493694, 0.9300232680463987, -1.8842379337148856, -1.3086255182265436, 0.8400614199800491, -0.7396762270952311, 0.18282628214177105, -0.7719436381144246, -1.9708240668410706, -2.4341811015516543, 2.2490442114352795, 0.2153161029665194, 1.0418547921153394, -0.6601656076184266, -1.4683439382187635, -2.557202267767851, -2.5797415362591134, -0.8412354349109595, 2.1223365880316676, -0.9889392737838039, -2.0484333297699377, 0.008398728600218935},
    {-1.7970507727441354, -0.60240506735087, -1.6100926588599056, 0.08235492800444856, -0.7393798633804883, -2.081642227277578, 1.3960064979545168, 2.2299285802783007, 1.329827095772124, 1.0426705744957852, -2.173051244294245, -1.1170220964561266, -2.772935164030152, 0.6988886623816494, -1.9438664460040225, -1.2381390354103843, -0.9700188996740787, -0.2590264195952505, -1.9044145531127041, -0.9497575602472994, 1.1084434238639198, 1.344798780741744, 1.9774736013469867, -2.0262399954727206, -2.658725509330976, 0.1457120070612134, -1.214248634159093, 0.6189342922693343, 0.08486774037539954, 0.13648303267985404, 0.8246639652784241, 0.35015557691578775},
    {-0.3612762300812615, -0.29206299915172107, 1.475667836970875, 1.3899814600221996, -1.410166316674554, -1.046265583630281, 1.9853948464296112, -1.4769729646923246, 1.4439726922668035, -0.6221805078472958, 0.20801385810556505, 1.7227742929165508, -2.405059471854217, 0.24101808775430725, 0.500668045233772, 0.682963991972199, -1.5347023905332888, -2.323741752878676, -0.34488789699183064, -0.9384736549278242, 0.31427361786729985, 1.2573648834285618, 0.7340789104720682, -1.0222926357958588, 0.7637906938908358, -0.586609398987678, -0.7554446139317914, 1.1491303622875328, 0.8846604991452317, 0.7705766233647133, -1.3778891025753752, -0.5910670643896744},
    {0.9407029291462533, 0.09165474044539404, 1.841020977249607, 2.0244107948625483, -1.592545136594011, -0.23635065550164416, 0.11545442931160621, -0.17133786320201524, 0.5484346273071347, -0.08206492497547394, 1.8501168181115575, 1.0877141535620598, -3.097924135371951, -1.060238479402544, 0.2130860970532618, -3.035367720910162, -0.23890402797632582, -1.584927091177341, 0.8434289268371112, -2.538780304422758, -0.8028124177433945, 2.1783128189922873, 2.1836830336509196, -1.626879000371087, -0.0033559660734819117, 0.21730545398537449, -1.8721838766351477, -0.3357158048864359, 1.6835508180749743, -0.7723018136965617, -1.3993881248742472, 0.7027868081032674},
    {0.7916096287079847, 1.1964390844138706, 0.08538754123362571, 0.38057912674403716, -3.273148080289624, -0.49640982729043737, -0.01062916279414483, 1.2091574986659195, -1.0574720856532505, 1.1507597790449806, -1.1567242729744867, -0.4848940814935068, -2.9344880862777227, 0.8665351744748965, -1.3188791319575852, -2.528682197097359, -0.6139890332203893, -2.1504896636216437, -1.6902911377431709, -1.1841385690649913, -2.133323721484208, 0.903824106710518, 0.11021844313334646, 0.29765425624912467, -1.615647495365795, 0.3589808726255609, -1.7955118586747265, -0.3979835645713031, 1.984700792797439, -2.0154549955350003, -0.36482338924521024, -0.8300460956798151},
    {1.0490383680502202, -0.7244256417827478, -0.18840478573572325, 0.6804104750196754, 1.2620828292432211, 0.45699952798309795, 0.32985210665932024, -1.8269338552341912, 2.0804576478246752, 1.9913428702800293, 1.0327386122111166, -0.8418884123572451, -1.3965937663614632, -0.7296165100390785, -1.8446905916467526, 1.2578532859084743, -1.63707520714779, -1.419450549200097, -0.06706404393827177, 0.4312727876285865, -1.1616980756419206, 0.9707614631735326, 0.6493358369873454, -0.8378422935747875, -2.012632599761104, 0.7016555126600861, 0.11209393621994157, 1.0145179210768407, 0.042571677350343444, 2.3086811607924345, 0.2504490499740701, -0.9072553340418872},
    {0.05085217339331136, 0.21234377736363308, -0.6628088426160581, 0.2037588540958221, 0.3795273315509064, -0.6415218020476531, -0.9693517761078698, 0.2630770163151638, 1.7685211353168904, 1.6582083348669314, -1.1618419091842986, -0.15687054396699462, 0.5502550115701795, 1.0295000943639137, 0.191689947229634, 1.2070970364457352, 0.750168232958597, 0.4475321616781671, -1.8977414770035106, -0.3311452898317252, -1.1664625163557027, -0.07409242411379438, -1.13377926609895, -2.061652836525703, -1.5835322749019578, 0.33459187939813384, -1.301118906593184, -1.0239086739945298, 0.40702801418591245, 0.12461218280182616, -0.15097550249598815, -1.7377721954700744},
    {1.6367141151514921, -2.031240283734646, -0.10890538698217307, 0.6799494953026589, 0.33190981935143754, 1.153342738065714, 2.448464334564232, -2.325949348313323, 1.3598920464393556, -2.2573735641106634, -0.4889303054030458, -1.2719544226376664, 0.2686577131591669, 1.881807176306229, -0.2599583399148684, 0.30932332847364546, -0.05649680426921588, 0.6610919038946749, -0.3595400954090205, 1.4731092445353202, 1.8613502921127212, -0.19656046769953767, -1.566670386642293, 0.19030582578326335, -1.6626773208813441, 1.1757473839996413, 1.278711813153559, 0.35409304404123704, 0.7048787089194148, 0.24731264059520552, -1.269243369626942, 0.24793860287298922},
    {2.0453526294514917, 1.6775334831582014, 1.148689289056915, 1.1648056638537132, 0.9308662244369472, -0.5689983978396216, 0.4621922016018484, -0.13308178238272617, 2.323141819127531, -0.027632780637919876, 1.2842925043764701, -1.2179392226129717, -0.8683392608440126, -0.7637171339804497, -1.543638800287781, -1.1582400511124809, 1.3861055127189421, -0.4100139202733358, -0.10782962791089835, -2.592072145472155, -0.9683199472256055, 0.2453926825634017, 2.435327231744023, 1.0151788916847864, -0.20999463732265394, -0.5850896609715218, 0.09595972569870924, -1.1417321916603425, -0.20531707772288152, 1.1682358981469156, -1.451025846130713, -0.33010433621680374},
    {-1.1514279508279224, 1.7189767258692321, 0.5426880413552698, -0.6892229734719392, -0.5649004795075381, -2.057077644915184, -0.9981420696292858, 1.4919584747056172, 0.6917296374586338, -0.6067519109102015, -0.8841341403155475, -0.2246250783634278, -0.4841253318639895, -1.7272002177257928, 0.5232040760161297, 0.7251163526640022, 1.1746329106345967, 0.2921662867882134, -1.0310484044379618, -0.20402450767529212, -1.3917855812825244, -0.875270530352986, -0.4928037414156129, 0.5559533911495774, 0.8478920964306964, 0.5200892723237285, -1.34054089191683, -1.4382759209757823, 1.1535425670082327, 1.0098339897363762, -0.25257558505636263, 1.2747886295310724},
    {-1.179983250693306, 1.0847359206627667, -1.8090030938983301, -1.934047807555532, 1.2212516033661676, -0.8898257926044503, 2.6946979935643482, 0.3071128922397722, -1.316000665036626, 0.6496062585747961, -0.16000910680049524, -2.282695790877943, 0.32899698567931324, -1.1017426018641008, 0.11888058171604937, -1.011454725367975, 1.398998447224603, -1.9855237355713553, 0.7323354561565996, 0.9575975820776902, -2.3647760349850055, -1.538344072196248, 0.14413570228243916, 0.9348526122948262, -0.20159205321492535, -1.220464589892015, -0.6903457495323901, 0.5967950991859862, 1.7060060644955959, 0.5840765307282588, 2.488958552671519, 1.4270216223180392},
    {-1.3258606517202711, 0.5332166540656321, 1.1929051225993486, 1.3097718243275922, -0.7792489527230251, -0.025866898460388293, 2.1452254076376374, -0.4697377293161008, 1.849536293575681, -0.4757816211387809, -1.2056924705611802, 1.6092694826612337, -1.683130234273155, -0.9987982440405724, 0.23277628198389283, 0.7842168224178486, 1.8707498886641138, -0.7968975484918562, 0.1639717374664752, -0.8044245571351004, 0.26623735062062165, -1.2357792895625461, -0.23042513514697838, -0.467307712079973, 0.25586944713794557, 2.04904550843018, -1.1943163060349593, 0.5873419222075759, 1.1600478436649708, 1.0665449815407995, -2.325676139821589, -0.02519804638058726},
    {-1.6130624865952052, -0.7420582123039281, 1.0979638613372387, 1.549501449845128, -2.0079878903765263, -1.5283384193330645, 1.4624515148384352, -1.3121389570443247, -0.9256831613394089, 0.8345224776439237, -1.3422123679680458, -0.9822534376191795, -1.770930897020373, 0.9541246797872864, 1.8145061141414376, 0.6502697176465865, 1.523108528274583, -0.9087831863005353, -1.7954820806157246, -1.6118698666935594, 1.0878354925912401, -1.0056640924118878, 0.7789988398005019, -1.0715468445804597, 0.7554841299131039, -0.6835224808669608, -0.04999975848859398, -0.33795019875975096, 1.1563528989023033, 0.44180105246286366, 0.5005576776837494, 0.10902563060192592},
    {-2.443459487779166, 0.82209513500126, -0.3336856804294931, -0.7987377278371859, -1.7913402374362126, 0.35147390073168844, 2.144430892724687, -0.5314003836275947, 1.8167734084321026, -2.4255123510874625, -1.2747382335806152, 1.7725549487421897, -0.7965243901479307, -0.9391388276033781, -0.9265131769631193, 1.4631494003092156, -2.5888569160961703, 0.801260160256138, -1.7226202861228943, -2.1118256279143157, 0.3862348830216148, -0.887499395370151, 0.6744188100566986, -1.9059530901425523, 0.3198346887292816, -0.7800089052570117, -2.1886581339353386, -0.017632173105122804, -0.0636378423958748, -2.1449926716993204, 1.2431935363174675, -0.19570580033770282},
    {-1.5062243694235626, 0.33433496087005177, 1.7198222928131568, 1.6076156004966857, -0.2619481914059797, 0.8555562428969754, 0.6953092857341509, 0.43857709902115194, 0.6526857723528365, 1.6530499640108636, -2.410540749835796, -0.7224623853290133, -0.34723087648813966, 0.4802133354031173, 0.6099360144043102, -0.8397638166963314, -1.1347392382515735, -1.409510486449926, 1.3245562138747573, -0.3718693777540532, 0.6938331719513917, 1.6751327168914922, 0.9218298695364756, 1.2339589145833738, -0.283056529884767, 1.0155230085896378, -0.052133836800147874, -0.501432679805096, -0.7241542254301025, 1.7901810385147143, 2.7995777204699825, -2.086428108354713},
    {0.568558705440848, 0.20391658148639094, -1.4329308255335607, 2.2169186620643107, 1.7587526654506174, -2.2478696996752094, -0.7722672881212549, -1.1484694250597864, 0.568351636101534, -1.3233954220613469, -1.6451902163123833, -2.1946724397571384, -1.6027188868017155, -3.9233597952578845, 0.13839266339026013, -0.5602433797048436, -1.2345068691164895, -1.601693215910292, -1.5930271311674336, 0.26005557023183207, -0.6574523104478533, -1.7080550530793914, 0.884217598970567, -0.00672669959483146, -2.327709820575673, -0.9119424736009146, 0.5109498174303241, -2.3848036099482997, -0.6926750299122182, 1.8852570084522084, -0.24099221995733394, 0.7779989132599265},
    {-0.4450666678298164, 1.859011752458696, -2.2702620366480417, -1.4519596507940737, -0.293534457514666, 0.7448687397371612, -0.8294955424315054, -1.24351380401707, 0.3545760105249395, -0.2628940417333051, -1.6208033943791187, 0.4453975811832395, 1.1817880619469046, -1.5580483762442134, -2.549811201909855, -0.9138611958348024, -0.46954647313229747, 1.2137881601928955, 1.0248874434751414, -1.4752287659039864, 0.4559515291367914, -0.9753753792317499, 0.16924171568811855, -2.128509493541048, -2.1515036724647136, -0.09087704081611013, 0.34391627856439605, -1.5405054958322122, -0.7008695306375392, -0.9419016603896361, 0.005788198753675854, -1.249033037833518},
    {-0.517495610951357, 0.6133343983555771, 0.7709169730794423, -0.038920008027349025, 1.7787590273602212, -2.2818775838764487, 2.085596302149914, -0.12136618427965258, 0.07037063958030515, 0.12847357072867646, -0.3952701902455923, -0.9877806713315355, -1.3562979150497807, -0.11916242856744796, -1.698214638980144, 0.3848426592035595, 0.5145745085407252, -0.795150847680629, 0.7997665325089767, -0.06323601669570295, 2.537595564919701, -1.2570072360590845, 0.5778760351175471, -0.14311667109678092, -1.0188457612662771, -0.06797513842197761, 0.12065010978563388, 0.1646076556659242, -1.587520711938301, 1.7747370153782371, -0.4828730641563659, 1.44873728544309},
    {1.0320803234891114, 1.6356274870005187, -0.4869715287935284, -0.436494955844799, 0.5330915728489424, -0.08507713447098281, 1.6611196644599804, 0.06929984978531939, 0.6592068466575471, 0.800663242505186, -1.5245632379155973, 0.7285065765284388, -1.393341593391064, 0.16226635453780391, -0.34666185087363355, 0.24971642898640398, 0.7842225866619981, -1.9269268377336923, -1.3767656739685883, -1.4700825866122735, -2.4529735165389566, -1.1514642650804994, -1.846494879235957, -1.2560165130058396, -1.406038012881917, -1.7004235228244413, -1.3742645539842815, -0.6230114490461577, -1.4228492597872806, -1.007414264975365, 0.12327235854259451, -1.4909824715573246},
    {0.5039173863711501, -1.693450393504116, 0.13906277905701034, -1.2232467310032367, -1.2061368658445848, -0.8494877463436603, -1.15910739288609, -0.2521725455986357, 0.07214914541388337, 0.9408425051141678, -1.450248950943058, 0.6672126549671105, 0.4037494867298425, -1.6349992388012984, 1.3939940424334976, 0.46517846533578155, 0.7868139489201316, -0.7408007128625402, -1.1581371470131312, 0.329559360987727, -0.7673445959827266, 1.078738428524253, -0.1688083884594224, -1.3466427977928959, -1.6715718229860215, 1.0711602326382603, -0.6768824645515527, 0.5565268668972221, 1.5109007476575917, -0.6425740378010043, 0.7429186159621477, 0.26552167596272097},
    {0.44209115411426775, 1.7374013546943554, 0.4069536366139141, -1.5760444643557252, -2.2972242446134574, 0.4529892552992168, 0.8954154885329262, -1.1828290767503196, 0.13570786478952296, 2.2518117707338035, 0.41647132794208547, 1.0106374061626953, -1.314664802634418, -1.9285417932737414, -1.7192389362758833, -1.7309947029958357, 1.274814852334231, -3.0450397236458158, -0.5377939123097314, -0.9108199272418264, -1.678614444409175, -0.14474267970004745, -1.755826026056168, 0.6387200612226563, 1.4510553652088178, 0.16897920284194173, 0.6893131983908861, -1.3999893110469899, -0.26632609838634985, -2.1607608585137608, 0.4865175339392376, -2.0880365404597407},
    {-0.7134963337629554, -0.7835732871157727, -0.3864257222489695, -1.4825824211943193, 1.1876280304266478, 1.1349334063078365, -0.9671797707908295, 0.03175945741954124, 1.884446200079492, 1.3826946613412012, 1.0713026073943248, -0.07799714911360893, -0.2246685472012765, 1.233459787301488, 0.6026580404731244, -1.3235466312967834, 1.2436402691326496, -0.31398547095001766, 0.4329260601625587, 1.1124569386899907, 0.6649658776394293, 2.049401938620109, 0.43128667781725155, 0.40840501541800733, -0.0035106879487995096, 1.7000422464272442, 1.2193740390949679, 1.69690987694104, 0.7189553960134002, 1.8134238371585478, 2.155942503093406, 0.854013626850749},
    {-2.7325209749334984, -1.5295581731922179, 0.06291213671340005, -2.430230720166991, -0.8088742878280479, 0.4402388133007782, 1.5378602695640282, 0.8636528002807333, -1.548216509314779, -0.4056170939027993, 0.46033864512084566, 1.0668396365924855, -1.5287534214256875, -0.04862291154901279, -1.4622838231839894, 0.7968180585459103, 0.027738357142232096, -1.9871260240918247, -0.5458390268827295, -0.28493788099786643, 1.4771869752963025, -0.14933299703097025, -0.6460346343778282, 1.3857445043986276, -0.3627366376378768, -0.597594115339962, -0.08362208644279275, 1.412816567008598, 1.9790583861421498, 0.41248047816558, 1.7221365001874165, 1.672738390615969},
    {-0.21538015831175877, -0.7365418199360908, -0.13553067989468262, -0.9950786804322993, -0.04063162195448589, 1.7089223151653747, -0.6627613247026223, 0.9973655928236576, -0.8963462666326094, 1.0518636549668292, -1.8654161198479056, -2.0720724305979186, -1.168977378402752, -2.4294788793212367, 1.3193730964147736, -1.0605465342650569, -1.8501585670153242, -0.7636768223271921, -2.995570437435196, 0.6471980248463408, 0.10655194693940101, 1.2741914374399086, -2.6711312079154625, -1.942778640733943, -2.066008061003298, 0.21614581647209583, -2.592525505036962, 0.0020581263025362373, -0.7273208855373713, 0.5115025367951805, -2.1367911586123953, -2.452991553216666},
    {2.2837483122281914, 2.7107849108398567, 0.40929555816420404, 1.2601085445718434, -2.7118691786300033, 2.0907913015634847, 3.0176700289974754, 0.22993725494979636, 0.2363932348443459, -0.6408461353001866, -1.1291428335453624, 1.150046971055694, -1.0486367741021088, -1.8482017668872877, -0.9557618665852267, -1.9839091249519456, 1.6962224669677772, 0.4793180791496393, -0.9149081445903422, -1.1089774285192413, -1.050027082319386, 0.06423666015747241, -1.1630003485478648, -0.6699835237878407, 0.775452089256657, 1.0520970067273054, -0.5199257087714467, 2.074171638108473, 2.5525359587823298, -0.8427872032770775, 0.6937453132905192, 0.8271365577334212},
    {-0.9714274901434204, -1.8180681661779803, -2.2120681416872046, -1.2303843518738071, -0.3570726335806276, 2.0890553776000567, 1.2335799146389723, -1.931317027931372, -2.357001197103139, -1.9474975882694023, 1.3350943778475914, 0.9604099928516502, -0.6004168294092189, 0.8888114719218497, -0.6063728636496153, -1.3457370237647062, -1.7110847055131484, 1.302233200644869, -1.6792839128875798, 1.7248025223645385, 0.4409501147671299, -1.3420454861212134, -2.698162653195365, 0.7693104195204361, 0.6856329529522524, 0.6764054823771015, -1.6467992346661167, -0.5017090239599443, -0.9183670675466615, -0.7480762565107344, -0.28660924744432564, -0.22093855597403939}
};

static const float b1[32] = {7.66510444993393, 7.953869441382914, 7.949099901831027, 7.677782183052767, 8.11828759835096, 8.013033559776183, 7.842456392487861, 7.27986157390303, 7.880731030267622, 7.757435181701765, 7.793714699335117, 7.745443346067818, 7.980334524775973, 7.788029585937271, 7.672582467370142, 8.028390471480165, 7.846228447892125, 7.819414787218977, 7.883904473862585, 7.689290705993785, 7.87921292663747, 7.0629632446153785, 8.243496925831655, 7.990470605304881, 7.800370227962331, 8.193211990265949, 7.962520168447437, 7.557108686452859, 7.480513544310321, 7.790342153805768, 8.077119140649128, 8.17295756789775};

static const float w2[32][16] = {
    {6.961307765206393, 4.710338866825831, 5.818518639244767, 4.400780653046886, 6.647273658093158, 7.14457817033245, 5.710661806445241, 5.691711625913104, 6.306006622588317, 5.604201507794964, 6.983530892418554, 5.408274243792766, 3.135998984613565, 5.854583862608464, 6.899314830624824, 4.285773780923777},
    {5.649301168049498, 4.348919723839122, 5.87142503730964, 5.75266717877492, 6.3074333382586785, 6.5168882920442845, 5.96564711307835, 6.12305490099447, 6.029478942798891, 6.798912238727259, 6.602251203268868, 5.394194611029923, 2.027978277686437, 5.495063064763951, 5.824802445074816, 5.60398216797745},
    {7.095073298014247, 5.979250159794359, 7.228713743321094, 5.346486783856845, 5.75847650911488, 6.167182325192218, 6.943160859955589, 7.379167437842465, 6.62944289555847, 7.14967962179792, 6.404718933183841, 6.329425729695054, 2.851362966150665, 5.565280665124017, 7.323075920203691, 4.7217892608250525},
    {6.380526736745879, 6.25483255094981, 7.439259897758823, 4.526453683855093, 7.040869198155224, 7.11148261842232, 6.0909863276347025, 5.914743032468079, 5.4552963023882315, 6.004330580816837, 5.968402959947102, 5.890115344980714, 3.0676926646100884, 5.984697096053618, 5.9178779517238045, 4.496778559580699},
    {6.484285415761296, 4.782788444211667, 6.375815100966924, 5.185579939930935, 6.795463710825958, 6.396428822862367, 5.622493804798142, 6.60736348016199, 7.089120760086992, 7.369156617709785, 6.852260732527249, 6.714111762661489, 2.107474609660035, 7.062894456124481, 6.844111166460985, 3.9785263027724342},
    {6.641090010955216, 4.460334284122886, 6.904155191980005, 4.700377304154485, 6.453946306997251, 6.014446421957496, 6.478792122626986, 6.201255777961763, 6.334644250012139, 7.331921664613573, 7.205147304358936, 6.628817878016789, 2.6801891830317497, 7.021982884896385, 6.691957300058163, 4.821410844682902},
    {6.389591346273293, 4.164896120572525, 6.522847068067358, 4.115318233335669, 6.387867363940977, 6.140299985649663, 6.556875452390209, 6.8724611786910845, 5.613788328599979, 6.910868346815676, 6.730528268504583, 6.812475483624048, 2.1244337729015053, 6.731769990581965, 5.601088127974086, 4.221852096117967},
    {6.6344587721662736, 5.1676557927524325, 5.489576940364948, 4.342113386171043, 5.448365824192853, 6.568293771981894, 6.518244169673624, 5.946368003612239, 5.837797589403739, 5.728076338790034, 6.850911233098269, 6.755548537992445, 1.778883964754244, 6.898870080727226, 5.562822142897381, 3.896567136966124},
    {6.905778391685902, 5.237133434658608, 5.942824231814915, 6.044472670133659, 6.648506913436377, 7.232037368090925, 6.707180798848444, 5.7239886493337995, 5.435659738585171, 5.773458036726871, 7.166653835741879, 5.931100379924373, 1.8392031655368732, 5.527224115404776, 7.381957122669282, 4.6272506851528545},
    {6.225222012147355, 4.559749948401716, 5.498434320299978, 4.275840436271717, 7.314981580850789, 6.769616240850286, 6.40362138919618, 5.889743478579371, 5.512951420077658, 6.991006652465971, 6.356190403082919, 6.826381268017679, 2.5888547935525703, 6.113162402355357, 6.304629970284298, 5.121908769880494},
    {6.683381800773634, 5.5457024473441985, 6.140847210639871, 4.188012969281594, 7.345786776406101, 7.540445899112859, 6.8335350451933365, 6.992448235603781, 5.527806473892165, 7.015688693367482, 7.385974303231416, 6.817328441931853, 1.6182962302447603, 6.014101339489965, 6.288285318254219, 5.404615698737056},
    {6.128519349310328, 5.847836067137221, 7.111382696477839, 5.404818317087546, 5.682871537202455, 7.035299188110371, 6.845931339822237, 6.723142648545589, 5.405673210484646, 7.4683664336814095, 7.1119402980072906, 6.505714956446582, 3.009255289707824, 6.966384135171709, 6.197381390681221, 4.741226342348172},
    {6.824949644232028, 5.543226310165352, 7.099523590232532, 4.288195733343814, 5.7740562635457655, 6.79525293105869, 5.221777003538805, 6.72049167163822, 5.31887329173182, 6.582550660209736, 6.138502489171502, 6.353257823237072, 3.218131383913793, 6.872241904266955, 7.1292887065005495, 4.6688353797107975},
    {6.091273502560665, 5.903571015645264, 5.5606267312590765, 5.367480646055837, 7.27108028836848, 5.5883743249038815, 5.97243273844276, 6.073290476460382, 5.968762451265524, 6.828418778589929, 7.099042296383634, 5.894400287800538, 2.129439157701068, 5.241260673661895, 6.2445161935146425, 3.855970136391198},
    {6.706286906578114, 5.179631541103214, 6.7230543465771175, 5.390110388095882, 5.9475207254006515, 6.088467933353529, 5.830791128253207, 5.643107299363446, 5.427038132569713, 6.675342591373886, 6.898228162571643, 5.815503191898424, 3.349239930812781, 5.257206232338078, 6.536391739425183, 4.807740033062871},
    {5.173464892085427, 4.0753778716405895, 6.627632311710154, 4.964416894136678, 7.263883798934979, 6.321478670444139, 5.559050786263206, 5.871818805538424, 6.965708332576215, 6.4567789399516675, 5.891264072785987, 5.6393193301224676, 1.883754032094504, 6.028159532124067, 7.377468757553505, 4.17687184582303},
    {5.452048041724713, 5.311558559520445, 7.399953542787339, 5.229352141275164, 6.677871302705437, 6.648184330355798, 5.633482378471122, 6.489726117191347, 5.445081073077897, 6.005161726502735, 6.9254976411728695, 6.105558997656316, 2.4036360488663586, 5.868997841240746, 6.699518253645671, 4.718533180699952},
    {5.344004584445535, 5.760744608461833, 7.065617037206229, 5.874756883775983, 6.799879990197676, 6.75785984572496, 6.062061028802231, 7.569394533745711, 5.942658234686229, 7.00549700476355, 5.676200566173065, 6.437810350159369, 3.5473446344005173, 7.298271486580213, 5.901769079256015, 4.974160759601188},
    {6.739412900303827, 5.690386693403712, 7.085727859840575, 5.381178394977634, 6.823341424486237, 6.927288721115146, 5.922984292686074, 7.411886602106213, 6.561395550865943, 5.839288697864282, 6.561179297689237, 6.745132422667995, 3.2892581727776187, 6.970143326862876, 7.309724663542185, 4.742492019460672},
    {6.357742149494882, 5.65343126249273, 7.015098288223412, 5.44234896309268, 6.161652695293176, 7.34192259365394, 6.357184557158279, 6.529939694788449, 6.638080764718686, 6.803831458278177, 6.054991561768562, 5.333315477625701, 3.10735786512613, 5.601325990699129, 5.8339931244174785, 5.229647619955158},
    {6.094912218857223, 6.017134471389549, 7.4609554407599985, 4.912957189341586, 6.751084186544581, 6.757556048845457, 6.932473403659559, 5.805445956918417, 6.210162937876697, 5.990716981994954, 6.438388396398359, 5.657143289879549, 3.3729921926394657, 6.51120438314745, 7.092641422135555, 4.10795670891109},
    {5.5616044715560005, 4.125051617895852, 5.821950422092577, 4.025605197669059, 7.13019699638913, 6.151642704336682, 6.022339059108515, 5.50362249674369, 6.629956784011994, 5.767471116429526, 6.366811665915117, 5.67488993409508, 3.076248957234635, 5.604463492012667, 5.463489958456985, 5.242507561857301},
    {6.814007821249659, 4.979945480838345, 7.610979900512591, 4.262382120359508, 5.839245215002751, 6.401995594345358, 5.464233190195774, 6.796475382810795, 5.807885472097191, 7.272778635294422, 6.094141878075235, 6.538545182915916, 2.8154182635819374, 5.510240537274213, 7.3846876153815115, 4.608978996876482},
    {5.487311692490582, 5.207680310488952, 6.932397271197346, 5.978405682202429, 6.589014472687452, 6.918202576084192, 5.828529038179372, 6.2603969493362435, 5.763859594550009, 5.835664964852405, 6.7088146586368005, 6.732676436212987, 3.272065810927795, 6.171161921409829, 7.476840220267901, 5.095409628256154},
    {6.584458472524682, 5.932982805179445, 6.245630633024512, 5.6041871673874954, 7.261111678822435, 7.146865456805953, 6.86864206454145, 7.256492198803338, 6.595959669195109, 7.373667053445287, 5.918192576006088, 6.385909127389354, 2.0353314035499768, 5.6723254183886285, 7.083856302257652, 4.108190042819525},
    {5.598794846654349, 5.055484209478811, 6.273022496858807, 5.683299237902643, 6.868188156071539, 6.74348240968429, 5.919620825724374, 7.134145011707318, 5.553714488416115, 6.064153723087647, 7.138165076728474, 6.9589965849297, 2.5681734392595374, 6.304439612568047, 6.374974389491391, 4.568808035232495},
    {6.022056704496182, 5.846096276249491, 7.309552299629104, 4.959995304522036, 6.184558391772633, 7.1963641489660715, 7.130210390151135, 6.938382621246394, 7.036264297638485, 6.157183078613516, 6.390687533793031, 5.841972578655875, 2.486622655138263, 6.605924226316934, 6.539217491796768, 4.339213333768722},
    {6.367406489395906, 6.08933262892973, 5.823748477707607, 5.673764334503984, 6.117024676687065, 6.635823020303129, 5.62482442321294, 6.598863414622022, 5.876384966077414, 6.713789761013214, 5.959014779602844, 6.377281735635004, 3.1830419321726686, 5.495627867972955, 7.641723249230751, 4.771558267202891},
    {6.083776187391551, 5.208610509998684, 5.859176766938846, 4.097560824886664, 6.933242151526773, 6.1623158798172994, 6.62187957359505, 5.802433409143626, 6.59647470177668, 6.98852748900121, 5.9191730451288285, 5.48334317104938, 2.5248877011278905, 6.6737594498812305, 6.078238718547512, 5.533851926702486},
    {6.286458739001329, 5.384453490317912, 5.62457453347471, 5.462277676581203, 5.979961184780535, 5.804726464371848, 6.546322764665324, 7.4065932120499225, 6.167510081244666, 7.316400097964968, 6.675078730824688, 5.59585025739179, 2.0727743182370997, 6.760336289320588, 5.59005430864872, 5.034762022014565},
    {6.801977485701861, 5.977988654799802, 7.57018231595494, 5.343068711951737, 6.513179594669961, 6.506337352117263, 6.117183313180084, 6.4558325525354805, 5.71451749991318, 7.071497383917543, 6.111982729874134, 6.175318437246613, 2.031751484498762, 6.475605310142245, 6.351341914199967, 5.597266193161771},
    {6.864265986662763, 4.831199319172004, 7.575413954211882, 6.087178732329604, 7.381160350598903, 6.548224850416323, 5.54444092282357, 7.634801169374448, 5.916464814065251, 7.6847902586685795, 7.5687468970938685, 5.867584731142566, 2.0084393030283336, 7.014236340385575, 7.692644740123477, 5.441820782971504}
};

static const float b2[16] = {6.701720398893464, 5.772456758404366, 7.030047484828024, 5.808806434517346, 6.9898085716863605, 6.9801565413121525, 6.523769871948765, 6.9361292929410014, 6.752768208910886, 7.064684810355311, 6.940582511587341, 6.64890533402614, 3.056576812246221, 6.835235540736548, 7.010664269933959, 5.377006965538647};

static const float w3[16][12] = {
    {-4.127513279629034, -4.790930041008679, -4.903534912394113, -4.531977254780053, -3.734921349149373, -3.966549923899566, -4.027544151102468, -5.584342569679585, -4.539929225771523, -4.323135451634465, -4.787050218572169, -3.707440636798927},
    {-3.7589279955563963, -3.198934737478141, -3.1667492077122166, -3.2755747591462723, -3.585914302103, -3.9139220800806376, -3.9250732925924994, -3.406544366177483, -4.1126744251900105, -3.223708166687616, -3.5762873929268646, -2.9319935184348576},
    {-4.73971082510413, -5.2922900060594165, -3.840192488149361, -5.044955071641432, -4.995197643237616, -4.038140476691578, -4.488685031474003, -5.521883370779798, -4.912057230978263, -4.833044521368048, -4.567430099372891, -3.9808991894928973},
    {-2.59144277138588, -3.513313645404527, -3.9111611621322657, -3.5147031632618564, -2.9729369495434588, -3.0697780889285355, -3.751177103771265, -3.522550183065003, -4.2540304320505395, -4.527297690692527, -4.0054657275861665, -3.341579138731403},
    {-3.864382520214382, -4.253347935655885, -3.8016815289180967, -5.4746548082097455, -4.109799907114848, -5.46276385922047, -4.197132283363831, -5.056561073240453, -4.748551551738893, -5.042020623899992, -4.6728356352251685, -4.427759843198238},
    {-4.780305597379133, -3.8430396774793927, -4.779126702981585, -5.125062895546338, -4.3050049644214585, -5.5474835557845, -5.224431919153069, -4.1799614216568886, -4.687443351264211, -3.43470724177191, -5.016877709410462, -4.628204359956682},
    {-4.9410124232111405, -4.983195087370528, -4.813449048678559, -3.728821403492728, -3.6391900329526043, -5.527783105094763, -3.9776699212871107, -4.79094162209438, -3.5737640100408425, -4.019650236100388, -4.109077166659209, -4.872690512507844},
    {-4.7670229567559605, -4.905210374400623, -4.92097141527389, -4.209862658410723, -4.48734584520065, -4.545750119697061, -4.409273881083014, -5.3560375401548495, -4.749615327478767, -3.549253186274813, -5.869607948897441, -5.5161846552619},
    {-5.000721495075947, -5.436090338121287, -3.7112598522887734, -4.249806996252666, -4.841003014869567, -3.596052987078343, -5.433976260500259, -3.5728138157030807, -4.994101605765535, -5.18146641821837, -3.876283182224377, -4.783715173586799},
    {-4.399306920363075, -4.900322707928505, -4.739707474887913, -4.481678603294208, -5.621930888513035, -4.536071831142702, -5.054269681249055, -3.6727153767656824, -3.795904540013009, -3.9155151776937838, -5.148513763564788, -4.290346237667222},
    {-5.014175472751844, -5.133766778914876, -5.035151116138466, -5.178860830138411, -5.334066757818562, -3.709574126552296, -4.553634634517659, -4.789083116336673, -4.420942155314498, -4.986296911809791, -3.826595906979489, -5.502435193773094},
    {-4.4608109449719375, -3.771571627445327, -5.07004456455882, -4.230997807123005, -5.539865361969092, -3.677883806338554, -4.694005015518028, -3.934834809148509, -4.359388656855995, -5.01466142039212, -4.399599518328682, -3.9562847734064808},
    {-2.19443004214661, -1.9754915075759454, -2.73244724900359, -2.3813706418829064, -1.5220414149766088, -2.8712796110639633, -1.9296914149707587, -2.9629511741711267, -2.0111443829115414, -1.5134682584972985, -1.0699875860943155, -2.049564814282682},
    {-4.89761341949255, -3.9794453998788915, -4.8299243907332805, -4.611545959271201, -4.323519582369442, -4.982094201153518, -4.703048356516624, -3.9885867357189237, -4.682757962989264, -4.63489930531027, -3.956722392418188, -3.7248822383018307},
    {-4.333379224903472, -4.188929483994985, -4.9158735076354985, -4.546068786387357, -4.632773945407131, -5.336175068145053, -4.1883108261337645, -4.184395691865591, -4.975097707581885, -5.400369280725922, -4.372407237848451, -5.644529112685508},
    {-3.6917583315756906, -3.163040909161008, -2.5352268740765798, -2.9105350765983196, -3.428433876507231, -3.056265221726181, -2.931243081615442, -3.477369366961846, -2.7587632340235984, -3.9622116716677445, -3.7835797570778777, -4.086367291901149}
};

static const float b3[12] = {-3.244081488878041, -3.1840729375495185, -3.2966597032416534, -2.9917677662117748, -2.988782293914196, -3.3791574342855992, -2.9864932113977383, -2.6474397072008946, -2.8539623015146973, -2.8381414553029813, -2.4767417932624105, -2.9888092254044403};

    // Input Layer 
    float z1[32];
    for (int i = 0; i < 32; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[16];
    for (int i = 0; i < 16; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 32; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Output Layer
    float z3[12];
    for (int k = 0; k < 12; k++)
    {
        z3[k] = b3[k];
        for (int j = 0; j < 16; j++)
        {
            z3[k] += z2[j] * w3[j][k];
        }
    }
    softmax(z3, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
