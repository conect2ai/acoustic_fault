#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][32] = {
    {-5.456653176389503, -5.8662728384586975, -6.091773106447188, -5.299971758641374, -5.511018137965872, -5.221959563242485, -5.363708901492583, -5.346343882170236, -5.101854964485408, -5.269240404447686, -5.721379351806328, 0.7832928182478879, -4.924674066206922, 1.3017583761657878, -5.556874060982388, -5.095806633987291, -5.2937766295237685, -4.621863770899857, -5.212912414579645, -5.336163179797572, -4.586549425116331, -5.6537525428897615, -5.498786750195156, -5.590281449533316, -5.623716228300584, -3.5262892572541724, -5.776729393910925, -3.5462775251962197, -5.77441211314577, -5.147464071147275, -5.580588331101257, -5.183702054404049},
    {2.6372289964753226, 2.3787916380493574, 2.6180986346954125, 4.04067417367843, 0.6814358057737152, -1.4192141149200104, 4.852717314801557, 3.478898130350754, 3.915450663434722, 4.232725489785809, 3.858878070023665, -4.26848733978293, 1.356635138946882, -5.217592122725687, -2.2162434533915403, 4.33502235020526, 3.4717254462237115, -1.6837447865590283, 4.233055360819232, -0.7763797506085284, -1.9339100896157593, 2.862525134213885, 0.6256848167407426, 1.408538965207123, 4.233051151784139, 3.545224237491361, 4.453626970460012, -3.6754045428718185, 4.264115583541549, 4.811525277282119, 4.478626411714288, -2.0593406357577613},
    {0.5016771326288929, 0.3322641366140965, -2.8071325294050222, -0.5924280561560886, 1.287280778766868, 2.31239494015425, -1.2264101276502628, 0.6828931805847652, 1.7369041763622077, 1.8682981024920111, 1.8989074097616958, 1.271284742551292, 4.207556426659207, -3.0292291616485283, 0.8570634233570915, 0.24713826604550468, 2.3903541981630005, 1.4012570125485433, 1.9733465455105503, 1.0408173930739033, 3.3324269179896846, 2.585881733760593, 0.9634912285517331, -0.8665909385450682, 0.9535904482556998, -1.6180972077361777, -0.5361280251817571, 2.0167722680305284, 1.1790953056783768, -4.325045178314926, 1.2530645738760493, -2.1536233690092677},
    {0.2298588953156586, 0.9901383126743862, -0.4909048084904527, -3.8447457568105614, 3.5613418390588927, 3.9648045888015706, -4.001819794684797, 0.1964859539229792, -3.234357149032625, -2.8353198893368057, -2.512879752016249, 4.4249693992122126, 0.9217364441570071, 2.9440411325241866, 3.330762241760083, -3.212760215683562, -1.529346406268752, 5.22598268263776, -1.9807410502448262, 3.642537944119451, 5.457728266026573, 0.7876458548297361, 2.6089602497285096, 2.160592662161244, -3.0298295345049175, -4.787906479377327, -4.089389563228835, 5.641850481868032, -1.6064404569228945, -5.701288698823283, -2.6519072333260447, 2.823857657744878},
    {3.258891911578262, 5.116164546508459, 3.097467132037952, 1.1709013271840407, 5.101822252606373, 6.036303375087376, 0.03495087282942207, 4.201197731897943, 0.7605187772991175, 2.7941753022987545, 2.578445797187709, 4.036521215340419, 4.641719551815928, 0.4631680274812683, 5.3612702350492105, 1.0957796275215237, 3.0439675289217285, 4.409088182733104, 2.490155709170837, 5.0621463888196505, 5.583949845313413, 5.190160511018035, 5.308609682249871, 4.111631361521132, 2.415186451741316, 0.0888391774935965, 2.1517057903062367, 4.875258371348874, 4.05017802041984, -2.1530597314455466, 1.5518211590383169, 3.639200288952757},
    {5.780911716159323, 5.44434169696528, 4.378364735645597, 4.3496286617604865, 6.478644970908976, 4.811511932607064, 2.7557437209261093, 4.468246026698746, 3.96565561620595, 4.053250905100055, 5.056253125675401, 3.0280050598589634, 5.866499709490512, 0.7914791261194805, 5.918979324525389, 3.5407429769117753, 5.200948333580646, 6.163883200302743, 4.7065934307130615, 6.276016323367017, 5.392465634346916, 5.211358173704734, 5.347415586213617, 3.3263871921988266, 4.850594289782423, 2.4245051389866226, 4.293082543808543, 6.599432957588879, 4.433514537929527, -0.5483313562840024, 4.581253091837123, 5.79993638125107},
    {4.676807153165832, 4.61813111726386, 3.6255523948221797, 3.4137676315915297, 6.125478537499803, 3.6232615731312596, 1.8066183772203723, 4.123537316400906, 3.2493239014955266, 3.2830484214519076, 4.761450046856391, 2.95912267860796, 5.157199894400773, 0.22096304003054706, 5.764224367434636, 2.8433743373133047, 4.572561803371051, 5.989396965122876, 4.032275293129557, 5.700573643902758, 4.6320972468585655, 4.857771556239533, 4.900473476998366, 2.725827377913859, 4.226423262997432, 0.8664532861787011, 3.0730811177051702, 6.237632291331619, 4.300913893289962, -1.0868135923186137, 3.7272611037946657, 5.421435299621798},
    {1.5943619568771177, 2.0897681650435564, 1.5504030327902487, 2.508793767544968, 2.1209949912615578, -0.22939501653628178, 1.565786667524034, 2.926425517351259, 2.9570327720544802, 2.9886891653123957, 3.0460103010565707, -1.065281310452713, 3.483326353968489, -4.064990465991933, 1.2948795805483473, 2.098957703161293, 2.788949836182944, 0.712625151211612, 2.5166581148507143, 0.9140380736245787, 0.6213731365765113, 3.185849667039264, 1.8751064874990993, 0.8059402817810031, 1.6785747982346715, 2.057157573433886, 2.6791140323841076, -0.16516732503835344, 3.2976414749154372, 0.36496565819581, 2.5909118299597544, 1.2927766900020121},
    {3.6165130776791306, 1.6981710762279645, -0.383653373281765, 2.641951625117628, 2.7978627998911727, -0.4249951029335379, 2.753750204147182, 3.203007557271878, 2.5947121044158017, 2.6517623621180655, 3.6537116666054343, -0.9724091920604528, 3.432370532609371, -2.4164123348006155, 2.275884813468859, 2.423087122417072, 3.8433002746428806, 2.2226832698313044, 3.8473376050770147, 3.0244178089815397, 2.5363184979541002, 3.526693474593043, 1.134518064759124, 0.7646831426661961, 2.763651185965288, 1.2504311320567094, 2.0573134467906655, 0.9294625876568585, 3.1091354497728223, -0.8860105803738594, 3.605250068351505, 0.9733765649384412},
    {2.1671821336028225, 2.286016901294872, 3.8594871960302126, 4.039043853657905, -0.2839236622592062, -0.19368072122768265, 4.268553272156309, 2.9988064961892325, 4.044510179765083, 3.826800217936904, 3.248732896674938, -2.4263836695911793, 1.3810253938547905, -1.3775708818873647, 1.7508367815661297, 4.259535045648077, 2.369385818891399, -1.1224408968780635, 2.9694670195093007, 0.00343296832592677, -1.651152307313121, 2.246502365068086, 1.6306142751612633, 2.681201006082612, 3.305694716615942, 5.276064919258274, 4.4944752374672285, -3.8481420646042555, 4.156860876466356, 5.2233779258010085, 3.4708874260188036, 2.2643225543799463},
    {2.028808689966105, 1.7386186314818268, 2.8950172975263277, 3.72847570942745, -0.4950177780259033, 1.0845184053184733, 2.538191457474467, 1.1944452345723329, 2.5656270003222477, 2.9672715655059725, 2.6503801488655396, -1.3713438305093586, 1.9433219183642938, -0.4336514791311609, 1.3825988960324964, 3.100025512029241, 2.1769150113669897, 0.02250144396889367, 2.667429908449469, 1.2371065325448742, -0.9864898323248965, 0.8419888561434131, 1.0580560780524721, 0.27204539120373034, 3.401610879649953, 3.477439843307316, 3.68672810774366, -1.5554641408402667, 2.855221572203679, 2.704578448712923, 2.519874592733684, 2.144041308258634},
    {-0.8388439736048551, -2.306809206204724, -1.3491616360756233, -1.5535579384235052, -0.44265352001511993, -1.2803611456679622, 0.333264255715081, -0.918878082884887, 0.7393585990427873, 0.061181921641387874, 0.24891079805166855, -0.7789373820137551, -0.6646100835693397, -0.8772859477621939, -0.7830859022426255, -0.020245290239579654, -0.6889121039292743, 0.2120309435316242, -0.7865002670738824, -1.8006765000078921, -0.02814828453769305, -2.2957113490589243, -2.126998316770209, 0.38841994676183383, -1.0632329337468223, -0.8164739079677056, -1.672493193096322, -2.0442231696537347, -1.5282000456544307, -0.30721502093913544, 0.7113923128930199, -1.0390253009766282},
    {1.5034013177427807, -1.2665354233057224, -0.9657138054337613, 4.8396041265052405, -1.9419169091917767, -3.3668438100627585, 4.847243640903311, 1.1292499091093697, 4.613418200871448, 3.820691538949405, 4.618725608605626, -5.182464329468583, 2.898958167636759, -4.732830035283691, -3.3681897642496192, 4.7689631164322694, 3.7836389447436773, -3.063996308191086, 3.6359148283392044, -2.9652064304329913, -4.124724511142725, 0.41411162899167253, -1.9130131270799453, -2.611756076173419, 4.229778559862427, 4.512011911247812, 4.57243022388362, -3.305131028603664, 3.1725942290616875, 4.960778276053733, 4.890340791302081, -2.584337661421871},
    {2.718785755186527, 0.33180964179988975, 0.21538373318011308, -0.9268966697502062, 3.620308447262916, -0.768757586354343, -0.6063278221404313, -0.29436086498548353, -0.21298411383164104, -1.67101515032713, -0.6565873708238396, -0.03235505115700445, -1.6152423937809317, 2.5374213479662773, 1.2999376542339203, -1.1852245545824744, 0.7147975939581415, 5.177303325755686, 1.0593562377813088, 4.304552309133963, 2.0396155327340986, -0.9052016782960015, 0.11577886387314931, 1.4626839743195028, 0.9841401213137092, -2.5858688218608212, -1.27836100079675, 4.603058956600871, -3.1465101155107282, -2.717961834322828, 0.1911457532597247, 2.9438014007850968},
    {-1.562691788675451, -3.827960579698077, -4.14379972356933, -4.121831157135284, 0.1535085091361914, -3.6817771135636717, -3.6967216675883527, -3.918272797527933, -4.118779933278511, -4.410771803278267, -4.0457845168493956, -1.5307908134448434, -3.2957295777765494, 1.9319755874350946, -2.4344074887662535, -4.363486308062876, -3.0680622218990243, 3.7066162308438657, -3.1001420925818244, 0.8263834253641069, -0.9109898164132496, -4.0850526958880025, -3.8985243851961755, -3.297962240265601, -3.1618515580084927, -5.0949937776301075, -4.780810916044182, 5.251716535559959, -5.253739579769746, -4.68981405885651, -3.685293659529121, -0.08213573855156146},
    {1.4567243022056215, -3.550463854092572, -3.795332374208085, 0.6902229007078581, -1.4845753328095486, -4.703146807259454, 1.7056560635626419, -2.8168412986022564, 0.5398169846297577, -1.0351954740072626, -0.17793644823940005, -5.0858958306349615, -2.0926052378420343, -2.026927000190383, -4.406926075790718, -0.16051727373494099, 0.8773318504171697, -0.7411426298549004, 1.4228553086477984, -0.7356588966021795, -4.239261004135646, -2.257794273019397, -3.618470915433781, -4.289224812269268, 1.3241358266093695, -1.3502295938960218, -0.5370230156914889, -0.1683852155942612, -2.804145750270332, 0.5028971557683535, 1.2721675250317257, -3.3154517014807423},
    {3.01768699162594, 0.6924858576587826, 1.7472182310343642, -0.13207125341861484, 4.936593010296755, -0.7103240492127907, 0.024052716750283403, 0.2984529934612115, -0.692808364009415, -1.4666233095807508, 0.3780012809088216, 1.3898570571701558, -0.4850469608876289, 3.685036181677869, 3.546297894140264, -0.5868269039777012, 0.6455085224143611, 6.099551888713782, 0.8378547303131666, 4.841943983309549, 2.801288100627459, -0.3910152557403742, 0.8415414717932606, 1.6320113338770412, 0.3422267334820932, -1.8602033666287683, -0.5777284356324586, 6.094863674440394, -1.1973481656369478, -1.9515851982517358, 0.967495158421761, 5.250299271315271},
    {2.845224347430047, 0.8936588269726162, 1.2296524760738976, 1.2114163895486987, 3.2563303918730457, -0.6791924875781851, 0.8036638262594369, -0.46279559867366665, 0.42150396241135357, -0.6703503915145483, 1.9170531465062974, 0.03825328310014816, 0.39023428026240686, 2.5687667519796693, 2.532101170089347, 0.6439296357026725, 1.5783584276263127, 5.000164222531847, 1.4418008047391342, 3.727123442789716, 0.9448669383690301, -0.9447972920538074, 0.5429030764818567, 0.6888561894002051, 1.9340558170441537, -0.8393665944116468, 0.7020065612001802, 4.435078605159013, -1.1671485480316115, -0.0009602829060593012, 1.1799446645747742, 3.6442546544298153},
    {0.2933827468556939, -0.5873582865864233, -1.2383567269527616, -1.57997524871314, 2.3410080556561743, -1.5251594896864333, -0.9136582121676771, -0.29744858055143103, -1.1328454916315611, -1.8312395026348618, 0.615162659853491, 0.6003299694330119, 0.6969723600196118, 0.8884364771612578, 0.703491444371209, -1.1716720695051954, 0.7754617516224284, 3.8301302729692006, -0.10597252500193903, 0.8097046677971057, 1.4430377533861196, -0.8427782892380241, 0.06736666627014531, -0.3467051296043809, -0.497711558848668, -2.697090325791804, -2.019255651064993, 4.309059018917456, -1.0996006694365903, -2.0792619367027663, 0.658771320320289, 2.02121360863153},
    {-1.0428733948232927, -0.6178114112562649, 0.4076903430399054, 0.27592635839942675, -0.6310483845736456, -0.6354755207041177, -0.8892019211320344, -0.317156101818774, 0.08599192317981315, 0.04554469734105299, -0.32001090777641333, 0.9947736178933891, -1.1318601363348546, 0.857733032075245, -1.1490148083740053, 0.7644614771310659, -0.10429877575074605, -0.17431077028364933, -0.7335113721206294, -1.425762853996523, 0.24520450443368663, -1.2526675891163732, -0.8658939315253205, -0.8634083106649437, 0.2701997668091672, -0.5899910723725077, 0.23126782957185565, -0.2928694304040536, 0.19889140980732808, -0.7501179505726904, -0.10892451379089188, 1.6012610637382012},
    {-2.9883391367178604, -1.9953309795199072, -1.8661970000551995, -3.807566195785353, -0.3501660471622222, -0.5288311461376277, -3.5767350645304687, -2.6693977880329505, -4.306624117314322, -4.316182939547688, -4.05138064877562, 1.7430404803329904, -3.76198089779781, 3.947186205829033, -0.5340415455431997, -3.3555894542525557, -3.6273523567532986, 2.9717401371453835, -3.682266020145197, 0.38096748317091106, 0.8996863243298144, -2.5949057115531775, -1.4300464783565066, -1.136133418077226, -3.554028307232376, -4.587740037501005, -4.001889101593493, 3.692102771625227, -3.2737578575519555, -3.388807908743619, -3.659463018374771, 0.35964587778461105},
    {-0.2655664476989997, 0.8818123410597882, 2.0950774162803136, -2.8836804830063243, 2.0585875367917787, 1.3732033818414038, -2.9776047007489908, -0.7047145513528049, -3.7649451611106115, -3.8289637704494535, -3.4531347356380118, 1.570434464693438, -4.4997455008180545, 3.6333861536813488, 1.445167030295307, -2.8967875615474563, -3.4012423268906486, 3.070530142537778, -2.763081170134796, 2.601977251178104, 1.1644337506743598, -1.9115991802352372, 0.4144794391738732, 1.7243247326241546, -2.4800179656240795, -3.91284256824523, -2.9109931992209357, 3.194182008979245, -3.4763747315476845, -2.2040733665709675, -3.423864710820703, 3.292194149568459},
    {-3.156221309238951, -1.5230361772121839, 0.29046923998791885, -3.8181436134356352, -0.260183389543451, -1.2140289127506732, -3.5155005988345946, -2.6181565270026748, -3.669430383051452, -4.042305517956878, -4.130225377665249, 0.2129277295326344, -4.280521049631584, 3.149516501214952, -1.678725545025969, -3.378043634969489, -3.9112750863021923, 1.5492539070185642, -3.6611185778405, -1.2758739755257469, -0.9513620386062052, -3.4332870212153552, -1.5155770873830905, 0.352683744670025, -3.2661764710319123, -4.342128483154391, -3.986049220995616, 1.823408214939205, -4.422962683054819, -3.0286149946010807, -3.873255203391277, -1.3350279663336342},
    {-1.7081010678803006, 3.15040949583138, 5.2850546835804675, -1.1877521025468376, 1.5262144735063594, 3.838723573743832, -1.6951870410638141, 2.0040013348400634, -2.343070698433157, -1.2878716788634628, -2.9665098384895248, 3.516361393436131, -3.3252909341640877, 3.544941737987683, 2.4260902390171535, -0.660631498868657, -3.1307549320579704, 0.8755293068423778, -2.728130150628442, 0.6264235932969514, 1.7270149679547195, 0.04292389148889008, 2.856577253724851, 4.423875455795979, -2.3898962911185464, -1.1865648380331406, -0.44626451190665317, -0.33570616945118853, -0.4605749107813874, 1.2548560311892685, -2.7514995718755832, 2.5436362409971043},
    {-1.5582226803905186, 1.9250465953862301, 3.3179085864123086, -2.814174752541575, 1.6542371272103054, 4.494497060208274, -3.45021561878922, 0.6039677078767945, -2.883985888571429, -2.0743548319258323, -2.633961750187499, 5.821926043949995, -2.09872254409213, 5.211902547602608, 4.6820958080779835, -2.803637618434719, -3.124002049925578, 3.009524413852185, -3.1638170047726533, 2.2772536654287356, 4.398727868607503, -0.34023014272817076, 3.4928623133714054, 3.981699132386295, -3.2948573025028915, -2.7984960972074635, -2.380297974107994, 2.3995041338676444, -2.002802383473336, -3.317094149053799, -3.80803426880926, 4.11032903345835},
    {-4.218784300296235, 1.0077362202581557, 3.0766589533150306, -3.4788104258746513, -0.8738602284035785, 3.355210611532437, -3.887711810896224, 0.09566376199939494, -3.646054383028357, -2.1536105790393285, -3.4594128808238, 5.801426920773819, -2.2081350047559787, 4.664453193053016, 4.0498345566272596, -3.039387220138995, -3.8132031004855325, 0.08488910840279769, -4.414427540816427, -1.231199477027737, 3.492431728337833, -1.3807722511715068, 1.7163574976477614, 4.175128926378379, -4.300212562045652, -2.2232574069894917, -2.9088853415554343, 0.059403742192972266, -1.0679613204589968, -1.482704492889462, -4.112384064543635, 2.955779372760859},
    {-4.146562684352146, -1.6986351240566648, 1.892982841373691, -4.5266856774533615, -2.0642768406784873, 1.566125053734856, -4.449009802027288, -2.393951061134399, -5.357745840876579, -4.564597554584561, -5.162538323112012, 3.480333372827722, -5.19161360648473, 4.950279749974652, 1.832305918335802, -4.245401870607524, -5.703564445681427, -0.08470462559740256, -5.46896588523311, -1.7922197934615447, 0.2957282359465138, -4.242178706097888, 0.04573564687931725, 2.5316497642551177, -5.233862570337169, -3.905063111071264, -4.233643674595772, -0.8879497027469299, -3.820576740339485, -1.452467193539997, -5.237525768388897, 2.484857456450983},
    {-1.8680837983036354, 1.867529679416237, 3.1277123355476473, -0.6932043511237833, 0.16244866452580206, 3.854905189281702, -1.432445192086409, 0.9531136291052044, -1.7118194357032985, -0.6532897792485344, -0.27603432313837256, 4.345981264535169, 0.8366250896014832, 2.5809966077297815, 3.519155528295647, -1.3014625137197522, -0.8708199417297949, -1.0119608391900432, -1.6459668646466015, -0.4996784574591018, 2.7389942660449704, 1.1792761876673485, 2.713305456193202, 2.9709871441381823, -0.6405800094785484, -0.9963785812110179, -0.36607214847737796, -0.672413813695089, 0.16718115898807942, -0.1746095680908223, -1.6431250001845938, 1.6352029369796626},
    {-1.8919017551932307, 1.7619636770595577, 4.2828239802408445, -4.336879200507621, 2.690490449922971, 3.5601268585929597, -4.176171913713156, -0.6479785567245189, -3.9646976628981863, -3.998700481214004, -3.280149581216882, 5.231832678771641, -2.8882327318763146, 5.016671777218595, 5.194074650851783, -3.838258169969658, -4.058831013692634, 4.29418915773591, -4.194039619712361, 2.202964857362108, 4.089909038163811, -1.8061699727225686, 3.053214668317428, 4.162890492927238, -4.056481587268556, -3.8398989069047427, -4.039596664672818, 3.4447801420418256, -2.9465645234813462, -3.37164424977907, -3.7152553595085407, 4.8370115589098495},
    {0.3504623958181185, 1.8245490268037488, 3.1761042447084216, -3.0822849551089995, 3.2516164499009266, 3.502991416104057, -2.951396380566016, -0.10071843426536098, -3.462761680679963, -3.041267028230055, -2.6187525917199355, 3.691104401380006, -1.442220331431066, 3.5508118912953117, 4.596300615625456, -2.9209166140055975, -2.301753156569531, 3.8966943835627537, -1.5035898222794586, 3.1779854929480202, 3.3590636803740272, -0.79101395369653, 2.314013675375587, 3.901634855600182, -2.259474531255917, -3.219512218419741, -3.027110354798439, 3.507481226517489, -2.38316165264198, -2.9102601033951343, -2.173403352352303, 3.0479308590484195},
    {-6.106686900866077, -5.854148435563835, -4.989882640704235, -5.942696325468625, -5.611111206477394, -4.501465676453371, -5.929018707838861, -5.794282847847161, -5.871905136059775, -5.440468914576691, -5.911717383110037, 2.448682855354654, -5.040726944626555, 2.4079388212407813, -3.3408541690265348, -6.154039221466643, -6.018927065164146, -4.530576622585195, -6.061906878730181, -5.534146639337103, -4.216039758032665, -5.703849113928185, -5.5144303984686225, -5.094132514485544, -6.177577664578342, 0.4319806578219297, -5.562149929921758, -3.14957052679795, -4.855357042937498, -5.703871023112388, -5.532613642415358, -2.1337677196626155},
    {-5.235784896513811, -5.420200653132918, -4.919085563537791, -5.001928859677641, -4.810407285831893, -3.0515572034954, -4.905398503313934, -5.340954287160787, -3.4513799201333786, -3.9377992652414977, -3.7352005804029895, 3.6354552206351842, -2.0416914448660783, 2.9967536263974055, -1.5575157550186356, -4.880321765759351, -4.397735708465637, -3.391809999442215, -4.765338939642895, -4.728523414247699, -1.7024446642562856, -4.8562381110949175, -5.044563638128622, -4.2482365467492365, -4.602462280646044, -0.283125140044455, -4.316245877846828, -2.5940496288867445, -4.391884139472167, -5.190676080592178, -3.7902800868036692, -0.8078704113333082},
    {-4.305831999795972, -4.385848691388214, -3.388023743913613, -3.2817577990782847, -4.716941254695169, -3.2348200064927735, -3.212507501006994, -4.055816817935984, 0.000505375461733636, -2.982507688000935, -1.2701136135852236, 2.4971655537475104, -1.6458792428113116, 2.2481837400632276, -0.9879425887727029, -2.9749879794101424, -3.135224408823058, -4.14632763933604, -3.089349349740268, -4.295533332921368, -2.1992496228726472, -4.185554832430779, -4.068927646498885, -3.0129591163269325, -2.963270961393229, 1.7047890290066479, -2.558882974229714, -1.4479425911644375, -2.494106290822903, -2.7241859511397033, -1.5670331977864567, -1.0630391115247733},
    {-3.8924987395630533, -3.874713492092011, -3.2213741042177015, -3.0484292845653203, -4.517825377689546, -3.2639942680785685, -3.037772483803254, -3.9844353687053227, -0.5261597923120768, -2.4582501343075847, -1.3126824429682413, 2.4303069320435076, -0.5231153029255893, 1.9063100666636554, -0.15313538651217784, -2.9103227140158276, -2.517456058332579, -3.381424857210307, -3.01494638992958, -3.4299693172817682, -2.499086778849493, -2.7081995604281963, -3.405844829660172, -1.1505882514094878, -2.8586190705825074, 1.6232964571998116, -1.959255030933867, -2.2760732671501693, -2.4826213060244675, -1.8895436136825339, -2.167745704486324, -2.0381619839670995},
    {-3.421184629796956, -1.0547000361371246, -2.1056354783115623, -2.253402129426177, -1.5156866585870192, -0.1419413001236902, -2.7827383498466305, -1.4511525679746653, -0.6670325075934833, -0.07614533824953165, -1.0700673998177845, 3.975237645357932, 1.7081420935956628, 3.4854837774299217, 1.834356775709428, -2.547600522863491, -1.597862481477333, -2.3251999928948863, -3.0472513816931284, -3.2795882359043036, -0.32082701589206386, -2.010370936975923, -1.8588668319805983, -1.8559564547231375, -2.873505450969599, 2.0131118162077013, -1.266969209943645, -0.3906271234605966, 0.47182014057866956, -1.1576259553104091, -0.9593256629186686, 0.5812949512031113},
    {-2.8281947814811605, -1.6532233464802422, -1.7213216037196482, -2.523479747960977, -2.606159047932806, 0.2535956097473808, -3.056648747281649, -2.430796233590889, -0.6643466617553943, -0.7050376451108258, -1.558271163341458, 2.753197306641141, -0.1650920019380426, 2.6185458065065776, -0.33965791239561244, -2.1083542471285543, -2.5774958702960205, -2.4057893721372765, -2.7070223986936957, -2.7625317391088204, -1.5375318316017543, -2.0886243459588045, -2.0265126256650032, 0.09654673934354693, -2.84539718650056, 1.6439710624775654, -1.334809518556577, -2.5979366689710255, -0.4982631553943827, -1.5002757344739952, -1.7503326864093531, 0.18202492336691384},
    {-2.2560069010358106, -1.4742508234027734, -1.7928452666169403, -2.6022147764594026, -1.2990203619700147, -0.9252404552211686, -2.029047085574536, -1.7685589906222174, 0.3843184074504172, -1.527656194571005, -0.022427259639648745, 2.5781547827977125, 0.4502933742825567, 2.418770043801075, 0.6818874650790498, -2.0924330873517047, -2.3450171665230592, -0.5013511743887522, -1.7841222953788327, -1.7197423439930892, -0.3279430053993767, -1.963298879185357, -1.4692212708503136, 0.7177987251505511, -2.104783934263946, 0.2024881847904418, -2.36988358635934, -0.4365749811095168, -0.7697129976450869, -1.1527613156434606, -1.3125754097156261, 0.12143517867749495},
    {-2.3494961295663166, -0.7616220230374287, -1.951926042059947, -3.3648217959058613, 0.7967096575560566, 0.2491362858319354, -3.061091594206942, -3.0528480830097573, -1.389777271819467, -3.390905474855451, -2.894114136661644, 3.108338996807324, -0.7774266877146232, 2.874282762525386, 1.6582650539436365, -3.576973730979548, -3.270987774241222, 0.5005723236922582, -2.986186459937177, 1.1936905684139476, 1.196970366465433, -2.2626110530939183, -0.5366357024565085, 1.7581752911421737, -3.3931341770535797, -2.6447257824736687, -2.7957658664322427, 1.860127921666707, -2.357392639411741, -2.717259550586855, -3.5842353531020215, 1.5992648611989135},
    {-1.8351998936736247, -1.7096473789102382, -2.691518906672416, -2.782651293638078, -1.0664437658061445, -2.174607913521383, -3.133494442335497, -1.9613267692217973, -1.8052584259251192, -2.2547013040373085, -2.2054161419395237, 2.8206422506836146, -0.3388545649535024, 2.7112679078689537, 0.4233614815263947, -3.3022465959807947, -1.6993947862377796, -0.31508027483969886, -2.8624443302740095, -0.7791835962829703, 1.2186099984292298, -1.8968164456791896, -2.71752023286268, -0.664673029166236, -3.2007538197546666, -0.9963203504528416, -3.0837701807600766, 1.3535392909821944, -1.7161197299595488, -2.956046160744562, -2.541778845313636, 0.24905099415295823},
    {-0.29954153008561424, -0.7260363556695728, -1.223707138550595, -1.1522867496310913, -1.9593938080442612, -1.7381770263216705, 0.23782418826935703, -0.2728600069642898, 0.8480213646864834, 0.18485401000159862, -0.6426541942636739, 0.6296428282564491, 1.2604103971017575, 1.071920943203392, 0.8701816795796196, -1.0231010092726658, -0.6178812603631049, -0.7118299342284701, -0.693626777987233, -0.8283763229613121, 0.11946001709709253, -1.692482161275708, -0.5854553107732805, -1.5619392577849722, -1.366901258976193, -0.30681329610441727, -0.8293991451763058, -1.2991020852466062, 0.43795666112222914, -0.5726904952401933, -0.5395323527594326, -0.20788098550549108},
    {-2.211116809827403, -2.832516486645041, -1.365074914201049, -0.6185323536100716, -2.3606301434303796, -1.1816890126579591, 0.23134996238644556, -1.673466422385604, 0.36148704933180204, -0.5426584099901504, -0.24816823747105238, 0.6776769823177954, -0.018214893674879794, 0.7607809589603692, 0.03689910383261036, -0.9415622672224014, -0.24194051550470166, -2.071783490403226, -1.0083448462313545, -1.5609553062003299, -1.6129930134361894, -0.8624352581193776, -0.4751607964721037, -0.7157532956788364, -1.0655661056476626, -0.20327860487778088, 0.06113318661103525, -2.292515937017039, -0.6124608342795829, 0.8801697586795701, -0.8703796817789038, -0.8664033850101714},
    {-1.0309863419830647, 0.06719181423981757, 1.0714025324457532, -0.7782848496210949, -1.6979779231343106, 0.5726084696055188, -0.444103319698389, 0.25992397384210464, 0.9429397939219987, -1.6629322236035258, -0.49297280096883017, 1.5619823386213032, -1.375227867145603, 1.637510567357992, 0.41673121742302216, 0.6671919005897622, -0.5028959160626987, -1.49199467219858, -0.5004740204569094, -0.25502905125832426, -2.0066576822824214, -1.035586825297488, 0.25635109841616394, 1.5635074798860473, -0.5404097679223984, 0.7989542442197011, 0.3724635325581767, -1.7522727402032265, -0.15651910303323455, 0.9154956255884221, -1.6505363819385201, -1.689065651476878},
    {1.1287138996945099, 1.3121664903498829, -0.10280680015790751, -2.778050498900323, 2.37161116042698, 0.956298579153029, -2.857448800815518, 0.33279597855477705, 0.1670956717929869, -1.505661510092315, -2.371675343225702, 2.121906053924507, -0.7731186978215444, 1.8001688073785322, 2.2024495649906113, -1.4830939472425446, -1.2415809047450088, 2.192437630608456, -0.8972986933238535, 2.620191941926821, 2.5107760827121894, -1.3341520076800646, 0.2819685063937871, 1.9610130249023106, -1.6377853691488147, -1.1642363195003336, -2.2431744286435107, 1.5120911776914994, -2.4822609210442645, -3.1802374182911968, -1.7800818659033497, 2.3282485300374547},
    {-0.7178766461148959, -0.3128616042594903, -0.43303239274541233, -1.0460381025612402, 0.23308620328093746, -1.0830798299468576, -0.405980260202041, -0.9308346156899557, -1.4781836736553498, -1.8568312552180484, -1.7082784965497944, 0.6632897352130256, -0.45359677716459795, 2.1944081422073993, 0.58968062724721, -1.2618631729390846, -1.829969277049177, -1.5707051909474476, -2.220772140311717, -0.8386191360626642, -0.49012448510120693, -0.8063991676761947, -1.0671961888371253, 1.3439775761819581, -1.8354687146530277, -1.2020805129985408, -1.9289861967015367, 0.01744783845657108, -0.9753840767634006, -1.0458118231646398, -1.5394522551284082, -1.87308523689195},
    {-1.094963776183227, 1.3572370083031198, 0.7322397905264112, -0.30396481092930266, 1.0791615962600565, -0.841061463206668, -0.4465495664219758, 0.788133287897843, 1.8392178694323706, -0.14316819849336765, -0.6408933679568983, 0.6002367732016594, 1.6277187392230512, 0.2540695605964298, -0.07443096761188142, 0.5100701996088863, 0.49294749535025206, 0.17483965298806606, -0.5966063609547191, 1.3291996233721552, -0.17041562809804675, -0.017550336550243333, 0.4279233181593144, 2.650508466190277, -0.7784899716371249, 0.7768938664747497, 0.3331958576201017, 0.28251390500348766, 1.386110469911728, -0.14189022444753563, -1.204691378309612, 0.5721187137641798},
    {-1.027983314724594, 1.0399995636240715, 1.2734060266729479, -1.177197917948724, 0.6429286294845296, 0.02829500186534021, -1.6610215996271191, -0.6783265107997892, -0.02099783495078889, -0.7017829823521889, -1.7120135844683415, 1.565871850579069, -0.2647194520214798, 1.399058960404083, 1.5481799760419859, -1.8798255257797385, -0.5762752141137997, -0.07342278696288823, -1.0755558211617104, 0.11684481100379672, 2.3310160820336905, -0.6660152781645076, 0.6483094212479799, 1.504514197119934, -2.213860780323646, -1.9030985353844632, -1.0545946123683438, -0.007721853877669544, -0.5261758704276331, -1.422303402613461, -2.055907293834905, 0.9717643884318253},
    {0.002699406520433445, -1.5093184648777782, -1.0175623859207268, 0.10164704555555232, 0.546165056059495, -0.07914122888724055, -0.6135418052377968, -1.953186246472462, 0.5786110527009086, 0.30149813322437413, -0.14846302808450693, 0.4905290228807377, -0.2524991746217676, -1.193281971637924, -1.4599309096319042, -0.7824941277400885, -0.553708526044085, -0.7980507270013699, -0.6891386735793045, 0.2729388757719301, 1.591183730760168, 0.2718591159926218, -0.010862355707091166, 0.7846056286338705, -0.6315092636102667, -1.0033684628577082, -0.18305615797052407, -0.6216567272223854, -0.4380095531672796, -0.7128975779514729, -0.6595220519858417, -1.253077712938043},
    {-1.060106747818202, -1.2127768007798032, -2.28613198065202, -1.1649843487940013, -1.3844838169260911, -0.9184282984847887, -1.0499668581463646, -0.43279733616387417, 1.0995572951878012, 0.12339294678696025, -0.5209266123415169, -0.6727164263521348, 0.7580143833566636, -1.5933661046803076, -0.4034007288127495, -0.6925396631003538, 0.6408722487226532, -0.977267072527772, -0.8744516775478339, -0.4406393252684123, 1.0040265458782858, -0.4520744469064062, -1.527047199406728, -0.25022426722274244, -0.6097078396232903, -1.1270522758803332, -0.6640840674943385, -1.3656604714061944, -0.904842604256898, -0.42696280107409457, -0.1342552538587979, -2.0234647935441386},
    {0.4301087931141789, -0.9640716379697796, -0.45632882075382103, 0.8973811435025125, -0.6650501712607028, -1.0918022041515778, 0.8578092036822969, -0.13039772310022674, 3.5200557762680496, 1.8193396033606517, 0.1698814603659344, -1.1602132010012125, 1.8680144320740526, -0.719062632708918, -2.3278332163454354, 0.7923928059196675, 0.8862705603439223, -1.5031179658692444, 1.7232443615958812, 0.12363824281079036, -1.254108696218039, -0.6761565828589131, -2.577555471735936, 1.21789207747201, 0.4022790301896968, 1.992724957742961, 1.4741585669170463, -0.01971359484703286, 0.6505470694998042, 0.30247106686642133, 1.1574631271692444, -1.539915403922842},
    {-0.6301338261647405, 0.04913732855545778, -2.0445969316373342, 1.091857993681869, -0.7149214877176907, -1.5455576194943295, 0.7819686321325434, -1.6386332119538833, 1.473293051654131, 0.12265646790566438, 0.058359736947410853, -0.8253166999335334, 0.9269146046617966, -1.6096741767417444, -2.833275992103897, 1.1265091909463858, 0.5778021547208124, -1.00477906572183, -0.38685015796817457, -1.5398396835121069, -0.4759155636990797, -0.46127895095953414, -0.16556529440481269, -0.5039586582583546, -0.20558766592146901, -0.725178633085413, -0.7469116990643332, -0.7882119226144302, -0.13403199608475466, -0.3445645395851354, -0.02113238132028206, -1.228501047351874},
    {0.6674389455657063, -0.6127773469117664, -2.140025624055464, -0.7460152560390275, 0.45298798616847774, -0.3572024582040472, 0.6682381899115161, 0.4401485584573471, 1.7006866421471738, 0.38132206442090744, 1.2599504827549146, 0.13805526120086292, 0.12318230273130733, -1.903175911187392, -0.802265480035095, 0.7262881079671405, 0.8096095519057518, -0.5530845844078076, 0.26901848409691126, -0.40126943317177677, 1.7598631052816407, 1.148870170554514, -0.98354905533191, 0.05087307600571426, 0.48797207402343157, -1.2863511576299353, 0.29648394843368847, -1.057892325868175, 0.8444639856868321, -1.6324966380650252, 0.9595008346191889, -3.215352222839296},
    {-0.6960568175401083, -0.7442377785277953, -1.1956419974327865, 1.0842234817785033, 0.7658169235895873, 0.28992407644706386, 0.8002781537986966, 0.5474053369674434, 1.541785904720764, -0.171123572395586, 1.2356275583123968, 1.0471431160882136, 0.37587393102200845, -1.6274202981381547, 0.13681125093588553, 1.0454743805249613, 1.178597408431531, -0.7790534899703092, 1.320115866869554, -0.3054442789935841, 1.6319252635407553, 0.426420949415534, 0.01972069453879859, -0.752539852657479, -0.025691267586276198, 1.6232129526932964, 1.3667915308803247, 0.2426877855458847, 1.3838884910363283, 0.07955114465333163, 1.313640397546122, -0.5436634826391235},
    {-1.2496559785817907, -0.8511761470901199, -1.6764018213319931, 0.28689437854240557, 0.18014138096968255, -0.2585743590567775, -0.9112552120242678, -2.1501265930698743, 1.0980088201339238, 0.43712747166815585, 0.4020795281611501, 1.386675003176572, 1.6995510016292128, 1.3966877501212365, 0.5305384762376529, -0.5747034523741562, 0.620623902269015, -1.0350357209588046, -1.111750483226725, 0.2889783645496024, -0.6621015067971077, -0.8694823795234136, -1.963368765789466, 0.39398665918988596, -0.13605377737106836, -0.12525566403555563, 1.0807080080298888, -0.7653612270686208, 0.039471169677743896, -1.0566603334309002, 0.19074599403735135, -0.41254955605078536},
    {-1.064666330593492, 0.26110786669228464, -1.190530279825767, 1.2292347907604562, 0.6960828701801849, -2.2939632973415764, 0.13246478516157895, -1.634709954274613, -0.12778093197637974, 0.9047746343221232, 1.1371461335082225, 0.13508480648200347, 0.8563559544259867, 0.06483284135292737, 1.8869287659937757, -0.8678450093238645, 1.2025029107720993, 1.2278853127736034, -0.6127229699271508, 0.9466909517644313, 0.37038861868347306, -0.3995235035011591, -1.186111471934484, 0.5337712989140704, 0.9886068036500132, -1.683027397954876, 0.7781635558025685, 0.38290936756595756, -0.7562751504039081, 0.29923598372898097, -0.42040893321543493, 1.334720088139485},
    {-0.7054483820220788, -0.540985153202873, -2.121890765695123, -1.8909840291957196, 0.3309491613354145, -1.209019681760308, -1.2690872169494969, -1.9849216035108435, -0.292912984470515, -1.4644197182584773, -0.9672904633444341, 0.44488809693827214, 0.7361836331838871, 0.9510153389315783, 0.7959848002460295, -1.9885468250623, 0.18066328032511622, 1.1059714341506004, -0.9455894164529022, 0.37470612591747526, 1.4421016502424095, -0.9700574332831559, -2.0330145206369923, -1.8820464729958202, -0.9292389093062113, -1.7320178956420669, -2.2623435383350974, 1.349646549391879, -1.942676660356813, -2.4355516649481324, -0.8972641848122326, 0.5283358813514137},
    {0.6550092694388212, 1.773744357285541, 2.0149219144221107, -0.6262637488612017, 0.8159667545031, 0.48387419059866926, -0.5579283846864967, 0.3581820753990952, -0.15775193248290117, -0.04905587285957975, 0.4587369485964976, 2.082660542176188, 1.496161052192806, 0.4742267538395314, 2.0775441440500524, -0.06791462630857782, 1.1820981926492855, 1.130954621570467, 0.2840229419493297, 1.1715294968918626, 1.8220953528809667, 0.2403225564600196, -0.2914321829169944, 2.665016345680385, 1.051111630489267, 0.7473405015847844, 0.8629817711881969, 0.8791126832452354, -0.03441129157296567, 0.14941451657260116, -0.7919251758137609, 1.4455291564185149},
    {0.8521535884013453, -0.6182759412045623, 0.735181837805259, -1.4800926079283805, -1.0566618883402938, -1.3997675220489507, 0.7113023611718268, -0.5848820255219485, 0.3793234707247072, -0.9199735353046098, -0.5713312013765358, 0.5667802860264286, -0.5356105412145256, 1.577345084733446, 0.8810813275173044, -0.7580848179952828, -1.2246796338336474, 1.4292840717653768, -1.0288272630610682, -0.5205895111976477, -1.0660118553414575, -0.5766455101778277, 0.32243489951822746, 1.0018278974426766, -1.2092646770632407, 0.04931363856871443, -1.5041820005340454, -0.35707771779786973, -1.5281212194365588, 0.5171233522067359, -0.3757279176062796, 2.479691538342738},
    {-0.4218387068226318, -1.0151837926318483, 0.4630566727935079, -0.9731895835420682, -1.0804185015158614, 0.8005568880984121, -0.34766985137251744, 0.15071409299052035, -0.023473255567521008, -0.3034677141742199, -0.7554954896795711, 0.9683544035157386, -1.0714333053308196, 0.8468580061491812, -0.19492684358494147, -1.9430081042361496, -1.2538568215243548, 1.230216708170451, -1.2436783968707406, -0.1158451538748349, 1.0693165182088822, -0.5842517442510631, -1.3051766519674373, 0.6802092424254866, -0.4570243341697077, -2.2490614667131097, -0.7284717914571742, 0.1139092362455789, -1.613880828989074, -0.3971333423408725, -0.9162357133444335, -0.4100719007466187},
    {0.00591721657472112, 0.8322742916910849, 0.7566170021997124, -2.1021711904205618, 1.0485717086503532, 1.6613561897662656, -2.385106379050483, -0.15033264117082404, -1.7322231000821402, -0.3203596148884888, -0.5669133997946186, 2.196777391932556, -0.2395546077138599, 2.2611649183904765, 1.046831218311733, -0.32095884529904667, -0.48248294274701115, 1.431106500701269, -1.8522868361612266, 1.7120449172482601, 2.3512180966265985, 0.18209356138643043, 0.7974907866794354, 1.8952148918203604, -1.534261237000971, -1.3732526973376877, -1.6362433127004519, 0.21747556022471773, -0.6738928933868809, -1.9755425585983941, -0.704412020131137, 0.3503454882898133},
    {1.0579452145571322, -0.4133527973031891, 1.158717488322721, -1.2063906053949884, 2.029440701548627, 0.46202750569647494, 0.13921339220438245, 0.8943867597041013, -1.084250716455149, -1.1813227291967436, -0.9677737464068633, 1.2362706052448755, -0.8736012531543206, 1.352605759686712, 1.5448789963263312, -0.014561997569055143, -0.37276493487124296, 1.6130039826415616, 1.1952012736330655, -0.2015005458432492, 1.566760484168934, -0.4668319009711284, 0.10177917520062443, 2.022459131576905, -0.3636114982934372, -1.4010720434208006, -0.6240392632688393, 1.3028049842803535, -1.0997761889705517, -2.1685625281422154, -0.1681148426023883, -0.6279782838825768},
    {1.1869818122346305, 0.4222853740572856, 0.9397938602432158, 0.4181976782843215, 0.9636688602089684, 1.4470967572244817, 0.43794462440334436, 0.7063873121642311, 0.5587956391660994, 1.4068506919933332, 1.1120967392783339, -0.6750900512958236, 0.7661509395161931, -1.088917395279137, 0.8580253030280359, 0.18151902483460444, 0.04569919188309857, 1.1257953421805573, 0.7671674574851252, 0.7246195758337342, -0.07678748015128214, 1.2299778014499538, 0.774694680704263, 0.5739133324414203, 0.6473894103693771, -0.594821088782565, 0.6883882609534482, 0.5862099613827177, 0.26852962094720867, -0.24767285189998542, 0.6849456728063182, 1.6268062477493994},
    {0.7825575503333222, 0.980738365298032, -0.34676579462275575, 0.2929029018447962, 0.2266175292309866, 0.4741626203329305, 0.30693839117513644, 0.616019989415681, -1.1111094492172053, -1.3705051659702934, 1.1636352031959565, 0.16542190071934054, -0.5849384093583916, 0.9630863201756084, 1.2524370315527953, -0.04889462359284037, 0.5844824129023102, 0.3936919421696211, -0.594694099407281, 0.4994969373752135, 0.9825115923941814, -0.090240244407214, 0.4959740657645588, 0.5527534817066547, 0.6744295204809235, -0.2787353925767844, 0.37306414678523053, 0.668139595753954, -0.18976340782287784, -0.306641182023251, 0.6444352157912964, -1.3240245973763154},
    {0.8132808299936501, 0.259788924455552, 0.77650221456857, -0.5851144984913688, -0.7832192959906855, -1.2677786685889292, 0.8454396932226197, 0.8654040926619769, 0.02820362435789689, -1.596482309259488, 0.4970174771624146, -1.052745110383205, -1.0850027955778465, -0.5543633916694727, 0.3502447461948546, 0.23384785235287534, 0.5155980512430007, -0.12288770769716201, 0.2512596377038892, -1.3871331265049376, -0.6044997820925696, -1.3671110716301191, -0.7796704027474198, -0.16741692641935185, 0.4885442975168074, 0.33356216837586494, 1.1086022694667983, -0.23538649524120428, 0.15678259790564902, 0.8612004399567581, 1.1363067777328455, 0.12011656678646696},
    {0.08463341548323065, 0.2515503142874981, -0.21074692545098644, -1.0410301912718842, 0.2978098104889114, 0.612378377601415, -1.0740966697864718, 0.2691944431264491, 0.46646866880308296, -1.1629715551586883, -0.18516136217827694, 0.6258916314950745, -0.16730087866080634, -0.1546791687135765, 0.00036363793824234703, -0.2196261576464878, -0.13228494667108914, -0.3491315944946464, 0.5862239390472277, -1.0493836710439302, 0.5700971030938868, -1.5557981371792975, -1.5592774844832267, -0.030081794227585452, -0.7199539837948316, -0.25917454973616455, -0.4730073396979382, 0.6912089318702109, -1.1209995704300797, -0.8246385488794614, 0.22143656591305286, -0.029624840239969554},
    {-0.9609932195481491, -0.6937182185823242, -0.9577645370748935, -0.1846972334939592, 0.19807175860416393, -0.268419579526671, 0.3045149447708366, 0.13163457314825855, -0.5893872326607084, 0.07749388492380946, -0.9344712416623028, 0.3524424579167558, 0.6445169364881824, -0.10075306665916925, -0.9320456198306689, -0.3324251853891169, 0.41209550928766975, -0.8775093061870418, -0.22694379375661147, -0.2904212715730644, 0.6077249816483676, -0.5514389738875299, -0.5175042941725052, -0.1919166618924006, -0.4334751996488595, -0.32687283083007196, -0.7516456935853337, -0.3493677079291986, -0.10777617487368615, -0.8365527061320096, -0.37147830920001684, -0.9953128602432791},
    {-1.0893742992076199, 0.3943040414626279, 0.9800206836946592, 0.6310998079764498, 0.5078206543888918, 0.7090176040699321, 0.01236165812731281, 0.6533642296732687, -1.1847838435494356, 0.93577313433626, -0.6854338733983919, 1.4494403795344288, -0.07863963526182159, 1.0944140076589466, 0.2337110327435699, 0.1039430976130685, 0.16587558794640742, 0.009064147952757288, -0.8592554939240256, 1.4025345222059546, 0.9791777409910095, 1.2829227350964791, 1.3861210775585875, 0.31610931838319656, -0.19366881184514975, 1.2192208216967604, -0.7775430327602811, 0.7478804157903062, 0.6811811975352368, -0.45456753206518147, -1.1495808831617966, -0.6959827120708241},
    {-1.035026241244344, -0.12982713029992188, -0.14863233162328107, 0.8545802004894996, -0.7313394099218258, 0.028199761788174772, 0.07912084668560102, -1.235311200988286, 0.7912842929593777, 0.9034948240069121, -0.48276624015029224, 1.1451836773031003, -0.34458777088172904, -0.27975353311801826, 0.2788547167512025, 0.11567643464861564, -0.17139791983049818, -0.8365100900226791, -0.7898659415524856, 0.4483559857833418, -0.9850994135866329, 0.12318931004754734, 1.1043146722805741, 0.12018165897618145, 0.339472646793628, 1.367567187425219, -0.7587449911894808, 0.013148383087057786, 0.32322600207783575, -0.05998785638945064, -0.9189582349202413, 0.09734836956356145},
    {-0.5923829911377979, -0.29683672919677306, -1.513631772969685, -0.7090971634557929, -0.7029416890860515, -0.9054051691777338, -0.9417812955869432, -1.5031571645192732, 0.38494606198441705, 1.4790314156694795, -1.6816113273857494, -0.4859819990463926, -0.28670573308755526, -0.793049947552724, -1.3638756655156357, -0.18481726033035872, 0.07367388523279736, -0.6929798000760309, -0.8646649122131355, -0.6693876598912265, -1.6478958607070648, -0.477355810583215, -1.1902469708233518, -1.3815317440215134, -0.9235688109927427, 0.405474332813194, -1.2813761480632795, -1.3685732625440017, 0.456000314441857, 0.39317197778567015, -0.883114329108844, 0.301851379597422},
    {0.22484803841404236, 0.5858963711775598, 0.18741958413393667, -0.504156159060565, 0.06775157523222348, -1.5133347409632847, -0.5777915885415308, -0.3330062730438395, -0.4849694256821349, 1.0503235752292581, -1.7793778914848632, -0.23006756887889526, 0.05156942060889518, 0.32826737353121116, -1.2064019479441324, -0.2052817705323742, -0.25758672189353005, -0.279018097831118, -0.2285778521225489, -0.6505985613844288, -0.7680555972385635, 0.18429522444819083, -1.0675273056966204, -0.028803436046571894, -1.0632049834555763, 0.2958023474523169, -1.3962862980299664, -0.0756963952102157, 0.6780048992822405, 0.5225282455772338, 0.04153187645091717, -0.5728825051994325},
    {0.9781330493077272, -0.21264563633202274, 0.10196309090048805, 0.8039528755043137, -0.7493797957010723, -1.3843792791021223, 0.5435856916988502, -0.8142074613289977, -0.23469998839805523, -0.11394346387320492, -0.13168372045713927, -0.018542718563643396, 0.3193071323853731, 0.7233380851069127, -0.10893473881340089, 0.6666776421883286, -0.4863099109311674, -0.3641971802511803, 0.3798892803777047, 0.4097692480845406, -0.5948800260945074, 0.9537886974125537, 0.5703331710717573, 0.48547221091602794, 0.5276155460512051, 0.44328888270735095, -0.44268131382677467, 0.4513845870127239, 0.08561593723046804, 1.1661132877925124, 0.21586986188563925, -1.0300683161295632},
    {0.45695581979315847, -1.1647018546188077, -0.8014231858597392, 0.5442247170623189, -1.0684729791862144, -0.4251344884827045, 0.40806723454498056, -0.6707452191218363, -0.4774575954415027, 0.673323829258555, -0.5756544575648277, 0.6299650056329782, 0.4807286980762245, 0.02437802523488725, 0.22840136124565047, 0.3211178485787438, 0.42974385464761927, -1.2197243159743802, 0.6701396029051055, -0.12088383899864705, 0.9251775177630487, 1.120304959784481, 0.7885815106347036, -0.3847913962378883, 0.5857015901987828, 1.0501896507093103, -0.7195281680342839, 0.49529531375159347, -0.688230224756759, 0.6824276379100849, -1.0926570345602873, -0.492027649305808},
    {-0.3249221149036608, -0.8704715974416299, -0.018332166704388603, 0.0342894216179762, -0.08092096709999407, 1.3015711162447698, 0.3220545481933622, -0.0066807571589427295, 0.1398716010735311, 0.3656601307207852, 0.6865195659942291, 0.11663141380064478, 1.150469065936122, -0.9461534487199267, 0.4629178831749196, 0.20476000597046987, 0.8178382149526335, -0.2112441632555782, 0.5541456286700075, -1.0059899229077862, 1.8686486633828223, -0.13737015949562692, 0.023998626614247832, -0.34276796472031523, -0.2913741424502709, 0.6396537276071986, 0.8577502153782921, 0.21520241738357127, 0.016452236112471704, 0.23371910585594155, 0.6281799941850017, -0.8915856597008353},
    {-0.0601390841153059, 0.5120517959224383, -0.522489774686499, -0.44209764798041423, 0.34524207751268654, 1.0210596480397365, 0.2061673167027097, 1.293959020331519, -0.18425776660526985, -0.8806154739435494, 0.698986817903098, 0.30392824056840373, -0.558528399375307, 0.8595926367688081, 0.2104595262153774, -0.6646316114659652, -0.6450705299809241, 0.37649307346173605, 0.2720736242188243, 0.004985829384866221, 1.0369247893197344, -0.3733300349205041, 0.3909181390802232, -0.49824199321250373, -0.7853756978400954, -0.7811628346875389, 0.4857396635287248, 0.18479841620795556, 0.43703565365937824, 7.961814675040249e-05, 0.35399550753195463, -0.9467282209718163},
    {0.9270978458432583, 1.4963027686982155, 0.29062532401088514, -0.2961856552840272, 0.7299550867270689, -0.11295791808607879, -0.47148110220137146, 0.0578996581600009, -1.0535660046342477, -0.7707570458696884, 0.6657957979019581, 0.0802328025651935, -0.39591940488490523, 1.2619846215468058, -0.5085432879838131, 0.021055399937685865, -0.10084448378729909, 0.41737194409736605, -0.35862525943314527, 0.34288803687301517, -0.8868547661328028, 0.18243962910092215, -0.029167782651690295, 0.5491624566970669, -0.18651299835454463, 0.21005713113328556, 0.23816543553670347, -0.6867397642309373, 0.9183679621997604, -0.018825472382560705, 1.0821557208477284, 0.6748970596155218},
    {0.1557017432508865, 0.5405203490829624, 0.4606964887093593, 0.28923505481562434, 0.6530244960592994, -0.19255092652376912, 0.8838901193779739, 1.2341229852735998, 0.8557684609449063, 0.5225037062493582, 0.28971244665231216, -1.0410332636030912, 0.2275924074095285, -0.710687936831425, -1.1827242611153412, 0.766766043895736, 0.4120260164940853, 1.0146806495245655, 1.113012697142077, 0.08000335339616355, -1.190659232643016, 0.5509430814394776, -0.18613898767003295, 0.966766593189511, 0.9871604446928337, 0.24223550688453227, 0.06807471598188726, -0.15358989257104996, 0.013932952248193731, -0.04939733644256813, 1.2310792454665975, 0.996293240604015},
    {-1.1601453921747389, 0.04073269931029545, -0.4482196242360373, 0.6064157942158664, -0.6235337309446647, -0.6426722519296076, 0.47073766539359124, 0.8298727148462834, 1.2183924845272758, -0.5220076254570252, -0.1410057154927697, -0.19919383230013596, 0.2303812378018197, 0.5512397975632896, 0.2276466673419955, 0.00776220758086695, 0.6531530873318596, -0.7542969088630354, -0.05626769297889304, 0.1570205869626999, -0.8037855310413888, 0.3193002883836649, -0.3597601128996358, -0.2947059115487557, 1.2482737766067153, 0.4478287771443737, 0.902551472610822, 0.6616842508763281, -0.5798301695366, 0.7893852130522554, -0.3180855701426959, -0.280477209717142},
    {-0.4327449655485035, 1.0968099946004728, 1.7710315786454698, 0.46352619571291864, 0.39143590061135586, -0.9041479938930413, 1.1790794042103823, 0.9663159360775232, 0.6849749978183697, -0.05587979126846434, -0.1393618673054084, 0.26005884250213646, 0.1639844753402447, -0.45241153783397037, 0.8456840488456254, 0.07465821001760402, -0.04226466376081341, 0.7535135031299519, 0.18596865210724248, 0.8801596670344533, 0.15499335507027345, 0.3301125210145842, -0.5118461385341585, 1.2407683593771264, 0.7102828128343163, -0.9319179322335767, 1.432420498414698, 0.30733464515046266, 0.3383846726729646, 1.1423708731164515, -0.9712314002740592, 0.5755612893161451},
    {-0.3273758449071802, 0.6153300442084426, -0.5020381799641578, -0.41846400270680834, -0.15218853051017064, 0.3565435047048979, 0.06759478849544868, 0.6505011152612193, 0.04234138192637127, -0.8173346799706016, 0.8547536097232978, 0.35105976193729427, 0.5898197059509573, 0.256938432948139, 1.0580080381926633, 0.051618391530280305, 0.7701468271084662, 1.818066707473941, -0.3596155970617942, 1.2945892407782447, 0.5452270593014867, -0.4293802915852796, 0.1253716997606356, 0.9444489270749953, 0.5094629979200644, -0.4278814738459936, 0.012421063533596274, -0.18467172572070017, 0.21809724809804237, -0.3699085840633946, -0.24808521889348978, 1.7024396960246135},
    {-0.05931985859068674, 0.49864038485803786, 0.0012953366319226746, -0.11575870068790088, -0.23047743710935595, 0.44763456052033124, 0.36822114757673785, 0.5535933744435505, 0.6316424861557034, 0.6177126968162595, 1.130862874605385, 0.1879568268894978, 1.4172970328436518, 0.4308708321875327, 0.32435183594201644, 0.7247593192252424, 0.6109794548859385, 1.6106743350545383, 0.6237509352215744, 0.9905461718823386, 0.7956572670658163, 0.3441329539362064, 1.0913536646959359, -0.25864347764192874, 0.31759672255129445, 0.47955371698669097, 0.593339281679075, 1.0012720325191822, 0.3769993668411107, -0.19565458845228487, 0.09089419040748375, 1.2422889861673254},
    {-0.2478985192055578, -0.3307003610782831, 0.44704365363852916, -0.6099121362305207, -0.6109978275616219, 1.153856883987895, -0.6248793555196178, 0.7631130534974551, -0.5589885643657585, 0.15726851153703755, -0.4648344209920668, 0.591733885249869, -0.41608759844848986, 0.7567956644288366, -0.4053901022536262, -0.5953703581386179, -0.9438572191645229, -0.5020187415286818, -0.6632640168259772, -0.45691771867242326, -1.3570061304861212, -1.0818034239055945, -0.7706601841060046, -0.08568007040257147, -0.9265177619591052, 0.053790989667074685, 0.2959182108757399, -0.159752682508238, -0.42301358832428104, 0.35972271042476944, 0.24351512668035138, 0.03927433155429202},
    {0.4018587797313296, -1.109697072818441, 0.6662608342042609, 0.7431683708182091, -0.6093129796229495, -0.5583462865025819, 0.11117800423399742, 0.3868658585548538, -0.18944541337462462, 0.8297384982866457, 0.3727701734794206, 0.5862972692932645, 0.37585460877130533, 0.023081037448593168, 0.1970612822138564, -0.004970858827926698, 0.22400261423227485, -1.6582141225877014, -0.2620074251795703, -1.1799985779582924, -1.5662278154916076, -0.11580578401746369, -1.091077437475517, -0.47629987666628343, 0.040125199411660074, 1.4999105698844228, 0.8216504456160977, -0.7216438220272609, -0.696164164112141, -0.1533870975461059, 0.27272177379643175, 0.583779576041462},
    {0.25730937968208156, -1.3117676192449537, -0.37186658681062995, 0.6937512788307167, -0.812985464888778, -0.11739520785953239, -0.3754627170629877, -1.4041924522174791, 0.5485042841192846, 0.21819775521142876, -0.0660069433350807, -0.9537863776226454, 0.44301315217877907, -2.0059272033180067, -0.9448152526013287, -0.17356018410440321, -0.3671471551595711, -1.5395734194318904, 0.707933942301194, -0.956285577320767, -0.922829305341189, -0.10391538623620172, -0.9549351550365583, -0.213128259777258, 0.23723483005171506, 0.9775196261440843, 0.6353669294728398, -0.3068363796388299, -0.3935197910257379, -0.35353996366284207, 0.6489553182433637, 0.37776655809919224},
    {0.6220578117300412, 0.8078009635543616, 0.4856507964246348, -0.13383433806133335, 1.091250010873112, 0.6337990406723757, -0.6896542477580326, -0.5190065073511216, -0.8028941798020092, 0.5303478012367435, 0.06506363683558891, 0.4003600048213313, -0.18016221602023436, 0.20540224896246304, 1.2319281690086556, 0.5660170851029248, -0.4024732240627742, 0.3586231526391262, 0.41193136804031233, 0.3643415082810874, 1.1233758385138521, -0.06141714833351747, 0.39056616824125046, 1.0186431089133263, -0.22083906682897175, 0.5407264522297904, -0.8975414843071009, 0.8477795872389696, -0.6558860534817543, -0.02144717818130968, 0.8312011859245948, 0.031276146476557624},
    {0.2586283584709795, -0.23598691569905775, 0.33469168119226583, 0.5472156379515427, 0.4017759327313821, 0.18465983201600397, -0.19261669971154377, 0.9056371919737886, -0.4004487511694883, -1.0451817331482907, 0.836257016969482, -0.13193562307108733, -1.669919757956456, -0.3688248850596584, -0.2575388954605719, 0.14415210219143154, -0.2325283447154815, 0.13391875871396663, 0.7396857009371876, -0.0004140195292164241, 1.0288551172020732, -0.4538788778986163, 0.3396184018222934, 0.3049831763727401, -0.9883783382945793, -0.3676844684660322, -0.08623714689760102, -0.013364429580022995, -0.2174313224142277, 0.4506313674569631, 0.579163314941382, -0.5174286051624611},
    {-0.22519783100063018, -0.8811369253540046, 0.35705187935296917, -0.5504770404943188, -0.4124461611455646, -0.78499483152036, -1.5585611802329982, -1.4456191042002875, -0.35801711049648804, -0.743699652332334, 0.47507238621746833, -0.0955791430002031, -0.3198949363199297, -0.8527248664228774, -1.1004295207304415, -0.8023964285206099, -0.5848012712179882, -0.7358678326664317, -0.6435245569198712, 0.2429687074354218, 0.6724566217251913, -0.012682066931376844, -1.1130255202930233, -0.520478996383582, -0.48132053510677847, -0.306408819412201, -0.34915096685391434, -0.4590143798535923, -0.023434716647021344, -0.6504629116878873, 0.08075986413840723, 0.5999001960465359},
    {-1.0090467829589078, 0.09040648400923873, 0.3650773854197942, 0.08184645121847284, -0.9738575987830422, -0.6315830544403548, 0.9299540467456868, -1.2883150117085291, 0.34783716227417755, 0.5435776867026005, -0.8831151217667587, -0.11438682959565706, 1.1653835138488482, 0.4693007531245368, 0.31153162247977345, -0.324460237058799, -0.561025328425532, -0.31430346677310256, -0.7074546550554447, -0.2635151037464391, -1.4403865685193546, -0.3942472422095761, 0.8474981144704072, -0.7556864960717065, 0.6036020631736094, 0.597395371473254, 0.7154447519844854, -0.7245675866329161, 0.43020508974629423, 0.5720958385205834, -0.8681057021439202, 0.9701815505232025},
    {-2.015502549369882, -1.560341623059495, -1.0267641335723228, -1.3328419886249006, -1.2094035163501449, -0.942280928689523, -0.5287527451774332, -1.6003398551661705, -0.18866327978286113, -0.08548006958238404, -0.7593943885443969, 0.7675824596483194, -0.4694670820051085, 0.9107666794670175, -1.7729324908582895, -0.9307575305498289, -0.91089119119488, -1.0146971024946951, -1.5684527972669144, -1.309758247072226, -1.6836920060852516, -1.3075892651493144, -1.4555017166775475, -1.4846408245988778, -0.7954006316817057, -0.9986777606536433, -0.5250149282100809, -1.0585691488213456, -1.47001977998272, -0.5528061729961086, -1.689744011856762, -0.8727028200115469},
    {0.32200495481785235, 0.21472835339437077, -0.15422425745544105, 0.5617990726811608, 0.26158295041527047, -0.5722136086170685, -0.5034863199770491, -0.3183939006180039, -0.00428121285339201, 0.5961828385819022, -0.2794430252854744, -0.2673113169513837, -0.5221895988119951, 0.3161701341074693, -0.9372001728486173, 0.6674515370712546, -0.3728509005100431, -0.8179663238765144, -0.838541901546037, -0.1716544423674048, 0.0024687917500563986, 0.2292583667244509, -0.29532907650861134, -0.8543758311307501, -0.5043672397723119, -0.34511871230423213, -0.6828615612602297, -0.6234973260396454, -0.2605102041591781, 0.3586448722995274, -0.5973083783737817, -0.16667380780813587},
    {0.5296423064734118, -0.15964619342742006, -0.34273665663971314, 0.2905829550506523, -0.07055142715025794, -0.3081125750492811, -0.36924997331227216, -0.22123739001773934, -0.19715956195348625, 0.04849388826746861, 0.19049377207909532, 0.15611557884796992, -1.130060614940082, 0.3336821509839914, 0.23407442350943816, 0.20420958471637135, -0.10773523054312822, -0.8306946826301221, -0.04746165789405078, -0.469558434479337, -0.7113421058305416, -0.4665616710382, 0.34440082289365787, 0.33799866965339154, 0.142199424227657, 0.4906268114178625, -0.001755470234970017, -0.0797943877514404, -0.5436635103160076, 0.796658920739975, 0.6935049558416462, 0.43670301657328464},
    {-0.10678622151616668, 0.2698816648196122, -0.45109813186559944, -0.9589182283345624, 0.187570466676918, -0.4256364377372307, 0.3824420300799118, -0.41834015465394414, -0.14734632204926995, -1.332991249549319, -0.6673513399191, 0.5140314803468096, -0.5287006337890547, -0.2986568184460452, 0.6435410778941673, -0.5708917791641165, -0.98481837363455, 1.0610970734139074, 0.0168388760120753, -0.49800401794589516, -0.024955515942701283, -1.064751152227231, -0.09253807543778404, 0.26091586604805006, -1.253009507101338, -0.9541013428741449, -1.2095846892668665, 1.4163640581094854, 0.1821899459970933, -0.19887440006656223, -0.9444808450024471, 0.4290123976310438},
    {-5.123532563051786, -4.678777933097103, -3.5897560982399823, -4.54586059823437, -4.676952409545757, -3.0971690999197805, -4.730037319480638, -4.279435131118856, -4.8132961805008945, -3.9066168107175936, -3.8967985679800283, 2.745244599450639, -3.823131967977507, 2.7735156661223077, -1.5741561099972685, -4.79155746009506, -4.66569818708938, -3.3707969626530003, -4.546071092543654, -4.72563133329514, -2.639942678022957, -4.740214411385603, -4.445862769193434, -3.6010994776663003, -4.697742272184264, 1.3063515447041316, -3.879862789274951, -2.7158151297223196, -2.5781619353460874, -3.45169806007256, -3.9295510849554005, -0.5812219282539269},
    {-4.637240459141801, -5.037195305323864, -3.902333144754485, -4.738620853419273, -4.311464819000123, -2.7439498518195977, -4.15615689126039, -4.180096487470695, -4.188104801084389, -3.501544563460929, -3.234715242651937, 3.463388636648188, -2.6997796563161294, 2.6553379754344344, -1.131966096125864, -4.602336835518336, -4.272419131389415, -2.5194729322077185, -4.226734807964612, -4.238308448502996, -1.587318277565246, -4.474577744775115, -5.001038789813507, -2.803830171267542, -4.56172083688459, 0.06590229686116365, -3.9541956868611563, -2.340731965292316, -3.1784902821207814, -3.5488625108966727, -3.1942226030372693, 0.3655557292620839},
    {-3.6424289920798634, -3.5776533585453922, -1.6094813562028405, -2.587262319705374, -3.7556120289311923, -2.5345130850910054, -2.7780965903434462, -3.0026514134778797, 0.14318267863358816, -1.9603277976429552, -0.8117417753898156, 2.308086116088742, -1.880097872183797, 2.101971783017839, -0.06533545129539815, -2.1274288900234364, -2.296052827109171, -3.3266598746418268, -2.0511576924666186, -3.3922060420616376, -1.3592503829527007, -3.47753295309462, -3.096775720573348, -2.035757187726942, -2.6451718502080053, 1.8012217464545712, -1.5440425638950785, -0.9919990375892782, -1.8295939125501273, -1.1798257988332048, -1.1069171690286814, 0.12118018772126914},
    {-2.481055305401781, -2.6672056371387964, -1.4161749130701808, -1.6039295299067293, -3.400404916474414, -1.8749280508049726, -1.396049746881982, -2.2379687894222546, 0.5872774724476999, -1.871347688012352, -0.21494563311499018, 2.2059771915023645, -0.37263239363016104, 1.8873683563834132, 0.21770241267735913, -1.7168187332479625, -2.2969057213714734, -2.1208047826124568, -1.7647852858849946, -2.792705154717521, -1.7276449076583749, -1.5637203286851438, -2.1586681139754065, 0.729589858962099, -1.2696346667470142, 1.4877361715891608, -1.1371604198775827, -1.9764853566835352, -0.9667217309029267, -0.5941641511085773, -1.5893267261330097, -0.7446669515772383},
    {-2.621177277985034, -1.4296275507257694, -1.6167406307213523, -1.8103880169387783, -1.0515049990950183, -0.588337010849, -2.1279153823641095, -1.0592441958623056, -0.26590741608664265, 0.3096044907872162, -0.5487273030035973, 3.1334742492014658, 1.35396754978828, 3.2614744485277343, 1.205853066696686, -2.505845631850215, -1.7576697613201235, -1.9772745808918066, -2.5501699364009, -2.7395196205062624, -0.3092676926657686, -2.225150980622745, -2.1032373663390627, -1.449660380159803, -2.4853891193237874, 1.8869408972995905, -0.6042799118147858, -0.3798284245350146, 0.1477811648379109, -0.4512997166944311, -0.37912473114471174, 0.7527417806343302},
    {-2.7814794340739235, -2.6446530113599946, -1.530343881589728, -2.2944745336963583, -2.22464092183793, -0.7652036022717882, -2.745091203271633, -2.739926979248518, -0.2959323922206191, -0.40504591847576366, -1.9012572887961667, 2.1604557117083694, 0.13218721087094612, 2.3356427172519014, -1.137975181748726, -2.1390920745754345, -2.6084513132643368, -2.2426663199729147, -2.3361507620928155, -2.5512056306047195, -2.562820503563996, -2.7264798905743453, -2.580184570765844, -0.07790831047091422, -2.6667704052538723, 1.825221087951747, -1.2545748042804175, -2.2237666289715734, -0.5514884278675604, -1.4483806164848592, -2.147183430210198, 0.24600565639877986},
    {-0.8736957874522076, -0.542350795052587, -1.5445020319166751, -2.3891541880975997, 0.42796242207409857, -1.4279031556027983, -2.0241025382824844, -0.9486867366361258, 0.24761507869836935, -1.3805089078409405, 0.14592926470735967, 1.758360100229698, 0.21207117500709777, 2.2193524241901694, 1.4967056322385075, -1.5169333672422256, -1.84198311894302, 0.35927627366080456, -1.1556585515080025, -0.858460665066922, 0.18533280668222696, -1.8291849209065734, -0.9286769917816937, 0.7262880339162268, -1.211132785976529, 0.09146903841256486, -2.056443879125346, 0.6999845108299542, -0.7245003002821617, -1.5324724430292238, -0.6505292531642408, 1.3254690421573305},
    {-2.347746817180018, -1.0976455063107569, -2.111845650296814, -2.5001926789019433, 0.07615446170557255, -0.8498922394557499, -2.6432512682640934, -2.771495369445364, -0.4732169368387924, -2.7035472860352883, -2.0312371011902233, 2.1331229584273297, -1.0782191432491364, 2.49048089461579, 1.1319835234989368, -2.7249336485797917, -2.629908882744274, 0.23631373215318022, -2.3154816498607063, 0.6066582317530154, -0.4035924503859842, -2.1166752277774235, -0.880117878722809, 1.2012436429132194, -2.9283437028025308, -2.4835707460167518, -2.265516776625279, 1.4046526191188082, -2.1405256294307717, -2.285997629238201, -3.251334123863513, 1.1353992731219944},
    {-1.5204122960791353, -1.6788590265366323, -2.7428099227985445, -2.6153374907790488, -0.9680086301051084, -2.611002319407157, -2.0041455677198776, -1.9860496018387912, -1.7460212655840062, -2.18318730101498, -1.7845540277907581, 2.73915840137755, -0.26495117523945666, 2.2417237456226564, -0.00043881046327107513, -3.0463593735756773, -1.376109329341931, -0.1444141607875251, -1.9967804806605371, -0.3525432245822884, 1.1003239466963093, -1.6038243862221901, -2.8866997150584934, -0.3010220982774466, -3.3044689080216263, -0.7223686238366532, -2.8171557535582856, 1.5757788552657326, -0.9065274670173776, -2.803656957998266, -2.465792071181556, 0.19819811030387688},
    {0.02783933323351666, -0.5103699086619609, -1.3531005598161387, -0.13714218527450506, -1.7738353155983535, -1.8556321944650294, 1.3577517821930312, -0.5982455740208434, 0.8235984800824437, 0.24171755578358378, 0.2211207808811039, -0.7682746528338743, 1.369651998048165, 0.5575539784535879, 0.43127748760936113, -0.39835687357633986, -0.484195952196093, -1.4169858273754923, 0.548049961757422, -1.0402614563595618, -0.7918530485355378, -1.081955739833615, -0.38509826044388573, -1.3293338137257655, -0.09495016080236968, 0.13683016034996326, 0.09877890542895171, -1.7797185434572067, 0.21248009119745592, -0.28928350497576855, 0.09751683527929282, -0.4692449608889378},
    {-1.9630318054147526, -2.2920114587206766, -1.1944671224717327, -1.1079126356641693, -2.4459472069738126, -0.9866515180473299, -0.17256724137386417, -0.7720584039715012, -0.3717312381819684, -0.15601639057436345, -0.34133548551388654, 0.9978301540233847, 0.29736217231050016, 0.5093204600458681, -0.3634775500883704, -0.9756025625816107, -0.25258395865340605, -1.2973116132147928, -1.2751963493266762, -0.9653249145181281, -0.8963106580432324, -0.5780661265392356, -0.057308248532957906, -0.17375374181670264, -1.838785585058998, -0.04953351324170943, 0.41505396667652183, -1.6385478242855696, 0.2585938913949077, 0.881505919515993, -1.5303060542070772, 0.6928269005806108},
    {-0.9337031237222669, 0.5755656506718921, 1.0882344401651018, -0.604159659812499, -1.2371621326653146, 0.851966135819292, -0.6644774685493178, -0.19690817401669197, 0.03873691908346184, -1.1495045190874051, 0.20002795858434377, 1.9376287799571952, -1.358549266850686, 1.9847207119674697, 0.8629411250942222, 0.6677848002680116, 0.09758675779051722, -0.31300522677901, -0.0861699356799004, 0.22301636138547026, -1.8111464814331462, -0.017396479959064046, 0.7182571121922502, 2.073083444683497, -0.3587521428443583, 1.4641614501969267, 0.03844126403073176, -1.3283382033315714, 0.6792545907430716, 0.8928238328813476, -1.2057425655480438, -0.6989433651681309},
    {0.6632833870126645, -0.2645496747171919, -0.9506221976892972, -2.5700354724922794, 0.48219069154197475, -0.10647545859246198, -2.656819983862753, -0.8123640831455468, -0.0671047616195676, -1.379124654315395, -1.9480804393068325, 1.593816876560003, -0.9216703786008495, 1.7900592865123361, 1.2011927916116973, -1.9461496519394152, -1.9459228516193077, 0.40262850261699595, -0.9028655586996929, 1.0424914423273708, 1.522490915195945, -1.930010399656833, -0.8221121141259677, 1.0339941783391198, -2.324167344397836, -0.3314850521345529, -1.7470848961933487, 0.6056506994530081, -2.403012540256331, -1.7682474408346107, -1.8006498161185196, 1.1215402932391356},
    {-0.4860202615239626, -0.9433979504603065, -0.6522242559620431, -0.5540977687177746, -0.10011557919445603, -1.5711254362193288, -0.11482335996477601, -0.4251610645379469, -1.6686161975585376, -1.6615443618171384, -1.8797111611001232, 0.5297314798614912, -1.1823000485238468, 1.6119820598139507, -0.7383234163498192, -0.9324186349216942, -1.6578982437591328, -1.6122572316993924, -1.8482042301671597, -1.2075071265383635, -0.34369512244062655, -0.6169132341230811, -1.2394077924529916, 0.6839050244150247, -1.5158594438426019, -1.3870300807528166, -2.245277400540899, -0.09157693107139897, -0.6225643696255948, -0.7800678937950022, -1.5500088827345166, -2.3569475950182546},
    {-1.1263597499738278, 0.761569872567312, 0.8790725830305784, -0.16166044183346537, 0.7787992674792542, -1.7253465123451035, -0.5650438039462261, 0.5993268383983148, 0.9125476707500427, -0.5248294715451814, -1.023088791879772, -0.6312329997992929, 0.21341388152602858, 0.5834361670890705, -1.6627904530738677, 0.23429815056051023, 0.031737887011076577, -0.17709202653592265, -1.0451881999816504, 0.9605706533378137, -1.7598259143341048, -0.7039632825360636, -0.4346993528738025, 1.5659937202010876, -1.2357660193369715, 0.6646748429278927, -0.355356513884298, -0.9275520634556579, 0.5231160001945577, 1.0383489298553392, -1.2216809697797621, 0.22308428882527687},
    {-0.7411105967292241, 0.06682704944535475, 0.30643969884929034, -0.7252948783257899, -0.004559061670788063, -1.636558389284249, -1.4269298965959774, -0.52540441620304, -0.5871057599154026, -1.352961047549365, -1.7942564595706156, 0.004715522782614151, -1.1263423786925917, 1.0466015552970354, -0.11806603108191599, -1.2811881308639217, -0.9409851451618694, -0.4953232584812603, -1.3893984379595685, 0.00019198120159496823, 0.8242553920769478, -1.1304090236068431, -0.019651938013450495, 0.33869744704845467, -1.8296501598178725, -2.334089680388469, -1.1047895894258333, -0.11510679602977997, -0.4886797041180657, -1.166117945734411, -1.359822991787685, 0.22481916743854896},
    {-1.0481114177380484, -1.399450835029639, -0.4162160394267729, 0.3627856570317905, -0.2067229224549068, -0.0168333801732955, -0.40606505771388207, -2.205360050512652, 0.049329938691187375, 0.26134120559751606, -0.42965223464300933, 0.3460077855353954, -0.6075043863329648, -0.7631692407165731, -1.4366897892584987, -0.39768435097931737, -1.3099770846662881, -1.681965111615212, -0.8712985132391711, -0.6213195942890921, 0.4062607782054983, -0.5170870821976868, -0.7515275327289646, 0.5389279135927707, -0.7561662742190544, -0.0760768300072478, -0.42291253092402104, -1.029742377977829, 0.14291826485592227, 0.04749240557971764, -0.6948683189956525, -0.8455002830510219},
    {-1.0785033386212621, -1.6024123979682843, -2.3417574820152014, -1.1232118610238464, -1.3866719540157033, -1.4590484217606794, -0.49334304091585496, -0.1571200072145091, -0.10376354691643422, -0.8376416095244982, -0.6064816108468647, -0.48689058932855783, -0.7167214990007246, -0.6033367855210788, -0.193892006316034, -1.243098747476892, -0.25047854179864615, -0.8666449247582022, -0.8087601061069412, -0.7965179384546625, 0.66237450791918, -0.8161718247259983, -1.504479833147763, -0.17465396581665535, -0.9085184052954328, -1.4540543230135439, -0.6304891398130805, -1.4638905675912766, -1.0880592715181987, -0.031074783206061232, -1.2015605384977166, -1.1204925938138313},
    {-0.47668236197727154, -0.7842878320264304, -0.40545798799901694, 0.08925392137465572, -1.090281751185036, -1.288514192173275, 0.3541135240843168, -0.44884419115033686, 1.8829787886432907, 1.1465647132423031, -0.5028400910595917, -0.9598793165382172, 0.6627223158584234, 0.24303936160277562, -1.932517719411875, 0.09696681717074274, -0.1317507776913358, -1.5194733264522367, 0.8528772870850814, 0.27469728963618145, -1.2238450060422512, -0.5839745385152627, -1.7475915375295663, 1.243585232320024, -0.5193690029748995, 1.791050047364328, 0.5221361205273851, -0.551215489624647, 1.21156639347466, -0.09608727675690373, 0.26605072010052705, -0.8312612035202738},
    {-1.2524381863196565, 0.10479883277428673, -0.8082670510925027, 0.9337849091130584, -1.3240225820913223, -1.2548801664940734, 0.7517966730944496, -1.3579333071197668, 0.8297380646360148, -0.1660779377649435, -0.4773534459961522, -0.5350453629652822, 0.5841909290296405, -0.6005939230590787, -1.8772226704115904, 0.46538169900434234, -0.455320943334922, -1.5704867137705047, -0.9833394329339941, -2.284847147326432, -0.2303505474705289, -0.6530909226017286, 0.2171275160583008, -0.09504577374876347, -0.9731459201795558, -0.4757134518994536, 0.1681317903563904, -1.4356450157505023, -0.2734107543207386, 0.47519996160446604, -0.07754451921868197, 0.12180872600303468},
    {0.47874661328350315, -0.26388956602559116, -0.6903177335455771, -0.770093761457678, -0.15303069543656606, -0.4409714778094544, 0.7268878153750102, 0.731712415415638, 1.705453746135974, 0.06775794305363414, 1.3189438527340154, -0.05158821278586458, -0.03870363173570915, -1.4160140300221222, -0.9441439132708738, 0.772969473670738, 0.691400900977834, -1.0262789736638687, -0.25426437130391033, -1.1697378519300858, 1.7728740209798777, 1.2110214939426198, -0.5557116695000252, 1.228524374202968, 0.14480394715711514, -0.664441194594473, 0.39965301155881877, -1.631237444906726, 1.268324128472609, 0.1487021569677962, 1.323719782374661, -2.2320674409622874},
    {-0.8940062869019246, -0.581508733131218, -0.08762333756631725, 1.0955012215810331, 0.29615487967557813, -0.14442149152553752, 1.4295930887596286, 1.4623189262181155, 1.8892355725539984, -0.09934404250214657, 1.4875034861687664, 1.453430908740763, 0.32996108341617736, -0.400503917231951, 0.4501042517617519, 1.4541998347826803, 0.6300234914622113, -1.0210676145889006, 1.056380708474285, -0.9814510707444019, 1.4939153598266528, 0.2598858282390652, 0.3379974649084836, -0.25709708365635214, -0.6343264065891164, 1.8483747672596025, 0.8213601318552783, 0.22111027945731185, 2.1893717112103044, 0.8942570873822436, 1.0592402423118394, 0.20242350329517503},
    {-1.698698550465929, -0.013423383841396826, -1.0946413290006656, 0.3625405617054928, 0.3551171364105371, 0.030782043277668772, -0.7994822935684107, -1.5409084544709126, 1.0976790013903754, 0.5736028689128936, 0.23180375417860385, 0.9956385946863601, 1.1214902514195835, 1.086786760482833, -0.04592885251770542, 0.5353768982473974, 0.47613262768702697, -1.2272681682440114, -0.9573439587446338, 0.4424617330375328, 0.057703671215461085, -0.5463960955633645, -1.4254677377112301, 0.25546101705685137, 0.2718635452848964, -0.28531885998536854, 1.142582460089551, -0.8750778471815531, 0.3300559163893482, -0.29066255650913425, 0.28965844816988845, -0.9094663116301258},
    {-1.892207605765493, 0.5532469337226491, -1.5938548511203774, 1.285577048173473, -0.5617450367786041, -2.207768096507909, -0.25918392207607865, -1.1855571056371512, -0.09990855491597313, 1.1908650920910278, 0.7401919356503668, 0.09234036459982367, 0.6670071062512588, -0.052995599388494984, 1.5985871373307443, -0.3729227078268663, 0.7296965231378769, -0.6184268945695298, -0.7998628154650786, 0.17021588395203463, 0.08053170415643732, 0.1354837010551611, -1.0571516536957672, 0.299565957934922, 0.36796991748201124, -1.2958229771612568, 0.974631698858873, 0.4238238839475587, 0.25241148775890704, 0.5785022790020561, -0.46820849576658813, 0.051896283746421995},
    {-0.4694721549278158, 0.22778516361985576, -1.0746327639185778, -1.0163469404586223, 0.0681767015982659, -1.5669293450925965, -1.5883479563090281, -1.853625137023038, -0.44451357655591495, -1.8314008877039851, -1.2581011028455555, 0.8717761525608484, 0.18151621053978806, 1.6989537777389543, 1.1194110100805723, -1.2275871958812357, -0.30070260283974126, 0.21072355197898168, -1.2370970468905917, -0.1811426568431713, 0.6850795956845004, -1.3131547727510484, -1.8902390897765782, -1.325720300206792, -0.9859350095859399, -1.3347497265242192, -0.9793637398600811, 0.4563466867702826, -1.464303312527064, -1.2473619212516704, -1.3065131119042936, 1.522892035260088},
    {0.11384989625322914, 1.3538373305747287, 1.2797346629812212, -0.9373885240079657, -0.31637430370500363, 0.3835052639907662, -1.2701516884665822, 0.4302282691037495, -0.686913280204154, 0.2602306670767557, -0.8689827062125457, 1.8916742401452002, 0.9672649572661405, 0.7890652644977678, 1.3273419728519467, -0.6074560588105783, 0.4973797731940743, 0.5369594577935304, -1.187040438990674, 0.422353883036057, 0.9600774230842879, -0.05790200393091199, -0.1555944414275158, 1.8573827140712924, 0.14799706330792387, 0.6570104171855061, 0.22416166999191312, 0.18573080706731748, -0.34374531063735814, 0.7150807363731426, -1.646121177482424, 1.273129607713237},
    {0.2215691493161067, -1.6893764420151929, -0.6495831311322546, -1.5523811255092426, -2.6339025497077766, -2.5884009112328727, 0.07093546926797085, -1.0627059080639445, -0.2873853940514542, -1.5615615885962886, -1.1915586594706384, -0.20168280292285595, -1.456610266680617, 1.2206925178965942, -1.0960639106273007, -0.7856313094362379, -1.6597930155635532, -0.24187782226418794, -1.5332286627071765, -1.8545502718585818, -2.169582126548059, -1.2001344098376239, -0.7600466624038388, 0.10397166315809252, -1.220290830466203, 0.2378256705624782, -1.3583726309232511, -2.2477935907397084, -2.3037527545012324, 0.6336452066374101, -0.8907507691089106, 1.480373878184392},
    {-1.1153646377043087, -1.0356651391578495, 0.7092278073510893, -0.9685430434091973, -1.3940968840748391, 0.6299945850252343, 0.11783187500042848, 1.0737027624106716, 0.3181372630457961, -0.3881735293057037, -0.18969143228099739, 0.319946953009001, -1.0310240670850717, 0.4426741637833819, -0.11085843210671203, -1.588568532812831, -1.0340118697279614, 0.5436860879187206, -0.2588672947544927, -0.3976093504088991, 0.7693962272932958, -0.29804512305012226, -0.9741467732945263, 1.1245372803746734, -0.3123716484171415, -1.5283991827115933, -0.022700375815415452, -0.5691241140721033, -1.001646119466022, -0.3258198274697086, -0.3048787653730797, -0.442996329959299},
    {0.2923921158747028, 0.32765342987456914, -0.13864644139378643, -1.762836523048621, 0.3772595171285389, 1.2184688517259885, -2.333545635988329, -0.6748882777759828, -1.3301277215418335, -0.013404835391073745, -0.48683569147145084, 1.1165118715741085, -0.4589048430674129, 1.842252505625253, 0.40403763686364436, -0.13788535787545048, -1.2604688519342697, 0.8676633043543608, -1.6057565130118177, 0.9192020761700792, 0.8769663790416592, -0.12369147979122905, -0.14689470285933406, 1.3564589756978052, -1.2619651597622914, -1.1515804239519003, -1.3195363026818578, -0.44257717121641355, -1.004500570198342, -1.0678305168088225, -0.18145226968683725, 0.32536048603654755},
    {-0.11926352448578194, -0.8256543572521042, 0.494131748050778, -0.6811513900935369, 1.0666913445037283, -1.3280751629430276, 0.20197733871089585, 0.7880951987141102, -0.9749538941955991, -1.0538172819328038, -1.2555890667167773, -0.07226516290164921, -1.3358398723109064, 0.4113133108547522, 0.5788417161212951, -0.0715298055418722, -0.7676942270691346, 0.052511293824370024, 1.3148389615360176, -1.1935499047573679, -0.4133468159140741, -1.2332717784081886, -1.6403922364773098, 1.343637622181108, -0.9172711282509735, -0.5908094555873692, -0.7002649493958659, 0.09586000550364936, -0.8882921366601019, -1.565874294412592, -1.0800096774589167, -1.414722102004941}
};

static const float b1[32] = {7.7289902099929355, 7.666173566970618, 7.84385866347142, 7.595325597010467, 7.879923507666017, 7.782691182829564, 7.4084189996321355, 7.608175709935888, 7.704130271879966, 7.4978369627273755, 7.705681211159055, 7.989090643125805, 7.898700584351762, 7.98395166674154, 8.014231477985307, 7.325226368139421, 7.561063092223403, 7.85706343188036, 7.514537651580011, 7.723034963360965, 8.056418686381308, 7.624249156359681, 7.805939632315462, 7.9917032861957855, 7.645885295293404, 7.7049253833321005, 7.596467697730116, 7.806452178152003, 7.607179232460915, 7.469109030188176, 7.621379526001338, 8.021660337972568};

static const float w2[32][16] = {
    {6.738545833944593, 6.729463422843951, 6.541885675165021, 7.0812332373208235, 6.635734789154677, 6.644145356514865, 7.107727694030051, 6.954989635216561, 6.793135126345555, 7.021430646075373, 6.768502755306884, 5.665498461328328, 6.559172721701113, 6.544022012326099, 6.646949784436079, 6.985519530120997},
    {7.1089860839018915, 6.608539196056448, 6.801937036382154, 7.246618775077104, 6.504074468905173, 6.6834737851721275, 6.958138194997891, 6.956863944240613, 6.876219334020963, 7.1319455932576235, 6.70029253295795, 5.934032831410587, 7.011292644103099, 6.950552103595351, 6.973974821449996, 6.841872040099309},
    {6.717274867459719, 6.626181487554819, 6.614261396053488, 6.957434423283132, 6.677639368578454, 6.744462586981783, 7.074190935520305, 7.237524037551354, 6.888807968628232, 6.910943521080835, 7.316756043405421, 6.054929756552385, 7.165487173445868, 6.758735041129533, 6.957033852758504, 6.687140459423711},
    {6.476887389204738, 6.4824123391266895, 6.3544199925290865, 6.817236956146863, 6.064061672476411, 6.630634043503773, 6.622253652055918, 6.4731826255899225, 6.28113522985528, 6.230612121495472, 6.777084459458, 5.487281043229092, 6.239124366749003, 6.697095688816, 6.127729986981987, 6.775681796455631},
    {7.141714136851432, 7.202163929202816, 6.830605032300314, 7.248751808318819, 6.72696106881112, 6.907151580346154, 7.4950801583998485, 7.01475764943039, 7.141058344869167, 7.276930403681414, 7.43570166336765, 6.26832221787097, 7.219934982948038, 6.806418207792922, 7.093627834810331, 6.9210786663483335},
    {7.187920689144909, 7.164351460284769, 6.949779230130428, 7.011198996072712, 6.461178853570002, 7.3249534790601425, 7.186356312950381, 7.14110706604549, 7.221195271630796, 7.268413820783448, 7.0713486427565435, 5.997415801576716, 7.188611176004326, 6.85679129528168, 7.154457122123723, 6.783197134057887},
    {6.6180551303978294, 6.576990182686057, 6.5739124498623305, 6.817480701452768, 5.877305174839752, 6.641382892049383, 6.483783057291252, 6.434923495698988, 6.780410895736641, 6.552309423638388, 6.24655721611601, 5.4010352779058985, 6.776337598488739, 6.407149536969548, 6.532659361382411, 6.464509874086543},
    {7.0038524363011, 6.974891537199273, 7.04635585283238, 6.756401844976285, 6.6885630530395135, 6.827515341652073, 7.121346389021355, 6.593053339057809, 7.0603369714382715, 6.770794917128824, 6.9744273543717545, 5.58994376918291, 7.018862494205526, 6.936955956955199, 6.646630111347389, 7.1179178031056285},
    {6.867069767683647, 6.327323248572332, 7.066124807428107, 6.81323834299153, 6.157796869162751, 7.046341693153775, 7.106612047305551, 7.083126509902482, 6.805277835559337, 6.470161431004226, 6.642549765336516, 6.135391538683222, 6.498111588384972, 6.827841035725961, 6.415348554531477, 6.955098858528619},
    {6.824783628954532, 6.838295526965841, 7.023498767608196, 6.7568117590425025, 6.165477149132888, 6.666887584689369, 6.784747961618268, 6.854670748279641, 6.7959428544997404, 6.68482823941279, 6.602226096469158, 5.788175134924937, 6.58581534923641, 6.589372746406899, 6.8892476581286965, 6.669032813314847},
    {6.7285376057375865, 6.4790197632787585, 6.448158696570221, 6.871629286111229, 6.6487503278343985, 6.979607814617549, 7.001306434266642, 6.82125792276274, 6.460778492586352, 6.669432906143065, 6.720009506094569, 5.873101042112568, 6.830819391483567, 6.406599257645221, 6.63700952953189, 6.77619762961819},
    {7.193699664095418, 7.260828007546204, 7.146620183481924, 7.298755131156327, 7.209568252391998, 7.645890824303028, 7.08249680974454, 7.307619024043528, 7.3740541068048975, 7.196735991599372, 7.2535809656704275, 5.890210866961114, 6.977715662279244, 7.072483647631637, 7.466475111220477, 7.0074297568328525},
    {6.841182577027632, 6.975580481425138, 6.926600644196792, 6.83124042895758, 6.826970169808296, 7.335162864019212, 7.2549444016279745, 6.764926441055538, 6.977785591316037, 6.959968555835148, 7.226757122633248, 5.852711950665399, 7.1065862101910104, 7.223877014917432, 7.186906817054504, 7.002102120959958},
    {7.10926093201428, 7.514939653344585, 7.393197843937085, 6.964262021908911, 7.252778467861142, 7.043181084368259, 7.273140313875959, 7.371535249528671, 7.309644770386712, 7.26934109906982, 7.673536574523779, 6.291831871555207, 7.246486619284464, 7.3925565595542375, 7.045693837319704, 6.993202154792264},
    {6.760998657869818, 7.014568303728602, 7.2905730991432875, 6.88151286361932, 6.667904696096539, 6.986715092175558, 7.41229180263375, 7.212668959663573, 7.357903253665811, 7.3638784373964805, 7.36689524529847, 5.9479050970755765, 7.091306835608873, 6.875166205200473, 6.990765029351159, 7.278616790527213},
    {6.4768375367234965, 6.77330770416642, 6.886783005757477, 6.5216472112879655, 6.136043130785816, 6.612466658741941, 6.576103700838523, 6.68161420461943, 6.597019345574488, 6.474807087373585, 6.406652026601605, 5.510482332886394, 6.386641943214081, 6.71445308366637, 6.636706814648045, 6.81675327885983},
    {6.486125767519072, 6.598207891534205, 6.673950911163534, 7.110507011144557, 6.396718070864123, 6.740856403796255, 7.068899878103504, 6.717344296378887, 6.475039842285651, 6.552550886007294, 6.588889376543812, 5.9825495601455225, 7.015989183169274, 6.878825806213642, 6.8362574629673984, 6.983596621198286},
    {7.176789412058587, 7.3137186852206995, 6.889741104627784, 7.3781386691558195, 6.816104480776573, 7.244860594102147, 7.046447842111525, 7.2907972393187155, 6.955396647628417, 7.354013749215856, 7.59024534834921, 6.260190265889782, 7.413636553679683, 7.455233702043794, 6.9067955215929215, 7.0234250511877026},
    {6.9094007475905075, 6.379180480724146, 6.626830360431986, 6.56404626860187, 6.233582942305438, 6.577296166755885, 6.889489670569246, 6.353150447771907, 6.997333160680079, 6.680207543082426, 6.672693589373003, 5.931613216580861, 6.650082311315748, 6.527561994443533, 6.6430469012177555, 6.949505795165268},
    {6.994012581130408, 7.2103452821547185, 7.528294028229764, 7.016224926567627, 7.174779311834777, 6.904198782304187, 7.487223380360905, 7.152733031559869, 7.217341069797218, 7.397887829306438, 7.2863107302897445, 6.440172240439166, 7.171852188560084, 7.225261236488938, 6.879047507620542, 6.916140322781504},
    {6.825753267729288, 7.127006999052936, 7.309254006028756, 6.957122405471786, 7.050585663370761, 7.304011424935535, 6.921346835697342, 7.140504157974106, 7.4093222971650565, 6.886785491063895, 7.569407369318457, 5.827007108868114, 6.8940949922752255, 6.776043106449221, 6.936344647800134, 6.820561855502845},
    {6.965227419426448, 6.906235365819248, 6.478313541684837, 7.025440968432036, 6.135837287716227, 6.523418128806424, 7.050008451166963, 6.530094737492277, 6.983853687424915, 6.638438171447653, 6.712678303213049, 5.860069462253902, 7.1297072059533, 6.4689536358139526, 6.631309707464222, 7.049684409311201},
    {6.876739796768284, 6.817854267561682, 6.781235657593528, 7.135693606605691, 6.845902183267527, 6.809099156462705, 7.341735628173302, 7.345049838381812, 7.001443826894304, 6.844521098613735, 7.045802519172605, 5.968803289691617, 7.07697924841459, 6.9973989219980925, 7.0472578352222754, 7.22357032703463},
    {6.777515749043323, 7.035216023744341, 6.889411267760311, 7.132963354508495, 6.8081697656549265, 7.48093706395339, 6.9071726278102865, 6.9730799136181965, 7.478653498922106, 6.890220628005189, 7.0011501148147355, 5.648065424080808, 6.9323661486071915, 6.933735487846916, 7.168624591396225, 7.0412497507382446},
    {6.884988677180511, 6.442793591625474, 6.25167733239136, 6.453891119500562, 6.27150553463425, 6.371937092673106, 6.835872939425391, 6.743004491532852, 6.347203985647346, 6.904197215515682, 6.873002000315173, 5.410858093960444, 6.660592672017225, 6.243901123763802, 6.660718870109148, 6.640895543973969},
    {6.604764538157478, 6.852432953650104, 6.824704685719807, 7.037240050878223, 6.472634946883378, 6.6503292491037325, 6.794194848962645, 6.803425623229611, 6.994000260481426, 7.232862185206557, 6.510940074639533, 5.72700454716529, 6.748525919510079, 7.0458096084447766, 6.404577809797994, 6.943243892309572},
    {6.547757135810308, 6.378491882995053, 6.701096142504989, 6.907915291260093, 6.348155963490602, 6.529780414603175, 6.521302207564787, 6.621727521217673, 6.672449221143966, 6.641384170522884, 6.450888476027463, 5.725021113045851, 6.356393169948077, 6.746683999825648, 6.301128228170401, 6.356521328606012},
    {7.602021332445663, 7.182622221311172, 6.955230034847332, 7.077650747803814, 7.128557188840509, 7.401298569898903, 7.655315224461142, 7.14798461623103, 7.417025521124773, 7.7043979007477015, 7.283352117713173, 6.418444874225385, 7.461699089267828, 6.964427698723109, 7.4248560561501735, 7.060065011160429},
    {6.835340482410791, 6.625463220345374, 6.379373231914828, 6.453468861186104, 6.109899803061406, 6.730323870452067, 6.929019901438853, 6.890131310669258, 6.9538366633989925, 6.907415085810533, 6.54655294313706, 5.625891673725, 6.794057382437067, 6.302265533395851, 6.680274575926684, 7.081709147564787},
    {6.581316586663891, 6.707609972028662, 7.04031575370746, 6.583441550505849, 6.096524947940153, 6.425111340861469, 6.450842334653278, 6.445973878837351, 6.517205215101713, 6.8921853330287535, 6.961953360081255, 5.665906845904444, 6.800533406161968, 6.835344030115691, 6.678738818593469, 6.556160219925251},
    {6.57307842201854, 6.548784569572039, 6.584087589175445, 6.947328854458872, 6.0438857446913925, 6.764440359265207, 6.7289912564270775, 6.659842635704047, 6.795807368157248, 6.850403350727378, 6.511863482624786, 5.732925627107328, 6.571984690483567, 6.747768675196273, 6.372136508874427, 6.941374147946122},
    {7.14512206830905, 7.409963743430979, 7.126357724504866, 7.252479243528005, 7.025281299696825, 6.988603165557625, 7.3191167514406406, 7.319224274668045, 7.5541647654362105, 7.057228147494275, 7.609661624483541, 5.710509393710593, 7.051426703032951, 6.9721683785006405, 7.163776810136729, 7.459196414557858}
};

static const float b2[16] = {6.562885455521101, 6.529575806197938, 6.587648656511109, 6.518989276386817, 6.7862787664841715, 6.544358299336863, 6.609203831169967, 6.583491342533387, 6.621126219566171, 6.609486808481596, 6.511356317457648, 6.165419120456764, 6.640890855067353, 6.600289292915705, 6.5180941775111805, 6.565667447119491};

static const float w3[16][12] = {
    {-5.042238604179642, -5.293292611201039, -4.493280339244058, -4.4326064627529185, -4.411379084361368, -4.994724661501532, -4.595592566610697, -5.021014312941639, -4.868513156042068, -4.72398388848338, -4.554426024190786, -5.255553273594003},
    {-4.993714296955887, -4.545615470068656, -4.613119570086645, -4.831131507108558, -4.889233444676017, -4.9000618443615, -4.383149876445246, -4.35349432470001, -4.377437213861282, -4.796104361481172, -4.71020950952335, -5.242040558684464},
    {-4.3615175933697055, -4.87289652932446, -4.9468554673803995, -5.012204542364857, -4.867719848575348, -4.7725151889345785, -4.777633826222224, -4.487453142168272, -4.95972260994627, -5.351096679000401, -4.903051662510941, -4.466567339581127},
    {-4.625780302291261, -4.891165797108949, -4.227459152306886, -4.900419101675566, -4.323498241941832, -4.438369622128537, -5.182232900007378, -4.69763325965172, -5.039509040210513, -5.037592927310236, -4.780423210496592, -4.962134469102813},
    {-4.729469604233176, -4.361962246805757, -4.853581156880693, -4.385834277167341, -4.399872465027747, -4.229472969275501, -4.726049874614069, -4.802284579841116, -4.57486865524641, -4.662022325977249, -4.952374646883181, -5.004753006971446},
    {-4.801239846645609, -5.162449562768078, -4.40545341485015, -4.806725378470765, -5.194710498876308, -5.172179837298214, -5.183743415819695, -5.035444527420258, -4.806364357595303, -4.612251013643838, -4.56494837774869, -4.632429880748166},
    {-4.659576065464699, -4.709489147144349, -5.088385806174268, -4.4673779320418205, -4.480331257189142, -4.85330304116982, -4.500242116186981, -5.115004688280014, -5.245645336050714, -4.485079530549342, -5.1241122786057, -4.859073060169963},
    {-4.6317698025604415, -4.961334833695373, -5.12898556882297, -4.946214771710712, -4.9843173248679955, -5.150007951151547, -5.117221575699288, -5.17138560936492, -4.686018865664484, -4.738602797738192, -4.694945844485392, -4.5651978908094595},
    {-4.771060193046952, -4.684208776189396, -4.820431787435279, -5.069996577257496, -4.865635363852597, -4.913578266907415, -5.025985945798434, -4.8216830970225635, -4.670630962006604, -5.091386580151424, -4.773443967973884, -4.457425512848385},
    {-4.696379581090913, -4.574999168603483, -5.243659249623201, -4.4635391820404156, -4.946567222502481, -4.699664495644288, -5.050214844395568, -4.920528586484786, -5.24880506297827, -4.739690479459509, -4.984295480918322, -4.9788583398863215},
    {-5.146573704538555, -4.5949507259414775, -4.869604253069926, -4.7971421648159325, -4.984581195208135, -4.879353387149035, -4.996734169123714, -4.7957498174057065, -4.339213834210868, -4.910799898495311, -4.998859085737633, -5.192559926740129},
    {-4.014702366079943, -3.7823705520147306, -3.780367656019457, -4.242683009721853, -3.802880704056557, -4.042456001683827, -4.071116625348434, -3.8962709548911856, -4.250230591618787, -3.582148367491043, -3.7375114329258974, -3.4854968408268587},
    {-4.379828548618837, -5.112249135091691, -5.224758156462813, -4.891936259176233, -4.711968112382487, -5.125672700281633, -4.527394360795422, -4.891156781359081, -5.031627156345772, -4.701762545063998, -4.8623447551032095, -4.715153474617614},
    {-5.188885917590639, -4.707075689495364, -4.718171992884946, -4.738438251287956, -5.306064484612034, -4.274497818687485, -5.08255741174303, -4.384128995859086, -4.849583320980795, -4.664524087156809, -5.20733884389469, -4.560316034038795},
    {-4.9564505781241825, -5.314123245533774, -4.675420977473588, -5.066371976896675, -4.498913721230311, -4.735502863911968, -4.433729332527172, -5.14000740127462, -4.389061608517373, -4.785709115982805, -4.584107122464351, -4.500088181290874},
    {-5.049335619572273, -4.465786940342505, -5.067667356265553, -5.03429760995241, -5.1640446972200555, -4.847326505475705, -4.425824915360809, -4.512228225362309, -4.756639499278082, -5.055755257309598, -4.536719735528186, -5.121889427079826}
};

static const float b3[12] = {-3.265458498407331, -2.901471060846092, -3.3703195998192967, -2.979936446449699, -2.4019999929474936, -3.529890495709617, -2.7115894197602035, -2.2025208366516993, -1.9260904972772752, -2.088894001245549, -2.7321101743618263, -2.6927230129402013};

    // Input Layer 
    float z1[32];
    for (int i = 0; i < 32; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[16];
    for (int i = 0; i < 16; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 32; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Output Layer
    float z3[12];
    for (int k = 0; k < 12; k++)
    {
        z3[k] = b3[k];
        for (int j = 0; j < 16; j++)
        {
            z3[k] += z2[j] * w3[j][k];
        }
    }
    softmax(z3, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
