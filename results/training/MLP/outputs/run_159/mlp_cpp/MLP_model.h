#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][64] = {
    {-0.9028039651058837, -0.7225259510057321, -0.14979544482856672, -0.5963418529355912, -0.1306435167046866, -0.5971806585614284, -0.8000186441891479, -0.09441520860194312, -0.6972775877781344, -0.5716120124891313, -0.13417300177786418, -0.17580028005556544, -0.8825341298519284, 0.11359986212772305, -0.5892034338982144, -0.7780825250870435, -0.6188628301811308, -0.638055345065203, -0.647009688171374, -0.6245040664867113, -0.25595838059053744, -0.5465867529638784, -0.9330527855392682, -0.7768147130885301, -0.7883331456942162, -0.4552307881703243, -0.8319984004092866, 0.45803205340199726, -0.9556439927307158, -0.5880065565371462, -0.03920063795363914, -0.04519603506420625, -0.29149763818509916, -0.8818449309784717, -0.8914293762844631, -0.23553562611661008, -0.7026364717736815, -0.8342315635286969, -0.5179344955504315, -0.5509083686281192, -0.7968416634133573, -0.5329704935689932, -0.7222708236808492, 0.35202101202380554, -0.8740859218182175, -0.7962883615891829, -0.6122631959396124, -0.6303000994880056, 0.1947950852516396, -0.597931891156309, -0.7759860584003976, -0.7388732407888091, -0.8041214665945814, -0.44493563888764853, -0.7735191072090071, -0.788843376231476, -0.4733575117882603, -0.8849874801561719, -0.8257488655256313, -0.030292458618323883, -0.5624145175578837, -0.8095818371874967, -0.51995230723738, -0.7343606780053539},
    {0.7941509800098626, 0.43327092831738023, -0.060415983018440506, 0.7664125622414741, 0.48744518195061093, 0.23962375868964345, 0.6363354206169237, -0.2754236676073498, 0.5121331615102727, 0.37243117941611903, 0.541342070149618, 0.132320373113017, 0.7625422842182669, 0.5471592544108683, 0.6029670378385834, 0.036089857864618394, 0.44250256678651706, 0.6125029716274873, 0.8343449539396074, -0.18212656056191623, 0.27981771255912197, 0.815092737674461, 0.13614663501267044, 0.5856432711810786, 0.34133388254924163, 0.3701607411417096, 0.7614154601266314, -0.565361700612685, 0.803932371694616, 0.5051304191011236, -0.376896361615125, 0.5469076760077793, -0.2643276933326773, 0.3818584900205902, 0.40735636793324703, 0.41421169747919906, -0.08860137101040216, 0.36209685889334264, 0.43126478543207003, 0.8132945713099524, 0.7330189761170661, 0.46190583458954776, 0.5426768416962365, -0.525360335979098, 0.6377582108779124, 0.6948102341891205, -0.012371296392982909, -0.5566021738621576, -0.5057687412710283, 0.6880221530399713, 0.522088955376975, 0.5366183295543173, 0.29775307514896254, 0.5058164372908605, -0.18375441781746157, 0.027840099933846084, 0.38978826850159204, 0.4613561384265282, 0.551515607506446, -0.05556490247110546, 0.5025477278829343, 0.685489293920714, 0.8731499474106703, 0.22546401460123675},
    {-0.026652645562547133, 0.6404880665260543, -0.6099016178388259, 0.3103664552330516, -0.40855535376109103, 0.10443723411669896, 0.5967237943157597, -0.5705602929681078, 0.4478473982530295, -0.04179612314633276, -0.3502457277654063, -0.41424288855409297, 0.08051086540254856, -0.36791971575854765, -0.0701946663695416, 0.1871352499453676, 0.40706873407568933, -0.05048920360951922, -0.3013860033019317, -0.1785994032700179, -0.5317051193898066, 0.3563832638161445, 0.23566957335659858, 0.09175754571675895, -0.03414936675548219, 0.10595941330642339, -0.0163850722192846, 0.17557147149371882, 0.04580709242492774, -0.3695573710636579, -0.366496156178287, -0.5319478433419168, 0.4540856742059953, -0.6205643230955136, 0.30320580349170223, -0.2354891203303951, 0.08861443763751156, 0.19750348291611214, -0.6231064444572088, 0.16551904689266264, 0.4261272901882714, 0.28554866661456235, 0.27771459585573727, -0.5204082331958975, 0.48304201599677665, -0.0160510920398639, 0.17068002249883654, -0.21071490703727716, 0.5004469676701455, 0.3077600116998113, 0.6015492582402696, -0.40444064309691524, -0.638500769212715, -0.6773042268074109, 0.13853342587439438, -0.3273443147814584, -0.44827592314295095, -0.36066613559163097, 0.12848260459606053, -0.07171368271257898, -0.19853764760490303, 0.10352148404533994, 0.3223059126289213, -0.05485555204394233},
    {-0.048637720700425886, 0.2975537189556932, -0.1377195889268862, 0.02801425687377217, -0.07347657474077404, 0.6637831355535646, 0.18123438910401496, -0.17562122314955694, -0.06211524935198714, 0.12333340506786239, -0.12654966744105903, -0.0995484731085316, -0.23089306267849288, -0.15394839182027772, 0.15615404230880986, 0.0730183322944262, -0.2874733615708291, 0.038698863067876, -0.21846404769310637, 0.7394292906731679, -0.6890056576091543, -0.3923304820783823, 0.6594916224395297, -0.35079365092546017, 0.10715731044605034, -0.2943198418737496, -0.23278715055607982, 0.5508352872017126, -0.2714019851195267, 0.06772881033161166, 0.513290893870259, -0.30877821702213903, 0.6762358292887987, 0.11292170871830723, 0.5560739917102709, -0.6138283749365958, 0.785386473767887, 0.6029284644232065, -0.4842827830116536, -0.5032083037560658, -0.053275280092562244, 0.3884199962603217, -0.500232774918016, 0.44569610664606757, 0.06264561525549615, 0.15558831459510286, 0.20667825059571132, 0.6927564605111279, 0.5225172812688129, -0.41848272425176336, 0.5576767499936157, -0.3714356385336605, -0.3243415073196947, -0.11559069838034983, 0.7305830324703186, 0.02047721106727748, -0.7453627711547687, -0.4128995993596923, -0.1065524596597813, 0.21835984264665576, -0.291006643195467, -0.3603784451574056, -0.6578379625190182, 0.689389519776135},
    {0.6241065063415218, 0.8378666174999622, -0.5513650806779171, 0.2766634476552007, -0.029054559530338947, 0.42735784315329434, 0.7216537761111042, 0.27499538628312864, 0.5674235651843043, 0.5838037065095367, -0.044289825100965005, -0.04315068652535216, 0.3748989803718433, -0.4395868467972744, 0.05025506594648184, 0.8630096463381819, 0.5078065436242148, 0.7839220332161715, -0.19370494249602946, 0.6524115977609652, -0.5319329682897666, 0.21915003601764899, 0.9466954640750079, 0.2279651336040962, 0.7709092517998721, 0.2995917682842857, 0.7328507300517785, -0.09575630939183112, 0.4747123234200116, -0.05846040562193072, -0.04435552134617493, -0.4675007147552118, 0.18623554038691106, 0.01214716483144477, 0.8615035551812665, 0.24285751871124298, 0.6287723415036991, 0.6520733701370008, -0.06581652247141387, 0.02502179673968192, 0.37469782823580544, 0.49097283585869606, 0.5785929034298735, -0.12617805061443213, 0.35030728558632096, 0.8773437874505101, 0.29995376841114746, 0.7335176364281519, 0.156343805705776, 0.4732145529395033, 0.81075620945114, 0.3315584886495589, 0.4553539830563114, -0.6895363336820328, 0.6489215135416198, 0.8508632918750225, 0.10498213707794857, 0.7380722871464271, 0.6645139267252199, -0.1283197583627673, -0.3601929433130805, 0.073887996689349, 0.2625002523645314, -0.021753235128190072},
    {0.6588534249070931, 0.8663816199981234, -0.505023927623111, -0.0563305525871654, -0.33342708091671924, 0.788935372649792, 0.8035038023177963, 0.4449571951349666, 0.754221950473672, 0.5653028991774349, -0.06947365913051282, -0.5578348309568955, 0.3042026069740291, -0.49342968376963875, 0.26695583477287416, 0.7308082262266268, 0.6623331674853059, 0.49931168635529055, -0.14167064874113292, 0.8171759942208062, -0.5993258770592114, 0.32320187278595713, 0.8922010379704074, 0.7992174980417706, 0.9097118093868297, -0.24312137052803193, 0.46651516034291207, -0.27761146688832716, 0.701480954221451, 0.24353163561737537, 0.2704542762789774, -0.8115970346733488, 0.5014315703240544, 0.594541349476283, 0.8169532812738218, 0.3169601283070845, 0.8800059250067286, 0.5180849615146744, 0.39948385215001603, 0.0028273591871044515, -0.12311668799230656, -0.05910771446035096, 0.6846212332174744, 0.08521034006432564, 0.6953910001235473, 0.758370761690526, 0.739600387630679, 0.7846323912115128, 0.7886827671912022, 0.5250081476084814, 0.9739880146170483, 0.5463126862408345, 0.33019263801870075, -0.19433030568011228, 0.2675600345675813, 0.8324192101917331, 0.39073918896786347, 0.6744552840259227, 0.590568706580362, -0.5419755986301708, -0.3506291798583668, 0.6978794133960096, -0.14280848092733847, 0.5040364489171271},
    {0.6680537482446023, 0.7987529266326172, -0.5131555808187922, 0.22834196202221746, -0.44244844706686126, 0.8365342626916, 0.7543287976425403, 0.17756604205599907, 0.7119328047935848, 0.5448473242286601, -0.22751678702018724, -0.5608109000553982, 0.6382233716730142, -0.1172137125420652, -0.07676501191292256, 0.8163481404978772, 0.34388880334502747, 0.5349685113447132, 0.2487723620137931, 0.8837454023898259, -0.4311342764250371, 0.3199060160487762, 0.8479268828200829, 0.5750750885728325, 0.9289531918563645, -0.30477927560638274, 0.5496622427447919, -0.1740117447012397, 0.5642690100294118, 0.2816306599024218, 0.07001381509039635, -0.8070198365940666, 0.26787317227832064, 0.5038072148476662, 0.6647229837051407, -0.06197683277920319, 0.8919013598850382, 0.4398308381754719, 0.11495956274305764, -0.19077033759106268, -0.2937697538167744, -0.12753315733456388, 0.33199342488865924, 0.1437392793129085, 0.8281948596195248, 0.6603940438890713, 0.5831190178171056, 0.6585664534345688, 0.7540504615398439, 0.2969872300214569, 0.918127452311103, 0.44765457921298063, 0.5154594393922357, 0.06427413921534628, 0.14465664114187646, 0.7803136973986766, -0.03392797063493064, 0.24685629426628877, 0.7254891853262867, -0.5145457110518127, -0.2639978961355674, 0.39415396952544374, -0.020750121161074168, 0.4581316203317317},
    {0.33025921214734216, 0.5579175434222258, -0.7039220632800266, 0.4361827227243319, 0.38356192414283063, 0.37444558663658434, 0.43024237635056534, -0.06872903690709763, 0.21791335714576543, 0.5301169326409694, 0.2917757302080416, -0.27427925594678676, 0.6086661142840147, 0.3385703292715912, 0.45220771227356216, 0.5247110139322704, 0.009303401265599903, 0.4655825820872196, 0.132915285931004, 0.4542955405229395, -0.5651056952901812, 0.5059607405127589, 0.7041627698468226, 0.3825712601806836, 0.5878890711808066, 0.2981550542259241, 0.6774467404721406, -0.3069035624255806, 0.34156273017232225, 0.1728484411494556, 0.029564622053380934, -0.15045907955033985, -0.08712515400385429, 0.08046244322821536, 0.6646656282136707, 0.5445772042655819, 0.013398201090678536, 0.6588553475669423, 0.27593614161750835, 0.274624017620755, 0.4193425186298329, 0.48431496568393606, 0.3998023479769779, -0.2944832840205804, 0.6859762055477836, 0.45787778127900775, 0.4168151201865105, 0.3315705960416244, -0.4246026653137293, 0.4566736087884249, 0.5524597497945472, 0.14351717759171506, 0.6406514877181674, -0.0624982806020394, -0.2577355015947971, 0.5130932157371616, 0.09447083705852352, 0.4594933137387677, 0.4835819141538352, -0.5513439832860669, -0.025379271313418366, 0.2526902772545604, 0.4730393878049407, 0.3177331264578412},
    {0.28226769566394183, 0.0750039622272258, -0.4902985681533859, 0.4676138582057203, 0.022983500004778872, 0.3993133398264051, 0.5052237923583416, -0.27928697907372707, 0.5010750738871018, 0.21190777194840912, -0.15729641899777183, -0.43401942730148557, 0.330594201801709, -0.19651228782219224, -0.16019083091309783, 0.5055834641630391, -0.2788272383524681, 0.7267104274715642, 0.536792669840183, -0.20134899789287894, -0.5595275018471492, 0.003853685231089417, 0.16410000748001113, 0.42202790717813066, 0.2693425938289681, 0.06572196812643054, -0.13591596918472423, -0.4027142604692485, 0.491795152050237, -0.273293399311966, -0.043851155727528554, -0.06529164728219308, -0.2297609974220367, -0.04486486014332131, 0.20213345787748738, 0.591149382984127, 0.24943804881249587, 0.33441509244085865, 0.18092077624351377, 0.2803338661957954, -0.1058935137028262, 0.06027293028561443, -0.1326710326601045, -0.14858298208928947, 0.8102385436853773, 0.2821612539930405, 0.21839754676741088, 0.19545949380126101, -0.35703083894301696, 0.5715132793533237, 0.6028698350643884, -0.16042274526599806, 0.47895566824678376, 0.004355843926178926, -0.2695453525523213, 0.4141661922651546, 0.32363754742034073, 0.33174077816839026, 0.44800674549234804, -0.47984480556388287, 0.2507033375728029, 0.41503268724427217, 0.635493720759519, 0.3645829157045898},
    {0.4547046976336358, -0.058248171364533224, 0.44179008505448875, 0.5876773188193467, 0.7012837611121597, -0.06684208051745534, 0.39462040706384766, 0.29166835494273086, 0.19847289965006018, 0.1905680762069526, 0.7464422465265566, 0.25721917570836006, 0.5354514564216699, 0.8495704696110109, 0.19127023562114195, 0.23400263895070939, 0.5660509303291842, 0.3846747851078661, 0.7770734040083249, 0.19113094616513168, 0.6480416542056392, 0.6972424998475618, -0.0674746506692811, 0.7070020263848269, 0.49272521728429425, 0.15037814329813595, 0.25677955469905106, -0.4385428043802209, 0.5994040898024331, 0.602403392331657, 0.059638359008991025, 0.29742601996334367, -0.08386630584967486, 0.2150216376602277, 0.441111704856181, 0.5744211179329081, 0.06460846421886068, 0.13712881621437636, 0.5328670624503982, 0.5503003056829258, 0.15423547847697425, 0.7234040979460549, 0.18949005781083184, 0.09972453047946477, 0.4959451742683474, 0.18373531056934422, 0.3267727787691554, 0.3892198527688585, -0.6132388225721214, 0.5183622269666263, -0.20501657101308535, 0.6067310184970444, 0.673336742929601, 0.7285383992806019, -0.24668166911243025, 0.33468460116574483, 0.5715029732955869, 0.7377656811575178, 0.05809859558436087, -0.05836911745674105, 0.7744084993834485, 0.5030718770534566, 0.4363212925261412, 0.5833240439031917},
    {0.3609106772882565, -0.2694940772426332, 0.5606186465589378, 0.13768114117193223, 0.45253778977663917, 0.1397026498650655, 0.44840797108486935, 0.49133754199123825, 0.10759497780784145, 0.03818465974402732, 0.14707951777573552, 0.23184170365701284, 0.25369920966510834, 0.35546825696739426, -0.2745886965278275, 0.48438273956973216, 0.6697217174573453, 0.5070658838205204, 0.6186000909530149, 0.19727968529361595, 0.3914011345204944, 0.23547961548856783, -0.10179460098684211, 0.46169997808277685, 0.4781094948569709, -0.14255358836351092, -0.08648777571885051, -0.19273325304382874, 0.21522202080917854, 0.21426158643625204, 0.277331533119097, -0.3808581418175624, 0.39238961095966124, 0.5164305969542479, 0.25262231172767075, 0.5232797916617344, 0.11987374210465856, 0.048682790289605885, 0.386249232456218, 0.3361740068648472, -0.37463747944984377, 0.3665716800192012, 0.33903312952768594, 0.3798007228615968, 0.09780183688712459, 0.16476200089417348, 0.41955112050762944, 0.30563864756828085, -0.3176498093246561, 0.1430432533917317, -0.1678186305128362, 0.595187529994392, 0.6484509516638751, 0.2702153603666645, 0.18084085835030883, 0.4875709114166047, 0.4681466807912878, 0.5516798904665233, 0.5469264026171778, 0.1572257493119668, 0.4694800196775531, 0.6703439327191877, 0.20506793374211738, 0.5675629662774304},
    {-0.018741415233063368, 0.11336977594774424, -0.24977292048124095, 0.38534820779940115, 0.3300568971107251, 0.07965217149403363, 0.057452941620904724, -0.5699350810236609, -0.05213406646520773, -0.155070365613339, -0.23437705986266089, 0.03601936067090892, -0.1290236957378599, 0.4280122605485701, 0.5336906956240584, -0.35298615602067973, -0.19420510053452433, 0.3824656955898164, 0.6230319446068152, -0.4031664185585261, -0.08297789916993632, 0.15309081703980684, -0.38486309812818614, -0.26217833146718983, -0.13214201392897218, -0.18251630991329584, -0.13828313469636802, 0.2360366389043856, -0.517290148986061, 0.03609492123266109, 0.09297826068492979, 0.4880298690775922, 0.5319690715405985, 0.1660375099503554, 0.2951067712941775, -0.07696855352178854, -0.0257497245538833, 0.33482729808819295, 0.26143068553044063, 0.27547835007607246, -0.0257200610372511, -0.09382198750273414, -0.30222062827566015, 0.09161555258792735, 0.08214996742843271, -0.10375997828990058, 0.512257541581327, 0.23061089698315915, -0.14542675004210884, -0.16846423605215374, 0.36339626170220657, -0.5452098994040036, 0.03558978022286442, 0.4742406433955583, 0.11334583922634596, -0.09118843643578217, 0.196066328368029, 0.16425396362643602, -0.049757227887143575, 0.2110677001126072, 0.15411402860640286, 0.4818609932509893, 0.20393266526401987, 0.4760430789291171},
    {-0.025233346626932416, 0.2096948796788172, 0.016176864834699715, -0.18421886958714587, -0.31338238042717614, -0.4075085927528487, -0.16735437719942695, -0.29940209784902494, 0.38527134854992, 0.03397598186896581, -0.3086131715103854, -0.6458536792801197, 0.19462184048407122, 0.06248669177778629, -0.32914578975267844, -0.4996978113212723, 0.5614549002507806, -0.06189767539063601, -0.38435515375165985, -0.5105935450396429, -0.2925519853655194, 0.35667005862020934, -0.42924166697427785, 0.3433471630610426, -0.000528120762505673, -0.13394643970802328, 0.5777719927537788, -0.7318177466023958, 0.37894307784256404, 0.08228229979890887, -0.4665953521939189, -0.17061806825169348, -0.5679206795397139, -0.40584826307260125, -0.5848045324104338, 0.18978790937524267, -0.6040774530770006, -0.6353564071828522, -0.21416033392146575, 0.7743377483371388, -0.1794511033685466, -0.2623557992747263, 0.5754202261832151, -0.7083817752906051, 0.49217865922960247, 0.018370129727180315, -0.3947995413502358, -0.5721618191786677, -0.489505420192048, 0.5486313426054708, -0.28049795597060284, 0.09323287038907564, 0.08371633648633289, 0.14006448941524585, -0.4852045298503037, -0.31487326044757596, 0.7881148008606459, -0.2761237032139971, 0.013269463933519151, -0.11790415368660075, 0.005657893032792429, 0.33950142209176454, 0.3685192872505885, -0.4661527588461355},
    {0.4329360384342699, 0.030716777176679845, 0.5222729197426934, 0.5392354369323417, 0.02363969311370413, 0.7513169749878805, 0.6820455571258102, 0.6041368612345389, -0.17295506773236008, 0.3537393593092867, -0.020855460671337415, 0.30605608528875183, 0.05880948584478256, 0.30911449871999724, 0.42989993954343053, 0.5603424234723571, 0.14821487700482375, 0.35467391139897225, 0.6151960920347057, 0.5854273050755726, 0.2655542896122197, -0.47300798259935395, 0.6760094921706267, 0.600280364831198, 0.22190774972672261, -0.43694100112957907, -0.34734314366487123, 0.5874573346427425, 0.3678139039067129, 0.338824329255326, 0.5445810377723846, -0.27799618083060973, 0.33742745087150444, 0.8671444259576866, 0.4758780881460722, -0.5428589262129676, 0.689944708052611, 0.15417989224390982, 0.4383629575219366, 0.1678596865577049, -0.4892528661018823, 0.48558587913179774, -0.5514863713577275, 0.6028239943498147, 0.33594156468261704, 0.0697972489925784, 0.303122795861191, 0.49081487983583133, 0.43368792320447985, -0.158102881783493, -0.2103188252999435, 0.4613693692666877, 0.6445056668482626, 0.39837422580896087, 0.2213143987610914, 0.39699581878601714, 0.417563929012916, -0.2817586404077003, 0.6328397455933437, 0.6861782329202315, 0.4567426471778234, 0.8396606988854298, -0.4834915399993871, 0.7961294869154655},
    {-0.4796827058966155, -0.3930806536358045, -0.152662364801631, -0.7064475239339728, -0.41588637902011455, 0.11212958489569295, -0.7209023701559796, 0.105417196540744, -0.46986975806593045, -0.24574657695124108, -0.6842910560384737, -0.2909950366139379, -0.7641305155918976, -0.5094337490966632, -0.049759037792014536, 0.01556132995023898, -0.49774763213728207, -0.42100946890645025, -0.7617654452091208, 0.3401321180611557, -0.10486848556107801, -0.8340470593170872, -0.29572707285573036, -0.5461275887567438, -0.3719240186439546, -0.8352857773271793, -0.45689879648854587, 0.0697940572066347, -0.7569538801142695, -0.5579976929944307, -0.09876058261365867, -0.8319126145082134, -0.19276506209897815, 0.7844357156924574, -0.7020447666105499, -0.9461871083082647, 0.5643599236908233, -0.71194671462457, -0.5259083151278032, -0.7178265824231299, -0.7973141848416292, -0.463658929771577, -0.6991655594555174, 0.37815251968176633, -0.46638685530223467, -0.7608042801927464, -0.25779351357518837, 0.4432684363709566, 0.30571801643072277, -0.7937534764792147, -0.7636720875352091, -0.7601924225501691, -0.134795830810314, -0.42964185906304525, 0.021807454579273463, -0.5497667888731955, -0.3208753450125734, -0.8805842093925658, -0.32300564420745526, 0.09489934238243942, -0.44888242690897395, -0.08257525468604623, -0.8493785344733804, 0.2120815503133162},
    {-0.17464665585891512, -0.12479987832401142, 0.16142069123675215, -0.30075881625335404, -0.34847928520470334, -0.20846495820589478, -0.4104362375665205, -0.43955435915250946, -0.10643374988459223, 0.2896031837978019, -0.6270095249531803, -0.1252615888849088, -0.4092348793329081, -0.6806510669797761, -0.05268747571981651, -0.4439885431500667, -0.11326833681110662, -0.38642719240427614, -0.39775923597869106, -0.36917154465102614, 0.20167779852114584, -0.29626740465586116, -0.07901131910126795, 0.26998636017439714, -0.4899229691911742, -0.63126930716333, -0.04182015639532145, -0.671508220000539, 9.88819291822464e-05, -0.23339683246037252, -0.8078435147639865, -0.6985154270269435, -0.7870252498128638, 0.5927456378514703, -0.713964281242159, -0.544463252063984, -0.2868355174029205, -0.8247544627166931, -0.5278556580614056, 0.22690789687497873, -0.8060304642843059, -0.439734666148099, -0.3713368566507034, -0.05150886830911456, 0.3827741076454362, -0.502470950074053, -0.6870099849747558, -0.716929210350235, -0.5010258928695969, 0.13396958979744444, -0.6613302860565063, -0.3535204799666306, -0.23553300062241947, 0.04945268784429527, -0.4006762849116782, -0.45876530859441295, 0.7606641606748313, -0.6357604967886293, 0.3377667024966054, -0.08569175111398968, 0.3079442409662498, 0.6666599023836973, -0.11511078688194931, -0.4978831060657229},
    {0.22256727770442297, -0.0395849209722305, 0.35326464941352803, -0.038593382265124564, -0.20073316333231547, 0.809285537766336, 0.1437018296066379, 0.4165616782416964, 0.1837742590632945, 0.6111449255427266, 0.36557271653674356, 0.31135796799924054, 0.14170782033650944, 0.54794454227424, 0.43168976713963997, 0.5312099365728091, 0.03515746132239821, 0.19306885249021866, 0.49741259950438, 0.948075103381026, 0.5695323247502243, -0.426436395936919, 0.5907505926474971, 0.4924879534443105, 0.4154995108020142, -0.5603820841615321, -0.4030452665939677, 0.14545556023066522, 0.18896527182500372, 0.027495054981664126, 0.43476141915619676, -0.3706854661068162, 0.5503701800369996, 0.996605752909266, 0.24958059538306973, -0.6794852038629853, 0.7994901183976855, 0.4852502621390002, 0.32508040636940005, -0.43854070061993117, -0.3350606622528521, -0.07052286515259934, -0.585951130480795, 0.8119782168366363, 0.5750404663503595, 0.04546454972168103, 0.09077515864753728, 0.812939722011824, 0.589764451099452, 0.0015376693106369426, -0.13140789442715228, 0.1586525971537791, 0.5131232937126343, 0.8746651315749728, 0.576240735270335, 0.1856224506276346, -0.1868136081981317, -0.2632529573838735, 0.5968266172835424, 0.044541780428097484, 0.6104466060277969, 0.6959102193086601, -0.4485781735125801, 0.6753010273694234},
    {0.002392139873104783, -0.08191872510239508, 0.5240401151582267, -0.05586349133729185, -0.22752542999409842, 0.5886685318695163, 0.3029020547691072, 0.6110014852246505, -0.14804647020061523, 0.5148610538455016, 0.0762956398113003, 0.006457409915866106, -0.11789515836215374, 0.3996073037609504, 0.48904472233768176, 0.5683554100252066, 0.17976362850233643, 0.24891696608110817, 0.46883874790148194, 0.745507635913825, 0.46771101790203123, -0.30000417046921746, 0.46950186186272486, 0.27603969967242054, 0.3578674167937272, -0.6761157702454137, -0.38904614330624876, -0.21693283716596035, 0.02527365555896117, -0.051778011446096214, 0.21889985682464472, -0.6694598429509929, 0.2345634765009313, 0.6780694191461335, -0.16521542709875903, -0.5203518293332328, 0.5574281220598125, -0.04751644942728207, 0.35363871472615843, 0.268961741001188, -0.5651418736084385, -0.16450824034106173, -0.5578235201066076, 0.7146331294393792, 0.11096095298234504, -0.05545318076032013, 0.2800708806377783, 0.7428209713409798, 0.4672173388754834, 0.07930314580572885, -0.2893509695830934, 0.08036128680033225, 0.23502298796765161, 0.4123837566709754, 0.26090593219208763, -0.044801022401151254, 0.24299785868281315, 0.028880222267601775, 0.5080403067622093, -0.10859761214425614, 0.3519905677977707, 0.5790048159273655, -0.4334964956358614, 0.3607991703895174},
    {-0.22865080156291878, 0.08232484576134771, 0.4459414796396394, -0.3402730381370278, -0.154011619859758, 0.0970801174743696, -0.25549274421456936, -0.2542958579718359, -0.24836083087676727, 0.3569160833096471, -0.5520926836300863, -0.552097729043479, -0.5062077335160358, -0.13311070320265134, 0.2817838815325664, 0.03012671503345552, -0.055272391162532034, -0.15030623568583196, -0.4865886634164764, 0.332940802461629, 0.07563180842517643, -0.49738529300690143, -0.04973703249741645, -0.16898042206174255, 0.10688863483487522, -0.5852721725529495, -0.21030591256762998, 0.22414206103065434, -0.29028806029156146, -0.25598654948122523, -0.1643662443359405, -0.3428964101734853, -0.10260630002421421, 0.5764235289239668, -0.29914364311357977, -0.5534605135397334, 0.2732515162752951, -0.11679367068759902, -0.18095884758964545, -0.24028017897456153, -0.08239421542196987, -0.6591885595100637, -0.3940555765780571, 0.11967537399522538, 0.44722745138607317, 0.02929379228791316, 0.10356305346651541, -0.1301825175373062, 0.5019693515600167, -0.5346872098431749, -0.04357065133349288, -0.46146693158106306, -0.10932146511298634, 0.3727325543797248, 0.35316688791477513, 0.09283149358744149, -0.12881596037251938, -0.3815898812495914, -0.22372755891813373, -0.38888864022899966, 0.06267797036433319, 0.18679765893867004, 0.04397581119465597, 0.03004006252562943},
    {-0.41797112617635523, -0.4356842353724912, 0.47813883083304404, 0.5159804428537444, 0.5980357634370415, 0.4493531684590586, -0.4985326734252734, 0.29680299270938837, -0.22474418222577175, -0.2596139893528123, 0.537022134547467, 0.5930168757852838, 0.22995607249595088, 0.4531271216011163, 0.024823347032286797, 0.06919156450156537, 0.25651613799735457, -0.3489871597395778, 0.5092395687677835, 0.618987624425405, 0.47100913789806786, -0.07560471888346966, -0.3266301647833398, 0.19806547124730148, -0.06024809789904854, -0.4081352883577552, -0.11806219100591368, 0.6406860849248551, -0.08928872313904253, 0.4921205801794096, 0.4818340181848058, -0.03451399102521088, 0.17203777337006798, 0.5685196924274151, -0.15005441760336694, -0.5459846062933879, 0.5534431219343532, 0.1334557849552485, -0.19913029658589948, -0.136160309933229, 0.3199659696359044, -0.2582376822507024, -0.13098022660514724, -0.008097260677795391, 0.1455706369579443, 0.4675567191183823, -0.11513389340656602, 0.22542442988410827, 0.5310264710617256, -0.37716589656769406, -0.4935846502048286, 0.4731703870223046, 0.5146088042857461, 0.2734224196963001, 0.30386401163536275, 0.2105294775970206, -0.09492518260365052, -0.1565757145981646, -0.06646897721074008, -0.14677935784124713, 0.3530798173811117, 0.11037499946441852, -0.0058523020422545325, 0.6714321873979554},
    {-0.627755060755708, -0.19992215432823346, 0.20451947432132542, -0.41153666183433274, -0.12115693270844799, 0.6362382636448848, -0.5714804891706793, 0.12139870856032134, -0.24812656243341502, -0.1753052965187229, -0.36582250838825003, 0.115838147539758, -0.056247905195716395, -0.19880270526722502, 0.10268192223450046, -0.10641873767485949, -0.5237615573820712, -0.4023824729899652, -0.4547445332387911, 0.7282782153694318, 0.4383626905416029, -0.7089435858287239, 0.0814419132821911, -0.45550846193751665, -0.48662486340616373, -0.26494552042480385, -0.4854490878952287, 0.8584767139815748, -0.4578417350070156, 0.1730689377297211, 0.37186762694405195, -0.12623172233112753, 0.44477281658018775, 0.41229419742842616, -0.24522033332526566, -0.5542419045928865, 0.586876087630038, 0.18850090036837477, -0.44873153583671527, -0.6658930123754953, -0.4392136677306858, -0.04386421085291274, -0.3597526370132368, 0.6377567951981156, -0.6214295464409401, -0.43064687953744435, -0.2865582182777808, 0.6315029538742946, 0.14971595213619454, -0.4804961674969359, -0.3391185256058076, -0.24124789940754687, -0.013692431215896876, 0.33593602441680054, 0.36213484812548064, 0.08066339479324174, -0.20596292138935474, -0.44832816258349184, -0.16571725636101264, 0.4114250822557703, -0.3731375779676319, -0.5701780827411655, -0.28455865284744175, 0.2178509729771129},
    {-0.1852917090066102, -0.3658631865990773, 0.4974567201736239, -0.1259905286181198, 0.04713915560918298, 0.5138103524715255, 0.020395886918666974, 0.6138340527580102, -0.3557420914576762, 0.15377207152432826, 0.5880013273758968, 0.7350082983682247, 0.3716522897787336, 0.34590846332409186, 0.09948004914054462, 0.6455112525036788, -0.18469728224215878, 0.11436275383079744, 0.2805420235552687, 0.8233252365378363, 0.5938089972837302, -0.5608285557750613, 0.13705262049663233, -0.054286044327971586, 0.3821425331152229, -0.5819775294961136, -0.32456513777636825, 0.682877783410672, 0.10219711380167934, 0.6133968825865675, 0.6847197906084502, 0.26442357008397444, 0.3377339489220328, 0.8157316381900626, 0.10689092034988383, -0.7046079815038195, 0.5774604846542845, 0.27197948037233166, 0.13451780298694527, -0.33214170498059903, 0.1093424630401022, 0.10512846112977467, -0.4881156460980471, 0.7192203823491233, -0.3818094491851342, -0.0032641451727553755, -0.038290787666207596, 0.7161566514730083, 0.5496046592619175, -0.29081131872038263, -0.7356938754228952, 0.7329905970994829, 0.3350352005731231, 0.5127101165102177, 0.7133260293229182, 0.618036401364976, -0.08029668307554785, 0.004758910406619945, 0.18507120390527898, 0.6260090040971157, 0.1848536415454884, 0.12199528821408454, -0.7265809663535986, 0.6606250064232143},
    {-0.4997935928477083, 0.2020156162443168, 0.20912213655088474, -0.04785111022087149, -0.3144105713941047, 0.17681005430898966, -0.533002754619985, -0.11897205015963581, -0.24525578070376175, 0.0736050123647807, 0.5081492264871879, 0.7497202804933203, -0.07242871973969156, 0.12792214524421644, 0.5610062958921092, -0.25514028503037484, -0.08382210962611088, -0.732404542272457, -0.2739853769767243, 0.4789567421066762, 0.36971641184441645, -0.413490256517757, -0.1324882116207991, -0.5339134460826198, -0.6541952358074477, -0.27180519469170505, -0.2769781902784421, 0.7250443861810905, -0.3700244766571587, 0.6346699875060308, 0.4453664632320088, 0.11548189737049576, 0.4668535982187212, 0.43529246636197494, -0.2279856530778641, -0.9145849414571662, 0.5572249860246946, 0.15417629122343107, 0.09745294728720715, -0.22882146721777674, 0.3247904934655846, -0.20161209619457088, -0.4668473745549233, 0.47970442287507903, -0.5955247161742372, -0.0014693570641029872, -0.6125914301339754, 0.07735352947743752, 0.6810928897065958, -0.12280347200524723, -0.5839052339577798, 0.37070959063603376, -0.23337314378712562, 0.5701877680901667, 0.2597684689465118, -0.335340815173204, -0.43543789963393853, -0.5386694748656188, 0.024470020374426946, 0.2653790435837262, 0.29847721712346725, -0.09717785006312216, -0.1851859350024705, 0.4066781983778523},
    {0.4469838218135501, -0.009224641595486893, 0.5749235548774891, 0.34930524976901084, 0.7560029672784683, 0.16662815127715402, 0.07805063999283146, 0.5709178945729786, -0.14938678517451282, 0.09854164305223143, 0.7609491160898021, 0.83592350135082, 0.7165389695833858, 0.5763504769843906, 0.6244553136301476, 0.32074055767685106, -0.11789706275492018, -0.21416910283331603, 0.7416496601503167, 0.7567335864965369, 0.779884465514772, 0.01549261935293515, 0.38073995435471725, -0.07779868122149064, 0.015756599609940868, 0.41537874302905387, 0.4401119500324052, 0.6994708668364601, 0.4503899814745132, 0.8574842132957741, 0.5555778845572183, 0.8554923408991918, 0.3069672287108321, 0.4209287930148724, 0.25503114990635983, -0.3287788998763126, 0.4241066121177759, 0.31753522303415826, 0.7722265402903782, -0.1447299811455959, 0.7296352179031573, 0.6309323288458001, 0.3123676177836024, 0.27590544118950455, -0.35034205298885474, 0.31364796820008334, 0.06394696951029633, 0.6970952202898159, 0.09509711528366854, 0.08884339114592328, -0.44622136098112003, 0.63652873645851, 0.1912904032967733, 0.5119199607188216, 0.6253142159054351, 0.48156139714922275, -0.23624973070746844, 0.6211835434570343, 0.12249099651205192, 0.24507218086823165, 0.3039534615585786, -0.30606113086282716, -0.05228218008390369, 0.5031397418577473},
    {0.18025151190992192, 0.05088476349782053, 0.4397019691740663, 0.5778391950835249, 0.6561566793404338, 0.6989509287562337, 0.09885369319891739, 0.7474265455489711, -0.35384168353070156, 0.13550705804371332, 0.5870164967883595, 0.6287047546142897, 0.4411214185425577, 0.8274092177873625, 0.7905876491541012, 0.33302175953368446, -0.04385479138775659, -0.08247930704539796, 0.5250160703934083, 0.51456885020866, 0.7400949227578596, -0.21354553007059274, 0.33016541658972176, -0.4405978568835616, -0.16952696834671274, -0.06246142707302462, -0.18603779188445546, 0.8739735064948938, -0.018192150408680132, 0.6723529344612714, 0.9319273322530733, 0.5414942247019253, 0.7766703278182812, 0.41113736592551026, 0.6459462619803373, -0.2043535262023115, 0.45720065476278376, 0.668342681964626, 0.3170231284606454, -0.6011421348204127, 0.7958875561011715, 0.8099843397867404, -0.136529895124409, 0.388212160126994, -0.5638971408206674, 0.10144291969459794, 0.6004049275304036, 0.6340410107203571, 0.6998701222578652, -0.1661853294714879, 0.0010479358932671274, 0.6991488054098888, 0.2771753760282338, 0.3836668347321729, 0.6458482772390354, 0.6395154732326734, -0.5322482627173396, 0.4977604665691319, -0.27340968770642265, 0.4628548763930802, 0.4389326242111948, -0.10090654789499122, -0.21823490902687376, 0.531306293212411},
    {-0.3907817772639079, -0.05119058935300932, 0.6773514557803452, 0.19494931187554265, 0.40946265124675, -0.13607215787832241, -0.3739407540748987, 0.1587561799272387, -0.21422920766144882, -0.3533152293038296, 0.7848549094629034, 0.5041848072393967, 0.3470003028231233, 0.5444278276690205, 0.360285029080918, -0.04895929480154781, -0.14409784116281185, -0.04225648262130721, 0.5385746149630676, 0.277988122983347, 0.32442033848842583, -0.4011700958886318, -0.4547365438454459, -0.686643046587049, -0.3076418618240334, -0.036379258112954845, -0.4068527003295339, 0.928418655725838, -0.5419516090100396, 0.6215171318405422, 0.7259474951582909, 0.49453921437417203, 0.7407651815642005, -0.21672638982876455, 0.051257155937094026, 0.1212993736446309, -0.10150084847613912, 0.7077697726887218, 0.33123604697409526, -0.7769601195024264, 0.7349216619531838, 0.7008478269956113, 0.11390861026327187, 0.12936740247818573, -0.7812672496181825, 0.08292269123593995, 0.341898191489106, 0.7289624713227695, 0.23812310326569666, -0.4345113518347963, -0.385419347972501, 0.1635044093482738, 0.07931880699376226, 0.4253757894949567, 0.5561139573118058, 0.4635427486508685, -0.9183439100477433, 0.2775373702295377, -0.6251498335410309, 0.13897081845014136, -0.0019105792106259838, -0.8085011143912314, -0.29322227313250115, 0.5199043089479745},
    {-0.5283520667503975, -0.6618873211426121, 0.7049055484255107, -0.4145570586723188, 0.0852292460157455, -0.27441453044359365, -0.38406644127949163, 0.6910672131044231, -0.5084773521375195, -0.3690792759876928, 0.5801497770081743, 0.7134289004533855, 0.1084856838013988, 0.3278233470797148, 0.09316192657372883, -0.5907952841675007, -0.7736138272645251, -0.5461106371954142, 0.4005534414816662, 0.6303949426187, 0.6229787717028223, -0.6687985543241652, -0.6536692781502499, -0.8992180232116997, -0.7399343657144175, -0.3428701428354258, -0.5329880199110795, 0.7060052612255759, -0.3116020521396687, 0.6546993198902324, 0.6502977416510334, 0.36589209898952835, 0.6632341437914433, 0.3829440639907066, -0.4810558380706808, -0.6928707219326597, 0.23792736825642385, 0.13509802333859575, 0.051169016381792415, -0.8184544031405852, 0.20203561398077446, 0.33465373904727025, -0.5870436999159752, 0.43382590509444907, -0.8706422365474408, -0.4939474354160575, -0.20901249159008123, 0.549037117986284, -0.29685160580101294, -0.6976169624284472, -0.8672919204249359, 0.15996514360878572, -0.128121698469865, 0.5713701874522527, 0.6747156348526112, -0.3058744564968685, -0.6966398286450308, 0.07180193886815882, -0.6235197944970166, 0.29241735627699933, 0.29170347521952766, -0.8276051300272063, -0.6249575403192924, 0.3824974359583825},
    {-0.18725536428188802, 0.3504093553345684, 0.05254853468070902, 0.1011412737819315, 0.35504216919906806, -0.20166190110278387, -0.36763823527994777, -0.07778748681369409, -0.05623067286283382, -0.29680039398156516, 0.18204688031507021, 0.19356650220100383, 0.3876605567401645, 0.3103884749946964, -0.25164090591035404, 0.19860146581606672, 0.11721552896947084, -0.45009044618955624, 0.34102080196430173, 0.06867375677121088, 0.300334747162842, -0.2626233494149716, -0.39401620370023754, -0.3997624317924465, -0.12452329534875836, 0.10078238309709406, 0.05759543397910578, 0.33755881571826296, 0.29393874424135874, 0.6146138509044479, 0.4249369298382674, 0.2811485508618086, 0.4703870848610451, -0.1341035206814021, -0.02287421987842403, -0.35740884590810357, 0.08771825291209769, 0.18302761205011606, 0.22239143144502818, -0.5145073600658233, 0.5969145983187175, -0.08223038560687776, 0.41873312573261595, -0.5747737590074918, -0.5385388959933983, 0.2900313917035355, 0.16030387414739214, -0.20615656811002436, 0.27943027184675334, -0.3533968215087841, 0.12417920576279246, 0.26388413076143236, -0.34987316130791996, -0.5092866063721037, 0.5214334072207237, 0.3542932041138967, -0.5980320515073889, -0.020517955153005796, -0.53437123824924, -0.38970208169196924, -0.30580675224282217, -0.696916461728499, -0.05169449309383411, -0.39223654232606575},
    {0.06974993445716848, -0.010132652419919036, 0.5159873505053779, 0.16927728017921742, 0.4875713505041861, 0.6771397805894599, 0.31608142372969084, 0.6982782591201495, -0.4912621507617409, 0.11839427469975121, 0.7586784238192448, 0.4582598691140595, 0.040158314174964294, 0.5337786629697584, 0.35581171168536696, 0.3088254587695, -0.4186250132803298, 0.21313964764127427, 0.6068960049710577, 0.8560107602188685, 0.7335477457022374, -0.6047510180340275, 0.5025270890536543, -0.5961923499193643, 0.18843348631673207, -0.3484744601027831, -0.451567734235235, 0.5720625061385368, -0.020268195123790574, 0.7115627624559029, 0.9157678292310968, 0.27161779205715897, 0.6710046053973897, 0.7895339148791017, 0.3283361329646269, -0.3540329271371159, 0.47228294511940067, 0.38508576895416774, 0.42492820331669356, -0.4969092555486434, 0.46987699141709355, 0.34388176274342186, -0.4555242706747952, 0.5248072072220893, -0.44698013450463625, 0.009135159273874247, 0.4355920586355979, 0.9443263378855596, 0.44084398132473407, -0.45285352355154307, -0.3675262174069066, 0.2155321648407626, 0.7248217860665317, 0.647731374592142, 0.7235101679786502, 0.5515045248511282, -0.8791956467870587, 0.10049144701007551, -0.4571426633669372, 0.07269904700047566, -0.12319628874773118, -0.5451607743453611, -0.8651763479671019, 0.6460988199368017},
    {0.10909327389546483, 0.258343221960897, 0.18143603987346907, -0.14428685510988262, 0.33451899104349664, 0.1382709688184058, 0.21592158987780607, 0.6459446805532494, 0.20626557295500522, 0.2515544556135252, -0.167822817887344, 0.44278004219617123, 0.031651256158858096, -0.049596319615678536, 0.3311141896241767, 0.30713820061437924, -0.3028014070905496, 0.41983622028135287, 0.566768083182408, 0.4842446351619275, 0.14998602010701875, -0.3001937016795356, 0.4054567106530569, -0.47825371462822935, 0.30166364851424227, -0.23168572584351402, -0.30145068558741084, 0.16978570539028473, 0.2572888876890146, 0.661506792262403, 0.6108641815180107, -0.06266996617125249, 0.33784477026167836, 0.49426253299501743, 0.044420365571421115, -0.4719474654278315, 0.36047498097595543, 0.3838194878309462, 0.07536441106431921, -0.24738575053896278, -0.040846034091232435, 0.3451203610463104, -0.4258236656579596, 0.6116743011289386, -0.2753540448801485, 0.4256096805594164, 0.4548208886358181, 0.37760407037574106, 0.15843888872711212, -0.18817240940491167, -0.0982424995734434, 0.37299321224708415, 0.5847144686302594, -0.01307141801540363, 0.4260711709750286, 0.236605541504643, -0.5616498335825818, -0.15654090593993059, -0.3300866122975614, -0.151519698577003, 0.3361840020143317, -0.09388485981739826, -0.5419824755926802, 0.7373225994821804},
    {-0.8542540348086759, -0.7016276909708395, 0.2023896801720284, -0.5420107085172623, 0.29599112242620823, -0.1731063304110767, -0.6181671679108789, 0.1436937566602808, -0.9250071263059801, -0.9469845474236234, 0.2769380900723188, 0.08264299027034096, -0.8145459182552696, 0.5265286910626958, -0.49928015311013535, -0.6868451141477498, -0.7992439364424866, -0.530093845057463, -0.40849461605544535, -0.5749198926364292, 0.2990652564863903, -0.37156486084376666, -0.6898378731354835, -0.9114391236454435, -0.691107082550683, -0.9267623959285554, -0.8915560941862093, 0.3932897359227994, -0.6623255109396228, -0.8947117086157261, 0.5020032044835827, 0.34904936644661894, 0.25013961679285446, -0.1668456157972115, -0.756449619934932, -0.0033227917404150637, -0.7605004189589485, -0.20362391061376056, -0.48485050323197876, -0.6804208441433164, -0.5093109154622539, -0.5595515647883377, -0.48854841022096357, 0.42780617034845697, -0.870619815517469, -0.9281588872943803, -0.2945077904629722, -0.11929598813375439, 0.16898949144959244, -0.8746612034276738, -0.8404199946720388, -0.5479946926706437, -0.37440810081432935, -0.01107972398557442, -0.6090693196170535, -0.5938262377481213, -0.9457940120229201, -0.44003213870661173, -0.7974362732418845, -0.34917200474611426, -0.39610854590911254, -0.7627009529444799, -0.9513231339555184, -0.1735700972800438},
    {-0.8256272444342728, -0.822726500169085, 0.26046023631432724, -0.04856370286799167, 0.42829924308757805, -0.1484842267222902, -0.67640090516884, 0.14022403208826031, -0.865703640390484, -0.5899776442483189, 0.36308433053726014, 0.24375210244644155, -0.8238147500967451, 0.6378747224729041, -0.3729874933746769, -0.555288876503649, -0.682382375402896, -0.6221122629501659, -0.35610458905759096, -0.37174697554775166, 0.17943963362712, -0.25117504352179343, -0.6494520245782119, -0.405127897218358, -0.9097213223889817, -0.5808362368544624, -0.9461999811472523, 0.7226580043750642, -0.7486630606911588, -0.63228281350298, 0.40981518043833226, 0.40723979222476636, 0.6113625680359, -0.23346371691334908, -0.571702133513306, -0.18857705568469726, -0.32636996618635117, -0.1451302642656988, -0.297744940768058, -0.556118627854931, -0.05433626118897131, -0.4263330319518429, -0.5912782924810852, 0.49169597968740353, -0.35551446481158694, -0.8619124771335058, -0.09277979109571113, 0.519680417197412, 0.4090363543743583, -0.7736596931268053, -0.7340288004134615, -0.8645089637304705, -0.5928432765752005, -0.0164532579611672, -0.5102791533886473, -0.7487494771089674, -0.9054906051394034, -0.40287960774675097, -0.8344676626177099, 0.06078452762437686, 0.14405255628959535, -0.35945046872427533, -0.561934444294941, 0.12365816780037196},
    {-0.871433730567407, -0.26949263697866643, 0.38473164468817217, -0.362895752111035, 0.35489131815003994, -0.5283736527892564, -0.6458658228937758, -0.08474803337169398, -0.6804398641888492, -0.40257003852262474, 0.3104703839182189, -0.512638863743669, -0.7523355665164984, 0.3792640543045477, 0.015284462451040539, 0.011405410930927938, -0.48368441064427814, -0.494852909733201, -0.06338058271020246, -0.7854680051867154, 0.11571228192595917, 0.19020346222929865, -0.19347773594323903, -0.2904246442454558, -0.49920035993554585, -0.09328438467154161, -0.4783675612045642, 0.3878974029894442, -0.6503819118835232, -0.4424818234519424, 0.414202196684448, 0.4695343241888927, 0.5232567720305094, -0.7169988878033644, -0.782816654360381, 0.28943445760243114, -0.7431606630711107, -0.312177335869088, -0.5437477584331393, -0.5831886493627778, -0.2243235191146553, 0.0004972453947591432, -0.3047147929128701, 0.51374729453318, -0.13453993563870367, -0.5307114042705491, 0.39747945734094575, -0.06481373650833257, 0.4695569502923204, -0.5856795594522614, -0.35052453525957594, -0.7066000691179055, -0.6321015037232292, 0.061873899337178455, -0.5776431587248269, -0.6621352349542348, -0.6943847381508894, -0.5661079034722689, -0.3921242272257009, -0.29302331712665775, -0.06825159300117924, -0.6488161274088614, -0.7434153385121693, -0.7341553663409677},
    {-0.634062426919651, -0.059916412644403984, 0.3084755426001295, -0.2164822304038613, 0.0414819543663779, -0.4768420462986453, -0.15353983987569142, -0.14085771881699102, -0.5311414403430276, -0.3622088902577535, 0.275099250488134, -0.368807065590246, -0.7044909126352772, 0.6048369444128546, -0.2451612823063831, -0.07146823077650136, -0.4751719782074128, 0.2060684565035163, -0.18191990735651256, -0.8086051659751362, 0.3500565932280546, -0.008281552233397277, -0.13230753627713476, -0.15696790088604662, -0.7543877381721752, -0.06684538502441265, -0.49801967078715165, 0.22749307545077546, -0.5252989683867574, -0.6419368644747695, 0.5666667977664012, 0.5052750236480036, 0.550634825549024, -0.36053081841915624, -0.32790646709740895, 0.29030409078213754, -0.738753161442995, 0.11069826243097591, -0.40260167898895755, -0.5683492245657505, 0.002144228972282203, -0.13349934277900918, -0.5640495557750607, 0.6339440935554989, -0.29381284923436957, -0.8267481265296092, 0.4749238956850373, -0.33324349157804944, 0.05921830387630367, -0.3806525794133765, -0.2697253475004505, -0.7464424252472456, -0.15389360065221, -0.5834594365674156, -0.5313759913140632, -0.6469444885708003, -0.6063557253925796, -0.5306036652114493, -0.6183322376423562, -0.08242862623973356, -0.11835223269921603, -0.1730736319385188, -0.6096117701116125, -0.6296534917196592},
    {-0.6418333433754129, -0.2288742716082349, 0.5004117785081181, 0.275570251129103, 0.3007025538711721, -0.0019162968085545873, -0.34112977134017236, -0.29454850969363666, -0.2981106430493698, -0.444748234347721, -0.18719630355026207, -0.44315547778856357, 0.06211740906769533, 0.14608980157541798, -0.26391643545423354, -0.0923081799248405, 0.32577771382736115, 0.44781852942028577, 0.007665197542359703, -0.4634588732224417, 0.46190476105117995, 0.11998637690394813, -0.04111918164387495, -0.4537716289634706, -0.5362963237373748, 0.30414627540044126, -0.07301248460784977, 0.568798208361394, -0.4951637421054705, 0.03914278716243901, 0.4404223141135407, 0.5079571613812067, 0.6437001881822565, -0.33042987506353655, -0.13714846797721067, 0.4912093955428136, -0.22780005571298242, 0.46629396838935677, 0.018778860863626044, -0.5987753625102786, 0.4811740852003083, -0.16157686515305206, 0.24313279626705334, -0.09378724666506741, -0.18464695091688854, -0.41646378944803736, 0.27932098566325436, 0.0865251691878875, -0.223251442723876, -0.21127409690235274, -0.08835432863134879, -0.6325019400767907, 0.06283645730031243, -0.12795978779511938, 0.2032572986726852, 0.3794224999955541, -0.54566363924701, 0.41161020656574937, -0.3927528088827478, -0.04750828901317156, -0.21028604465840675, -0.39263294741140037, -0.49319191818019814, -0.11213532893187063},
    {-0.4130487730268164, -0.46039191547562636, 0.537341390173036, 0.02712499272551956, 0.40571515699184035, 0.15401524319341617, -0.18149768367281532, 0.17343838835820402, -0.5143371247652545, -0.5497157416147145, 0.45722162339540273, -0.4639631470861132, -0.08314704184929683, 0.4193398402537192, 0.0024257069072918577, -0.395445279167502, 0.058629416651669604, -0.07999449350881459, 0.12356041478379184, 0.2376654261402753, 0.1632172062450886, -0.017843641793519747, -0.6564709632698787, 0.2066162849843968, -0.616203069996148, 0.33153809117773, -0.6838769594307644, 0.228972869090343, -0.27169894655285304, -0.12966842046986404, 0.5447106229906579, 0.4524055458906659, 0.7678594131869049, -0.1228915518125158, -0.1652609401162413, 0.543807138498467, -0.26926614377586205, 0.1543518747038631, 0.16625513466734912, -0.5006933937034705, 0.43169558588269313, -0.12983054556152787, 0.17046285510703588, 0.10111071776644617, -0.31523696115916483, -0.1508945157046738, 0.5421877089898782, 0.4231954668117186, 0.3079965443730333, -0.3284390046608519, -0.25677653820596985, -0.24286058898011975, 0.05060606425180999, 0.21481338831181757, -0.02054990180700958, -0.15348119635817398, -0.6969376678355093, 0.356762066175475, -0.11614662764108727, -0.21841366386614794, 0.41122819686429735, -0.2558215034471151, -0.3263021398704245, -0.19118323342979018},
    {-0.6521293134142981, 0.136597348785976, 0.48088411203057874, -0.06037039048182161, 0.2857060717462288, -0.7785742688399433, 0.18181344955999162, -0.44476056369758293, 0.0049142010937638985, -0.044439724838913015, -0.2867330955714154, -0.5279919156560012, -0.41453899765503643, -0.08196259638191836, -0.445241423822847, 0.12287424778680586, 0.09206972392454012, -0.16266503239038865, -0.20039458281910388, -0.2173266112698368, -0.33829718427543337, -0.25358119441951427, -0.5559088248514905, -0.3021379797429786, -0.22088825328323558, -0.17160338758911925, -0.6086122582133284, -0.1634107600336382, -0.6399114342635407, -0.5002736817215534, -0.29666953908693783, 0.5118984095381165, 0.7279395636087341, -0.3847017746268101, -0.2576491140537657, 0.144559405466227, -0.591727780677951, -0.3875515767157357, 0.09380461784072122, -0.6135451138730641, 0.10089473465670394, 0.275197533371291, -0.04577085806657429, -0.0028204836988868598, -0.0744314364861069, -0.535519945160354, 0.39868104250428643, 0.26598341465516634, 0.33413553983501487, -0.24940037239785684, -0.046164249646631066, -0.6123445282711727, -0.6958092469352677, -0.4188775411344127, -0.29585058033396966, -0.28872538436263706, -0.6536670014646093, -0.02283682351366361, -0.6143659378428188, 0.30763382639000214, -0.09698328602826782, 0.024299614858719246, -0.40913158097196795, -0.54846907586533},
    {-0.3275219529543084, 0.08378081516230627, -0.30372859103775707, -0.6321201694947508, -0.45200603528800193, -0.18043614619322237, -0.3831960659784923, 0.09606309878486523, -0.6506058844470252, -0.043335162675283236, 0.25539472228473786, 0.20925792819864394, -0.5478369129345267, -0.024643403060272635, 0.24819263810348932, -0.01392835732612061, -0.19627761160446253, 0.13963647569341914, 0.12649883758774655, -0.2574211766034127, -0.19027654264550978, -0.388332430658708, 0.0834267843212291, -0.5034281209544071, -0.1917426421548858, -0.5874106852074971, -0.2509570778120528, -0.01829827029273878, -0.6812516830606995, 0.07616395513752874, 0.48731872286646905, -0.3387106909310449, 0.3342407805724834, 0.14743669931033365, -0.651022281361996, -0.5547768085388384, 0.004162696427877753, -0.6633410397751602, -0.20524632325180958, -0.5363860112654371, -0.4096291715068556, 0.2604090210154951, -0.13085280445068795, 0.3392082969580121, -0.20499297111857137, -0.3281926533294544, -0.029973541569916336, 0.3347333440103824, 0.1403035129746089, -0.4514484097863851, -0.02695491374364225, -0.31810251789023947, -0.5970064149694517, -0.4157243975057869, -0.38958068641013055, 0.14112385337236596, -0.2065322747459174, 0.05732520638155464, -0.18452044084249847, 0.1910275589558515, -0.6273490416591183, -0.5973656723988867, -0.7662014182265152, 0.1657273788995819},
    {-0.5512227795280372, -0.5839521065953976, -0.601144129574425, 0.036801354797319885, 0.41764422821662134, -0.3924767200507369, -0.07720747546100773, -0.19303364259894212, -0.5458776230370885, -0.23748720677535243, 0.32854166944726876, -0.6025091137122162, -0.19153819206734843, 0.4163586456887919, -0.3432768868602375, -0.5582707171857714, 0.33933361915903254, -0.037344035138432534, -0.11001617499032512, -0.38521109303963696, 0.22313516388271065, -0.5474960298473309, 0.2079500420091516, -0.11350737864793584, -0.46894355346536987, -0.5248851625699421, -0.303097672693683, 0.33843226019660605, -0.2501729333316233, -0.21763846361720401, 0.03746438393013648, -0.46695007642924036, 0.5925038498987149, 0.023253258812881955, -0.5625233178306219, -0.24068940776382988, -0.27524721007949443, -0.472365047460036, -0.4929499118083249, -0.4556717351277177, 0.1755516328806652, -0.41625713445093393, -0.4987006551750228, -0.3387380829211636, 0.14750271187894967, -0.5143129312166191, -0.4138011442758961, 0.5531650272912407, 0.10684488503132641, -0.5596611105499063, 0.09834813080841256, -0.5928833149598243, -0.6128925854614408, 0.10646584313472084, 0.11486209073889007, -0.4386417673415835, -0.1218425460804007, -0.5451799241724445, -0.6731127765962415, -0.4427486092096098, 0.24656100549532906, -0.5275127306341337, -0.4810254750944392, -0.12077703382745333},
    {-0.27489704152611355, -0.24722719142868538, -0.415002884954505, -0.013794065869116303, 0.4606456928949461, -0.26649569194412936, 0.009278929446894625, -0.6176857961661597, -0.48154392401271157, 0.23503590012085715, 0.21332515453613163, -0.35949432815686555, -0.09923815156032573, 0.5072133450454704, -0.5282204038391349, 0.09762675678714652, -0.0022582253194785994, 0.6427345954133353, -0.06915801642283892, 0.2546937655349498, 0.05674283315789147, 0.18285660622661098, -0.1293034342540673, 0.059261027549970584, -0.1572023796921201, -0.6278281192392576, -0.5091926878082894, 0.5387228375381379, -0.43991314433693907, 0.13157934802153218, 0.23169152298287699, -0.32853926397848, 0.27410241609933655, 0.28202548633969576, -0.5110446518317712, 0.3161325017024727, 0.03950142029357209, -0.2677253660067617, 0.3639502900080092, -0.4967065915002559, -0.49143913936092326, 0.4848154511260046, 0.1494158992791438, -0.46952636871138353, 0.20277572214545803, -0.17498372134529916, -0.25132919413906457, 0.20451126180828055, -0.3068707807501472, 0.28904319489427094, -0.21139212963953044, -0.3635163193194851, -0.22768093146233245, 0.46790359717253077, -0.4770352100302944, 0.35600457120244405, 0.27972060418267525, -0.31169184790011273, -0.19624406765480165, 0.08486617579026667, -0.24442279655771804, -0.15679834310538984, -0.32366994876405497, -0.47116816435300546},
    {-0.13913992958948657, -0.28634215770363824, -0.15661747365801085, -0.27176669008735976, -0.05642049050673588, -0.47098740954687235, -0.06694672975568168, 0.15202669131533003, -0.4100936931656222, -0.6416635681619995, -0.25019807453064863, 0.08933926503594898, -0.4960868620050838, 0.28369832312787385, 0.2616195881302497, 0.09829766469806436, 0.4542665260969229, 0.4556355373367849, 0.2720632699154529, -0.4325230061762357, 0.41934463414161915, -0.15063683402310027, 0.004265487156645476, -0.5741314803590345, 0.17856129501956086, 0.019604058873944574, -0.2695972331746026, -0.3645076104450271, -0.4317957048290637, 0.013938864201110646, 0.41492118470858225, 0.33452547246950576, -0.23640148025505106, -0.6672316510280197, -0.05955720659990942, 0.43803863321310216, -0.5128381882458923, -0.22645408968860267, -0.2910911047176685, 0.01333515906141562, 0.09693354689573488, 0.6486127687028796, -0.074452569403478, 0.0007837334773608036, -0.09917986213025941, -0.6183567056382264, 0.5253784878664045, 0.14790812217443744, 0.4112385250196324, -0.38167671062085706, -0.14391252350780548, -0.5078860969646746, 0.2064977672998826, -0.19793616114033966, 0.02436291885271702, 0.16964279056765594, 0.5026144427861766, 0.4493328028462637, -0.49130443285085157, 0.3947482866887396, -0.4538648130242486, -0.17545315430699224, -0.08405395083955665, -0.40504441368384986},
    {-0.07606112914618689, 0.0023523005510128676, 0.5147050962114876, -0.32022160672857486, 0.0832085383610665, 0.016340984228158814, -0.19470369974203838, 0.09235265013547547, -0.4198026257204153, -0.2051197423355302, 0.4468669544128493, 0.16768661779281213, 0.32910933057470737, -0.03968466429584388, 0.2025303907486208, -0.0723629289335282, 0.4117843983539341, -0.49561479339179754, -0.3059647662465146, -0.5299105620481854, 0.2429353626265976, -0.17907198208886296, -0.20589781646490252, 0.20522085838407841, -0.41193418241727, -0.21613256805584824, 0.35148061558079563, 0.1933304017160705, -0.1764771774887605, -0.18720919990044493, 0.15675613381032955, 0.26877834913649973, 0.09118489285250056, -0.41195642278223343, -0.1779169124305122, 0.43284697158003144, -0.32449791119706956, -0.5527579769985097, -0.27228896822132953, 0.3834562059052866, 0.032024011588573355, 0.3080645323629863, -0.1821501585984986, -0.49355174361590815, -0.13413407845988326, -0.4723068008482081, 0.3724453137585917, -0.2980193402609793, 0.14634725885166164, -0.32582506746186346, -0.39461378493411053, 0.15090083898122805, 0.04518930935723852, -0.19092971613448387, -0.5218892879177168, -0.0035916632433488633, -0.30048537379279244, 0.43587063235758566, 0.2658034765071202, -0.5613304180216296, 0.3430041255145731, -0.3448366184900161, 0.14288419925532764, -0.3359843462409672},
    {-0.1491238973167721, 0.15208990736451658, -0.42472975714024414, 0.21319449030355184, -0.2707033557183575, 0.6451181041568853, 0.6084683893955158, -0.10216689358288707, -0.003019927599743678, 0.6700331786233257, 0.4281421237323373, 0.08931689156251647, -0.14889218583499486, 0.42907985726602865, 0.5414887646614263, 0.37575299331163325, 0.022464354730384623, -0.06437930609968266, 0.6031772038004974, 0.3948224487316386, -0.2898898396744293, -0.11747483122262492, -0.003913023506926456, 0.1414442811209004, 0.26128563508991803, 0.23658106655679592, 0.09571432328271681, 0.22668340118083605, -0.15181674267320056, 0.38053246549773406, 0.35709502388523806, 0.3686209316001209, 0.14231854091222293, 0.08359235924474302, 0.3228382657732784, -0.39457393199353746, -0.08672223639277155, -0.08031873097780023, 0.3871552556537565, -0.1856358249482141, 0.23281256729622793, 0.7424552211711921, -0.35408118070988, 0.03248669451199905, 0.22967983663535949, -0.05695425393184572, 0.39536834406653265, -0.07626357502331423, 0.18055250665667782, 0.05558729592895938, 0.0919908836099306, -0.06825534817851005, 0.1920934232918055, -0.057597842057149164, -0.026624293706967717, 0.46715841393143404, -0.2650670247242704, 0.0016521905441455324, -0.16973655585844688, -0.24483695917171983, 0.3212698138490179, 0.40093975287345335, -0.48628253764112256, 0.10379744648843568},
    {0.13385112584630718, -0.10178997089761233, -0.4731970483195751, -0.015039819681791607, 0.22345466354159008, -0.30417691293689897, -0.17883752840295844, -0.3471494079036372, -0.3027426942881578, 0.13605120394613657, 0.33653720133634796, 0.2618155769025373, 0.10921025013161408, 0.19019917247446633, -0.25403333462969213, 0.12143756414506014, -0.15513034742037837, -0.03521703683785918, -0.3333767921218299, -0.022653818731089688, 0.04843390734483876, -0.483198018284372, 0.05480898560523447, -0.37826121641178967, -0.321336583240175, -0.5434654869766273, -0.3700653678567574, -0.07733283104311406, -0.06157008147824646, 0.12432619593482597, 0.2603263403752672, 0.39653364190356255, -0.037900733390760465, -0.08941506315353512, -0.3397536911702639, -0.39404366751541786, 0.38718556737755805, -0.5670125620619353, 0.1495610432159906, -0.17617543051287776, -0.22416926800113457, -0.059113446698809004, -0.1353055210589705, -0.3949998166570829, -0.16334723354696068, -0.42616965647800165, 0.0076081973843304266, -0.28438625344951707, -0.5552817657706766, -0.04740884959684975, 0.07260516477400249, -0.19337239811329476, -0.08117721036438716, 0.0012484118756452126, -0.37816937157395436, 0.023331717874509092, 0.10485123127214548, -0.323849844332547, 0.16669045812691505, 0.12308517315967923, -0.21157733082464017, -0.46164764342670883, -0.017102430573766203, -0.2530563340498403},
    {0.035442014452100594, 0.00945343684983199, -0.2413955437159132, 0.5415672961398823, 0.2500538476468709, 0.47840165719355704, 0.15264317556258541, -0.28197035572882123, -0.48523949468257654, 0.49415747401879595, 0.11514889159164973, 0.15133152462799587, -0.04757715944297969, 0.5473935587119277, 0.16797747816682496, 0.1546982233020394, 0.430261752653944, -0.22979447016912824, 0.06932462572539191, -0.08375951771546257, -0.16753838489668998, 0.5400932448104815, 0.4313095199198279, 0.3568225250326504, 0.3125018197805124, -0.030335537345967924, 0.24196357221740958, -0.33139967076653276, 0.20701471809597827, -0.03671133262015951, -0.39056699944037726, -0.07091394277814557, -0.22147367584764127, -0.3114173786160543, -0.21533037866431637, 0.41856439587368, 0.1525410333002123, -0.0725043370777359, 0.05510941163958786, -0.11967662420680597, 0.6407196269639354, 0.5005461958948242, 0.1510081853487243, 0.21660102579690457, -0.21793175720874064, 0.15738790374804407, 0.227947413070984, 0.01719683148503475, 0.061348198067751325, 0.35466006496339525, -0.14638518260150846, 0.3551741769939252, 0.39875130115400864, -0.010877745872208642, 0.2608259559934499, 0.05225267094208386, 0.24402378744195857, 0.06823662118374134, -0.24157386750353937, -0.32293827664716407, 0.6109750960176416, 0.393984937723975, -0.1007120245559206, 0.01567300643560788},
    {-0.19087544528429073, -0.2674107588725375, -0.2450938675485527, 0.4287162397999217, 0.5908727945224175, 0.4815820339139754, 0.4454448393643887, -0.2405374226113605, -0.3513817895948545, -0.0871893593738462, -0.19658225910059549, 0.3567369432238521, 0.1936419312730302, 0.6963477033103607, -0.2645293138119386, -0.018909351095047836, 0.15921467462851313, 0.06129737022309626, 0.11135454810050997, 0.009882003390137041, -0.05605933180757559, 0.1984480750113882, 0.04492284901671337, -0.0613199443753028, 0.012207708813869097, 0.0245538315997853, -0.30274763425211604, -0.15962677561045266, 0.24609495457555117, -0.23056911888795634, 0.45442886521648584, 0.011214553105297956, -0.0023622768678789896, 0.3450870194113458, 0.6360548582920792, -0.1508934132293543, -0.0266574076933792, 0.6866569236765876, -0.04720178652864952, -0.4401543455050219, 0.4151358459201486, 0.7492910918018629, 0.13055815101871757, 0.1195793025945896, -0.3299166351357831, 0.4055931869308966, 0.4208529092653548, 0.4168305848693955, 0.3981114430839545, 0.4666461744314096, -0.12097058928218166, -0.1955638281813277, 0.1215385723001557, -0.2929890251250798, 0.2791035242366087, 0.19059962347885906, -0.406344785047909, -0.271696533029962, 0.05455300537121174, -0.36696289200661014, 0.35235255684667033, 0.4428777819123967, 0.05574293275879301, -0.24858979299908127},
    {0.09909986504547433, 0.22867250593383912, 0.037014611838561036, 0.6063222641335392, 0.4467208694848513, -0.25531174414299396, 0.39195799106408774, -0.6458843722772193, 0.15908207570717853, -0.3269025261685454, 0.3984680288991368, 0.16826097429510045, -0.0012484395982267902, 0.490409417980611, 0.0007945288196678737, -0.4731194670021731, 0.1609664381700394, 0.5039698503811474, -0.46770867709395514, 0.2489573704559903, -0.24660640065016998, -0.13430170664363508, 0.10586135585693071, -0.06386325136183772, 0.06541136941609343, 0.40603735007900466, -0.17207206538698458, -0.06013527202441035, -0.29800429400311657, -0.11109358073818162, 0.15833353604137793, 0.38221929111219, 0.27265948356284525, 0.2054502517109384, 0.38390147427022536, 0.061087639131740146, 0.371385890338358, 0.08043510348754428, -0.09597865081034966, -0.20939996425703417, 0.5101390649145353, -0.2701694674421253, 0.06097352078207475, -0.016476910871876443, -0.06424935961707004, -0.558906926586071, 0.13142560883914067, 0.12916749332878114, -0.48614530117366694, -0.19422539668033134, 0.19372293096115134, -0.03443020072846894, 0.5140280601747077, 0.2708438711133505, 0.3248840123036929, 0.08010499323784168, -0.10193250228904864, 0.08703111034876554, -0.09605406626952429, 0.16519784547390634, 0.11180351931016153, 0.5019849533009796, 0.44439496497999353, 0.14313532573925636},
    {0.13209897514452207, 0.09504795628306882, -0.6826792818200753, 0.07932909925885004, 0.43281762963271136, 0.08502737678979251, 0.28399353875426553, -0.6217744907742759, 0.019011746967380075, -0.40840342794423223, -0.6474317443678297, -0.6769253775697036, -0.21804181792782962, -0.3121571361862105, -0.28356699939164726, -0.017024982388098076, 0.05150190903889619, -0.058218704469366306, -0.2538559825100809, -0.3995120794734864, -0.22469386553465093, 0.3869112746981878, 0.462738809534191, 0.4398683248404103, -0.15328839077201656, 0.42814578712408424, -0.10121593417609813, 0.41510470742779015, 0.3205443819616263, 0.30403695555025334, 0.1289656521301775, 0.10251686524923588, 0.34925376741441666, -0.1726992403710834, 0.18520170459457158, -0.09780191257572521, -0.1518073612148896, 0.13804171138926039, 0.37130596302360475, 0.36761299339838277, 0.03462395404732956, 0.10013809059568368, -0.4849961817605203, -0.3870436783887998, 0.058686497322478014, -0.2888897501272147, 0.704154400921658, -0.5214802427132389, 0.03953653166938063, 0.44434853672986324, 0.1618665790599721, 0.13110401027270813, -0.37115734187181665, -0.08150293636204599, 0.08866402350549284, 0.24960140172693435, 0.1752070495017439, -0.20477660640794312, 0.4099429470436794, 0.43786267851599076, 0.15297450841197427, 0.560384461498705, 0.28306774706125154, -0.46803549853454246},
    {-0.2353375346949669, 0.18677322628800405, -0.5103495368102411, 0.5667212291994717, 0.537811232173235, 0.18127150886467164, 0.5095504222545273, -0.4593249393295028, -0.4353867311549063, -0.13205613142327996, -0.22345596215175134, -0.350706102185536, -0.43699578782817283, 0.017425980027315657, -0.4090068825356985, 0.11201542575177119, 0.06299043987215516, -0.20106447805225305, 0.3627537085296982, -0.5977394999590842, -0.02086828577479955, 0.704964946375995, 0.350062270438592, 0.3435723394287771, 0.11791500254584023, 0.4591020022279155, -0.12236037174918522, -0.2951934125286763, -0.11494191423250699, -0.3294583478712704, 0.13543075970727075, -0.22464740687169982, 0.27365033838293984, -0.3630609002872511, -0.04945511451832814, 0.5993609750196887, -0.22847484948219918, 0.07545706380592233, 0.2289657528884443, 0.47955734767078606, -0.18541484711160383, 0.03392889815006754, 0.3667465596464127, -0.11043124565614452, 0.5363183946712824, -0.08318195884214886, 0.4217080075155602, 0.13463180654208715, 0.42493387922287845, 0.3170253853375963, -0.2130453930324882, 0.012290681977758549, -0.26805485885385755, -0.11590464232757167, -0.38015301058182677, -0.040686941969794, 0.5220528114302558, -0.12461631558054857, 0.34051601119410735, -0.08966241901483951, 0.05830094533457814, 0.3698769412634728, -0.10236262105801984, -0.16323556006040674},
    {-0.36338493469925426, 0.4506232512032894, -0.047886536223602005, 0.43073560822616236, 0.3728747067659569, 0.017246555261284862, 0.10253205431910838, -0.7034420922660576, -0.17007181780437317, -0.12557390878435487, -0.11073574618269416, -0.40128490160995706, -0.39485159743405424, 0.41063091145785474, 0.6529705597148977, -0.42617407757947984, 0.577332598419122, 0.16372986442067713, 0.1783616376848649, 0.13391330467201704, -0.324245404517364, 0.38504496914382613, -0.09388487495131045, -0.13112528477247692, -0.193647944408874, 0.4678997438685165, 0.32986265079146115, 0.2029076396286651, -0.3588272218165349, -0.16213255687784417, -0.4205235250254138, 0.01756834814709491, 0.165292292346902, -0.31759968879685735, -0.10039154355821718, -0.028129321653370704, 0.06702087356318041, -0.21501837445296718, -0.11601766076550199, 0.49419056258889144, 0.06884169356629585, -0.213959198368837, 0.6340479144825716, -0.472469000132948, 0.14621922174819307, 0.007712993555801157, -0.06451168652700691, -0.2058574180343503, -0.3609985885119644, 0.19429561890012617, 0.5856276532461907, -0.12496718841035599, -0.5582705694981867, -0.009159944033686215, -0.3986543250566442, -0.5330378977865389, 0.013360241287656066, 0.20608547520335618, 0.07438817126078112, -0.47187896294159, 0.22654959073554898, 0.4148365299365435, 0.4628056242691924, -0.02170357989870795},
    {0.01871588700464044, 0.4505081222600333, 0.1489400807715421, 0.6311260982760026, -0.04717070298760843, -0.0650407556223444, 0.15993036188983778, -0.7063202479026993, 0.45453967130416667, -0.20150418333976564, 0.11765368954136667, -0.5644152623451455, 0.16519058101025144, 0.16860215051825145, 0.07675160024847441, -0.2320840602242338, 0.6045779236235006, 0.06830445734593577, 0.07146748923293092, -0.5747016391770595, -0.28616051634617057, 0.5688586568943459, 0.5173242724276987, 0.20402374770143475, -0.06904464553221265, 0.6821237837559978, 0.4701077053673974, 0.32358960464290676, -0.4701823783548535, -0.14512090288705382, 0.24948633400636747, 0.15687933145560612, -0.008868104874359262, 0.11652250937438222, 0.3258716142159853, 0.09929317129031391, 0.32171341435076206, 0.43439246185009894, -0.3820696394661652, 0.19725713647551804, 0.5103442888778212, 0.3159735982739288, 0.2740062088318215, 0.0937023307444971, 0.3209392382063905, -0.1686463690036934, -0.23905814808651146, 0.1986607531543421, 0.23004769535618547, 0.3431952689696857, 0.0953563939860494, -0.4593560376809315, -0.301989288733532, 0.07434733903365284, 0.11813652743732408, 0.16055433556244564, -0.526956514674032, -0.06130608768452299, 0.24582788644583983, 0.632266232184429, -0.04933366102087223, -0.1430544870371619, -0.09622450748854777, -0.37577562021813266},
    {0.2971116900220781, -0.11962445488476285, 0.01331158834817501, 0.291340751803736, 0.2707735394875373, -0.12301424869566312, -0.250356832990765, -0.5602161601246962, -0.16821423707266744, 0.26564813917534424, -0.3267196356954102, -0.4246482247824639, 0.09927397068936733, 0.09705729027483836, 0.327544290428321, 0.21108383118830473, 0.4203432254219769, -0.1874946984183558, 0.06824198359524389, 0.3590713665837459, -0.18441907913745553, 0.5546441972573213, 0.5255726068896938, 0.43483016752221515, -0.1739049977247502, 0.09147769251319145, 0.6206679238962428, -0.09759634193326677, 0.5087088845534634, -0.09085270035172598, 0.24225515708931109, 0.16581053328858555, 0.014559498990431961, -0.32837119244446544, 0.1556951200613984, 0.5133937095541674, -0.040687860139675076, 0.40331703321383094, 0.027621747873957277, 0.4474918720175376, 0.5893333095742972, 0.5595357965416707, 0.3639546498197471, -0.3473034826195101, 0.2769016788920965, -0.19802453630264497, 0.7282196944215968, 0.10088198283759962, 0.5805779034202306, 0.015018372771437442, 0.3407579022522636, 0.11058156582284319, 0.45934706599367625, 0.5010060549121579, -0.13806917057786394, 0.14749797029236772, 0.1422754063833616, 0.18182062197163623, -0.30006428711805344, 0.09275858968132089, -0.16323510652140982, 0.32906063149680903, 0.5186458351766432, 0.07516118960236899},
    {-0.09115746313609913, -0.19858433434651454, 0.022270081690247377, 0.06217338417029217, 0.1486032854094883, -0.507079573290348, -0.050544658587795756, -0.5258932121739214, -0.22744348540788228, 0.022708917181490526, 0.1211727676533032, -0.2678146096779706, 0.41561736575811564, 0.31391892415778155, 0.3701937988054142, 0.19906916954496187, 0.21439155583832653, 0.12324163433852856, 0.3298649500162491, -0.34253161098363444, 0.013521941794772773, -0.22127674585930146, 0.1385248563058749, 0.4438642488722898, -0.011003923018882504, -0.2551427247587429, 0.041930742926974, 0.23028710703659133, 0.17803313051648997, 0.03530632597884972, -0.2362230260433394, -0.3421653799529697, 0.44847755556112073, -0.2690733010586338, 0.27651026942197593, 0.349474694252396, -0.37643336686484136, -0.5872444880797428, 0.38303733663092066, -0.2275791044756148, 0.013473446868704086, 0.31751262300819133, -0.2933353555101254, 0.23746080960851398, 0.13192819338894113, -0.0029027244785781825, 0.6653969495989339, 0.10177887388280739, 0.4197133111813676, -0.005321551329528984, -0.10908675350920222, 0.018700791085858638, 0.4282009122867591, 0.42363259026722583, -0.4225679736734372, 0.1528503265309988, 0.06576403501088197, -0.25084681389596486, 0.33049494839654453, 0.3935707794876959, -0.35307620011062363, 0.3657026328442878, 0.011182818545605478, -0.26616766742251946},
    {0.003867070883825743, -0.27507256658974666, 0.10807759057196994, -0.020190766730746983, 0.22490627996887258, -0.1921291120419291, 0.20943327166294354, -0.4665041404606637, 0.13843405104824857, 0.4064319956591395, -0.30565687048677065, 0.21076962435125615, -0.471990405975777, -0.10808765210797194, 0.2530444416241651, 0.38876725276120155, -0.1976257444703982, 0.32253325178414527, 0.10377742204616726, -0.12468518816187314, -0.022355869165028703, -0.10950322761534018, 0.30181670823854184, -0.04817873062268509, 0.37225100510130316, 0.4175613749863448, 0.1020256469352609, -0.42896071507929445, 0.23715426854608918, -0.16794274344147625, -0.19055333277578698, 0.11668368129803734, 0.41082511690138673, 0.5627454155491954, -0.016376420586973972, 0.2596764549893431, 0.37664352564273335, -0.13081755782665802, 0.05874152451295504, -0.4089818260966856, 0.1379335317101925, 0.02831015539390056, -0.07216468585137652, 0.3809958036726717, 0.19693025700747419, 0.03931994912815007, 0.0065185500021867045, 0.5358798144438481, 0.32492133674644075, -0.10408482095187752, 0.02939260548685683, -0.3471574027000333, -0.17456677874345056, 0.022560910152162193, -0.04019288448817902, 0.2982804032610424, -0.21309932946093624, 0.14013653872477758, -0.16878473286074924, 0.24165347800896692, 0.27740326348324434, 0.39057912350171964, -0.10905267587659073, 0.2972115448868819},
    {-0.45833997825082573, 0.2719771383332051, 0.28336612824346197, 0.43665406161889203, 0.3256297015777733, -0.07037972354182095, 0.15536360841328653, -0.2473784778174391, 0.0838329754556551, 0.022009773351520916, -0.040327214823362836, -0.29908288107487585, -0.3236307051679871, -0.5879827677794316, -0.3513304395075488, 0.03758601686719151, 0.13547197107049744, -0.305736226823172, 0.05005182073834199, 0.053975429358558966, -0.022626745307769473, -0.3818600723452812, -0.15636675403691844, 0.030350441847563747, -0.40823306127167974, 0.06647739727252719, -0.6326253209813565, 0.02960428653071808, -0.0608067276813777, -0.07088426167462067, -0.4466047751110656, -0.0014799647623309942, -0.20495436000195869, 0.33676741057234116, 0.1155457061074522, -0.30749980997228415, 0.3551056814378437, -0.009960049497106816, -0.04881264202767853, -0.12229247590526994, -0.058626721888536314, 0.2025816561920486, -0.1914653922474094, -0.25825808360113295, 0.2773426692292327, -0.16405798140602762, -0.3645541313721331, 0.5928023230433341, -0.32010139075003713, 0.21135875776513127, 0.19321589923137344, -0.500042957955676, 0.15192931062859003, -0.3076484982482591, 0.16787852503195175, -0.09970342361744067, 0.24664112272456268, 0.028255024851987415, -0.45024936088476697, -0.20241958906590804, 0.42487446233808907, 0.5068485617041641, -0.41109911972027474, -0.4068435268755917},
    {0.23891235765303337, -0.05190968005254443, 0.019288101550109543, 0.4159783137525691, 0.0952549219945617, -0.03437633721168648, 0.2656651015981244, -0.11089471366850139, 0.070676943472223, -0.13193368657162302, -0.03405593817213932, 0.21859619765871371, -0.11179827977228161, 0.3793654926117528, -0.2183464356868003, -0.006484194101576772, 0.030395990001590836, 0.2453704827617076, 0.47226369053593725, -0.0031251531087730395, -0.15420122332536088, -0.3123559060591942, -0.0671620739170527, 0.4783512630864972, 0.4930984349801325, 0.0029857866826933947, 0.2793145897463622, 0.13235008308319193, 0.45004349362753604, -0.5115047246525096, -0.35774624584775505, -0.10783423312296421, 0.5092863896473142, 0.3162529468256587, 0.15173146365365647, -0.2702301435835617, -0.19177836453877434, 0.1305179847578968, 0.3077408692497999, 0.2494459549700176, 0.3319086878850267, -0.15516908684378436, 0.26144466577022807, 0.2265341837168279, 0.44579864472446556, -0.10349064309191112, 0.2753769912526603, 0.08754772097788331, -0.3128708357720709, 0.3808825624099223, -0.2741893690670775, 0.07855371235504528, 0.46104391175955434, 0.14176834521715498, 0.3338999922354385, 0.4064832552243078, -0.34480516336879174, -0.30659214326956585, -0.07705679872109525, -0.3630191008648158, -0.3848206507920725, -0.2616897815583986, -0.0893140282389967, -0.10258493516357407},
    {-0.3620194913940402, -0.09351126702943485, -0.30840270558443467, -0.2194246661912711, 0.4209386179172255, 0.35452876557670354, -0.2385763686761974, -0.39075040070508754, -0.3505011006446851, -0.4389555549737317, -0.03265875926396752, -0.5822649063002598, -0.5045991713469231, 0.5593080092548324, 0.5738965202671324, -0.5613883960409634, -0.18823549405007892, 0.30216202695110816, -0.00013898226511834495, -0.1875967089029734, 0.27098171879894517, -0.27500580284483944, -0.14106427729853743, -0.3742057405617992, -0.053062370813371465, -0.05062446762236006, 0.06063975052671247, 0.2546896013579964, -0.24401798362482555, -0.12783410364660586, -0.03455322972976511, 0.5034209358526401, 0.28311760566739946, 0.36537784620667146, -0.5526518512079671, -0.3904589013808844, 0.25728534748891524, 0.13604140021281103, 0.2307891396412983, -0.47333777778166675, -0.18905995177567744, -0.28737998755647065, -0.5213214699468193, 0.17317632920895265, 0.07840444176110156, -0.12422053782167877, 0.4116625619408533, 0.23402477418721143, 0.1150276351640835, -0.2859252202166485, -0.23973025502551254, -0.11591042676370371, 0.41039017638342434, 0.3998812507344067, 0.2552660782789889, -0.3501481928866148, -0.4709176972773436, 0.13327628161493427, -0.7347631796063534, 0.34774616823812277, 0.5510184209491891, -0.3043062672467821, -0.22917423203495035, 0.11539444841606435},
    {-0.4279719057243011, -0.4061486093974136, -0.2253536840834886, -0.19283296323416246, 0.36965260636668784, -0.08248253241452592, -0.26815052565785835, -0.3208998249308817, -0.26102360075654146, -0.46725083658042427, -0.1702707390164279, 0.3317990224597651, -0.15057504754752987, 0.2006237164128763, -0.2510350543982839, -0.596763073063842, 0.16366283030037101, -0.18009754564504224, 0.008174732723762158, 0.1892049366072356, -0.2750015737038239, -0.6063804550707715, -0.17040134128307252, -0.047340515165416625, -0.5005431541897368, 0.028348767513500024, -0.07266461348796249, 0.1276630140163144, -0.3963280219746518, 0.6638603397261943, 0.1295966883732891, -0.5579999097376133, 0.24649047517061057, 0.3055712451199738, 0.01316266202608095, -0.018412483311847076, 0.06164564887064446, -0.03741761108223982, -0.3110346238770658, -0.17267359825363177, 0.09769904933872675, -0.21422096974465565, -0.48818365922034823, -0.26524812521028424, -0.3237056672069737, 0.13154793836111833, -0.34446697580754726, 0.27172780237940874, 0.2434821364706036, -0.38789203180794907, 0.15291328654808833, -0.19628896866288137, 0.33357148835493045, -0.4549816931568768, 0.027061857187615203, -0.21611061065461967, -0.18240185008016818, -0.46763764327128654, -0.5355972708291528, 0.24604998655894855, 0.028990556224244988, -0.21285113252342186, 0.23132774171652573, 0.18012370640843142},
    {-0.10764666167173255, -0.29741047162709394, -0.5909863186224363, -0.13103233534833492, 0.5509082146819614, 0.44754613819620714, 0.0715784686143409, -0.266575115760007, 0.21427359189139064, -0.059298228871575966, -0.21880204472810777, -0.08634200327650081, 0.17502548567537907, 0.2442431475063013, -0.04150967343687595, -0.035369007162463856, -0.41004389199489216, 0.3851585361081035, 0.13921826916617513, 0.07947291515664079, 0.44466462634235004, 0.09205332517773748, -0.10795108182819463, -0.18846391566966936, -0.0940617986013636, -0.22739576855117746, -0.4926004718799411, 0.5577477520193113, -0.19448399289669221, -0.27104420504993565, 0.20377316053534486, -0.5247433655342435, 0.1602978664955543, 0.1938628891883355, -0.12447257988140129, -0.2540691611719566, 0.44226379048380643, 0.01723340613567249, 0.523635347008263, -0.4027140907755045, 0.29413347617518676, 0.439805382425274, 0.2523671724373122, 0.07031739057720243, -0.20336748731623217, 0.1510363735954839, 0.5618959849354996, 0.39761538211453873, 0.13620946488076008, 0.04731688083339478, 0.2398881484202044, 0.2408879207091459, 0.3335794202473025, -0.2933730373059024, 0.4059523241865154, 0.32691000945314813, -0.3546930105928373, -0.34750373514810196, -0.14604060490653975, -0.10441782637075465, -0.1317866449671841, -0.4318587264511603, -0.3376399209610422, 0.5935511409487276},
    {0.28442644806532436, 0.07001004396741577, -0.4092599015364151, -0.17491455293398306, 0.2530821547594221, 0.6533901113624195, 0.4734588947402669, -0.2174538432836826, 0.1378678292915831, 0.40169513127886686, -0.2620614119398045, -0.23966257349712006, -0.10665996589966856, 0.05723596182861455, 0.6081742158204165, 0.1749774165835098, -0.2500529025107509, 0.2514316124835739, 0.6295883012917581, 0.12123343008496883, -0.12741215515699147, 0.3738442711536838, 0.31936823931134023, 0.22794044431447333, -0.39349530219702117, 0.10479188950392446, -0.3891181998120139, 0.6026620943622547, -0.21066851511479878, 0.3470870551033788, -0.07883389315640577, 0.09578178997997364, 0.5982637034851802, 0.3008726642213606, 0.35703830185691376, -0.003143508287524326, 0.45133654122403905, 0.6213050570558429, 0.6463545948571312, 0.05784928180689001, 0.26009249925069994, 0.5630095822050117, -0.18040823084911994, 0.6031032208569799, 0.014963087922953144, 0.2521661191982747, -0.4583348648587381, 0.6445213404848836, 0.19729340590908095, 0.06350188889132515, -0.16023166470365321, 0.5290025506818603, 0.18598263312348387, 0.6276165739325603, -0.22790612044373515, -0.11577301831686336, -0.14166533679880838, -0.34563500157295773, 0.38558150477882186, 0.22884624007932267, -0.241348672624348, 0.5052760986054347, -0.39188116462383604, 0.5018579758295025},
    {0.19102938865306165, 0.19630139666184476, 0.23602644069480633, 0.15584432267192977, -0.18240242456992917, 0.04296832627510497, -0.003360610456793363, -0.07312086558947928, 0.04398634860159421, 0.4101743019702526, -0.39096294188647074, -0.4108164791499717, 0.4475685654809647, -0.011204192718586506, 0.48191594447472225, 0.16627981685023385, -0.07114195810648155, 0.17351428355219578, -0.11871261101663326, -0.06955811234455861, 0.052876119181383054, 0.079058389224447, 0.27463886928274955, 0.2090822109878103, 0.011243205212722047, -0.026800888128969004, 0.25595867731833194, -0.2228325499341177, 0.15275866967254031, 0.19695246219347046, 0.13377391280294362, 0.0349565457275192, -0.21107448148239055, 0.17171233924948595, 0.23440986793637258, -0.05994467427266672, 0.23118984638846382, -0.10697367106847802, -0.11578467507477819, -0.13537954258100451, 0.508449777758424, -0.27749940144057145, -0.08569157195132529, 0.09318813495788161, 0.078290609641437, 0.37718808166348505, -0.03783972737002583, 0.43191860526777126, 0.2762968845375328, 0.19244798521337594, 0.24453007014442008, 0.2828076122473285, 0.1262583541468446, -0.10477268553117186, -0.1773283318714561, -0.1491224831360791, -0.0106861564596507, -0.16951628227209944, 0.30759056094323356, -0.26167390883276864, -0.15736243546531373, 0.08918972200538253, 0.10553140429180226, -0.15448664671890144},
    {-0.31889480957431443, 0.10894476339026007, -0.010810701895508553, 0.2357595617394613, -0.24565125849852235, -0.06857215299692807, -0.013334251831835819, 0.1045480324530383, 0.15260999021138832, 0.04780847231255216, -0.09310489564926606, -0.010069581221205196, -0.45393011681670603, 0.08864666939211864, 0.19833896272406962, 0.03966572022387404, -0.31342550842984734, -0.26074274664129937, -0.45496600488122346, -0.4562097010437673, -0.3753802838318274, -0.3529503690078086, 0.017422147469597606, -0.10269385976718254, 0.34160601056513845, 0.05854659976696785, 0.15785791618337688, -0.1295021740896221, -0.21844430838522721, 0.26938790817674035, -0.21029296055459382, 0.09444372916083087, 0.07622174920577833, -0.22684082463340222, 0.1297621183704687, -0.13639957513324752, -0.18777564268056335, -0.14592225426211852, -0.525025229683127, 0.2700689438647424, 0.10306933216527916, -0.4196355283390338, 0.06249713268360731, 0.026210602564113297, -0.23142023074413337, -0.49165034143102904, -0.30727915485353274, 0.0047178201730469944, 0.3144632254113563, -0.5638022786723326, -0.20509155922746783, -0.3172225195921763, -0.2860182671123828, -0.23497471608363515, 0.3588379382489097, -0.051074504849966805, -0.21157179192439018, -0.009979934841257554, -0.4627568729252713, -0.11277949913443339, -0.37866530451431596, -0.08293149598549063, -0.23737410532209774, -0.20386221213646843},
    {0.2850931675621879, -0.08422982245685559, -0.07119544553182386, -0.27722369109863887, -0.4003945871736747, -0.18487646896401905, -0.050780280920612486, 0.2452810195176599, -0.50308272542109, 0.39310942264381354, 0.12350889043835742, -0.24023498578124539, 0.10784948812392336, -0.012001701275016891, -0.23542871913329874, 0.07698413636154948, -0.1144664401800808, 0.31014984448839017, 0.35416951193226087, 0.015015425803400526, 0.4996885409986568, -0.001057180147536765, 0.2924069673983975, -0.25035103556051347, 0.13728250341218176, -0.15095376724778314, 0.06106187099673766, 0.10394626707885499, -0.16693510342684584, -0.19451560645223206, 0.27170249759091397, 0.10620036865307105, -0.13935042955325538, 0.00032110652287542935, -0.03207765264109609, 0.025273244678684442, 0.21417448954489576, 0.42494611476948785, -0.3167014368972584, 0.0352688603441564, -0.1663893233558566, -0.12385396870121762, 0.003929358198540962, -0.20716577125208965, 0.16565279091106147, 0.17811710496281405, -0.25118440566681055, -0.18719841735353232, -0.09636916803494248, 0.333230426678542, -0.053920868419108904, -0.07143239721578551, 0.3756626185314861, 0.13293368393736635, 0.30392398083650796, -0.15329348950940325, 0.19718100972536734, 0.15709172655047315, 0.04420103287901935, 0.005404085454255361, 0.3908173337750846, -0.044971278965971036, -0.14231976087961049, -0.1298664460099785},
    {-0.14814776155802298, -0.4033528866821834, -0.12197726787722785, -0.43376324429691787, 0.37535873338843706, -0.12570430995999018, 0.22297302899981897, 0.26250161005747324, -0.4642892411870456, -0.11875688147035507, 0.323391712665909, 0.22770586168660364, -0.2716939207694867, -0.1499863904441512, -0.5108857401804857, 0.2137848218421692, 0.1357501084620561, 0.1143059623884319, 0.020639070053117586, -0.12039845456202057, 0.21565990365439702, 0.1586278223206349, 0.2132859217853164, 0.052503347907739646, -0.5067539042035112, -0.04782933587178236, 0.22997690990512085, -0.3066125949420302, -0.09870049599912918, -0.11579009563599776, -0.15616631867681569, -0.18419720496708444, 0.1984356446484575, -0.2741125764458171, -0.27263670572991894, 0.041516195931908924, -0.01944625061727699, -0.2978018624904788, -0.40960605759951824, -0.12362521567858696, -0.26844652989236245, -0.18002873589832924, 0.22084879685335987, -0.5104700640308013, -0.013244303841215862, -0.05519788317971646, 0.38935061722169895, 0.12266385874115898, -0.18647875887798715, 0.44863286888688003, -0.022668015386381215, -0.10599124433100035, 0.3568322084366951, -0.26051177162137273, 0.17689281864940165, -0.10723038727034954, 0.2568963757463901, 0.013652834277242634, 0.024245873692208108, 0.35663919676307404, 0.1628166301194788, 0.15375929463150262, 0.05599678339654206, 0.0710981518433948},
    {0.2611721596388686, -0.009542480040301988, -0.449688606149418, -0.007075603678024772, 0.15572083720815855, 0.2546737440372328, 0.3453494623548372, -0.47327992223103543, 0.24822565715369285, -0.387132437225317, -0.4175451526904106, 0.4426242716337887, -0.2954311104332007, 0.10186276414465341, -0.197219986912462, 0.09784310193462219, 0.37141789518278395, -0.47654355417746774, 0.10497909200110182, 0.3074467038198599, -0.030922251499219462, 0.020926882891768573, -0.15688938024208396, 0.10370799625371772, -0.3511821034072239, 0.03420750401805782, 0.0966689683322658, -0.3731978193688565, 0.5237086155131183, 0.020469589932130765, -0.057406944654601465, -0.2752569687167397, 0.21602206608569052, -0.00609216677868203, 0.09944505947326866, -0.2580182733641893, 0.14041684844410643, -0.3949263202609906, -0.13016574518141877, -0.11172674223463737, -0.49844801754169116, 0.381048130628603, -0.0020143420529505273, -0.5560750917801546, 0.19513055224080614, 0.19749370348063347, 0.30537010825379374, -0.18002255237844672, -0.09015463382793086, 0.391059637747166, -0.40705150632267706, 0.24966722846801398, -0.13330361008390357, -0.12705255996805465, -0.4016346165224806, 0.26064973650975715, 0.3205498292418964, 0.2683075637701556, -0.10819011087013608, -0.02478359120624901, -0.44687012200713894, -0.16060835649701977, 0.07485022739932111, -0.29608216316614955},
    {0.3909768107894202, 0.08766011312232388, -0.4602981733160657, -0.12195194781524285, 0.1641466976047444, -0.21596581822060587, 0.4681154989608192, 0.315392089262613, 0.5132898130315622, -0.156284237023883, 0.23205208442162578, 0.419347783282794, -0.1478015162657578, -0.12300467998998106, 0.3447593175190644, 0.14934164351625526, 0.07877223410054193, -0.48789887404790194, -0.13695785663802515, 0.3363529557396518, 0.07344859001603236, -0.1063558285803077, -0.16668295212752318, -0.10985769491084031, -0.19086075859199456, 0.27317139666745566, -0.3011353437496295, 0.054493400883812035, 0.4947873892870142, -0.31278929093980545, -0.2546200090884758, -0.3132696107327312, -0.22716835546518324, 0.005342370952179462, 0.006770839248300984, -0.055228343001405555, 0.1501594765420875, 0.21351474154867464, 0.2900065125889924, -0.09204008505787112, 0.29037410336884273, 0.011776742017981044, -0.19369303012077727, 0.11751216503190016, -0.4403322848762416, 0.0480939842993421, 0.05038006434594428, 0.23210127003587624, 0.37085835695713076, 0.23143052787083307, 0.12504509356392243, 0.228015153897, -0.2487900871904814, 0.09233783925268821, -0.21656716340268395, -0.07688688994095308, -0.21289550461419673, 0.05829064388483714, 0.2003985545987423, -0.3911699653981959, 0.03056693255145991, -0.15704420273427222, 0.0777533189316018, 0.3168385011381589},
    {0.20676205646945045, 0.30713951583241167, -0.10300976174685812, 0.3022103280147155, 0.47995274189327514, -0.25023807969122025, 0.3255333802335902, 0.43695497326581156, 0.4849634872463725, 0.4501645247569058, 0.30937857444321964, -0.1760790812857157, 0.1356372609900634, 0.10007752611320186, 0.39356018722113884, 0.1322605691924103, -0.3467288787738827, 0.1624964619816146, 0.040426061566732154, 0.026107992461970868, -0.24591896871061442, 0.21137652559433792, -0.07458053306626065, -0.3745150904384298, -0.1929433293888059, -0.2585708363206454, -0.13745407060653425, 0.16890752412451832, -0.19647900832398352, 0.03859758093505784, 0.1719349354024736, 0.07624802763801801, 0.18517472144893343, 0.20442240977624299, 0.3000154387272259, -0.11800546352095743, 0.3904565119206329, -0.2343765654848945, 0.08597149027816141, -0.16981883028555197, -0.05741311904530388, -0.19450689653716502, -0.1219363017626807, 0.11179884636544438, -0.24133528502194565, 0.42600367906689157, -0.14998786445520365, -0.2782879972013512, 0.28982731215646257, -0.14509730150084862, 0.4152917691651251, 0.252825681367145, 0.33735108323076607, 0.4077601182508957, 0.261285724372824, -0.21339162086626495, -0.3712569344198549, -0.1281846939971137, -0.05980134756109065, -0.5145987713626577, 0.54730444203557, 0.10597434958763613, -0.1537951748264539, 0.31354015662452106},
    {0.2963406909511709, -0.18071366693492802, -0.3154953295186027, 0.5093026131590948, -0.049351068671274034, -0.4644145017722084, -0.18231727140900858, 0.289344529644906, -0.019845461980731262, -0.24876693938578298, 0.1785274374181142, -0.17626690035693288, 0.010109867202717226, -0.38695618497598866, -0.4302245129600579, -0.2779889828898556, -0.32972604459369187, -0.035165503693251186, 0.4364379999937564, -0.18720749335755343, 0.0974400416428041, -0.106781110330993, -0.1277295692355318, -0.4762370926897084, -0.13544861505882863, -0.2596020196452756, -0.33580920981921847, 0.5027887114473608, -0.14446229624254614, 0.25676051459902716, 0.2015353789451392, -0.0960465792597905, -0.08940199060688778, 0.013735750101890824, 0.1358670509831572, -0.2920012152710148, -0.05896408437849489, -0.1355223532822906, -0.3137491776606795, -0.36874654840552096, -0.4805299036143764, 0.1802630365065272, -0.3157115851952013, 0.35319448538554526, 0.2824553010686475, 0.07846709271256684, -0.2637544304720217, -0.2908604298820289, -0.520578807026252, -0.1981909057641137, -0.04379097258309921, -0.2829598455777441, 0.35262409073008655, 0.389488398108114, 0.30971217778887716, 0.26965597866937635, 0.2024967030123402, 0.19570718373520257, -0.12117017864815041, -0.19715277316778113, 0.12342101114564277, 0.05627318955454661, -0.032736343473291483, 0.3559664006329964},
    {-0.16964077799464727, 0.10143494794012489, -0.43279862403047775, 0.2734186062778508, -0.295308218345273, -0.36274053131390305, -0.4965849096799236, -0.013188349848246595, 0.23014996407596292, -0.5616446452331993, 0.31182208258317345, 0.008377143744421141, 0.20146395847407933, -0.4509232621291179, -0.22478011026945993, -0.37046709758258345, -0.26906665003151986, -0.22078001276141995, -0.39003161948287035, 0.038255931056841004, 0.4796682719156483, -0.2934420822226079, 0.2695837397233633, -0.15533902498369656, -0.012858546117243264, 0.2275950904895886, -0.32773434980924926, -0.004893118150136821, -0.1458259247028675, 0.2506812255590924, -0.09653763902679038, -0.08469913183667567, 0.07837305910298753, 0.07763123222463987, -0.03084113913728521, -0.25877248175875744, -0.21573031626877695, -0.4158981972771072, 0.37101428269141257, 0.06769068503616282, -0.2705480797673477, 0.21309064592549337, -0.39925502809539576, -0.46531361297244034, 0.03264564457871027, 0.20035007229414256, -0.361525132778555, 0.12355967820838025, -0.22288857048182215, -0.15191104451935214, -0.24187380731226713, 0.052288681172407536, -0.08837066074318721, -0.17975620719879135, 0.16593776490234233, 0.1579670771113226, 0.0025429774660374964, -0.06851799811165292, 0.2758689276524042, 0.3086137757145575, -0.2818326740333937, 0.10185409233260902, 0.10046463124530049, 0.21347915488950997},
    {-0.5127365660902438, -0.21009124814159438, 0.24267848651959653, -0.3528611618401566, -0.5314153959466311, 0.18550721746159307, 0.041126300702390865, 0.21172256381758767, 0.18565508842997477, -0.42345356171556897, 0.14539634294239842, -0.2624378014610682, 0.20160707128274608, 0.22938608457582987, 0.22798831987900936, -0.04360131489420649, -0.18736595582587873, -0.15034542130739506, -0.43130574211222056, -0.29811456100407413, 0.3613952433798217, 0.27989903154873874, -0.0072992859834847155, -0.22250280804325906, -0.07877041240225054, -0.3019464300433466, -0.09260737538898377, -0.25415615645985473, 0.38918948021683636, 0.2562763654113844, -0.37561058030324557, -0.2116715376300974, -0.23698641811215218, -0.3804854325056821, -0.10431375838391799, 0.29675314174451567, -0.05818112767998928, -0.003385391675203732, 0.32359832341859274, 0.06585655920505139, -0.1874678824150151, 0.44589782244170717, -0.3607162830958071, -0.3543568580646895, 0.2088550704030005, -0.2337372119780891, -0.006376583868982757, 0.1437625413845785, -0.26429608040273495, 0.0746614479945122, 0.1429515529627895, -0.2547821255730835, 0.1615259527563522, 0.08804094386347192, -0.4706621913358802, -0.2654782975340098, 0.18973980376307753, 0.3786675560726894, 0.30578556868659557, 0.28242027167910133, 0.3986002061801724, 0.06641980259171905, -0.24526446277019026, -0.31679415024286633},
    {-0.3346384273361063, -0.15129352283713243, 0.3438801357554486, -0.11518859571434242, 0.1909544493473771, -0.3035673321971735, -0.31454789258225624, 0.22069408105889887, -0.29525791121737016, -0.09093546837715771, -0.0717526764658298, -0.008462140763179816, -0.03772979221015143, 0.3979046764254147, 0.15899182488466235, 0.013813399086601131, 0.08680728946121714, 0.3462147114304873, -0.31382914376847115, 0.1272690503555965, -0.1591216187422853, -0.17690309702843315, 0.1279467865950128, 0.32549511321797453, 0.009477068852367806, -0.2942807203518498, 0.06975620676771696, -0.46616320433403985, -0.23881580170402977, -0.3359617611432189, -0.13797802875022036, 0.023179944785021445, -0.4443157008609836, 0.043929452735940594, -0.22378316045713614, 0.20097198534798552, -0.27100034521364746, -0.041572830786160704, -0.33885859010188185, -0.02547080185111261, -0.020253016618248236, 0.33798926820909275, -0.15835098723089952, 0.4000040104786636, -0.2324058949430626, -0.17516299700033172, 0.5497294016053508, -0.12875631737661775, 0.10749125263257962, -0.2660626417362906, 0.20761591120293738, -0.12614210317171168, 0.2734268424835449, -0.45596257644248833, -0.5584576459513676, -0.3959157973065264, -0.31818644345406466, -0.1303985004455055, 0.21938300980486827, 0.09604075729247497, 0.5009255065254485, -0.16065711642656194, -0.25615061343944007, -0.3902749400233414},
    {0.19849704774288662, 0.11521164311291433, 0.08752201472732696, -0.1128912007306428, 0.4719631811255243, 0.12928488422615544, -0.1231381621487776, -0.15327699654850166, -0.28660041486007776, 0.18213496793056289, -0.05627282797750274, -0.11998839538928265, 0.25164707727268, 0.006410523963741193, 0.1898102074823163, -0.46271642407118624, -0.26518099032407794, -0.18894355729157178, 0.40853633282109186, -0.2979251074516833, -0.3411948586183733, -0.29416832282378796, -0.38559871294851683, 0.1941726224642914, 0.02554541476443904, -0.006477484033632474, 0.12689385011777207, 0.3255333514666879, -0.19450985167700785, 0.2445958477621964, 0.07778410183594905, 0.13051200211592395, 0.2009742169329881, -0.18424976709842547, 0.1378817916912142, 0.3396329326984895, -0.36003911436853986, -0.24805531929628394, -0.24735852929953733, 0.07591214470924539, -0.17907719906376313, 0.017024245685006063, -0.17358790816205608, 0.588444574599772, 0.2374734129393231, -0.09808670773834557, 0.19415305742274286, 0.11848925983030624, 0.2897481329391371, 0.12090060966537274, 0.002306604176326188, 0.14371735726869742, -0.21039391032853502, -0.05478746812737966, -0.177763633806773, -0.26077316528057426, -0.4169250660259274, -0.2619181092678055, 0.20919119573937514, 0.01644958300112683, 0.22627268444736393, -0.3112239086152924, -0.11493177601905419, -0.352161188654816},
    {0.05128539281617435, -0.124676309959573, -0.32930411068607773, -0.3458723941628837, 0.26316556303485134, 0.052115079056883826, -0.12605512066838456, -0.39364898440268287, 0.19371891952583686, 0.31712766169415585, 0.18098789060604542, 0.3043811768131911, -0.34363931725993807, -0.10061232073116544, 0.24973779356667483, 0.0889818947495612, -0.3022479107320535, -0.11368615149052949, 0.1679095437171931, -0.08623620223020054, -0.25755816259761805, -0.1598983395691188, 0.18708545775427932, -0.09441945070380556, -0.19650281757317892, -0.3663016165734059, 0.02738337965844548, 0.4504503088756022, -0.17652744999002648, 0.0579033776542205, -0.01630209063162292, -0.21356551922027384, -0.06970825458752747, -0.07612660215507949, -0.20762826890234665, -0.2249787694778251, -0.40504698171671427, -0.13225561934521782, 0.17577188853375628, 0.06404959930592853, -0.36500502269584023, -0.13828581417489685, 0.35348505026336635, -0.4468964760088614, 0.2548773854169191, 0.24334806560561492, -0.08502417076694499, 0.10693845836743059, 0.37319869058388533, 0.04565267660550007, 0.32125268805476204, 0.3146881768369134, 0.030688291369300454, 0.20011795561182957, -0.06094920552802497, 0.3265158826247358, -0.20101016686195433, -0.3334166938279565, -0.026958683967236875, 0.1345513629983412, -0.44461401749955326, -0.27454956415425513, 0.38080975052751187, 0.06016765028380657},
    {0.3053301354039233, 0.2810392908345301, 0.19126211931208423, -0.2526925841319069, 0.32674757333955606, -0.09007720756343758, 0.10433291258700184, -0.030979614277948455, 0.37220275841623435, -0.2996968795289242, 0.1641073212594732, 0.4925741520908518, 0.08829165254235315, -0.08959851290111309, -0.34107908212266846, 0.40801637219688686, -0.157936432590837, 0.2588217562047411, 0.1334332970304833, 0.08223163842779702, 0.11968003654406724, -0.28296471920757993, -0.08555128201451197, 0.22441916583128851, -0.33335315649985264, -0.08469080096411982, -0.3012012519735536, 0.3319203502265963, 0.2780367779535328, 0.04394643196867055, 0.12120041464490396, 0.25988504609782603, 0.18195521568667433, 0.0865576181444229, -0.011835097869486718, 0.1267403570454162, -0.22765839048655753, 0.2418403382853131, 0.23920981253031273, 0.3397880966876407, -0.1425541868079981, 0.24297322532807597, -0.05954057564947303, -0.49537373932858825, 0.16285564554044588, -0.3570663107540473, -0.02836440678715807, -0.2120464495033427, 0.23737054960311496, -0.25278405199572274, 0.020769953043612698, 0.2781700904931383, -0.2053086550554122, 0.3096289603074629, 0.26431675554505196, 0.4538118102118006, 0.34836489387067054, 0.31044124711195564, 0.1134428666312659, 0.025308481114551796, -0.45004612449666254, 0.2039693110383065, 0.3492646593482051, -0.04718131306361799},
    {0.11609017109173213, 0.2862199120094274, 0.18617435990641193, -0.041324042080463794, 0.010636117101023638, -0.038507250488314326, 0.1034621969228436, -0.3148423090412703, 0.126632584958346, -0.2554019975642255, -0.5301528884580424, 0.2747360285981683, -0.19436005755607944, -0.28558247514003166, 0.13891333595415264, 0.29099398499836565, 0.32528017997508024, 0.3702166388374085, 0.20682626963111608, -0.12376443001943749, 0.009923854830589763, 0.3513040273190111, 0.007411902841849903, 0.022629822315910274, 0.12452423026121437, 0.1319973516518602, 0.21098780704212125, -0.16299766979596322, 0.03922177982868701, 0.0690093173597795, 0.37680297447448624, -0.13594129395589316, -0.39137565975960165, -0.11999519907784782, 0.33699798631872846, 0.019667543577410303, -0.03651386645113214, 0.27933416674601386, -0.20582173158527922, 0.02381525439239324, -0.21909663022943862, -0.3257461894095252, -0.265293728167525, 0.19922375231352094, -0.1662781573603949, -0.3309901714913088, -0.2879227287194217, 0.28432621372618555, 0.2251576378501604, -0.44006892061770625, 0.22566639706310515, 0.2676322938667161, -0.23693039908266444, 0.1380073867312639, 0.2246094460452984, 0.04811022870082216, 0.42568555520686757, 0.19264324386395346, -0.09110800111654022, 0.21876221714238694, -0.3401108998241262, 0.46407736179731085, 0.3776660083057564, -0.17936954422267481},
    {-0.45353787486669683, 0.1353723645088985, -0.25143266255321944, 0.11500930115051548, -0.04938469678999172, 0.042621269830681346, 0.33363700676971453, -0.05875007190412608, -0.19329101158556353, -0.009323327202420068, -0.555385559258326, -0.27912550547713, 0.04911756655098377, 0.21102788931764066, -0.17196052443267498, -0.1611324434380265, 0.3208761930473837, -0.3470618020987192, 0.01936252048183036, 0.23701129180469244, -0.25542670471936474, 0.1034677222667271, -0.003368538547051491, 0.27366884852255124, -0.005708693827889816, 0.10828413410423932, 0.3230581734958902, -0.46058377484396507, -0.07746015073921557, 0.023516356157701614, -0.06733883739658361, -0.12038857497908441, -0.15465280898233905, 0.25164038482420775, -0.292264059420568, -0.017423585307462814, 0.23296188564463322, 0.17394230099429084, 0.3061133801428747, 0.11411927971847852, 0.16962567877000972, -0.23631413893373454, 0.3243162948077849, 0.36899539409324467, 0.19170709684001822, 0.37802644635685656, 0.0454196120572649, 0.08774461510314535, -0.10822830156557031, -0.0718467342721673, -0.19078469090098443, 0.16286178738752682, 0.28416268356141217, -0.0535207197234238, 0.28416720471942064, 0.2633102805218745, 0.2087270145753911, 0.18585028489539876, -0.2855509331449327, -0.07962401552677709, 0.34675350632393537, 0.18647103234249107, -0.34155652469713704, 0.19971562849218374},
    {0.3058710215383252, 0.2415470674202258, -0.27769056462906966, 0.12762125495439855, 0.15573957179337664, -0.4116196703781067, 0.18570313131910987, 0.1443361825712175, -0.17649840731155544, -0.3275103382254465, -0.07641309712481914, -0.001268818065663186, -0.1959381486747617, -0.006481776793408028, 0.05372618415473237, 0.2475323990664839, -0.10152072603289485, -0.5093185048996811, 0.0802023889518351, 0.3073362753943418, 0.1699837136607113, 0.10210215859063856, -0.36935629850488233, -0.17098011342512023, 0.06108957345255314, 0.39870706474249273, 0.019276419365893936, -0.017475022943717604, 0.040588562743905536, -0.008093791630684384, -0.3396032419449935, -0.3955574138157034, -0.07121421938231091, 0.12835671222851303, -0.06745422829897704, -0.4238520255081394, -0.21519304794882493, -0.25495439768923217, 0.4361377786223287, 0.0318002063489279, -0.22969486732409775, -0.38227067326799263, -0.18616228091937492, -0.2419046665189299, -0.11692245714269289, 0.23350499645895328, -0.08084063468778388, 0.07346892816668464, 0.15650033500981247, 0.13816452395608697, 0.10103945632393489, 0.18484644952181406, -0.2509624893022755, 0.033280068352089076, -0.3201796972014945, 0.15003151377773094, -0.07607562690042735, -0.062152672311207684, 0.15313496360990428, -0.3014903699668271, -0.2544538390243399, 0.05745822563149352, -0.13488645259682724, -0.11523733934797994},
    {0.012777893000285714, -0.2954475420799081, 0.3938411444735522, 0.05120602432549967, 0.2695469400901746, -0.31928987086135024, 0.33362995144701446, 0.1474406428760802, 0.26378854600592033, 0.015403889996238578, 0.026910922795347618, -0.023146817635689897, -0.2025375143999575, 0.00557615122474941, -0.23994165612727483, 0.04584603575884092, -0.12004367629813632, 0.02456796028651207, -0.34635193233850586, -0.22665284995124058, -0.34242422990590343, -0.21508948435953323, 0.16015612161806797, 0.05033169154433247, 0.2647376396064797, -0.07327697573641206, -0.18208565537819307, -0.2017967987093325, -0.26827655144834417, -0.47218295918128306, 0.047936202740695336, -0.11083298854285355, 0.31688104299910447, -0.17594911183946224, -0.026336189609447454, 0.14869772126722638, 0.1899617205951627, 0.17292273787516724, 0.4051975338377416, -0.21437483259467885, 0.17020709247100185, 0.10521403913390558, -0.3673517323166469, 0.25925085520911806, -0.14908493159131259, -0.2820220951739248, -0.3917917482368699, 0.12331313322113764, 0.37863227300566243, -0.042533360547125955, 0.35684145109087945, 0.22028407524589716, 0.2874449391158867, -0.22502641930651707, 0.13122723494172844, -0.3507544541034929, -0.013148974088910366, -0.5437353063744241, -0.00838018800824983, -0.4245302400483339, -0.22433501804465936, -0.024539968344896003, 0.23397163417470157, -0.3580331718536698},
    {-0.20821672644290418, 0.2433132783086506, 0.3694208395940843, -0.13366602652256618, -0.2990723730053472, -0.009460331330396083, 0.22059314354598164, 0.065149064555818, -0.019366044762184238, 0.09881644041990764, 0.06423030646708754, -0.5539052624560142, -0.365690339234016, 0.3655363421274193, -0.23580709338305877, 0.28914798086596566, 0.1325708986309275, 0.23635470463343602, 0.28065098150701395, -0.19218589597581515, 0.14285439801171493, 0.3948988992368407, 0.4574204918396229, -0.1195354069117811, -0.31971984062268916, -0.5094291016384838, -0.33889101568594776, -0.32779661142854927, -0.2866819262291569, 0.004276556340600333, 0.4454577689905775, -0.06916929994156024, 0.1987032652718729, -0.09178732981771551, 0.16025326216870114, 0.29950328415507665, 0.247953493732207, 0.049509398016607614, 0.18640648004638524, -0.011203958306131273, -0.27166617402782517, -0.059441727293198625, 0.32287244191619874, 0.32603282325951666, -0.04416770544915847, 0.2559536995382186, -0.16529274765184107, 0.07854323040006829, 0.04851801326128292, 0.24604692613364038, -0.2198777781627675, -0.24275890888895024, 0.07144798473805569, -0.15208542544639625, 0.32370895007731315, 0.02286340571040684, -0.09176289936967978, -0.4980061999161291, -0.2222174841589152, 0.008052425085993166, -0.08699418024728776, 0.1550064958042574, -0.023987110014158968, -0.41305727136190445},
    {0.037928733717461534, -0.14073618440270577, -0.20378530975364162, -0.31002199663596186, -0.4214290071199246, 0.44070276566232297, 0.08926975538945962, -0.22232364274604463, -0.3359591149469998, -0.40139599202949905, -0.058299362324339084, -0.39090776628894297, 0.2923460749397636, 0.20487981032483882, 0.33891628110450306, -0.13709055745474974, -0.29196538984244835, 0.4297081039423781, -0.05890703538174484, 0.22252307246123576, 0.33652543849633226, -0.03471471989720028, 0.24222428487942835, -0.10124489330924491, -0.08728426194229273, 0.03144787935461699, 0.03141181864005695, 0.05176443554996783, 0.21666067443821507, -0.12017684379695193, 0.09427228755100422, -0.11223687562360846, 0.29253756561577, 0.18541119613638044, -0.026556978593777144, 0.11855363878937154, -0.02382136717615075, -0.39076033910286617, -0.33207083206033056, 0.1187787758509604, 0.2196348246637098, 0.408121325644372, -0.2449366354050858, -0.5115328687000831, -0.1626201501970854, -0.42773896667431915, -0.31757556906777734, 0.00020516760546280443, -0.5141130366931121, -0.19950039995360885, -0.2089691843540576, -0.3297769783047702, -0.20479652489388786, -0.319751493813232, -0.3705898781443307, -0.1497670490245278, 0.048705217526028265, -0.25476387118255367, -0.2026384541335508, 0.3553679524229539, -0.4145460394702807, -0.13520399861892649, 0.2911288333235928, -0.24072395490010182},
    {0.23616459253517025, 0.06528464653506522, 0.11354716782347543, -0.10117126027744125, -0.27712196660380783, 0.2842210945829328, -0.11831300672611444, -0.2140847441182871, 0.13240268354932172, -0.2921175058092356, 0.4692798225570306, 0.2626519639067485, -0.1329418814555272, 0.1761351972374905, 0.1015343153499644, -0.011544527788974227, -0.18352366914311696, 0.3082678341489479, 0.193077840913756, -0.17876039149869943, 0.18816360285672792, -0.1415673772836766, -0.1130189601325946, -0.16957231382273835, 0.3959065813258732, 0.24917483872668658, -0.19355841774312924, 0.07802349050381291, 0.37736166436614643, 0.1570512785833353, -0.2680558409651773, 0.2718665689250285, 0.23806276431382553, 0.16860809897137424, -0.10155390510465444, -0.16747888263462132, 0.018704620291790302, -0.46925370816805284, 0.16029815649568996, -0.06869839573341215, 0.44956586296117623, -0.10602213596353507, -0.05288080025469604, -0.34994118823679843, 0.26036332787864414, -0.2818355866013383, 0.09236939531593821, -0.4994292089905601, -0.3679811616461553, -0.3192787336800605, -0.3100415828503812, 0.23583047555068656, 0.05845557991017841, 0.13619711980948235, -0.08765294898523403, 0.33126286301412744, 0.11302471625722568, 0.42134857210146887, 0.26554976483804676, -0.45438588330446683, 0.11681036707286654, -0.1553395312281671, 0.2123650541925507, -0.007185162433457125},
    {0.15378281994409185, -0.10632828865941955, -0.11063523742034605, -0.00019358436548902626, 0.357052852258655, 0.4025904723742884, -0.05209187896830771, -0.06284285922103938, -0.07330075563740619, 0.2505530543604143, 0.3347552783933618, 0.3529380319476512, 0.5135329946930598, 0.24000511921667747, 0.05978820127089373, 0.012861162079503585, -0.12755164481380493, 0.034912353053524005, -0.2207097354611738, -0.06718279417717418, 0.32057901206126715, 0.33574937430125773, -0.09546028618384553, -0.08443149225208249, 0.050272306839923904, 0.2856407708093713, 0.12564330997756867, 0.029737995828475507, -0.0267640790452346, 0.2709628909159789, 0.4679948445457831, 0.41917604689524174, -0.07870066512090518, 0.09084608014230776, -0.259530150282268, 0.3600802551291131, 0.18818739968299503, 0.2698894772918464, 0.18748628831980438, 0.2845981487148915, 0.5193238960590819, -0.5187609569825403, 0.26895789729288067, -0.1888159756631684, 0.24436716285100826, 0.36931893714575315, -0.1833609351723111, -0.4127448461070222, 0.3372511472422592, 0.37615442843444524, -0.02093515410584875, 0.08406522029011927, -0.00839061968598327, 0.23592361333081086, -0.2553936596037359, 0.32176285215680067, 0.12527316490582785, 0.3409350109989926, 0.33897281157504794, 0.04502282421452825, 0.48731839413766725, 0.17714573485814192, 0.06203392602465427, 0.26370873391276595},
    {0.18260466063714523, 0.21406197039948746, -0.28088254035420773, 0.13235414392320077, 0.13186888798697763, 0.09826147965692973, 0.41046950526690423, 0.1804658690192471, -0.07478963392260259, 0.26188635443666, 0.05725117829592022, -0.07320782840192154, 0.03348213748723651, 0.23156735540314982, -0.3972697886472693, -0.30097032338493335, -0.33811541033699416, -0.11787797096838833, 0.28354903433988726, 0.06546146447556027, 0.02017320886470618, -0.20341432158687273, 0.2351306260688584, 0.5221452165773393, -0.3044258281326143, -0.00303256563482621, 0.2864375230774072, 0.44242122646435184, 0.00456830466424822, 0.33121676171695574, -0.27954482988326607, -0.19316780162935454, 0.40789320161944204, -0.02608397987102647, 0.30925686634946764, -0.07370821774047816, 0.28715024183112997, 0.31207895904296257, 0.28083851566407997, 0.17730291102525111, 0.2524550397630867, -0.22213905013390178, -0.2073969285857308, 0.146013104248013, 0.16209476737203665, 0.425369553587023, -0.16374129154230438, 0.012722383620485722, -0.09141883642697902, 0.40687976847523827, 0.10904215538669292, 0.19020747652728073, 0.3026733545905746, 0.3644377680353176, -0.346381348703094, 0.031795494742911726, 0.054848660426685986, -0.12480069139369651, 0.111330473884072, -0.4119724083750583, 0.10755737829957114, 0.416706462503057, 0.0760109541883652, 0.21879796627704762},
    {-0.17259545537858723, -0.2353538631923049, 0.19587854200358698, 0.05228628006158997, 0.11932442334934648, -0.15358939814658926, 0.184138587382506, -0.060449569233329135, -0.1199463454481545, 0.20755069704741846, 0.0665920380639858, 0.33368628622093344, 0.04487577493760989, -0.30984525067663415, 0.25646433765252497, -0.17515047598813502, 0.004967988382608202, -0.3353915589519317, -0.13401945525882658, 0.049555024955492605, -0.006656737380398479, -0.14328637856366327, 0.2774946369237405, 0.19459390305956875, -0.035200355290716315, 0.09567429668529091, 0.03513885873172027, -0.28158227821274484, -0.2888478947883651, -0.3511398337511037, -0.41404142746022154, -0.4482573794707393, 0.20089798638909218, -0.20126854569847963, 0.268707903579338, -0.14062693795299497, 0.1599004149570162, -0.2394125449102595, -0.2201435803161305, 0.2779140013171186, -0.5265337085435102, 0.3238670457708243, 0.19627272956373687, 0.4023003170951447, -0.06517993671044568, -0.18825340503029822, 0.02861746502097727, 0.04406714650571634, 0.2688435923975514, 0.22142235345528608, -0.3694408410601073, -0.15533149722735187, 0.3909982948115037, 0.03402467958167056, 0.1403153135811742, -0.39640729050556966, -0.1208663213749159, -0.23663535826399312, -0.16341257416708518, -0.5470715624385735, -0.12338874179123617, 0.26816217892686445, -0.018048342265938117, 0.19618873867570152},
    {-0.3177555776375576, -0.47478180227046807, -0.2967354829712295, -0.2700901996828736, 0.2086619743348586, -0.5931771110611849, -0.41571872220534795, 0.07421267951218743, -0.4151388164977745, 0.09928580201236584, -0.3589090672884321, 0.26979494265093906, 0.21204105595406406, -0.06273274515969662, 0.34080022295860546, -0.5119118323122909, 0.2396572649534237, -0.44856652992041823, -0.5068565157238692, 0.14292849730788507, -0.386095462714075, -0.15533527901717398, 0.12329690883248691, -0.2006992881446326, 0.25182099246645273, -0.24235592242395088, -0.3707373410457371, -0.3728064110188184, -0.06131796282260747, 0.05927932699870412, 0.11647998639324326, -0.4889620816948575, 0.2732315039331963, -0.037516167878075574, -0.23258361121959126, -0.12967186303255046, 0.1333865760770358, -0.28024039207761425, 0.30244394581705425, -0.2314090124208705, -0.273171551396852, -0.23929732501533102, -0.17714559426113, 0.24027664658666031, -0.1210052480988281, 0.03289808589517247, 0.005464331426738071, 0.19119417555949464, 0.24801597031706332, 0.09624672500753051, -0.0018205124360370357, -0.3683673319995633, -0.4930105484936062, 0.06433548158085503, 0.12746272823419724, -0.26190850572301333, -0.14293755758323254, 0.17642234715253033, -0.1214104379387952, -0.08204782188580079, 0.026331865609059084, -0.3049925817323708, -0.23593019073063123, 0.2957290732078415},
    {-0.21836754605686, -0.10769221498033818, -0.2783914685846757, 6.989449216292701e-05, -0.25779873477883564, -0.356483031782542, -0.20594285401422688, -0.41466419232855806, 0.15695533061323938, -0.027893987046450262, 0.02378501761484164, -0.40440077198435304, 0.09101252769592655, 0.3975651456671996, 0.2076802614097584, -0.16733683935613528, -0.2759856911617687, 0.28984340239131823, 0.22277140615075972, 0.2215900501943391, 0.11233326886422443, -0.18927183163341074, -0.08497322190387334, 0.10764899355244585, 0.16395759345041805, 0.26928769086311594, 0.21423676392138735, 0.28200684754532845, 0.22235344338186194, -0.27051543412454365, -0.43444302106276766, -0.05714529501319239, 0.2959364503853121, -0.2879211007837571, 0.1915293749576682, -0.1548731739655554, 0.1268119087808679, -0.20706385920871992, 0.005876188329121931, -0.26770228077349084, 0.3713740622437533, 0.2683896630452866, -0.3237017429067214, 0.07162543151220101, 0.021456577181249673, 0.31594667635806195, -0.034029773806773286, 0.2963688051339776, -0.3268532036437356, -0.4202227753568043, -0.00841141280014402, 0.10194570354204922, 0.11238693945511115, 0.4062462617486371, 0.05012068142352129, 0.2126255212226848, -0.26470417794709267, -0.03155030991506617, 0.2547742684637569, -0.333582470097843, 0.15941027218461862, -0.3715595315855013, 0.024082294322280567, -0.03858934355543378},
    {-0.2372345598278198, -0.057574182049622474, 0.3570285387051993, -0.41848872203928067, -0.14624272197202817, -0.15507381776725315, -0.22922347089974376, 0.0006871265948885539, -0.19133175996480162, 0.18972835080352096, -0.3347601619396798, 0.04111799924615069, -0.27981939058843147, -0.2374321417463318, -0.0814063544824674, -0.09512002800616351, 0.07386870368149644, 0.35422478138003144, 0.004190564186605331, 0.07237892309255776, -0.28129053384743136, -0.011424978868742972, -0.48026841757711647, 0.23608867378513626, -0.14408518682506513, 0.2691788416707802, -0.35785653602724526, -0.33341570263124026, -0.333836073780635, -0.3068111799230435, -0.15755099776690995, 0.1937880112024075, 0.18724321936678778, -0.31565924252435396, 0.15645447778381225, 0.2466434439900562, -0.0195973234700024, -0.09390747762049714, -0.48330965281526445, -0.20870278813444784, 0.11110204220298822, 0.008254149194290338, -0.4250964957702679, -0.44760572295722173, 0.03614862193004313, -0.04494938397950067, 0.08324997455072378, -0.08465333356515016, -0.20948981833971805, -0.3038592376180183, 0.2283811342016959, -0.20971429390325283, -0.3595083125940712, -0.3650135006086552, -0.022341735067170167, -0.00833251911970672, 0.005754361913717259, -0.26401056279659113, -0.18119999176799642, 0.302809816825772, -0.21148224992663125, -0.3225128578758131, -0.3657928046667351, 0.08089697402880296},
    {0.3832936095705213, 0.4037692808228529, 0.054589966511172414, 0.018033023761914468, 0.24186177637712303, 0.19396983288085945, 0.05188094914476304, 0.2870019847422095, -0.20700967244161306, -0.09270111215746109, -0.20327950212044393, 0.39109969559028035, 0.36053936493360783, -0.31689902333151165, 0.06340402189623143, 0.37031130178731125, 0.009284942213410115, -0.02401768083168325, 0.29122890974284743, -0.060197209727115404, -0.19947128277002427, 0.37459772899822924, 0.4303557099042751, 0.02143739097256168, -0.08641186516659226, 0.0661053644200166, 0.00434373716930553, 0.38758341326936063, -0.10167586268943377, -0.02197030869319584, -0.1867550085409884, 0.20168415203861606, -0.11710183189540764, 0.4141840069560931, 0.29528284289098117, -0.293899068746242, 0.38590356317971725, 0.08596058824161733, -0.193624509123335, 0.3837765891202641, -0.29797124774239364, 0.053263627119140365, 0.24488379936485502, 0.39078193704652264, 0.26215917166180996, -0.05928280036287069, -0.029136956629033744, -0.08253519836943563, 0.36801760699021946, -0.07104074682001606, -0.3093635355202071, 0.09626201424001939, 0.19723396793804487, -0.302613281069038, 0.08762647890613774, 0.2615601107363127, 0.13232761976565524, 0.15161634160918314, 0.19992345812209378, -0.047528154423027935, 0.24560491364822185, 0.1142071088411592, -0.2501540030503343, 0.07688546405766167},
    {-0.2704969012242155, 0.2039370415828768, 0.007147646797995462, 0.4034765884574139, -0.1438277024684942, 0.2673674709832738, -0.3040038773808661, 0.25763516175710055, 0.09679331322692435, -0.0646438159227559, -0.003633108670938814, -0.37967413455169374, -0.34084003071903346, -0.19923643662358745, 0.3652494230085961, -0.3193236078026854, -0.057487757678815254, -0.38735041655645625, 0.29506460451344335, -0.12702829456284023, 0.22825464783028626, 0.2479823897343015, -0.02278343452374584, -0.317545381162063, -0.11878265138289466, 0.25202803022636033, -0.03509237529051261, -0.10680441354334129, 0.1275103232447337, -0.4971398883423549, -0.31753130724932854, 0.45663248250745264, -0.03693159049214746, -0.12632162653673354, 0.02266938355167762, 0.28668317839940854, -0.09180066404576573, 0.06721547790333987, -0.12458003974460635, 0.13266120342095777, -0.4801303798642244, -0.2758305321411229, 0.28211159653776224, 0.4675388768010848, -0.17578685431104177, -0.31037370859234686, 0.19247057572603618, -0.1821661481767575, -0.10019556104949344, -0.03864955103649372, -0.3954499610594308, 0.2728648944287964, 0.031384177024224594, -0.17601130055741818, -0.3447119843988238, 0.004016456673127045, -0.2557607739176479, -0.08494988575378733, 0.2230910582940469, 0.1758138868527651, 0.3793236075149423, 0.1831798414150994, 0.010369700719966351, -0.39051561866936163},
    {-0.2084623384261337, -0.0954222804936826, 0.024541964740049448, 0.18828142359145714, 0.12061360175920272, -0.42710070705266284, -0.3590002317772397, 0.2116354447712843, -0.031983136758656217, -0.22766838695368002, 0.5064991197858002, -0.1521407136057599, -0.3476822327977044, -0.3522919444772533, 0.294183272973832, -0.28790139321262215, -0.12911190420776447, -0.3696976082557635, 0.14357315208205285, 0.20294936230856966, -0.4242659681076909, 0.19985388206876617, -0.12851344175356813, -0.11307865466249326, -0.17491911511911445, -0.08833568123593717, 0.12014194575881933, -0.1326627761864235, 0.2141142416642523, -0.39122929235538495, 0.10329954048663395, -0.10442047592444167, 0.3491835913708814, 0.07498312946527542, -0.10939701454483665, 0.032143131140717277, -0.20386246408318873, -0.26920569273301254, -0.346959505162434, -0.07440299996956652, -0.4474864905382101, -0.07973134137528419, -0.21383468637469885, 0.3398572558400898, 0.2024136826315371, -0.40918503156157593, 0.29603201982606103, -0.06853657788066923, 0.1505934242832315, -0.21872804291880812, 0.07447525448289116, -0.17546649018233187, -0.4347914208535926, 0.23618143094722904, -0.1766372445659826, -0.3280300555539593, -0.02341609135501094, -0.2421200701494455, 0.3508088421155976, -0.02113074893253647, -0.49307097202405065, -0.08267640388723561, -0.42057027103471145, -0.5042708528381049},
    {-0.9023639885491863, -0.8578202272267519, 0.09817156660085048, -0.6532172064237579, 0.5660441673043606, -0.10859515665610747, -0.7519204642559846, 0.364676295067133, -0.9438340927443664, -0.941395168149197, 0.3909778036827425, 0.1548250552515128, -0.5463582738041672, 0.6256175206302796, -0.5640082102617858, -0.3021294427879295, -0.6329201960970963, -0.4733970494765891, 0.17414632079392797, -0.06893114560976121, 0.5747265695618933, -0.37463592936019297, -0.6542810564040188, -0.6611686686130569, -0.5731297724917769, -0.8899678848363524, -0.6208695284664274, 0.37400772448714237, -0.7829425746381332, -0.5712559009265438, 0.6781224916335495, 0.29816745785253757, 0.4815748702036634, 0.08349222241312752, -0.5258415582809567, -0.02782597992789522, -0.746635874538763, 0.021732889348503377, -0.2984251436005718, -0.9520041296146473, -0.011585767134696905, -0.5203576865501603, -0.4859507410220366, 0.4399130965108191, -0.4860531975040663, -0.4888130694095844, 0.09089722609534616, 0.22706327095713627, -0.001867203972769642, -0.6719314034773376, -0.6583988267375374, -0.3952650055756223, -0.3770979521433106, 0.3121600369989773, -0.13472494055693865, -0.6533438118669571, -0.7049772685401797, -0.28056248320001176, -0.8868484113764725, -0.3826292354002639, -0.019259623119947188, -0.35172074012385246, -0.6361422435399271, 0.2232963130885641},
    {-0.7408187560902426, -0.7833446000811183, 0.40553991117879495, -0.009194946538955138, 0.5904059122175103, -0.044813450752900344, -0.7772742342094424, 0.13636994925565396, -0.7362654675098432, -0.7451741511063489, 0.3641597544528452, 0.21944322971205935, -0.6140208602186155, 0.5630153327770832, -0.22550654142606394, -0.7845714400770557, -0.7626050064211074, -0.6193807921695271, -0.10899013629407873, 0.1613415188750687, 0.41126049109995194, -0.45444153585716707, -0.5178399531473769, -0.404830032070527, -0.6501249250492961, -0.5333242582900612, -0.9435169644945491, 0.6285282592835624, -0.6914508699522496, -0.5217096296908023, 0.6271693222580543, 0.36443280335962736, 0.781672074179345, 0.3328380857080056, -0.7255542760283814, -0.11031252516613486, -0.4433766277885916, 0.236849145777438, -0.0765542311315224, -0.8894248527151487, 0.07012004496218525, -0.29687744554343315, -0.725143581541386, 0.4796312760016825, -0.49919328624474035, -0.7405273809246127, 0.006960636275776777, 0.5778759403350596, 0.011702032111552366, -0.7819053913007966, -0.5650478328603278, -0.4710507485170703, -0.21143059569840136, 0.4940497340776753, -0.2866303911920525, -0.5394353904182269, -0.9921049621920177, -0.36046974780378066, -0.8194702142833751, 0.024726686961637687, 0.26731681818654135, -0.1735375572373799, -0.8592254997591147, 0.20319931638993732},
    {-0.49743100403503765, -0.21623999172071673, 0.45871950376837295, -0.20468782511823513, 0.25055542638056827, -0.5859077655535992, -0.38882392619663264, -0.3277354618492693, -0.6031591160675933, -0.7084950699027205, 0.3223382890849472, -0.5755639314381243, -0.50492885264259, 0.4917635459372529, -0.19774351358345466, 0.06639699597011975, -0.19975606465513782, -0.6066433713295358, -0.06954329426438273, -0.7488457521317671, 0.36147310237498387, 0.12201187052565123, -0.025677736171327913, -0.42979861674184616, -0.2969071335470109, -0.36597316132638014, -0.44790258955932155, 0.4066238397409752, -0.34968636576490586, -0.5300775273643143, 0.03132257047518095, 0.2294534798131255, 0.5266215146867946, -0.23938547289807557, -0.7762905236594415, 0.055476321917010345, -0.5003754987033634, -0.3599088528828882, -0.10784629755039613, -0.5575125451267869, -0.2893286675649628, -0.041541309837336796, -0.5565322337488627, 0.42139093965032975, -0.12118315634270474, -0.3434093638597987, 0.16894735110284478, 0.16131367380373626, 0.08646166516989544, -0.4132195796164546, -0.7674670850891748, -0.2819702486787439, -0.11006556636709576, -0.25657276680528657, -0.16299609584586253, -0.35992740579271737, -0.3262617957228855, -0.5814884609111195, -0.7223172755170733, -0.28713858022932964, 0.060418671974392095, -0.5819094192770571, -0.6837525507674111, -0.4608277433183668},
    {-0.3535530469910869, -0.11919020093280183, -0.07571350078182294, -0.13588299662611963, -0.05579112662120179, -0.00016384115875697284, -0.36805775085544495, -0.28667953316135064, -0.20639979464373773, -0.1553393586705385, -0.0775567509180212, -0.1821801856733415, -0.5239799704888144, 0.3481046839392717, -0.2816283893831114, -0.29175255976943193, 0.16654214606967374, 0.25725631159520057, 0.29186345695666716, -0.7111182764976157, 0.44510795772650386, -0.056402973088452345, -0.212420490992018, -0.11730639944708726, -0.4317929168239775, 0.32667337443042965, -0.153822673631125, 0.13817464569627544, -0.32092901622666414, -0.6828065646553071, 0.3649892432158906, 0.5850404061859263, 0.4865802164474857, -0.27017766198350734, -0.3517126522085631, 0.585812106347724, -0.5828323755065121, 0.22343994048351928, -0.5039814157649125, -0.2838787362004306, 0.32786223685057014, 0.3257969237388661, -0.45671929344878487, 0.6441257704423619, -0.4550405857496847, -0.2747333219794367, 0.5013481472102225, -0.103370800626782, -0.2727836051362977, -0.2948636632533909, -0.36563455592503447, -0.6079727920062171, 0.2090789608785971, -0.6409066952497522, -0.5493073610605815, -0.06246074499703091, -0.5663382990693046, -0.4314514746279502, -0.14977386925296646, 0.2925316715685073, -0.11915077109476918, -0.3193158324615701, -0.3522491762286323, -0.5731644302378326},
    {-0.5296259006543602, 0.04809964901414502, 0.0773475799955234, 0.1330370375000831, 0.4354450272736146, -0.3501742728500217, -0.4369102768112947, 0.04068223649701726, -0.49597890046780685, -0.5889599908950918, -0.18320669255789637, -0.06852359698469343, -0.12159141225417489, 0.3925239980095254, 0.20412847386323624, 0.15365035961106008, 0.4830746927026818, 0.4105974360907218, 0.006106223594612596, -0.4869214790890153, 0.5054127759537455, -0.03972354341814928, 0.1239379201129981, -0.09061880446641774, -0.3382289305002427, 0.41205740697165383, -0.3230455219470395, 0.006269805948450354, 0.06806971436880066, 0.29476088784189003, 0.6297164856199138, 0.5140609527374168, 0.6228061141137301, 0.0059553326784110286, -0.3609466725373251, 0.5498848266438222, -0.5025520620393712, 0.19555775888486943, 0.21449926107838824, -0.2376613913039842, 0.27103580293656143, -0.19807169910054645, -0.14729384997341738, 0.03786294716228091, -0.34392349156934776, -0.2158445404857978, 0.5420695937510932, -0.22117853926857287, -0.14134970612283349, -0.17801610798496315, -0.23760986908086806, -0.16457974250422402, -0.21088027886038344, -0.15860709574935888, 0.011753261498159156, 0.38005305682280494, -0.03911753437085942, 0.35432299459634925, -0.0945625887846766, 0.0957206132380996, -0.13189260788219223, -0.15739333966489327, -0.5578566000834277, -0.22419683879823685},
    {-0.46104150459002435, -0.6379577963438496, 0.039211612589104106, -0.3040538028066959, 0.301432231225171, 0.009095621553292276, -0.2965541517944272, 0.32626697780609387, -0.4838253101104442, -0.3601641021862024, 0.05823494722517181, -0.22026574893072445, -0.2141911075093896, 0.5696251196190049, -0.2539896339659198, -0.4036970162298283, 0.2983534054269722, -0.12921902406240499, 0.42664026334752725, 0.24026462903299062, 0.1601029051347266, 0.04413429210194529, -0.6493795652761051, 0.2958719635988468, -0.5551318752628502, -0.13941501987000404, -0.5810979143896906, 0.1118301013423458, -0.002575388164383747, -0.23986329963033595, 0.5705959455816056, 0.396211002219442, 0.5169320502035071, -0.018352280581508645, -0.368462057271658, 0.42595009183280874, -0.3445027421128853, 0.025011601407506277, 0.3619524697984824, -0.5475250420241156, 0.09054510289977122, 0.007351831677676125, -0.3176422192896096, 0.08892821636031328, -0.3319288478072717, -0.5418388508178965, 0.002626893033442808, 0.08277896802565905, 0.3405213610846868, -0.566371257863006, -0.47856954137207586, -0.4554164716650874, -0.016389332201130334, 0.05803176032168472, -0.14388298503368296, 0.05753784759488213, -0.36721304332837773, 0.3874991750006012, -0.1742505291140083, -0.17401544505593983, 0.09507386960888889, 0.03575259929095905, -0.6917567239686286, 0.08208163138969371},
    {-0.3472182340685064, -0.1549650117249761, 0.36254233361927624, -0.21609126716610588, -0.05564412269833995, -0.5745530195000483, 0.12880945413022885, -0.4405442981755503, -0.15129708239317358, 0.31649270684922026, -0.47361180898458416, -0.1788016349301376, -0.06068132897056628, 0.28426681681513816, -0.19988704413775704, 0.33601177942142235, -0.4058890956594729, -0.11211043021717275, -0.2969169606646565, 0.08524259702383036, -0.09863060743576293, -0.15580343867170945, -0.5809628794926227, -0.44496603846393057, -0.016326375666310806, -0.03664138114210029, -0.6310217521442815, -0.40793268231814145, -0.559207576240905, -0.6260390055995277, 0.008233260743843706, 0.4783065103982823, 0.6509268853615046, -0.2054308046258083, -0.5004007288246164, 0.29643414470126794, -0.5127192055359993, -0.46306845345683323, -0.09660642623267596, -0.4742497694615765, -0.07788527195861318, 0.002457029884904578, -0.039446849183963, 0.07502581700047958, 0.1658572388160862, -0.3319237952066072, 0.12764119246943623, 0.38613337812308607, 0.45579816520363536, -0.42346433090056224, 0.02895867115233109, -0.49939427475552245, -0.6192050898334833, -0.29874700086205563, -0.06634270814902053, -0.47779878111877444, -0.5186011163439935, 0.03679384288340391, -0.18949052138266428, 0.32940877079232017, -0.36343235263025625, 0.17471156897226015, -0.5569003676599991, -0.47459434781149407},
    {-0.36740949615320295, -0.1707061112345698, 0.08282543307191192, -0.33104229068494073, -0.05798091821378438, 0.09820650396237804, -0.1562465237013812, 0.1645845825551914, -0.6105027121817248, 0.3449527614791468, 0.04155550555334031, 0.1165884159443133, -0.574530694846481, 0.1843420274563579, 0.4061510474857078, -0.08767098278375958, -0.2908868774528794, 0.4690421797304792, 0.027089258120646862, -0.2619935673229042, 0.17386199518667328, -0.20862365563834426, 0.03983689951618444, -0.5345336075059408, 0.05592915953708468, -0.6624955141797537, -0.1885365833755432, -0.3323067883622789, -0.6778502465744197, -0.2276525898142787, 0.4680645429994635, -0.47772290364947895, 0.4489342328305701, 0.4484618699904834, -0.5713375097724558, -0.4053736531702168, 0.2653209246959551, -0.5658444928770515, -0.1632384966906717, -0.6224502228698529, -0.3596505767911081, 0.4213301602949149, -0.4096670743885974, 0.4138011907603744, 0.22549641297343562, 0.023735029258970718, 0.01349482871171192, -0.006513278042667828, 0.06978434149314779, -0.2961691755931327, -0.29355673003958105, -0.2634877400891092, -0.2810543740721721, -0.21069211687706765, -0.18403243571650632, -0.11208410090241752, 0.10597381761865236, 0.2579282717706859, 0.02320940008355976, 0.06552747742967827, -0.4825043788319133, -0.3752628461249545, -0.44707686062734264, 0.342141989770414},
    {-0.6694958830026646, -0.6025126575195072, -0.44029369362826565, -0.22931087612889597, 0.23187951758976463, -0.21280528933876475, -0.4387897428213931, 0.14840216924169206, -0.3092586325300203, -0.21066900334452396, 0.1297340616629903, -0.4392332173985259, -0.363545863697182, 0.21323145567532475, -0.07756450096834475, -0.5096189897409676, 0.22161921392334533, -0.13432006914643094, -0.11726402435848003, -0.02387073917276251, 0.04397849434188002, -0.606261537536188, 0.06594034769506492, 0.03633554080100843, -0.18050675833604626, -0.45071176503859284, -0.6563521418845191, 0.12760155506877924, 0.035098690587412, -0.17854084342614018, 0.40895217142701307, -0.5385431129255616, 0.6299585520997947, 0.11004813179261547, -0.6702691821705227, -0.5021266427435117, 0.08565175661793105, -0.5912515185528973, -0.3933667748042774, -0.692812397798739, -0.09371259889629527, -0.3792674903625393, -0.5513653463926681, -0.13891393700485233, 0.2233258489146629, -0.6661555132879918, -0.3282667410921802, 0.26913411905196066, 0.39322325436243105, -0.2420872231034875, 0.13784999005009024, -0.45475513571985143, -0.5301390223775811, 0.2865843958188826, -0.12287782824457796, -0.33899701327512904, -0.2989844501972975, -0.5758004748836406, -0.6435464626193685, -0.5932244897488771, 0.20847042783029318, -0.2860654826224406, -0.6841408134462331, 0.2577261402372797},
    {-0.20294150873177802, -0.2081145092749573, -0.04119892594533469, -0.1832451981658888, 0.4646850719359379, 0.1110349485306066, 0.26162729355078623, -0.3427216772322039, -0.13545791615559064, -0.08076181048314629, 0.4385101344407775, -0.13207322897537138, -0.1858493944076997, 0.45187434664039616, -0.44403719311337275, 0.20346962035342142, 0.27724569127411014, 0.6212446014384502, 0.42168641628823567, 0.2725765516509533, 0.3632003353994789, -0.029633364929468973, 0.223898013994645, 0.2991287461525458, -0.2978227388521031, -0.4541402403602799, -0.484079519363569, 0.3094991075281351, -0.10565114789282794, 0.08612905577361858, -0.041241307258633286, -0.31509074020423483, 0.09419298176753811, 0.2550969674203641, -0.23985420808363625, 0.02585227851407159, 0.09770476694238915, 0.242798173116132, 0.34518318915866414, -0.46698375122723546, -0.44009899607300634, 0.517807906586282, 0.33116384406844634, -0.4198958218956132, 0.19462160143391266, 0.17291554471241544, 0.011097155266159816, 0.0643837962404847, -0.481497718838281, 0.150655226568561, -0.04890736263292888, 7.14045379278289e-05, -0.34082189289294074, 0.42066460078562923, -0.1942975897741501, 0.26486275158025196, 0.2043142101153557, -0.1643101813894233, -0.4492101021637952, 0.23972638190133805, -0.13802915768214108, -0.23511686959755437, -0.15091271226624978, -0.23996320931842852},
    {-0.0015891719381675553, -0.30179407197743163, -0.011570527649436169, -0.45763900221913684, 0.3493687115877683, -0.20695723683796666, -0.3276320006578205, 0.3149328637804244, -0.6412568253641381, -0.5728189699237266, -0.02376193547052936, 0.020949374004619388, -0.4386402746637449, 0.4305506561342198, 0.3384603245219905, -0.10137515779976294, 0.38038180976964725, 0.44772479348235544, 0.16623348318879494, -0.18049247829652293, 0.4391528438009646, -0.15513187010529556, 0.10438699661298477, -0.5331450902372221, 0.16678702780177615, 0.35932310089364927, -0.419999486754383, -0.24411044067054427, 0.05352697658129074, -0.24149418088542215, 0.34333747977856105, -0.04406562781844151, -0.2923235948939036, -0.5438307385284807, -0.3907923455613858, 0.2324270842043149, -0.5349836527722601, 0.1305902980663932, -0.25441145277109206, -0.24221213966214306, 0.02495880317472419, 0.6325948749841692, 0.22212854421037836, 0.047224814177850544, -0.14646751755662776, -0.6377006683568747, 0.5426948688973586, -0.04269031431667815, 0.42944928837223384, -0.3416378450486144, -0.04650010864192336, -0.5033038870940418, 0.05640180238511554, -0.21175684229975678, 0.3059893003693813, 0.2249389223959467, 0.36639292064989804, 0.20316896994937245, -0.1348223420766628, 0.0763128375002833, -0.220365725860975, 0.07053190210285576, -0.1803238053305449, -0.21157355935804875},
    {-0.09396236872865789, 0.007747459632819277, 0.2750247059452162, -0.306625476984026, -0.0939981803594856, 0.11129328198851665, 0.10955386836518581, 0.36021866951146886, 0.017454902985985378, -0.19830027211215603, 0.24153749402067265, 0.17085954343062643, 0.0037519532915044618, 0.3726910631943048, -0.10867288040753054, 0.1299673154635651, -0.05984976528402067, -0.1106616875849626, -0.4277656521064103, -0.2547425733359991, 0.3580344486039052, -0.08691780975397338, 0.14608493289965774, 0.32410964514706414, -0.07079047334202987, -0.2645509593485983, 0.253113574998631, 0.3814613349969963, -0.11261247221394584, -0.031903077673580846, 0.3382459311974529, 0.40813215756349047, 0.23391818554007712, -0.01089962085985832, -0.09441058240868377, 0.2820132213045767, -0.40363797001636265, -0.6092060763811916, 0.06028612805372302, 0.20326190435654498, -0.22671837511311163, 0.5209162909928993, -0.4237569237256174, -0.031084782284790915, -0.2208578871268113, -0.18862267242871908, 0.12622998948494293, 0.07990475796858279, 0.29558414517646653, -0.4476734519898751, -0.5580282317700406, 0.030285766376420987, 0.1387423474591569, 0.0025468771617589985, -0.17547921172874328, 0.05177139806459624, -0.21640389158755996, 0.3955494101297821, -0.0577688623236763, -0.6432649139881679, 0.2511022035652303, -0.3693627056077612, 0.07942559241190571, -0.23729005980997228},
    {0.1551691497452639, -0.010316567023235922, -0.3804110086923317, 0.27225358759619284, -0.26512666118243466, 0.23149097511654804, 0.6081225196478217, 0.18476692966518013, -0.4076244614760897, 0.5709020396822613, 0.16297384636030574, -0.004464498130257914, 0.07027143695619384, 0.3518811284352665, 0.6140142593887806, 0.3662053923815516, 0.20354170843276, -0.10684610690108856, 0.7516062734985601, 0.4839016100867005, -0.10075461732319715, -0.20244711353737907, -0.23186512737026413, 0.315012210431987, 0.3401947683000528, 0.004862079763640729, 0.006196715364568954, 0.19393400687696696, -0.2652978148182389, -0.2558218960301917, 0.07409979375770495, 0.2530863714757297, 0.04904230505200931, 0.17588008686895765, 0.2655576827501553, -0.01444464748128766, -0.1832283087617039, -0.05473155060415929, 0.397912069313795, -0.4423441693682479, 0.04014467760063028, 0.6699490895348452, -0.38616030917533933, 0.10700274381565841, 0.35833691383756955, -0.3005901081920786, 0.3085183418119131, -0.10398630810838187, 0.0007055336063600681, 0.27999945658253905, -0.12609901624178652, -0.2640323033601869, 0.11402972454498235, -0.1142135301621789, 0.11556098831327967, 0.22785568690797664, 0.09031794514784847, 0.16952896694580774, -0.3532257852341256, -0.2933353049030201, 0.044567301678172064, -0.00974506387924528, -0.42282374800761197, 0.1357865285514253},
    {0.11647459166187765, -0.41493942420677515, -0.47132457289527047, 0.2696470102773384, 0.335807804538667, -0.3495466572486438, -0.23202288228916346, -0.3787968592952638, -0.24865911279090713, -0.0033714452414305156, 0.3950639574054125, 0.24533527862799706, 0.2592901026075638, -0.01694943765342149, 0.0676593952458881, 0.17884749057427024, -0.07495462194711933, 0.15097262247830667, -0.23591292782032977, -0.2792891455171592, 0.25108572960222053, -0.3515901717959884, 0.1748677532370414, -0.06877950459636488, -0.5937844915000002, -0.6190003103648963, 0.0194222606043731, 0.1067343239163246, 0.04224149710640661, 0.11804088409838516, 0.0706613694632605, 0.0650561046693746, -0.1783261497779149, 0.22773987260451684, -0.056076743696699356, -0.1424497495374214, 0.30767336776344134, -0.47868346818223884, 0.17635062459834341, -0.17012392747299956, -0.45976188699560605, 0.266936516326032, -0.20619514334712377, -0.2869646608398183, -0.4287869183697234, -0.38694348851612065, 0.2161292779362989, -0.08176902159420685, -0.5011526017270658, 0.20276207061392365, -0.12403356715385476, -0.3678680192643496, 0.014197054915026385, -0.318784612630293, -0.4138697670064537, 0.25846945538242944, 0.08346157385638597, -0.07453984273792467, 0.20279129427738246, 0.3552388024882754, -0.34763001616218736, -0.08705258392970917, -0.21893980205420255, 0.11405697512635134},
    {0.18374070746523224, -0.2852520475220399, -0.4887123554208955, 0.29807757382597877, 0.24944764902284322, 0.48815591164002076, -0.15948239031068262, 0.1363829329936781, -0.6350265613562311, 0.15549309563137498, -0.3268776974172512, 0.272669329629119, -0.4025626657630212, 0.24949103664104752, -0.21908737108129409, -0.38470817178542294, 0.3902350266398222, -0.33724968124359656, 0.2431252204748745, -0.19397162476195254, -0.12316680625491722, 0.2982194906410509, 0.23715714426206655, 0.24271798741034062, 0.1590868026635097, -0.08902388326783024, -0.08711920851013243, -0.4868933843405258, -0.19701413086153238, -0.09866813361345073, -0.24899239446271082, -0.30435363908046, -0.2536678130822626, 0.23365650384647496, -0.4720418804823646, -0.10288548298752416, -0.08916437984908217, -0.17462649419004916, 0.276476584526593, 0.004626963243783677, 0.437767435499452, -0.11531228619647703, -0.14105479024391854, 0.09689570885342924, -0.20524494645032082, 0.19052939190043455, 0.0633787670510853, 0.3052905317217224, 0.3085926855613145, -0.0023376388977396504, -0.4494329217273447, 0.1987967790234443, 0.06414720456176588, 0.4682123489332029, 0.2866429591666677, 0.2572712745007607, 0.007841427919740119, 0.0322742798387845, -0.18918948852331594, -0.4807792822285227, 0.6028803082681271, 0.1825520559905744, -0.15573637468859472, 0.445225064846997},
    {-0.199623182768118, -0.44364924359708696, -0.450761864449998, -0.05814520302001611, 0.495468357420638, 0.5095012722199311, 0.03209387032920946, 0.11270161132725914, -0.46440421663142967, 0.16425311009895166, -0.3778489187837958, 0.4246208521963461, 0.31088474583275805, 0.7122372824659707, -0.3725057504979831, 0.3459214087465223, 0.39535951522660673, -0.010157518136544605, 0.21519908717525332, -0.0424612483665347, 0.014243032295822335, -0.22065697683452953, 0.2977803584065155, 0.10047800525632493, 0.20516385879332288, -0.29509256398121086, -0.417361426343991, -0.17560955267459197, 0.1384092107207232, -0.3494573513476107, 0.3260027027531742, -0.14604572515847322, -0.07002818806658465, 0.5965528500271561, 0.5664644347813645, 0.07284799220561626, -0.03877668594565678, 0.4021175060355836, -0.22543537642312197, -0.5744418817319179, 0.3061072720909838, 0.5927550398875724, -0.23623861153122208, 0.02160242510617388, -0.1322635587472413, 0.1503134437137474, 0.25038844050730785, 0.5355340970177558, 0.17402617783556426, 0.30537529897132376, -0.37767159886477414, -0.24224128450196347, 0.25076660007957435, -0.11065146301252506, 0.22658461678374964, -0.16363245172222993, -0.0054324789919590845, 0.001827190116487561, -0.10936700905076585, -0.40605576077166194, 0.40740744389797184, 0.6053755149430052, -0.31667135214532155, -0.26844525374816536},
    {-0.09460450493001428, -0.021061988170469052, -0.0010815419870015513, 0.36101096602358446, 0.46578261711627866, -0.38816174219742844, -0.019672646950932068, -0.3798343941509991, -0.4407037439009515, -0.30828178696103203, 0.3883308199596681, 0.3180874168495742, -0.1066202035083584, 0.5092706735054119, -0.34252500505486627, -0.67757073178083, 0.1682380585013719, 0.13693193820603228, -0.35352786334913316, -0.10427929318020292, 0.1384787042234285, -0.14616392580255125, -0.12101552895416372, -0.21724273953466874, -0.32721267198217513, 0.34454924215605265, -0.028305180161270625, -0.023685475610829967, -0.46135158727558445, 0.20023577668647913, -0.05048742839024785, 0.1451145073800472, -0.0727854499218945, 0.25962427652074954, 0.10530214605972864, 0.10083579477266735, 0.4299352314660499, 0.1447590994822028, 0.34475578001761265, -0.4385370107399828, 0.5367405518560812, -0.13943766284009043, 0.0054022642365625755, -0.035576268230621516, -0.35196391078450445, -0.5821224602549966, -0.14209788538258328, 0.3626469356164904, -0.6752393427518723, -0.32882820485409686, -0.2030977642078136, -0.13281418535126258, 0.35679800514220456, 0.49507820939651714, 0.19905948987870495, -0.06062662009475121, -0.11117561018237482, 0.2305071835178001, -0.09328901169183712, 0.32440518905830795, 0.5607488680047269, 0.20393355809624747, 0.32363465337410086, -0.04047601032438754},
    {-0.3555989769907337, -0.35909140013264607, -0.3635050132583318, -0.24410687510264772, 0.5229619022273336, -0.14603425931113817, -0.2120290184693385, -0.4316612628075287, -0.2087889880123284, -0.35424502018987275, -0.6038800983763475, -0.554562230028027, -0.023321401348625967, 0.04674624928326253, 0.07083266774781434, 0.037926999913465945, 0.28289914810222816, -0.15172720300649556, 0.15034953364616235, -0.22125713212976503, -0.36018926974189114, 0.1586863151459929, 0.2646282414836471, 0.06471052066363939, -0.02894930251441089, 0.001961546528658245, -0.1395795654406658, 0.16646796956683957, -0.032746687136802045, 0.42981312969608204, 0.18163873100724448, -0.09472084100448111, 0.44396088142278556, -0.07450445906449127, 0.1715177798216254, -0.32826722173756157, -0.40428310426841335, -0.18133916383245652, 0.4172298034746418, -0.19527809504925903, -0.17967095880956027, 0.18848185135328413, -0.5195910363720401, -0.2633644951395974, -0.33357922442887306, -0.13678984228063937, 0.6687131500891473, -0.42956842415648994, -0.40125121553073184, 0.31038934596837564, -0.19199074092885307, -0.19473823714272143, -0.3801049144573066, 0.05663895351570304, -0.23453920126213215, -0.261018373894503, 0.037734329045203144, 0.04130390893441567, 0.16932260307833397, 0.400682598958703, 0.1198839209819008, 0.414861289798443, 0.12491841483150211, -0.2816610797989014},
    {-0.3985723859974132, -0.06127297487582625, -0.5599497151181898, 0.1203295051643515, 0.2519177610811716, -0.04839683454918568, 0.1851172243041234, -0.5093099330361678, -0.544893900929621, -0.23717828685140646, -0.4235326515183463, 0.057149626674528865, -0.30593221034327384, 0.4237420036306866, -0.5168698539518414, -0.3019606901103937, -0.3172270518030714, -0.29834078692796323, -0.12785460701910137, -0.5600552135488376, 0.08289511395636835, 0.5559178237802468, -0.1331705080580588, 0.3690832203598685, 0.12754398913390905, -0.033574997268837656, -0.2552986861244811, -0.23545294182524834, 0.11744125866289624, -0.4024623566672092, 0.2529347809985239, -0.3035264395723264, 0.11032035216581101, -0.028374691285389473, -0.10146084377648905, 0.3197247987458602, -0.05609378856242812, 0.04758952116164002, 0.2962299557767998, 0.23233415669118895, -0.38277022153662715, -0.013315387153820106, -0.07693028639887249, -0.10230897280935662, 0.11195050796440136, -0.003665421157273572, 0.4139331563524728, 0.3104308113277524, 0.28362805153517207, 0.3266227311061902, -0.5052465386348044, -0.334357404051636, -0.3574767035292229, 0.17477369241064628, 0.07921057701367856, -0.3903133624238263, 0.35734977353398767, 0.03647046751387135, 0.07223980530066171, -0.34672394102374987, 0.10504149697167854, 0.3890589118714064, -0.44686015308376437, -0.23256121085422418},
    {-0.08154141028118297, 0.28125201576380193, 0.1409425308649585, 0.27721474319003536, 0.22135817777981553, 0.27788811011491704, 0.0950189250904912, -0.38747365886417623, -0.05655960174096656, -0.24899718781583752, -0.23358615529209048, -0.18027603722865398, -0.18752237971407223, 0.3071907342278622, 0.6146762554904024, -0.3907705835174966, 0.337066145961836, -0.07851478343043039, 0.2756405121208429, 0.11839075444742404, -0.04918547589680294, 0.33939372022990194, 0.1698038354795736, -0.21334885744268237, -0.37204754450560373, 0.026802076623147653, 0.294407177504878, 0.04433387298691793, -0.41063695668848205, 0.12556299934732482, -0.15966755808596156, -0.053748970427628835, 0.4040704521921859, 0.042543525638486276, 0.10022729206043812, 0.19624688848566835, 0.1341543929901023, 0.1832765029819902, 0.03734146306226093, 0.18969501262182198, 0.2972556921039822, -0.21750301522224577, 0.569999531431643, -0.024095128885701717, -0.17883801802817126, 0.04327328529048945, -0.30980807692138634, -0.33582828467944104, -0.3247156633008398, -0.1844154976114586, 0.3601021489927417, 0.10731665492991563, -0.3799292583112106, -0.08905478118198443, -0.16960088476635893, -0.5236467243136457, -0.10278683596106607, 0.461743003804373, -0.19490831894662447, -0.47853270367011924, 0.11197345632498762, 0.29699084598218417, -0.05392601941651081, 0.37020601160875505},
    {-0.3884344496967103, 0.20260319090177914, -0.10914785649877361, 0.4379733613900087, 0.36216661649080184, -0.019187785529798693, -0.28894322816666157, -0.7437921767912457, 0.20920347985056945, 0.017536556322035414, 0.25924415428372616, -0.17414617078036226, 0.4664964915336486, -0.0350511881113545, -0.012101972632748785, -0.0793758675846435, 0.283950784912789, 0.17933965515028683, 0.3043764156510364, -0.6250392809506713, 0.06348694896598361, 0.39645406950782636, 0.15871346105492656, -0.20365330740944554, 0.05247830081636322, 0.24283364671674468, 0.4895159170294169, 0.3507554408175846, -0.24087578845568844, 0.10565798838151753, 0.060997872113037775, 0.15298787082587872, 0.4552979155885734, -0.26013791953822146, -0.18729343135184032, 0.23217895410720962, -0.1752047300637614, 0.06556024537369975, -0.4240937744953179, 0.0004442990440806447, 0.38002775334026806, 0.5147529216736461, 0.20937436618176772, 0.26201361908620263, 0.31227771382943875, 0.16285143290376755, -0.19478954797583178, -0.051866744334150755, 0.18200908313798536, 0.3726096932461988, -0.14052845594743357, -0.133227261253015, 0.0029740123507193713, 0.0994873715986681, 0.16934532770749702, -0.19166268602495695, -0.46487358597183764, 0.023826470203908025, 0.17857402730711894, 0.444147577632906, 0.12626365323190963, -0.23819626284858617, -0.166202473910121, -0.31111321840305084},
    {-0.16022736555163733, -0.43540570794413513, 0.17929009366152934, 0.32940126131837416, 0.4982553007863209, -0.33382042035170073, -0.4580479375349588, -0.5717298728203217, -0.2905027729230559, -0.2364903119313474, -0.20457703217039871, -0.5567541991376196, -0.052659073694278816, 0.6152549585266496, 0.3230181852003477, -0.37946614881820445, 0.5550937078887704, -0.3860453736619794, 0.2790900734839229, 0.26147799916500725, 0.19271722789127346, 0.5360474889196486, 0.05303885078577794, 0.05757135003257374, -0.41056260064615774, -0.30325243031008153, 0.4345595470934713, -0.2706721146350956, 0.4434887766316016, -0.02208646214738414, 0.2543282649529015, 0.4857044786396571, 0.0736057757504462, -0.2106011900110316, 0.03384276519028574, 0.3638735179709948, 0.1633987894476973, 0.33090213948810854, 0.16941777852657083, 0.10921702877778824, 0.6723880249215141, 0.2781811672784757, 0.15627682052228256, -0.10530537542474952, 0.2022485331646887, -0.21643530481143575, 0.6853188720985668, -0.07271483705435393, 0.33650984448323507, 0.19738239902779517, 0.09604203378359166, -0.13972967549051823, 0.6128787972614055, 0.6500260623391224, -0.09296079991068541, -0.21066589255065454, -0.15034100059037203, 0.2932925379632749, -0.2706427758005863, 0.22592582245536902, -0.10994703875552286, 0.18133521966311253, 0.26428852691455323, -0.0008238681184340421},
    {0.13024225436501818, -0.5194191329787661, -0.04170972372250843, -0.024539082826964036, 0.10080222814825995, -0.5150681708382957, -0.20319023738400996, -0.3845108510291494, -0.2770119115436358, -0.04002770687649221, 0.10181653924884755, -0.06249001295821904, 0.3060807066055477, 0.4901699368965152, 0.018357504074418662, -0.36432382518200845, 0.008439663430483208, -0.5008386046162252, 0.3665387549948333, -0.25874344040881936, 0.05133816696112525, -0.06778306977304877, -0.10650285338982746, 0.04933189139460179, 0.10186778635831853, -0.07521148492027412, -0.3066185632948835, 0.13856213687677024, -0.002544545145954642, 0.0639686482499999, -0.4994115199156187, -0.3936440241210457, 0.1279092598056472, -0.0362970822399935, 0.3062819145706107, 0.014768485609684464, -0.3516342129616035, -0.4168244218214774, 0.40645229362254937, 0.20204427669418962, 0.13648926293774447, -0.014662627938641452, -0.3150057128906542, 0.09524660855658357, -0.1021389681917408, -0.007541618993234726, 0.4544698401155218, 0.1791068800990936, 0.40092792987766435, 0.08665469427456735, -0.34614967433435173, 0.28701156298329844, 0.20750818232139293, 0.4887344674629581, -0.3587132554578795, -0.06875166818068158, -0.286093427252627, -0.35994726384037423, 0.1838660954775964, 0.3001391206668211, -0.3693411696175787, 0.14724222219083483, -0.16057639149829098, 0.11652559651933526},
    {0.06460978434304361, -0.19727080389631707, -0.36678516018570256, -0.20380408009458353, 0.38070005425575204, -0.4055948061603048, -0.11384252566301178, -0.4370203312927557, 0.24336747720676635, 0.4333537048711389, -0.016999016154126353, 0.3884543621231684, -0.5188088606678285, 0.21451665292430466, 0.3514660552751412, 0.42582285490406585, -0.13070851734773473, 0.08816176758051537, 0.001975970132376709, 0.037056899840354054, -0.3255464302340752, -0.00391248126009437, 0.34174319684727805, 0.058514519827588166, 0.2600803721026078, 0.15434906883973842, -0.0056137197899463545, -0.25709049838862935, 0.29888426880760804, -0.4866306532314266, -0.1803502906404921, -0.05473540685158717, 0.4129938325189666, 0.12789637862800543, 0.08215441290664917, -0.003680196494015869, -0.08885451835457672, -0.12717381337760747, 0.32466775341819476, -0.3351052979583366, -0.10748224786832684, 0.17737551616335154, 0.1469528730966512, 0.07327668733573688, -0.09245016208730777, 0.41292788036419936, 0.11899934225294483, 0.48371317785190365, 0.303404207419152, 0.33099191440837356, 0.13412140870042846, -0.35181733763897877, -0.135296571881013, -0.07514880874739897, 0.21952103576703239, 0.20796442226427717, -0.16071383494193123, -0.218492653062125, -0.21614922180615664, 0.2881667258419392, 0.4016170177766608, 0.4404366789072202, -0.13957145284186973, 0.3546399317061192},
    {-0.49758232845430767, 0.2549576905783451, 0.16556108549356047, -0.051247682130484494, 0.4785067218205797, -0.21680473506991846, 0.07057024354441245, 0.23314683218475268, 0.03008461707587417, 0.3015154062933614, -0.044240839194972896, 0.1902765759963563, -0.45516498000900363, -0.2371550094394103, -0.43883481770617466, -0.09417670422901071, 0.0625696740711114, 0.1228143950326837, 0.03137336101246612, 0.29473623255413567, 0.2190699072407837, -0.2008384365389636, -0.4420239583156714, -0.15226072752373798, -0.09721423294158657, 0.05078261618750976, -0.6669186188397772, 0.23726146548427357, -0.23025813866528963, 0.04395526186694436, -0.2856425553655382, 0.2856533531640064, 0.030753532766023776, -0.08697908694000883, 0.2071611252126787, -0.2029643406261986, 0.24983414088725317, 0.07548809104735946, -0.255179316169267, -0.39858801039601544, -0.28129351332926067, -0.24895690977498444, -0.24017349560902046, -0.05080793746716791, -0.11268322625852153, -0.1657311648321346, -0.19889194696917956, 0.5293258334522325, -0.48044234055298135, -0.16190018722664667, 0.01610734581710738, -0.37823109667737426, -0.23977303674672468, -0.15338950160756262, -0.03297922284330016, -0.04794431468464697, 0.08178476074669017, 0.27877284487847726, -0.6460821986292662, 0.2105352149769703, 0.09648560672271506, 0.3158871616414622, -0.16495520968721863, -0.4847665022773952},
    {0.3277071811612347, -0.254969416869901, 0.18144796654876205, 0.12808425429961603, 0.4768258224301619, -0.3804949428624743, -0.008029245179414042, 0.3042501904380773, -0.22426665224761072, -0.28025641993649975, 0.28099352901001307, -0.1160229394913101, -0.3289263686225824, 0.500474563494286, -0.45333656059518135, -0.1352189269167954, -0.2975301703460323, 0.13424225419776303, 0.07772300356511928, 0.04670034994543738, 0.0212259020200222, -0.1904601348185637, -0.28629312727356954, 0.06908899925562148, 0.5594032465167845, -0.200678570241327, 0.1618975389967629, 0.23494422498415868, 0.2789710162316536, -0.5981862720065203, -0.3726551325070616, -0.07789845971105541, 0.1680021734609545, 0.27198666745084205, 0.3008568697770742, -0.38445837086796103, 0.14207515004812482, 0.2084082260562275, 0.36119241809199004, -0.10875113748903323, 0.4135515074873372, -0.16387230645168901, -0.01728760279250983, -0.12309502975018725, 0.30838307016381683, 0.25863412236508104, 0.4981874139679611, -0.1415666663480599, -0.2576433641634086, 0.20713011046528085, -0.3335117886946496, 0.24239664472141273, -0.008012979174259012, 0.1688163574692576, 0.16767754192689152, 0.44993050938309187, -0.4200174861507766, -0.3833700909297706, -0.29349477999801843, -0.5979797417464815, -0.2592934447004856, -0.3749577594208696, 0.10271459074203723, 0.15921876138915528},
    {-0.5535288438138231, -0.5728636735042955, -0.04492143705355816, -0.3141828954526818, 0.3640373368420917, -9.675810620744457e-05, -0.4366114624629437, -0.5243934540336096, -0.635628570249595, -0.35901090425543525, 0.36520606997150357, -0.46611688728409234, -0.36048929691013903, 0.6361356943295212, 0.347965416210019, -0.5925646441283211, -0.2051389392687163, 0.09234903050479894, -0.023961602348090628, -0.06271609913927952, -0.11520230116035327, 0.03446266391996693, -0.40582552862381177, -0.09498876312760807, 0.1106290388697073, -0.27724688850025947, -0.20817348968714672, 0.2837235162476659, -0.6058343917380916, 0.1955160744030533, 0.27055429535108644, 0.5177065732346469, 0.038771761148437556, 0.2516134114241317, -0.7129586070549474, -0.34642696721668464, -0.0037082278353745713, -0.08425430348945619, 0.1692469279942854, -0.20054041436477918, -0.3557748676564997, -0.23658999643948292, -0.36229839630857835, 0.37558224116140304, 0.04503736641878077, -0.14450858049863022, 0.37411510056138897, -0.06477066831969261, -0.11511664280756127, -0.3415015898915196, -0.31208354594309445, -0.23288938405657578, 0.12092348499336994, 0.5174670536016386, 0.3720856745119077, -0.19255037725200924, -0.06832713425788486, -0.02029955866539251, -0.7588628017880842, 0.4708923667348745, 0.469530408933789, -0.3234412740825878, -0.3403221105298, 0.22584364217415573},
    {-0.15636217525033125, -0.2667010796989076, -0.526183696568834, -0.4094017690719819, 0.4927160663492467, 0.018720589479679046, -0.1320851304576018, -0.11916880974706355, -0.031990197737922735, -0.6122157142075825, -0.36810700258229523, 0.09504328539019967, 0.01543611235741345, 0.027489584346676352, 0.01806767341536407, -0.5538351943924363, 0.12442777462694872, -0.0726915625792283, -0.17449452839927262, 0.11621876037128469, -0.12484704635412891, -0.5737893433301388, -0.03841781665881848, -0.2010546829040449, -0.4718982569223135, -0.25413217758525813, 0.08280719597062026, -0.03358909553700313, -0.3310234437591643, 0.5487470687707746, -0.3196370054767121, -0.44599057473313414, 0.12004707804696028, 0.17971929763140662, -0.005036247852459668, -0.13819075454181015, -0.344505503249271, 0.17596709669412647, -0.34888332631544633, 0.010797306383114224, 0.22274487527296866, 0.14815713543071504, -0.2529699771274351, -0.2869516790774407, -0.603286421368224, 0.09660290551912995, -0.1707140139252202, -0.022782868510489173, 0.3704492466188293, 0.05647637669427394, 0.23392523752420138, -0.4150348580511514, 0.04767314136733547, -0.5030651755393007, 0.08418517146101621, -0.17763368003373298, -0.4248039478848981, -0.3776965160543768, -0.5840697205177025, 0.17924101240141507, 0.23086999690165103, -0.14566981108642948, -0.0026827584727201217, 0.008886306254262125},
    {-0.0440294178742903, -0.4593601175933651, -0.4197008843740596, 0.18875891960852684, 0.324112910595147, 0.3605909368676057, 0.20883986253135806, -0.16746575529857216, 0.057296018546827525, -0.21741121121315402, 0.3117312452510942, -0.32619472817321743, 0.053598991888508, 0.09229575236758449, -0.11110828495435575, -0.1839274853286804, -0.2124811943196409, 0.12970710845889755, -0.1930648481074154, 0.018482090782545365, 0.42221188880917365, -0.019941033822983064, -0.1611158704800741, -0.23967317513992342, -0.36214531008465994, 0.0638806299992296, -0.5318048355311968, 0.30850543710990785, 0.0029971707422556714, -0.3138193816142644, -0.0956467874341398, -0.3950415972308351, 0.1820218877905604, 0.16815613520276101, -0.23137334862738324, 0.18689160051519838, 0.3690000060323847, 0.24962750587499793, 0.29253170567450204, -0.07584420913179042, 0.26233371753662627, 0.46843204496693214, 0.15689725836378451, 0.0035057597361396907, -0.28052933391657664, 0.03170559258957298, 0.3298265689954503, 0.35749555228356894, 0.30484139988634507, -0.3311860273235756, 0.030609036924443313, -0.0660866210381295, -0.2542184059296392, -0.022880658558812484, 0.004794218452083651, 0.15824975905967062, -0.05581278759793115, 0.004774914676135987, -0.17099394046699162, 0.13691715291307494, -0.214261386021852, -0.33156692055283293, -0.39963278100332206, 0.07795471246906134},
    {0.3110700318362106, -0.02426277129314743, -0.3064968071916022, -0.17350279006001512, 0.07969069240931438, 0.46753634689119167, 0.3042810616680542, -0.042520005606492765, -0.24747499265847683, 0.3577643104131525, -0.22351143511738314, -0.06427674157875679, -0.3402454245593277, 0.2711166067779766, 0.5371140028839719, -0.2289100101650053, -0.4106301107138418, -0.23447925769222971, 0.5129581165374731, 0.21914185951529935, 0.043981187776961105, 0.025775044124994588, -0.19917866318571345, 0.29811191044929136, -0.5565814087071687, 0.17346899655270093, -0.5126161080204961, 0.3250535575157896, -0.06096147397617509, -0.19954120080142823, -0.2283633927479824, 0.09168500747953451, 0.5648988162332937, 0.46798636627014856, 0.32738530930408927, 0.103529538958216, -0.1972350683742165, 0.1542519501552203, 0.5668556495432184, -0.21683584606853715, -0.15335502199290896, 0.21077575512859253, -0.5027176012438365, 0.1637760764586362, -0.12991621162202982, 0.03175896820522296, -0.620100267446264, 0.1367604708001298, 0.18277478137536668, 0.19436732124962272, -0.028586598015697576, 0.1716091175026903, 0.23094965966312422, 0.4844326516627422, -0.5172735680695844, -0.12596852144880913, -0.4784419907995575, -0.3098105741009551, 0.04464752782701301, -0.15841825314894717, -0.35802985500821605, 0.3399545437969062, -0.35217653433861346, 0.1772793014547739}
};

static const float b1[64] = {0.9197868694652229, 0.8231449601013193, 0.980138208836969, 0.8157318334416377, 0.866554369328784, 0.9513137217763198, 0.9372781984945722, 0.9643380075823477, 0.9500841935869574, 0.9069205676447054, 0.9243534842125785, 0.9131412289548266, 0.8939475174507013, 0.9390756679865531, 0.9137320376973793, 0.9361665188299272, 0.8521142792835059, 0.9430770561275453, 0.938909323200412, 0.9042848109090185, 0.9049083793077348, 0.8623520319895475, 0.9171783810767677, 0.8928118421439444, 0.966775827283736, 0.9013839446474304, 0.95876715804298, 0.9934098513775702, 0.9014125804146504, 0.9561047103179938, 0.8853802181645691, 0.9129129644403361, 0.9789220656438922, 0.9120350389235118, 0.9278956004880274, 0.9453477940277758, 0.9184347206195096, 0.911277325777736, 0.8236269493664105, 0.9096534019876097, 0.9335671664902175, 0.9632841575341766, 0.9156900036065484, 0.9654280373201856, 0.8235195713412478, 0.9451333636505894, 0.9625794090985542, 0.946810033571922, 0.9616216644864275, 0.8796933142152364, 0.9143894861999242, 0.8364393917420657, 0.907057609901049, 0.9401920678174548, 0.8688304961229962, 0.8768174066984176, 0.9558442135637956, 0.8710433914216233, 0.8986778700335546, 0.9415207785719463, 0.9068905114104269, 0.934458270247765, 0.895530203561318, 0.8872907902715631};

static const float w2[64][32] = {
    {1.0330226284119386, 0.989399148937174, 0.6051672717874194, 0.8078707786144098, 0.276029087592069, 0.9545848755560419, 0.7327681341689319, 0.715502149540093, 0.7896064163550115, 0.8732390281465525, 0.5470288548655587, 0.8945544162282237, 0.7678624873378312, 0.7075190483232167, 1.0709262853406047, 0.6265194692982649, 0.6228055614307859, 0.7904518021466893, 0.6466568531018896, -0.30801251899405047, 0.8894162287990934, 0.8055247712841106, 1.0098896770093737, 1.0800531681149128, 0.2950350157859615, 0.6301421726835841, 0.9685535374406327, 0.9247414079547059, 0.9182204598705153, 0.6821143476979802, 0.9672026320690029, 0.9352335088281134},
    {0.6600886655749929, 0.7695809081314847, 0.9100193969816642, 0.6659148559218172, 0.5747108890518576, 0.8340099326868989, 0.656121014351524, 0.9130540962987168, 0.6529628987040994, 0.9198008800526651, 0.5128941955833322, 0.755384337211094, 0.9910303721369828, 0.6986074363712479, 0.7214848330783743, 0.8207721232131441, 0.773823998821776, 0.7114567567339757, 0.8130277044999994, -0.290324052311541, 0.7415969993234566, 0.7367447461440715, 0.96746750127004, 0.6266401771349582, 0.42262207080112907, 1.0202172552525979, 0.6944908915060508, 0.9430001984933771, 0.5972534639743764, 0.7927297712171768, 0.8011167225508015, 0.7773550605724592},
    {0.7875954881773705, 0.8362689897858198, 0.9547401206206061, 0.956593651706037, 0.5680868726454278, 1.0359004758451553, 0.8787046005876634, 0.6426926847663075, 0.6280496258574196, 0.999509300690357, 0.32007264986052947, 1.0190604773922713, 0.7847368008731419, 0.7691657043966765, 0.8075872398936838, 1.10118740907557, 0.7839361071851924, 0.8732544659781054, 0.7233867776190495, -0.05777754611653754, 1.063078150436055, 0.852632056733837, 0.7313713288802661, 0.8601637948559542, 0.048624143754178686, 1.1155899654533705, 0.8763217872274807, 0.8970740033821728, 0.6412490125476632, 0.8177758602858083, 0.891643777529449, 1.0847207207271052},
    {0.7624839966646496, 0.643115645056317, 0.7376821581434131, 0.7068898999635544, 0.5160893811766565, 0.5797832980315509, 0.8656791020857999, 0.8290158617485821, 0.7863541900373683, 0.857162129624298, 0.5363067449760102, 0.7880637032050911, 0.8448621934177147, 0.5247060354954648, 0.7799774953942163, 1.0238003933645414, 0.6908677378522676, 0.6176406942947521, 0.5962811291209581, -0.05761598438330219, 0.6939844987722634, 0.7251646085333237, 0.9220255749476932, 0.6070417290549585, 0.02611964763120983, 0.9428923176736946, 0.7896631062477942, 0.8378742699337061, 0.6113970279244846, 0.5992005114800617, 0.7211730773736799, 0.9642008430140899},
    {1.0128378735396988, 0.7811166389797902, 0.9811586909907917, 0.6548998302489764, 0.309693190979157, 0.7967753847838597, 0.5256363627904095, 0.8383208430186982, 0.49704965927027567, 0.7288041748827877, 0.4205469893922152, 0.9079437229325772, 0.7548156744618606, 0.7598676500398663, 0.8596703863703176, 0.9032439364837129, 0.9107355638251212, 0.848281441921352, 0.821279200605615, 0.024265181885577476, 0.6590976797754593, 0.8296872313173692, 0.6608799928723613, 0.9362501355370089, 0.2106978849458711, 0.6849732115385226, 0.9168724811401769, 0.7181766006910885, 0.8773778260607681, 0.5740680790137295, 0.8570604005686507, 0.9860362838816635},
    {0.816249730888279, 0.7619855320023927, 0.6417236454851734, 0.5469550994155226, 0.5464464193087996, 0.8919746531738941, 0.7926787180143375, 0.7346956289374115, 0.48797320104944497, 1.0551796132384765, 0.4306635264928807, 1.0418905912529441, 0.9871995403740406, 0.6890317289761735, 1.1067676971673197, 0.9421771343072538, 0.6447548795691632, 0.6102532839143512, 0.6271742383474506, -0.032146121969712005, 1.044055033150344, 0.7782532669618465, 0.7030135836658703, 0.9566237892262875, -0.008422195463722104, 0.8483236948970666, 0.9130229616645522, 0.5914407462315947, 0.8479962701493009, 0.7508238736476484, 0.9802779508987236, 1.0076971607010885},
    {0.7456271619932503, 0.6921768174401096, 0.7694807722004874, 0.6714056217265446, 0.44155361793609615, 0.6532987495016773, 0.8039659112944613, 0.6542825095847392, 0.3803957211608759, 0.7744916583052861, 0.5781508240629658, 0.9383180713778773, 0.5779311258585057, 0.8060619082419622, 0.6852925520560297, 0.8993106912362923, 0.6800648634742205, 0.5656656202268617, 0.9771289354117835, -0.07191812650774432, 0.6595712627487087, 0.747129902542537, 1.0021223493327232, 1.038245500261428, -0.007464793460913714, 0.9819743441014008, 0.7187620069253036, 1.00225617637439, 0.7393799809313623, 0.9000561140052614, 0.7644613938045968, 1.0876571945484519},
    {0.6307887209171895, 0.7223776310348211, 1.0680821271082193, 0.6317579781651392, 0.3487708053385133, 1.0510016070366162, 0.7371177477785171, 0.6184693834133104, 0.5465996292992984, 0.8924442295081886, 0.6115614462213499, 0.7763395997733479, 0.7487271146169557, 0.5634274541459466, 0.8182759368217151, 0.9356461483546444, 0.6341064731292737, 0.7669997587369873, 0.8762555389974008, -0.20666810621408127, 1.0733798499105676, 0.8305509378610381, 0.640654229573007, 1.0525993736812187, 0.24432334623538365, 0.922492698640817, 0.6347397475650193, 0.9875785463820556, 1.0374167214389602, 0.6475084661647839, 1.0174926130759787, 0.6528726088689792},
    {0.9053171723757564, 0.715778802114291, 1.024428432594302, 0.8823681320680355, 0.5653313420362835, 0.9368957726809334, 0.513026488732712, 0.7419958608360163, 0.41254159114009237, 1.0169120783647632, 0.5007811533268859, 0.732130399216571, 0.607780127030372, 0.7370080940234738, 0.9939611602202311, 0.7373613340591589, 0.5924168220093012, 0.9326712077538856, 1.0491216106534338, -0.031107123658587685, 1.0914969480792962, 1.0158213983327673, 0.8886408718670747, 0.697398071245773, 0.2992157719461479, 0.993626082707057, 1.0018938883749422, 0.7703973752881714, 0.6650435486001323, 0.6533040189594538, 0.8884413037771314, 0.7652902714146783},
    {0.8908562784788132, 0.5909419829171784, 0.633410062182537, 0.9450144051277972, 0.34971639395705195, 0.9234880315816681, 0.6300455881434943, 0.8882664356821097, 0.6989611325237455, 0.8200291929974938, 0.37881894551345224, 0.8559947774123873, 1.022403921208994, 0.8746627235376002, 0.9499056513509105, 0.9369001705995743, 1.029421742573236, 0.7917098711635779, 0.6657577243047312, -0.30387398966788276, 0.7817918278286407, 0.9498011980596995, 0.8262254438190534, 0.6884470561488482, 0.04072513236579871, 0.9270618600065008, 1.0543459002719144, 0.683557267934058, 0.7990783201466168, 0.946925613342017, 0.7213715011506602, 0.6709132188280323},
    {0.8814081970405283, 0.9933776651330082, 0.6309490653606791, 0.8767992217293263, 0.36754643601539067, 0.9598743971066025, 0.5303886085828081, 0.6973280784368397, 0.5536818424302983, 0.9648396358589334, 0.6395203151916297, 0.9398326012588598, 0.9020098210546593, 0.9299042382057562, 0.9949143441933896, 1.021628718560226, 0.6047846332242076, 0.5895493330791327, 0.9334698404041523, -0.22916063072089737, 0.8297178944730783, 0.992579039184644, 1.0070129033711188, 0.9083950489774762, -0.012142248803242106, 1.0579609445027436, 0.9779458637709049, 0.7813153180702002, 0.6981801062613069, 1.0567385263426803, 0.8387144083232007, 0.6948899969585939},
    {0.8695827682306786, 1.0467272543112638, 0.9384400925062042, 0.8346776836011989, 0.2923999471087687, 0.651596161206581, 0.8774867297118635, 0.8156912499782495, 0.5400117741666113, 0.8163860425659872, 0.5451022453246428, 0.8519779338041931, 0.9362758834198491, 0.9120847491949803, 0.8955896620709987, 0.8676828713695307, 1.0043138956596065, 0.7269900559833535, 0.8200084350166734, -0.2784323299690761, 0.8811412800679407, 1.003949200002261, 1.042355731769134, 0.844467561713034, -0.039449104629770325, 1.0231423960721353, 0.9518294089955478, 0.7616963243208705, 0.6601186960381358, 0.6045703420355407, 0.8502430086149031, 0.7067164554100073},
    {0.7785884930948178, 0.7642156717277514, 1.0598350634119205, 0.9561979354383591, 0.4471091112792756, 0.5776033999815863, 0.7884531495625295, 0.8608603507077024, 0.4391989434097084, 0.8482589209327657, 0.3879134656740345, 0.7118910440051739, 0.955087122964381, 0.9900572730316729, 0.7758375268225808, 1.017237803283695, 0.748911627210746, 1.008411895334583, 0.8487580770207069, -0.0867804109252034, 0.8461236304356949, 0.8863069756770084, 0.9193211734200046, 0.7825204423827188, 0.1765697065939346, 0.9590973744908307, 0.801470483092068, 0.8328362013980172, 0.6506013009498689, 1.0259680841313608, 0.5958620412762474, 0.817704150407525},
    {1.0560354072793945, 0.6744783624500246, 0.6994445501794081, 0.8391899139905507, 0.40365688966749774, 0.7673720080746018, 0.6203322105214921, 0.9340292043258187, 0.6571055043934745, 0.8813000752318544, 0.5771165753390053, 0.7131340155400275, 1.0310814689142318, 0.6890131364760848, 1.0562631786303949, 1.0980474546470718, 0.7074854701701965, 0.9093175172752969, 1.0078000077001446, -0.18883902945238315, 1.0528130359828458, 0.7745992846458843, 0.8740807920856024, 0.6979023182037565, -0.07474280798343555, 0.9919934652263598, 0.7788379750733315, 1.0730395752667339, 1.0355037087730157, 0.7790570876075975, 0.8301930514841116, 0.9117409287873965},
    {0.8802082207204831, 0.835734466879536, 0.623240053967725, 0.7785197982103471, 0.3106920345014907, 0.9883078824960706, 0.5890621521502727, 1.0528132792562959, 0.5637814634618197, 0.6609580904713734, 0.3458518963093173, 0.898049964064027, 0.9718327971643597, 0.816550945875516, 0.6698798424522497, 0.8080873501891839, 0.7011644094660444, 0.7965077016415009, 1.0482561843767173, 0.0667568060197881, 0.8884799353122858, 0.9476265475333554, 0.9003583606953486, 1.0597410893406543, -0.07493518023994819, 0.914049757480557, 0.7970435093565276, 0.5801502951278866, 0.7306701406018441, 0.8416500259294032, 0.6151186829710271, 0.6435462591333},
    {0.652010862999856, 0.9848389175403675, 0.7953757889584321, 0.6333333968837737, 0.5806713996864722, 0.6099400343737191, 0.8737436684042312, 0.6206501365697055, 0.5190864687342721, 1.0567364745547247, 0.7140693647718531, 0.7538245853676498, 0.6523233912882475, 0.5970401785892853, 0.9871124064615993, 0.9398331476738693, 0.6814687718058536, 0.9105043269121875, 0.9041914064201302, 0.01018907314296227, 1.0157343620881731, 1.0857756432303027, 0.8602126201951777, 0.7265178423210134, 0.026604434105811873, 1.0002592994305637, 0.7911794233067382, 0.5938532005661274, 0.5979023312997463, 1.0423296275393859, 0.7891225996344396, 0.8202471907574427},
    {0.7961911623304662, 0.7716146642231599, 0.6115842377989376, 0.6780770418692365, 0.36708942442451653, 0.7075555433798302, 0.8900701646731587, 0.6585304025898908, 0.821083380916358, 1.001195631627485, 0.38226303188534344, 0.7329471153557067, 0.7377936718101368, 0.5741872554969261, 0.799277284582532, 0.6929353890132494, 0.679152663954078, 0.7994290015807002, 0.8505856907341782, -0.15516744230687562, 0.9477249514686723, 0.6367906625479052, 0.7516717404675562, 0.9308074637034005, 0.001488430958854362, 0.749805766497343, 0.91844795418565, 0.8118400179283228, 0.6667902176060946, 0.8310145620401379, 1.0169136508867653, 0.8339417336103255},
    {0.7942079349171753, 0.8638306205276981, 0.734769028048626, 0.8826665157859369, 0.6056533339277601, 0.8696622695667607, 0.4732099194413941, 0.8151303802880571, 0.398917823271625, 0.7426470241641139, 0.607391644653177, 0.8026931706095489, 1.0018995729912816, 0.7045431546784633, 1.0745821856350717, 0.772693206434517, 0.7102829281114605, 0.6112431920390488, 0.7929602528449582, -0.12435051334134549, 0.8212051394758402, 0.6417240444673312, 0.7643465863183969, 1.0411132132395233, 0.19759960623194786, 0.9875336972420808, 0.6432967318768495, 0.7515132178551278, 0.9622532059510466, 0.8735965512328807, 0.9838158845373941, 0.8836271936546658},
    {1.0079988990036277, 0.8907495119747325, 0.8333344120815233, 0.7570282294086749, 0.42489797596861817, 0.6742624626734904, 0.5806575346455763, 0.9658795241304424, 0.4507377269247823, 0.6798684058853831, 0.5998353005769324, 1.041167568732603, 1.028845160781348, 0.8726289372232103, 1.0909277224498795, 0.8364692738992526, 0.7896227697517236, 0.9213175170047915, 0.8818692911368212, 0.09616035537253259, 1.0916402678051562, 1.0619522995296284, 0.6033356185819937, 0.7058096025477022, 0.28929580252492704, 0.7209063405589738, 0.9804397140661547, 0.8912122773567157, 0.7683569304585403, 0.8944553350669581, 1.0252080678434052, 0.898878134687141},
    {0.6690705456498249, 0.8525873759573294, 0.6370096886028888, 0.8559800001102387, 0.519340243117735, 0.633001692312885, 0.8149587564563118, 1.0068285351498205, 0.601237678129117, 1.0807448794271317, 0.7582223131836953, 0.7643640624921141, 0.7528409392155612, 0.7163866686948077, 0.9366726015308484, 1.1002634214702565, 0.9294984314186205, 0.8862655477287518, 1.0424673685943728, 0.15341033802396986, 0.6547278989527104, 1.0392780620629256, 1.0173191445422258, 0.7549337802281438, -0.03046098940747595, 0.9480989262871373, 0.83481108838921, 0.8618205747966166, 0.7150561229495673, 0.8423535600275295, 0.8662409263272975, 0.8688013632091203},
    {0.7232717118077161, 0.6683764461889059, 0.7975657882028321, 0.6809356935478251, 0.34922345355707973, 1.032514248083082, 0.6487563109454034, 0.9557012141903766, 0.816803644670449, 0.9387029700807282, 0.5286799932660807, 0.6936581436128364, 0.8726679714982662, 0.6616587286670057, 0.6908520859862897, 0.6280800564083259, 0.836541915953903, 0.9396893838533917, 0.9716209261505936, 0.03991099514184187, 1.010668696813054, 0.9992518143622913, 0.6792670881082316, 0.9952653637380829, 0.4179067760070328, 0.717045488596934, 0.8243733903186803, 0.8800378439114102, 0.7813855553386703, 0.7083047003029833, 0.6548455116406205, 0.7464495393029508},
    {0.6222723695375775, 1.0258024991157748, 0.9811979388904568, 0.5129836597932403, 0.32064908662499825, 0.8567159719060141, 0.7635754357289396, 0.953396863080923, 0.7274738382105269, 0.9579885841429717, 0.5725088750331326, 0.923730786534244, 1.0112662518915803, 0.9541593892130735, 0.8684940000053689, 0.6780212251919064, 0.9497561191999049, 0.772551525181652, 0.7917564897574988, 0.08061188958130147, 1.024784930625379, 0.881699584248829, 0.9796675284396706, 0.8333965707908895, 0.23397503459308855, 0.8197298065924397, 0.7004674877354408, 0.5986982692906714, 0.6067838816443558, 0.5550724126135876, 0.7026511961240677, 1.027165814052482},
    {0.9083825951584535, 1.035363122188121, 0.6104649732028437, 0.8946565439702283, 0.6462233111156989, 0.870296502833997, 0.8905749618976883, 0.776207899296655, 0.5465601204230746, 0.7609491084131864, 0.5461414859966168, 0.5925375829374271, 0.8885928652019309, 1.0202109725406716, 0.7674342313990705, 0.983358539279419, 0.8671712623413663, 0.6824277952775071, 1.070882315625415, 0.006837781688108674, 1.1166059334599603, 0.6428921702238487, 0.5757490117780976, 1.0186919027274093, -0.07098424689104704, 0.7778239780673675, 0.745436374864092, 0.6329106823789663, 0.8427883119883164, 0.8066397079183871, 0.6935013976038067, 0.8771158120705939},
    {1.0278412711569032, 0.7999607041049643, 0.7259081108718644, 0.4928253787992447, 0.4154745116223822, 0.9743094977069362, 0.7290570708702618, 1.0570632944122447, 0.33668110066719303, 0.6665203473829494, 0.42155468301408877, 0.7970220016427908, 0.8996551520609178, 0.5402683011038691, 1.078101327426182, 0.6971842974666506, 0.944896074693385, 0.7987009404404383, 1.04277892089193, -0.17723635273885005, 0.7377302213028623, 0.9828137937762503, 0.7160743162004768, 0.9972363492273719, 0.41936463362356996, 0.6995616753421154, 0.823740121928323, 0.6848219259710798, 0.9501574519717013, 0.6033714122244772, 0.8688720128697663, 0.6691748325168744},
    {1.0758904633054924, 0.9310759057481821, 0.7842246331062454, 0.7574196585474199, 0.6201053327791731, 0.680769075879717, 0.7070522477507198, 0.9277594800565124, 0.5503272671746879, 0.9930605545622503, 0.3933577019056696, 0.9357174969467117, 1.0508445478629271, 0.7558132797209248, 1.0743027291506169, 0.6519029229573353, 0.6246994823567653, 0.6119598553842228, 1.028414414317357, 0.036611550161422646, 0.9751106589867514, 0.7203322058530377, 0.6754228340548307, 0.785078146490677, 0.36789644208863204, 1.020467675586481, 0.6988821726379201, 0.9400695874883128, 0.8329732868637053, 0.6610608266394413, 0.6453725333241564, 0.8679215156750644},
    {0.7952732803146184, 0.8467255479276249, 0.6562977290633137, 0.5820136397965442, 0.6279769056454018, 0.6518087735680523, 0.8192483726244241, 1.0275705296969377, 0.6003908244843458, 0.624070954113357, 0.6204428474367175, 0.7627298374200603, 0.937857011423774, 0.9714924312739688, 1.0511106081582766, 0.8872681268559622, 1.0373223801189098, 0.5754714210289161, 0.8122214162038757, 0.00044843783231264246, 1.085526442172383, 0.975129445855241, 0.7738108638145333, 1.020305751023713, 0.40326213856515325, 0.705386351383462, 0.8295478149048361, 0.6572833661945631, 0.6036544319693815, 0.8357828709838347, 0.7110267673178624, 0.8812729787169493},
    {0.9516199326780836, 0.9645206563861867, 0.9440495290976716, 0.9615827522612789, 0.3595902794442295, 0.775923046031744, 0.5924502256791737, 0.7535655938698859, 0.6284868837826181, 1.0681809818441883, 0.7566216525005438, 0.9920915967226519, 0.6711068351099825, 0.6169375169552602, 1.0149079220086643, 0.8357396467300605, 0.8837783863027664, 1.0092887677288458, 0.9961724586254371, -0.12471167740467622, 0.8268872752168168, 0.9278488273806073, 0.5735980815643529, 0.6021117823091874, 0.0258103481618456, 0.9871803561395517, 0.598211488661821, 1.0256110136002656, 0.5702512425666858, 0.736481959603895, 0.8951162202065814, 0.833424854245919},
    {0.982439870510468, 0.700855259551476, 0.6425868675654678, 0.5595083430017177, 0.4231838928875034, 0.8735614983524806, 0.6778568909760269, 0.7750532590283093, 0.7244902556612249, 0.8147180061713563, 0.6652768884217501, 1.0108164541490336, 1.0688095364364496, 0.6785033092658219, 0.9838187785701813, 1.010229685110887, 0.9510540681395595, 0.616218353916668, 0.8642302932864998, 0.11767260570431391, 1.0716980870197377, 0.8768224139047929, 0.6966019515474088, 0.8055346372131769, 0.04964643597543785, 0.7691442399062622, 0.7963129880013201, 1.0125584738794664, 0.5848466641979293, 0.7853987744921134, 0.9491830121406954, 1.0626703721423054},
    {0.6813528211761487, 1.0110051217158162, 0.6068411328957235, 0.5437842853413731, 0.5724212779832564, 0.9629918627423575, 0.5518670905875686, 0.6956950237803919, 0.8107159894177883, 1.071166205872021, 0.45236710012218456, 0.6695234532515764, 0.9689491177303657, 0.579636345167565, 1.047764188317408, 1.0136791552517925, 0.938469948890516, 0.7047763656109812, 0.8026082521104514, -0.07476875413768198, 0.6224445949171394, 0.5998545916911008, 1.0385493970777397, 1.0561781583356549, 0.20760376652269283, 0.9690911505002886, 0.738438810532936, 0.8842963590148946, 0.6370738720346261, 0.7042193365149736, 0.8242976629080154, 0.9019651880971872},
    {0.8525915342055264, 0.6004150477233852, 0.6239615063924474, 0.5393148446343239, 0.27310783406985295, 0.7224343709774583, 0.7324785434356876, 0.9825625629875762, 0.4830710891113593, 0.808635118179862, 0.6034836314720075, 0.9498723482074932, 0.580344995246669, 0.9015303235885747, 1.0886288354071267, 1.0636427425595212, 0.6225742085235795, 0.8954255237691267, 0.8204046142684934, -0.18494365592250117, 0.8565625522644796, 0.8561663740551653, 0.8387881682289878, 0.9183780788456944, 0.13424910941519494, 1.0696803502989138, 0.5809566255529627, 1.0412557743624122, 0.906585385818308, 0.7178471911656381, 0.8088571498390285, 0.6311243193388957},
    {0.6439749608878127, 0.7328327279097011, 0.9889662961227614, 0.667644410238087, 0.6032955617874458, 0.5714555765312335, 0.9295381444890456, 0.8020125747065229, 0.5758331207360713, 0.7456193955897366, 0.6206464979010007, 0.6415156933651053, 0.8031289873187025, 0.8906752225335639, 0.8486742153057277, 1.0267219348074823, 0.8330737787496431, 0.7793889271086356, 1.0735440822523776, 0.04525360287219767, 0.7335061314299238, 0.7790395989016423, 0.7219543353469565, 0.6472586351978712, -0.05144368861856498, 1.0600222906175532, 0.7561839299068263, 1.0789205318370128, 0.9363502842451826, 0.8522780653997082, 0.9185815102336428, 0.7609966452766481},
    {0.8509950188169342, 0.8547262321190465, 0.8940954262721257, 0.6568662361125145, 0.28550012364490174, 0.8405699578600521, 0.8152572852070731, 0.8439321173627149, 0.5654474344770615, 0.8281984439080554, 0.5586560350831241, 1.0230773766545354, 0.9335310551812763, 0.7895812478615352, 0.9908699656854467, 0.7926504727118208, 0.7053198175244322, 0.7333705297731303, 0.961304303642536, -0.059965905229715226, 0.6623801408567745, 1.0902450134577581, 0.6134552502538348, 0.6591400142146175, 0.211032452115791, 1.0902557133724018, 0.7469931621060407, 0.8041216150262219, 0.6406574530680818, 0.8267468141986186, 0.7028069309478728, 0.8722115821971577},
    {0.7964822302936752, 0.7772269216068006, 0.8725488226955505, 0.8477747149483268, 0.4200401682205464, 0.6197023197952742, 0.7590636065455822, 1.0080762292013403, 0.5935629968276872, 1.0064396104958524, 0.3464094273265649, 0.8458153507056376, 1.0224240518039502, 0.6458690454104592, 1.089403461745418, 0.6417184200224708, 0.7748096918279697, 0.6702506906440112, 0.8075556028881763, -0.04792144456166074, 0.9063738322708408, 0.9012710605591445, 0.7822602569951664, 0.8204075090336549, 0.016770533850919266, 1.0078242699974032, 1.054497298520333, 1.0273412842201286, 1.0017708134025327, 0.6326805380376275, 0.9254057941855394, 1.0430513711787828},
    {1.0786063268212773, 0.6100836733062842, 0.7179247558011094, 0.6694892727563011, 0.45464895584964066, 0.9560453365687821, 0.8040252662237367, 0.599018349642477, 0.6339092117561357, 1.0706460903986503, 0.6121103001846631, 1.001604943713756, 0.7841607031724034, 0.6368192260945724, 0.9609753840809644, 0.6333014906053063, 0.5819959213313028, 0.6063659256630114, 0.8891516615559382, -0.2478585048906576, 0.7799929639166711, 0.8203455950055393, 0.8064185705361486, 0.6944196684433831, 0.12235464304464175, 0.7953792706335735, 0.6583034906572713, 0.8239379794160265, 0.7845612729520398, 0.8657549098187599, 0.7629884737670414, 1.0473121207618936},
    {0.7535969030690325, 0.86295966660818, 0.757965543398543, 0.49050082712049997, 0.47649893630614976, 0.8689538091216615, 0.9400485504433028, 1.0371132559943168, 0.4459033357784853, 0.7383856458064173, 0.47768775708178646, 0.6915367728099775, 0.7116899924360024, 0.979026368129619, 1.0412201955355969, 0.8835959493346941, 0.8573403121588439, 0.6582972515724896, 0.9863169600478073, 0.06815604805017962, 0.964816924833171, 0.6155682321110783, 0.7077149582671032, 0.8832015018192995, 0.12170337597841327, 0.9795832721167923, 0.8220431452724647, 0.892792123953334, 0.8653493497732945, 0.9194717890315005, 0.8681055895861466, 0.8728428675611327},
    {1.094540595396633, 0.616842492456021, 1.016913406697125, 0.8075853244075827, 0.5730556297480648, 0.7861398923161018, 0.4723768251969179, 0.7640299024280139, 0.34845691399356243, 0.7255972637125082, 0.5636766879123615, 0.7704096765826471, 0.8967419204043482, 0.575389358685906, 1.0489151083833583, 0.7954455132462518, 0.689517560063709, 0.7593430303800024, 0.9901299839957922, -0.0747596257376758, 0.6782234792697647, 0.7786400208288026, 0.8639597472607397, 0.7227489448627198, 0.2553995376583939, 0.8128360461833098, 0.7371731932313687, 0.9216156658839145, 0.7540571845008995, 0.707792756936737, 0.7845767544392439, 0.7013926988580961},
    {0.7851947216702243, 0.7699208557385109, 1.0154868230915188, 0.6284379295723431, 0.44104945356647324, 0.9452306803754538, 0.5174921062913428, 0.8447208845865456, 0.7503740098116567, 0.9655986141291315, 0.4562964357670838, 0.6910322508783862, 0.9884906883895952, 0.8200388336930029, 0.6528931819008935, 1.0038586872127846, 0.7361554735798339, 1.0212749857701682, 0.6504899146477456, -0.2713578043278347, 0.7193850911349204, 1.0640370224345934, 0.8354296503476821, 0.6507101754827429, -0.07166491370878328, 0.8863052989348257, 0.9813990701285636, 1.0812206393219004, 0.6916951476750719, 1.0306053019553854, 0.6660492358320883, 0.8029875014301566},
    {1.1083742982924378, 0.5675833629500316, 0.9599753048171047, 0.9562619005140071, 0.602779578432987, 0.6233760513137429, 0.6860835332603148, 1.060766604240826, 0.5534241692268496, 0.9065128401595203, 0.3373936457906426, 0.8010944870983193, 0.9958454987285335, 0.9364947239582269, 1.0524243606518735, 0.9130664650796426, 0.6097341349863818, 1.021987584991328, 0.8029414020411098, -0.04998115160775353, 0.8532209310607959, 0.8567723379931239, 0.8467451743002096, 0.9012003172311578, 0.2070653059209269, 0.7923063857981928, 0.7856264134862329, 0.6388551738450385, 0.8120189218843047, 0.9329772722205288, 0.7332813791691403, 1.0339172883444487},
    {0.7421828421724098, 0.8171775213350548, 1.0210581344616094, 0.6523360721984185, 0.26218543223941443, 0.8297653914930089, 0.498414481168282, 0.991822695264137, 0.5765901952259557, 0.7015417147002463, 0.5156966351256493, 0.7626928162546267, 0.9992786269104232, 0.6714318624272766, 1.0204324562986846, 0.7931506604569007, 1.0061589163986695, 0.7010803136958942, 0.637242866190996, 0.1711821220972034, 0.6704208884990045, 0.900045907536537, 0.6008491412653723, 0.6360248004940813, 0.1964766506729506, 0.9981018276528496, 0.5721205295813557, 0.586635471608753, 0.9512536928239828, 0.7041980547049067, 0.6979563707162889, 0.8806072929466582},
    {0.8338937201511226, 0.7465087995368765, 0.5947994176284657, 0.9190318979104124, 0.758596309423217, 0.9040545972266334, 0.7506203657800191, 0.9031053960993737, 0.5181436029590962, 0.9407792594001898, 0.6465622989980483, 0.6119067483139701, 0.7989707928439174, 0.5927660112987432, 0.9618697578495474, 0.8192777466680693, 0.936105557671299, 0.6916670668099009, 1.0281303337884011, 0.14419167344526299, 0.9903359803540387, 0.821215151501263, 0.933473040975084, 0.9501834395199462, -0.09442730017566472, 0.6637595209924663, 0.8246029419993568, 0.8676691721453896, 0.9172064122228183, 0.8882166695990424, 0.798352034105621, 0.7430068540117357},
    {1.0431316338779324, 0.8519129548623641, 0.7502292959250402, 0.8470110613023157, 0.7083099421254889, 0.7026803409987701, 0.7550296656825521, 0.7930838730235745, 0.4410953198903558, 0.8410319695052871, 0.7519610861044682, 0.8932029079064265, 0.9162161036736032, 0.8550060771851795, 0.7758511248740566, 1.0408194358157483, 0.7931486786587293, 0.9361914187901181, 1.0343384226891295, 0.1222898409721922, 0.9563668068976793, 0.9752388746780404, 0.5635894006144516, 0.7006426591407041, 0.11823531354867262, 0.8428207482041705, 0.9271319861552375, 0.7712598018620598, 0.7294488682609541, 0.5603114449074732, 0.6108261451940772, 0.629255083183429},
    {0.8872577666090946, 0.974316996602968, 0.6721812334078285, 0.5141887534961811, 0.6252649815900162, 0.8074677218287644, 0.5338155652448974, 0.6454894857738139, 0.6195882672705043, 1.046155887998104, 0.5553625899141791, 0.6911275810682335, 1.02978871118525, 0.614768520204796, 1.1072456307350107, 1.0050492103387478, 0.805361764311473, 0.6833038639665021, 1.0844658013808168, -0.05064647065550168, 0.9143245022701987, 0.736525233232824, 0.7386647771475229, 0.9069530061594134, 0.02251764210435369, 0.8727244453743721, 0.6390551360050065, 0.9351883075656552, 1.0599446309087588, 0.7597070956786336, 1.044729050227168, 0.8161506116005461},
    {0.8072067784794477, 1.0414375150216317, 0.7021388867549977, 0.7550604047649051, 0.26422315428474064, 0.9364985555748515, 0.8220354687903647, 0.7859783960287973, 0.3856438152853262, 1.035628569336884, 0.33134809318401687, 0.9594026606544382, 0.6411617271521208, 0.9925055418240403, 1.0338051060851194, 0.7351333923904273, 0.7745275256074123, 0.5526545902641296, 0.8833142098075538, 0.0978384992379234, 0.6631976310594065, 1.0710206255702424, 0.682169025106782, 0.8619550352518411, 0.3501624051376022, 0.7065461702064937, 0.6084939137696869, 1.043823347038288, 0.748473132812652, 0.674034474930776, 0.6257040600070931, 0.7229475232995682},
    {1.0771466757395087, 0.8534419628794289, 1.0697300359950732, 0.8124877915298506, 0.6737129958906984, 0.7709171636754181, 0.5489855656647187, 0.9668606671557726, 0.7597232498610802, 0.7510624961454355, 0.5119820309314271, 0.6927234678866717, 0.747051985843454, 0.6380493189509188, 1.0528906079340825, 1.103079351505084, 0.8943084113349444, 0.6375526639575855, 1.0296460452230747, 0.02687811062713126, 1.1351457718593743, 0.793476657667499, 0.7433707699765069, 0.9358727784318317, 0.025778022480088973, 0.8275733665667161, 1.0660602205130678, 0.8360687816219974, 0.7315099353072687, 0.6827862660866475, 1.0693600528542544, 0.6159107808012079},
    {0.7770291322815684, 1.0534256979029968, 0.8889236378968833, 0.7401387199010762, 0.34861176256156384, 0.8294255171191545, 0.6300476905740908, 0.6102122614302231, 0.6208292750739467, 0.8330819358185015, 0.39007872126638166, 0.6106531706051084, 0.8250829438768614, 0.6320161371260371, 0.9823829497028842, 0.831588661960558, 0.962514001428883, 0.7594943983022273, 0.7246538592178763, -0.042903950045061263, 0.6565535834167191, 0.6145551738880773, 0.7706660830870626, 1.0260208170872087, 0.21810402205257465, 0.8737809173039613, 0.709278593508056, 0.7548041814845793, 0.8099210325819289, 0.9100367923435184, 0.7621611255591542, 0.8541817347998358},
    {1.0944779699955822, 0.767570178808286, 0.6922650031290616, 0.5428282925044885, 0.2484707274421617, 0.55965597108646, 0.6376818485329888, 0.6835984737262646, 0.3760824940640359, 0.8569586643467854, 0.4497217096947166, 0.8549928264953922, 0.7890223145018669, 0.5800433468547581, 0.7325913563943663, 0.932154108427958, 0.8663592060032583, 0.7039394251923534, 0.9497243214102283, -0.2582004614448763, 0.618792017744825, 1.003157724285807, 0.6364892072612851, 0.8356985233273065, 0.06604266429497904, 0.8199079401334527, 0.9844134148802608, 0.9515507375665763, 1.0300126376342444, 0.9412690676193359, 0.8928966737520534, 1.07445826311422},
    {1.0310969140661639, 0.8967006212125674, 0.7023051207542812, 0.5227590396110544, 0.4756374399411001, 0.7719691338465344, 0.759914604140009, 0.9347025639649605, 0.6910647126557447, 0.9798032744006944, 0.46037244960580037, 0.7775876133927562, 0.6670668891590343, 1.0194601411461677, 0.7534095428680119, 0.9810471902007324, 0.6189743693721168, 0.7329087249317641, 0.8691655994750238, -0.217750627481694, 0.9843422186387798, 0.7338478264258398, 1.0310495324536422, 1.0381559085223688, 0.08450136841802273, 0.7913854500158319, 0.673198917474477, 0.9141312761295314, 1.0094097007302771, 0.7177112936984924, 0.6581843845080998, 0.7378249189655867},
    {0.7813664540313433, 0.9232125412660251, 0.6110917483527838, 0.6317396902955303, 0.7130287550187215, 0.7909295297363556, 0.6915450462380253, 0.8158460476773759, 0.7609619450733134, 0.9430500033320931, 0.36969872780482893, 0.9222567703675856, 0.9391617702104779, 0.6895780769441802, 0.7307563259264609, 1.115119705582897, 0.6837053028231513, 0.9129473128564032, 0.8714175027117922, 0.05216292651352978, 0.8051166507926191, 0.8882344044591568, 0.9729790791716786, 1.0204543880228085, -0.017669397274274964, 0.9617581992562542, 0.578940357302569, 0.7726356032767433, 0.750335597644365, 0.70761259318625, 0.6228544620476139, 1.0687970026598672},
    {1.0717513033010246, 0.985913145031332, 0.9374057795193633, 0.8164233068973349, 0.4038633308998519, 0.7918409373581606, 0.6541944779576814, 0.9021901212192799, 0.7677006293988202, 0.8616339725929408, 0.5657835457057127, 1.06137822708269, 1.0778374404163344, 0.9223330443457275, 0.7856792895483189, 0.857440317681067, 0.9165068269937264, 0.920386952493105, 0.8207270442559167, 0.02711876951404539, 1.0866772908139124, 0.9746348782831213, 1.0552808606289727, 1.0029126019639638, 0.4307093746971411, 0.7900950226911825, 0.9218397444700301, 0.9277845920134294, 0.6478809369298238, 0.7612562599695311, 1.0007187003709015, 1.0344476966183154},
    {0.7130835264148142, 0.7212986764928047, 0.7684926367514462, 0.5345523550700113, 0.6477399531038839, 0.9916521686143529, 0.8907435308963305, 0.7324730264399151, 0.37147636700514874, 0.6093765781198699, 0.5292641055172702, 0.9757233384362434, 1.0137727016098625, 0.7188835449950812, 0.8738892703272868, 0.8224423894066817, 0.7741491860221912, 0.5930272495508574, 0.8839888591013966, 0.048248876569395756, 0.9543926618916716, 0.6349396781187651, 0.9897319284116016, 0.9208255309423439, 0.2808177690490411, 1.0183707960707247, 0.8299608903625934, 0.6241661400395557, 0.5661210293156611, 0.8493441358342407, 0.8487272293869711, 0.6134857610543611},
    {0.6865692121103745, 0.8926795963585205, 0.5999502918949065, 0.9507746450181916, 0.6104084809585938, 0.962532682138743, 0.613356644651585, 1.0362708043902191, 0.4306728400593563, 0.9876031854235082, 0.7250315881495933, 0.8301345976698189, 0.8901862481834092, 0.7099347764849223, 1.0423293792411534, 1.014462175894094, 1.0206272186418557, 0.9172852026248405, 0.8021615594960726, 0.11196494248761588, 0.6535801139636005, 1.0542553170947082, 0.8759946924228669, 0.9223211003510933, 0.22402151381569976, 1.0388592907465577, 0.7440069522686531, 0.8666781165287321, 0.8351416397611731, 0.9498170617628434, 1.0581773426100674, 0.9844465283246212},
    {0.9030599118189155, 0.8049317318325209, 0.9926068157276873, 0.7696729926685795, 0.5592680114304805, 0.5325181601131024, 0.7702299835485816, 1.017738394444169, 0.6489727115038241, 0.6781177533474425, 0.46743181745719936, 0.7522063756933207, 0.8720821433990567, 0.612865215807476, 0.7526421262052208, 0.9503358347959024, 0.9871598811500163, 1.03259930374728, 0.7940174879096871, -0.2955305617491085, 0.6380600378267905, 0.7800930640358963, 0.6126268674769075, 0.8905747607781573, 0.0748707546798535, 0.6432570321147811, 0.8272051871182283, 0.8567791597516308, 1.0063937995534282, 0.949939410599595, 1.0155536472117137, 0.6770634440904972},
    {1.0540576688757235, 0.607833229064375, 0.7711564445832366, 0.7286106872153664, 0.587103089033498, 0.9917449771135003, 0.8113251446775301, 0.8795445457288487, 0.486493561234214, 0.9637975857124587, 0.331633590067561, 0.8234981502523413, 0.8178004809272721, 0.6499796662758752, 0.8088906193173899, 1.0505279400285223, 0.9384945446747419, 1.0157041985792548, 1.0136824834066438, -0.014805542526992614, 0.9357741746724754, 0.720174471000626, 1.0321691434870233, 0.9448626725138021, 0.2890150040662487, 0.7793945432960064, 0.7050270261082013, 0.662698368854684, 0.7473599856241911, 0.8308736174500174, 0.8506580482452385, 0.6015004018640273},
    {1.0821486411365344, 0.7173490742761315, 0.9021576370520421, 0.7441613942685396, 0.44116895628680153, 0.6427850564373334, 0.6145302261136293, 0.8120439904080677, 0.5107948788322879, 0.9254537801886774, 0.7310930891021351, 0.5649088482333147, 0.6252546327080787, 0.9756698256329315, 0.6801499521453304, 0.8741843076944237, 0.7499202452201718, 0.8730837035969344, 0.9703289837566439, -0.19620256280169937, 0.9181998948323343, 1.0045297982084418, 0.9586787691742414, 0.9393668482849652, 0.2978863214516638, 0.6286935020145523, 0.9777521346974081, 0.7301094439612895, 0.9721588822642219, 1.0244120541980062, 0.6124195089388204, 0.8962815816592116},
    {0.6849538943002365, 0.8062699019003231, 0.8807770055651889, 0.6651250215163157, 0.42402367698374693, 0.8919699098604055, 0.6750523052388943, 0.9924571813552545, 0.7232275602870911, 0.8144702179509898, 0.39253412173392493, 0.7608069621364967, 0.9076929217067573, 0.5511790129775296, 0.6802853775721768, 0.8787392791538944, 0.7746946135934565, 1.016244233325304, 0.7065901167684366, -0.13952983507550612, 0.6518424133881864, 0.6658320768574465, 0.7898499615432806, 0.8468004040004687, 0.07562963180226373, 1.1225306712485803, 0.9409063939167651, 1.0251593602903377, 0.7658046095372585, 0.8516493497319523, 0.6433784372083587, 0.8246058862018135},
    {0.7124809942039417, 0.8082492911198896, 1.0319822216964178, 0.9156163626002954, 0.3365203842132733, 0.5707794752305584, 0.7424859254887787, 0.6215449241490908, 0.558004740710421, 0.9099721219495309, 0.5110542315422006, 0.9488944283425507, 0.8330096395626012, 0.7430712608337483, 1.010170122812978, 1.0931135043781686, 0.8566945629997439, 1.006022512140241, 0.7718404397647302, -0.09941921614630406, 0.762401860254381, 0.6349730465268272, 0.9131295000537991, 1.0070157284570769, 0.04242754743010378, 0.7076558485714165, 0.59355461128824, 0.6717715412269398, 0.6549522213411354, 0.990391242680908, 1.0755270281085971, 0.6346347718706853},
    {0.9558142630276536, 0.9459298986453312, 0.6856412276787844, 0.8095824334145237, 0.6083319151245605, 1.0529477274531833, 0.7029040379347921, 0.7974649536281783, 0.7456046787469338, 0.6951401192435043, 0.47090438290008424, 0.6651394119971739, 0.7904892903664381, 0.6104787080969704, 0.9284806104888402, 0.7664490570855883, 0.9025179107159951, 0.6255986539725676, 1.000741540797544, 0.1243760952743186, 0.9386542930807693, 0.9166266251195747, 0.6987617442959074, 1.018819508594985, 0.18312452921558747, 0.897978806480327, 0.7910156412618058, 1.0628591720018672, 0.6092018932884155, 0.8804583267040975, 0.8413904148824788, 0.8418542288671165},
    {0.7780859255328259, 0.797022876298288, 0.5727792441357017, 0.7794415640279292, 0.23079241544223833, 0.6361519009962247, 0.8533709493301268, 0.9589436783621664, 0.8103188210816147, 0.64394323682858, 0.6391118823162989, 0.6369269838952568, 0.9883139222954211, 0.767123051414015, 0.8740635240990191, 0.8980207169093828, 0.8909218187025676, 0.743344622498221, 0.9110499832107496, -0.010237792112577962, 0.7967846258598683, 0.7171017214348061, 0.7367000519012995, 0.8635256013119691, 0.1260176742909694, 0.795018713732373, 0.7795775572283945, 0.7668928518995584, 0.6779103750600552, 0.8005690916113768, 0.6619319304666502, 0.8144834094283852},
    {0.827829852819301, 0.9441944234709602, 0.7368537985648739, 0.7382634049747135, 0.7185266511928535, 1.0016905905287101, 0.6717390293843564, 0.6735372864025438, 0.36465468819713653, 0.9940392061366767, 0.408597855082287, 1.0302319008486591, 0.6395028767123611, 0.8706046314315445, 0.7346120749314035, 1.0118986928469988, 1.0048498415354654, 0.7341023105268808, 0.6563780839857437, 0.14122259855504268, 0.9077191150181393, 0.925654689106414, 0.9404133136546329, 0.9979755962861978, 0.04572676981381242, 0.7726878628728963, 0.7266668563765906, 0.6352958808488253, 0.6010826593669862, 1.0330263069714878, 1.0766734611367597, 0.9129934714453345},
    {0.8544822659745462, 0.9852682266829833, 1.0791269574718783, 0.9785004813423819, 0.5256239973522405, 1.026290767430974, 0.9368314330338814, 0.7767128875764064, 0.9226056426193068, 1.002187609019126, 0.3456764777458479, 0.708370902934692, 0.8079278838432992, 0.7558339790809478, 0.7340208609832108, 0.7583187683180879, 0.8103228316264749, 0.7048976531456785, 0.8315551376845398, -0.11514516841700052, 1.0384520849117145, 1.0295449834193855, 0.8399920155165921, 0.9787593030053908, 0.22632724883284336, 0.9602041179258889, 0.7459769617319943, 1.0372157482454811, 0.8719101158652622, 0.7366755107249658, 0.8424005526523892, 0.7206677449818935},
    {1.0527184955695725, 1.0199513346385232, 0.9099147665139865, 0.915372210209749, 0.691401724649993, 1.023793275018095, 0.7885356274918596, 0.6478537597580577, 0.5542116753175335, 0.933010850345583, 0.5290274601906512, 0.87034271643178, 0.9055233084914861, 0.775951307498395, 1.0600300729778764, 0.7544381276907722, 0.8793479224421398, 0.7392371638677359, 0.7589054201205848, 0.0358960032410672, 0.830795593617878, 0.9078304241519892, 0.9851424972189298, 0.8902512338690409, 0.15434070724158042, 0.8800595166996006, 0.6566168521368926, 0.7644321150835308, 0.6550773789236545, 0.9812264684896523, 0.6121779016947627, 0.6417925474885788},
    {1.0276921429164094, 0.5981697002185108, 0.9345695462323009, 0.6202508615476146, 0.38489156738308344, 0.9452770702318244, 0.6302733810303686, 0.9755395260279662, 0.6673235684624288, 0.9082133894477716, 0.2805363084436881, 0.5322361597564841, 0.5826490385654662, 0.859576817794624, 0.743742588557154, 0.9842052634008855, 0.5340698555450933, 0.7855559198462982, 0.9239291387222429, 0.09212106708751466, 0.8760706885928364, 0.5826682630904019, 0.7731070539039286, 0.8184467902862881, 0.2157098249273635, 0.7535595065915418, 0.7429761471062434, 0.7827499233818141, 0.5894981588576842, 1.0329091088065756, 0.7862130551668914, 1.0075549250694913},
    {0.9387115441393963, 0.7697657098160152, 0.994322152964874, 0.49470935730692195, 0.4291116161722717, 1.0112643683236475, 0.7109393671780009, 1.0444354531526443, 0.3974557924112461, 0.8726520356170065, 0.32782921094823014, 0.9992830655452402, 0.8540517205538057, 0.5398659243773197, 1.0407762002332788, 0.8118237521969581, 0.8574178221143687, 0.9392129307775108, 0.8765625704362401, -0.10644650148140068, 0.6383983897144324, 1.0424502239504285, 0.778556408469018, 1.0838788493379248, 0.018237700625380066, 0.6847386461112396, 0.9044340786004478, 0.895366846077978, 0.9180381335582316, 0.8253563504966123, 0.9957946914413066, 1.0363767498671383},
    {1.0799855630549786, 1.0665530714603109, 0.9381239438835586, 0.9140865215321962, 0.7067143896071014, 0.7517756279122172, 0.5049613495832146, 0.6628503612410697, 0.839854946027298, 0.8874501369775641, 0.5626610796428679, 0.8632030511164753, 1.0604470598086844, 1.0367373894533891, 0.7229159507166586, 0.791630146624734, 0.9549457323154741, 0.8119507954761874, 1.0912755753576533, -0.23283503144871973, 0.6324255160612511, 0.7419469616543252, 1.0602330755564486, 0.9825961021377211, -0.08002842963660955, 0.963659464999432, 0.7229651538195628, 0.6277560859922444, 0.704867796696774, 0.8487003380196899, 0.9075069285762913, 0.6806540968729309}
};

static const float b2[32] = {0.8245953567986815, 0.7833232004606425, 0.7861744684265315, 0.6991493598105366, 0.5179418217365515, 0.7430088469415369, 0.6623552943026086, 0.8071379702267637, 0.6205739632094623, 0.7983613185711007, 0.5138442608748773, 0.7965207762911845, 0.7615838624778163, 0.750093367215878, 0.8277887819035531, 0.7946824276734609, 0.8240875240693282, 0.7845731501149861, 0.7811535777827696, -0.11187522244284613, 0.8340427026389866, 0.820660863390694, 0.780460896347595, 0.80070514160115, 0.1870780403860539, 0.8266006885907197, 0.7895147538460562, 0.7822186757370889, 0.7948951868247398, 0.7659164694347618, 0.794646608908493, 0.8505871272066073};

static const float w3[32][16] = {
    {0.14139996025729554, 0.15541906031360658, 1.157413906567532, 1.2516344409792957, 0.9730547064442165, 0.9743916910127138, -0.28530291816207204, 0.8192412435977129, 0.8794251903458268, -0.028869317620444618, -0.26289127768316056, 0.6208467459145403, 0.0517131591408903, -0.352216209406165, -0.09455063447583487, -0.0319799266882838},
    {-0.2647618027748963, -0.3542664346817299, 0.951860054588888, 0.910867883250471, 1.244616838581166, 0.6632153164207775, 0.13566886710412926, 1.1059819415461019, 0.8820256467025154, -0.2092269538940485, 0.24453232126278074, 0.802384102676783, -0.008592624858234697, 0.08016827724957089, -0.09943885435835145, 0.25494921887980476},
    {0.29573725267592577, 0.33430029567444924, 0.526517160239252, 1.1754225949282675, 1.209201599863943, 0.990618897966059, 0.1604691182448503, 0.9956340309233989, 0.9206878719507607, 0.09074100856259534, 0.23984119599613687, 0.9143732159115199, 0.055609011726219446, -0.16346947167861905, -0.025716886903548255, 0.25909526836286617},
    {0.323310850873256, -0.06999032653186009, 1.036323303657151, 0.7941900644374053, 0.8513554057339289, 0.9072605763906733, -0.37155048783007216, 0.7502230855275301, 0.7465800951359338, -0.2871362690928952, -0.05577711743328187, 0.8741541569200592, -0.3372080991596831, 0.10169210821276647, 0.15973141116939224, 0.056777375247174584},
    {-0.023392313175803765, -0.17474362993838283, 0.7145938121761849, 0.4908499653303337, 0.448287524487654, 0.5847420630300959, -0.02665963245232271, 0.4685967852152006, 0.7661444902683495, -0.12706096145418652, 0.09910375085299956, 0.8531275014884497, -0.12246837685582401, 0.01564278211082482, 0.036924167150601546, -0.30107564482526056},
    {0.10252961648719891, 0.14045068497937344, 1.0431979239353553, 0.8008581290759726, 1.0514039825648052, 0.9859705536984954, 0.05471094200927299, 1.0651485597575636, 0.6182978685879018, 0.2652340062477761, 0.2280763555450568, 1.2410617122928655, -0.005552154117469568, 0.20978920900563114, -0.18346029917549841, -0.34192121733953745},
    {-0.3450733069140019, -0.34238592738443085, 0.8746693838441779, 0.9001133371294521, 0.911695675920303, 0.7654973627643226, 0.2501775260857491, 0.6434874713800262, 0.7888117990436108, -0.08697940450567691, 0.31551826712364694, 0.8911132990773085, 0.23968722773264012, -0.1329163360001873, 0.09072516027873065, -0.10283620694759547},
    {-0.04690609422713722, -0.0267052905760473, 0.635821732826923, 1.0903697556731502, 0.6379569781621522, 0.7114990409380816, -0.23203404766828475, 1.2899410318095055, 1.109220954983672, 0.2803726640270363, 0.14444804029323266, 1.1381426084790696, 0.08901700366132015, -0.07066179993370886, -0.05913027937691882, -0.16636728877141999},
    {0.08086233404361728, 0.29816095901475637, 0.9270477959954976, 0.8880774932812315, 0.4167069346093572, 0.5742977930026351, -0.25324522308043373, 0.857045731370568, 0.5650283830604556, -0.23420914740681203, -0.12580084119414883, 0.8094193732986208, -0.276797436929175, 0.09378875109788012, 0.1289210154742802, -0.06241635918370289},
    {0.04062274920341292, -8.035796716640444e-05, 0.8416252070711961, 0.7574954171709218, 0.9696332460509576, 1.123600290930098, 0.16073857854964224, 1.1146939432606295, 1.2663226552137827, -0.3237424741015983, -0.09906432084971266, 0.8216173385271823, 0.13682033246735872, 0.08774664719017113, -0.27966107593476924, 0.12412263820145643},
    {0.10630565278352375, 0.31414399385437436, 0.737892473105041, 0.8858042224171202, 0.4623030563832395, 0.6279959362599877, 0.28469897628283475, 0.40057981232218526, 0.48365423958813186, -0.2649228692337351, 0.018462812910181228, 0.8086539354615612, 0.26343071392248707, -0.19520188270131777, -0.31427801933979593, 0.006274640157348859},
    {-0.27071885154028885, -0.06562300819024075, 0.5629462340486237, 0.5922468483899026, 0.727942137272213, 0.6832813682178521, 0.08865190929476519, 1.2653342225284998, 1.2968940178756763, -0.3938335959504342, -0.013712909088394317, 1.0753193635958898, -0.2402375484737175, -0.12810137692320003, 0.0748042528939701, -0.34329426346323405},
    {-0.06672791027190515, -0.3326441876597607, 1.0231498956812468, 0.8593438704540652, 1.187064340851849, 0.748068808667698, 0.24737451003318559, 1.0446235192396058, 1.0828933250412576, 0.2664200426901453, -0.07912447503479689, 0.8676409026827994, 0.24468398434637156, 0.01342810478941308, 0.09236288123569258, -0.30706942359756184},
    {0.04587042927970911, 0.08080879081543983, 0.8371791345675679, 1.2089140396727283, 0.9270937377953781, 0.5733489618987917, 0.10686187331854728, 0.8351618190635444, 1.0269458688415496, -0.2607721222413826, 0.25988061427691117, 0.8082566098175905, 0.2743176427597721, -0.33590182342880526, 0.06522337458986215, -0.22571589688291396},
    {0.1103798745508887, -0.042405757798918364, 1.1457767055945385, 1.1222686662817036, 0.9895179067641099, 0.8496311475087418, -0.27363060025282576, 0.648755427048302, 0.6215387900707973, 0.21277419231904104, 0.07233355565521318, 1.1160199721781403, -0.22726337874973665, 0.00495271746806123, -0.05058787826363469, 0.22027752778727328},
    {-0.1475398867088431, -0.3401040670742579, 0.5239138470632803, 0.8775616132716861, 1.2431788617521802, 0.6659761731692276, -0.09949929468162722, 0.6648491328464572, 1.2176748394912527, -0.22486823231767994, -0.15461414317256986, 0.8630484118106397, -0.21905236490845162, 0.20658652029542832, 0.025848373179377486, -0.2733335821046342},
    {0.2320037742091057, -0.024794718782609082, 0.5493287408752784, 0.5972721240312876, 0.926407630326355, 0.9445551543741679, 0.12833060987486394, 1.2950856469767855, 1.0311722077713723, -0.14940680785801264, -0.06391690507838962, 1.0981892630570054, -0.36453616238076414, -0.20112628743663621, 0.1411293716932255, -0.19530150794838189},
    {-0.271689721033316, -0.08126723475743931, 1.0620232669202059, 1.1990657677368686, 0.6784841562354568, 1.0146575930417459, 0.2711472205926809, 0.6576435189986817, 0.9846133822164915, 0.09181991307131794, -0.011548360662287394, 1.026859378977742, 0.013103254201184945, -0.35554300386301163, 0.024375885955825353, -0.04361747312345671},
    {-0.07469914099409658, 0.0779716076242834, 0.9925867082831219, 1.2165359363187525, 0.8906271033145813, 0.9387205082309359, 0.08454729104872274, 0.8900204926074077, 1.0661254488885625, -0.37211451577587484, 0.04704935682948454, 0.7072142621093529, -0.3041679880662277, 0.11045661199398815, -0.06549511528071407, -0.1584808009188099},
    {0.029372184197974792, -0.08667706427167478, 0.1409413594341875, -0.07870919302890889, -0.07315703745439746, -0.2732775540609472, 0.001097853363940661, 0.32233024428159146, -0.17754943849623664, -0.2572002585123205, 0.14736920779440005, 0.02671434636089569, 0.08819041402496806, -0.29911393341211845, -0.10455023340544467, -0.03820847499937183},
    {-0.12513220132174072, 0.24619095724710863, 0.9254691443506948, 1.1072688616333752, 0.7653540057141621, 1.0300354920213228, -0.4269367244479479, 1.1649463391553694, 1.1861035592076055, 0.22900607741152054, -0.064473799401338, 1.074555000767525, -0.08962653898398194, -0.38190390153052123, 0.011025091932084456, 0.12029112499643783},
    {-0.07502349230276134, -0.05425359334143597, 1.0959238867376637, 1.1910849833554285, 0.9959175391270121, 1.0489137766500234, -0.05559333204596783, 1.0598719094541051, 0.6803606567102035, 0.28831970154494757, 0.27075096843944274, 1.0015921835313393, -0.05613915568699323, -0.3004718488439594, -0.24792118509365058, -0.0538444804297165},
    {0.24347114051730195, 0.17448101438055363, 1.0857252652379783, 1.026628002571212, 0.7114672787166645, 0.9370671920017652, -0.07947548997471277, 1.1008749709845926, 1.1398497351367027, 0.22500913801966196, -0.3925545300934977, 0.801795082746149, 0.07247253885825441, 0.007836205314721609, 0.20329199100482032, 0.2639609424529142},
    {-0.06634338342656401, -0.2795284264595751, 0.9751982669694487, 0.9832267926213524, 1.138021058022414, 1.047919045099875, 0.21152760347234598, 0.7280131719146898, 1.1976028652777213, -0.007670365040323416, -0.2755060416660936, 1.1424453969127835, -0.10103518064478613, -0.3258488486848665, 0.2333675862617896, 0.09639973664147058},
    {0.14834187207550786, -0.2458468568096492, 0.32180091399669586, 0.07011738821357222, 0.20576414267206738, 0.5264875135873048, 0.17354537603654682, 0.5011693672457584, 0.10278798320346236, -0.06739828395682924, -0.004849989836966599, 0.2953442992424231, -0.009155060611965677, -0.11567608478142033, 0.28708109584117375, 0.15283564442581948},
    {-0.3460360834375167, -0.02654541957910472, 0.7379753285654373, 0.7674073827272634, 1.2124489583029578, 1.046902662556977, 0.15304298999944138, 1.2463301548438126, 0.9503890552829449, 0.08235614709701926, -0.13235338914974748, 1.05925492641288, -0.09298184917765943, -0.09832890235635283, 0.19851585035985717, -0.3478562088233472},
    {-0.32733242268980206, 0.06477987891419267, 1.1590343208045912, 0.7383041721815633, 1.076209136247334, 0.5701408936649757, -0.0009571563872259902, 0.93350694712967, 0.882351679188124, -0.14172628742079935, 0.20150587851301502, 1.051523691039057, -0.03295113550053516, 0.05682288260788693, -0.2278550788585981, -0.009010939930182366},
    {-0.24669852425485886, -0.25432555124576417, 0.5877039268638309, 0.5777840351110605, 0.8322934173578073, 1.2346248421148744, -0.36738433772462903, 1.2246172558236263, 1.039442504275427, -0.19133398309466845, -0.247610373227338, 0.9833885087036967, 0.2607722040041115, 0.14524299146141098, -0.40740548943295474, -0.3676572658514346},
    {0.29104114404690185, -0.19771339997948942, 0.8141277372369425, 0.6448357962050226, 1.2034017729926418, 1.2319521471898123, 0.2605098159800371, 0.9421553945729748, 1.155661271337653, -0.08937479378097013, 0.2570278046391629, 0.9574755047465574, 0.15869105260203675, 0.153189206750015, -0.18326489626629958, -0.17308307711794998},
    {0.08699925224805038, -0.07098759302348726, 0.7301530609787039, 1.2078220566645812, 0.8854203924804719, 0.5614050724615496, 0.13871635065138505, 0.7480943458835916, 0.7499561472961168, -0.13444926168038773, -0.1824512003481609, 1.0214205065454163, 0.2860881358561798, -0.004771773127652449, -0.18927734415825556, -0.18882310614511938},
    {-0.08168451437905246, -0.0947520509786019, 0.9248656545813123, 1.0360124313859167, 0.9646522552966994, 1.1922046540838582, 0.147883637598883, 0.6260308713315534, 1.0575929855340478, -0.2780352204405903, -0.4317265421121086, 1.1660676190218922, -0.0023944793564641045, 0.24602758197941, 0.13817067005466138, 0.1406917119560948},
    {0.13166762450673683, 0.12311489763704175, 1.1685362293726653, 0.8503431266961887, 1.277696350852201, 0.8476234403912, -0.4079920905047327, 0.9812490556151511, 0.8409437758175077, 0.0533352401098364, 0.10115050152823209, 0.830376863412387, 0.17590797833766597, -0.19195411995304848, -0.10026989484384348, 0.24062275782243928}
};

static const float b3[16] = {-0.022416926242487187, -0.011239394883757366, 0.6186438982520792, 0.6082154830325006, 0.6214158289561242, 0.6608055801014094, -0.0241205978429029, 0.6548216999743188, 0.6504104003912536, -0.032207159341516044, -0.023187964267719702, 0.647124215526896, -0.03329654817214595, -0.025258675785788984, -0.05336235443834842, -0.01660451905701032};

static const float w4[16][12] = {
    {0.30684697791028287, -0.0950143443215592, 0.286524841488431, 0.18323660452643648, 0.2555157681268845, 0.39166327665526646, 0.4190798445807879, 0.15476357436708243, 0.28510186584547137, -0.40964622027196673, -0.2498403117625907, -0.07975244546551206},
    {-0.28326386707836454, 0.20420407227193077, -0.15885852916714313, 0.23170439320357483, 0.10618091540920216, 0.25637853685689405, -0.2080977650483508, 0.06127476856649427, 0.05488956352487495, -0.45388615951586747, 0.013947218842351665, 0.08681646473784767},
    {-0.7722930540608007, -0.990635815252883, -0.7940806950243491, -0.7852535990816732, -1.0013742901560232, -0.38189660512912643, -1.0832281982946759, -0.7407721751497304, -0.6798373254411327, -0.7077461521876687, -0.5949209780620094, -0.6464164107200652},
    {-0.3443371737680026, -0.25126913578713467, -1.2146435828359103, -0.9972331012865078, -0.974617193532368, -0.7275788500872217, -0.7914497947543434, -0.6400923081318501, -1.0610043319563849, -1.2638376545046128, -1.0198101606878376, -0.7102233916904354},
    {-0.8941223924295663, -1.1007810711028438, -0.4572594914223298, -0.5961051856531149, -0.9346348800310431, -0.5082914520220037, -0.4519342662147174, -1.2243999363599152, -1.0252652791829588, -1.2202235429181079, -0.49364243472335084, -1.077894665425749},
    {-0.813622892672865, -0.9110343473502159, -0.8283950775915326, -0.7673752963085378, -0.5908915233770722, -0.6335850107333639, -1.0898276133124138, -0.5927982411328719, -0.8146624128189764, -0.5434879992090818, -1.0725076788362098, -0.823633129931075},
    {0.36138898869350755, 0.4059519653100765, -0.02108883586524374, 0.0002619091579220317, 0.0356723619076459, 0.20113129162305463, 0.39731121993271173, 0.2419698165571171, 0.14448342789304444, 0.2393066579892712, -0.29903338123046297, 0.38144143181688894},
    {-1.0716953951804002, -0.8498081217220382, -1.0093908403460394, -0.8001848467927933, -0.6243590597334534, -0.8897406501034257, -1.0937540274938453, -0.7056866609775577, -0.5008385978508445, -0.5445574806052856, -0.9102205274327108, -0.8275668136656851},
    {-0.8623521626804755, -0.43935087836390097, -0.8681592381655907, -0.9616730361680592, -0.5764005920847974, -1.245469596100389, -0.6523288480273762, -1.3279580721482243, -0.392801975004883, -0.5859483944056038, -0.5969479884837864, -0.8140049773082688},
    {-0.00811676407709545, -0.016021324900595366, -0.02721117752735405, -0.412382412792002, -0.4965699437532354, 0.06882488660973672, -0.1769943810503598, 0.3963878549973754, -0.3847114503886568, 0.10334966789393499, 0.058298701583723765, 0.010144522229160907},
    {0.3395400041974454, 0.40135862049328086, 0.15357730588907964, 0.22567889648755018, 0.36458557478116616, 0.12047638841111984, 0.2706315310774753, 0.16700262117047804, -0.26339816307431624, 0.20230715975778937, -0.2995939750672325, 0.24807155592398308},
    {-0.9277230300755778, -1.1217764474923062, -0.5012494680640768, -0.7437028234117273, -1.0206778007728012, -1.2696074754855577, -0.5492320172803611, -0.440779927533054, -1.1959910797584494, -0.7714080890827267, -1.0119093323519812, -0.7222620719624246},
    {0.3387115966502094, -0.1849125250211526, -0.13720798676752172, -0.4907506861280416, 0.3747717769673551, -0.025197046193044362, 0.021161578938708115, 0.1411575910179788, 0.4140495582909827, 0.008882112528737784, -0.27286563043760903, 0.36987626815823893},
    {0.0964953539773212, 0.0515375116755095, 0.38506807070336024, 0.38956259705310226, -0.18637407873680614, 0.18907161484930007, 0.1363127705631902, 0.3943660533345555, 0.2775123285943128, -0.07823855973545424, -0.4651702744277086, 0.03211756336382695},
    {0.24431612397725425, -0.45895066009403357, 0.40693981728242584, 0.19591070087924606, -0.48472515767579727, 0.23971029510353692, 0.17195350752625324, 0.18705293725963482, 0.38679282036113405, 0.29493804289594855, -0.5085933742822084, 0.2937309616924782},
    {-0.2675994798417374, 0.11050338343236431, 0.027387327204269795, -0.2363816053710943, -0.3794678912306341, -0.21853011795133978, 0.1005047105786111, 0.14707654656468655, 0.09762934353742364, 0.15112635236022473, 0.325381320342983, 0.13901674332228686}
};

static const float b4[12] = {-0.24046328530545244, -0.25331401117346847, -0.19887108890845756, -0.15749340459250963, -0.07240934179466162, -0.33885354623148106, -0.27090513443448, -0.391847739119766, -0.2421327307711488, -0.37919037390391885, -0.2358393580459059, -0.22107020108049819};

    // Input Layer 
    float z1[64];
    for (int i = 0; i < 64; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[32];
    for (int i = 0; i < 32; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 64; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Hidden Layers 
    float z3[16];
    for (int i = 0; i < 16; i++)
    {
        z3[i] = b3[i];
        for (int j = 0; j < 32; j++)
        {
            z3[i] += z2[j] * w3[j][i];
        }
        z3[i] = relu(z3[i]);
    }

    // Output Layer
    float z4[12];
    for (int k = 0; k < 12; k++)
    {
        z4[k] = b4[k];
        for (int j = 0; j < 16; j++)
        {
            z4[k] += z3[j] * w4[j][k];
        }
    }
    softmax(z4, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
