#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][32] = {
    {-4.526508404002993, 1.6678243944726272, -3.937884010923678, 2.1679649510385133, -2.927174888933078, -4.708288563865431, 1.3529335197552033, -4.28737404984422, 1.2024730603121283, 0.19140612627273118, -1.3381519473512424, -3.58436894393778, 1.5052193041468918, -4.583517884778986, 2.4003088181359313, -0.36027680354861974, -4.416232408584909, 1.7762660778466255, 1.8763916672220142, -2.2014393022288843, -4.769728292486438, -4.425368748606644, 2.3008848397096267, 1.8053393814703949, -3.2672756951334065, -0.7239013646970075, -0.030069859252904813, -4.012061014745353, -1.4852716870196505, -4.452743516200718, -4.982742387106158, -5.882859000571998},
    {3.122871097125744, -0.7753834798319788, 1.7165158214811185, -2.4582918291856775, -0.23356310761606927, 2.853723701400136, -1.0076519727271938, -0.08336035157292285, -0.6922778971311562, 1.3904206518365485, 0.7282505299595812, -0.3250555327241527, -0.7688974268640623, 3.0075960694883492, -3.6227506829124043, 3.448285411849706, 5.475966425070691, -2.7149691421787883, -1.419185182803234, -1.7040577940999408, 2.9384518317616197, 2.982447706481257, -1.499418231049198, -0.5476219269700321, -0.5593186801696568, 4.531495255875937, 0.6536762618442603, 2.2989833149533974, 2.231006149537954, 3.067515642671438, 2.1816134199516495, 4.872029436287604},
    {0.8006198088600393, 2.513185386518067, 1.463983650872037, 2.52697149642737, 2.3311663613230733, 0.4581934538999784, 3.389293702181424, 4.35432877558995, 3.6828950385782697, 1.1283092329433375, 1.6075011073194647, 4.345555649001634, 2.6171306622360255, 1.7452858875893804, 3.5289568962949756, -3.0552567762307614, 2.6430082236903236, 1.9382375869911452, 2.238238428771768, 3.65387711639683, 1.682207993859236, 2.3925960550389433, 3.0308592964552505, 2.4524689192155313, 3.691174080769858, -1.5511784523893308, 4.5139469565212345, 2.1810615593347435, 0.6601768923626953, -0.5118409395947678, 2.057000610207544, -1.5685521163964136},
    {-2.7775833120158224, 3.876118911751153, -2.090411032666047, 4.130164244792287, 4.480064051370831, -3.9163270622135737, 4.415300215693919, 4.724889371549525, 4.830437420770588, 2.09611764162961, 3.303485519692068, 4.66886584301107, 4.367523510723249, -2.5833173519067536, 4.434593776013364, -2.2839787114277827, -0.814881271365465, 3.5455269007280146, 3.038564378113857, 4.73809057458537, -2.1083728272137296, -2.7818280181609367, 4.489844886388715, 3.6444789744424773, 4.804331081121143, -3.2060497658139857, 4.529548962604079, -1.972371774378948, 1.9482883715863257, -3.6164077065809144, -1.8472389796421955, -1.1158954123783968},
    {3.1555962289357162, -0.015421297199664917, 2.9629898630543035, 0.4207344131683341, 0.569887819503711, 2.5217189785174905, 0.1274997128799324, 2.279969187211061, 0.3086937601582493, -2.6496049439493334, -2.116220574029727, 1.6868859395105398, -0.9081387031441799, 3.786051378172451, 0.15014271788277075, -4.561743546443645, 0.16814551317367446, -0.9619053204750077, -0.871361860335556, 0.9467946428930255, 3.4735581682893213, 3.2387551307320805, -0.6492692299761383, -1.3171658258517718, 1.45351658079331, -3.7622316272268685, 0.6550882668711377, 3.138124469331921, -2.208477628548544, 2.191208252970725, 3.4904289778590907, 0.1633792474513863},
    {3.7149854225461403, -0.2908094116384901, 4.569037823895762, 1.0198825926542643, 2.071915956914891, 3.6042679020147035, 0.9592800742416698, 4.523447883523935, 0.9767350308820938, 0.9427737799125101, 1.6378176755645506, 4.849155574977374, 0.6944800448485132, 3.7757736802183506, 2.003673777317819, -3.0356189695655202, -1.4491480206729992, 2.0538122656816995, -0.23583993592273292, 3.384780226123199, 4.4444113652063, 3.5842153442702687, 0.7187365772742093, 1.2232280263609163, 3.3504931919567005, -5.063080290501448, 1.1770807442824442, 4.269540167057955, 0.5119307803348263, 3.758953783886944, 4.780272508410844, -1.7828209941729374},
    {3.1008746532530593, 0.790653164761769, 3.900147976950947, 2.7078496672346963, 3.882708748001532, 2.730450160049806, 3.1646054792968994, 5.734998776963452, 2.9428174162444636, 2.921294320268414, 3.1931596625883505, 5.873330049328183, 2.5911022074560175, 3.2494626646963103, 4.135470660272503, -2.9259706870062243, -0.6260178655670141, 3.6198137590225508, 1.7945568868646469, 5.291496085422611, 3.764210531276016, 3.10901399415313, 2.7558909946610117, 2.613260295641518, 5.261236700282918, -4.603177348075637, 3.1863691591838705, 3.7790363858788765, 1.8749270635826314, 3.0123378152202323, 4.205336276799261, 0.21917862540493754},
    {2.747867809880296, 0.026690851055441802, 2.735780372931232, 0.6466939546780966, 0.6113463633281804, 1.4194256759676338, 2.1025368123365875, 2.481866906011714, 1.6291603516475992, 0.9908784452827472, -0.27886869806710435, 2.3347730592142666, 1.2539483698286549, 2.633972370424631, -0.020848775030541604, -0.11758673658796075, 3.506960553281697, -0.07113173264391649, 1.091375582759174, 0.576970384568274, 2.650304763810708, 2.4059334556477556, 1.145714519607008, 1.127856581403187, 1.740014557348597, -1.358284490141537, 2.289962595422306, 2.5145834946687873, 2.2448274053380444, 2.1362813737592914, 3.0012620798125424, 2.5084003027476003},
    {2.8185461325780192, 0.4551289828134737, 2.458689441961031, 0.26688276188148446, 0.7999570060353312, 1.59906121354015, 1.6144050942982862, 1.7599388973036636, 2.1678463084084894, 1.0400059820879544, -0.06959438634721145, 1.4116414541243572, 1.0066863146277556, 2.908525898265336, -0.6609624433114807, -1.2832143567805756, 3.283874930043686, -0.30137689491174263, -0.08293631361679846, 0.4194487601712887, 3.193719217275011, 2.039057252231052, 1.5395229051522206, 1.7199364408504487, 1.6205258562103975, -3.0266034493931233, 1.8259310341549408, 2.828433887507778, 1.7411790493110788, 2.293436784164849, 3.3579834960846804, 1.2510393725891327},
    {2.268482493498892, -0.786563140481146, 0.45082384251658547, -1.9904014944237836, -2.305294969271188, 1.0230357339055844, -2.4074435453248366, -2.6420389604082093, -2.0045942094813927, 1.592657795070964, 1.207360382195636, -2.453544093241314, -1.4120414557837175, 1.122288026251203, -4.580237866650749, 2.2182628512072324, 2.8855410675183526, -2.362816766426593, -1.8932771791602245, -3.424309421768469, 1.8507428140180857, 0.922331738926156, -1.1342243678334678, -0.6869115737238383, -2.7962809173473113, 3.335902477076697, -2.3783714202417077, 0.6100543053029351, 1.5214486798196512, 2.2204305783481333, 0.99143732732676, 4.397058374091992},
    {1.8755147304677324, 1.347294040904623, 1.5768609558660573, 0.0017776957502712051, 0.7940681008733137, 2.2057867861480718, -0.38850414448807624, 0.16681566953744004, -0.03929624015370255, 2.137752775150623, 2.3378872407812827, 0.24359335777530985, 0.34196962937931474, 0.9562769816589893, -0.7715594904452902, 0.5541252216221079, -0.27241535619392054, 0.12601007494183483, -0.6562884165363013, 0.6702648087636144, 1.734026635027467, 1.4759290281697104, 0.3821030894686007, 0.7767297339082514, 0.5544110246326621, 1.5019760009011394, -1.6754349428455706, 0.6051298077707133, 1.5258354198446147, 2.993141156956216, 2.1111700277110113, 3.01668361608832},
    {-2.419908257282175, 1.104787382367127, -3.057595485938745, 0.23320968235609435, 1.48583100394424, -2.452622150328195, 2.698839070927962, 0.8891022950442209, 2.4858738529470803, 2.818828128417703, 2.951308059297991, 0.5260879630547681, 2.784882072300153, -2.765522122070201, 0.7588019830659386, 0.014353982464039582, 0.84725135608109, 1.2570583168901217, 2.4493485783580247, 0.27208516879630507, -2.144402224119938, -2.5286461173193073, 2.5863060692339848, 2.214732002176421, 0.5303885570190939, 0.927949492909927, 2.0007167230199725, -1.8223169929470808, 1.8124940550215562, -3.044978584491358, -2.8103102282765993, 0.4321371762845761},
    {4.868057881017086, -2.9115498886740028, 4.519542214104476, -3.3203221970775485, -0.7137057286960684, 5.451673718303301, -2.719557301329085, -0.679907606910008, -2.799617348005984, 0.23359333273180766, -0.07154662443286099, 0.37329531697308077, -2.4225451713737054, 4.7233691812309155, -1.5593424878592563, 3.376330556251346, 4.2533929854872685, -1.8108190366103074, -1.5785634215439006, 0.06923078399897833, 4.386408920311028, 4.983295517860048, -2.9439732589664627, -0.9729062188885889, -0.3813903340856708, 3.2241099550553995, -1.6253824453634884, 4.858246867398069, -0.036760828564945905, 5.042780725471559, 4.196167821031438, 2.475201138011347},
    {-2.210088826639059, 3.4566225197347897, -1.9960754574196748, 2.3590057649756417, 4.819016983599122, -1.8471893638891836, 3.429815238246979, 4.215741173432793, 4.253548953085944, 4.480697182498917, 4.5162028702663894, 4.387456292357367, 3.631013740156871, -2.504221322558979, 3.4202018692044724, 2.444599763581686, -2.50628371360683, 4.5911268415156785, 2.6041840492667854, 4.318607173200456, -1.9040066317458193, -2.92668724426527, 3.7876969450796674, 3.9437591773788836, 4.715679063633022, -0.09289826413125718, 2.930912374390257, -2.7160336028255503, 4.319570768793165, -1.652114837846484, -1.6600274957808228, 1.3753721695363335},
    {-2.978349390470908, 0.1602314386268778, -0.47304419756171073, 1.8823060062266095, 4.964740245407624, -2.274343033181322, 2.650990066391998, 4.373838215509693, 2.5359456191386136, 2.7062764173419875, 3.331147366968791, 5.48039169853821, 2.6379963761614684, -2.5223348460863795, 4.379149191711379, 0.6105226783816234, -4.451395945556308, 4.535765520736012, 2.5749399162153206, 5.693964778690817, -2.2392244036886186, -3.2872348037014594, 2.7565870582613314, 3.0176602432444257, 5.256175736685231, -4.248027210088686, 1.744658482445366, -1.585084180907892, 2.8272452076321497, -1.813847794009902, -0.6664289906890173, -3.459959815269456},
    {1.7906465638016054, -1.7777888719660047, 2.675542267527474, -2.7557464241430116, 2.5380333804289665, 2.593971871684199, -0.9541780737255187, 0.8670410448606742, -1.121682973124689, 1.8063064779260998, 1.6324172072842433, 2.9280615112204167, -1.2401895024800569, 1.83027193796197, 0.46005415692284296, 3.369071158492648, -0.19272218184005824, 1.163233646464909, -0.9984418834055986, 2.3547670143831163, 1.9034900341363685, 1.1109748562332364, -1.4511725019454185, 0.47357631465542005, 2.4711239589482266, -0.5561015427728159, -0.9495542490675551, 2.0761281996316363, 1.565417275514529, 3.071237004436243, 2.709695565158994, -1.3449340981004427},
    {-1.4412799143871098, 2.6836268248408475, -0.5039823259308819, 3.3255989539179285, 5.378643125640096, -2.1228385206876434, 4.143497903426273, 5.4255646025760225, 4.100996361342139, 4.815102825612223, 5.128660337367538, 5.665567402697605, 4.208143987142207, -1.9827513067124247, 4.046248283346976, 2.4432307926848624, -2.4416053801542974, 5.26557829102078, 3.240259831906224, 5.920523435455563, -0.8745607254734192, -2.5280626518476783, 3.9543189646056294, 4.374430246703923, 5.4402272098490245, -2.495114784112891, 3.050153133454837, -0.9469759892643025, 4.957912008691958, -0.9991456191997086, -0.41953072930469304, 1.2028002759330523},
    {-0.6336494551291758, 0.7694175779988676, -0.0198077306998011, 0.8299180012575615, 3.7340107258349042, -0.06610748131889217, 1.2087334464390336, 3.3879275222408145, 1.9581748919689508, 2.9866320771597024, 3.7502622821137948, 4.337229437846613, 1.4071284128195098, -0.8833224737043776, 1.9401757631578436, -0.19396365720730535, -3.4592436762773464, 3.514006150484329, 0.8899943408279684, 4.017195348350501, -0.10458401497568649, -1.2056422364132104, 2.3734827511513346, 2.214139654068663, 3.947362608193934, -2.3798083903094436, 0.3021597589664278, 0.35789993931044034, 2.5981737813310275, 0.5585179484434978, 0.6215150855023324, -0.8108467367706237},
    {-1.7742896903656378, 0.2585445599938504, -0.8038200693857463, 1.0605439694508365, 3.2199039974681445, -2.168585728447403, 3.408040638454099, 3.7057140082882816, 2.844577251877962, 2.1895303734859337, 2.0212127977483654, 3.2968212140864877, 2.6544697536544564, -1.2442363390502305, 3.2704357158915087, 0.5212890462341517, -0.31843401534819227, 2.8375692839057938, 2.3944531485778264, 3.714467001973827, -1.3174439230670838, -1.0145006093779327, 2.4756978741036955, 2.6773357551080177, 3.5963339412769724, -0.536737256657376, 2.404819204225862, -0.040710058825660395, 2.57982153379803, -2.4148596169093848, 0.05168144327456011, 0.08403192912723838},
    {-2.2476659520700144, 3.4795719964012477, -2.089304355287141, 3.2418331037454275, 2.6858571813803, -2.5274616973544757, 3.2912510305721163, 3.1225555106839376, 3.0620489833297087, 3.145794174270612, 2.88097148363026, 2.644212908146884, 3.373289201240173, -2.4189207877770964, 3.3426076901408455, 2.43193371762965, -0.14874867474588005, 3.536584789655119, 3.047208859231101, 3.256600387702415, -2.1315972952336852, -2.0155553600713385, 2.8903799382362854, 2.878807078220481, 2.972632455740165, 2.8661736676109517, 2.88130370095878, -2.756913552629616, 3.1647673237772036, -2.4655951947600023, -2.4049684855437046, 3.242890500163458},
    {-3.598616132391552, 2.5272084463667577, -2.4447645816296473, 3.1025459021029644, 3.940080069317592, -3.9996590159953747, 3.19882237785811, 3.8790943378929748, 2.9938578033517906, 1.6168340141710813, 2.26548849465572, 3.8311227698458516, 3.2399313838253114, -3.8039491237217438, 3.5144415922564, 1.0630888571009258, -1.6661930816665307, 3.5127624891401075, 2.630046006531272, 4.3676414219530395, -4.208860230989208, -3.615746113717732, 2.553737499910191, 2.181305909846302, 3.9688597488967705, -0.4247577323547614, 2.397619834455136, -3.56990424690155, 2.7165335354859894, -3.8072849735966456, -3.4553200469822216, -0.17860814886032803},
    {-3.110883579826943, 2.375468404856322, -2.8862042983127214, 2.369928654765634, 3.6172207938591328, -3.356828159077926, 1.9848180232662793, 2.101662859948782, 2.3048609423018225, 2.414127332770151, 2.279345971389654, 2.8049789898748902, 1.8453045599283195, -3.6577679399057335, 2.130899471106204, 2.882367991469688, -2.083825198031679, 2.42449461230585, 1.8497796912873299, 3.4840875371572175, -3.058729321894681, -3.821064076017301, 1.9078944537627085, 2.0776476831227835, 3.099768516521551, 1.5572198790943532, 1.2096138491965331, -4.209143078360052, 2.9287821128223874, -2.229985033892628, -2.9332069822732145, 3.260283169219636},
    {-3.612721677863315, 2.4652648859993262, -3.39399028564984, 2.6577148599755045, 4.115382481965226, -3.813214035411326, 2.8139440196332988, 3.178918340740371, 3.0378578240817147, 2.2806406037101215, 3.10904459809648, 3.5443061047993187, 3.0532799524705423, -4.037574843283976, 3.785932101060484, 2.674419171020403, -0.6648064300162956, 3.513601916263047, 2.7789189577759217, 4.038937647971802, -4.421255180364609, -3.3703351717808627, 1.8415659290471114, 2.642047025742363, 4.247878996032113, 2.1408670436277997, 2.593006988190811, -4.040797194587937, 2.6629703326259544, -4.241078216112645, -3.833686946790345, 1.7191802588776037},
    {-2.285102202187807, 2.0345795119467414, -3.8593614592594947, 2.124997387471287, 1.92344478119166, -3.652389890519014, 1.417704725243673, 0.09003919510584922, 1.7935659785041151, 0.9104763403543575, 1.2730867631183382, -1.2371673616733583, 1.8646932221769192, -3.25567291228833, 0.29708510058944176, 2.6685844162353938, 1.2309325419037414, 1.0378018673213003, 1.7658478982934709, 0.1585907342306808, -3.785001859050085, -2.514315450628534, 0.12038047991561844, 0.07171535643330888, 0.019976525640480008, 5.021471828358518, 1.120336023734777, -3.8582796981970904, 1.5318983715751375, -3.0434737861734473, -3.481702939477353, 4.92073064838603},
    {-3.4044712655497222, 5.373960679681992, -4.118592785295165, 5.135344438901536, 3.5229963056271516, -4.488581356382126, 4.401127352985739, 2.704279808884089, 5.016855796062091, 3.425898101447273, 4.409495325196993, 1.2964440223884162, 4.853899627621935, -3.883433838876541, 3.8705943744630638, 0.5314465839348269, -1.9090037364028023, 4.609465573593717, 4.481822358930276, 3.121485082248918, -4.054294290806923, -4.289385366540823, 4.650362526509586, 3.871135797116506, 2.9316120225144124, 3.0147729076862007, 3.9372681386401225, -4.257963725265106, 3.4739228437758802, -4.237838790331784, -3.862947102973255, 3.2249476946122937},
    {-4.395490045725176, 3.766130543392588, -4.7739703171380325, 4.371167835755765, 1.1043896638796011, -4.918957592710532, 3.5236771849919317, -0.17579016097050523, 3.62996276267114, 1.3436203641923339, 2.0292452974246733, -1.4117898537391576, 3.476683363806797, -4.518907122222169, 1.9612955941473595, 0.5072097072058611, -0.13227488382334776, 2.2031047386570872, 3.770622583453517, 0.10324234462607101, -4.640835646726031, -3.792875410800438, 3.7829252297989155, 2.1795354427645375, 0.11024338544478374, 3.61279490352802, 2.5824257071263244, -4.40728598407504, 2.0075856629279136, -4.859888679274176, -4.92979960893099, 2.5581831614873964},
    {-5.406160620258116, 2.06893817297901, -5.543443040601265, 1.76120938243394, 1.4036599582204279, -5.151995193165149, 1.487349930709767, -0.11652301672641018, 1.2405081134126037, 0.4986799817590612, 2.197089766771019, -1.511974851099175, 1.5533897761152498, -5.45281586746536, 0.7231913714136171, 1.5847515820107523, -2.6440258953903664, 1.4357373683302384, 1.5710360332699493, 0.4547203313700766, -5.466180977460094, -5.349662106389868, 1.6125571890190284, 0.4913333408496916, 0.3586178958727386, 2.0802714955917274, -0.04179166590005243, -5.627179803651333, 1.948809656026272, -5.256129447309388, -5.49975899088171, 2.3237560912405457},
    {-1.1824826010043796, 1.9916632041557116, -1.3745777991127235, 2.3843563650601474, 0.5749515286215572, -1.3059446264829857, 2.316387889337197, 0.7070312392706976, 1.8159814957006317, -0.5594437254990595, 1.1796245053342038, -0.6623694182267049, 1.5365998383360655, -0.22990126055407947, 2.4494465546323196, -0.35498305041842776, 1.3536217645264912, 1.3468588325104671, 2.290750389462467, 1.1322312524182512, -1.6315257241364882, 0.46188840226242067, 0.26034441766930766, 0.26440709990684136, 0.16322621741973406, 4.122522224807712, 1.2684763240085208, -0.6119061225590936, 0.4756823165405006, -1.8208865365387934, -1.3468139173115732, 3.8826158154336365},
    {-4.826660381019919, 3.6762703495740143, -4.382748827242833, 4.267643678669724, 3.753623956865641, -5.3548365389782075, 3.8149263856680244, 2.5062597921867686, 4.53713708938658, 2.9808221842623603, 3.8249532186544486, 0.9346132710952815, 4.608680509677789, -4.776779537879326, 3.227386715911119, -0.5739446387179378, -2.5751523984886866, 3.598910538327957, 3.68322330730911, 2.750476425826111, -4.838353573745138, -4.975677599092693, 3.95528774433956, 3.194391767795289, 2.451611552110698, 0.6557467026823127, 2.721645970912125, -4.7576349309515695, 3.059007871149346, -4.9339048985769836, -4.56829415000198, 2.181181014532878},
    {-1.971795150034699, 0.8549651053278463, -2.4683859798330063, 1.1888155384185524, 2.5459612905102116, -2.5593851335118343, 1.734111358448004, 1.9448665744574904, 1.9817029080303004, 1.2602482978249157, 2.6410712624813586, 0.8696309850726076, 1.7926949897540232, -2.180041364327768, 1.7739302587525552, -0.6436341788245957, -1.9410413666478006, 1.648180614486363, 1.2520104463863497, 2.469713057836035, -2.4850214085869937, -2.6134784032279335, 1.3648106731189975, 0.8717144888398336, 1.7825827197208088, -0.4167069694626582, 1.1372268577004736, -2.148306256315589, 1.9158476646081442, -2.959811542673777, -2.4200918071090336, 2.164102097035005},
    {-6.422415947659776, 2.0176327730680463, -5.724227059660603, 2.1391288702893827, -2.4451542392455132, -6.734431259738464, 1.912098877415584, -3.9015500266395957, 1.4220815568803729, 1.3916454290357263, 1.1930652723336865, -3.365915455771498, 2.1066771491197525, -6.414037857349253, 1.7754245764434922, 0.6501779117945831, -6.087262259063379, 2.1206558091159082, 2.248602868465424, -1.8574512800633698, -6.465391212525391, -6.378687680476429, 2.2069516879138837, 1.8342859593495056, -3.621899718908697, 0.502556101664884, 1.1974107211863736, -5.72304204358671, 1.3193934911965084, -6.16620569391783, -6.510816334208449, -4.620391344319487},
    {-5.149297832535524, 4.340769372968596, -4.7321645391107845, 3.61028067475647, 1.028033823935589, -5.771589747913912, 3.8986585737922894, 0.0780194467716868, 3.8126210311337023, 3.3049107295908695, 2.8535927287239127, 0.03136151997777962, 3.747302613943902, -5.736980230977974, 3.3036717153812694, 1.835823081397709, -3.293077090897682, 3.7920340097018648, 3.705573154333297, 1.2138031597122074, -5.237099596297673, -5.39082112104887, 4.184769207918494, 4.177378082952925, 0.19416313780651456, 1.0453443347802844, 3.354759429626673, -5.043598320896645, 3.07743818513667, -5.68836186876826, -5.441611823739378, -1.818181170168838},
    {-2.844579497671609, 1.8182317663034382, -2.172085294125044, 2.685815472627671, -2.9182928063836604, -2.8868135016433207, 1.245981130219172, -3.0516007917979717, 1.753462553381198, 2.229820718022077, 0.26874101663976674, -2.784767389884516, 2.418663412645844, -3.187075068778677, 2.258008259212688, 1.743314974589353, -3.43237298988184, 2.1913680473648594, 2.3225120885188235, -2.1348408015302938, -3.198859017474313, -2.9845343421071986, 2.715598076778616, 2.279943506860302, -2.963895039243312, 1.7750554369749887, 1.8399942448521693, -2.661513674567343, 1.1417525725836726, -3.346112082648111, -3.654468984024055, -3.5247333341888627},
    {-2.2608100107350033, 1.6343486511660263, -2.2925107388911057, 1.9235329152689344, -3.0049815840655714, -2.441543512263358, 1.571126854704099, -3.0786783808612928, 1.3046905227333048, 0.8290316308148, 0.7058342493492247, -2.7250537983816625, 1.6868077231865621, -2.710584874014224, 1.5154322772732902, 0.6638167175565046, -3.3743716429614996, 1.3457134645429976, 2.03069865602688, -2.301759188324427, -2.815079840111296, -2.4520521815742575, 2.152242990512528, 1.7057802075053563, -2.9252994673439146, 0.8853273160045144, 2.146593793253414, -2.0619081774907158, 0.20559629037301078, -3.393135740626263, -3.339082060943607, -3.572811968467641},
    {-2.473018746196117, 3.498790051471137, -2.3859989248385896, 2.960240107101301, -0.6616452489436135, -2.7708448069123444, 1.6795863258599815, -1.607252681100112, 1.7497938151829815, 2.421323375631681, 1.3135982854601687, -0.9606645187306349, 2.653179803099356, -2.6065159998503473, 1.9247841267694115, 1.3998470854532843, -2.0232164512984827, 1.9572160297679855, 2.698496729861138, -0.45126265276235017, -2.862559413884784, -2.1956981514529716, 2.1658151040972697, 2.5354396456137978, -2.1028226229764653, 2.1477615219658417, 1.756427480113022, -2.4110813685415606, 2.085709486840781, -3.3218801340368436, -2.642067544921923, -2.070935590024371},
    {-2.2800549726021844, 2.9532818242929286, -2.9995849039944638, 2.6531402226183114, -1.2582723649688268, -2.5411397445788606, 1.8208110831650688, -1.8979278035794134, 1.7401985529573278, 2.399125644746057, 1.6467440141232899, -2.59827852091748, 2.538540151476396, -2.823955758486755, 0.8011788364032508, 0.6627385102041337, -2.954507298491795, 1.5454264047520718, 1.439000288225134, -0.6038366733745838, -1.550566968227119, -1.6096386678788461, 1.9170189622895175, 2.3441501980178496, -1.94687905240822, 1.2875174104157197, 1.2122101708180215, -2.6435263858184115, 0.562821333538588, -2.886500992003134, -2.3633500912415917, -2.1970368186616014},
    {-1.6634232246913307, 0.45275458850847533, -1.6030714165243158, 1.4141459971586958, -1.4344630103404366, -1.4381784402968691, 0.24680461739926499, -1.3748856735301034, 0.7231284624467884, 1.4285736535564035, 0.8667937775111005, -0.27972781271903896, 1.8535624777415638, -2.094117186856946, 0.9392454945085291, -1.0896728718769446, -3.062398796361097, 1.630682962855946, 1.4490636141056938, 0.12143715631376997, -1.9415823073861382, -0.4467193317331598, 0.3984178111769947, 2.3378675966423015, -1.5046785564487097, 0.7559666947194854, 0.9769502744294523, -0.8569570488722523, 1.401884731014694, -2.352343650906454, -1.6165004941287755, -1.4343934339301692},
    {-2.3846239173376866, -1.5218578841671022, -1.4771404550198293, 0.49887267507761435, -0.2987019572999012, -1.6725553418237553, -0.4431526971695313, -0.7641685509221509, 0.20102298864264254, 0.7432003375864549, -0.6401609252705291, -0.6695435229856009, 0.5097173565690173, -2.4126865265591992, 0.9935483863619924, -1.7808055196616863, -2.1831486748860582, 1.291871862992599, 1.0700311756392449, 0.3194145826214417, -1.6560925440147378, -1.429307031741086, 0.8879171925608678, 0.5075068935933233, -0.479292480887564, -1.395721438714769, 0.226905571179319, -1.6084423845830982, -0.10228746229341124, -1.9827282252100393, -1.311762154800966, -2.7890555896247533},
    {-3.9848250150809355, 1.4029968964884862, -3.0842043549182665, 2.222456893937182, 0.03809337771473922, -2.4092895505496084, 1.8501685710671936, -0.6138010068030558, 2.8186145234681192, 1.7581738616269942, 2.567198274732552, -0.5386562964397453, 2.382344792939079, -3.269978212361608, 1.1742356539535403, 0.8871771133303245, -1.5504115407424646, 2.6662948388445638, 2.9466122416579936, 0.13436102713050288, -2.811516937081849, -3.1663546443209323, 2.4163566543959516, 3.0100724876684435, 0.9020829557620674, -0.060216219956741424, 1.6030884104969136, -2.051410279474256, 3.0728508669479604, -2.729807056147222, -3.074962905450199, -2.0831472290480546},
    {-1.6865440195382535, -0.7567823606104874, -1.1363405281541967, 1.5073285408689443, -1.2965304398932878, -1.6690260768159404, 1.5657164329008264, -0.6852035165944408, 1.4657458737572127, 1.931436578490015, 0.9688067404437246, -0.739364149469426, 0.9171254570587125, -0.6447722344902166, -0.290663037261894, 0.4760957964803447, -0.18232448573588195, 0.7751767088611838, 1.7780339975387045, -0.844699967490313, -0.6271167740150574, -1.9468527149271773, 1.641088883320199, 1.0889134682904087, -0.8589390479063439, 0.91736583916582, 1.5653615108623975, -0.2732016746890451, 1.682875968476503, -0.45581247067836783, -0.8720480282688182, -1.6515192367449583},
    {-0.03619527455530508, 1.2099708677351784, -0.8073049328644374, 0.7831966662900524, -0.8688599683073869, -0.885004933107381, 1.2702646079290416, -1.693825117991919, -0.44535314283101657, 1.020364280422278, 0.6431346151969404, -0.6471821816742904, 1.0858059379283007, -0.6814588472908865, -0.23333400466429394, 0.46157688499867233, -1.4074452495919583, 0.21170896635316316, 1.5848652396738687, -0.2912691543790812, -0.8927224748277846, -0.4200748348608367, 1.5093381621331399, 0.7554981957384631, -0.6736927806779158, -0.588270120792365, 0.5416676053882538, -0.5841435738542841, -0.29675631016113413, -0.26616733166725787, -1.2588678433844402, -0.41546082971329984},
    {-0.16220296210061325, -0.4614345141022025, -1.9886845525421017, 0.92516672587998, -1.1085331643858416, -0.07079744908061636, 1.858139288557697, -1.6738445326540337, 0.8392425980622673, -0.37928879088653833, 0.9231343306705553, -1.2066085588806414, 1.0136796572156408, -0.05626472892787883, 0.45813503848031006, 0.7980043872850445, 1.2241023287824937, 0.0516025271535332, 0.14432313534106953, -1.0135278356929822, -0.8645841666414661, -0.6347650997387221, 0.29184665694379264, 0.9726850086471338, -0.550083137734776, 2.4164319871596645, 0.5144373024269571, -0.6209718945380488, -0.10363120429896865, -0.7022682309531899, -0.9335706396240633, 1.5901076812502615},
    {-0.38846530733226603, -0.01883657150743124, -1.854577012217107, 1.393386926950255, -0.43455427034000926, -1.6103461109919959, 1.3431956001038425, 0.42918649060779834, 2.121052364860012, 2.7036631373236557, 1.7608059283765916, -0.1923950092794647, 0.7288369928345885, -1.7387228603275657, -0.4209315659233144, -0.6014162461188226, -1.5554541800055093, 1.0829432355818915, 1.778486093633572, -0.29735848296723966, -1.0523896867544145, -0.9838343155774787, 1.6711208156802546, 2.286209556136195, 0.3642910580470548, -0.39965789434908966, 1.7271024637504024, -1.1392701468794324, 0.18986347422203112, -0.8647100960673177, -0.8028801557185509, -0.6372333477475761},
    {-1.2764125625132547, 0.28995971286181677, -1.3475698754282337, 0.3801662114998809, 0.5754201131779197, -1.2221018126662526, 0.42526054634987287, -0.5538631004185836, 0.5093772969791741, -1.503561434085072, 0.49014971827720566, -0.593001991856639, -1.3944918538652777, -1.0802527305434226, -0.060811114294780574, 0.1046299463143093, 0.03503917766766548, -0.4311134293120861, 0.15622086960151335, -0.15404297985772838, -1.4075120397008052, -0.8618819695719611, -1.0092593903705744, 0.4440126216106389, -0.7136708682103126, 0.20287859700518066, -0.2099846039621045, -1.573115094515368, -0.6342806841790977, -0.5459635439770638, -0.5459646997992843, -0.789512433111518},
    {-0.9803581103961648, -0.8066695093128019, 0.05208811854125723, 1.4245585095144913, 0.3556288102208688, -0.8356269519819226, 1.2337287866107747, -0.006248407045800605, 1.6303585585526768, 0.45781932404276476, -0.16142009785556405, 0.7158372388829999, 0.6110497172099839, -0.261900254811525, 0.5363886715657914, 1.1427550298294122, 0.6259825699472341, 0.3334717344173957, 2.4111528468712136, -1.3010555036155105, -0.11005079026528546, 0.6654640727565059, 2.0317051618644393, 1.7729563157871497, 0.03835957738689985, 1.0736968838353953, 2.657715813950125, -0.3527140239781082, 1.232729670709158, -0.3738429472208061, -0.3894844493116586, 0.40907389422937146},
    {-1.463549073015212, 2.2919430504384684, -1.9896591134722874, 2.17187707244627, 0.45452147568412704, -2.657277842793064, 2.252332871364809, 0.30038630672084454, 2.3725979902602545, 1.4317753763760848, 1.773257093720188, 0.42942394554651714, 1.8979949365802227, -1.676730167252374, 0.7704816880792419, 0.567541035066305, 0.8489629002651854, 1.6877193905126888, 2.333032573164546, -0.3299152120689309, -1.2284243689794783, -2.2252506178550773, 2.2987953072807503, 2.1333129700778724, 0.43164433702414934, 1.6480886819143574, 2.802327427665015, -1.6337017027580263, 1.0316372360317607, -1.468402696956726, -1.1689018814598313, 2.4459416559085474},
    {-1.3450300654615934, 1.8166137900782535, -0.518743436052666, 0.42537398184943576, 1.4042976136392424, -1.1789341590766655, 2.111438141199703, 1.0363715844304586, 1.5731637366302123, 0.6682683273142254, -0.08101382842405064, 0.48604674263802283, 0.8469047659904478, -0.9911381599157142, 0.7780342051392548, 1.6212232135904758, 0.2370854960260608, -0.06630511966625564, 0.9414158446624364, 0.6423054330154447, -0.24970693334404911, -0.6580283233177888, 0.0586587737187654, 0.07632317186999835, 0.8359536547895428, 1.1810054336567568, 1.2213944063983873, -1.1470106099950321, 1.0444509734368035, -1.9072098390867613, -1.2464904659682399, 0.4401882632971239},
    {-0.5622763621888371, 0.5223677665330301, -0.8340379272403287, 0.792623569546852, -0.28036355710344585, -0.7596997415141089, 1.5002982865117076, 0.6764779425405782, 0.9689941633637983, -0.41531377952345644, -0.11549402023187134, 0.2893221501369504, 0.5768250266790227, 0.39961367530159553, 0.8952169637616145, 0.8774627820960191, -0.2217020962197353, -0.7254432550476322, 0.2892389187014001, -0.9941974315654051, 0.1518889888882656, 0.20626125550690178, 0.7937905214435083, -0.28611785954044633, 0.8293230279655202, -0.09083678965448487, 2.592609491078156, -0.9789294309295992, 0.438506534880335, -1.5144485611311576, -1.2342101499054379, -0.8094912458197552},
    {1.0658484473878977, 0.37400703770836835, -0.3082870769086445, 0.3409576906733172, -1.0903736469254681, 0.3355546243413902, 0.527564503046243, -0.26355458272391213, 0.3400522109460802, 0.05470351194777456, 0.751272767271291, -0.17294110489467643, -0.16312552744708086, -0.09475548063051685, 0.5474216309606447, 1.4214924462391636, 0.5014081994308403, 0.43796221267436314, -0.008895781673062313, -0.7909095045981266, 0.37233800689248786, 0.06808156563686474, 0.2678145566630696, 0.9629636334164414, -0.4100132530662974, 0.22275571752009418, 2.7965360921992937, -0.2964051500996687, 0.5156725568607229, 0.664330764765199, -0.43306669826132005, -0.9778839501964588},
    {-1.0143492606303004, -0.08814180546349007, -0.6715591276603305, 0.8427940901783816, -1.2093082795270744, -0.6043017122393225, 0.7060685223326565, -0.04344618789224364, 0.2022036154781961, -0.7339531374370083, -0.8569681656303266, 0.4379589165947853, -0.7557818157373295, -0.08542217835980291, -0.7510254592029676, 0.11280713990001941, 0.9363854034852938, -0.7712430686031045, 0.6317281890351676, 0.029516173133487804, -0.9531914487271562, -0.2631180460598657, 0.33744104384494394, 0.47931744363463996, -0.14728559631439106, 0.7955953682911553, 0.8592191164706171, -0.016718302118702448, -0.37931377302706343, -1.231966188934204, -0.7732923259158251, -1.4540525675226093},
    {-0.16138158685244822, 1.246066396173566, -0.22615221664577256, 1.1643234023547857, -0.04512363653924384, -0.27627467093492164, 0.7358782079035255, 0.41325546606654184, 2.0411901190941326, 1.0973997883161932, 0.03517776803233199, 0.026284324158170926, 0.9719327212584742, 0.2343717915220951, 1.210246009238635, 0.21127316298644028, 0.8113508863299196, 0.1699136354058167, 1.581372610298149, 0.05383857838719123, -0.08128717599992852, 0.22216017510168323, 1.5198664776827675, 0.7476154369536987, 0.3230134864080469, 1.587735028813752, 1.7374932333618909, -0.18193438536537687, -0.12514707430791958, -1.2093150299323459, -0.20603666345825983, -0.8807926000783233},
    {0.19032168094492616, 0.8915479870943449, -0.43003682428737844, 0.3353771610017392, 0.9436538661821084, 0.34279615794358415, 0.9807627607290923, -0.07135143468649086, 1.2340604900596812, 1.4173926221350752, 1.2208360231342839, 0.6277209895779727, 2.0823982798824345, 0.30812624281255957, 0.10297667599491765, 0.40912235387726614, 0.693569805100465, 0.6364845872861667, 1.2691993404522979, -0.26230301804142286, -0.21713934674505986, -0.3870142212706791, 1.6723077208500274, 1.4763059593158703, -0.5801648501716388, 0.7490748585111704, 2.073645588256689, 0.09978227511942328, 0.09093488972576713, -0.8851100722291995, 0.02422756574958174, -0.28608656393811704},
    {-1.5612885099478186, -0.08053705965469939, -0.5574934661403833, 0.8486177756273949, 0.351202007616805, -0.6194222355331938, 1.1361794385738897, 0.5932602481823981, 0.21814882624580118, 0.48701137903300107, 0.8748224180767986, 0.8849145720852816, 1.046330220328962, -0.812398525567484, 0.31587571109645657, 0.1550701314134482, -0.2643709174391245, 0.6202346294965221, 0.5779914886958492, 0.3706148852519893, -0.4532320100951109, -0.6039664180361469, 1.491885600408198, -0.17979436714021188, 0.5631523052521196, 0.19050442071117998, 2.087774677852224, -0.13624797404578404, 1.0988850611192917, -0.9077679550291016, -0.7581149422973268, -0.6340141195294323},
    {-1.2745623103564023, 0.7765247042409703, -1.135557414975165, 0.4965269018758605, 0.3735766572714093, -1.0208154588066571, 0.01965503421565056, -0.02693288614377734, 0.4168007516055959, 0.623978019057114, 1.168277473747969, 0.05077818948192677, 0.11077731572149052, -0.9683222157402288, -1.376609473503173, 0.7351153527880459, -0.3342490750234157, 1.170900271505085, 1.4803028566766985, -0.15432597501224132, -1.5481379930666515, -0.5658318896384792, 0.3766903860535126, 0.251118740693732, -0.2079690959540026, -0.06423189990630318, 1.0020713744882148, 0.0022291227456984896, 2.61166347901234, -1.55361726856936, -0.7287513711141452, 0.9105796295098825},
    {-1.1673284915514328, 0.2869587020676526, -1.1555776762184424, 0.14376588136405508, 1.078380682631398, -1.8792160517692449, 1.0309168710907073, 0.6876907767322934, 1.6279781198988013, 0.9498735017729745, 0.11676812109699747, 1.370151905042083, 0.6829232244880438, -1.4088240394123686, 0.39710048270008214, 0.03953922032806664, -1.2319372308645427, 0.7477662770932275, -0.01565985534808412, 1.6191936970465666, -1.190122714035917, -1.4805053934413082, 1.0719046868094346, 1.6541240255823175, 1.1277627081593238, -1.1238580623764272, 0.7339567534790299, -1.8962591018878634, 2.285806914125339, -1.9974223631376573, -0.46120628652952617, -1.3552450772176088},
    {0.005479564692786734, -0.3225051483741001, -0.6158554673828582, 0.5875823504150407, -0.7023204557866035, 0.7976501332852547, -0.05635509111442482, 0.6310584671337202, 1.322578849105392, -0.12416915642379824, 0.606993160055846, -0.39320950787221626, 0.6703183694885332, 0.6159496669864182, -0.19049197081928707, -1.0881315282906348, 0.3977876972519295, -0.10616731862422116, 1.1059369456215473, -0.617015356294243, 1.2563399589873576, -0.01850112348105166, 0.28358137620411067, 1.1042197683251742, 0.3104410577698481, -0.7498009309290491, 0.9172562461659759, 1.0477700154115093, -0.2542176780484335, 0.43157369337912577, -0.10437255922114098, 1.0560680740750095},
    {-1.4765958573151285, -0.8609059287132877, -1.7245039628946344, 0.27742645263203314, 1.107870981074965, -1.7703656796110983, 1.1269997450716036, -0.23232310780888274, 0.9777892239124316, 1.9780868834577918, 0.7302968823365996, 0.27337329900185303, 1.1988095276004371, -2.491546607214265, 0.672898332930231, 1.9216005952800763, 0.0907332135530227, 1.574475061527538, 1.5924245165454198, 0.2503258193357211, -0.6030381284515255, -1.958910219582613, 1.7547082624783295, 1.6194527019395235, 0.07021528090998704, -0.23271635276344446, 1.5280812704661046, -2.180288644797405, 2.248557562503828, -1.7101385096866486, -1.1414519622354973, -0.5741038897289007},
    {-1.9154739391756672, 1.8113231025042238, -0.5612417611414899, 0.9660210249745637, 1.4777639234126834, -1.690466521926989, 0.9636741659080452, 0.6814091213364705, 0.6841874626648221, 0.02148462750818391, 2.4049066533615604, 1.7872610119738608, 1.1106533966119276, -1.29833215630129, 1.3814563351137052, 1.9560165483813037, -0.11312465157713265, 1.769290405151213, 1.346830239950942, 1.457687024392424, -1.8045123315529734, -1.3825022116646535, 1.5022459046699206, 1.1663974787891267, 1.6684475239595002, -1.412518205403852, -0.33014360203434456, -2.12838085172488, 2.065171279898203, -1.4897603418498342, -1.6666481768679635, 0.607032379717013},
    {-1.7785082892111523, 1.992133750859173, -2.477604454619609, 2.3076458055418585, 2.0615689010852223, -1.5588562797419072, 2.4785165295227563, 1.8397473645172853, 2.326620242751657, 1.8423702928622858, 0.9732922855494167, 0.8157373258909005, 1.4125999098083797, -1.843044028559105, 1.2071381322652952, -0.14804061997017962, -0.42508782396586936, 2.387027459660211, 1.9110220556697182, 0.44256598958003945, -1.9024774346452655, -1.3528585620098512, 1.7638677983435616, 2.197683869113457, 0.573210340603225, -0.40531526954962543, 2.523791721843671, -1.8833126664181254, 2.2434805701518727, -2.148989895843393, -1.0123022651655997, -0.4506900642869673},
    {-1.3173084923872171, 0.629901365425687, -1.6970715960804796, 0.9288862257632233, 1.118236165350044, -0.8059727951131084, 1.514693419766475, 1.94903515204679, 2.4198336530428497, 0.2868760426736669, 1.8546577661409906, 0.9141988542270043, 2.298954982037743, -0.6656188346520924, 1.4556509346270055, 0.8523286901801757, -0.12378877753018652, 1.9380100018036373, 1.5698388789998976, -0.37227381208112525, -0.022907746749262135, -1.5892838680309576, 2.36550889526776, 2.6220524900594313, 0.9039932497318767, -1.3547166898314762, 2.7366816248564314, -1.2205474657417346, -0.36547584459227944, -0.9030827447124076, -0.8026228993573373, -0.1162963467103144},
    {0.46728094869582026, -0.042519507005118765, 0.6998633446611561, -1.2389635222461262, -0.04505509411579322, 0.8991512668616015, -0.7434962504537382, 0.4639906570525325, -0.39816660031800005, -0.2803108796147561, -1.6547873797385426, -0.2900207833187433, 0.16106724414366025, 0.8870724647937108, -0.2908282951668098, -0.9208951419684942, -0.13919520395739757, -1.1378827418071225, -1.4236125500633008, 0.48274731055663045, 1.0928739269245982, 0.5174397762775642, -0.8726297733970095, -0.26564508185913854, 0.017028867528894757, -0.574279287563089, -0.9927516714469398, 0.45785858105924826, -0.9524516695878539, 0.10085253779276969, 1.0784024030507329, -0.34463533416757486},
    {-0.7579012875112006, 0.03773415572981394, 0.45729328266286995, 0.32999336289835507, -0.15027109740661468, 0.34286721734698766, -0.3853764357203619, 0.037973779858156094, -0.4475880147490192, -0.765586531322192, -0.7337485500245079, 0.3483304723023228, -0.42615837752003566, 0.013426994356076716, 0.6077253894642017, 0.2575104845657518, 0.17528499259663796, 0.22113338244629158, -0.5476407268489022, 0.31838015765451483, -0.4575865436122527, 0.6770282901522479, 0.25119060254038345, -0.4037105900400341, -0.6333548582602615, 0.6354933380778368, -0.07568957567583727, 0.8087900034611942, -0.12944512699434804, -0.029389802402036664, 0.8134314273086508, -0.8852752129688175},
    {-0.29370182434922726, 0.524580771553962, -0.7095666242932553, 0.5634654373174274, 0.2870846653498441, -0.025255090100778817, 0.41374072241141635, 0.18870988096757488, -0.27069879830267274, 0.21513224927135818, 0.17543554272640025, 0.8369320397121086, -0.3364446674542121, -0.37777931787982244, 0.1981421606594906, 1.388151066909387, 0.9980232999561263, 0.9276019573950003, 0.11995996942641678, -0.27288445149316, 0.12897161854989658, -0.027354510870173456, 0.11726935299556761, 0.7501272893507582, -0.12008638082690122, 0.9716145100893883, 0.21332910190287638, -0.3889809434679351, 0.22264421870138362, 0.44160614776246726, 0.0004040076689814189, 0.5800544539805199},
    {0.7014033737746337, 0.39952386667705847, -0.6610852512446124, 1.103269188050578, -0.299153169365961, 0.07333086213853295, 0.8612543979613367, 0.12561729604236202, 0.41281623534865264, 0.5677944797079136, 0.504051043419636, 0.7734066745606254, 0.48189028788118077, -0.319619348492789, 0.626732280439718, 1.6662327933568557, 0.4195875200532629, 1.3159317308863423, 1.0825254277009027, 0.2025972840559785, 0.8006633668388287, 0.09452281217814142, 1.1090159816667777, 0.8974302296838508, 0.31736494332505294, 0.86199557229342, 0.43337144644516196, 0.19164515691122055, -0.6674016426122397, 0.8393118879911352, -0.02962636954017845, 1.1631686536905153},
    {0.554959678728292, -1.343876223574835, -0.07074522906776214, -0.040696197729526346, -0.655614099361681, -0.35658787921738605, 0.05930741737814752, -0.2584439821878411, -0.22446947247054022, -0.41843778601605397, 1.186151153346504, -0.6655972415702227, -0.16255816095083897, -0.010250974101138127, -0.6074751670209635, 0.11017174485065068, -0.5343987800916846, 0.537981811405702, 0.6198865387824732, -0.5741594534361478, 0.0577774196239225, -0.4438590432313651, 0.627904483598029, 0.15832250412697263, 0.24666901919445597, -1.0155990759008409, -0.22335400062229152, -0.030467360682805266, -0.8399275532146986, -0.33208819504655257, -1.030444269318485, 0.6233489710028023},
    {1.1792689428111027, -0.046484223301246845, 0.14347613484850757, 0.02378857973683354, 0.026843690391223033, 0.39504263273986123, 0.6628290628282363, 0.862513338527397, -0.052159296022626464, 0.49619282326540204, 1.4280427801451026, -0.8734217401897214, -0.02525155413262915, 0.58591260254278, -0.3878733023387966, -2.218976084190044, -1.1677278278370733, 0.45257825817962366, 0.9926221796230681, -0.17686792403113485, -0.17019624766376507, -0.2800969593471935, 0.9266802792088988, -0.023750627991764642, 0.29665555920752434, -0.01855336143196064, 0.3809941103549903, 0.04051772035497941, 0.59830289187229, 0.24427209828580226, -0.7069057318824274, 0.32761248782752533},
    {1.5736761207420031, 0.36670897537454256, 0.0017879777395005997, 0.49235055505536185, -0.39573186161093277, 0.8724241057170783, 0.8454491021618327, 0.5683503343571162, 0.20700984452624904, 1.274505345433305, 0.46666491743605854, -0.20278433809587357, 0.20478842726366553, 0.43787596264860545, 0.6036207471640362, -1.1665334036860346, -0.32201202683232416, 0.5646619675929739, 0.6762245470009505, -0.7578675536925379, -0.2792062204266566, 0.6894194513276801, 0.515483296008178, 1.1796283765604656, -0.07222314067965488, 0.757773830795158, 1.8563013439482963, 0.04602207495074624, 1.1983102976844908, 0.846668606260179, 0.45832524768140526, 0.4284068734622277},
    {0.07741861927753885, -0.6676858742367908, -0.323231589105673, -0.07825089471593134, -0.36193108146321196, -0.5860590082932174, -0.054877989763390186, -0.7360084384295298, -0.6871731419412347, -1.0376762543145523, -0.5456143491205345, -0.3840492873888875, -0.3137021771560732, -0.4264881083258734, -0.5394653651437443, -0.46328282729338377, 0.18696678784263085, -0.9374006995861189, -0.1350277646839407, -0.5790738708186385, -0.3533237867602679, 0.08054120630585318, -0.6983878427612457, -0.4728646439068501, -0.08773629593383361, -0.4069623692761961, 0.6355849639515819, -0.8733084593555359, 0.6162801678685871, -1.0750638312831775, 0.10438625476374802, -0.17768707158678476},
    {-0.8201703831722209, 0.318265512795204, 0.27642345908908306, -0.4310569765205097, 0.8480734608914446, -0.13722508785768237, -0.6657089449227865, -0.7321721812118237, -0.000948999964099255, -0.14389309963764732, -0.7059368413052881, 0.3440074738152279, -1.0925282938608902, -0.41630190820688656, -0.446075912033133, -0.24465514575370825, 0.04449014447425449, -0.8392207574845493, 0.3699003462602805, -0.1540394170442714, 0.22531722138003893, -0.2206302837939645, -1.4314251685594215, -0.8600491477349742, 0.10266525620282732, -0.08565035005699946, -1.1763273870076894, -0.8360409935945194, 0.4183981423814278, -0.42641810326533475, -1.0240901803618798, 0.22477001302380817},
    {-0.5225470944044996, -0.37251121106196605, 0.14233522608410223, -1.0453921800897394, 0.6174245437540072, 0.033347811567718405, -0.06381089762253922, -0.7635909685501273, -0.6094893753917888, 0.381968448027006, -0.5845901844186305, -0.5076575335049608, -1.063473292568366, 0.26065400389583704, -0.8596422905272514, -0.18982310158357799, 0.6170392803631949, -0.9802010413353881, -0.09899425607282115, -0.31361302167337896, 0.33966495659350937, 0.6684060583834703, -0.9179871370504986, -1.3078502276778117, 0.2070259489414608, -0.849757992917109, -1.4631042684473725, 0.09311634803473591, -0.03793662522251299, 0.4704543902262414, -0.3268866395155234, 0.6770247473718347},
    {0.5095108430821541, -0.6881877084094027, -0.37085829952545624, -0.24334444524474422, -0.7762438235634975, -0.3126340823293743, 0.4293389561313515, -1.0668409325288, -0.5570417599330298, 0.663817249758531, 0.47626002311096727, -0.7595987499109721, -0.07697540327607966, 0.5436941987671211, -0.44914020262164583, 0.010759289720772629, 0.4057069505157375, 0.44219493419732525, -0.45447552485562337, -0.6661036785168438, 0.15585238421123865, -0.1682813739791667, 0.5670034301748527, -0.047820958335991016, -0.42559164625971896, -1.1904627055011436, -1.3344284035110696, 0.11710236441068797, -0.38669914799923033, 0.6077651484130507, 0.14728929656466694, -0.17902427385213618},
    {0.781370430185855, 0.6800347654950691, 0.741689132753777, 0.8441244808550302, -0.03342218349268336, 0.5841617922153445, 0.9996007922690977, 0.9029526369410547, 0.7048753627799305, 0.7015386904751664, 0.12716652895774763, 0.4579233709947168, 0.7203448987364562, 0.2579875989103803, 1.034773927195394, 0.02699893982173292, 0.9851678727135526, 1.3203885850624992, 0.8025668548205123, 0.941383918598063, 0.2444391824916894, 0.4415600643190516, 0.40889836151697434, 0.8028359464804484, 0.7915207107154186, 0.0646898841655314, 0.461230642451562, 0.6883618344242859, 0.3062335274784095, 0.8434977634269462, 0.41938095208912207, 0.5501238264602315},
    {-0.40554253058762635, -0.06963909913325594, -0.2155050811095947, 0.6178203765046298, -0.23396397578299927, 0.2323083235103437, -0.3211558167224728, 0.3682085856143703, -0.30122493361155256, 0.24775277547607796, 0.4241522313897882, 0.03772269164481183, 0.06342280374940508, -0.5858359873166246, 0.7383108772866951, -1.5248504047517442, -0.4914410393191342, 0.5854167672342497, 0.5916011898179983, 0.5476941561280153, -0.05887310184277448, 0.3140852707038019, -0.03767847307477478, -0.09770085364757695, 0.19548372693462776, 0.25719653740419424, 0.7982806799136635, 0.4333061546016691, 0.6900551268276405, -0.9473478773239224, -0.07783606273741007, -0.6158954868465447},
    {-0.9041414713874012, -0.5144250113964236, -0.4823690606087901, 0.33996677117812124, 0.3993639615991797, -0.022349049911423672, -0.8446645612762053, -0.08410214917234171, -0.4730414794104272, -0.04882608065271659, 0.5854023468739991, 0.14155308610221512, -0.005297158212420333, -0.09784109375011087, -0.09955100711279952, 0.13754369673363828, -0.7126793846645149, 0.07309559327913007, 0.31897712774965054, -0.6745399099059476, -0.31279492559764277, -0.3336752074542594, -0.2242624825601384, 0.2016012513608145, -0.5528136426609601, 0.6919681761177455, 0.06671235163858538, 0.45764859982256834, 0.47570168281801223, -0.7996511452285984, -0.4576938504148707, -1.0220077720406378},
    {0.5846508669000874, 0.8277258262258922, 0.29705414680186615, -0.8598231215599893, 0.6564270589948971, 0.609566932369427, 0.4722117046635383, 0.8823034083441718, 0.5489086314102941, -0.0006122918016912967, -0.2555545541449232, 0.819716493161036, 0.4848000444987699, 0.0706798383828154, -0.07680386501308391, 0.5784682987181485, 0.6328118881989648, -0.3138130523647356, -0.47070661335629754, 1.0651846106946776, 0.20465065834207818, 0.23603402439677876, -0.7576420936892476, 0.40613253519825343, 0.6574559912930024, -0.38371958985345667, -0.46115688656980064, -0.01671630929586493, -0.3543560561830217, -0.7395730509399808, 0.6164154095059616, 0.3428678995431005},
    {0.6187598250116976, 0.5438028869653735, 0.6012655355143817, -0.42084414972448175, -0.4001020529555491, 1.0317904569964866, 0.701745331484228, -0.09842075717181568, 0.2607289546750404, 0.10011660795425874, 0.2671017994083761, 0.5473981115531236, -0.7673530857546784, 0.8911402516802323, -0.49066363783475003, 2.019018144921668, 0.42845605317777746, 0.19356746771129413, -0.04341165203741116, 0.7481662651052231, 0.5617749601306842, 1.340081071517265, 0.05605161436425056, -0.2322579646831112, 0.6830075505636386, 0.10779129491650383, -0.8976149786346889, 0.7937937097162163, 0.46254669836557877, -0.29880965035768814, 0.29018965266074864, 0.7307755192580443},
    {-0.13772103816253753, -0.7340855201620414, 0.31276220909807717, -0.9463610204861528, -0.328161034288365, 0.2720769276728599, -0.10801438326553618, 0.42665321972492637, -0.3008929008294235, -0.40949681873276966, -1.1346391219456569, -0.3682127736332976, -0.26499538717614657, 0.9687867210570664, -0.7196050609857769, 0.562937993885676, 0.7817958152759233, -1.1701759344923701, -0.6943153516485238, 0.446050889586886, 1.1004843243003641, 0.306444351251356, -0.8915794334432444, -0.6308897760152615, 0.48852930082585067, -0.1339335370182591, -0.3678990304909656, 0.22542210995947215, -0.2696854102351931, 0.08755448212179523, -0.2714069738722158, 1.5256440976584869},
    {-0.835947125610418, 0.08087172348002762, -0.0847716255751611, 0.4541707417159377, -0.312501165938979, -0.9993522141544284, -0.23573388644301102, 0.2682656906313802, 0.5974720023856674, -0.15533686923905762, 0.474853083131578, -0.43106542263545944, 0.2448959893848189, -0.8211243295341959, 0.7581646199446408, -0.34023032317554436, -0.15344159900487941, -0.004135526301423517, 0.08574742949982771, 0.045642468833560025, -0.4416985031092535, -0.5398610760034586, -0.10258524325808266, 0.7601632475456997, 0.17817965190933593, -0.42205635776891703, 1.1786380418975977, -0.5544724343639286, 0.9525652673277032, -0.3025978213311196, -0.5330031987233704, 0.4024471494653677},
    {-0.003766062765244513, 0.9439817198678747, 0.2967782958894911, 1.2441454605508568, 0.41640989407937534, -0.7110268147025622, 0.19878909884817067, -0.22427589986287058, 0.624592359965205, 0.1742340089573858, 1.6242609477301018, -0.40232852476868514, 0.27666492324710873, 0.08899286315288055, 0.7107301395469922, 0.3439124064059782, -0.16041924247782718, 0.8437009610452352, 1.0997328219819749, -0.03164032282172525, -0.6911099714954364, -0.12863542759438273, 0.5222528288029838, 1.0071795175791813, 0.5196418481094548, 0.4751114511225469, 1.6654134878528433, 0.6042026370473589, 0.9842022476140712, 0.14921121392117276, 0.3171954608826611, 0.09530680696878445},
    {-0.6220972848021192, 1.5227108961936469, -0.7134802409402057, 1.0175820515771778, 0.3815658932899169, -0.12100708206399315, 0.34856071510723036, 0.14094488461887378, 1.0887022827419917, 0.7286035486545734, 0.5119230518660021, 0.10439806290200887, 0.42236789453832285, -0.04160861785681433, 0.32548051362912683, 0.7266408872691206, 0.3855489795760215, 0.4217365009270838, 0.30410032704862594, -0.4639453495286919, -0.6600328126561474, -1.3781565389303432, 0.28766595490519875, 0.8578076251073007, -0.17211924157900707, 0.119651346671983, 1.6561490929581195, -0.6601247153114047, 0.37162592619156337, 0.14464369618274778, -0.24816454650178615, -0.7365680108420881},
    {0.3159148200789354, -0.5863038548606768, -0.17983009180640797, 0.30368799633313487, -1.0570721523708089, 0.889457401370913, -0.4393239729050846, -0.22349700576295758, 0.29599017966705493, 0.2874623431043307, -1.159157761480004, 0.4100417939349128, -0.4436154580016985, 0.46992893770140254, -0.3525655776263542, 0.6952486512168009, -0.0009625133764258655, 0.353616652860677, -0.5538646675147032, -0.7549913458886099, -0.3072980136946272, -0.17752182012708034, -0.6403854971746129, -0.27122884938028696, -0.31307926569730016, 0.8899638889100142, -0.9983964205006668, -0.02869373331957191, -0.23356065906138224, 0.24274209602358254, 0.16765293281966673, -0.23195629796800044},
    {0.2664742897189965, 1.331790306884542, 0.3632451921227035, -0.3852121140031666, -0.21856926323232792, 0.23309590923701823, -0.030730957438092826, -0.4148115072327847, 0.14893193765977406, 0.7226485669250673, -0.9787512376800122, -0.1627582546499322, -0.635323031340366, -0.6157242204133405, 0.12381464085305842, 0.19100363161492595, -0.3314591841563506, -0.45598604001463905, -1.0580140281116246, -0.4873377260669378, 0.028259326704059225, 0.017377304942913056, -0.5059729153377727, 0.46969284204823014, -0.45021795235725615, 0.3921934443992843, -1.3282443045346524, -0.28176834325819267, -0.5582356763507191, 0.5383283904305443, 0.009963634472318397, 0.044843405757524234},
    {-0.2259164804337844, 0.6969457036790087, 0.32438716019081126, 0.9312520301162802, 0.2627512932577147, -0.13646789902184403, 1.1367623053380351, 0.3442070463166201, 0.8204355120509624, 0.25000169023273455, 0.9525529562717538, 0.10198910097510586, 0.9911836846020446, 0.4290452021520663, 0.2531579390043572, 0.9285442771577774, 0.3319785850465079, 0.7729568468290474, 0.2486496130660501, 0.18039213895732284, 0.1508535531702024, -0.07304337184426181, 0.7857041585270754, -0.253878289066351, -0.14666441862537166, 0.6597826799296901, 0.3464727324319018, 0.7520205626203282, 1.1108763936435033, 0.12301410433922959, -0.27313720454336954, 0.33930301146092656},
    {-0.8932012871595748, -0.6845009493672648, 0.13095421287286915, 0.11470563168270317, -1.1183930167198235, -0.23655302757415414, -0.948889789464295, -0.7875445174714474, -1.0866653428700588, -1.5594980718281979, -0.42618414613417294, -0.17145176147850283, 0.28485314804792855, 0.04502941828907288, -0.6901031751686544, -0.5156849237660645, -0.6126117231972364, -0.22050017978232897, -0.019893599959071764, -0.7068940824135472, -0.4619963702774786, -0.88707420762611, -0.1431211794679389, -0.8553027791123067, -0.7170015782317571, -0.006840237719543135, -0.04972729219753082, -0.9497778068632706, -1.207348534621116, -0.41542934710241775, -0.23016588250479117, -1.2130841706614168},
    {-0.723397208708382, -0.7238455979993824, -0.3104159339042834, -0.4441058482791383, -1.0961229063363545, 0.006808850837791449, -0.72288546945924, -1.028125020119619, -0.4533919134368228, 0.15553687051188228, -0.6447044289623263, -0.3961515956744045, -0.2833461369658157, -0.6211213052766341, -0.5511014005787774, -0.1084754745817889, -1.240577637280778, -1.0223536214928939, 0.340732690125673, 0.0683596658049978, -0.30857296543097307, 0.29434933257883483, -0.3272331300428021, -0.5143991216990904, -0.42737006539159417, -0.29436400101851523, -0.8125991617553188, -0.8493983651675825, 0.2568874794339739, -0.7730727497193367, -0.8726224818734908, -1.172681443418554},
    {-0.01354429756776136, -0.13798524962155856, -0.1074167735630756, 0.15467777716933, -0.6441537259498624, 0.011652521175442108, 0.882175681174412, -0.43971098507436823, 0.6078336414094841, 0.6158793189430366, 0.7626367744977955, -0.4883479309805694, -0.07880813697128565, 0.0170018826563091, -0.26017423872909595, 0.49794074202764904, -0.3811621526580406, 0.3582618395710361, 0.7987133687542042, 0.37406917312616716, 0.12506065511166548, 0.345721268618286, 0.1080139637229376, 0.2554134911411511, 0.025776170178224006, 0.45501442578960083, -0.6576855747499593, 0.06060008409146511, 0.6412201096598535, -0.42594076778656503, -0.49214031759030935, 0.7807837632324042},
    {-1.0081736609326253, -0.22170938837783652, -0.6629168191847881, 0.48349714035036395, -0.6758579624090133, -0.2728662671707391, 0.553120667924176, 0.07268993855695605, 0.08654223339707859, 0.135503606355298, -0.5426795492929966, -0.0778897748474417, 0.09450689504903659, -0.9914912955534381, 0.019632050176368324, 0.7272317047281072, 0.17448166286326314, 0.15653176819340034, 0.6171860073675812, -0.19165810934424735, -0.026786020657605266, -0.04198272687696569, 0.338334908375262, 0.8208646682591116, -0.1703246010607529, -0.1222823250850477, -0.14707485274890017, -0.9648779101444167, -0.35153399058676443, -1.3741125176273388, -0.8430200623258155, -0.2512662105454498},
    {-0.44955259543820103, -0.21231946798507842, 0.11826803004536561, 0.48622157641521624, 0.9533053118790923, -0.1568275660299824, -0.29043922186209264, 0.35749971355592236, -0.23673210560136193, -0.2644262771403969, 0.2842156666698385, 0.4788389014943558, -0.4279951865879331, -0.02018875996203749, 0.33632440598350855, 0.3073944146148367, 0.6156935184821128, -0.13023579417627884, -0.5276641761031565, 1.1917815994682945, 0.32418204591513494, 0.15253513362673612, 0.13068030290458804, -0.4095667260446802, 0.4054545840020028, -0.23249698814816183, -0.2991167037204224, -0.10058171631509062, 0.2099827549595939, 0.14051549976121283, 0.04540824589364528, -0.44451020884465126},
    {-0.17005642231004717, 0.5112987777351309, -0.15833467602800155, 0.1748531722089117, 0.5471623096987813, -0.3190228728656848, -0.5281616917792891, -0.7127925701896425, -0.1092061163680049, -0.21736165658234816, 0.010770209545098896, -0.5885253367867426, -0.041664636755517015, -0.3427003032564323, -0.6630499507988541, -0.6559445299846571, -0.587859581409171, -1.0132937264479551, -1.6261113896624697, -0.7469586900298142, -1.0781493234175579, -0.8842129805959797, -1.055503814566232, -0.44819295891857436, -0.31190654018520503, 0.6840872730088952, -0.13846277578693308, -0.4175500576837536, 0.016061924121650303, 0.15197905360521233, -0.9647874021059973, 0.39012129423470715},
    {-0.16085463371948858, -1.02868555061795, 0.36267123354700237, -0.6469568373926451, -0.37656314003901636, -0.47622751910409666, -0.16280323945591962, -0.14441069032846568, -0.10104139344777517, -0.8319169352780539, 0.007665159002191041, -0.309558363420519, 0.28528511469361545, -0.3933515812130984, 0.10549765480793317, -0.4087382282785153, 0.06242424737962595, -1.0470578984394205, -0.3099200675419614, -0.4608603223998677, -0.8030027135356085, -0.41765109583011834, -0.06587158056888519, -0.4640784665485535, 0.22481870202895746, 0.46577549566856097, -0.27251715205897264, 0.4421183704312586, -0.5498713802270591, 0.36414163730616733, -0.13451725484638474, 0.5583642703086623},
    {-5.554118223171587, 2.6427859384827666, -5.066915905009339, 2.796764516537107, -0.7540178034801555, -6.023318282325852, 2.312956784747376, -1.5796148764475424, 2.091379929357823, 2.233981340814711, 2.0486202080634834, -1.7835194016790223, 2.7949025852886415, -5.87279384206302, 1.4151593177912596, 1.6175618317641833, -4.671798984387142, 2.118746555124774, 2.4371181602581786, -0.8127193402171318, -5.701933768217609, -6.0800506207071825, 2.7106657490231907, 2.256809926776778, -1.6429332123404048, 0.8999350139802869, 1.4488722812784571, -5.11903445243447, 2.1955238294690185, -5.10547410539279, -5.668995442712155, -1.4435741520248924},
    {-5.494623337424268, 3.788920565658839, -4.998039370152472, 3.5225055852416958, 1.5373465562777406, -5.969489001695418, 3.1082027650040747, 0.8551751492535068, 3.2113332751661883, 3.2993409096111197, 3.187501547440136, 0.7227775713654774, 3.572259514758856, -5.908976493116595, 2.2291115735336064, 2.8875589517166236, -2.051188384090901, 3.071331148975966, 3.455753957337064, 1.2617303815814955, -5.378482518781599, -5.629240721724618, 3.576979026342766, 3.490675339029376, 0.7850024622976538, 1.539376825978513, 2.7307483950349045, -5.327348868922113, 3.5565259508634703, -5.520082622494588, -5.735433205312775, 0.4622291547237663},
    {-2.4168799160154926, 1.61088733136625, -1.9732186810242691, 2.3836962667105395, -2.0492990050769953, -3.1075363987553177, 1.3385412457079595, -2.6291080604253834, 1.5673438071158259, 2.552955403230778, 0.8104114157882081, -2.7199982081760217, 2.1593557423533474, -3.0274779928733118, 1.7980232953797757, 2.4602679284711684, -2.014878459960787, 2.1166294428028762, 2.2772319454920313, -1.288116259491396, -3.0156776051614367, -2.5271778512061176, 2.098092829914349, 2.4171171832532394, -2.7717731773216903, 2.50900152624727, 1.6832621683086766, -2.5473645504390934, 1.0529624530361072, -2.7043059362050266, -2.5714313779801086, -1.5548713468235749},
    {-1.5129538955275794, 1.0396654043468563, -1.547879727569051, 1.798976477126978, -2.451778972160645, -1.5082167909955184, 1.3632606153237938, -2.6274020978976953, 1.5515030690822398, 0.15589745561170057, 0.6297780928457533, -2.0937018750688967, 1.8248174470497966, -1.786662579519948, 0.8924350852500028, 1.2902303142898468, -2.238408437954504, 1.1445026468109616, 1.7376927912315256, -1.9881285701539078, -1.1738022441639346, -1.0803597724691734, 1.5318095782464731, 1.9894271372490038, -2.12474797832902, 0.677017837525881, 2.2031304005515353, -1.720693904185933, 0.14920289673641518, -2.034192925345782, -2.122728621094064, -2.1728171333720203},
    {-1.9572888971987543, 2.280201852926447, -2.225220556963406, 2.0119060215997684, -0.8945483493993153, -2.42749333579985, 1.1269688914564937, -1.665119689660525, 1.4028888801399277, 1.971910921805953, 1.3213733514803565, -0.9707815835632102, 1.6585883360040383, -2.34123061234331, 1.2143785636666362, 1.893695288617933, -1.2628477467934605, 1.42906585778162, 1.9092698598924638, -0.18109893816553174, -2.6487533369007026, -1.7033701997235733, 1.621519639025801, 1.7382651428765974, -1.8550340442792685, 2.222521220546467, 0.5408306107108019, -2.0042042459512093, 1.6270419881656746, -2.602547174778799, -1.8811283431421135, -1.1328739950857472},
    {-2.2494026067059374, 1.67163951384571, -2.8572030836228723, 2.12914323740543, -1.3445506421542468, -2.888819229812161, 1.4592579805432129, -1.875220840045409, 1.4824008847675325, 1.9504682419629205, 1.408650112822611, -1.5466299340977532, 2.048227872766199, -3.161470128336312, -0.3204960342951265, 1.0729461198747179, -2.948486722909721, 1.359860607940774, 1.237195329164283, -0.35031357582289135, -0.6686020991781184, -1.8120768709569925, 1.5812379680250988, 2.0474342103208065, -1.339185331558884, 0.8675963723901351, 0.6136529638354019, -2.6187514284050057, 0.7303109934701117, -2.2589851892112724, -1.8421155009733656, -1.3490704316463562},
    {-1.5673635669319086, 0.03805207321569369, -1.3886190065363981, 0.7326934014728997, -0.5556443426888967, -1.58515772742249, 0.5430939286778683, -0.461157207817511, 1.6419956000613227, 2.2486525812628133, 0.6629690429674755, 0.6248777477713956, 1.4141970192947, -2.2416649359163117, 1.2874868748315669, -0.5433987542391842, -2.618296709638127, 2.0134181738708388, 1.3121349444337946, 0.96154878133243, -1.296105606124889, -0.4444899970249462, 0.9618202805290086, 2.729076677309694, -1.1250789628221565, 0.0891016242761347, 0.8173810199129988, -0.6098402315461866, 1.5486389059176389, -2.0431145840250453, -0.6911063583203033, -0.7081708509623493},
    {-1.526907475058007, -0.6816546496496267, -1.222131980851089, 0.7640625699305289, 0.3357743001147557, -1.6453734967170426, 0.5725270242078644, -0.21729061748473943, 0.7795662700495102, 1.8522764549332487, 0.2116270945315308, 0.061866302418779454, 1.3068930098455498, -2.154145752332583, 0.8304135371900698, 0.3884170866880026, -1.0461990129556782, 1.8063107757314618, 2.018059851732227, 0.5720551477612913, -0.7469312113793136, -1.168288353110353, 1.694787902381134, 2.155000404987238, 0.38065843712055314, -0.8548222892051238, 1.2760071059355609, -1.2614639910440888, 0.9945010268996215, -1.3094327042160745, -0.604473042199618, -2.023349504643592},
    {-3.9740076411855667, 1.1567730701220185, -3.2038741104946573, 2.4233890262853612, 0.7994253283647872, -2.7520643087395578, 2.1855752558949826, 0.3108190789101481, 3.052266832648818, 2.579583336813324, 2.889023320381737, 0.6479805710510992, 2.4416967171929023, -3.168842288999982, 1.1539644791849883, 2.0005138428179525, -0.6425938757168347, 2.525401272072425, 3.5003209657800625, 0.656111715228865, -2.538207447867698, -3.2662918827367986, 3.0468532367417542, 3.5262990939064776, 1.2831587972985936, 0.005472276383781995, 2.0002874068795595, -2.4183156398934185, 3.1001070596228053, -3.046076410535955, -2.731732371598258, -1.1391119822339746},
    {-0.856015674804825, -1.222806479935684, -0.6491264995911781, 1.248631796396141, -1.2671031075907178, -1.3364295470890963, 1.3381296365132684, -0.7373671789995403, 0.9386722311979375, 1.485117588898679, 0.8284033221392505, -0.320674719913335, 0.7999378854168461, 0.29367199430322705, -0.06525561674761272, 0.9581851963274562, 0.11753811094018081, 0.8466603476223888, 1.5517877567431706, -1.2289305286260255, -0.3379441954600355, -1.0331542979183366, 1.235682915510096, 1.3883721454361664, -1.0438981821649918, 0.7291889545345667, 1.0875676507442658, -0.14780852295909166, 1.9412205299114587, -0.08131231263043573, -0.20097711363256068, -1.0236950829722207},
    {-0.3075471637761372, 0.6674934906184493, -0.7278872004861067, 0.7455672033916573, -0.4276338079560686, -1.5630682349578762, 1.3778854905109248, -1.5503514350608192, -0.36531457287270647, 1.0743489544892375, 0.49466306699944096, -0.7540625653478306, 0.8568253183892601, -1.3626078754242987, -0.7755864735851138, 0.210924999724946, -1.662560036935646, -0.5851243379127719, 1.376795246891137, -0.2851080518857494, -1.1926407647564077, -1.152471459522102, 1.6274074137024306, 0.8917292826529118, -0.7837714246467935, -1.4081321722003959, 0.47274908082268946, -1.3893898764621537, -0.14271150091204418, -0.7824825859179642, -1.743741943057202, -0.5508573122717086},
    {-0.06940938998226621, -0.2233041608092302, -2.0343794639517805, 1.2098681093017623, -1.1271190379112803, -0.2116461329651722, 1.5255272897015566, -1.0883131873728145, 1.3145015610746353, -0.3901583570710965, 1.3653394321654575, -1.1149343033404377, 1.1062132268671847, 0.12074601245495416, -0.21413983374560328, 0.2554808222837384, 0.8852500896070516, -0.39266737422098313, 0.26251621546235476, -0.5827741426104688, -0.8775746979100992, -1.0491240938870063, 0.07081859449819138, 0.1466647285238145, -0.6652245950888171, 1.599821587958601, 0.062477571784967795, -0.5726524134823089, -0.09106951440083283, -1.3992261667783976, -0.8520990388791727, 1.3851999559409693},
    {-0.6417668269701964, -0.6481104557324692, -2.4384908695340997, 1.096057729818919, -0.7124146427607604, -1.4218169776082685, 0.6727620884763669, 0.23195808609233154, 1.1685707956065927, 2.3528483702316896, 1.4772056535342686, -0.3416974274598648, 0.41630282952654557, -2.4235252696642773, -0.5370231866646498, -0.4986129369568301, -2.2255770818564193, 0.674373949376272, 1.441810999703198, -0.5557252047874222, -1.0697692154693652, -1.7640734453547933, 1.6809024360129405, 2.0583864620506778, -0.3126559783450413, -0.2792441705886428, 1.1537339240292566, -1.2706941877267794, -0.005933778750038698, -0.4521681696072059, -0.7925711800148865, -0.9394829831794871},
    {-1.1577752200392049, 0.3713052462036377, -1.6635039154844575, -0.3218045675446588, 0.4445375482164137, -1.6674713419127056, 0.1635702456266714, -1.2215165932418308, 0.7991404251748958, -1.370084333297987, 0.7931523461791714, -0.6757190656530362, -1.370349507563343, -1.2377287893776583, -0.5103707296433759, 0.15726869898307355, -0.19902981252908933, -0.44083196300131056, 0.732793342757929, -0.898248597756952, -1.361182008794147, -1.203409490455834, -1.002176254982019, 0.4052615465986123, -0.9167743275089874, 0.3190949956055313, -0.1822432790986768, -1.6718718931809515, 0.011205043341402623, -0.6688098301930518, -0.6411891224269236, -1.1225626548414935},
    {-1.0482116903508956, -1.4498358789297516, -0.04934182592155351, 0.5404899504995673, -0.17722497972285978, -0.3727515592992368, -0.041993790537068025, -0.7239745658766835, 0.9422961310995714, 0.3798282063445459, -1.04993274663715, 0.5944275595692031, -0.042276571060688946, -1.327746981153544, -0.41736030015115927, 1.3936488348488052, -0.7628762195269814, -0.11286781228100473, 1.9291841148314535, -1.4177871406310487, -0.5330549692039535, -0.1606299499349503, 1.29453718292164, 1.2685972398946652, 0.05403494054576208, 0.869250615331787, 1.2148790393330515, -1.198539657195243, 0.7923043811661128, -0.17961808096471457, -0.615053052719425, -0.5487219467298952},
    {-1.2293646225105543, 2.170908249469727, -1.7586524519842632, 1.6657662670910989, 0.35191914763296794, -2.587340757364241, 2.2312157407772855, 0.12624418119238004, 2.0467770127154634, 1.4028318747593462, 1.6644626036448869, 0.5376517547075618, 1.9459225180532576, -1.7043627633885192, 0.8166131827111395, 0.7330175855386871, -0.5517599174657859, 1.9940859336047339, 1.8737543191125132, 0.3380865630808388, -0.9636520660374458, -2.6978403568032343, 2.38531126366054, 2.2506471934772296, 0.2985851490380521, 1.2572410287731535, 1.8624944270265311, -1.8597019910531003, 1.2154205415053831, -1.2794920446266063, -0.8663778966790089, 1.975825782314319},
    {-1.6298006518207162, 1.634208432843509, -1.1681459468487678, 0.8450083848600964, 0.589163515308869, -1.8657276040248956, 1.3727931241760458, -0.26017970639410243, 1.0123173554015135, 0.7322595778659139, -0.015566013747990217, -0.04174989796823544, 0.38481802699573103, -1.4284144926403575, -0.24415260990452617, 2.5183449209995254, -0.015497465543117954, -0.09610965931803414, 1.0919454320451156, -0.22825703663605887, -0.689956729223813, -0.8587564293062098, 0.25075136574735163, 0.2883034857109833, 0.003295102581602967, 1.3223592350853977, 0.7304818524258299, -1.9124133786483923, 1.3295113438129962, -2.035426186295657, -2.272519101045493, 1.5772907299643075},
    {-1.1719751919246097, -0.11758279824299313, -0.9208464761885006, 0.3304082201896916, -0.6633680896560226, -1.3160187077645418, 0.19417327386899036, -0.779528495705038, -0.07199030174598683, -0.3362076136341926, -0.37838094439779646, -0.30903747253171776, 0.33651512825048124, -0.9411459250622121, 0.002440763930119044, 1.7052456964544849, -0.84736879768701, -0.914237768706815, 0.6373143907826865, -1.3660125381813286, -0.8006403603392857, -0.6704500054089737, 0.6172785437694289, -0.8877267621048245, -0.15219044557561534, 0.5196528910666387, 2.0195485705133804, -1.160463103658151, 1.3338321952135608, -1.610665841145102, -2.0791607170421718, -0.3634335698393262},
    {-0.23713998878417786, 0.860649500610115, -0.9260326302082768, 0.2381632527206516, -0.9500918852254315, -0.7876532510356818, 0.7861994460918957, -1.017199219507545, 0.3251601436748605, 0.4918420386265907, 1.299324135224902, -0.7396952799131898, 0.05532666451081838, -1.1420029419103175, 0.041746580879389414, 0.7534489299179183, -0.7827926440389569, 0.05966633749354668, 0.4169584296854067, -0.9029426143926386, -0.9402111607725923, -0.8043458761506812, 0.42634502264992696, 0.8860113723677561, -0.8128202057894651, -0.1749975242032312, 1.8321353539135499, -1.0794202194619547, 1.331670862880575, -0.5057749699357817, -1.36979360161883, -0.7480339456938905},
    {-1.0721760442172588, 0.1976484591823075, -0.7931876646021611, 0.6417013195281198, -1.5606387376789734, -1.3190654030934847, 1.0216497826352167, -0.7757916710051103, -0.10662758403487044, 0.3371694055124393, -0.8750591789411736, 0.15550895165999817, -0.15910556822728986, -1.4253488296569847, -1.4450924474443037, 1.4380499205595652, 0.690032706584938, -0.4021069342131101, 1.4066443887628841, -0.24726259354563657, -1.5331140834115364, -1.1596032238461818, 0.37662646678879425, 1.1643665268349421, -0.6776034442069857, 1.386809697249607, 0.7510972032261612, -1.0739038561518184, 0.3592095438476809, -1.417633681856882, -1.069858185901564, -0.5582378885382213},
    {-0.5999484737261819, 1.3868050362371216, -1.3812594756561747, 0.7464652581373061, -0.9953234386541152, -0.41453907646200955, 0.03877233078212738, -1.0444852369568127, 1.299874808189866, 0.1283954938250957, -0.37243051696226487, -0.9034467221747039, 0.7475015133018599, -0.05233153882678013, -0.020520472524381956, 0.5902999119691498, 0.6578401885357311, -0.7345121711781866, 1.155952216834448, -0.9107337524723222, -0.664398016325872, -0.16209145614896048, 0.9825029865437553, 0.2619630293058945, -0.5600908619049505, 2.47896722383524, 1.1806008747919858, -1.0128786783664465, -1.0045971956739221, -1.5328294048217428, -1.1013367142689507, 0.09940983033006941},
    {0.42415559930147484, 1.1484552593830373, -0.7140410810482852, 0.6501928472229657, 0.5453186131924866, -0.09303618248118871, 1.1460326551043614, -0.030161374922528343, 0.5507628700178407, 0.9810403599305232, 1.8618826281325902, 0.10046839440953359, 1.8529793394948002, 0.09280962732608106, -0.34229831160213264, 0.6188850709136805, 0.7857809536044771, 0.4394223294914692, 1.736506994667608, -0.5177905774527252, 0.022772012984049364, -1.4127223938227655, 1.5906903366603873, 1.0655213375244341, -1.2473636195273787, 1.1324684762816752, 1.4824771295216983, 0.49295758746090124, 0.006526844274747848, -0.7417646100437623, -0.6765675480735573, 0.3201782036091187},
    {-0.983524647541448, -0.19968676590966725, -0.6782850901031113, 1.2769499812373215, 0.22478909287259832, -0.9821476328636516, 0.5890553145236087, 0.1477323507759205, -0.1541281067563974, 0.6369507689714737, 0.8486196458603262, 0.5022385297138274, 0.01568954856180363, -0.8974021838397563, -0.1646608106586711, 0.6842355604271475, -0.2295959357066496, 0.1460588686442617, 1.1357837728630853, 0.11199580967777747, -0.6544700548053404, -1.052312844703512, 1.348296289239192, 0.11008515079154746, -0.019937663199840493, 1.2872436815830748, 1.9512757064925212, -0.5364694930518932, 1.5976434913005864, -1.2583219818206617, -1.4143297687412175, -0.04557351831168954},
    {-0.7945543504153191, 0.5101588198540821, -1.3161906659598621, 0.9212421290751835, -0.24050822044671977, -1.1198841981780292, -0.5130496438987564, -0.3188498320474537, 0.20586112522608885, -0.5691507856537572, 0.8686849308603758, -0.2751277472580165, -0.5156253463044426, -0.6718431462383911, -1.4028523323395745, -0.15573665257370414, 0.02248620180785856, 1.3940402448185034, 1.5447161149516535, -0.5056979945684917, -1.553012902629479, -0.5596607027358713, 0.33484884363011647, 0.20722672608540602, -0.2589890640240157, -0.04176748709602772, 1.4929810575678606, 0.813806981400585, 2.142930672402806, -1.2031421092774535, -0.7116872622023453, 0.9621400570418206},
    {-1.5017615135030669, -0.42551911993314484, -1.80148554921171, -0.7062316027284452, 0.46482535251597273, -2.03089463127134, 0.2318456322061456, -0.8550959364924785, 0.5143724002783899, 0.005626671320297384, -0.6409178518442394, 0.047222113885617076, -0.6289285055093455, -1.7137904623454145, -1.1053046787428744, -0.44290439828583344, -1.8578255459447008, -0.7723457034061328, -0.350577576515387, 0.09047464813752674, -1.3425742501056614, -1.5710556079709035, 0.17784385380909215, 0.7160865218393695, -0.3166453425379528, 0.25917056260752125, -0.293511672147274, -1.9313360532606942, 1.5880801011920311, -1.8353189705241366, -0.7918495063081513, -1.031159066733936},
    {-0.4543198631280839, -0.07642753262842025, -1.1758562976159599, 0.5922594876400847, -0.5065009906692933, 0.7027585846155956, -0.23838867369221636, 0.821182025927901, 0.9636962753834997, -0.275203722032604, 0.3841456555167583, -0.7749703335660412, 0.07686400388724064, -0.027888036580957884, -0.5599068609680384, -1.8527250617365418, -0.21167412673388944, -0.172254856357651, 0.7838785773918333, -0.24182700930344836, 1.116174354377319, -0.5729493518885296, 0.06839253244303602, 0.6421226703887373, -0.030700481706408655, -0.7089599663244195, 0.08961886603386388, 0.4604773669486757, -0.3154627783622505, -0.05655045871941828, -0.8636429256657059, 1.200779469911182},
    {-1.4572891050310928, -1.2483985803067021, -1.986302803729195, 0.11001823398610663, 0.5287384933661098, -1.5018041563092288, 0.9876061973695057, -0.3271679243487373, 0.4837231583683325, 1.3557389133022952, 0.4356019154321669, -0.9902589331774523, 1.0736043493131655, -2.433890335169466, 0.3065951873862559, 2.0094049766769615, -0.6210155794950214, 1.5272742535550112, 0.9780722747868418, -0.5869755845386697, -0.5461802948027736, -1.4673655496136102, 1.134281041307423, 1.1084938304680674, -0.8921001134338752, 0.25584385914527835, 0.9735958214443747, -1.8788735256790858, 2.18110520351898, -1.6370666923064094, -1.338263730354177, -0.6672102980941904},
    {-1.3458739954866132, 0.9915620662827871, -0.6812605945861829, 0.5896795307247467, 0.15376255292559082, -1.335957267026036, 0.6525507560226543, 0.15796411137267682, 0.5825883620089098, -0.36176358413383847, 1.5755443235217323, 0.7815895984259319, 0.8823363867551687, -1.2677339302356885, 0.5789375561653373, 1.6536659329906354, 0.4212809228838418, 0.7884078312054298, 1.1678859896540723, 0.45418749264177194, -1.4189875317286695, -1.3755747486911454, 1.2025140430907704, 0.7441232558002205, 0.820715166022301, -0.5648920097830581, -0.39265468383451274, -1.2665769255042025, 1.3174862968547805, -1.260529080061792, -1.5759412244033724, 0.7928962436593039},
    {-1.0346275340464708, 1.9314144395354422, -2.2096183972842125, 1.6087053302747305, 1.3629455117074245, -1.0293203478517468, 2.014730776913231, 1.32733287757458, 2.0665448059149067, 1.371833841507825, 0.052544105921645726, 0.42110958464542353, 0.5113509112910638, -1.804096800179707, 0.49695360284739887, 0.7408728690660512, -0.48493561274011926, 0.8820238455056679, 1.2243782886610666, -0.08203536469639157, -0.9409087993498346, -1.2268162734690393, 1.2576163013335817, 1.5471088612030859, 0.10949502706079521, 0.3556216922188705, 1.6603372333676187, -1.5445443952632258, 1.126495797333166, -1.358769980871179, -0.6813759106547548, -0.15067951605401808},
    {-1.0683928960023579, -0.313389181691393, -1.8684033435393903, 0.40498661150300536, -0.030223343489796925, -0.3108025725137504, 1.2879899868314293, 0.7554453893044422, 1.749919816879794, 0.13467833895707187, 2.0602936349261496, 0.2218931352130864, 2.103493100876164, -0.8112319471521318, 0.31450734041414563, 0.9197945017902341, -0.20567157496646193, 1.2805993984789803, 0.9106410821636577, -1.0103055901855136, -0.4389597237912965, -1.7681519698378885, 1.732675487660798, 1.9124394528047577, 0.6416643617601632, -0.9733834675024485, 1.7234377781203645, -1.4504060771524006, -1.009290881437571, -1.0156051478990644, -0.914306259436804, 0.07780147918400267}
};

static const float b1[32] = {7.955617865385834, 7.837541142777728, 7.906658116380413, 7.7900171558935, 7.484505405336775, 7.798326123626545, 7.545944987463133, 7.876402045750428, 7.752567395811181, 7.564080125126431, 7.736052314012433, 7.7625106943442335, 7.71312303084247, 7.843846394462263, 7.407646700262691, 7.5629290573881365, 7.922854703246573, 7.853631629075789, 7.646329991257024, 7.655790870531687, 7.937420841315529, 7.859777969736393, 7.838225075551512, 7.597201624354616, 7.733114342808115, 7.90232036645388, 7.669532763093492, 7.815440073292864, 7.775755574722548, 7.876310119029446, 7.947257704568107, 7.991493362708955};

static const float w2[32][16] = {
    {7.147816740373049, 7.258467499649232, 7.041310920260111, 6.393100942970772, 6.992584950355881, 5.807982932164302, 6.953674103809879, 6.043062218721578, 6.590101474899714, 7.387749906341841, 6.6474560494712716, 7.355745713572514, 6.9899553982669, 6.48363686254128, 6.373790131169328, 7.040314059954138},
    {6.697936618466444, 6.265804083528002, 6.5472634971036, 6.458687661688802, 6.2158226205131095, 5.221590664395788, 6.707555412449699, 6.187722334058437, 6.227236146967185, 6.640374011780069, 6.280387896682912, 6.316508187915405, 6.224923123383899, 6.393533246191769, 6.3853973442026755, 6.344308257593037},
    {6.760417153355638, 7.2865244573243615, 7.115763350342942, 6.500084602889564, 6.4732671442255665, 6.066235825563043, 7.067828492875827, 6.686156126012278, 7.000261094639812, 7.003677095676951, 7.355883521535947, 6.784735450940135, 6.6403067386953465, 6.936952721738376, 7.129899307524006, 6.780922110679671},
    {6.299780683804354, 6.502793520769263, 6.707355632152707, 6.338879678758282, 6.398781183148402, 5.541366969835442, 6.98583444633851, 6.0703895097227845, 6.9417066240958665, 6.521763541987798, 6.153495851722902, 6.39687877838377, 6.694031475188592, 6.231172936876523, 6.1067740453696615, 5.961572572339129},
    {6.520941338259107, 6.816075702099191, 6.637603566478673, 6.670967412606142, 7.094965381306985, 6.199483252302942, 6.7531020208224755, 6.700869389759256, 7.139807977483205, 6.450532255855961, 6.952922936012552, 6.456119657930349, 6.360774951407281, 6.398622891585388, 6.74415101767651, 6.426965998433341},
    {6.905177067669333, 7.194594875752161, 7.471449514543697, 6.898634496847038, 6.607230840991205, 6.017054701299602, 7.351104270176148, 6.749282408907829, 6.404970467518569, 6.967197081217246, 7.138372885472823, 6.776172231446344, 6.979399317321345, 6.658863970093637, 6.78181083079839, 6.843976843758511},
    {6.431417762228878, 6.300630359585676, 6.636883413028609, 6.662290253120061, 6.422860362223775, 6.053897699855211, 6.668030733444156, 6.278983805328123, 6.752757561543735, 6.35877001585148, 5.864885854249088, 6.251946311363024, 6.673907570966779, 6.273421500354341, 6.691008343111278, 6.635129026399006},
    {6.926986497557841, 6.798137596750479, 7.122349380398601, 6.925775442581182, 7.3207390399112215, 5.93486499572083, 6.975295752069397, 6.5724095029128895, 7.097515460188081, 7.3974732837112755, 7.019013183949558, 6.841083897209788, 6.760218347626246, 6.478350914213855, 6.640824671967839, 6.798196925459533},
    {6.507905812047623, 6.404101458176582, 6.718115949957213, 6.6918872080030845, 6.90752941692511, 5.9529871904703775, 6.384486300497485, 6.5123054345002584, 6.587649274451021, 6.573850045848763, 6.0705189035798055, 6.4418088341070225, 6.1649002145923655, 6.376999041319971, 6.429107667112631, 6.119859433832235},
    {6.389247858231719, 6.489571497690584, 6.712143426657786, 6.692468563861575, 6.348474561588491, 5.665784412551124, 6.635894076492032, 6.479628711756316, 6.548273663249104, 6.572342592799094, 6.5545947481186, 6.179994011747128, 6.838436937487602, 6.614234511048042, 6.928858695205936, 6.738216608356937},
    {6.700856289207999, 6.371210442708339, 6.913447827822183, 6.652745465351883, 6.506313524092243, 5.670661657801585, 6.631019041314714, 6.231338328869303, 6.47878213268528, 6.262299012065618, 6.740449456465843, 5.957331251394533, 6.560090723962921, 6.841428059202716, 7.136246774441658, 6.426165643970473},
    {7.050872193173022, 6.916890024414676, 7.30014416465091, 6.992750612287476, 7.101490259753079, 6.130241929422814, 7.161748349657374, 6.9400568721001346, 7.017113460033336, 6.866192721841294, 6.831918315261772, 6.797656681144071, 6.9780440043920375, 7.39887609375513, 7.207584307949231, 7.11535618673662},
    {6.50900452243388, 6.104963109137435, 6.730340652461782, 6.23908940243482, 6.31429480549205, 5.819430080818435, 6.666137540277528, 6.048793161031664, 6.58207374038695, 6.601371246856368, 6.215366526897084, 6.720325025657283, 6.779096283722797, 6.390281429250463, 6.266461175357609, 6.367703760370025},
    {6.750441601784325, 7.4970241463412215, 7.319387176735666, 6.816420346064162, 6.751961088880332, 5.8831970599511685, 6.7979344812713265, 6.453354054513078, 6.480749793515652, 7.026275619718031, 7.300933816382532, 6.347372338715394, 6.707396244721335, 6.550463076053466, 7.02345787273519, 6.780512749501376},
    {6.350722275582972, 6.670056353919906, 6.553311561631153, 7.015407996607107, 6.8324894148029305, 5.806249441905279, 6.826060194806443, 6.172870066868943, 7.077320284364895, 6.131941975318645, 6.676955829444681, 6.477506614737598, 7.015551535157457, 6.4891459358418375, 7.155823257635377, 6.722864378964943},
    {6.5767788324911285, 6.404012359956735, 6.469605263371203, 6.43457760542694, 6.544048544691363, 6.51953070564939, 6.511740527789236, 6.32129449022657, 6.384974297794357, 6.179185393369333, 7.046191454656664, 6.822902313486076, 6.70700090275552, 6.353868210136374, 6.6100909346481975, 6.356506173913853},
    {7.182139480529456, 6.765882382137362, 6.95328084783163, 6.963182410360113, 6.993614595534351, 6.0299234693633315, 7.247015269672814, 6.782328724402371, 6.311337481133393, 7.2233709151290295, 7.030549881183653, 7.097167840016789, 6.748763063026301, 7.46179813584358, 7.0050841691279135, 7.075516347930306},
    {6.647662988068153, 6.559474932332531, 6.68365713882872, 6.435390504806311, 6.695154250645272, 5.950496749147185, 6.160143027825637, 6.249945259067852, 6.313957835437059, 6.279861372228968, 6.352733165131431, 6.042696072830132, 6.5496438857005765, 6.40329794307139, 6.54841463737151, 6.110580248858907},
    {6.192029329513224, 6.324811621252124, 6.6516067639746534, 6.418929402378695, 6.714267217658774, 5.788225420451121, 6.719207183082592, 6.0404667350239025, 6.209735166137971, 6.454831343445024, 6.854596940423634, 6.348477458459644, 6.41224743722685, 6.2725611925264815, 6.0139151551505075, 6.218675675233757},
    {6.915501883257598, 6.835022761820791, 7.278853828373085, 7.266503201185733, 6.75040457444308, 6.114076857132508, 6.90771916624571, 6.678156674986662, 7.182510758562945, 6.415736476848163, 7.022063580439399, 6.521463720750169, 7.007965705214536, 6.879638677138713, 7.062807285337346, 6.442201206970506},
    {6.961477868398724, 7.383837273387277, 7.3145249747196015, 6.635540235132459, 6.463219839979745, 5.527124518526455, 7.072302460055862, 6.1548917852776714, 6.680930813990809, 6.94634673898165, 6.795240751797543, 6.7440417632264955, 6.779950382844277, 6.7710033143199215, 6.552055682538734, 6.804781313809792},
    {7.042598707496722, 6.570303932507219, 7.345527893926804, 6.766215534114495, 6.455048286204025, 5.853226389143578, 7.099798776050954, 6.40243147609084, 6.7312310473340435, 7.2143642410609425, 7.173706357932389, 6.849491847214956, 6.726088574535654, 7.402778292236453, 7.0162245876608225, 6.945994374094324},
    {6.585007611311824, 6.381364488429303, 6.667937558003606, 6.538971357839497, 6.784819472262828, 5.791239192823807, 6.642841838509995, 6.127957489894538, 6.311414622111044, 6.854456316607708, 6.427690353482411, 6.359192926701389, 6.613601434910908, 6.526042307582345, 6.386732013616006, 6.331923715259001},
    {6.31374931427657, 6.275504544660378, 6.621239100435432, 6.282632974432202, 6.3306446794733455, 5.579072044634889, 6.775221788441199, 6.604849184888327, 6.744316164151957, 6.871063501299662, 7.17401241485535, 7.024237655842362, 6.488714449502683, 6.322322394250566, 6.835479503880412, 6.520110416389608},
    {6.911644054475481, 7.286849176941699, 6.670731841586356, 7.054732631275668, 6.8165642789132, 5.569867876384075, 6.858736213820791, 6.626377539155026, 7.260199297426923, 6.976036942103666, 6.791605965465376, 6.8468607667405115, 7.091388988658212, 6.650187643866497, 6.62027704123225, 7.238648039315847},
    {7.202356082750159, 6.7693629135614835, 7.062404841300862, 6.588703075297642, 6.704725189464929, 6.3122993151046805, 6.557504990792403, 6.839697846695527, 5.890079785859478, 6.906491434484176, 7.110388272615035, 6.732970824618175, 7.081233295929023, 6.5426332525191455, 6.794348829599172, 6.677259883517502},
    {6.749417189904345, 6.2889783534304335, 7.129132190836299, 7.015920585921683, 6.972400992194429, 6.1355955770520865, 6.354142910221301, 6.287064820673437, 6.620707604602016, 6.73388745892521, 6.537394180292278, 6.15359302653007, 7.240570570618801, 6.989556638670173, 6.898388824513047, 7.000485397230425},
    {7.1897563649708935, 7.0871829723695, 6.798693210614366, 6.862371959621594, 6.506585508428321, 5.987649810974846, 7.047234744611028, 6.924756592706409, 7.341830119688111, 6.97964437603978, 6.795341207466896, 6.876046106019256, 6.832779702285375, 6.83239582014917, 7.365013755480734, 6.979104613547213},
    {6.533399823228994, 6.408616546947357, 6.573950450745476, 6.2645559585366914, 6.1430358138929995, 5.560686097714442, 6.640596244453707, 5.916765599873476, 6.299099405915281, 6.033929976546232, 6.520476973713706, 6.5642038147458805, 6.635900391348024, 6.30258311608903, 6.516294125762541, 6.349365229442034},
    {7.057316696690444, 6.967888851172158, 6.905360784777037, 6.774650849817133, 6.678377511318095, 5.501141633463717, 7.178607967709346, 6.575666484106626, 6.631719171949385, 6.698316543511146, 6.7085074461149405, 6.941237725219726, 6.484408831203224, 6.754864655676383, 7.033327161569239, 6.4442870244332005},
    {6.9952887092825735, 7.009738402391676, 7.227924412322707, 6.806451913349038, 6.93591437747463, 5.802313127345312, 7.172876545376394, 6.44652200030318, 6.877574303206798, 6.804846400635776, 7.002695592191524, 6.571068578027188, 6.552470004157363, 6.469004128978297, 6.55828854443041, 7.141391725171334},
    {6.996410905111361, 6.814572149464945, 7.372751853867814, 6.330690533808576, 6.896666568046852, 5.825841629452898, 7.221717817087253, 6.581990262971316, 6.85059223016461, 6.617972899108599, 7.365739269577819, 6.480702422562553, 6.5004856789658305, 6.892379020887792, 6.689836786585183, 6.576230201730127}
};

static const float b2[16] = {6.633224946777107, 6.561579093054181, 6.591674678011418, 6.599352803964507, 6.759548621648733, 6.7193320814209345, 6.694367499306359, 6.7923119103400875, 6.627328029016763, 6.5822474109506794, 6.720467839580165, 6.733651017026551, 6.736184300599122, 6.553811459980215, 6.634745166966834, 6.73786276603536};

static const float w3[16][12] = {
    {-4.746106750381844, -5.186140107137949, -4.808287940487831, -4.864805965558834, -5.043648694459617, -4.738124887810617, -5.3811945323245505, -4.574394060248721, -4.393752078028525, -5.78546362375932, -4.851166514336744, -4.617991023489516},
    {-4.749651677462324, -5.322179781069584, -4.846464065629092, -5.163647123223721, -4.721498698671504, -5.420876719149353, -4.172157136158402, -4.923851748483557, -4.986472415379705, -5.473830085419183, -5.343488802369841, -5.061084986531027},
    {-4.779365675576668, -5.163350677646276, -4.76635643332279, -4.986402581611758, -4.58625930518021, -4.942896018867036, -4.829958460736659, -5.021258403284369, -5.501985384391486, -4.319106122110857, -4.159907457378455, -4.744391323707561},
    {-4.618143826271447, -4.6379368330638115, -4.829523237233965, -4.76883726700255, -4.54558507971775, -4.385072078179085, -5.09627977233588, -5.2972585119722035, -4.761545019603964, -4.215642181038804, -4.197194701089048, -4.927319648120835},
    {-5.349646428257317, -4.76699001454304, -4.36329217629144, -4.771946209236521, -4.857685867743359, -5.422811110016876, -4.833314008926659, -4.602511027024343, -5.463080752679851, -4.937977724821298, -5.484483906149169, -5.417816742383281},
    {-4.81925480400919, -4.445542876792968, -4.558400294901709, -4.187337760172041, -4.531761869406534, -4.4397841090434085, -3.9450135784161704, -3.789419236764872, -3.830357361695458, -4.088977614907501, -4.278778529891501, -3.9675926476288175},
    {-4.556755346284057, -4.8586746483358505, -5.319376793193427, -4.855015436682655, -5.086862639273547, -5.17533238725125, -4.934141670298412, -4.552520670876419, -4.872443941148599, -4.620616476167307, -4.2906646019095325, -5.274408313998839},
    {-4.718717619899838, -4.399244621550834, -4.6820632011830305, -5.089410221848437, -5.251502276978498, -4.600478189587237, -4.801110126568033, -4.5592465927831825, -4.6697445225040575, -4.285605565262042, -4.943543357628939, -4.638605726473706},
    {-5.7240172975652355, -4.724141864230184, -4.008454648780309, -4.610653514193423, -4.931126482328953, -4.181847621443552, -4.7334828168158225, -5.057332589615117, -4.275228546591601, -4.5345354939743165, -5.367705592093451, -5.288309179293777},
    {-5.274072305932107, -4.76433758557566, -5.135921497960219, -4.973610566130967, -4.7354053740717115, -4.612626233209304, -4.735882903635852, -5.2626366390142625, -4.9324821127238305, -5.9661215915234065, -4.838043330831919, -4.21606355394365},
    {-4.7089321644360975, -4.606633954874548, -4.840009435537169, -4.911355106227584, -4.249479444533034, -4.892860120518844, -5.591921136140193, -4.571685921139926, -5.280979504931308, -4.677473099732113, -5.011536823710531, -5.386350618481525},
    {-4.884043606704474, -4.710919711587965, -4.5825713863979765, -4.573562434705203, -4.793083147149438, -4.203364919628713, -4.691067949110755, -4.916376940792263, -5.055667945330016, -5.25843329981747, -4.499619734540088, -4.464468893576785},
    {-4.2472613926037655, -4.816488322124518, -4.928936647669249, -4.223026320177374, -4.526366638279465, -5.3430056980947525, -4.938714235223049, -4.753603296338431, -5.2602625916183605, -5.218158387782162, -4.515530539668403, -5.572979354359332},
    {-5.338706180986461, -5.20557590453446, -4.583518349201614, -5.406032723700286, -5.369687317555683, -4.7515789970528415, -4.8456212032010955, -5.6662908828366705, -4.890597590185752, -4.904169120483874, -4.609235215533953, -4.05976702161468},
    {-4.345998095042615, -4.602912613225748, -5.391140380447033, -4.642987541279504, -4.924540497548349, -5.399224816467334, -4.796599990593825, -5.037280229159478, -4.59578860019554, -4.445471417730144, -5.360529115659812, -4.751605657997012},
    {-4.605693236900293, -5.142512216870079, -5.697686001367093, -5.338415505903462, -5.070659483987118, -4.72176398381983, -4.840592240440483, -4.659121574316205, -4.421249915700436, -4.551369086231134, -5.540159726180262, -4.845537836089351}
};

static const float b3[12] = {-3.3296439458534155, -3.1941489795410805, -2.568966477559612, -2.9678760753412434, -2.9334200331401568, -2.9958380559923157, -2.6941712676903533, -1.7229676404635939, -2.984190676030287, -2.3799839346400415, -1.4742334897487095, -2.1181208944321916};

    // Input Layer 
    float z1[32];
    for (int i = 0; i < 32; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[16];
    for (int i = 0; i < 16; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 32; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Output Layer
    float z3[12];
    for (int k = 0; k < 12; k++)
    {
        z3[k] = b3[k];
        for (int j = 0; j < 16; j++)
        {
            z3[k] += z2[j] * w3[j][k];
        }
    }
    softmax(z3, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
