#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][32] = {
    {0.7227751980742483, -4.1149756639601005, -5.028248903785436, 2.9343056143862434, -5.346941741410415, 2.3723223752303206, -3.7789067215252086, 2.551307523966533, -4.871337659503922, 2.3005465031802346, 1.8251506837348852, 2.232687050639183, -3.5033568255168204, 1.918501320047174, -2.8171463035173607, -4.733813209784959, 2.9447797654334646, -4.563660883948048, -4.46305194111954, -3.034430117046318, -4.954533659936543, -4.407979247476772, 2.96194610930611, 0.840189420731581, -1.66290000106262, -4.468886701951018, -4.264326746962445, -2.9168974384865978, -4.455854808191048, -5.284072879831465, -3.756304143431561, 2.4856845401449683},
    {0.7665711046470599, 2.7876872773116856, 1.5291848489030682, -2.7010985875202675, 1.6800847010943993, -1.3952169678181923, 0.05879271338887675, -3.9046464995389076, 1.6272096417121387, -1.6145699050086262, -1.5228853636015662, -2.290005021095511, 2.6950147374941564, -2.8082482356889686, 2.2812512524515984, 2.6308859850240243, -0.7084564114057413, -0.06088801588134605, 0.3869144135159794, 0.6470586708515549, 1.9795868594127246, 1.4757810575105215, -3.8326425704283045, -3.0946625240472443, -0.2241439948876133, -0.7030217535730902, 1.839558760782361, -0.716317850706646, 0.206357247367911, -0.4648158213654742, 2.3067717837174704, -2.9254817449720063},
    {-2.9766961648772656, 4.5501382743506555, 3.2676962441243753, 2.624070665102737, 3.106610861054498, 4.337408400176642, 1.9880104300418797, 1.9451568678397912, 3.4872530857819517, 4.2273029563929025, 3.1334454450392584, 1.8049415437884664, 3.732979935444233, -0.5149802985670217, 5.581569977878938, 3.257290002349442, 3.231407367792211, 3.9193047209712724, 3.8598446338718446, 3.073847576613904, 4.060756833135117, 4.171414660020893, 1.2100391512543625, -0.8258598952259995, 3.257231764502423, 3.0200370520906112, 4.622823773147757, 2.527352708976347, 2.7416009311649616, 2.6588942323077935, 4.490547189138262, 3.2531223690671056},
    {-4.900157196847591, 0.6235255639388809, 3.347896302212774, 4.200603754206539, 1.1842704011086644, 4.810697419495264, 3.5534508851441005, 3.8520435916607503, 2.5640519784960323, 4.4737981876671995, 2.427271836971272, 3.816684389751719, 0.7355679996061981, 2.049370696016324, 3.3599222634706125, 2.9192742565546315, 2.3448669998314915, 4.077084264717801, 4.107327407448161, 4.292438028684657, 2.4679485550298907, 2.5099757922486066, 3.2864606809780796, 2.3023104230498657, 2.676179425957177, 3.937706955041728, 4.147912926585893, 4.303193516349069, 2.0774089110388956, 3.6141777674936826, 3.520287359904646, 3.5397922133743136},
    {-2.9102440692628164, 4.6366976720782125, 3.8069177729163375, 1.4018367302641537, 4.214984011992039, 2.435452749499474, 2.7491294596399896, 1.4873562187926592, 4.150200450725725, 3.7152907051366086, 2.7406406785045, 1.5871312273281224, 3.782176355733183, 1.031325551489239, 4.8352503287141815, 3.566751570617264, 1.4577709786508428, 3.953147184522309, 4.092838778137349, 2.4386964787823042, 4.013684738999958, 3.7568663659768364, 1.1553247027979825, 1.323442347111478, 3.7098753392309267, 4.5480566112004075, 3.412839798621848, 2.4613065627134434, 3.511218621371276, 4.070266743294354, 2.814368941842832, 2.8315056874040896},
    {1.5370130914991187, 5.090125672616988, 6.1158444074730385, 3.152112727215036, 5.834558554747495, 3.466886047287548, 6.095211636780302, 4.4855184709443465, 6.307358906082086, 5.144832085883722, 6.0327736407720085, 3.5117400685601954, 5.215263452654144, 4.675385245142343, 5.2567584267464005, 6.5081999579435665, 2.7920975342045415, 6.430324999687298, 6.367514727889667, 3.5584028556621785, 6.00995848074795, 5.788524700404865, 2.730643140015853, 5.040715803117247, 6.465346407843084, 6.74599515632414, 5.663758621505221, 4.486815144607543, 6.658947268610367, 6.308618741494734, 5.352340503156921, 4.013545839466045},
    {0.7501133466203689, 4.388200479788872, 6.39584744331707, 4.213693292200474, 5.426808512586774, 3.744467501987467, 6.151648851467601, 4.822800837777801, 6.014205643808126, 4.664186298628228, 4.945120738294568, 3.6931721343341004, 4.060841299014615, 4.640042972531023, 4.609609875542571, 5.99422754246525, 2.106257101490577, 6.298123330534778, 6.158502856901706, 4.4730426889046075, 5.437542435396554, 5.695199132964366, 3.3612158354093116, 5.595150447937959, 5.708920981213661, 6.475962942653273, 5.588438968671204, 4.620616553527387, 6.3192228695779615, 6.425622625920451, 5.264281958820595, 3.86374490390886},
    {-3.287273999071264, 2.9160972393164872, 1.5854965813948327, 0.6347824921843038, 2.4858466398103105, 1.1745709738305583, 1.69254352268381, 1.020184740677323, 3.095955004642213, 2.2207413765897077, 1.076915470840427, 0.9847147390941189, 2.925837216228539, 1.2099799910343918, 3.345394816200834, 2.662006809160096, 1.2228186100544902, 1.590989933642104, 2.3331194773106203, 2.461727411019054, 3.166052002890528, 2.961137551438401, -0.7944174860770977, -0.5220520450465947, 2.0788524596209794, 2.2873242660465363, 2.854196934861613, 0.7875917023503323, 2.2687356312753963, 2.218040890599068, 2.2443968582441567, 0.45627778277527914},
    {-3.491473568559517, 2.013759691751042, 1.5473773189911137, 0.8639636615308277, 1.9465071147729645, 1.4448377387303635, 2.0880214098417516, 0.569583947870894, 2.959981267606021, 3.1786883475427516, 1.1086224417180979, 1.452483455873246, 2.779949602332429, 0.5268211408956136, 3.610051374209089, 3.187124776815087, 1.8121537595010337, 1.8624159243739797, 3.2470645788941224, 3.4883859345578325, 2.987542322168095, 3.7486416970487615, -1.30269864691935, -0.7001762527557356, 2.827780188572198, 2.189349242364813, 3.06657458876931, 1.5147342672281257, 3.0699081052274924, 1.273395784993133, 3.41491717930459, -0.8243236828074658},
    {0.9885181996997877, -0.44181993694624516, -0.9099993396882821, -3.7057632925609365, 0.10439829801229977, -2.5443936279837818, -0.45666784403158106, -3.7502222462494936, -0.8070727343668042, -1.9504269756574482, -3.042981341911742, 0.33386981736032906, 0.44969780477340804, -0.8268461984160722, -1.9995048310960282, -0.3291004858730889, -0.22511143613091536, -2.328957191546924, -1.5784960024117467, 0.36547501031073976, 0.5766093749521237, -1.4855913872815052, -4.5000901859833, -1.6969412240503257, -1.7644003551491194, -2.447065290095557, -0.0166417712188056, -2.136459640745986, -1.3235350931696623, -2.0198795399755762, 0.054401645292698524, -3.276450459283181},
    {1.2261198147250172, -0.7032183448681005, 0.32406214163811026, -1.3497788338637888, -0.006794548182093174, -1.151911101089561, 0.5668610927731108, -0.2056533174031327, -0.32367715621167154, -1.8611117556647319, -1.840694555785161, 0.2978122544651253, 0.3432051047395243, 0.8941098102130236, -1.5644762306457587, -0.4054810778506474, -1.386503763463034, -0.6281454448022018, -0.6208686281561682, 0.6075647523714206, 0.8494275144217319, -0.6852608149845327, -1.8902962135782735, 0.7031492246734462, -0.5283226951935732, -1.1584917438005466, -0.48932358549492666, -0.9886775507121662, 1.1850538121682317, 0.18942662767904878, -0.31738463061028904, -1.1637346457825315},
    {-1.5623454032047182, -1.7858376634921804, -0.46711555286188994, 0.7774037730298738, -1.2480390796618965, 2.085882298579041, 0.9702572646221235, 0.21526531928629986, -0.6852063855812018, 1.5304187844060362, -0.45990212047113493, 1.4677316122842026, -1.232678888509861, -0.45187448989694257, 0.8166757609983417, 0.4703632483033732, 0.6539951581262681, -0.5059010118607326, 0.8919884975322655, 3.238281290646409, -0.4506341474308259, -0.7811276165862615, 0.5868337691205026, -2.693592419521966, -0.6089932856466675, -1.1656422864753189, 2.6987451004340715, 2.1093509142549687, -1.3104202844938166, -1.8713154006790724, 1.972886119996184, -0.6803794857243926},
    {5.058631870952215, 1.5215778178387995, -0.5935157796652641, -3.6821196588812275, 0.8486600081194456, -3.6221842661445276, -0.8083835244381048, -2.6033361308454857, 0.8774930654563234, -2.7874035405295454, 0.10308174722489934, -3.570119037729473, 2.0609513314517955, -1.537430016405801, 0.018047823981752763, -0.12220099915863267, -1.571771677920138, -1.4091038309987425, -1.6817463738624445, -2.220364982944937, 0.4880282308497845, 1.5152895797455381, -3.36831276965007, -1.5557727169185531, 0.5909977202684394, -0.9036567566901726, -1.846946068812119, -1.3600426651745874, 0.8531232757224227, -1.2475278235638059, -0.8054444102693152, -2.957301204741149},
    {0.9362279655420327, -2.4215314832552273, 3.0788143027177526, 3.871165044485115, -0.44235150572590876, 2.3275407418987313, 4.246708939284161, 4.256918061874821, 2.106643775238823, 0.9383025364945853, 1.3334027693032193, 2.872147355889821, -1.2043251383612488, 4.834495372221754, -1.2849729194416293, 2.688039277010714, -1.730980169860066, 3.5337718277803565, 4.054110185725607, 3.6499364346907957, 0.24642368174632434, 1.411232614571029, 3.460478905778404, 4.153014886060139, 2.1230369419579755, 3.5242000234272424, 3.0898538543044443, 4.7468006819881, 2.8635237954703294, 3.4819723290943068, 3.3573177515935044, -0.3308209388854043},
    {-0.21903121007347032, -4.262806853444579, 1.989285866056735, 2.610401240944336, -2.4171823418261846, 0.8529814813872149, 3.8275992000408627, 4.746512941933023, 1.4636949674674933, -0.3479913334347071, 1.7531776865320423, 0.41488693518063696, -3.9248893222801224, 4.634517315822198, -2.5996620770127143, 1.334935205985094, -3.288963207317697, 3.140703297258326, 2.7479128598888676, 1.2536438633990548, -1.8317263203143814, 1.074752669527078, 3.891981310392165, 4.914982443576431, 2.8440521767818527, 3.7629141505446957, 0.4987152217786144, 4.82130803977788, 3.670837083625401, 2.7166606887271585, 0.7144061369493666, -1.7191137053643237},
    {3.9041143836021766, -2.2255733300692113, -0.034059400410672534, -1.9814292804025335, -2.2123748873454376, -3.9161704280446967, 1.527263981364241, -0.8353284181923153, 1.1541017274249517, -2.8389301044700748, 0.8562561581570007, -3.417485852668417, -1.9658653094128644, 1.6361032432354154, -2.622022833782212, 0.66393763901324, -3.869952973572515, -0.30281469163203933, -0.008675829446184613, -1.4355960642590233, -1.3052533956113141, 1.2213702926347352, 0.29708419064683195, 1.4622097158594505, 1.981967730896149, 1.6869895505211319, -1.3462194103792238, 1.8058152234422176, 2.985846847597836, 0.4325342608070906, 0.1921614258173816, -4.750504863841462},
    {1.2908621518301884, -2.621495769210073, 5.092041072326133, 4.030658223304463, 1.3101260633786198, 2.382032432238934, 5.653117076207941, 5.193316897210548, 3.5911068269700546, 1.1137851967089647, 2.2461632105135005, 3.779874386268002, -1.5231858456124259, 5.197189879736553, -0.8429295088002036, 4.323471739375872, -2.709835192181557, 5.436533360066207, 5.05133101249499, 4.447869175350512, 0.9864899919913399, 2.561416517003069, 4.001678498631283, 5.973957995157586, 3.295323134110071, 5.044769581185779, 4.62283516477718, 5.641041832384813, 4.458703317280264, 5.19217509651662, 3.846658900862141, -0.3940423923090934},
    {2.3946662064564417, -0.8769677779388485, 4.054943060713248, 1.960159407626665, 0.7702002065312692, 0.4286083908956869, 3.964826823620142, 3.5960836370983795, 3.157768194355882, 0.4491175000191715, 1.7803473367859526, 2.200653948104193, -0.6448778755342083, 3.2853699092669078, -0.9549534490829613, 3.246979505465621, -2.6423630332800085, 3.628874846392896, 3.2965190964876805, 3.044299926387486, 1.7788657056887927, 2.614597695902633, 2.1414644923448223, 4.329241679375748, 3.113412850717852, 3.8320966547405257, 3.0560226201062566, 4.371486098096824, 3.1982536416627716, 3.8992678126577998, 2.966691234734563, -1.3068631456207664},
    {0.4517313134759516, -0.9961758394178402, 2.7420495871944306, 1.3082810231705941, 0.5428313863358423, 1.8584957345829491, 2.061232310439917, 2.988677139727946, 2.6845113733603814, 0.2026108939699815, 1.507462783801944, 0.8688785807242608, -1.1451142061310426, 1.8463340919888218, 0.8071612485248622, 2.2357134964370013, -1.8929035072702527, 2.9836157277291835, 2.7613726362057656, 2.406671242451876, 0.8891197921196576, 1.9808272714275967, 2.9632795507173926, 3.1505777958361274, 1.0427945186984433, 2.3000304087031123, 2.291936559537783, 3.650229890693473, 1.7577090343185906, 2.7623110353873948, 2.4322691573523256, -0.08805730889051772},
    {2.006475389848527, -0.6429734918452303, 1.396715165807963, 3.2622719250562313, 0.2511106626415244, 2.0021772423103847, 1.5821131583923829, 3.164419364355206, -0.3638833110531648, -1.8585366663679914, 0.2582707284002051, 2.0658437925154374, -0.0625720817494444, 1.926971586500877, -0.9039870490924471, 0.9930392468857688, -0.05483137416552483, 1.310109073199689, 0.8020781519486931, 2.2031724748860393, -0.5338572920503626, -0.32357555203862615, 2.7324899227680373, 3.1634006937182906, -1.0016208159079498, 0.323298928423086, -0.08124425019329755, 2.504101532466981, -0.15594758203383596, 1.3241267453116057, 0.5490606802561042, 3.188278013454482},
    {1.5223876209093623, -2.237307677502864, 1.3862004240663544, 2.9044713746131596, -0.6034705637008017, 2.914480092216852, 1.9796323207774658, 4.040200469327172, 0.007824830071707114, -1.9289917047549527, -0.0032145371113109396, 0.8701411068611925, -1.683174821451635, 1.1941177183723808, -2.104123637310567, -0.055017246924653096, -1.654888970109115, 2.5723125788686096, 2.1767410452698828, 2.298644047351335, -0.9630004690014194, -0.19581563498155277, 4.372302287034702, 3.454428382241515, -0.6234059607263862, 2.2257350879240607, -0.844214142396042, 3.6999162432901107, 0.6491266138477688, 2.5254772871504394, 0.23591237110460275, 2.249858377936037},
    {0.2262650613493724, -4.280236436762024, 1.151241041047007, 2.2938106778644554, -1.5866466289058925, 0.3403430742859018, 2.494103021706026, 3.6129271200470634, -0.9096905275640844, -2.9164420944625173, -1.6006888622547184, 1.8254199979058159, -3.680258645116024, 3.54607526132764, -4.510782862702948, -0.6807594396940903, -3.5056564988689223, 1.4946587656278854, 0.8860114719869644, 1.5203851772875963, -1.5823744123824501, -2.1403737883582896, 3.4361718856303125, 4.010647159880369, -2.2139808879914233, 1.6253907569038981, -0.5110817350823259, 2.8026638922464246, 0.0023629979168677965, 1.8853821948679534, -0.7179703023112758, -0.6245225815202085},
    {1.2537731137250367, -2.205577768488605, 2.2336909126567224, 2.8355312950245106, -0.705182963113344, 1.1017226050447402, 1.3606419452670748, 2.0040642544884006, -0.5369735515188119, -3.5829889652424662, -1.125896238490307, -0.8663512393982448, -2.701866119824662, 0.21766258702643387, -2.938313576540477, 0.25644881670249614, -3.326174694733483, 2.1683419947077542, 1.180149126639235, 2.410313734741106, -1.7992713969158511, -0.8552154236477947, 3.9835331671490763, 2.754330090067266, -2.2959436718355954, 1.7433912567622876, -0.02969385432581801, 3.7544271546672645, -0.4790732215715333, 2.5990993889887952, -0.050124788816975074, 0.4068265172584371},
    {0.8009273779581726, -1.735232519208963, 0.23437463360486896, -0.1992568828609072, 0.6411312936724994, -0.104787637673042, -0.9483614639291288, -1.075105161662622, -1.9748778872018848, -4.042202241528032, -3.390731619066244, -0.2610836979630062, -1.5735066433783136, -1.4082685889509488, -3.3011245713518873, -1.4399336483113694, -2.3735699814070537, -0.24052901508605032, -0.5513243486790956, 0.7674446964283567, -1.1132093939950845, -2.8139886494210953, 1.3553089218534333, 1.0296260442305416, -4.505323481790238, -0.8344649049473154, -1.1191001723040528, 0.20436163423668985, -2.174225952810789, 0.9754962714145606, -1.6692530538007713, 0.2171372561018525},
    {-1.2640105942346267, -1.549995693555684, 2.4253936858564016, 4.614575501074421, 1.1326731100868572, 4.724306290497884, 2.3306378603497433, 4.453556345270191, -0.35790953010937043, 1.509871350085052, -0.0951186867842716, 4.871448408037132, -0.8024636218119079, 2.7689508760836636, -0.3870327962342544, 0.6473521701577258, 1.5811214362090287, 2.506409679176977, 2.4602648810356667, 4.207532503034991, 0.10437667102421741, -1.4690636266397632, 4.240521843405445, 3.4478668125757426, -1.651013703698854, 1.2732212486044712, 2.518313890535457, 3.3239457374140597, -0.16227975341729256, 2.3671037544619074, 1.7007231415808717, 4.101477075620155},
    {-2.046473427530186, -2.053902760716048, -1.4793808981247512, 2.5092973864065105, -1.0534953338333195, 3.6761606745099633, -2.2399122498796973, 1.59451196390524, -3.223825985283048, -0.33623528449207296, -3.4350281424336266, 2.854072619887301, -2.350060649435399, -1.261648501516676, -2.0427332585504145, -3.110616310933063, 1.7333339222827915, -1.3452331318294206, -1.3235613523674066, 2.253945935078748, -1.3237890062138589, -3.726347231864563, 1.9250714062134906, -0.4570956404662001, -4.1990370468891, -2.798785643758586, -0.7390277999243329, 0.08288591621144496, -4.166364435053949, -1.0133113114732673, -2.2619285972920142, 3.311799608466975},
    {-2.1296706833595973, -5.523891628793941, -3.1042998008940024, -0.9332562830529745, -3.6760283396440707, -1.340786198201694, -3.2907776654223175, -1.2238816372200554, -5.339815855447086, -4.551437382567569, -5.877629127925147, -0.8886114166052983, -5.749714786847987, -2.310487573961026, -6.144131602618544, -4.713616660024722, -3.821677762876, -3.03424923884518, -3.989847761127869, -0.21850732235323045, -4.846546809763234, -5.8373682160268325, -0.3777859966153481, -0.8677109387917789, -5.60379023310748, -4.179398037449651, -3.6067307965425806, -1.345299330026337, -4.947470177692796, -2.7219185778890567, -4.7540930986078, -1.015059064935535},
    {0.19689019946390632, 1.2875148177954236, 0.1116511792287638, 0.2695101160959526, 1.7337156125122164, 1.4619037686111078, -1.414685713006724, 0.19365023834405196, -1.2056261052701789, -2.021136407654191, -1.9499104368627893, -0.16274474993412086, -0.031524861538718765, -2.313335234893808, -0.03236764927869793, -1.5206029618735897, -0.8087057432806363, -0.44199324030210935, -1.0713750780466882, 0.14570350393040854, -0.13223314038362705, -1.0648717261793061, 0.7937735810070119, 0.2458543934076537, -3.1359381128605013, -0.4894665268480394, -1.0083522140288992, -0.7030413477645908, -1.7859021620528976, 0.7189171040949618, -2.3532534211206753, 2.713464009927899},
    {-2.103572900262214, -3.7506433785997713, 1.5166583996849303, 3.4240348161689114, -1.0132821528311027, 3.4832057940674956, 1.6078164220172522, 3.1668447380535363, -0.6464037165386444, 0.12190267134890544, -2.068985205252204, 3.9750698544152807, -3.8174457687651087, 1.6411652941783539, -2.9323238592933314, -0.31250273821032226, -1.0713834083589655, 1.942678956870665, 1.552883801886425, 3.698593626524529, -0.25218284797477813, -1.8362770697662232, 3.591608398573718, 2.449931625933924, -2.2583357370627377, 0.7644604249733797, 2.074558582053719, 3.253119625331678, -1.7250517995220807, 2.208624002592652, 0.1880298666552978, 2.711015741961914},
    {-2.564821153974684, -2.7550093166317318, 1.744549664147762, 0.7518667896433648, 0.11305452585522249, 1.157445308309463, 1.1126976535888542, 1.2118979862350359, 0.12040458448854802, -0.8513888552120745, -1.5651608914085602, 0.32727757616318165, -3.1821666309888963, 0.7521925333631495, -1.8887080303213613, -0.46492089055734076, -3.0454229144748144, 1.6783247207340535, 1.0746202917522807, 2.0462285382489176, -1.3339630431753695, -0.8671310273319256, 1.0185872720075198, 0.5945891596610368, -1.7782546302835651, 1.1195951526302719, 0.5743747984647343, 1.6900735291475553, -0.33309093468645073, 1.5543059608709078, -0.32542979396608446, -0.27838107432369646},
    {1.1692596488057796, -6.418807264122698, -5.116273473679553, 2.5738299136802874, -6.145921241065489, 2.2807601522993752, -3.41955265937327, 2.4825539086240602, -5.864446953967429, 1.8287698278084423, 1.9394123461038073, 2.4244946465718815, -5.511938904175439, 2.726133289510506, -5.744434575189414, -5.690685476655036, 2.02576395819607, -4.683765813167861, -5.080755065196862, -4.845016205678769, -6.078232859459617, -5.67768995398829, 2.273369587346255, 2.185629198360626, -1.0090820845468358, -5.350982295804643, -5.317089490302304, -5.432659014949943, -5.663288292456338, -5.342444267160747, -5.454661123143725, 2.4142740671286496},
    {-1.0159609739452402, -4.968889287313905, -5.173520140561171, 3.4998193995554963, -5.70792575119511, 3.4221772671882102, -3.083624110669255, 3.4319773034635674, -4.949022814473325, 2.5388213542862332, 0.9241567061077095, 3.725500685674062, -4.4899322492069285, 3.245168927419961, -3.2565509960758394, -4.657473611683716, 2.3798028172147876, -3.624674922218045, -3.602464092620684, -0.6672182526020474, -5.167330455817026, -4.654206941772218, 2.6770460342154148, 1.3770448872489445, -1.4621556990005706, -4.825955775837901, -2.8276775627089106, -2.0047721757794332, -4.657873697235769, -5.123397524143457, -3.4578288914857844, 2.6472955902693527},
    {1.0288967743221207, -2.5620577833231515, -3.975404172446952, 2.73998770212173, -4.24172928926325, 2.583596200903892, -2.1873742318643035, 2.751290372469849, -3.175119566055771, 2.9360188727880407, 2.694938287576773, 2.5298168494806004, -1.1142407594279586, 3.1599879947954803, -0.1764282885207114, -3.432724195004598, 3.523842467412234, -3.5912127339283257, -2.84803787709004, -2.514279499369065, -2.531844473897945, -2.50399897541539, 1.6923965909404404, 1.1892695436610041, 0.7121597998860144, -2.83838912238367, -1.3093425275366393, -2.6314717251932964, -3.707619548046134, -3.8107523329931476, -1.4248359814015727, 2.5528025844050153},
    {0.42806510292616595, -2.468021435821666, -4.264601907548567, 2.275397935972293, -3.0501985496764896, 2.4162004413996914, -1.4764321543506096, 1.9524594808673141, -3.7941200510938184, 2.221972664220475, 1.6194800365870399, 1.7138898820160393, -1.7387121860762202, 3.006765131380851, -1.3947700564466323, -3.3972934060419537, 2.673452713511658, -3.002186089427977, -2.6421164642840207, -1.4460981592098807, -3.2275238190235616, -2.4215609533187346, 1.8834794799684935, -0.1106055756219044, 0.03588624028485825, -3.3539537327177973, -1.6458607669751304, -2.485272955261034, -3.88665321183387, -3.7835847617903777, -2.186123867042299, 1.7237526368026752},
    {0.5945815016420793, -1.0390786967476313, -2.7065466511195257, 2.587141707664447, -2.530868774250897, 1.526290042441724, -2.3054065066242897, 2.016918895359699, -2.9136819266833878, 1.4274474965631012, 2.3983749432517185, 2.4094548755613383, -1.2558544839932333, 2.0789082775711316, -0.32329627973492037, -2.7672220822544005, 2.311160899038979, -2.6187386432236375, -1.3235889806857146, -1.5733065382112204, -2.163635638185289, -2.6348830551054823, 1.8490309566074015, 0.8396009184563322, 0.09513201657460195, -2.352967713950741, -1.2286400647619062, -1.7641130486234382, -2.4784631495900697, -1.8711411233700015, -1.7667755351119099, 2.483166245310177},
    {-0.6739094075498427, -2.43270135916812, -1.4535497060101088, 2.0202837005521594, -0.693132348020241, 2.36433729638952, -0.7398544949951322, 1.5529452451465233, -2.1596276111495514, 2.4306325667118496, 1.733608269081603, 3.4805396799056236, -0.7541299828097452, 2.010689711440815, -0.32124705840593365, -1.880971490062186, 3.2580439163217645, -0.7967286204117062, -1.1721895883018487, -0.7893721201993884, -0.7475688162949813, -1.4171898245501535, 1.0576048640225826, 0.9818111161880584, -0.1697371047936419, -2.9870174796544653, 0.1081466787668175, -1.3321059563219195, -0.762701388811, -2.7102994071657243, -1.0103078895022952, 2.719967396242658},
    {0.5972049098221944, -1.3061418173334802, -1.4196034711883394, 0.4882865293589587, -2.346818401967627, 1.8140707542932173, -1.0794180968342852, 0.42498403119740763, -1.3955397550640447, 2.045567242910872, 0.7487163399139457, 1.401002715247195, -0.7938231120652829, 1.9897251354804069, 0.16171873938977258, -2.133877831479348, 2.767768939441688, -0.8304332371288832, -1.2621981659600885, -2.2688935901151246, -0.7476018113790358, -2.2261443042465126, 1.1871641469570189, 0.4495528793809572, 0.7258295657841108, -1.7370188105813842, -0.2022357960310209, -1.870695917008141, -1.6755603195355688, -1.2664439325518737, -0.9128198327161495, 1.7468412717577022},
    {-2.3696434787291514, -2.160627446844964, -2.0132566418740225, 1.971631573473717, -2.9135441487562876, -0.532573917132834, 0.4300528205644314, 0.30931622063557185, -0.8344932652932193, 0.3830703267638945, 0.9415847838901037, 2.508923011125951, -2.587454638693638, 1.0713519326960368, -1.7483180077043334, -1.8372068047869174, 0.13355015146332694, -1.392452305219295, -0.6301329078662645, 0.25204919615565213, -2.3849506152987203, -2.1169014592460647, 1.7522727598275483, 0.5749252957595304, 0.20458417960559697, 0.356742989217358, -0.6759573041479232, 0.09108827186242703, -2.1769226460957034, -0.671475908691488, 1.3403869808900335, 0.12536693033957969},
    {-1.8829001797201477, -2.779699126549774, -1.8268008726790046, 2.236779928712749, -2.6796118127203874, 1.4192168539816448, -0.37007902831269224, 1.413483030670042, -2.1477991185913106, 1.5053267404111064, 1.1547165227305414, 2.3022640492446986, -2.9268304266822622, 2.381570706306158, -0.637165554723748, -1.618913532922627, 1.9296847809776347, -1.7840313411230184, -0.7075931034290738, -0.3968699728655633, -1.7686699384629327, -2.2450009525325, 2.19917748616448, 1.2898414106641263, -0.6939503243878491, -0.8133008358883476, -0.07573369136386247, -0.6150780261512564, -1.250594650872955, -1.6523911930682604, -0.18782733345675953, 0.8678651809699293},
    {-0.34077460511154445, -1.2564314141083732, -1.2197516940136355, 0.38906405575411485, -1.4645850718845812, 1.3462861948017157, 0.17676656157823759, 0.8819077603069615, -1.0925790793035377, 0.6291130099590272, 0.9471973558070979, 1.1059351592369564, 0.27477753294614343, 1.9666668219701209, 1.1994066671515762, -0.6331228592966358, 2.4861238760564452, 0.07037143678495826, -1.138728295871583, -0.2564289851266953, 0.3545171063479693, -0.8193270149562074, 0.19195442116197758, 0.02274013106405564, -0.9896447900935509, -0.6710599236000236, 1.224418154888413, -0.9541203049438465, 0.7949498301376297, -1.0194670398472274, 0.5723485649812504, 0.7168357803719144},
    {1.1795909604365074, -1.1629063245341547, -0.787126027183194, 1.0660935059783725, -1.7311127449071742, 1.594172511087812, -0.3237170969731168, 1.573211256409463, -0.6264909087029416, -0.008960408352867077, 0.4697797451648706, 1.063130005032853, -0.6506348310197444, -0.8912131002868449, 0.40109605388344616, -0.9595160422526885, 0.6162667863795708, -1.3429065475736337, -0.6013711636538617, -0.25659097388670676, -1.9199937817260744, -1.6381185047003752, -0.7228456077474412, -1.3112900662027023, -0.6589863994979562, -1.3297586571185205, -0.3504317078937079, 0.20917547986109916, -2.2360955635470305, -1.8950632185677865, 0.11663213009951323, -0.3571471514016623},
    {0.49540226608775817, 0.21630747415031834, -0.8035998865369096, -0.09521475115815692, -0.44666780446629994, 1.9085326778781386, 0.819816377166201, 0.017694766756656898, -1.0959701299706994, -0.8501634992933865, 1.390120803651616, 0.44294376015795117, 0.9134554064289498, 0.1898115067178735, -0.555837904619002, 0.16698332351567427, 1.3465708181141967, -0.9188662736312865, -1.3313152301780584, -0.31727082214894525, -0.13538270392658341, -0.4985044433635102, -0.7009799556371894, -1.5457867482266396, -1.8444456388717194, -0.6658314077264283, 0.6653786855963959, -0.2182003390894257, -0.34828894954145645, -0.11733514387133027, 1.025780007098023, 0.08064602312699438},
    {-1.8804419425097663, -2.1391117367686836, -0.0776311675122515, 1.658428607852326, -0.5396616258399913, 0.8930025064901752, 2.3310049274027036, 0.354037597671556, 1.1468177753515834, 2.058125077544141, -0.3115653325282663, 1.7384235573068743, -0.9471067300634237, 2.197962286358005, 0.10802050923366388, 0.9366806857819283, -0.1901844408962264, 0.8277775409487284, 0.8800950319923047, 2.3838828055282777, -0.24025884233364836, -0.27605742101932584, 1.3945634813752925, 0.0377631993906179, 0.38251256752919244, 0.3241764886837855, 1.4595700169107282, 1.5158805553554278, -0.8103323252692806, -0.3716091302039367, 1.7400626823113192, -0.33017387639447054},
    {-1.9201581315112624, 0.03697166348097854, -1.862796667604313, 0.4701968792956894, -2.7357415748288783, 0.0070839299811367475, -0.6748050647927764, 0.6607265574024525, -0.9249557313327763, 0.2313800866919303, 0.19830179947615084, 0.22704586460676424, -2.270635340769274, 0.32413278578620525, -1.1486903934183794, -1.3147424463349413, -0.39710908922944027, -0.710746134679027, -1.12263181549744, 0.5642692587271327, -2.782307510001423, -0.7558025760281163, 0.3257582553260524, 0.22460043851994632, -0.39772152585455356, -0.3497990200581125, -1.0112296474465141, 1.3306484699442576, -1.2691937229296488, -0.4773078558648392, 0.31797835467825686, -2.339553462361865},
    {-1.575296453870128, 0.8467989813512122, -0.2967871327219105, 1.1478862725946, 0.03477768338591474, 1.7955725157620948, 1.3688194131040043, 0.8657580330324024, 0.7975211470731586, 1.1734664398672146, 0.007196694824203732, 2.506422780332334, 0.0963274924328453, 0.5052093282291676, 0.7019911224841625, 0.9396784345291445, -0.9017881419728443, -0.7055614621548144, 0.8408437091223067, 1.663559851517115, 1.1885717344855442, 0.670288854746098, 1.578435648884974, -1.3379262063415691, -0.8766958221256749, 0.404079961856689, 1.7224536706962417, 1.508496063050361, 0.10944452867453111, 0.5211042686435091, 1.6788193124936532, -0.4596866043304895},
    {-3.5881667306981706, -0.027242068912392524, -1.0429693973511898, 1.516959182249542, -1.7633384150935643, 2.043061496651137, 1.1247593819197037, 1.0616152196765236, -0.9792469281421639, 0.37191022984891914, -0.43149004963468496, 2.0547843302464894, -1.2416156849420246, 0.6476945119043713, 1.001804519748567, 0.4134665364604906, 0.44559690700885823, 0.09295868330354551, -0.09230685625092895, 1.3915378435961403, -1.0241747585738363, -0.5899058030365361, 2.1304350416763462, -1.3769127556062375, 0.09376797541196065, -0.7365819300627922, 1.5989667374010543, 0.6018515709629251, -0.10856013698239765, 0.4091215626611931, 1.0632120121915456, -1.4337888978030815},
    {-2.5465455361152247, 0.7772663997509179, -0.8126070243710567, 1.2605376805906299, -0.48697731388127363, 0.43460287962990046, 0.1878267463313663, 0.44539961290837227, 0.5696886847318027, 0.38803080254695627, 0.9471672777096862, 0.5134415130788748, 0.8779508432235417, -0.9129071732263191, 1.163654774085401, 0.158795291501193, -0.7186123480804377, -0.8636120507217544, 0.6475494104295152, -0.06331862146086124, -0.2567379996026115, 0.4876236513931903, 1.3092780848764891, -1.5456666305086268, 0.7599020116102698, 0.37935556171713847, 0.916996785389849, 0.5234331993466511, 0.4077043572680828, -1.1915692893150136, 0.08477594447288006, 0.6101948610982698},
    {-1.7761195386313207, 1.4891070035179903, -0.8349266135665813, -0.34575933252429736, 0.8385948817140177, 0.32533593980239156, 1.2242524194157434, -0.16756240327504826, -0.15319654456945825, 1.349973956776948, 1.5102455525327636, 1.0465968879076966, 1.9556159455648428, -0.8455502165839696, 1.5219788713361178, 0.71726616235397, 1.7658183171324007, 0.2912824964268684, 0.2794959806721058, -1.1566136682213015, 1.8286178837499678, 0.27701246717883066, 0.7989233717418746, -2.3355365404990667, -0.6246564032719877, -1.1711223669565767, 1.3198985206433045, 0.09840016606003431, -0.362290967441401, -0.5982968727607305, 0.4548431915221636, 2.163396896633783},
    {-1.5162437580455363, 1.6613576548001514, -0.7130205766325671, 1.483721556161856, -0.6931548796789114, 1.6663102621814625, 1.6694113330135885, -0.023075713769665225, 1.2252210142385385, 1.4948131682238148, 1.7202653563201824, 1.750673354302069, 1.1456852076796182, 0.9365826934136204, 2.257842406514834, 0.7232920219563029, 0.14743089811619356, -0.8498128895593144, 1.0921475720900806, -1.1818453966889144, -0.3279753202968868, -0.28259412998553585, 0.3670010781737051, -1.660350346745853, 0.5622349477049624, 0.43845314821121756, 2.045871153114861, 0.04253500958451103, -0.7031045652536724, 0.09418066950070259, 2.321306753009999, -1.2330383275426402},
    {0.4310310052790413, 0.7043941033557726, 0.31730826859016903, 0.34670937136381047, 1.1076674514156744, 1.3259081500794916, -0.056281707730912685, 0.37433756079781844, 0.9355733624690212, 1.1418571548905871, 0.11280731211847633, 0.8291439083739607, 1.2679456405110228, -2.1118543668799266, 2.307165244212098, 0.07809459446387386, 0.6673022359643226, 0.46748957786059286, 0.03217221848231136, 0.2613997859478863, 0.6063811418579359, -0.04972719223101269, -0.10465277314988507, -2.6653541449907276, 0.3528489691086531, 0.299577137869847, 2.4039802761802127, -0.5330314054973055, 0.6736858799005827, -0.01816813727383515, 0.9044606284676935, 1.547549048511225},
    {-1.478260651012514, 1.5641372324291494, 0.0719943789035023, 1.9287459532502955, 1.5202307115537588, 2.112778680563436, -0.6486317085684717, 0.2538848299201284, 1.1077468246656479, 1.5337575252910016, 2.8558526525509107, 1.1248418895210455, 2.521819099987036, -0.6075629952157817, 2.867274296452506, 0.9274615820684096, 1.9816085885561097, 0.3056967106569442, 0.9823282677192552, 1.1936446408740031, 1.1044723725876904, 0.9909936067056027, 0.48706829716697836, -1.859403924787897, 1.6811047916087454, -0.08556499403421192, 2.410219243714926, 1.3296025481966192, 0.16128201182695534, -0.2730492705716604, 2.291186183165161, 1.6767570699821535},
    {-0.8192868526650342, 0.5164464256084994, 0.37751781977422955, 0.012776591462687684, 0.10559937368427212, 1.9132102764228545, 2.0923374948130298, -0.2713509613162401, 0.691148440170752, 2.283685669882602, 1.815647421832516, 2.65757217618713, 1.6465632666101684, 0.8079950543903575, 2.5104203212171288, 0.616121752930428, 2.1171117020661283, 0.0218594729727633, 0.05325063476351606, 1.0108415628013427, 1.5697777357695295, 0.18538229432044678, -0.9480541694252642, -1.7595948997092334, 0.03499002947242969, -0.057612823970097, 2.177958177386259, 1.4888692983569607, 0.658536821669913, -0.8003317896214085, 1.8226419190487695, -1.677910150840504},
    {-1.3156112874119243, 0.07736621653029141, -0.05102633330892885, 2.3933873004814674, -1.2891271425895223, 1.1652134227504714, -0.06383074935324469, 0.8650407515036224, -0.3810308974185946, 1.1991510450539418, -0.10403609432541058, 0.5542986007392123, 0.11533133519621132, -0.666521304827659, 1.0848471750852997, 0.9625053738190625, 0.6687332109671088, -1.5685869623539304, -0.4256035732582046, 1.1429726745430848, 0.47752909187996795, 0.41782978568653384, 0.948255715104585, -2.038710905350071, 0.5305929338175897, -0.015111379052658237, 1.0002147415671008, 0.016796412929423576, 0.6265381098799879, -0.9271859475005403, 0.8570152255591083, -0.018438399619511648},
    {-0.8036706998752039, 0.5505683683766789, 0.3423458608821137, -0.398233689162269, -0.8078741734754629, -0.5766941140949401, -0.5248302205019356, -1.5615500099928967, -0.33338224384956516, -0.429706469220667, -1.697064478009119, -0.31500014176810043, -0.2446316327727927, -0.8341827231996922, -0.2259806706001365, -0.08198865418359523, 0.8254234837539434, -0.19220485616762462, 2.017256834989836, 0.1782489025039254, 0.6240640657715181, -0.5676120080032491, 0.08599531246124839, -0.9970583237052847, 1.3021467850399389, -0.17443719553917925, 0.017885676410091932, 1.102834746750601, -0.1887288233790426, 0.0984891152884412, 0.33040103366197476, -0.7955655797415433},
    {-1.8439367401582603, -1.1867545438373945, 1.1892721001154305, -0.0346687440910343, -0.1737871072188889, 0.43751263608749996, 0.07747279212008076, -0.26020462718824044, 0.4658990681740921, 0.2272754354570276, -0.8248112252641344, 0.2594368077444197, -1.9767735592073654, -0.28370399107619737, -0.15934202440410383, -0.5483468151759431, -0.8258744851004843, 0.9437479402275938, 1.23880688315934, 0.5110014746533501, -1.3531345801624601, -0.844077216180262, -1.1221905584448753, -0.44425517757941085, -0.4118447723822336, -0.4461095111496197, 0.3956157237667247, 1.805630947556105, 0.35336351170335767, 0.4715124025224764, 1.4990581759841397, -0.7410384370683709},
    {-2.4550299138710368, 1.3856232405865136, -0.3734778545407888, -0.49739381512103387, 1.453660824084507, -2.308433733465181, 1.071947810407011, -1.7935975873496943, 1.0231144980778468, -0.44383859424370536, -1.3276313113726292, 0.5859854342208749, 1.0649823310358018, 0.2529513428417476, 0.6521201106625224, -0.1406162024584551, -0.019911563231310766, 0.20204341953492364, 0.29183888553039244, 2.0070820996565364, 0.283415415887741, 0.7159129494323186, -1.3059538362086074, -1.1320380556493026, -0.9729092154986837, 0.9868250053371868, 1.2087449210293246, 0.8482518667444966, 0.32233199860117445, -0.17205848345331903, -0.002167927890493577, 0.7951981353847445},
    {-2.1115316108032482, -1.3604492487507125, -0.2880800681372325, 0.2633962697594949, -0.5125396835712389, 0.42786021773841065, 1.2932631474246012, -0.6475838617188308, -0.39063987680318774, 0.320792430841978, -0.42495879543490367, 0.7851768750903885, -1.1769959433631307, 1.3289492457528664, -1.023275607014085, 0.8475720510474517, 0.9881615248909728, -1.232372631583077, -0.27798980915021876, 1.7001526581824884, -1.271643372453959, -1.593410059550202, -1.1142550350588465, -0.8188312479359777, -1.125082875613923, -0.340484096552695, 1.4401163321848414, 1.1692268913905306, -1.6408349532188025, -0.15133537880890452, 0.6430456820861156, -1.0350673020812768},
    {-1.0707258862990716, -1.0123023846871169, 0.7123640420967906, 1.1948328356907059, 0.48884614457721043, 0.5645052593310946, -0.15944281207288452, 0.7820883279163662, -0.6356609678398584, 0.9558438572856918, -2.509020007009987, -0.032985070221279465, -0.8217607068696507, -1.9794108260377954, -1.40006237859121, -0.11020014820036005, -0.27469166439010945, 0.6628994423252021, 1.0779289298799528, -0.03952183625655323, 0.08196185294728729, 0.09699834395168655, 1.3969775878060668, -0.7127955340802998, 0.3199071583345868, 0.4684900747757129, 0.5535518523769678, 0.8705670625832488, 0.27365762528604926, 0.2651138069971858, -0.7623969785141668, 1.210465621043288},
    {-1.3621354871432614, -0.27905230266923936, 0.754377674457367, 1.8621407369610474, 0.43730505729334296, 1.5262115056407835, 0.912354515467998, 0.41751306575119324, 0.3545702122496671, 2.088832036024472, 0.7477574264964233, 1.9819134526873046, -0.002338882640447029, 0.7980576361685379, 1.6608118145778834, 1.978734684762378, 2.191701555194652, 1.3083602465094553, 2.401286134113141, 3.1944295165234373, 0.44871524231773763, 0.904679992975481, 1.607665646903108, 0.5517560837081327, 2.0257558745054327, 0.44282171725043795, 2.32835586412799, 2.7811224926688505, 1.455568204485221, 0.9778592552584321, 2.0495896049785483, 1.2877439948649576},
    {-1.3669071083050113, -1.326116804007566, 0.7131665776469225, 1.6503849491608837, 0.5541653557622126, 1.7662023375529405, 2.0457858579493067, -0.25283962381626857, 0.6183201468544186, 0.7964941923116322, -0.9512423722228562, -0.09170368981958393, -0.42188114939908317, 1.4934509438890797, 0.9496004971489289, 2.0957206005652376, 0.4515635855902027, 2.544945702299281, 2.237837413000032, 1.9640442819816422, 0.7788884176579848, 0.5542751503507445, 2.4405556934243435, 0.4124537099812913, 0.6878246443773439, 1.7632204053455878, 2.925974783526033, 1.431244434606997, 0.394985374915911, 1.3481091645520775, 0.11910755911233412, 1.2849347977737613},
    {-0.5661252341883825, 0.30246635284275575, 0.4876889441415087, -0.4080079945208317, -0.4710226487698157, -0.045579825749509105, -0.15913025230889682, -0.322024804819416, 0.2718686606312072, -0.3349141180689077, -0.6749968935057987, -0.9941985227377161, -0.004025757540291634, 0.38070432766068013, 2.0598745585865847, 0.7950115410996498, -0.9656966714927581, 1.0844192166993556, 0.15596096166190693, 0.20998937470199702, 1.3742709606714472, 0.9589896346470493, -0.36777950336407433, -0.25487856999287173, 0.35844188629545826, 0.6113012463740025, 1.2962347367972498, 0.2796652597249082, 0.35221537620843335, 0.7567717363097985, -0.13892302143979218, -1.4142352239977927},
    {-1.4448940353422766, 1.1330668074261547, -0.8806755058500954, 0.2446336427413956, -0.4667554919402954, -0.5491803620228854, -1.754477928707969, -0.20627687774570339, -0.6373223064629345, -0.30198039746310257, 0.5535106002748506, -0.3502522898084707, -0.5317793069996104, -0.5051785379569149, 0.14484730281229516, -0.606540841355473, -0.4412581151144632, -0.25203408983962494, -1.4643374640630415, -0.6679644765010359, -0.8262407922601043, 0.6263256993479797, -0.2642651164553192, -0.500494103866269, -0.07331012755336541, -0.4617667100085816, -0.4817701690186061, -0.7236994849805227, -0.04310999835383377, -0.29379330990372926, -0.5831632518184888, 0.1331182035092056},
    {-0.8946274601552702, -0.3456021083602799, -0.013627026700675119, 0.91683821728937, -0.17823735458635903, -0.522011466687915, 0.164493344117812, 0.5044471885618923, 0.1424805577700651, -0.23725181978732182, 1.3291903229620765, 0.44867046281864115, 0.579851338909359, -0.7772791030883855, -0.3245646064169014, 0.4313547130996971, 0.5487571061490292, -0.03858637241659013, -0.5028512168040284, 0.12746004150465975, -0.08698912490919788, 0.6882241997371534, -0.6708524477676323, 0.16963054853526413, 0.34551904008001433, -0.0314783089444957, 0.16965015754465795, -0.0748841827940115, 0.5953821823445814, -0.86100301334959, 0.5197490590994126, 1.4884157737852612},
    {0.12514489078351806, -0.23050682007354276, 0.2919890199125135, 0.34198281157722266, 0.46472295616555503, 0.119480771191596, 1.3897415333098782, 0.5136885363342972, 0.14292837684621937, 0.4451039371898027, 0.3732451120663819, 0.24557213750216653, -0.017830650258638295, -1.0948156984502269, -0.7625981482068543, 0.00147335003709605, 1.1968589435291717, 0.41478036172994853, -0.029934531237433296, 0.15035535087095372, 0.7151052370915395, -0.4704034667272297, 0.49990882074256526, 0.9148146751059717, 0.16457611197839908, -0.125006102982592, 0.008013205097634455, 0.04842934135878041, -0.293441542538568, 0.4129520119309476, -0.35247028100976635, 1.3365791462737941},
    {-0.18653098376265306, -0.3799046737975047, -0.9309892574733698, -0.9497343128297926, -0.11104273115634877, 0.7276096989457462, 1.6150401480305312, -0.8243240591340918, 0.012576263812788825, 0.5158401967639624, -0.23165059777265345, 0.42302252723061945, -0.2596515988691698, -0.2935981224424172, -1.2430033891887495, 0.20890332863702915, 0.46316178348860787, -0.13886013140099793, 0.3227419182820734, 0.22921145759245568, -0.546836709470841, -1.6684204699453973, 0.41960299425605, -0.1963718394415301, 0.22873173674487665, -0.2033242649538231, -0.7831907417993789, -0.3119931956961739, -0.983160772577168, 0.21006507120967224, 0.21863033422127479, -0.2958933023263227},
    {1.2463145921618923, 0.03666780180157442, 0.17183120142604444, -0.30282978288571144, 0.7313808083264222, 0.871971992588163, 1.0493756267269072, -0.1782749369288552, 0.25733038719130596, 0.8359484767740482, -1.3801210345127042, 0.8843279028360724, 0.5945177038578902, 0.556311574457587, 0.21507361384305054, 0.20027847316805644, -0.12483791611576207, -0.5690124170738509, 0.8281983952395197, 0.8504874081740049, 0.33298298899441237, -0.6243228536378221, 0.25897986927462285, 0.05582047862203852, 0.2356737727972385, 0.5465229257749952, -0.3778039951656207, 0.7101887475312578, 0.26474662710584135, 0.6301744314765126, 1.0439017340958299, -0.12667994879142627},
    {1.6843791883269312, -0.0605158333940331, 0.4590854155530032, 1.3390060730835163, 0.4242910564257341, 0.0008259585821916928, 0.8870059527407929, 0.16578285663636227, -0.29866586653040955, -0.00026102934663617676, -0.39799435265286975, 0.29344884939550586, 0.7554745381426621, 1.3919612109590993, 0.46464523879423386, 0.16814037009729066, 0.377887657963958, -0.8058831716804288, 0.934558031521847, 1.0181069024123492, 0.42974119447322184, 0.2755280272413849, 0.7118528653523403, -0.2879990662623915, -0.032431142923130735, 0.31970729490030253, -0.5231701710082398, 0.1238606169727403, -0.14966991938118465, 0.27618144429943325, 0.6716176783982121, -0.3178453449760563},
    {0.15894734020284446, -0.6494828575853658, -0.5856570845412692, 0.10214542596697775, 0.1086102277933339, -0.87457019037502, -0.9502277207536095, 0.31565709011975185, 0.009596274269916098, 0.7255764645124294, 0.46031996930496116, -0.2596338853951453, -0.7381733785317764, -0.24292489532731926, -0.6012171264777119, -1.6772437977235632, 0.43163081622150296, -1.1939497236927814, -0.8797315960039387, 0.14199227361756264, -1.2188208972276893, -0.7305137908490602, -0.47937122481599576, -0.9448609058189757, -0.8838573862776359, -0.7560088953927896, -0.9294455135278933, -0.9330477257683673, -0.5429510690199311, -0.6149070817777239, -0.9188720703317933, 0.6597131061265878},
    {1.091035824508786, -0.061066308505466176, -0.6919185306036942, -1.264020567694097, -0.11888015350234518, -0.6233000256912724, 0.12053697987290325, 0.22386317646035814, 0.26550097178826, 0.015177648669278542, 0.019706245598060935, 0.18374300436750965, 0.6535942476622758, -0.35786974713946856, -1.0212102681608686, -1.0713402281728446, 0.13309729217038324, -0.6967926115095532, -0.3060650520990976, -0.7486647795371437, -0.14571075319276405, -1.1015292702917379, 0.9261693236060938, -0.4210220231928564, -0.4325500623624217, -0.09967382878432941, -0.3363549269759876, 0.30177754321177197, 0.6729817873929299, -0.4682761340361086, -0.7044110628276098, 1.5716680855091754},
    {0.7672071164808946, -0.08840307048893108, -0.36800984395748654, -1.0515366536214419, -0.16500593443599096, -1.7741124406687678, -0.6634820379264775, -0.3133653906275481, 0.49801793541314526, -1.0915627987054421, -1.1075362848767576, -0.2445426266159171, 0.37416251201913286, -0.5931553964370428, -1.3721668276836168, -0.48885005664448056, -0.420899161790918, -1.123568542175721, -0.7195642294777005, -1.4996333960712211, -0.8826302864945429, -0.5968036523134246, 0.14560375550739288, 0.24673903879506343, 0.7917149436110663, -0.6683808432239667, -0.36651585933378866, 1.0695563176801406, 0.7615797100465561, -0.46954789999730623, 0.1687801795081167, 0.17481101546522074},
    {-0.9713162359297393, 0.3086038727472438, -0.6579723343427855, -0.6590910905173613, -0.7656267611598757, -0.37635835256770045, -1.197931273586994, -0.4023873938110323, -0.543294691704385, 0.49921994354104515, -0.4115779920496305, 0.41695828506531607, -0.6150492372900446, -0.07313037881621026, 0.019642584344020636, -1.1409940238256633, 0.883305312811641, -0.46743720952839063, -0.7501478126897037, -0.6692598345776559, -0.9906254999878733, -0.5254633259328423, -2.3380052495255597, 0.8101048735154719, 0.09307244300541895, -0.6848432056137982, -0.19527945816305317, -0.2390053683700878, -0.7610298945091053, -0.6600819260018553, -0.16998132244126538, 0.06572344117785991},
    {-1.120290180152773, 0.908988437573896, 0.2823493167350978, 0.20240748408546153, -0.759278523244075, 0.1955296612374222, -0.2234866461004345, -0.38772193071737454, -1.1770719976176132, 0.4035259075858089, 1.1310455388885572, 0.06252880552751677, -0.24488450256620395, -0.8230758529513601, 0.47277295447577, -0.06018067153851773, 0.6130246181843785, -0.9462844387437749, 0.13906514941719075, 1.0446870312087284, -0.17867819970181112, -0.22041222521960718, -1.5981095874538156, -0.860476079161103, -0.3370428980867693, 0.210656905566826, -0.849783992248392, -0.7896264111217346, -0.19085257095894187, 0.05185027094473593, 0.3928008678598646, 0.9102799016861064},
    {0.6555442424913971, 0.6036173192342881, 0.24715126830169262, 0.02058765023873786, 0.4609105246224887, -0.057397451643082804, -0.33527546864918445, -0.3447707868403884, -0.7971247343886224, -0.18516271362192568, -0.3938278242536155, 0.11878021522796611, -0.09571099042984593, -0.6718344739744763, 0.16908497602842262, 0.03497748901330751, -0.6113774306719648, -1.1917299321340762, -0.29102855638042646, -0.8552927381183134, 0.08136684752355604, 1.1014391418315836, -0.41704051228182104, -0.5031668604560726, 0.42152687723572263, -0.2636555329223247, -0.6456495094752106, -0.7827338647597686, 1.1481086763826303, 0.9383207569708717, -0.08006941758969706, 0.41980983854303744},
    {1.2338179089199486, -1.0697399417995983, -0.26995740712484606, 1.1084451486048768, 0.203878746951413, -0.8604909063336057, -0.030378736357251752, 0.670616040580452, -1.0925587320719974, -0.7126610572308733, -0.26434595539068756, 0.6076764065506917, -0.5942623980302609, -0.40844903686000167, -0.4063864714093236, 0.1982304490765139, -0.7187558178577689, -0.3305686695959735, -0.49439650684420855, 0.12502632232436692, 0.0772575938611301, 1.1794842092820315, 0.34651780877389554, -0.7508495583181731, 0.21642855666016383, -0.06323898137115169, 0.5922786891783238, -0.1592483164225161, -0.5943451529228689, 0.7397125675335047, -1.3603823348416058, 0.0728928285346447},
    {0.43281258370004666, -0.009998252957575159, 0.4697575682808108, 1.9728603937309048, -0.05837955010494278, 0.889848934311444, 0.0018329877763780347, 0.5541919321246279, 0.8782950500324951, 0.46352836448198387, 0.30039402866047027, -0.45695132280342204, 0.6741444085958829, -0.8446680671838308, 0.8883659114145418, 0.23769102069243322, -1.2781522058249148, 0.9449940024959, 0.5978021995144885, 0.26441284059578285, 0.8250496199649905, 1.432815530269591, 0.2338448380489798, 0.01714243824892017, 0.5587615707067799, 0.5820810307433455, 0.5111508284747892, 0.23281852969943342, 0.036075732784952436, 0.035608073485031935, 0.621949109288739, -1.0025266828773136},
    {-0.004670601437134784, 0.49837179439111995, 0.22564904472173752, 0.6284091550015553, 0.012794521270826729, 1.2471152371936107, 0.8462055967459909, -0.3037343814377366, 0.7359929001809529, 0.196398205102576, 1.0225584279167546, 0.8548932113647751, 0.5703992581687019, -0.009538707030306069, -0.09468635891929805, 0.384435268632956, -1.0929919158514663, 0.5673950273739176, -0.4751346570558462, -0.12743926208707387, -0.015587886742005865, -0.04171218983410913, -0.42371676901435706, 0.019981233144055616, 0.7185064443485105, -0.16852160641847283, 0.2478890602582941, -0.04964376387904337, -0.016305162051492822, -0.5436382200744639, 1.399604330215582, -0.1121745223215938},
    {-0.4591711045648103, 0.7464261481375531, 1.1664871133740085, -0.6841554002866398, 0.5107450532490951, 0.02326741529827623, 0.7432051870473929, -0.7298612608117984, 0.09628213213827959, -1.2656108490195381, -1.3100184503794416, -0.560040543865249, -0.3484501354574516, -0.5020251452850428, -0.24813131002281458, 0.6396513268632166, -1.6230887512527599, 1.0782230711378753, 0.5693182433086593, -0.002231164258043053, 0.41155651027381224, -0.46315960512319326, -1.4875746929593148, -0.5293740923241634, -0.5446798677201257, -0.12554626330384477, -0.5094713042994378, 0.3774063716125524, -0.7353286380076363, 0.45090203808086526, 1.6216770198920119, 0.32412585870327165},
    {-0.45565339384114506, -0.641264799823148, 0.40014736456745914, -0.7475985755754802, -0.09055905388004554, -0.3074329412418238, -0.36252610865076484, -0.12029178174380345, 0.03310669449500825, -1.0348100687012043, -1.5222790775286807, 0.02649126527750332, -0.3939025196146391, 0.7149966584124128, -0.5400347872528292, -0.2949640576636078, -0.8381371656704265, 0.31599692422667763, -0.3170426571580582, -1.3349363195863835, -0.6201514827524061, -0.18655291570540544, -0.4021319546027983, 0.07974519870657673, -0.4832027980154408, 0.18508399205488787, -1.113391149954997, -0.45438161535484584, -0.7216570545834501, 0.14599688248513243, -0.2354307634390634, -0.4598641712014502},
    {1.4500113104668222, -0.34628169891126237, 0.3994777087484144, 0.6360284832529083, -0.07378901986791474, 0.44514767819426565, -0.4978823457041031, 0.2708089752778231, 0.6065951784031135, -0.8735849040837437, -0.08873640384704241, 0.36890403440190095, 0.4187052071274961, -0.8621215793475935, -0.2389587876031408, 0.5691169397031284, 0.7479558287942075, 0.3923868550851568, -0.29101183718476126, 0.043042124905615764, -0.5705847623313978, 0.6876287477863203, 0.02904465893593853, 0.6959354950045944, 0.012307520941643734, 0.15655276738132476, 0.4425412447232727, 1.0523616786020464, -0.5197096766506122, -0.2132979177408751, 0.8073729843378264, -0.4841369558127467},
    {-0.30107196594635294, -0.14393726426396244, -1.6379782781874992, 0.22111795103405069, -0.2858970733306214, -0.41407736958232755, -0.3015621674021138, 0.18246124846654924, -0.49000018049850946, -0.3889034674016418, -0.6496411848055631, -0.5710426990068698, 0.3774766138386108, 0.2671966614241033, 0.4124968058488793, 0.3369250255957915, 0.2865115581855022, 0.3072071612077685, -0.20658892591682348, 0.6159162431030185, -0.1503267729486576, 0.7492636453487139, 0.07894097465044604, 1.0429725562058392, -0.18732437148842485, 0.4943373330908374, 0.15354554197455422, 0.7712051380745569, 0.012636869333518779, -0.46921473110163764, -0.1568843803255023, 0.5627687908009429},
    {0.6457651117725263, 0.6575641350103467, -1.0084885324920851, -1.0753218357898562, -0.3795273425027211, -1.348420129277769, -0.9646909423517878, -0.5700606444144465, 0.07970227653118918, -0.9037205789069042, -0.3068525825940121, -2.14739694014445, -0.07782865553341552, 0.4164392354188905, -0.34095142139977497, -0.07774988515495883, -0.24717514555114564, -0.44543100194579555, -0.48768413946628203, 0.025639598590516375, -0.845093417799947, -0.41692678183044296, 0.38263388151586125, 0.47440476578762275, -0.8935404433115125, -0.27936234589615216, -0.9275437354758813, -0.525933859771634, 0.06530033452665651, -0.07469052179265202, -1.5729046619986693, 0.2632956667309583},
    {0.39485818826492947, 0.2059790380282424, 0.3530992962446101, -0.20316859611047713, 0.4758368524635409, 1.2468806072070293, 0.48607971922300125, 0.3031405844522533, -0.8868746734818403, 0.7663672206792443, 0.4931313129874647, -0.6849021246363386, -0.025204264443168624, 0.10321260773949989, 0.38384211642880806, 0.316973212847037, 0.21516731984959397, 0.36177477855451773, 0.1942450544968657, -0.0106718294944643, 0.5611491788428267, 0.02109885798241641, 0.07815771178265357, 0.20365187677427266, -0.7486332309574988, -0.30745137745142787, -0.22996796799153404, -0.18383705845184753, 0.8779946672711049, 0.2186418492282098, -0.31756001979917503, -0.265677278008139},
    {-0.6071195508466953, 0.45429487297083554, 0.4048988998420707, -0.4265483790748058, 1.0156008859013985, 1.0001554310154632, 0.6416643133758326, 0.4769778996409499, 0.09357240903519294, 0.9368627073685896, 0.3180739910497336, 0.4730557978960975, -0.16345582663224378, 1.6204830302941482, -0.5556900408698969, 0.21544337156788554, 1.6126859468291035, 0.8386489346674142, 0.6600108603242094, 1.1651518754445982, 0.07978507910807354, -0.3143815969448538, 0.27596775318625383, -0.3513712373761489, 0.40815453254737855, -0.36836098382483895, 0.5882205975678969, 0.21874122063493137, -0.08072345294968174, 0.12517153400732053, -0.675508244556074, 0.3708108583565396},
    {-0.905629304954289, -0.07792225186952854, 0.09175541483485752, -0.13047129095284396, -0.284130734844606, 0.37163474008498165, 0.018035541515495034, -0.008692758759897048, 0.5075977474772708, 0.028938435246999065, -0.29845894653547, 0.4309809012116352, -1.0103215158133467, 1.039388126596315, -0.44043865458764564, 0.02140099055295467, -0.3227325462259597, 0.20997938281719572, 0.0923207777074426, 0.14466873239632141, 0.26584694472054066, -0.6123088092878612, -1.0301841383275705, -0.1710325124202151, -0.16332177805850503, 0.2585433716953354, 1.0749671282519213, 0.45080101778815845, 0.39965952427810075, 0.7608515763250493, -0.4763420081032904, -1.8270561499612359},
    {-0.6267113378414283, -0.3638751742126867, -0.08537215219425473, -0.6153547675739778, 0.0725231079728784, 0.4298879758891313, 0.3097397423554549, -0.09149778475083144, 0.13623511928944027, -0.4002837648042686, 0.17003011447096017, 0.2928342558414567, -0.686342609970069, -1.1387534071145733, -1.1045235063820604, -0.6645845409928668, -0.4419665786445952, -0.5427392227664791, -0.4422746437132227, -1.402840015551609, -1.1644287777980287, -0.7047603904705424, -0.2424872802950873, -1.0835023649332254, 0.8091724491942475, -0.3174869547602397, -0.5224683473162216, -1.101085811067152, 0.051734421765571456, 0.10669116850099153, -0.8374178456502992, 0.8282409533069065},
    {0.7239981619518986, -0.832188411324023, -0.4982457242625171, -0.7521589292694507, 0.6838958829277059, 0.018101542435927882, -0.10229759846186427, -0.3832636647319137, 0.007265257455268212, 0.5170931553668197, 0.06873247082549246, 0.18979904135861403, 0.7958051976753608, 0.7225446775264281, -0.1540799420748853, -1.0928605955276491, -0.07264670784201253, -0.6140076824731728, 0.0609971321396991, -0.49547139428399417, -0.4855057524338081, -0.832014930137838, 0.14486432994638612, 0.12192047624751587, -1.3008758613302804, -0.7908009552037044, 0.04994465258316388, -0.6022379301860011, -0.32078517150888636, -0.2926988567823487, -0.3778535564258053, 1.093014791008886},
    {0.3723737162406589, -1.344373773999915, -0.9434880598685392, -0.10868665585328112, -1.2913262560871102, -0.8992695625147719, -0.9444282304768392, 0.5935189460566908, -1.1643385160968316, 0.08349970012319578, -1.031406205907973, 0.6710120339198428, -1.2996222567310465, 0.23014302138950882, 0.3605996210155229, -1.2502482085382096, -0.27521191641886666, -1.0973330541288395, 0.5173033764168952, 0.2139582878062941, -1.0081552091086312, -1.4425578640333006, -0.21890408951351886, 1.3393722824540633, 0.5269899557228575, -1.0270261574972293, -0.7359431090630801, 0.1798128637232575, -1.601308245168381, -1.333116322803641, -0.5836076132355976, 0.7273533669311079},
    {0.38523261381064755, 0.17003296602853812, 0.6439431159665918, 1.2579280730693023, 0.6366805295214188, 0.23738717569429912, 1.1906370595526945, 0.14741314397783534, 0.5950656801145287, -0.07463516759881325, 0.06524810314781164, 0.3683822038990461, 0.4529582054924064, 0.4530811440191833, -0.32415751240740226, 1.048814562725806, 0.10395536872626641, 0.5814099972988337, 1.0646588494976796, 1.0178858725734197, -0.901596928442912, 0.7474756063285172, 1.1037230191687772, 0.5841732423013561, 1.5051359538720686, 0.8466165503996219, -0.3532892337326551, 1.1487467128117055, 0.6352757520967486, -0.014128543807882208, 1.3382938484144353, 0.5705858191598164},
    {0.6295760898714414, -0.7507398648189907, 0.22503740046247814, 0.23293545687759593, -0.691586623531704, -0.3055342087872106, -1.1073070847905842, -1.4080386121405433, -0.5958468518507324, -0.49134485510195797, -0.8856585400259206, -0.22522528595816413, -0.26852882575619313, -0.2532801832992717, -0.39233932879855027, -0.5961507526895424, 0.3646233382208493, -0.5602850122810537, -0.13432882184968295, -0.25259337513807056, -0.5301293617154543, -0.529488229037514, -1.5484190177683235, -0.6108498715195099, -0.798391035604347, -0.11738921769379204, -0.06826328693562439, -0.7052914308063902, -0.7503189704783809, -0.46889231293585176, -0.20576399186350197, -2.0329814842785985},
    {0.11635897108989277, 0.09038114651011285, -0.32110676621193246, -0.1935845139797926, -1.0434850648427247, -0.41934417140973584, -0.20734336170957507, 0.07289644319537593, -0.2054883063622492, 0.7285941450601225, -0.5253067349843328, -0.016418221258410658, -0.2979209107197148, -0.11816294902420132, -0.2839376020260469, -0.5093232577722555, 0.9547270477922171, -0.7259418074905423, 0.0579002362236057, -0.48035530126633, 1.3981963223033782, -0.5394658719153435, -0.6823560746326479, -0.31260526371416153, -0.9447105265364999, 0.23954796458868646, -0.5476334465054358, -0.8735397008250537, -1.0623881064646974, -0.38163777561755174, -0.30207055827617546, -0.43657836048792725},
    {0.5956759569675534, -5.899122959499053, -4.609314845482438, 2.114002197445083, -5.406835987262514, 1.919285990461083, -2.8389793460920147, 2.037738162706597, -5.082057732228553, 1.3988384173167974, 1.1981295299337733, 2.890911812659068, -4.559844158629973, 2.1868783082573944, -5.218738633153729, -4.642055356080205, 1.3478441646464319, -4.405835866945343, -4.608855535104997, -2.9272512864652502, -5.142173186656416, -5.4305507293579165, 1.441463901322763, 1.524153934112923, -1.588214517907069, -4.617959271890718, -4.5814289243584545, -4.19989831144531, -4.940373862749887, -4.5730686588978395, -4.707884744743755, 1.898113757935288},
    {-1.9303634460674657, -5.854812669350499, -4.490532413741965, 2.3379018664694864, -5.745571937557015, 1.4222931059748964, -3.0833874714928156, 1.9692380540535808, -5.071637597370577, 0.34778264825842065, -1.548495305588393, 2.8407491934486813, -5.545934883334398, 2.9946775237433654, -4.449523352531149, -4.875348109184512, 0.6975952928178207, -4.010590124361041, -3.9169566674231797, -0.8921576498586005, -5.030464975568188, -5.189946698676384, 1.0612600054956796, 0.3856088446172252, -3.0711597094509338, -4.925096606772774, -3.6631865068902223, -2.362372934325261, -4.676913695235739, -4.725175781862746, -3.7693914297818685, 0.6910527035678597},
    {0.4727294146300009, -2.440505982704312, -3.460335104922211, 1.7137435942508685, -3.8344606862626276, 1.8820004533862784, -1.576607148944151, 1.9425505368376161, -2.4794399402399403, 1.2554817807976921, 1.8390450670444507, 1.9713902459534498, -1.0589214389245891, 2.9295777469987487, -0.538508651155234, -2.706509863323224, 2.755514674022807, -3.068747076316094, -2.2681232751405154, -2.5521274759278016, -2.431213114812329, -2.623367795165247, 0.3329000491370513, 0.49248262296876266, 0.29634226799158936, -2.5719042750600885, -1.3651997397757412, -2.5603847690733295, -3.0860508671200937, -3.331645877782875, -1.3964030881502207, 1.337116734609884},
    {0.8679174225210894, -1.6818322926917237, -3.2913366030235, 1.988813584557018, -1.5253826935848476, 1.5490404484848936, -0.9583618091665864, 1.5813030093710179, -2.4866369912688038, 2.225928457219001, 1.6334588466914801, 1.6306311570586458, -0.32348091283787545, 3.1142649625579057, -1.1849789625904106, -2.4539444677041646, 2.55437243000803, -1.8522959793755416, -2.0557764482601417, -0.6117652103579776, -2.484876131872049, -2.1967255764128204, 1.7436785711960656, -0.09832160049034101, 0.05238836190335562, -2.050351471424487, -1.1187766111510218, -1.9781921843334622, -2.545526158907342, -2.7197967004152486, -1.6214769423674162, 1.7993801448819307},
    {0.49511741297567646, -1.5444660273236317, -2.4051738965146154, 2.01148222922935, -2.02842311266957, 0.9797891699497383, -1.887721611796358, 1.663069240318372, -2.8159102466507537, 0.3835099882577625, 2.1577061351903186, 1.3449092821986282, -1.4640771930568268, 1.937963858134847, -0.7583705590138473, -1.9708343961853594, 0.9469248801212419, -2.137169327944844, -1.9927888397684235, -1.6620043973843563, -2.549053602949043, -2.553864729702489, 1.101548449875372, 0.22039754482302662, -0.2831922588265248, -2.0629411668035362, -0.9352260006593507, -1.6692654028555611, -2.357876797822766, -1.4403258519205513, -1.5792541264050874, 1.3532430072118464},
    {-0.8390504051719743, -3.4203499496709857, -2.0646683311162715, 1.5239425608184503, -1.501836284715679, 1.6178820028742165, -0.7791792325261168, 1.108242459233667, -2.2310901059730606, 1.9749882413643223, 1.4657367904419387, 2.8025187922096877, -1.8602883443885485, 1.9632130058888813, -1.6366180378025788, -2.072553612391823, 2.675582002863888, -0.7705688450375607, -1.2420256339332454, -0.4561802347062327, -1.471928241586688, -1.7748496321268574, 0.39407576147561924, 0.6846952585648837, -0.6356382228262435, -2.300401576747838, 0.04214702125155206, -1.2184457653161496, -0.6364179853790338, -2.342289773967284, -1.377063856028072, 1.0475949175448194},
    {0.3673435313452886, -2.0962815242300756, -0.8432645598141243, 0.7562617193298061, -2.0175792464871027, 0.8853073289843703, -0.10076878486668145, 0.7058206220554012, -0.32921260880820385, 2.002656937968609, 0.4300296074105468, 1.1891073057394723, -1.4415433638900341, 2.286508635278898, -0.12089470318867014, -1.0137889260091162, 1.811104419430047, 0.5554461538034654, -0.44548003895752397, -1.055118631725581, -0.5978061049678163, -0.8162531393361383, 1.1479102087280144, 0.8918300286216297, 0.6818036637802544, -0.5181413530960665, 0.45267664804292307, -0.851948898356577, -0.3605406323929002, -0.3038298266363585, -0.49429698008259404, 0.26321980166081305},
    {-0.8620465940941567, -1.9403032772799977, -1.196834201453907, 2.4167045132128244, -2.6280757665182444, -0.10304921587746867, 1.0935833573772011, 1.035865527164361, 0.06420453974597569, 0.4714929393568715, 1.318141334395394, 2.7914769579824283, -1.5712198268055781, 1.4700274904543853, -0.6136132596175021, -0.8155194215990312, 0.07616535986902277, -0.5625677691342796, 0.20870427013307621, 1.364940532272072, -1.5713193459475765, -1.1796271017677233, 2.647229789965643, 1.334206268155961, 1.0474505648231274, 0.813102783131993, 0.1628033933855341, 1.0836155634831806, -1.4602813794945608, -0.0015261292372102731, 1.815595869549445, -0.5358928970607209},
    {-2.053336731712767, -3.1719013931834263, -0.7722758354598313, 1.7842984155542525, -3.302672607093126, 0.8748330161212999, 0.6247450014643434, 1.2812275179390518, -1.3866317077980348, 0.17069771180776974, 0.5231630739361514, 1.8927994887239072, -2.9863741469557445, 2.2442246253380613, -0.797306869163297, -1.2732315531922016, 1.152681938620944, -1.6972448741221458, -0.4411734731772073, -0.7118287615258909, -1.504597005840345, -1.9236156790575891, 1.4156748185682582, 1.5305134538424927, -0.373538488574524, -0.5150720511895567, 0.08733166921953074, -0.43941446531490136, -0.2864819390845034, -1.525273475629232, 0.45204891060087593, 0.09275716889089926},
    {0.4934530167254424, -1.6617165385859882, -0.31618151406111733, 0.6671460976131829, -1.3879228569133162, 0.8951230580903604, -0.01595703580565356, 0.5545223537322942, -1.0816226949118244, 0.6315277558862628, 0.7984296227211454, 1.054355494012366, 0.4458700034207117, 2.9376643271059946, 1.189334974476454, -0.24107768396075055, 2.3242229079965773, -0.054180710424379094, -0.48907383194271936, -0.3777756897080535, 0.524860964374459, -0.10085322229039081, 0.5161141019229386, -0.17590645364133348, -1.3320792725910262, -1.0774784674044877, 1.097697922769028, -0.29465953621435176, 1.4040506925720109, -1.985252107707656, 1.2211462126924746, -0.48300829565139813},
    {0.9886088150053368, -1.1793279182238017, -0.6838356469663955, 0.018001060363895996, -1.7415042526395745, 1.560207549071556, 0.149915331647831, 1.6682735824660506, -0.20744311050098668, -0.10654744733082365, -0.1646503983595187, 1.2751502237795387, -0.20293331426201883, -1.4501626618869312, 0.19805405675129573, -0.7451328771036769, 0.21813155610656815, -1.2152645410660334, 0.10766172010921633, 0.16933041731590256, -1.5732968206436437, -2.0070980079103133, -0.628577329604416, -0.8504795888154888, -0.8313272132107892, -1.349574720756655, -0.5009861899061905, -0.25600376489493115, -1.472522497228259, -1.9667321747134727, 0.2680041763223619, -0.5807522448965212},
    {0.2747304552447578, 0.22818063371274191, 0.06334842495196816, -0.06507919105757325, 0.5472091211273659, 1.9819084176411383, 0.867313768957116, -0.03274562119892425, -0.294677744233127, -0.8246130736279723, 1.598365850794815, 0.6808518937744857, 1.0849677412873722, 1.0448400686087367, -0.8689190988107354, 0.455811950163098, 1.7555375091352792, -0.23924356582028453, -1.029412427590805, -0.6040775676677375, 0.8933521190044388, -0.5649251753964556, -1.0488144776529285, -1.0912692282487482, -1.1953108557541727, -0.11427646983866795, 0.8754554006445767, -0.19386719429119637, -0.021541220137507054, 0.5423142480281771, 0.7618543480194543, 0.3859782022226326},
    {-1.8169699900440648, -2.6869797696338664, -0.612170572400753, 1.99491973551891, -1.3748285331189694, 0.4451206065008665, 1.8850585614189421, 0.3786532827902528, 0.5699834674955457, 1.8131560055370994, 0.2589694839039735, 1.5201110475672752, -0.38822308511010317, 1.8553407967811006, -0.29661352214369047, 0.5671736866114321, 0.06574894547791939, 0.28776278581189924, -0.15756020344868435, 2.000724570825013, -0.2966465007153359, -1.002468139900669, 0.21574860170903357, -0.06748969019460298, 0.7209791994097721, 0.4106540297707643, 1.1864403484190522, 1.136095472032638, -1.3377994359376988, -0.6900550604857265, 1.2592101159694604, -0.3498058770030844},
    {-2.1709365859193026, -0.6213117168803931, -2.164059178426494, 0.8222485499641221, -2.4575881897002545, -0.09318369473069349, -0.1877572362444172, 0.5588020439333344, -1.1962199187443248, 0.39826184859438923, -0.2607918775174274, 0.49558560463275736, -2.585141561302368, -0.2504530084133113, -1.4595026958797959, -1.4431150517820903, -0.2730983950741738, -0.9942104199775288, -1.9074468658824468, 0.8110239635940859, -3.147616897558601, -1.4452370866339803, 0.45971342514817937, -0.31025701212782786, -1.1865895964252229, -1.384371598477398, -1.2258038243798948, 0.45528482990887226, -0.6647680847166311, -1.3793905802674824, -0.5020172214030008, -2.5252587157033024},
    {-1.8136103307494857, -0.8025335978968957, -1.0774759953465325, -0.3321013534318926, -1.0694857520416854, -0.3082453383383768, 0.9755154524225286, -0.7168570474063181, -0.17268629156833334, -1.2291519540284086, -1.3009259690082764, 1.9351765566217702, -1.1498008457641877, -0.6210311039422319, -1.283852515239925, 0.1326897165683162, -2.5768474202507248, -1.358400979557292, -0.12450889085604323, 0.03687500793933806, -0.6488839006490249, -0.6620414613076377, 0.638958982306395, -1.4983225592623595, -1.9970180059728246, -1.4950787271700243, 0.9023255217558702, 0.3715813637621395, -0.9181174145231343, -0.5572845668272732, 0.7036317735995046, -2.309076162678255},
    {-2.8885953746226867, -1.1418137782720559, -1.0767212776467874, 1.6686474002331007, -1.5021538341313292, 1.3551436538068775, 1.542596265873981, 1.1823853450846769, -1.269315104688017, 0.7944424287571851, 0.5928109956172842, 1.9890519331406356, -1.6511901944116383, 1.5415221830547188, 0.2810235817984948, 0.7924917251392106, -0.33949334070547493, 0.6184217457508752, 0.07242414289602285, 1.369324723695175, -1.252623371542581, -0.8469614671532291, 1.6076025982094808, -0.8635189198379156, 0.15634572961608195, -0.2158881708954977, 1.902603283152959, 0.8242300400054966, 0.39057423863650725, 0.32487867396174047, 0.9397136224563921, -1.8348101327117026},
    {-2.8723637808247604, -0.0708765682251361, -1.8998697702388112, -0.13851731846411597, -1.1529309707119995, -0.6965738944888663, -1.1530644729206092, -0.8720105037774861, -1.1869078330328098, -1.3806447156408737, -1.2229405716435735, 0.20767452817132792, -0.3370167108867066, -0.6153426840520658, -0.4355054200900612, -1.3119102768686366, -0.7603748253896425, -2.350148515700488, -0.734008706205512, -1.2093025179126136, -1.2604710473178689, -1.253487260234326, 0.7540130217234606, -1.8287321071498321, -0.9029552982904042, -1.4682668399497878, -0.8175804451474196, -1.2200636931069486, -0.9786291603578166, -2.194676142243738, -1.5010867139200976, 0.0019453156605055719},
    {-1.6349661559012698, -0.06092980901008693, -1.4802809941693746, -2.2332206992449413, -0.6146359144500457, -0.5381954408808339, 0.5075736320449634, -0.8482344779291635, -1.1606056479806781, -0.34728201121185065, -0.2541838012596005, -0.09002983529291306, 0.4265363341956478, -0.594652144605166, -0.8579941347281069, -0.06275344240465781, 0.8963897178883155, -1.3555154880126912, -1.3119064802161544, -1.718630521019034, -0.11364418910213268, -1.5010428589095317, -0.012789178085976216, -2.204802492057566, -1.90817632765047, -2.099470635898675, -0.651157187162722, -0.9210875059321088, -1.950488145924927, -1.7834627685739934, -1.738493240285347, 1.0834535935409695},
    {-1.2035043728741637, 0.1504587794587415, -1.5367838790133936, 0.96320648854653, -1.5274606334914802, 1.229707035007268, 1.0087240445402281, -0.3228602248082308, -0.2999610814090577, 0.18628815216126765, 1.1014488078819133, 1.818632446560044, -0.1069156217689148, 1.0926508264326535, 1.1131294362250812, -0.28743148123343537, -0.47264691446711754, -2.029976890546168, -0.5138638192863003, -1.724924880299154, -1.3054576825077524, -1.423204798914102, 0.02433904059395335, -0.581649572640261, -0.4926730069574927, -0.8243933545302886, 0.5745560043882122, -0.9466006769007113, -1.3451603848425635, -1.2307769813538143, 0.974943813685302, -2.1055120236239406},
    {0.0613761051866842, -0.6434503056786892, -0.5954188605205046, 0.4238558813406187, -0.2295476846718363, 0.7193887400276235, -0.39103957935364997, 0.6831373128026339, -0.3695485548264701, 0.37188800376763254, -0.7033967926002567, 0.29602418289002996, 0.1925885212303613, -2.372580305105437, 0.6843453423483273, -1.7240028371433778, 0.31928912903485185, -0.3724906865355702, -1.0194982746159482, -0.43936413722334594, -0.6045533925293445, -1.274907192668339, -1.3544422680014212, -2.8942951923019367, -0.8746525650010066, -1.505730531871252, 0.8850861162790179, -1.4519478904541507, -1.100996355389654, -1.1950346434088919, -0.7852976185516104, 0.4146327761473844},
    {-1.1729907784398814, 1.1370683310509517, -1.1871764613189595, 0.9268735050606415, 0.132377666684328, 0.7894133748839669, -1.4197370107079184, -0.8380600233763598, -1.0084150197295203, 0.15985371857197853, 1.536927632685331, 0.20245300483312995, 1.5245876827398865, -1.5159725209103723, 0.8548518435706495, -0.5752533015956585, 1.2157141504607913, -1.78673340611789, -0.626017243290914, -0.1840708647488566, 0.11635252571232434, -0.7146278464955386, -0.368047709839388, -2.4727678329458986, 0.15226812719061988, -1.2345926733759374, 0.6366097646538699, -0.03467685132871262, -1.4165284980009982, -1.5956259198604124, 0.7579426873906931, 0.2822011483447104},
    {-0.4832517887354138, -0.43641025565050523, -0.3879806338948828, -0.49356550043100744, -0.4568611778554184, 1.2051574873453996, 1.4780725326087654, -0.7485163825094207, -0.44635154790219445, 1.7201494291423407, 1.2423752362512634, 2.5970774912729544, 1.1036252122610117, 1.206044809647256, 1.306402884133137, -0.7082860638710893, 1.1762809693095682, -0.6231963824662238, -0.8048504794929848, 0.16683944051659091, 0.9580836271934684, -0.792527641501841, -0.42523410600038775, -1.4454855635270203, -0.6784861840402624, -0.9423848382351883, 1.4282117485438184, 0.3740089853747451, 0.5854957933825741, -1.5698192231451529, 0.5452440298516634, -1.0667079005792737},
    {-0.8925983749828519, 0.5377429508849801, -0.5536378801362106, 2.2608257222934114, -1.3991575752688021, 0.418454628546729, -0.5368390340944095, -0.015173327826800328, -0.563976465822692, 0.1815827841445298, -0.7541282303879338, 0.45534417626423934, -0.1827151232875324, -1.5689864060877783, 0.5452888745185189, 0.31140851789073226, -0.09007122430094794, -1.7058103631722945, -0.690915714479245, 0.7135884884182799, 0.041982567642569565, 0.34250670858550375, 0.6634941129321759, -1.8445357756427898, -0.17689952452768956, 0.26232438102013417, 0.5185415467753888, -0.28905014145293895, 0.3349234518030275, -0.7687006279676131, 0.9740646187069404, -0.8382636954962236},
    {0.062149464728011417, 0.954981580008172, 0.26123645970105097, 0.1602730707762903, -0.49174038326304104, -0.2747543742893409, -1.0576092068991998, -0.9931493380283808, -0.6099793614900249, 0.4411370342884579, -1.2315750870577078, 0.09467516281801407, 0.684336917768809, -1.0441779242179907, 0.5328057174696325, -0.11314144978498479, 0.8215355246021028, -0.5447907915178484, 1.4758768644658702, 0.2987052361739947, 0.9852679610849656, -0.5415410021175382, -0.04972467159764116, -1.0812348719101532, 1.3299679092143355, 0.27998774230214873, 0.1567998699146677, 0.4993168988177226, -0.41515887171550847, -0.3234088945131181, 0.46688158689035164, -0.9340291540373671},
    {-1.7718359279835, -1.8233421207534293, 0.3297525968874971, -0.5709249384439887, -0.7225770051217721, -0.44302849453403625, -0.28249416964535146, -0.462724397499069, -0.5280225911406142, 0.02819853272628425, -1.6443330535380956, 1.1488144186386582, -2.1776163017005197, -1.2446854620817327, -1.3607936132654996, -1.2850576397449247, -0.6896657550021015, 0.551910154003641, 0.5593472442259028, 0.3750719042584861, -1.2309910600345695, -1.3647531345742165, -1.7154059975627212, -0.5089179326897955, -0.7680280988920268, -0.9581831201717677, -0.22792634875603374, 0.8356694424524892, -0.5856295459261358, 0.013726342663902156, 1.0763832439470937, -1.180981577332447},
    {-2.6563394463825483, 0.9157657902223345, -1.3488007515300342, -0.5596238273200036, 1.3264643255793864, -2.170298538956305, 0.00907307267099518, -1.8016100522987688, 0.2555162143229942, -0.5319084959772796, -1.4877596647101559, 0.683368840736957, 1.0178809187727027, -0.38728547477897324, 0.3213458431145123, -0.9940760939637056, 0.4504419902793272, -0.2726019040784864, 0.06195139376183017, 1.973643267692718, -0.9912006766119985, -0.3954739367874265, -1.6430833763827308, -1.8540625785160094, -0.541736055304019, 0.3420441139846256, 0.750717822971065, 0.625370197180174, -0.23196964520664093, -1.2332966214528933, -0.8014857973051807, 0.815025590958251},
    {-1.8364814583810434, -1.5134151068716062, -0.9594632567144012, -0.16772761874619427, -1.023999192121332, -0.23350287546437765, 0.16148012608825363, -1.0246937526877808, -1.073931083335409, -0.3020676840322155, -0.7252898302852991, 0.22438675346245776, -1.6163270290986183, 0.9217348855953679, -2.0063844707719007, 0.462982590208392, 1.0155537452143828, -1.607579819642965, -1.5814978983945926, 0.9986967540754302, -2.0837780170005975, -2.2023497772653773, -1.4629369471533413, -0.9820537570104009, -1.4841101067572868, -0.9595385782914674, 0.35519339427458096, -0.08331015916832264, -2.1953350607769777, -1.0316192191718851, 0.25977033634562857, -0.9595932584568461},
    {-1.555882600615642, -0.3999462230896132, 0.057696712710621025, -0.4775238110739124, 0.15536938679181697, -0.29210437557975616, -0.7523809533578134, -0.16406291445980517, -1.7516598932900578, 0.2508363330019365, -2.8052824355949864, -0.8029730971794065, -0.8971302228630295, -2.9422469372944335, -0.74612466962572, -0.6698798758851965, -0.05981750700071429, -0.6074876014506165, 0.23080176103326236, -1.3090876329308367, -0.0027544756515496746, -1.1795631166859717, 0.6014743846878614, -1.98114370060274, -0.7112973209190283, -0.9572892514812309, 0.13284722469321603, -0.03250275321439341, -0.3392493017995591, -0.9426854693781862, -1.245887042031102, 0.7970648667294337},
    {-1.121398409704461, -0.6889555807288119, -0.027559413156039558, 0.05653620813396252, -0.3779298739156764, 0.11101834829951816, 0.3167156656268169, -1.0971056261027996, -0.5561418318982582, 0.7704455800577996, 0.08320133339941706, 1.0817957279426493, -0.521220471883492, 0.7907339853539429, 0.8951208973259623, 0.9730749254337963, 0.2647105965471775, -0.09193418660759053, 0.7242534968003222, 1.769080139453139, -0.31906180229312003, -0.10083412970459878, 0.4793992174328433, -0.9068827382194058, 0.6939835836250908, -0.32215753300253985, 0.7800632739061503, 1.3339854869619714, 0.5870058426343855, 0.09446716983531346, 0.8232647706933494, -0.8637000064372468},
    {-1.9396398340841963, -1.6225259583557599, -0.33700791101578687, 1.793795659465273, 0.2570501583351457, 0.8120269439336453, 0.9262954015359112, -0.9120446371177255, 0.34540316857900316, 1.1704913076254657, -0.6925644338298989, -0.8626664413801053, -1.3577088750485806, 1.0950775115384608, 0.11031258463515996, 1.633909847665658, 0.4141946744442987, 1.0142653112214561, 0.7049253538156244, 1.365350121271394, -0.22617769896691609, -0.12214172228036187, 1.3787856215139898, 0.03932742169526765, 0.7026199283421626, 1.0781006849684753, 1.9628696028436021, 0.8424461892463734, -0.9300285606463359, -0.20202162019649583, -0.5204410538435565, 0.7242654663660529}
};

static const float b1[32] = {8.40373715911717, 8.231311562187347, 8.129331164955982, 8.12595413555299, 8.192959041637549, 8.183961354510352, 8.036672362829803, 7.9783983250265385, 7.987121791909531, 7.8269728968834364, 8.025691491898737, 8.283154265679197, 8.146467151221291, 8.085913204356569, 8.19094313519652, 8.16135523715516, 7.951125199747009, 8.144420999219196, 7.953139615071923, 8.178568234783192, 8.161028413732641, 8.110550581176671, 8.189303464944476, 7.9546632856180395, 7.82166202490479, 7.853169640849421, 8.199803016578317, 8.12614181017835, 8.045596709672116, 8.134826414174825, 8.125442009073575, 8.372945795453456};

static const float w2[32][16] = {
    {7.54158164131152, 7.717596795766041, 7.076975705469527, 7.770208643046787, 7.544425131827809, 7.19353419415917, 7.448529324646253, 6.617134838018296, 7.16599018556458, 6.706549298843463, 7.332757672842322, 7.642484717740347, 7.406696405681235, 7.398560301071165, 6.674880013579082, 7.452613137000429},
    {7.920891375575825, 7.922741613611115, 7.209032031296955, 7.64738745722363, 7.876592772712857, 7.723207840402801, 7.555536092713302, 7.121839207561885, 7.471333879765415, 7.295499505470752, 7.091523282106717, 7.63752929155375, 7.360897741899903, 7.313907928145562, 7.453033523466024, 7.082717684050944},
    {7.2067372760958985, 7.2514522256469665, 7.213467930423379, 7.173131260196039, 7.877262805307615, 7.508826580096109, 7.419129309935335, 7.395950337346147, 7.58474240609175, 7.5496922935219475, 7.432031478676828, 7.023577837818791, 7.147977729671091, 7.466497784700178, 7.370584486648069, 6.979011528682326},
    {6.866317617722135, 7.417492236108545, 7.423133695316656, 7.796983841202537, 7.199962679503158, 7.298246634857588, 6.982606959910411, 7.121885796537529, 6.869436346199711, 7.369988004467279, 7.656141841219059, 7.45569729482368, 7.390491335790939, 7.536807764368094, 6.846355834963564, 6.771725088460579},
    {7.435647724355361, 7.702610353351843, 7.660797798830819, 7.543582906914863, 7.309186058443493, 7.85210020398835, 7.41775080759903, 7.468929556034446, 7.347327693156604, 7.50392465162759, 7.2839132994744205, 7.736734236528284, 7.652562255053982, 7.214306115095658, 7.994429707339345, 7.5964765480349445},
    {7.505801612204123, 7.769598442631173, 7.261433752285477, 7.42244737771347, 7.483282312862897, 7.859738171462726, 7.5032615127224025, 6.8797637237932525, 7.111434919986295, 7.5063167779296815, 7.13335246865954, 7.351348979843466, 7.7797610467209655, 7.639934632814888, 7.126002912929606, 7.50422121194081},
    {7.176420919968373, 7.539701937352485, 7.676460098292645, 7.6352714062929, 6.809199416001257, 7.125962589932262, 7.2089316023590575, 6.889618189859742, 7.534041433319457, 7.211753287562354, 7.6499744374647385, 7.121648695358998, 7.252098500897821, 7.5319384350833545, 7.317833669224027, 6.698087742687161},
    {7.476163349996201, 7.037432821253167, 7.237554006744252, 7.324058443861063, 7.351392769226858, 8.07374952877008, 6.96537831292616, 7.620233327066894, 7.776986987986734, 7.123652907568643, 7.163415765897652, 7.175494247580826, 7.133398529774208, 7.134376343023703, 7.453471473736423, 6.8274604718653435},
    {7.434223558783033, 7.351361308479225, 7.092457953904613, 7.827665350009703, 7.955525873804879, 7.528505355129928, 7.692958046358499, 7.1858192886003325, 7.535928707905293, 7.549914490326087, 7.262750091727249, 7.511823174189334, 7.616401234346007, 7.276261360829743, 7.388301651529115, 6.482539593244715},
    {7.339311159254265, 7.27933633055512, 7.22684717163067, 7.338161687931347, 7.32930757204927, 7.84008422326968, 7.66748354113316, 7.039610922497776, 7.118701982155952, 7.18052886456591, 7.170865471902141, 6.962111764113597, 7.5146659683766215, 7.035575728075745, 7.481561261690752, 7.079666140353024},
    {7.284310535185856, 7.399534275650173, 7.791166671671441, 7.002504756171979, 6.617718810986094, 7.444936754767359, 7.300111373412364, 7.120523499234901, 7.146241051149059, 7.153149032517799, 7.692879575690534, 6.907543939388281, 7.296518016930192, 7.10194764159092, 7.428417833270541, 7.093826064429124},
    {6.41617984110564, 7.277984258739105, 7.3900079352371995, 7.431333757903037, 7.5455068824445135, 7.457846574636676, 7.251031927781089, 7.301830973879576, 6.793255158933276, 7.590009622954629, 6.946203211805379, 7.225713578866126, 7.0438765902433325, 7.2720094098530765, 7.1277833834812165, 6.838019297146107},
    {7.604071538348685, 7.865718164332589, 7.53484796843667, 7.5259940851538625, 7.562460687601353, 7.6507949844236425, 7.179070367947802, 7.841316510775569, 7.378204418679153, 7.918738824406717, 7.350419948530512, 7.174493848351284, 7.263897934396715, 7.462016606074085, 7.541839928197415, 7.309736170133523},
    {6.838420382249297, 6.953210395767557, 6.917788583524595, 6.830240086288182, 7.001866965419484, 7.31419139294811, 7.053888049569048, 6.95070290097348, 6.749245862595321, 6.9828835825162106, 7.170475027409296, 6.950219397265462, 7.220692144350577, 7.597470333170803, 7.05573129955653, 6.715015867541687},
    {6.968816038282625, 7.708909208162704, 7.556558638793638, 7.389228677503901, 7.458658103851815, 7.294639190509111, 7.427023936955128, 6.974578070239, 7.496215591795911, 7.069204073650023, 7.26955989404785, 7.366565241388863, 7.738000309744096, 7.231342438733718, 7.575009360445971, 6.778214285713917},
    {7.2990273878220915, 6.990106143558747, 7.061453386484264, 7.448721359382281, 8.052859364228729, 7.683300064802696, 7.7530106488752075, 7.634071886501582, 7.564819557919793, 6.863894440168871, 7.053436841921807, 7.0407772688007, 7.315311996550423, 7.104445022318332, 6.895592387166821, 7.072524027655265},
    {7.108857702865442, 7.442047356071721, 7.562496200141976, 7.594117130244289, 7.237294024546702, 7.51432810360444, 7.476456330159584, 7.3276962791086255, 7.228728874204867, 7.4739181343745, 7.754147652870951, 6.92286100680156, 7.698968494307636, 6.768940933905615, 7.2402940571017025, 7.041990838786492},
    {7.298462511464448, 7.517688110100771, 7.448025311509844, 7.33475424980098, 7.181734966314815, 7.0520378559808075, 7.1896923236870816, 6.982600567677393, 7.251944450349984, 7.002295852188198, 7.255302038110257, 6.789940135237226, 7.381030857171395, 7.583254810555814, 7.045535124040381, 6.9311612533429585},
    {7.3780421307916235, 7.433321290096381, 7.598973629778107, 7.522612383542534, 7.119299580253325, 7.730042505311349, 7.335917120293618, 7.551497603931092, 7.998093328402407, 7.219130853212371, 7.078799683136503, 7.6627491868491955, 7.4006031997330135, 6.889096598565542, 7.36459782561742, 6.789995399592274},
    {6.9337835664720995, 7.4824741161673405, 7.213614954061645, 7.394912296846121, 7.157264622544104, 7.37822318818729, 7.554948756016729, 7.5624582708846715, 7.690414271468713, 7.7156465717941485, 7.696107993265544, 7.284203343531554, 7.33459008471747, 7.023123644307508, 7.596109315776953, 7.034152108757595},
    {7.490774420800725, 7.608328680735764, 7.428045534809875, 7.433626907338334, 7.907448877351617, 7.595730477053419, 7.731355979040505, 7.090172313348797, 7.178388665011298, 7.093719271542712, 7.7181786921671405, 7.346542270604904, 7.514840666710808, 7.312505573241225, 7.654315312317862, 7.132026949562999},
    {7.61578332605536, 7.280688467515638, 7.14829310530664, 7.70215195282122, 7.393396463581793, 6.9423620749780275, 7.8099467575638055, 6.8141965557362605, 7.267762404090037, 6.7794673877039475, 7.451099527790072, 7.246421689704121, 7.368256911945357, 7.5334034594941715, 7.44862490903639, 6.278537172144246},
    {7.654607815974829, 7.4104780965574175, 7.395662146017569, 7.142031042079442, 6.768636721977588, 7.434138580482426, 7.432218562708917, 7.684963919475306, 7.258475080686027, 7.644620590470373, 6.833872078242325, 7.19406135861724, 7.474481485275746, 7.247004180082414, 7.65607736638616, 7.269558497859611},
    {7.4729104258093875, 7.734720463221199, 7.522242662779344, 7.461208296013204, 7.514854602823741, 7.781750225667751, 7.37047470301554, 7.4694586619223555, 7.793624284894652, 8.052224455846817, 7.285851804440768, 7.895549736969211, 7.506740924879726, 7.380125526580541, 7.501687732343724, 6.832047095016879},
    {7.383605725307541, 7.5361082924887475, 7.502653924195869, 7.853210785247429, 7.743408450924957, 7.1483459349010365, 7.034810201537894, 7.045317104940567, 7.295131647736247, 7.040276810315102, 7.321048985209345, 6.860020321606584, 7.47715128552754, 6.982046394148374, 7.45510534394963, 6.888603863526868},
    {7.013352848608617, 7.650433528718571, 6.912182729981662, 7.097992539313055, 7.122684204263283, 7.309537254121283, 7.3319487251570665, 7.156009636766007, 7.4839119004105505, 6.9730302910153235, 7.5528061503107535, 7.200451612218052, 7.1653911246168445, 7.662071744231024, 8.0277836414291, 7.158523982218543},
    {7.548121429637593, 7.572920591678911, 7.29944259691152, 7.195976985026013, 6.985452425526294, 7.299218624180667, 7.538975762862305, 6.87898320934832, 7.722725311325392, 7.806089057823414, 7.536230392299706, 7.715313215543145, 7.334170456534097, 7.72102502650901, 7.082442573685564, 6.877916866890432},
    {6.998334940405843, 7.742032803294207, 7.424402917751364, 7.781224457462257, 7.251458853040944, 7.131090973834419, 7.408611355645605, 7.506926523211086, 7.451206551624942, 7.626025672982292, 7.1004802637327025, 7.173484387595833, 7.803908132845509, 7.6260513326607695, 7.52872649778288, 7.367393533540754},
    {7.36241645530171, 7.361460888746384, 7.341107603413541, 7.348593994704641, 7.324709349245697, 7.271216555807322, 7.255677006877831, 7.238803720226295, 7.509502822056008, 7.260779979274575, 7.143791594657026, 7.163427829467339, 7.359823948808513, 7.316651317947968, 6.778291888655807, 6.801153384895067},
    {7.1979060836656386, 7.302928469624843, 7.197329224865127, 7.312223389035208, 6.8487700026136284, 7.3138480910327095, 7.3145392027200415, 7.353374634303905, 7.36787771532315, 7.313612916789883, 7.061199449632146, 6.824886160145712, 7.515073671094862, 7.292274321562037, 7.16004005599964, 6.654481076207806},
    {8.061324532637858, 7.283786633441243, 7.637377245202469, 7.067516501391183, 7.209089492226099, 7.626730144104146, 7.71910374580717, 7.49779376486192, 7.289166043269747, 7.3490285626287575, 7.634557854319053, 7.447357084575488, 7.5825703018559265, 7.490885326816794, 7.823261621373916, 6.908378007967565},
    {7.311939337012723, 7.454982122994205, 7.161408340023642, 7.24917366528781, 7.389524156340852, 7.26047407916984, 7.809840770428859, 7.358227459175716, 7.26705337934958, 7.385109257864985, 7.379705878950909, 7.104904995715086, 7.704862911708217, 7.023843910361183, 7.228438074908715, 6.994075322166842}
};

static const float b2[16] = {7.202345542364404, 7.159258217124385, 7.219295215458589, 7.207386572651671, 7.145544566437138, 7.2689961079564025, 7.1360059075968065, 6.884665828646706, 7.194405494101444, 7.134052049575164, 7.1460384342340975, 7.067932936978545, 7.157715650530756, 6.927698533617912, 7.147728740718556, 7.165105337496056};

static const float w3[16][12] = {
    {-4.78991566877734, -4.845317671725932, -5.018851793631589, -4.589651231772182, -4.653849562593629, -4.839061855767215, -5.156794519096497, -4.440584006123333, -4.958626818107932, -4.806996599226957, -5.900917844230743, -5.085433304019816},
    {-4.636999418405664, -4.77611410841661, -4.698832120660287, -4.508094480068394, -5.205623523841054, -5.120354228719783, -5.0361977981073265, -4.928341676938498, -5.240546652711705, -4.739149993267065, -4.124826262328841, -4.163178528244901},
    {-5.000226495938279, -4.876183499071157, -4.755719750789846, -5.21472511057865, -4.6793853816907935, -4.70636947613947, -5.445672102769197, -4.510693892284682, -5.146979028482054, -4.779368566150938, -5.252489260473867, -5.040407319635314},
    {-5.020076889628291, -4.7244524820333735, -5.220654348520722, -4.921223525384415, -4.806414730585286, -4.701043902225148, -4.923937964814077, -4.398339051000795, -5.010367999515156, -4.754192074963576, -4.8817526765299375, -5.328434130133598},
    {-4.722112547369701, -4.973114857878416, -5.20085494279053, -5.1074846395077005, -4.784726548369353, -4.938237007392627, -4.859933015748649, -5.116182388055545, -5.122517310026256, -5.034404687872909, -4.423642385700949, -5.175786084248032},
    {-5.055897868452745, -4.681574519716047, -4.735499837659439, -5.008862763231116, -4.3257057850836995, -4.788325191540789, -5.127511071251873, -5.159087470087897, -4.908129006564102, -4.881909713354444, -4.495495664441607, -4.570973799103779},
    {-4.845180672973018, -5.150920974195619, -5.153991038896351, -4.837742666614523, -5.185367519752202, -4.51083029914165, -5.1511315752734035, -4.426464057457311, -5.255320250441295, -5.27924892952208, -4.855330973075989, -5.140260258943666},
    {-5.0659577887013505, -4.233720656475036, -4.558358177265007, -5.6935592719184, -5.175909781565644, -5.094460004798538, -4.7429873671034155, -5.753009922695365, -4.446401525989327, -5.081844238435691, -4.692713070808915, -4.500170285202684},
    {-4.321562470929606, -4.682637747742029, -4.278768731616797, -4.779643679412531, -5.248509946700642, -4.5861719780749075, -4.693911149543605, -4.866160181040375, -4.9209004071703655, -4.733342010884954, -5.049988823289244, -5.030311883658232},
    {-4.891526482081633, -5.357790207322472, -4.700504018089362, -4.475510943598438, -5.430229204381838, -5.187336045434867, -5.119797693634769, -5.498327351266034, -4.221415040007179, -4.823619111941477, -4.6791217473648805, -4.526160795743671},
    {-4.270355440820268, -5.617391155186022, -5.0905223072778325, -4.759441471428138, -4.40211455208764, -5.108332112578804, -5.11217599496851, -5.30596633409596, -4.8082922750311266, -4.718924872598635, -4.9613226564061215, -4.6571761367900155},
    {-5.027363781508887, -5.119552101286407, -5.564788589495191, -4.151000099350364, -4.598344316500839, -5.129119264091418, -4.735757619766793, -5.037558721519586, -4.997082461160962, -5.437622994335081, -5.273024206468987, -5.259735975475021},
    {-5.263187854460566, -5.2524985429863476, -4.769372215053173, -5.327378228327651, -4.892957653999868, -4.536304894031415, -4.684601618850853, -4.655703383847402, -4.581666174959079, -5.248061796618157, -4.945257533714571, -5.021004430224728},
    {-5.2173223304794485, -4.234384038145164, -4.8352788879663, -5.3385029292550215, -5.0751579319582225, -4.887791706321179, -4.443389879474538, -5.12600936364466, -5.018802703168706, -4.690631529033803, -4.9288197432326255, -4.962620207518729},
    {-4.8471760680037494, -4.619461575760408, -4.489693006717204, -4.48353838478533, -4.59443893562663, -4.912692802748007, -4.646342175748539, -4.706822198639604, -4.903740442803097, -4.173024889351263, -5.141799917280177, -4.647452761362272},
    {-5.003675512884435, -4.8142613051188, -4.9262179834175175, -4.75143277589989, -4.928632991879671, -4.92997792497282, -4.011341047082455, -4.110153426274637, -4.3724520768064, -4.764105404931717, -4.381775831583658, -4.841849533438371}
};

static const float b3[12] = {-3.334505424625377, -3.3642445086885115, -3.207077698160363, -2.5303225790836064, -3.395799562113489, -2.490309113572809, -3.39099695787328, -1.9068882800248017, -2.5375377145532867, -2.94150540813548, -1.8244662571514418, -3.660313911718428};

    // Input Layer 
    float z1[32];
    for (int i = 0; i < 32; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[16];
    for (int i = 0; i < 16; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 32; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Output Layer
    float z3[12];
    for (int k = 0; k < 12; k++)
    {
        z3[k] = b3[k];
        for (int j = 0; j < 16; j++)
        {
            z3[k] += z2[j] * w3[j][k];
        }
    }
    softmax(z3, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
