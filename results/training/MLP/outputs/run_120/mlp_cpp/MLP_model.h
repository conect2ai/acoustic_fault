#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][16] = {
    {-0.838248149866998, -0.3032990990445592, -0.4291907465434159, 1.2527916143317241, 2.7518496825910104, -1.4290472069679232, -1.2519275071285736, -1.0550637874741187, -0.4251198523731453, 0.8430398117274517, 1.628261657229609, 0.7087320753857754, 1.3758349049403662, -1.8825612161884644, -0.21315557192766654, 0.4566833293559295},
    {1.055286244616934, -0.5462786983494138, 0.2877189343829272, -0.5911326688787883, -1.4936710895456713, 0.2729054395490275, 1.0642602961521652, 1.152479817956143, 0.42824199424458853, 1.4869513357551083, -1.4292370734217725, -0.19918239818443773, 0.14013354030271094, 1.397161924437138, 2.0046839270590278, -0.935533438177133},
    {1.321979527831192, 0.8876184590519623, 1.6045042442513562, 0.10376989475962373, -1.3693921536167835, -0.6687240569184832, 0.976352205582627, 1.3883948527180083, 1.7947645666812033, 0.28729221874073035, -0.7093158376070118, 0.841352550577762, -1.7664789017545555, -0.7757817235265878, 0.9764824368361101, 1.1688126640592702},
    {0.6168508248415554, 0.2578559839455005, 0.9935680228114013, 0.9552213043620893, 0.5560731900426723, -0.44200901711240564, 0.4971483684591712, 0.8542748804295648, 0.32037321865411394, 0.9243181931918256, -0.5709910239477424, 2.2157462843472815, -2.4001535707224106, 0.03542339864933586, -0.1680683056563562, 1.1100841920590192},
    {-0.39201163858509464, 1.6343331302590858, 0.7823179322563636, -0.7812860128617776, -0.7476335414429328, 0.26060530230958057, 1.7904676099356704, -0.24061047313953726, 0.9342882681189475, -1.7730296323124215, -0.8545776053777533, 0.3163950223448478, -2.9527300129661884, -0.055674695179474334, 1.3767055525321772, 0.35805095108034024},
    {1.457144189178393, 2.4172222148679, 1.8623181824747914, -0.00268177563389724, 0.25964416481369745, 0.9332159539790189, 0.9965971984402303, 2.331863990708097, 1.7360438763394657, 0.3795729093098488, 1.3366993024298974, 2.3910146406667043, -0.9155734343904341, 0.6040993047750427, 1.287174682092074, 1.3767262812666659},
    {0.0006934703344358951, 1.7494439005814426, 1.6819431896531079, -0.8653023861113947, 0.0974950532073213, -0.26074050862511977, 0.8010723879447298, 2.149646789165836, 1.210503688485402, 0.2144456496736221, 0.767735875620778, 1.9269066445988832, -2.0917227321881717, 0.9808862208958028, 0.12647838394849925, 0.8564109485998119},
    {0.18484503345411152, 1.4263158146441104, 0.5184048929544613, -1.2585806815472729, -0.774137709822646, -0.2071710345729507, 1.4275829024803517, 0.39759652001721046, 0.31990885227953353, -0.3956487509829201, -2.0507176098559405, 0.2804955387659508, -1.4613654502876732, -0.15475116708514325, 1.0412921653972138, -0.31368129051307625},
    {-0.9854674728302669, 1.1801443107962686, 0.9688284308861635, -1.0664347691792133, -0.5861322362133924, -1.6552360838888427, 1.5097612038253567, 1.4950225632345733, -0.9665776108186487, 0.08616057046613837, -2.6859062521950823, 1.405762077081959, -2.415698839503999, 0.2705008435021649, 0.8263911502354531, 0.4566880510694183},
    {0.35579503291998194, -1.1691791309454944, -0.7004091987558126, -0.5005377831141599, -0.10781632752732195, 0.34172395462596594, -0.7654120935877115, 0.6940333935918549, 0.012801040501947232, 0.37852562324411604, -0.04819854070240177, 0.0033674123528951074, 1.0483326663438095, 1.3438557312051984, -0.6841440867951055, -0.9728444071170452},
    {-0.9539036069675724, -0.6425040009982, -1.7956795892949344, -1.3330169540469345, -0.11210573158881265, -0.30852681910102914, -1.3048575649611662, -1.222752877486726, -0.9863975009071991, -1.2177288680122254, -0.3246217290581263, -1.2155252478180758, -1.2883679664471213, 0.5204676479871222, -1.2196659682123618, -1.657776590396843},
    {1.343638090955325, -0.7540944335491634, 1.499062535153991, 0.2262870366267139, -0.10304278195566115, -1.8799244149726548, -0.4732440377925086, 0.3877007748228943, 0.5494652564889666, 0.5791275378751415, -0.362877080914678, 1.1563691182964957, 0.32154642126966443, 0.15293126156933035, 0.9328143953061377, 0.6756833478169055},
    {-0.4739565649010844, -0.5505634712729918, -0.7421819649272133, -1.213425949606177, -1.0629570984631276, -0.3856306362208064, -0.7886746681596589, 0.23273848156305899, -0.3146939366215904, 0.23983949243396255, 0.5011159856590055, -1.2837291468197676, 0.867458331696524, 0.93196727879861, 0.735857206796431, -0.1398816109131225},
    {1.461073457266748, -0.15303148124771232, 1.0001650823812347, 0.6276435418438097, 0.8674409064124274, -1.2676555335889617, -0.20246976680428172, 1.1720000638708408, -1.4369135613424464, 0.3215176728861336, 0.1780615617029171, 1.46822684287602, -0.38199495322990895, 1.1243057613161385, -0.9737606045371915, 0.058094952923786074},
    {1.0822343914389212, 2.17308018967741, 1.0008434899870229, -0.18311457360162364, 1.7286531042552291, -1.7386052087298216, -1.3966627351929137, -0.020065993184250397, -0.56205347891604, 0.5804297931264698, 1.3375271452325188, 1.0102660354099116, -0.22880392959176496, -0.6227878330543779, -1.2573075203531685, 0.9551851485435959},
    {0.6737902676384839, 0.5487793882925285, 0.37884105847952415, -0.5362449005535869, 0.30992614916239514, -0.9736100132308356, -0.44791669820229335, 1.5473315393214468, -0.602110522578546, 0.8437299269443569, 0.5045187279382745, -0.368870793169177, 1.4220131674410923, 1.2529357868072668, -0.11172441124306291, 0.7481063149377065},
    {1.3494342112031699, 1.2985583900565572, 1.1745211706276946, 0.7407596141084368, 1.807568724086475, 0.2485985155962217, -0.05248379042540316, 1.6208964899704592, -0.41107655415305205, 1.5307537653453767, 1.3646346009358006, 2.1360464668569006, -0.2363343121642054, 0.6154756555382762, -0.06300655171335154, -0.04266522978445302},
    {0.09703402131495997, -0.0696897968464361, 0.7847974960778287, 0.3063971427489926, 1.0491059486169072, -0.5702424283205054, -1.1375480095113286, 0.6801076429450194, -0.4732721383365775, 0.3641762469852462, 0.8265058378716326, 0.7995393898507119, -0.2946620710828139, 0.42580728052160544, -0.5404349945654804, -0.20547178103317326},
    {-0.6613483379980212, 0.33733818207056265, -0.160003819495062, 0.6031293522230176, 0.21102393611842207, -0.23834608830238121, 0.5356800529606841, -0.08018151043666452, -0.5264575598511408, 0.7347744513833019, -0.03832908301982231, -0.18973007518955637, -0.7428523627146292, -0.37530580784718715, 0.8998587103605924, 0.11221034257388884},
    {1.0224130458595537, -0.5151206957396135, 0.09079588418835025, 0.864340069512816, 1.6478485993498124, -0.18920571085092994, 0.2964615148143956, 0.46789859836473124, 0.8371700253639947, 0.7456175103952473, 1.2328283290457407, 0.6902869140864358, -0.42618885467493195, -0.03138093518426129, 0.5697284226586368, -0.04739799399563988},
    {0.1864780979617017, 0.4235621999769056, -0.31964868892220105, -0.308096306319807, 0.555040202917527, -1.2959456292178448, -0.11657159413852049, -0.0925637096029133, -0.33973240047217135, -0.5185182392395961, -0.6686074022466661, 0.014041846152957414, -1.816586468850332, -0.769948934218201, -0.42403840518521074, 0.17475878659178154},
    {0.5832020610953443, -0.09663257161666512, -0.6951911441091378, -0.52609873461913, 0.8265002166349936, -1.187444209468213, -0.5578804296338348, -0.5919414756736598, -1.1754734923440484, -0.9881543157472225, -0.04547961512253015, 0.2601392295955101, -1.1827852932155223, 0.9591195074108506, -1.7204141252785907, -1.0155440478438056},
    {1.89828754464533, 0.038987883699175885, 0.6551629880898224, 1.470262564289902, 1.2978093797168861, -0.3346190215172868, -0.32479566139274624, 0.7830441428053863, 0.29995379404442, 0.5311603796282004, 1.027767938658268, 0.6013476403867272, 0.6172794394535859, 0.2534586842085814, -0.80184814126592, 1.3447606435215922},
    {1.313522970519987, -0.662653652279338, -0.4758624704488592, 1.2632433119867958, 1.1709939823229207, 1.3893244758117949, 0.38804785832163236, -0.8855527920137007, -0.043314317136868154, 0.38864885002996336, 0.6102486917187718, -0.5845810123770683, 0.4865654345908942, 0.17580984560356686, -0.9886989870519702, -0.6385649255465286},
    {0.013606151985174791, -0.2553357949055675, -0.34684448184280464, 1.2251238039605596, 1.3174124333928443, 1.1425368294812974, 0.18374545420910024, -1.2591278796601535, 0.1059283520494879, 0.4606424622487063, 1.2076512127986139, 0.11668336646395566, -0.3433333131119671, -0.44577137405017636, -1.1920323340779937, -0.652687538221928},
    {-0.714492827834495, -1.4978798369339694, -1.4609001318463666, 1.4172473052880652, 1.3859928336305647, 0.8026382730067472, -0.3209396278709463, -1.5053798577193056, 0.08017531459895305, 0.9769236933826927, -0.36201816121403096, -0.7614248938127112, -0.1812190342987894, -1.1046919532951762, -1.0555741540398271, -0.9585000454427663},
    {0.32161961362639235, -1.308655671890113, -1.1768958188485406, -0.18666569650881862, 0.9953082423948852, 0.3039163127663474, -1.7480496267561698, -1.6878427835535577, -0.4356707140568025, -0.24894940593816836, -0.35647358243852956, -0.8339853688631476, 0.19043820753626053, 0.24350675519527634, -2.1304499804170294, -0.5579577262136303},
    {-0.8087593076046207, -0.6314597844356497, -0.64291084748549, 0.12647716657562752, -0.20646527266876097, 1.194148763705292, 0.5885847926884961, -1.5410275678772563, 0.1455169015998113, 0.4592907426720678, 0.4120111454170539, -1.8864448555236113, -0.6143569196601218, -0.30901207129624236, -0.6059559952164492, -0.35426375634622764},
    {1.6604506211816692, -0.6040035970078693, 0.4862800936409318, 0.4754794064337841, 0.2471885081445568, 0.13350945946914122, -0.7429779494710285, -0.9467186856327173, -0.44951487412263924, -0.49119497634939063, -0.0385831865305819, 0.7095860561843733, -1.4871326621046606, -0.15889922790901476, -2.0793930640412355, -0.10349268487098447},
    {-0.4849657920672798, 0.620770307209314, 0.0890441315554157, -0.9040828187639628, -0.5375095220753076, 0.08120358220222158, 0.04561631414615133, -1.3353690582261244, -0.8628087860714286, -0.9600383804600922, -0.446939186143553, -0.5264544837295637, -1.6649107598062027, -0.16451115306406733, -0.7201321007425182, -0.18742554843664708},
    {-1.980227712673215, -0.49185911819011624, -2.265294837406004, 2.057145179888234, 2.6870659159741974, 0.18882415495892457, -1.2328241218989122, -2.3320770109383107, -1.0917422824736083, 2.0070026341883724, 2.3469138660726276, -1.9721388635733403, 2.0549762762237296, -0.3304100396160777, -0.8365191190655165, -2.1566237178570686},
    {-1.4306785532333488, -0.9916063886881429, -1.3875805823306189, 2.0272209924623565, 2.6175786467303013, 0.28043418567557904, -0.5681609249487559, -1.686234171002764, -0.8260689609995215, 2.1047852209472317, 1.528352429739006, -1.3877652683493615, 1.82275294966404, -0.1374385237958868, -0.5391877361405603, -1.7879320428175582},
    {-0.2251366019785129, -0.5819647827290512, -0.4250990225878483, 2.0543120264835566, 2.149319519856846, 0.5180942396338786, -0.1178655043754913, -0.47129626033355626, 0.11620359953049267, 2.035290245931727, 2.5248512790172475, -0.2092610761832044, 2.4012699694497512, 0.02072621539869089, -0.07063528976437018, -0.5261741198425209},
    {-1.0997669380072295, -0.2960464397764716, -0.1563167176037386, 2.1146506102691762, 2.3795824576340676, 1.1267891610139473, -0.519894680291762, -1.035603626528559, -0.6908015460387181, 2.0542421775687254, 2.1774407666254754, -0.9341188404331966, 2.4982795647467317, -0.43805896061173966, -0.6022928327778074, -0.9974803882580934},
    {-1.1581177692077556, -0.30692139796927115, -0.05512100620713413, 2.3594034376032753, 2.2603459399054504, 1.8364734340619087, -0.6621615797939226, -0.3301356070892861, -0.28680429591547635, 1.553437736788624, 2.063880652035793, -0.9918191571590503, 1.9232774589866817, -0.3436111559465476, -0.6675021997524573, -0.7532932639983689},
    {-0.2216308391597394, 0.021382967693202148, 0.14927893699554934, 2.061475923590592, 1.6233518162983211, 1.407392877722378, -0.2734918808268565, 0.25388738168769975, 0.4356112483653173, 1.621993782928217, 1.359285627091242, 0.21889826816915012, 1.497505981535988, 0.0646573676338834, -0.17258806694748802, 0.1915117541677568},
    {-0.580223984074583, -0.4594308658867568, -0.4056453499651599, 1.1421587892071146, 0.8222109014086281, 0.3995068678538825, -0.6933714396743152, -0.7373189238441294, 0.06442022410060495, 1.0065419092771757, 1.3768466309839862, -0.7993245458843503, 1.4655811019987866, 0.12867727397738887, -0.6749036906979459, -0.1614026293273063},
    {-0.3068916750341215, 0.23200138212888538, 0.615419294732436, 1.5634793665075635, 1.144283992770851, 0.72338892116899, -0.29486640631661, -0.6055667183738177, -0.29696637407365617, 0.8410043386715197, 1.4300035193635754, -0.33068575461736205, 1.1085727405646142, 0.05178441851053898, -0.841364157671523, 0.7602777676289609},
    {-0.27025362412261805, 0.2821549088589543, -0.1859659480581278, 1.3036755188989346, 0.9442818362663657, 0.6042052672084941, -0.4789627716376476, -0.08342344469792373, -0.44800137669832024, 1.0017049694982318, 0.8445073530989279, -0.44381719966273336, 0.5495322658229388, -0.4952977592807229, -0.11470582478433657, -0.5039603700332158},
    {-0.49572825700719236, 0.13102152384750987, -0.07579385146438712, 0.3008561928945995, -0.003021506187254402, -0.14159561659980258, 0.017241172210122148, -0.198076820951653, -0.5271966338075794, 0.07572378769575477, -0.3199178688050143, -0.3877369191382142, 0.04569535191061066, -0.41976613171687477, -0.2716281003049928, -0.8998075939770317},
    {-0.17299518761339416, -0.35060130980854465, 0.49780242959648924, 0.7706506180889854, 0.9239239012298605, 0.800699628670192, -0.6131522004828673, -0.013032173457492111, -0.30723271577907973, 0.8426017312213554, 0.8247061193205304, -0.028146439527646623, 0.9900796567678217, -0.05713979642237037, 0.015247902003667192, 0.06088473705477769},
    {0.7617036564364815, 0.008713532679009303, -0.15108204367444253, 1.5342826125234308, 1.1552088812558547, 0.2868626897216914, 0.05528782514847938, 0.24337141181658314, -0.10644883899575293, 1.2973129790251825, 1.39976586718566, 0.12093884616124696, 1.020811918496322, 0.1890874837106712, -0.09567638049069942, 0.44960516751507895},
    {0.33504127331532507, 0.11231192062101314, 0.7613010114965509, 0.5406549323793549, 0.5047574721819077, -0.08274491781297813, 0.30309885423796323, 0.15567782690417875, -0.2867716865336916, 0.36512485553464286, -0.0820340820140689, 0.5363061256686578, -0.015991277840371455, 0.30571254257511954, 0.11309055640247372, 0.31463935244921876},
    {-0.5856010299030612, -0.2216099271238562, -0.04442777663776993, 1.012859394308229, 0.9520181916298376, 0.6119892813479978, -0.26142042669100307, -0.5339295881395146, -0.5518544393413064, 0.7185441383805097, 1.0619662602107343, -0.7753475598927937, 0.830442643353001, -0.1678097976489059, -0.8349770457409428, 0.18498967448011308},
    {0.0414208795056846, -0.2578706443979326, 0.25360608231155607, 1.4795883843850879, 1.031694983083074, 0.5029551658733472, 0.5184756693390911, 0.3012466242940795, 0.419325190160815, 0.6756224771085996, 1.2239358816481063, 0.2808269996826301, 0.5215538131813577, -0.0970590485813619, 0.7442403101850962, 0.032004081695591075},
    {0.0309522084871793, -0.02343412507063122, 0.5700286386301141, 0.9792455428936266, 0.6008265964007404, 0.45509674914153275, 0.23129012851309916, 0.10493546792783594, 0.41674607397591323, 0.6682765314106921, 0.3781339959454938, 0.1283131994972923, 0.7290540978354731, 0.35812306314706943, -0.28539105806557274, 0.4614472752594262},
    {0.788392987602805, 0.2225263591033887, 0.6247148940248677, 0.5502113557286105, 0.4383459128086289, -0.008773996098872862, 0.5319525565668483, 0.8045448590706138, 0.32927713252901125, 0.33031677020455497, 0.5527199363519324, 0.3921382388021396, 0.25301872937559466, -0.2651140137204396, 0.4167238465166033, 0.25303182503463156},
    {-0.6546752223974902, -0.22402612307666062, -0.3044839067028974, -0.030250517990756357, -0.548554093253988, -0.2834694150467442, 0.2612799476871026, -0.3831147304851984, 0.3634346139991708, -0.5268290076002797, -0.2117916334414376, -0.41466570408445386, -0.12999634219331957, -0.061678213748500285, 0.13729295651204018, -0.42216465149006294},
    {0.3095838226673938, -0.5618524869371186, 0.35568476654655384, 0.30998301792514654, 0.016561154402473324, 0.0731800880068264, 0.16392045895567028, 0.27310613138651185, -0.021473321683818773, 0.0843902195412772, 0.33717598869582976, -0.08234088267811589, 0.43271642748630257, -0.2923411691102816, 0.4398477902460703, -0.3003089678933696},
    {0.9998156378052656, 0.5170170341029928, 0.8568752651512362, 0.024960376598999637, -0.6342623901606356, -0.5247336562542058, 0.7714438895450694, 1.0961317004091662, 0.7861926018873779, -0.6012491467231474, -0.2984208994059071, 0.8032008626520942, -0.18212753590300662, -0.20674394798336052, 0.9371067504567477, 0.9274060878865131},
    {0.9949032137576423, 0.20696595318441063, 1.1423842047378545, 1.1566627345677096, 0.5801401897649692, -0.3697557687744742, 0.46992769180302596, 1.4755190453352258, 0.7776584163315186, 0.40020670296377364, 0.4588178506259399, 0.9031266309058312, 0.7260353475372194, 0.290883614946322, 0.7098048838853883, 1.0777066401022597},
    {0.5790394106680393, 0.45700402248292243, 0.8946714986727773, 0.8822438066738455, 0.23175118525577043, -0.22005163238626405, 0.5981212881406864, 0.8692493755321242, 0.7522460321490272, 0.369555202374405, 0.34590025268962943, 0.6163418120309351, 0.4699163545466942, 0.18692017717425383, 0.6549469670780566, 0.6288388384829514},
    {0.24274859101754034, 0.12397380427357443, -0.23511119152536655, 0.9680869728437743, 0.8921021842503701, 0.6021797953472833, -0.14562983032415003, 0.11634943368464915, 0.1376467621767234, 0.626342599568325, 0.4377876427568463, 0.04703912729666207, 1.0965206307583957, -0.07634076836862615, -0.5511838129845261, -0.2049078700733419},
    {-0.07428630723814261, 0.028732485064266636, -0.05069951811930745, 0.6659922841348701, -0.15153582925677062, 0.5569377178548165, -0.33380371811063153, 0.14682730075346162, -0.1172394346527459, 0.5524046265882838, 0.0977767867056852, 0.018964347168945305, 0.27827398757873906, 0.014987036652345983, 0.16192380737349196, -0.07052650348779639},
    {-0.08326729498914852, 0.4667342182487356, -0.6557674733760458, 0.5827404369308485, 0.12687551604609776, -0.39910576749312904, 0.07029086923168311, -0.4190104699830398, -0.2294735122082472, 0.5753101263442794, 0.4969175479453466, -0.5279157575618807, 0.34943458068940314, -0.3760540872593744, 0.22572267624644882, -0.4973167370305292},
    {0.19522881494353234, -0.14825048426288878, 0.4989319126304632, 0.2657631396256577, 0.3608768843946766, 0.38756989790203583, 0.7133423794623597, 0.25383843763579844, 0.39631471529591306, 0.1778648793379822, -0.09690925432334721, 0.3900771993750111, 0.2676619154965457, 0.027803601277337768, -0.3276810777382091, 0.5195498782007215},
    {0.1144485770020141, -0.6109601430929213, 0.09632816567938977, 0.05736181832589307, 0.0029722144638007642, -0.03245036649910341, -0.48642166170754214, 0.2652802010632066, 0.016525338478491147, 0.1271234780333245, 0.2626908267807184, 0.08193006212088727, 0.9442525920373527, -0.10208775032394907, -0.8899500519219918, 0.009834518343970972},
    {0.20073502293082499, 0.056013654186722654, 0.37024721570205094, -0.48955018249257093, -0.22473099347348519, 0.10630214539103151, -0.5750792236546491, -0.20644558880483269, -0.16785864181270851, 0.11347653133396657, -0.3690540897603713, -0.051947750489208896, -0.12590920090520247, -0.08428154038104048, -0.5848172126954668, 0.373492952923461},
    {0.5309061847639294, 0.3297852874021499, 0.8548712185081092, 0.6540601515355532, 0.39656841742333626, -0.26314445203772174, 0.3351624943150986, 0.7504081166554482, 0.8276824325680787, -0.015451388036353592, 0.05911921092030467, 0.762551908624843, 0.38642646984880413, 0.43665526279225597, 0.20357276973598656, 0.6040046786521351},
    {0.41477729657446744, 0.2741817804642668, 1.4088598811487452, 1.298268455466775, 1.0817382924900751, 0.5743210500921024, 0.3252861941864987, 0.8271219563215297, 0.24282043486925547, 0.7173226197302448, 0.7710270283799929, 0.7700420287094764, 0.9250623806431039, 0.236497416592742, 0.580700167027011, 1.0821266314711866},
    {-0.27940462858984555, -0.01326269140674022, 0.3413720322800137, -1.4194065912323508, -1.3053901699983625, -0.9150059933526108, 0.24294234218218164, -0.24860772670360667, -0.2217200806246798, -1.426638443227159, -1.234080373441404, -0.0876104167121659, -1.3553567588875095, -0.1294577018066393, -0.1340806347567801, -0.25725721408794644},
    {-0.7424820270037046, -0.05660213802205695, -0.37412877775965864, 0.16608009443499114, -0.0869026686266846, 0.20506653928057308, -0.4918530118729846, -0.07240877827835102, 0.007811331011726837, 0.0012175399327779197, -0.204286426273333, 0.18738129757074307, -0.20748957842750762, -0.08617453039062285, 0.017097349510941884, 0.345787639437532},
    {0.29956467575814993, -0.21629208941409617, -0.16255808603667254, 0.27885664051879727, 0.8024687218704577, 1.103791192526975, -0.1909519268030098, -0.028966135191649946, -0.17843030648159675, 0.9158968459414684, 1.0937128927055093, 0.06574898360311679, 0.6840601560402333, -0.2632783015308056, 0.190630967364612, 0.5714299068199725},
    {0.16320397849957002, -0.18029865661867214, 0.25943840903570936, 0.8646798762760911, 0.58429959650618, 0.7096425046247152, 0.0594033449816703, 0.3209485567733876, 0.03510045175598277, 0.6271530381041923, 0.8992420683903817, 0.2762134086133616, 0.6763228783277693, 0.21288112444514284, 0.004694098961355176, 0.6110167029830886},
    {-0.1705734942889035, 0.34702876218142237, 0.26639704324274804, 0.654770030961065, 0.4596127808454809, 0.5101490483666876, 0.29577013073289593, 0.003908598972303071, 0.028845932984426143, 0.4046824087403179, 0.5924643131831605, -0.042076564103168124, 0.6005613712535958, 0.251426559754816, 0.35867390245753555, 0.1711761103199596},
    {-0.4444145609030399, 0.5067535416687269, 0.09709808407992387, 0.31872595889062666, -0.25766807012675197, 0.30617685427778785, 0.47378082516777204, -0.14615928997456226, -0.25893319841496165, -0.14781614130383808, -0.1921147188616526, -0.2997819287428807, -0.04293505604764876, -0.1498613641991961, 0.33192654290320583, -0.14077673649099856},
    {0.2563114620541392, -0.08533959597341301, 0.39071499395098336, 0.8644070311090178, 0.9095756585322571, 0.5238154585448631, 0.2197636408458535, 0.1787795865251036, 0.21955016186504617, 0.6350327994527618, 0.7455790159759002, 0.3512467369253013, 0.9064363315443275, 0.1803893818944885, -0.5973406229288335, 0.15507513570674208},
    {-0.193862092830527, 0.027264670075280283, -0.21110242356665854, 0.5853018764932216, 0.31055968261592126, 0.14261487237948312, 0.14367883896414707, -0.4773861093364257, -0.3829260473783957, 0.4304404099334551, 0.35517873983993187, -0.39299069609079335, 0.7805783589783127, 0.021754992821750276, -0.2903107859969706, 0.015698655646126464},
    {-0.7636869467448728, 0.10545011930506898, -0.44863660963525864, 0.9178412574561853, 0.5504254685907126, 0.5594007260668978, -0.14925093915861629, -0.554220469509559, -0.27137629275050884, 0.9133509413983721, 0.7657197032366014, -0.9042524253137573, 0.46735427198247176, -0.294571282604988, -0.8405739133619881, -0.44657750026479626},
    {-0.0700433902084118, -0.2519895095263434, -0.04907322936299092, 1.1194973302554474, 1.2752075561558678, 0.49304436185955214, -0.13087300648943956, 0.27359438121441026, 0.16103530655261136, 0.5807695615185786, 1.4819023218569005, -0.17853768860568714, 1.7499314327695399, 0.03161301398022542, -0.49941627475969913, -0.1544225313101064},
    {0.15135878819746068, 0.13295579187392126, 0.49257165640603245, 1.3278294235025707, 0.5474491340247444, 0.4001642266511719, 0.24835457634498825, 0.4446130669140004, 0.43910855131979804, 0.5081951260310299, 0.7727106591003514, 0.3027723200710331, 0.879633406922406, 0.06809103815863621, 0.2206726499968528, 0.26542553918297573},
    {0.2101724745997958, -0.09349268148470331, 0.04742221222743866, 0.7997738914481909, 0.5295563551645951, 0.9239229207596398, 0.25551225706300945, 0.14683501628130388, 0.5877184650540737, 0.6621878697161094, 0.5128480178750958, 0.28208979790682226, 0.32453921961986437, 0.38570833466853616, 0.5757580445179626, 0.3899939365356986},
    {-0.44293663293461816, 0.2705497644504173, -0.3114560907710402, 0.6385678403740312, 0.7071352451063678, 0.8786025330109923, 0.038269669995072114, -0.4378261255778656, -0.30752859913408387, 0.653561380719152, 0.2734659372815844, -0.22542065666853645, -0.18015022440724607, -0.10780178607527435, 0.7531174300236712, 0.025896924370803556},
    {-0.09388002959728149, 0.061637993289119106, 0.4858499789721828, 1.1103237540403026, 0.9228137099140958, 0.5618184139575694, -0.16632176309818636, 0.18611797208231942, 0.14056847740438103, 0.8859291537268338, 1.0891021541586439, 0.23872250181223673, 0.849355723362441, 0.34032929407360263, 0.08830985559114912, 0.48009790266393343},
    {-0.261900045515868, -0.3086317622233902, -0.3688774129154264, -0.45607576089498897, 0.2754478169168356, -0.1093437162354433, -0.4160510377771206, 0.4361006502452195, -0.31424137528428076, -0.22984782299019846, -0.14554891015689028, -0.09814976627167166, -0.6421020852954678, -0.22244743773506778, 0.31339178015872166, 0.058979958344909975},
    {0.10268388204451721, -0.17503707232515656, 0.35237332443924413, 0.10688098032639347, 0.1201523388102803, 0.23956968142960444, 0.3594098940847134, 0.2632670757930868, 0.2592724799301936, 0.2925293100193441, 0.5811458062063354, 0.5149348195517752, 1.0195303171608168, 0.20793851037340233, 0.03721617196423146, -0.10833680315895952},
    {-0.20303988276612178, 0.2536109817652281, -0.05748249131202178, 0.5906321571840084, 0.054078730957272766, 0.1993373378567304, -0.1670169382613757, -0.7288764366266222, -0.2194348870154293, 0.35499253068615133, 0.24197895945364875, -0.5552638557121976, 0.4388928090072386, -0.126626287635865, -0.6089145635854374, -0.4702109314888459},
    {-0.6874283508540904, -0.5442732662675892, -0.9524517704428056, 1.0991001912247662, 0.7479933016758655, 0.6061324746377074, -0.40738947781217666, -0.6020666285055182, -0.07175441624676278, 0.6854489196664277, 1.0119434307921316, -0.6575009446625006, 0.41300564482557134, -0.24194210780387881, -0.6758270522018404, -0.7439525352647818},
    {-0.4523830262594333, -0.5466936208369209, -1.285927510774788, 0.6584577272458789, 1.0389692553676406, 0.38670471913800636, 0.08043032522336638, -0.253166851081141, -0.2225965767945159, 0.7635186677707402, 0.9666847097712389, -0.6236164936570409, 0.29894941132039604, -0.01493549538320159, -0.41694254433281, -0.3496488647524849},
    {0.4143181863860169, -0.123726006612995, 0.5601103696007458, 1.0377855982337965, 0.9308834177264049, 0.6154503512327573, -0.07269043499259967, 0.33025017883893887, 0.050300709597212445, 0.5534492287646042, 0.6744645819915052, 0.07222669051465111, 1.2775622110058937, 0.06459844003901406, -0.15933241766881018, 0.13975875496822104},
    {-0.6925746981055376, -0.09101193780359486, -0.5632880986277966, -0.08295672857039897, -0.4044547835017482, 0.15300065309569272, -0.11149884230479852, -0.5461962612935022, -0.31216405573947953, -0.07083154317383539, -0.056189140551429165, -0.5820144840992623, 0.4139871175112273, -0.017938460266960207, 0.07116360058377992, -0.6585938881311018},
    {-0.08292229936590682, 0.31595276915745735, -0.01660759490744866, 0.5955530505504546, 0.361294677318196, 0.11215415684046724, 0.31003306084418686, -0.159037391795627, 0.19809275980236726, 0.24850642336844775, 0.26037013166421213, 0.22158820228335, 0.316064756455699, 0.30080178143619657, 0.571632775471825, 0.09996780216641445},
    {0.49162850504227795, -0.0944615295275176, 0.32051529187568595, 0.4159544842507207, 0.8658477171225153, 0.4021988665351588, 0.14777266624735985, 0.31868893711392304, 0.30903005958537827, 0.5769561736572609, 0.36603288560697633, 0.299604750529279, 0.33937596954349314, 0.1916513501893027, -0.3681846991659057, 0.39071114015624137},
    {-0.03314848992547152, -0.2745864274103685, -0.33240213641132627, 0.45823755471420224, 0.2913549495381596, 0.6296999387140793, -0.13738973648888117, 0.1627338832725337, 0.20502457819796627, 0.06169090199049606, 0.4706984942573711, -0.09142848212039281, 0.4282240665038366, 0.02102541496483574, -0.07195682757443511, 0.2480948144828134},
    {-0.12268576025564729, -0.24067462747074017, 0.12266391692940426, 0.6577598293811671, 0.7360792662738805, 0.9205685588882397, -0.15972803499264696, 0.25945800185424095, 0.08751747912988682, 0.6030567168065472, 0.6671035905548762, 0.18244751003257983, 0.9237318757460368, 0.12364024529452575, 0.16374172960502154, 0.057082127708856976},
    {-0.4162304659912052, -0.03718159987293997, -0.09247340873927483, 0.09124204546394533, 0.2287245249906629, -0.38227450909859245, -0.050284572128322554, -0.496425725347398, -0.06695228613480242, -0.39060108757392525, 0.014280941262494058, -0.6985462806134023, 0.522255615457455, -0.2791799864155511, -0.2870408613728334, -0.5301739844757126},
    {0.08726119770051538, 0.050227178451288816, -0.26990232350947363, -0.3842905633174313, -0.4516217126919457, -0.3227886045379711, 0.2643588376703516, -0.11004538170843367, 0.010310217496940301, -0.23120075727104955, 0.008540979594994733, -0.22529880966379537, 0.04959349840013641, 0.10937021228857216, 0.17183474266033721, -0.24181456273712462},
    {-0.1790412458112574, 0.27211745456437936, -0.8207827393824786, 0.4295309428983533, 0.2730562357148775, -0.07962939387122203, 0.0020103746702585597, 0.30587214728414197, -0.16339796412986746, 0.22684442165598692, 0.6145169436438415, -0.2902996332299757, 0.014797205478687346, 0.039945957848672484, 0.5860744435644004, -0.49311911717187623},
    {0.053602860057069136, -0.006141903029126372, 0.025283846339575252, 0.41860792542538533, -0.11850994920877585, -0.2453620225217452, 0.2892726787834613, 0.37532255649894763, 0.06366000648413855, -0.39567866251497724, -0.23516455354407287, -0.18033323650173033, -0.278882173179674, 0.059986925475203096, 0.5666440124185304, 0.29919709153129537},
    {-0.5384716652284403, 0.052904356103008095, -0.4900907441543849, -0.7197951121329316, -0.49174399555549453, 0.2848863280405333, -0.2771474341702595, -0.8445679450940068, -0.2190396896701877, -0.3271756978847286, -0.23585037287259986, -0.38379995675981277, -0.9462942595019302, -0.29303127194135237, -0.008337650091004163, -0.5677083491356868},
    {-2.0559037567267495, -0.9454166422284901, -1.7462206042921025, 1.3162737385533971, 2.3410348343362957, 0.6121999689978624, -1.99773929376945, -2.1812495748233007, -0.09721716030782268, 2.088278960195813, 2.0143422558868034, -2.1659477168248045, 1.6034759776211704, 0.0817353185510313, -0.9024370010989577, -2.6266770830878152},
    {-0.9367111187282837, -1.4888472598247577, -1.2030423048317584, 0.4637144210701919, 1.9028537624368824, 0.2766924555883853, -1.6438319086793904, -1.670893167196682, -0.670184471040892, 2.5580857698882236, 0.5459263933707196, -1.899050973886003, 0.5864461025317965, -0.056909679238395856, -1.133772059334225, -2.1432210208203335},
    {-0.40899191072386787, -0.666421177843751, -1.1055165499996924, 2.028572330449857, 2.1211720748864717, 0.7503183504549508, -0.4619976799819088, -0.4360534641060329, -0.6484755869690041, 1.7634937945753544, 2.1517196694156144, -1.0776859265475753, 2.278897951807565, -0.1337838868075873, -0.22980099426698028, -0.9189009715548185},
    {-0.3250881782998537, -0.27098961518563186, -0.6511743662291459, 1.9929312897383502, 2.3933431405099523, 1.5682446018221858, -0.32428962851663884, -0.5699888589467175, -0.3263106925127558, 2.331008242314235, 2.2820850984251577, -0.8269188874713049, 2.48337644429001, -0.045609833451363435, -0.7284144190630726, -1.2063750387180288},
    {-0.17725710625571126, -0.5006270475620179, 0.21985789041298864, 2.178594396259776, 1.9603060895446482, 1.6801212942317303, -0.6899872546804467, 0.318155221053755, -0.5366670906491205, 2.0439363882400707, 1.8695769660171149, -0.03524143178263284, 1.9016000354510445, -0.017131910824984848, -0.7317587774343409, 0.09656690599585568},
    {0.3173780830132583, -0.044170767704303476, 0.1886092311343554, 1.5697755149978676, 1.7218328953090858, 1.1121923577947785, -0.5409751318438883, 0.20534181273394078, -0.1328723728387849, 1.3532112410923751, 1.6256779682934888, 0.08709004063233233, 1.7555863273712757, 0.047266797445223364, -0.30053568689067084, -0.012391858143997205},
    {-0.42464532127535287, -0.26581680175098216, 0.13287473415659895, 0.7413470832735154, 0.36372109656049, -0.20178944521807354, -0.2567372363917864, -0.12258735174073401, -0.5503622720114245, 0.5405408291616538, 0.3469814505390358, -0.29039730875365477, 0.532253674596536, -0.020678281626613015, -0.5723603503867232, -0.34015636231645446},
    {0.30806025949215055, 0.23891577436809266, 0.06330065951698355, 0.1349264776537732, 0.5349455386453147, 0.2563500735479688, -0.12712527037767418, -0.10194181915640763, -0.46997868602401766, 0.6155679294046931, 0.36681680798557753, -0.31066221673418565, 0.13117298854701204, -0.27954040542587416, -0.39439854037882466, -0.5695013235296068},
    {-0.35033634908457945, 0.038193128844982466, -0.06025264736697287, 0.3468399486484243, 0.7429593853676141, 0.4397607049020957, -0.5330269602706389, -0.3728705147643491, -0.3749928601319803, 0.9026885268929291, 0.22207692514266764, -0.6976473304084891, 0.46303667099869333, 0.21471051402787614, -0.6779423583051439, -0.7772659063523586},
    {-0.350056931851098, 0.03370668297640657, -0.056511777596978584, -0.2169322807139935, 0.42677488853270584, -0.17134667004481374, -0.3729442887579432, -0.4407110337998934, -0.16327349969722774, 0.2914482792191859, -0.23332139066747581, -0.5952251469805268, 0.2726782157494573, 0.019043515962990226, -0.6613338962636003, -0.7624159230899877},
    {-0.6977904140114009, -0.2915484857095667, -0.7727869761401979, 0.4949878229768668, 0.5139121436599678, 0.5467242116951102, -0.9509582097407772, -0.7227498035000829, -0.43065315918991703, 0.3791082683448273, 0.08372930856247954, -0.9921760615012409, -0.033712308323793884, -0.7723564532959698, -0.6818792882239109, -0.9335466770888722},
    {-0.1844003566915035, -0.4429936233120456, -1.201528269231163, 1.2218497575266338, 1.1762729409538968, 0.873137585977603, -0.16792275690732486, -0.22351686837597473, 0.3349515883436443, 1.3854927776802433, 1.245542648506817, -0.10070595127478332, 1.2468632274287508, -0.44764522300904797, -0.29141267924711844, -0.6010245424313712},
    {0.35825135494626686, -0.10633337252848453, 0.5794941578573141, 0.3868322893763998, 0.5082477188472221, -0.07780919427320145, -0.05419619439502576, -0.024147969819536527, 0.33028307884021, 0.17258013658915625, 0.5548514712838257, -0.04132744922142232, 0.5180596514495339, 0.12174538989971531, -0.6174363261114754, 0.08579867207654318},
    {-0.31869460652499565, -0.4626455968859763, -0.3167275552637013, 1.073525127093712, 0.8217640562305866, 0.26296639808652017, -0.3056012092251339, -0.47905382939023056, -0.21406162889696392, 0.6599155856559242, 0.6814356127109749, -0.284079980291375, 0.9487026554440853, 0.022281203580561088, -0.7787700480982801, 0.11906458433073089},
    {0.07043630324380806, -0.5339953568734673, -0.2922997925610565, 0.7952134721651217, 0.43445203318674475, 0.5761721819057818, -0.8153768276940533, 0.38641208387036347, -0.4010722845394747, 0.5437397382200376, 0.783077063459267, -0.0350344430000397, 0.34699682357859546, 0.036579490511862586, -0.30822339182985214, -0.1991090408603401},
    {0.36184885850332066, 0.32453385697838366, 0.16148534809902526, 0.17749250297989055, 0.5084063307682781, -0.4521149287437646, -0.1302371015719761, 0.23366080139560033, 0.09007658500633467, 0.4171988008098795, 0.16939211986742084, 0.14303817674258534, 0.15551880973541077, 0.17210922691024974, -0.46221050882356496, -0.1390924807421403},
    {0.45900463399093516, -0.553643014117458, 0.31737137091582085, -0.3230793358375031, 0.08939163900235265, -0.1628551699810056, -0.10585785438889915, 0.5690696899964723, 0.3722589733310285, 0.2573629209622559, 0.14387676670015398, 0.6136704090649596, -0.31756711038068325, 0.12325835577871869, -0.06270235954261817, 0.2715340806172617},
    {-1.0295018739886284, -0.6021862460941539, -1.213822749497963, -0.9864971950919599, -0.6855120196889051, -0.08580297428729827, -0.5463314683697524, -0.9838475473276928, -0.23998618312708692, -0.388561697385057, -0.6637715599248573, -0.9087984945192098, -0.6847973283592683, -0.4392849755859745, -0.18519320000000958, -0.8732139924545719},
    {-0.23543174628205554, -0.25661345506169164, -0.3439314174307752, 0.7260744837181069, 1.0061116276030562, 0.47553898968065367, -0.3010896753301685, -0.0645153956728574, 0.16987104768537914, 0.7739648017514754, 1.164944836120088, 0.08958878325792233, 0.698272723513124, 0.18181362977769172, 0.28381949689107333, -0.5414151627115765},
    {0.22709828410355623, -0.2754296137003222, 0.23071214930683426, -0.42614184875982475, -0.3381704073922665, 0.10806361169353426, 0.23972133228900475, 0.36497335255792324, 0.2630934603083585, 0.01705108268723034, -0.392828069098937, 0.32316621623550523, 0.19167147427065936, 0.05550015661643107, 0.45165863774537257, -0.10211672146066587},
    {0.28927038671064, 0.11630099991113406, 1.0645441608804835, 0.9367301079981998, 0.7367909724413788, -0.10640216033958323, 0.2690884969631725, 0.524893466598675, 0.7165079238510006, 0.04720403127383981, 0.42784570020867513, 0.4743809015007077, 0.882875326350897, 0.17093672284731992, 0.18175591074832684, 0.5613401754191077},
    {-0.11521827335467931, -0.05744154320012253, 0.06949801601095223, -0.38384544358327355, -0.49320276943222485, -0.24133996364539206, -0.20995760949576905, 0.0713252961507372, 0.3471072617080806, -0.6108230183253894, -0.391753798687256, 0.2560870963029453, -0.0924097235089074, 0.10465076806722012, 0.3267272042233554, -0.23197372416422582},
    {-0.04402424240144604, -0.2344858932448455, -0.3411896084723785, 0.9135203266504962, 0.28596089443164485, -0.1279293951432398, -0.36503784470697587, -0.05623871757232334, -0.14603964342884232, 0.47187830837545836, 0.0007160062615931364, -0.23227152306322105, 0.5415799069727127, -0.1834397531390077, -0.1877265027702137, 0.04418904687543856},
    {-0.24998683777770117, 0.07853771435219388, -0.1375642187289468, 0.3879422530510283, 0.24406548471987832, -0.12995455878212195, 0.06714514601553037, -0.07693113159135123, 0.020377026010650934, -0.001276582773955047, -0.05497209611907332, -0.13042842286416753, 0.3798314413316388, 0.09364311844991695, 0.08178314431069449, 0.021335343880021774},
    {-0.7740508656434741, -0.40398243799736827, -0.9761077894906522, 1.0821768134927616, 0.8167813716066081, 0.40004232765356357, -0.5100053978707364, -0.38723954058426524, -0.18480037768452298, 0.9968659370067778, 1.0590182406671607, -0.7034052283551091, 0.9598423433322758, 0.10187704257629719, 0.037005766750614025, -0.972085641842443},
    {0.03478287245107615, -0.598489032452857, 0.24198481335408875, -0.29999079449330124, 0.08207958944736665, 0.06808343361303049, 0.05072117279634125, -0.2809978418892375, 0.39866270477633126, 0.12078490330377438, 0.018629466725910537, 0.3138013430355135, 0.13249213984092623, -0.028264528577227926, -0.7717173173404516, -0.006228950756456482},
    {-0.02616532250907283, -0.6470420260423336, -0.21838579272465022, 0.11906077159673471, 0.8886183685704381, 0.4631337392063691, -0.682682977705195, -0.26422386957130756, -0.35294273502472423, 0.4009591309536107, 0.5525646721901165, -0.34493429108344004, 1.243342659802421, -0.47421479667931826, -1.2062709047447988, -0.5865955511437231},
    {0.15870700651959893, -0.16879221543210945, -0.1360804694883348, -0.9494460586482908, -0.7221964893362247, -0.24094689990579657, -0.0940866083301939, -0.18385911444262945, -0.16403009693993703, -0.4242075841017433, -0.9254146510294056, 0.20985107611938913, -0.5295013373329677, -0.29214043821984387, -0.5868887961412157, 0.3222381661701112},
    {-0.0959790415472463, -0.10417544852852105, -0.5284883766448333, 0.7304630848486788, 0.29491009995180584, -0.019534561665866833, -0.12641888703819126, -0.5506295561204685, 0.07689898993121141, 0.4322822923422038, 0.4420393667507133, -0.35408593843289504, 0.14620874543411277, 0.19748882964878725, -0.44176306168483176, -0.0887408317421673},
    {0.11464397133387656, -0.20046621354775956, 0.5410728558131738, 0.3602150982642908, 0.025184732257813536, -0.18644052148325574, -0.007110735926361448, 0.2522507474927699, -0.11905741206687004, 0.013833940363538005, -0.38421019018575614, 0.12753280914635, 0.2909578355128397, 0.21196815562664392, 0.03429031941834906, 0.16495999692659802}
};

static const float b1[16] = {2.874374628778788, 2.5447492102431513, 2.4573620644840974, 3.5290116612899993, 3.8210871904201515, 3.3410469091425563, 2.0367447755092405, 2.678872804052126, 2.2864985688322816, 3.833802706405586, 3.691706278330026, 2.53862376764737, 4.212228608240372, 1.4299760341457068, 2.4400636120653023, 2.3355989411028055};

static const float w2[16][12] = {
    {-1.6625838789388419, -1.3045328604559352, -0.9754629612121472, -1.7388346065700897, -0.962364769185346, -2.0721021086085374, -2.1962619429881953, -1.6750153617425259, -0.4513331893864761, -1.7420519928127631, -1.6886317447154024, -1.3265755665094656},
    {-1.640855096038743, -1.0522761497955941, -1.2234409306012248, -2.380523528021419, -1.007967165987387, -1.2377256066084203, -0.8494174233918995, -1.1528306626682179, -2.406790854289438, -0.7066220971852242, -1.720733147136953, -2.103673374112792},
    {-1.8548076791577168, -1.5585740007287006, -1.6432618475165894, -1.6044993922525093, -1.4461306361759718, -1.1756376660189427, -1.6592033820895602, -2.2771431103771396, -1.7012640387598277, -1.2412703871963198, -1.5507438947480296, -1.2076086353143296},
    {-1.8150893501463987, -2.542255975201873, -1.4716499358336044, -1.8950358493201174, -2.0582791369651936, -2.4458908478279517, -1.8069473749359224, -2.41071586792019, -1.6775565301124968, -2.5380713125474537, -2.103207100117754, -1.407990960676747},
    {-2.6698202712583328, -1.4113188479332452, -1.5529279945603192, -2.175022131678465, -2.574870760671498, -2.3458829063999613, -1.4772846419150552, -1.9904808580235533, -1.4752044634070163, -2.752264378556961, -1.9735410454251616, -2.8901711151622993},
    {-1.553837644602325, -2.090941659318411, -1.2637322781012241, -1.209138514989579, -1.3941769660063035, -2.177137879365999, -1.7768076583946062, -1.984932375255007, -2.3584241231348453, -2.074202729353962, -0.7439072649443831, -1.7618880065321563},
    {-1.4308036726626727, -1.9956455664237365, -1.2290227020460958, -0.5004361869471965, -1.2188329208109079, -1.7599910256868714, -1.0034153474057048, -1.5741791181455602, -1.4291747768567236, -2.0815668629158752, -1.9322128255973188, -1.4379157869100379},
    {-1.0222999345985335, -1.9196661844285259, -2.815660000241359, -1.9597440731631481, -1.354210171373344, -1.0940084444617866, -1.452729880666798, -1.7576699509662004, -1.9838914509349665, -2.030876195472956, -1.4618008500988597, -1.716047390256397},
    {-1.7134337137498923, -1.2540331250617665, -2.1344245211525807, -1.8024497813190397, -1.026912516527057, -1.5167294060063636, -1.5163812527519567, -1.8207442372061062, -1.163250600511213, -0.7201096069759367, 0.11166644548574578, -0.8059321438260147},
    {-2.086076954428829, -2.3201629057140836, -3.2694226071793757, -2.3674431790480477, -2.157047434375134, -0.7869823795780303, -2.269440639991994, -2.0714165232617483, -1.5733045735174591, -2.047404073585465, -2.629711725315611, -1.390188016052822},
    {-1.9441145802910504, -1.9530284178950572, -2.051033405973889, -2.6931477534984802, -1.8798158835385759, -2.3214056827218195, -2.4463608771527516, -2.8086792581599336, -2.9404322621653165, -0.8260414725525719, -2.50772094271949, -2.6724449914089186},
    {-1.568319499076763, -1.1385569403175129, -0.6663398607359232, -2.0053021509314215, -2.4832019195608543, -1.2737004141422417, -1.010908862860125, -1.931196809992399, -2.2691084662762924, -1.6581435944151068, -2.034165211426906, -1.2352741087455306},
    {-2.1436014934186396, -2.235079309669147, -2.8261760018331894, -1.7374128839811995, -1.9975412300686666, -2.2920429038916774, -2.6028845706504073, -1.2993304207684502, -2.6103976321107045, -2.323726675322457, -1.9580369597050247, -2.106900861896025},
    {0.5787609468909349, 0.08181757307949385, -2.3611254590280613, 0.31920637434629595, -1.0392016933366348, -0.7948837671371208, -2.9980516719594905, -1.861296020663784, -0.8736529087950493, -1.8591256465791468, -1.2976196305635572, -1.9950723844287668},
    {-1.738725814885193, -1.43267456041842, -1.6680545432331937, -1.0795412378088507, -1.3038748076509743, -1.2883890079550477, -1.5030261094961792, -0.7935203468667192, -1.6205864119970481, -1.5130633623968155, -1.5864077272571988, -0.9683414152739075},
    {-1.8030257841337813, -2.2901238588620183, -1.5534602039352312, -1.4081069286819472, -1.520483165907158, -1.996450395817048, -1.4033589362769965, -0.6018978337046575, -1.4471813561576348, -0.9060099659602814, -2.782458735206177, -1.9288130362746405}
};

static const float b2[12] = {-1.4010685697297889, -1.1557486077482386, -1.5011268128110689, -1.3564410988055167, -1.9716602672235954, -1.2548942282316975, -1.4326508185203533, -1.166702109525852, -0.9708512201778414, -1.1114030011671745, -0.4310215978249481, -1.3313368717674243};

    // Input Layer 
    float z1[16];
    for (int i = 0; i < 16; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Output Layer
    float z2[12];
    for (int k = 0; k < 12; k++)
    {
        z2[k] = b2[k];
        for (int j = 0; j < 16; j++)
        {
            z2[k] += z1[j] * w2[j][k];
        }
    }
    softmax(z2, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
