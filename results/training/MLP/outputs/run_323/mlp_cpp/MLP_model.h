#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][32] = {
    {0.31281421913730395, -0.8832524617067042, 1.916905630544838, -1.4807164479267616, 0.35784712987072187, 0.6808401196391317, -1.8849359009687463, 2.240272835774175, 2.6775399769402197, 1.38816282236125, 4.601385512326239, 0.031212664209137056, -1.1167117047260076, -1.0071626465566224, 3.555687191875866, -2.089555957376195, 1.5215432475070931, -0.38926946362481685, -0.930239468176003, 5.008400033338118, -0.9038796791321841, 1.8911221127609477, 4.272306020368237, -1.542613817338731, -0.4394715406062387, 1.899537788041998, -0.6646343764548102, 0.8573016462812134, -0.30670025386335104, -1.950990634461622, 2.569494139410058, 3.1275573874040767},
    {-1.6119242101273585, -1.2746646747397121, 1.7984042509042482, -2.909809237792147, 1.8323948371310652, 2.0364691546431604, -3.7981966130041007, 1.8467147686875927, 3.170919959489489, 0.8543292234476728, 4.595155375277465, -1.235299912897084, -1.0746631366810246, -0.3448613536039812, 3.969545202551522, -1.2263459380975388, 1.0638784726805717, -0.020665199399902072, -0.6231275777143271, 4.177695763696884, 0.6802728806388394, 1.0151195111684854, 2.977724362069926, -3.510655148382273, -2.2498991349652253, 3.977371365892758, -2.1234902072470203, 2.3699494006393103, 0.4682072567970079, -2.6392015329751177, 2.27506765936255, 3.999220269678031},
    {-2.97170737157967, -1.4586670529714332, -0.670231198364411, -2.2788528064218316, 1.7293126970734043, -0.11972467610987036, -3.2756262443858177, 1.9199104071277755, 3.7446646756909905, -1.4562693363872277, 3.8482641778391438, -1.4414296709014742, -3.6653280859649118, -2.6736368792530407, 2.9524342824020353, -2.4573977107287175, 0.06173305701486987, -3.1862350273484523, -0.7901508760680789, 3.7925155478543666, -1.047850292606365, -0.04929636992530533, 3.0162332796535245, -4.872159519803804, -3.283091264288125, 4.220757449229221, -2.959823364163814, 1.5244666879772617, -1.0018183489825376, -3.7677524604693, 3.7526972164988077, 4.324387171839712},
    {-4.2334837155769405, -4.415868906418344, -1.6146653582491413, -4.692313816097601, -2.335099854018052, -1.6114961293654722, -5.324697688419858, -0.5623994395496307, 2.3269201974852476, -2.2652297606998437, 4.704107082235389, -3.5165845104624007, -4.4708204761943255, -3.684490158827871, 2.0553918940301297, -3.936052975663172, -3.6045956056964754, -3.8474595076553877, -2.644004952071867, 3.9889041202126423, -4.415017389932045, -1.3254005053326663, 1.945955049112602, -5.894736149249284, -4.670553807639537, 2.4204430834237955, -4.591279890766516, 0.6304149905888152, -4.233710607500201, -4.627563263772938, 0.7868960421213653, 3.662108937601128},
    {-4.655722787404755, -4.988636370962746, -3.782537816897025, -4.548466344714368, -2.6559625995680536, -3.1616428317926233, -4.989677458623185, -0.5915783780075908, 2.5559899187796713, -4.363233917251889, 2.867954581110465, -4.0562893029169516, -6.069503018647861, -3.6799098429981227, 1.5467002945786477, -6.017259425815382, -4.9524907033113585, -5.075228363726143, -3.5735320630222507, 3.3863899270054536, -4.883187773780606, -4.553720584240195, 2.0195974525437914, -4.671723712331485, -6.162878871911758, 0.6080758216423378, -5.540707562787885, -1.4671725627151335, -3.6027884065754274, -5.073613957862331, 0.8966038624370924, 1.4231022430967155},
    {-3.834240336602153, -3.9413070067138394, -2.999897253716849, -4.452414383440417, -1.8319764503581033, -4.237374645548309, -4.984226824817556, -2.5084132220543407, 1.8162463595918992, -4.580943756229532, 1.3303201412987185, -4.7176991304497555, -6.1279470533784774, -4.380050038040255, 1.1328748594026716, -5.584520854064603, -3.6832494535852844, -5.589690649999738, -3.5339662788021893, 0.9952371108906625, -5.355734051170376, -3.8294619084160435, 0.718428818629454, -6.105774256669226, -5.235903787293016, 0.6157563091048075, -3.738797538990444, -2.678007194252137, -4.588948743105879, -5.560667395911309, -1.277353024419447, 0.9781148187054602},
    {-5.209262809977064, -4.013205710094743, -2.8623896797215633, -5.659187561126577, -2.2656258079323646, -2.79877615183866, -5.369838789719431, -1.1898657948653328, 1.325180008314151, -3.5434051369130177, 0.45449952601793003, -4.188394146449326, -5.85461704845956, -5.065325698024041, -0.9771587382568189, -5.422578174160702, -3.2299063982308285, -3.838004403033736, -4.378920573285126, 0.610399340455671, -4.737589404884534, -3.598917459878373, 1.2694846246066436, -4.4002691995727945, -5.478509590702454, 0.6716606653061481, -3.6573486492981826, -2.632664503718717, -2.877765643120922, -6.211383258332116, -0.7193082020051117, 1.3826907277653906},
    {-3.6059353802067915, -5.396422493936223, -3.3938286730435374, -5.142608012051657, -3.0604826548263757, -3.065925366994994, -5.760029424664148, -1.351027299673914, 0.9068149183835833, -3.4488475707381525, 0.04732251897855, -4.067139731653292, -6.5627387392501895, -3.7865295644467496, -1.4901812006302857, -5.107157623084464, -3.8192992639178462, -5.197439834344702, -4.7665217466187455, 0.44204334399285, -4.119371986670705, -3.938345056135634, 1.3839943754134334, -5.0692216322968955, -5.8482162136890175, -1.250173374918369, -5.379082705244564, -2.1843856671674664, -3.814517442637587, -5.887341072393685, -1.7848891176854, 1.1456680592132558},
    {-5.032043506266003, -4.182364874497929, -3.573076973698638, -5.4208096442514755, -3.57047997491067, -3.816029234923912, -4.592054747342841, -1.452283307095717, 1.5271501803660477, -3.63505723575962, 0.36821457673941405, -5.596241677785266, -4.974713863770414, -3.684460568973221, 0.6960444942305535, -6.096241568806223, -4.431573354771498, -4.8731164036019825, -2.968517142673765, 2.058433792902556, -4.051885855958771, -3.6745332077442874, 1.6494392112488205, -5.7305618619134435, -6.0298658879744, -0.9185088098953478, -3.820322596071069, -0.7579636944886666, -4.478458285841953, -5.0074890677942205, -0.5102726765644022, 0.841329561266011},
    {-3.933347223345646, -5.326069832340509, -1.075761066371172, -4.789502510546717, -1.0483326031294928, -2.822690730396213, -4.428801427715462, -0.3302366383660863, 1.6341060623186001, -2.516417313033132, 2.3064335765960178, -3.286232265749623, -5.536334900964639, -4.811540237675304, 1.0349133740199243, -5.3535119597691505, -2.221058464168404, -4.629306817449734, -2.9429124937372086, 1.4315601550962151, -3.120309415120891, -2.5804249850963434, 2.4842208718922034, -5.060647963785368, -4.8362403234591875, 1.7987044770473133, -3.7433324837245006, -1.006652028351492, -4.630518108079127, -5.2402466658835865, -0.022593256357119132, 2.708741936943365},
    {-3.1526445483528067, -2.8571491026719547, -0.710999947626466, -4.434089241056914, -0.4688052974639617, -2.8226652723092736, -3.8392815717303255, -1.3194453740834824, 2.393020590371822, -1.7765943920227651, 1.6963986379630456, -2.843241634117402, -5.259972589133496, -3.58113035246332, 0.3804544932007945, -4.63708310286832, -1.9358164055148734, -4.216052308702123, -2.1089178431703206, 1.0844210287901845, -3.4716479944538037, -1.4149626069678998, 1.7490825459597046, -4.43168251490222, -4.264531086081546, 0.7341874973948779, -4.578347987490241, 1.089909239042058, -3.4974693948496287, -5.787038540576878, 1.591746741284567, 3.1529427171566318},
    {-4.8579041958215265, -4.402343566257857, -2.564094368765411, -4.445324632596498, -3.3891700973764802, -2.7535538647785414, -3.8751251975541154, -1.9681231706314806, 1.9982415956086983, -2.614708297473793, 2.212329661572554, -4.128284190679638, -3.759325292757241, -3.9375022126074737, -0.9156296108572446, -4.317090204191481, -2.6581086451104126, -3.576004593353021, -3.1821037290451923, 2.1263936734891997, -3.8548874369411497, -2.309024413960227, 1.4936613663817597, -5.504838808910099, -3.8185073510549845, -1.1126148641794453, -4.819689280893889, -1.9674422890133574, -4.28682947152851, -4.930976232799472, -0.1359104767749374, 1.4340170584087308},
    {-4.4112138989595975, -4.748959481900839, -3.149617915336197, -5.217752457426174, -2.5109619892207533, -2.2859978785853783, -4.839857396806787, -2.002844526809016, 0.9873049667014192, -3.7084825954863767, 1.3009739223397532, -3.4102630763491737, -4.327545003304224, -3.1249118919157652, 0.8958568018196799, -4.299668021105011, -2.3399547172421387, -3.9834051286973082, -3.998629586187417, 1.604983155318552, -3.4104075416313187, -1.8157667440260228, 1.4815770434852638, -4.803624502224492, -3.9111871945949597, -0.5426183123521764, -4.145400154516408, -1.0113658265465997, -3.783095705007679, -4.64658341057936, 0.4035419306863953, 2.865447493000887},
    {-5.282704797076364, -3.385833028640581, -3.1395789331018453, -5.321345205472744, -3.085368016599794, -2.9650252608023506, -5.725263164092382, -2.2434278087720227, 2.2227326304900448, -4.173567057722918, 1.0484918974671402, -4.238197906740839, -5.23995703067003, -3.160719125170476, 0.6222059875602579, -4.2232261443887955, -4.490801222401557, -4.736450787628312, -3.284764055894853, 1.2663210976914083, -2.9626113727764927, -1.8544314165670241, 1.8024138977259268, -4.408076279662642, -5.230750272013907, 0.750708878219153, -4.129804153877169, -0.9862337515978297, -4.997610653164437, -5.255505945938757, 0.6132987328369511, 1.8306711824774213},
    {-4.902829421691973, -4.701936074036759, -2.11822756853901, -4.021253228214052, -0.8776139693191674, -2.091080161696412, -4.144667194087589, -0.6557984367047984, 2.7842242407303597, -3.275317176821972, 3.2219041264028516, -3.6556654568795244, -4.801063193396667, -3.986380256010412, 1.644895756206374, -3.568420395391172, -3.5589393580841175, -3.078468498373127, -3.5124739463442953, 2.1776802213618467, -4.195302536930219, -3.1670516042885883, 0.7759155808846586, -4.6214511995207594, -5.299187540976961, -0.3059312102109115, -4.55689463011633, -0.804803633946067, -3.876134116327471, -5.281285487408703, 0.2119538376610907, 1.8437253348619076},
    {-3.2763920661427166, -4.399707579845407, -2.319697831112454, -5.1795091833764, -2.141681089534699, -2.4508063543221867, -4.5904209224780725, 0.2578154390532594, 2.773663819062913, -2.618530672171911, 3.1707828649406467, -4.210044201246998, -5.785457421316574, -3.7871743931001514, 0.3559959941439005, -4.600342357853363, -3.2351922337271177, -3.5539060852414046, -2.0649737083012747, 2.633120945464478, -4.3764771440289705, -3.00402713191238, 2.1866616353762494, -6.321907957383807, -5.152911608946115, 0.10445060186795611, -3.3176711161667995, -0.9915563185846581, -4.370713516699892, -4.76523474459744, -0.0668991395109548, 2.81248575353666},
    {-3.4544172999899416, -3.156530060832399, -1.8657683281211874, -4.255342891835641, -1.8292527166232144, -0.7492993007321481, -5.102688441965255, 0.31496945433514567, 1.5621403616097678, -2.630150170100522, 4.576782434883612, -4.796372070582857, -5.03056073263235, -3.315267065261309, 1.0777968522871835, -5.091059056590165, -2.9407788742565972, -4.6793046298029335, -1.6232467495478058, 3.5168059213847402, -2.724667986176589, -1.6643452890324575, 2.601076544388283, -5.024236438228645, -5.681560033211149, 2.2787705209202893, -4.543185576841431, -0.42868492128193797, -4.61206684328542, -6.036835557814479, 2.1913896485257074, 2.9622511131661025},
    {-3.807176590353497, -3.866671138558263, -1.2299957627499736, -3.207177586872378, -0.026913821760693995, -1.684871183716812, -4.210527177563886, 0.5883123126107556, 4.2458900937882555, -2.675858755954184, 3.4364031641046395, -2.950593219018285, -3.374361631217708, -1.9488708684131, 2.7085823301145147, -3.2633719017562215, -2.2403933212356453, -3.975713990471269, -1.055223032229551, 4.663819265920809, -1.5534012582359555, -1.8563273232507773, 3.6944874311450717, -3.050749243688701, -4.112637575737675, 1.457429473654663, -3.5014779636604567, 0.638678101736809, -2.856884562840707, -3.7471972595068026, 3.1840712314038675, 5.063615473364259},
    {-2.404225688002106, -3.108373287373857, -1.0594793953079926, -4.544168163912853, -0.2960119749181628, -2.334691157959071, -4.790638512209234, -0.5344481469208591, 2.7209894692514482, -3.152920989431317, 4.768928658587406, -3.5300957019654686, -4.705061346976613, -2.504681470365051, 1.1159208992845757, -4.2776726714494275, -3.119548302416756, -4.2451944377592925, -2.03540524343913, 2.9154421535056905, -1.7483762604241257, -1.723077987231689, 3.5542275227472566, -3.855049913641085, -3.4914020855466377, 0.7122440854572067, -2.4800692454997386, -0.10304365417770578, -2.9777442672541783, -4.748808732072095, 0.7655189537669644, 4.308288663279487},
    {-3.769586521466398, -3.113077914659849, -3.0328114578586063, -3.7045816937635028, -2.2871175257410363, -2.4363349200506264, -5.3890972476534404, 0.28264091604108277, 3.298053450566465, -3.4077731222000445, 3.462770647825915, -3.8709995305113707, -4.020728246269452, -3.3456762492857646, 1.8149329425002139, -4.845305207583946, -2.3705637026545126, -3.6736796582505966, -1.6006484760587159, 3.9279197017285554, -2.9183061840169895, -2.3355888315117763, 1.8991950489615026, -5.888389584234359, -5.5130097922738655, 1.5146936106945652, -3.8970783535100177, 0.8623472506147648, -4.497449520336192, -5.562862215532642, 0.6965797377245951, 4.062049498989816},
    {-3.250849088929441, -4.417613426757729, -1.1034852175848067, -5.0182690378326935, -0.4787944316828009, -1.7082932322295366, -5.1448132592219595, 1.0147413780933028, 3.864957289774728, -1.310683699222671, 4.318553820738218, -4.448407153174957, -4.231664903268103, -3.746205109895453, 1.6872791092447692, -5.096077801165351, -3.51204514270344, -3.9399393087928964, -2.2725974453003785, 3.347745052376998, -2.773379303517519, -1.6885830439773761, 2.7366935861940087, -4.4481155336578855, -4.9047695108825575, 2.3962619778110663, -4.950454158910991, 0.37787896686769346, -3.5971239314254624, -4.636921205991738, 1.6894568089513258, 2.833207406260208},
    {-3.866797527545016, -3.370351811288688, -0.6878309884184951, -3.113011147694086, -0.005722645074021697, 0.4938031987663685, -4.395817308018899, 0.4360819360821987, 3.8274496708442367, 0.01598384063986646, 5.700075150069362, -1.5988998148131124, -3.2497126167078902, -2.767405250260609, 2.1914912730890004, -3.9060207737580757, -1.8843823142328875, -2.824702610845471, -0.22415729664557887, 4.3188382733403285, -2.480223696762479, -0.7573906240897783, 2.7711553157034285, -3.0829182749537303, -2.7078732381602353, 2.4935819741315504, -2.0858254677889647, 1.4178631783435969, -3.3165518477850044, -4.603821362121844, 3.559386118203094, 5.636787507663996},
    {-2.277115202106856, -1.738233421428615, 1.3022789413684996, -2.957699321577758, 0.49551177767225696, 0.1690538111184484, -3.906714091436861, 2.0029730637819094, 3.3389429951600813, 0.11152352518310579, 5.50041500925382, -1.5465774469700373, -3.0521094349188638, -1.2590910351586688, 3.1124338830840137, -2.7162440236161705, -0.4475583624102872, -2.022863948614545, 0.20231205000036478, 5.41499536659038, -0.8784072982336103, -0.5361509240445039, 4.548983246882214, -3.875283723592787, -1.7101259779312343, 3.7200281043948404, -2.643779961493641, 2.340583966961925, -2.347777330728859, -3.8108515918318493, 4.202458866652982, 4.576777363829486},
    {-2.3554034301104187, -2.6356900769344738, 0.16327348196572217, -4.060013412125636, -0.41572315554742395, -1.2559366759269062, -4.050351227625315, 1.6727647830269055, 4.364506223375154, -0.06629729792566913, 5.062014454122871, -3.579035517346679, -4.093045663473398, -3.2074133584832047, 2.9785320082763307, -2.681085729003461, -2.6654962199368604, -3.521995290003068, -0.8730344067538475, 4.773278731423176, -1.9655900631784315, -1.1866591709301149, 2.8473138765397668, -4.128116851612991, -3.9564033205615186, 1.9019055811151286, -2.904514264771418, 1.8991122481578064, -3.4017739087819403, -4.6198017491509065, 3.675200684994676, 4.6493356473086305},
    {-2.5788924902430796, -2.5217531099932367, -0.32402613626057974, -3.5560317466294364, -1.469908364098595, 0.09264305817558552, -5.545110678279969, 1.8664775512828309, 2.142478037507478, -1.2941214015187938, 4.513417139637862, -2.5302650837067833, -4.382268363593939, -3.503997340866785, 3.0994729550487716, -4.013352660663407, -1.5482994994847343, -3.3596090317295424, -2.407375156606349, 4.404270622439958, -3.1547921250216056, -0.1469789136070535, 2.232000684544453, -4.373483978799855, -3.5645630947753477, 2.0752179016319543, -3.962050300910651, 0.9925447776019467, -2.3632742771616737, -4.241806942240907, 3.1848156625154203, 4.639735677861317},
    {-2.010582825316218, -3.306395167067208, -1.5815025618697214, -3.935647283068632, -1.4610499973176252, -0.5334983124693049, -5.028240411610957, 0.6757254620317613, 3.4036918516957577, -0.5963206468878219, 3.335123853088167, -2.701560516541097, -2.615881848624585, -1.6165488048483607, 1.4013485410872302, -3.8502229436527142, -1.978180722426399, -2.3293361439502887, -1.6110009534863974, 3.137131573263235, -2.17064567400336, -1.8941132797662956, 3.600667613028339, -3.912158370558005, -2.6104778466811878, 2.1945096944413294, -3.1078627265986993, -0.004269871536918482, -2.8652623421272665, -3.689977646302937, 1.9753888233280754, 4.662106610386492},
    {-3.4029620714868796, -2.2550608761142374, 0.5293322124470329, -3.092698932325521, 0.46114103101146664, 0.1424461646670337, -4.837492498833255, 1.7487028676925496, 3.456374756755058, -1.3276205936659822, 5.22142586233922, -2.0677005312652437, -3.1716577613897234, -3.153910981899934, 3.189982952527718, -3.1195265872420785, -0.9805910500915159, -2.700146396292217, -1.9017516207010499, 5.349287877503481, -1.4552272329036862, -0.3644345759284538, 3.909196627304206, -3.771473530365252, -4.167023874090036, 3.2085819085736875, -4.364066210924846, 1.1382535740168096, -2.8753724093133814, -3.7157342644207723, 3.3637126089119755, 4.872284027350527},
    {-2.8995506773700126, -2.435905485014968, -0.36323129653690817, -4.62124923736591, 0.350328890499667, -0.0950002074821825, -4.721211323453029, 2.1303677419095024, 3.077015483880243, -1.3481100913995823, 5.382330337702192, -2.585823836250457, -3.102126197380035, -3.642228409824398, 3.123140917818944, -2.928848210646586, -2.4778984312666443, -3.8282592405643814, -1.0679931023752436, 5.0286067438164155, -2.747222735035461, -1.7433308985726126, 3.360261406641538, -4.482152057166845, -2.951430386047421, 3.254106652794653, -4.394575364162644, 0.9686668530374694, -3.2456207862087347, -5.236447854696005, 2.3611155118414, 4.578375119257388},
    {-3.6100280794384303, -3.523243382450944, -0.15243351141822548, -4.512796932941377, -0.7068743276797936, 0.17482866260641705, -4.832662815951843, 1.594718057007058, 4.447069339368971, -1.379306384818945, 4.2824257724270165, -2.9767226698914175, -3.0916157103500206, -2.896217475287189, 3.815316066810361, -3.60776155048387, -2.499312083532621, -2.860491418294158, -1.5405085538713155, 3.2579343237574325, -1.921336274047556, -1.3994164869777324, 3.7510062606255365, -4.567991953260677, -3.527629627576073, 2.8956644009417682, -3.6850865505381063, 1.6641436472408366, -3.220872753129837, -4.6207844337835535, 3.2803019928029866, 3.406868863269263},
    {-2.376027289353303, -3.1239255907357655, 0.5665841391301488, -4.146891546445842, 0.3373530716680609, 0.5842151097515824, -5.240709369753322, 1.3859019139588984, 4.214047496251841, -1.5475031978850806, 4.732482642761748, -3.3380540158699277, -3.9640379720988337, -2.0142193828820556, 3.376209028139416, -3.3008465377282215, -2.145001046393463, -3.35653968015056, -0.04897453634385829, 3.817969006801513, -2.111797509718829, 0.3973321485522836, 1.9224228800127654, -3.6332036263259586, -2.746053826060241, 2.6685401820020718, -3.2788536729949462, 2.2584067418921348, -2.4122187785220266, -4.974853784610084, 2.563001264289393, 3.879518386961406},
    {-0.4287060364600384, 0.5505445317018484, -1.17348232020821, -0.2491324797980958, -0.11767870079385266, -1.9543738879325812, 0.2397831398995854, -0.9677736330211247, -1.2054583586585974, -2.4388811671651944, -1.7735538227546335, 0.03309048024450269, -0.3707614223249692, -2.2491018238363276, -1.1097055014637185, 1.3397468437106246, -0.023621952865092447, -0.6290785686466029, -0.3247162964147384, -1.7404299696724665, 1.6624762137815088, -1.3018823438551097, -0.7462632482833824, 0.8842801120199244, 0.5530487774155364, -2.0796760028974406, -1.6479317465786523, 0.3003139817581059, -1.2456195985616745, -0.08173629926428025, -0.3881453870076024, -0.8150853378574423},
    {-0.6494374332299283, -1.6794899276854565, -0.7548176046357874, -1.1493379263468726, -0.06383369306368787, -0.36294748905303853, -3.7964419524020276, 1.0013537108589108, 0.8884229785541516, -0.8564215517624942, 2.5184984154551957, -2.4395651312943913, -3.496787185087759, -1.7631490946592143, 1.0346056851235983, -3.330373544085391, -0.542241888849298, -1.063261059010301, -0.9533919290895441, 1.8607466817983385, -1.6868028241502884, -1.4121899385752075, 0.32834396566592355, -2.4695670846484705, -2.204134089907608, 1.2380167297146893, -1.6472790241782176, -0.03205189716745718, 0.23078907850275854, -2.0453587465382226, 1.0804609379342602, 1.1516207789990118},
    {-1.2573733048961373, -2.4735258147878696, -2.924457293280129, -0.9203032449358929, -3.765229585287666, -2.7959456419035926, -2.2702724728937467, -2.4731483073818765, -0.6877100473910842, -2.921214747364666, -2.9776968600119718, -3.234613595745257, -1.8252149844858427, -3.306671644551185, -2.120064427748502, -1.1749807654676956, -3.028370390381895, -3.284570216664571, -1.602416892751267, -2.2918039606635334, -2.670550458987403, -3.313961105031369, -0.616632537261452, -0.036499836791421957, -1.1151797503749972, -3.6873264438640527, -3.043348756256961, -3.505138192358349, -1.2817456144830863, -0.7556666708687743, -2.854881470046753, -1.476723083048844},
    {-1.7712445660472704, -3.1224694672528015, -2.3987806451512546, -0.36853856733301665, -2.7329178987490637, -2.898853661576763, -1.220037847718284, -1.8416672405623076, -1.6150601419044586, -1.8201966233216855, -0.3241701150470574, -3.0485879367483713, -1.271041992495057, -1.796359172855556, -3.4288809268180884, -2.4337483656786087, -2.8027507479570324, -1.293900143195847, -2.027461858917462, -0.3299186437336423, -2.445485457158455, -2.4633754238008163, 0.5388477597707282, 0.40900049825515467, -1.6566430028406705, -2.2411540766553277, -1.4305275559999253, -1.1885639148893423, -1.8367336250932385, 0.12611649686795903, -2.3562184745530996, -0.1941145989029128},
    {-1.6393630356013467, -2.582608987585933, -2.519215499965415, -1.7816231626172858, -2.822874026597267, -2.73155069283902, -1.326648288241368, -1.3457784907898949, -0.646391623535541, -2.6017023454277344, -0.7678071390561825, -2.047244942963926, -2.7308613376316244, -1.396621475229683, 0.04034343566427924, -1.5844421672613385, -1.9825449896122411, -3.5794357774499344, -2.011367150827699, 0.4596326039175871, -3.0741953049585073, -1.7934769618342612, 1.2580126036684274, -1.4241443549796353, -2.9289264577434277, -0.21198920008447739, -3.7146122114715574, -0.8455568173013605, -2.7287824398760563, -1.7393894565580443, -0.005707760631196326, -0.23190979620597077},
    {-2.303365283367921, -2.6840882089046127, -3.1361667258175947, -3.1838836236891104, -3.843081655570242, -2.3994193283435443, -2.903415123521957, -2.1314562743678045, -0.6137641301355147, -3.0674867659892966, -0.801379600183975, -3.0250864980904018, -3.7200691772690457, -3.0113148292559657, -2.7278255213582856, -1.9768156376646393, -3.3416698844605306, -2.5684222426549397, -2.363694653976028, -0.5534332718649682, -2.0978435368974875, -2.2519184338471523, 1.1373080021163628, -1.4643924561636603, -2.5219990492886475, -2.331783479198891, -3.215814514921465, -3.0943355672087627, -2.8163434554751317, -2.249542540077799, -1.0635907645095581, -0.15837448758676412},
    {-3.2242970342622685, -2.4506729020727533, -1.7060044401091754, -1.7957284247182532, -3.5754639387212634, -2.9704626897092394, -1.5946036628035596, -3.156020488612755, -1.0521233860388128, -2.8176208196260784, -0.6518922533360467, -3.60038108468803, -3.67812830551702, -2.871412422127702, -1.383565137893117, -1.7574876133525432, -1.5493844103987944, -3.4400169158256277, -3.2165050441887604, -0.5076664661343658, -1.6722727051713755, -3.2496704981023607, 0.8231666359327058, -2.5289994362029637, -1.707411609708125, -2.7940665891200522, -3.4205801921859664, -2.8156443767978065, -3.0790710526056038, -3.7112826016899922, -1.6677510237887947, -0.9959692611851277},
    {-3.159926842050521, -3.213193843707938, -3.266288490204539, -2.2653780017643723, -3.037800669898604, -3.2760999034375575, -1.817019599307503, -0.6716249887665519, -1.1278352114004309, -2.4582840896958844, -0.7613696317762774, -2.0292109404508754, -3.493749409361124, -2.7618745631202843, 0.18013186667796402, -3.1891474050480375, -2.819735492692576, -1.9602299395513378, -3.023284954881629, 0.9986689961130372, -2.375102145887573, -3.3089615850862875, -0.4954329632766921, -2.9505065293532047, -0.5066946885971616, -2.0908366392886215, -1.9140011334537725, -1.5285361433584492, -2.3803800187992805, -2.595603984484726, -1.7471083001954348, 1.0060975280096691},
    {-2.3631448136724233, -2.5387965516620308, -2.633531858934394, -2.3683229018362195, -3.4021942557942277, -2.3410544085849003, -2.508902203733523, -2.0666408367653317, -0.3090628410914344, -2.7312731306223337, 0.6631917307816784, -3.6250150481819077, -1.8419709248508591, -2.7717212050022235, -1.7710961670249208, -2.6032818780017832, -3.77913426115705, -3.9560528891936655, -1.4943433089042102, 0.7541015815850023, -2.6911869197008698, -3.2263184007238106, 1.3262750124062066, -2.9547813172598176, -2.1245545536524935, -1.3717377451726678, -3.421333599308819, -1.9476716315597442, -1.5027323192638877, -2.6915049975266196, -2.194338365169135, -0.3269352902370042},
    {-2.5386550850827927, -2.1288782445957333, -2.3682546414607524, -2.5109460623797144, -3.7915375779674925, -4.0895557577335895, -1.4501807221370129, -2.820060605278519, -0.010240569592031493, -3.1865128519872674, 0.1931708948052419, -2.7282583387350514, -2.7799697111369865, -4.26535777162809, -1.7172307466231767, -2.015511416283869, -2.376091836804235, -2.452950303946088, -2.5062264484891332, -0.6313209249779065, -2.380321581828566, -3.623171123217207, -0.7424712486714811, -2.2747504381267887, -2.5087259930596413, -2.8472118628921437, -2.69392699683928, -1.1672889200810495, -2.729668559606825, -2.362232707559324, -2.7205189036416484, -0.11420056726147712},
    {-3.5106743130127858, -1.6775501586454908, -3.1803134523208616, -2.791415006867748, -2.320091592332219, -3.5766213454147757, -1.1663461983666796, -2.3161315071395636, -1.272144556760195, -2.1556249146585595, -0.06675677459499352, -2.649132860794943, -2.3139324808988797, -1.7023241555185276, -1.577989302845612, -1.3095304625159463, -0.8544849490207231, -2.981717438342172, -2.441885597367443, 0.21444305252798893, -3.174350638178388, -3.4467968337156294, -0.5189682366066225, -2.373120610173373, -1.2530973132532741, -0.6271689637317888, -2.968151867584249, -2.3976922508757648, -2.637631571038567, -3.439138393747593, -1.1552548442714836, -0.1986232399198395},
    {-2.8010235194456783, -2.3640519418532175, -2.4965530761629644, -2.983857038515518, -3.5394171155482708, -2.644200417154084, -2.5417691991287734, -2.7772861201199155, -1.31910390221957, -3.043469102250923, -1.3123576838120057, -2.211545149640626, -2.2705403297655145, -3.0011489185267193, -2.211996335749836, -2.8876501642397643, -1.6045941961281218, -3.266577055358235, -3.753683311025776, -0.21178311849383408, -1.2249473476164257, -2.1977332049612817, -0.5683715602234135, -2.1132608454242234, -1.4228521349385101, -1.9238606170155534, -1.984445922331033, -2.7012784990404866, -2.882804855576431, -2.1575652282057654, -0.9147529905459973, -0.17070445818160074},
    {-2.1566582170724224, -2.32520408465402, -3.7271914748272903, -4.006078984593624, -4.319089017617079, -2.7432919855005187, -3.090933404125615, -4.507322028172006, -0.8408890037325497, -2.488167991135942, -1.494522891738535, -2.4118798719805414, -3.7922130929454556, -4.424785568970586, -2.6038579091528087, -3.302607789302704, -2.498809232363745, -4.246977694315561, -3.6332268887069175, 0.2828928106607179, -2.6069515242865364, -4.164252924375374, -0.625276571976367, -2.508289663296033, -2.1547863663112814, -3.160855845937314, -2.7546113470515365, -3.5481252553675, -2.5902257072363386, -3.5696112271490907, -1.6260977184559449, -0.519954243057259},
    {-3.5688803436910566, -2.6862455309766156, -3.4944324201784083, -2.7636778059788867, -3.9215107547697965, -3.774795105790352, -1.8317541577323906, -4.495992021092502, -0.33961799161130507, -2.8728433675359506, -1.3161375905073678, -3.2394794877371424, -3.573999774702256, -3.885451284175681, -2.5485549576178297, -4.347646716942783, -3.8067094551347496, -3.3708575955021804, -3.0845082253120952, -0.9239250023160582, -2.177202050413131, -2.8549914747230773, -0.9761452627337035, -4.353092177842868, -3.048441852910096, -3.4381426394882793, -2.677947864429363, -2.6232323367971193, -3.717806946662756, -2.4548025323595186, -1.912649205239891, -0.765219706584212},
    {-2.5427706382643795, -3.6009251227528223, -2.775989351299536, -2.68651098485885, -2.7739455549115646, -3.8012910508536746, -2.3155032925223407, -4.278847634569913, 0.05510640275407674, -3.7383949375208716, -1.2615935704207573, -3.6516248317212963, -4.166624865144862, -3.467137165712964, -1.7213064711369874, -2.356693511828561, -2.789052339942141, -4.190535894731122, -2.7155032426142633, -1.0694288074866796, -2.3400911983888615, -3.6425826517210003, 0.7963108981026698, -2.385678225504914, -1.8652287904734106, -3.3118666862644717, -3.8768438513643755, -2.156352437078809, -2.375809945203102, -2.8368821294651947, -3.582051538571747, -1.035302549270358},
    {-2.252896496277561, -3.829649230399001, -3.852232065007172, -3.4240247629337963, -3.3891172234540554, -4.404469004583109, -2.160091325479596, -2.5370192432459255, -0.15769945369950056, -4.781059956319437, -1.672906118677445, -2.6503946107735437, -3.6927544372462653, -3.2323105528878076, -2.5056178613964804, -3.979012884097627, -2.8936843581247476, -2.1939281310956638, -3.4953184055046282, -0.9970964114793401, -2.7291168311965737, -2.8047924793350494, 0.006821452461949848, -1.6955738111327714, -1.647235306425705, -3.3389362616583376, -3.414527906792625, -3.849352533429536, -2.8441626803777593, -1.8764517630244615, -3.893118644225546, -2.2803939899229912},
    {-1.05784866901366, -3.724336467526771, -3.1376829284572008, -3.0626933194921575, -3.6787885037762065, -3.0374986807183553, -1.8141749128500564, -1.9074614372698995, -0.5588297140140635, -1.9364989070759127, -1.5852640201357595, -2.511244286552453, -1.1116317066542598, -2.803146101345581, -2.8061768418371815, -2.496245924293639, -2.7766707518617237, -3.2823112541626047, -3.3398177840003505, -0.6915271574510468, -2.8159182388459167, -3.368315112374214, 1.073444572772557, -2.5730059982764066, -1.771737507249123, -1.6828498021673823, -3.0687551500219814, -2.0168258294533996, -2.2461401747749767, -2.1243763869532346, -2.206880384609831, -1.1196982081781868},
    {-1.675664436070248, -3.4714600862053526, -3.036423151303916, -2.8231235290805627, -2.229780621824979, -2.683111981234108, -1.2470594255588938, -1.458950442098956, -1.1724008799453238, -1.579340575140945, 0.6850867664848471, -3.6334332959041293, -3.219008199044109, -2.3531792712171775, -2.292568748100975, -3.3641913023555414, -2.489617666490343, -1.14369085432564, -1.500208052490036, 1.0505453149089317, -1.4230815786359925, -1.7864649028009914, 1.5659775595213168, -1.6281970278929927, -1.4815486251565793, -2.8208408809278938, -2.6195227812878015, -1.1280712743063117, -2.122038630994591, -1.4456547702808524, -2.5346561738104514, 0.9484555230247976},
    {-2.2612695852868776, -3.9212896312187193, -2.805123369068903, -3.0991889881918704, -3.715811723064441, -2.6885551329011967, -2.1939256547315447, -3.30714237433827, -1.676831066521844, -3.4469293385688626, -1.7765423599472618, -3.5870257127932708, -2.6060746126465197, -2.0990183908199382, -2.780911313793695, -3.5913355093239847, -2.933414550127919, -3.51830631273555, -2.0290586568354607, -1.41902717677667, -3.1676241701098777, -4.153945080280403, 0.9584700097265155, -1.8812424895958137, -0.779544380299866, -2.8933888336155813, -2.937593643675512, -3.935037461211234, -1.7182958610528656, -2.1533780448165083, -2.0860894236526235, -2.0764825184342133},
    {-2.6721017131229674, -3.4171798776238775, -3.606996969678364, -2.8072653570780375, -3.4035150045615787, -3.9472380332893544, -2.0338027561767245, -4.146933436906317, -1.0665609946855108, -3.2105928473904286, -0.8435105531666809, -3.3171283271437972, -2.6710415683029067, -3.270186361344647, -1.8719598240018998, -2.7386080260679013, -2.365573590350478, -4.116531565684922, -3.267068480622728, -2.195650348182301, -2.0232650195303217, -3.664470296742446, -0.08351813685117393, -2.7920583620681145, -1.6513038363851857, -3.9299407156825303, -3.6296870008713245, -3.6259088745990633, -3.7272329323391453, -3.508299337847897, -2.3300378185499833, -1.4621684897633098},
    {-2.668328729339623, -3.9347170537960405, -4.0553242571425825, -2.923836561726711, -4.701803615404297, -4.262370558474864, -2.9393967444846174, -4.258121154352366, 0.21916420245480606, -3.8036388190724537, -1.6556115109097673, -3.054284702272014, -2.5103845724277227, -4.68005098248433, -1.9655512213580688, -4.346014181339401, -3.659027249649119, -4.03393394910279, -2.5846570062307177, -0.6326804490931804, -2.989621767197909, -4.805493950928454, -0.7769794948588217, -2.527021082314186, -2.6742053941148995, -3.776655788561749, -3.0639995585492965, -3.687414529046602, -3.214537612107152, -2.196365151411386, -2.209319679972625, -1.289649244374525},
    {-1.9277933289659552, -4.0052699893293315, -3.0809986045382827, -1.6496497323769017, -3.739175669444788, -2.281541797599913, -2.7452644004468083, -4.041770433124366, 0.26144846563153, -2.679552427591498, 0.5546842116808388, -2.6989106971829724, -3.4623009577295765, -3.214747451053614, -1.5353757134799286, -2.5860460140129318, -2.231955687333525, -3.0644810899374026, -2.6599985977975544, 0.2332646880472359, -2.560980425166275, -3.4735030426274984, 2.5656001750303523, -2.8528064151194137, -1.6257615278436324, -2.3293840767748812, -3.0231229412107377, -2.3351389084433114, -1.4543879444391954, -1.932643205814518, -2.2585744593002683, 1.0888908855325046},
    {-2.2284640539297604, -1.896243414481333, -2.278290437511818, -0.4896699908151827, -3.8220869024421034, -3.1939712118175065, 0.6513656406810693, -4.5025748858067525, 1.4932220205069968, -3.45094167631541, -0.9627298346288419, -2.4708481919143117, -0.7876890313303195, -2.144568592120115, -2.3904960083304103, -1.984294977405156, -2.944609503701164, -1.4505252466055252, -3.44618796809919, 0.31962373741667505, -2.0883516926837964, -4.453222432453636, 1.8961292447556668, -0.15664258219972055, -0.13716852378686126, -2.4825313100056055, -1.8060334510834855, -4.076961655298071, -0.4010288641586569, -0.5442925689016462, -3.17959630638562, -0.08458936388178201},
    {-3.060616459274763, -4.130227504295372, -3.006568389238506, -1.626458845220867, -5.238419565509388, -4.5039737660700645, -2.2548520798783573, -5.283052569528775, 0.003452596134062301, -3.5004034205767054, -3.1257782230065443, -1.920304766091533, -3.763793822055798, -4.755707367172716, -2.9880840977859124, -2.575227917196064, -3.794644465507303, -3.2312928355476465, -4.208565617315225, -2.628282969701453, -3.922816863397843, -4.733738919551476, 0.7542045867860088, -2.1327833744042506, -2.16372108192127, -3.432182576629312, -3.9900640423912055, -4.136781602721722, -1.4746533332966953, -3.262261391550033, -4.273877006210496, -1.903757847332049},
    {-4.288155330750868, -3.351413936328355, -4.864286619177736, -3.4950420727935394, -5.428743596509398, -3.988684946484014, -3.3664133209292073, -3.976465577742392, -0.6480952449613819, -4.588863367236549, -2.3220448615503857, -3.018676249931472, -3.3267623962184696, -3.7968056012732787, -2.7528542267312512, -2.6897225226588852, -3.767416366281636, -5.096905272226599, -3.6214377629630916, -1.8063271002122627, -3.9774187511995494, -5.2471472165099895, -0.13549583807080268, -2.0534904234357643, -2.646959271199482, -2.6907640191475957, -4.961331816444828, -4.636710946218345, -2.532810161091615, -3.347001191542963, -4.40771675500661, -0.8211552783619107},
    {-2.0654290461265092, -3.5894824506221794, -3.2855775939713006, -1.1039876766637013, -3.773214167309606, -3.343793258833405, -0.8420985978914367, -4.18815238158622, -1.342320161076376, -3.040534945898189, -2.264275713938585, -3.616346350109273, -0.5867201767828742, -3.1759871967687734, -3.528308494130678, -2.606278548007363, -3.935543563248678, -1.9940146786277295, -3.534210657116873, -2.458511701018587, -1.4757502332518424, -4.551252259747262, 1.4758732265264731, 0.010397404460066009, -1.1445234605178445, -3.537102833907995, -3.1719349366084244, -4.159830067500608, -1.0036463726806741, -1.5678236509860985, -2.8389982452756324, -2.0430643749939827},
    {-3.1347815218652055, -3.85601636414408, -2.470942455717904, -1.251288413965683, -3.7855466061329595, -2.9846075463551096, -2.027645139573616, -3.5138922117881743, 1.0378065603250608, -3.2114240746845333, -0.9402023793359329, -2.85951067086014, -1.2552526909187762, -3.812745932011222, -2.440292496233701, -3.174423228678189, -2.4933325824628345, -3.7994829602832536, -2.7427647002060276, -0.6600133220446758, -2.857408006997659, -3.9918560225143245, 0.8043699075327447, -2.1229753325403617, -0.40987782001094963, -4.126233900047416, -3.8207139487478425, -3.862871798161204, -2.244996531323294, -1.761517568059136, -2.289518930091245, -1.3433691876275897},
    {-2.734246941016428, -3.910947646189208, -2.6699675412993162, -1.982192521328045, -4.3176817807495915, -3.251882584645169, -2.1111630466127482, -5.31643749991423, -0.8227246552164696, -3.512261254338732, -2.2748200919852963, -2.7310045179292057, -1.837103546126838, -3.780097610920515, -3.9073412262035454, -3.7439068775098883, -4.505335596297778, -3.2701690826968415, -3.2627462579348347, -1.6937162288291447, -3.50254184520315, -5.410262048240382, 0.31630956928023585, -2.333786899424633, -2.5496818524242904, -4.070245788848932, -4.286387041166663, -4.4051260173475, -1.8167480080678333, -2.411083525083747, -2.5845088513507366, -2.1027456018514283},
    {-1.593366425325478, -2.5242389556045053, -3.7733929451044568, -2.8202553936150787, -5.0147547251217715, -4.55341736417375, -1.0750554828621957, -3.925563508700424, 0.5078929407768192, -4.631878679599109, -0.6937914005646714, -3.588800822221066, -2.2993029434225094, -3.7055696442079196, -2.0112449733795272, -1.6963340905991666, -4.5086669292872, -4.005313954756435, -4.167210292395357, -0.9535113887534269, -1.9922544244252083, -4.2602955723768146, 0.9762466904844024, -1.5331046292280803, -1.0970510504038644, -4.5613549253754275, -4.265003306017893, -4.762304360878203, -2.2728246393853575, -1.2354499986136105, -4.223157542094926, -0.7374766022958585},
    {-2.642378666504404, -2.361834143536322, -4.148735577342786, -2.273154572513317, -4.9600876262349285, -2.5026662281255443, 0.05839409426702121, -5.491378398388106, 0.5967658281541289, -2.6686252098941305, -0.6526009558630933, -2.7536659470960343, -2.4138625574704013, -4.028059956197159, -2.283585819227804, -3.0759519208610784, -4.116383281138808, -2.290904740938318, -2.1734970184664366, -2.2281323994249, -1.4462589000040096, -4.902426191571241, 0.7356873412542898, -1.799552930572364, -0.5855838589473511, -3.2515896638874606, -2.7292818595210315, -3.6661586066691756, -1.031811327741564, -0.7761661673603487, -4.176430727677369, -2.5045067010466617},
    {1.021774434250522, -2.3857217716583725, 2.34001086269363, -2.138467312127862, 1.7029270174150541, 0.212267807167109, 1.613355865439011, 0.3381055723492788, -1.6722476021500048, -0.6815729055070217, -1.365442694383382, -1.1637010270068988, 0.06870723447245632, 0.08565775124045885, -0.5727133783712104, -0.5545923978130383, -0.576968590259705, 1.877441132191278, -2.2921672991618016, 0.5512934676601514, -0.9395882869717559, 0.3174416487116897, 2.0778291174192134, -0.23162796499831553, -0.2556169689103863, -0.9581184586777294, 1.078785720397511, 1.1160020992031963, 1.5831015966717565, 1.163790247898319, 0.5481547610754549, 0.30576604705274124},
    {1.6955909214097609, -2.187546249535027, 1.6160201040953825, 0.12030323426676261, 0.05527913650706518, 0.9981033375051324, -0.2979661512206435, -0.5408062457196641, -2.516649035917961, -0.37213680757128614, 0.023772888305123828, -2.0299813121837484, 0.2291282798860522, 0.7194701555511811, 1.738485201564357, -0.9787658477025365, -0.8981569906041634, 1.0325504173433446, -1.4592024580137786, 0.9274198875915388, -0.5618087993523039, 1.9841175180772943, 1.3511296033644558, 0.5293680763639099, -2.4722422739974386, 1.0698551096531352, 2.174321956946311, 1.580981044298659, 3.4419517300144937, 1.312785007453107, -0.7812432711568711, 0.5704812612911203},
    {2.2255074794925407, -3.2201128178219323, 2.4423931326809707, -0.20080840247169307, -1.1310718684235415, 1.1111744325100106, 0.5463574787420551, -0.5175330824980344, -3.3747838455413794, -0.6117735733762856, -0.14684492550447797, -1.202126609198185, -1.6043981835867955, -0.6270720207082656, 1.4070594292383072, -2.5694260124753683, -0.6945531881786485, 0.8394608692977068, -2.5532877634763427, 1.1665741394526783, -2.5428068681852607, 1.5639195137132313, 2.2647262357609472, 0.41989817714396105, -2.6375100934155364, 0.24948048655453126, 1.6653031511638248, 1.1042425249701746, 3.6819443751815544, 1.2082453907095818, -0.1977000634022386, 0.14745079850948087},
    {2.877687691647519, -1.725342470932603, 2.677120043903773, -1.4812494797770144, -0.8331129394728822, 2.3918282663441435, 0.32556001392689166, 1.16294136773125, -3.074406059850395, 0.3423610032493004, -0.05167575818736612, -2.095779074851243, -1.0499340555318393, 0.22936798355114044, 0.9518056593582948, -1.459633410242315, -0.5560428992469229, 1.2617472314953244, -2.130980482676023, 0.7915217938575474, -0.6856715982653615, 1.1803539915191463, 2.6832782358412732, 0.6117101531638004, -1.3723050754231785, 1.3891983214058343, 2.1874177225837337, 0.5903361623455222, 3.1932649573157823, 0.5916756779899617, 1.3138385445998162, 0.7671933215372844},
    {3.3522295726079903, -1.9954148014786817, 2.382035993179935, 0.36127117455351243, 0.18062227923555993, 2.862406620855323, -0.7414275932998025, 2.1809958285412017, -1.8625048260810853, 0.87439423698613, -0.928904319044414, -2.4304901920680835, -0.8212070207371984, 0.05400631343148861, 2.2007204894704047, -1.3257953828320992, -1.6809474539766236, 0.9563418191033064, -1.9024973482445213, 0.5687937665313927, -0.5456675524143011, 0.25473723144577337, 2.2691025552208286, 1.4800218732839219, -1.1685727638406544, 2.2926246957746246, 1.9641738361563121, 1.7620727483364171, 2.2420704574578765, 0.019191968477183706, 0.5993092621677024, 0.8858979285863845},
    {1.7600539228182488, -0.8449880456145048, 0.9259353836484773, -0.20882502574492587, -1.2171169444207548, 1.746333698696095, -0.2488499440802916, 1.9997088057203105, -2.426042393434807, 0.6305344017729744, -0.8706515475683438, -2.1144023573430983, -2.1588401712234906, -0.9069957552209897, 1.770927641712005, -2.220252161848387, -2.154545473608383, 2.048736835688078, -1.3860481689861985, 1.7985435438834099, -1.3056015214910628, 0.5172746568279315, 1.8602713055264457, 0.7015615063707272, -1.2283605558864148, 0.6036208824397398, 1.9952735890362592, 0.550238325793298, 3.3690352105775374, 0.5087464052532585, -0.6673845513138921, -0.7646734157961399},
    {2.5331901930520835, -1.3365950038952186, 0.03017927454149431, -2.6672526454981713, -0.593250776500741, 0.79294251439082, 1.1744810307336895, -0.6530804316726733, -2.126412963001412, -0.5815064881931248, -0.39603006401473567, -2.8359927225932315, -1.5332617646820157, -1.0422924421915405, -0.26950900098904945, -2.557742948849424, -2.652205789223039, 0.6014985610056396, -2.5344556842061454, 1.1385026545037928, -1.5053134048192893, 0.1762665348825327, 0.9991028318991633, 0.5819497745278154, -1.5367845580809179, 0.4925275577324122, 1.0116645658924655, 1.1180565077547933, 3.6714382011311852, 1.427143008610604, -0.0624542001262185, -0.5094592803819769},
    {3.2494417503871866, -2.7014806385901133, 0.2369793604978702, -1.4375114870104673, 1.5607600483275017, 0.748347956196305, 1.909783569102605, 1.502151761958279, -3.4986566327326427, 0.416447458025878, -1.2193511404848747, -2.990865736939113, -1.23230279407824, -1.1979334333569027, 1.7971704714971386, -0.4680876888439168, -1.1191252926663884, 1.6159735671149618, -2.58950549083811, 1.6124199396355745, -0.7710408396660278, -0.4126492143836107, 2.578908361330594, 1.5378643481684844, -1.99275128717146, 1.601060244639964, 0.052250523079948, 0.21469640513023855, 3.8138805494571777, 0.4207603919090414, 1.6184480115194908, 0.31112123135879427},
    {3.3198031022072154, -1.9423409192175374, 0.9021357757689045, -1.8110593934470893, 1.6575513748615147, 2.31081020289928, 1.7608582158374113, 1.6490985790304182, -3.061614166828383, -0.9039515554219372, -0.6746035047386996, -3.0327854496304303, -1.4284590966093578, -0.8462265530296841, 2.1291726013325154, -1.167012412731731, -1.096395605918687, 1.7464308719456652, -3.672131850764263, 1.458414621488055, -1.5368213178266497, 0.9611606919303085, 2.447523951956528, 1.4640603133995969, -1.8530813449504908, 1.9143979049259567, 2.168856245358661, -0.12629458674059826, 2.535970738896869, 0.8203910958285363, 0.8611707058331143, 0.21069620253546645},
    {2.506337538190182, -2.6850014460883145, 2.396933550860319, -1.2130023880619687, 1.6014724926392072, 2.089074035655595, 0.023831788908105, 1.301574915736471, -3.120817182522162, 0.4902219131797458, -0.18673961182080306, -3.651332383142775, -2.5265218441119623, -0.22772916256616468, 1.4272505595258342, -2.453131067897184, -0.8352197578957112, 1.857761089799889, -3.3868594193697072, -0.37492014125952305, -0.7284735686469337, -0.12913835028572948, 1.5128176731683136, 0.37714321022403413, -0.7387317031889764, -0.3235379579975595, 0.80291705763053, -1.0398052596792047, 1.6598530739096182, -0.6223944693860435, 1.4671129816735446, -0.04593908937246233},
    {1.5767129882676363, -1.7021833698430597, 2.6891791563177745, -1.931827403310388, 0.1585911811837883, 0.4532891540341136, 0.011380003094187742, 0.42333985003843116, -2.668325542345107, -0.7682609091632014, -0.4623377661547018, -2.520916544454139, -1.4763809059528856, -0.6247287430709315, 1.6428003055729583, -1.4065066754756457, -0.149140291231191, 2.47870409127002, -2.8123848041973, 0.04010014434673977, -0.6890776140859881, 1.2815125276283708, 2.827555900201013, -0.10911241863284905, 0.06824298864191373, 1.3980115928373897, 1.4485335941244926, -0.41145489729960055, 3.2665269951922324, 0.5170847614762597, 0.1290133580067591, 0.9915052676731271},
    {1.5788121315625072, -3.093017740870735, 2.4036708055552114, -2.939167249834589, 1.4094794520970488, 2.2409478442995003, -0.11227877414772931, 1.6622913654881695, -3.2977770332259695, 0.22190260628001954, -1.3740317069324337, -1.6190443344294507, -2.080569739891106, 0.33495180220067766, 0.8747160626505889, -2.1686807354032704, -1.348373649099372, 2.3899206965492983, -3.396352113316369, 0.016490293328019042, -1.6614566660089403, -0.08223556897563243, 3.615274876732326, 0.6330591543674522, -0.2911310729990326, 1.9617895325143777, 1.6688766440064484, 1.1942673655448486, 3.5468721369921217, 0.973372651844063, 1.1498490409589488, 0.45440467356514785},
    {2.0480759052634854, -2.1390453960781026, 1.5001844901195993, -2.621745713321595, -0.3269944868734228, 1.445758442357961, 0.4493677121448195, 1.1031849865889172, -3.3720473086020735, -1.6688173569183906, -0.06943732662898044, -2.1784472616708186, -1.1998332939823722, 0.9842268134410321, 0.3442991332669944, -1.9586830057596807, -1.502655969958144, 2.128645432481872, -3.4760930346273184, 1.2279051408684993, -1.9972995782191736, 1.0489761587929667, 3.559721174856181, 1.1251842933727352, -1.628975634131047, 0.8760420475754551, 0.7510104009545396, 0.9787961871986566, 3.5823668373618385, 0.15147510516148588, 1.1269558732766254, -0.538670758260735},
    {1.4213076760945855, -2.685008871465582, 0.5347677570046675, -1.98608082736249, 1.189874862318225, 2.5419433671971734, -0.07747787665922375, 1.5593812797186142, -2.720731178263637, -1.3644160633534108, -0.5921666890619128, -2.3939717951317694, -0.11615685344790351, -0.2970868273539964, 1.2470284505148808, -1.0049950588304626, -1.531129370853032, 2.958567084092058, -2.834566844139357, 1.8821962743181082, -2.9578812307062154, -0.5890245765746787, 3.4294076867551597, 2.3129124444588385, -0.9870349068510379, 0.725000641895383, 1.591252400507256, -0.615526332505786, 1.94732272860216, 0.5955643970472554, 1.1055308006945757, 0.43809114189793835},
    {3.143608107359261, -0.8208519973237723, 1.7462519612588667, -1.808465098822943, 0.5137639164371128, 2.46906144505398, 0.8830536568818782, 0.4782119847858417, -2.850845424572165, -1.29880117311597, -1.32939839386335, -1.5925144588693858, -0.5149299236932268, 0.22649449434604801, 2.1016454389098276, -1.8115447218976373, 0.1030353231345927, 2.399780987626213, -2.916942336303203, 0.4844307169498187, -2.175056999967696, -0.0918669047107689, 1.9588891082379227, 1.139936719828518, -1.011781430925794, 1.1184094702072847, 0.11791101438497328, 0.9005037984027822, 2.352565678364546, 0.45343754953013315, -0.5741715319482953, 1.0115948588813894},
    {3.2743277886777955, -1.7875618681397072, 0.6651067646297566, -2.0757606790591754, 0.6268175630934126, 2.731151965799726, 1.6988934262928936, 0.29598892494089024, -2.6511439538890413, -0.2740753092105476, -1.2617085543556805, -2.4158394895369124, -1.3640207597586935, -0.744082808464044, 1.1243812867442824, -3.0493583876691654, -0.8493582855782917, 2.3237394560617344, -2.3146447092577334, -0.956121627275187, -3.23579485455923, 1.427414390359409, 3.462810592026337, 0.9706827413573196, -2.2877178077140057, 0.7687537386976528, 1.2780730746303095, -0.0813150686233041, 3.5029017034973267, -0.5842550045968338, -0.2858181079103041, 0.08421663916785424},
    {1.762908749697123, -3.3085118580326776, 2.7831756004449217, -1.8012162866724006, 2.0055169527945256, 1.344170221750639, 0.32462547181700124, 1.9142954467438082, -2.324229457257898, 0.2233673458197963, 0.1956296964580696, -2.5908680361255976, 0.08439089267705052, 1.1258411075503056, 1.791228088174866, -1.1913542487213111, -1.318336036538415, 1.2755461292574517, -2.0150943923667572, -0.5915241469656412, -2.1956277294833892, 0.3917827391139148, 3.3135158118242436, 1.351044753598388, -3.1818145407882876, 0.8406737451501858, -0.34875013243770236, 0.08623141251926056, 1.5027009245302265, 1.4604237096380384, 0.7046886116506755, 1.2648123573447632},
    {1.6628793092129674, -1.605880023588751, 0.9429818971113855, -2.2721284847108985, 1.6270097168107218, 2.3820500119451213, 0.8413117436843478, 0.07021489940438355, -2.3848226172386, -0.6820523533974133, -1.633233549588034, -1.7889930777899907, -0.9048170907591483, 0.946112834705653, 0.45653306253406767, -1.9970609276990576, -2.089723807674128, 1.3411652164766388, -3.304728260055678, -0.6724604888374597, -3.49958328411661, 0.5473021713297117, 3.4785703704009783, 2.430085082267538, -2.888087500943208, 0.3943747465482472, 0.30176651381193476, 0.900025512949419, 2.662938238819449, 1.5381221285536195, -0.9451373084124556, -0.48242915014225307},
    {1.7223855060863498, -2.9409090914065055, 1.373691805857127, -1.7615331801632328, 1.7361273662927985, 1.7662988446227856, 1.5656395359072133, 0.7332319384455082, -2.3296353670659946, -1.2642491090012855, -0.8577050979948116, -1.1809619751785825, 0.029183252571922145, -0.1332843271867015, 0.5113547402142523, -2.7847800580749773, -2.549115486829624, 2.48378608476772, -2.9544049316078524, 0.5526855025254442, -1.3461522378978739, 1.2831409197005499, 3.328827576957996, 2.190799632244432, -0.7234724077315804, 1.1389642124963175, 0.8428193424069994, 0.16948036535148142, 1.7276897243194005, 1.618960050310973, -0.060893787920539136, -0.9904569088921925},
    {3.1695861168155948, -2.0224351075551126, 1.1899591675007313, -2.6211770885285697, 0.47730212416341466, 1.7838475872980615, -0.2363761180988571, 0.3737252211217158, -2.2708072700874586, -0.18470611169288756, -1.6396903879896947, -3.255814486674459, -1.3117863380169092, 0.422658194379482, 0.7035392882689345, -2.443801798469135, -2.0959234891886394, 0.5259968669305621, -1.9993721209728763, 0.2510553020096359, -1.667813800042525, 0.9723899978946012, 4.287448856903821, 2.311647069794887, -2.53116352107368, 1.8459188616653879, 2.2857561508937283, 0.26810499055365916, 3.7992266323247574, -0.39788964870660476, 0.07287909689267184, 0.5331874126709949},
    {3.031985929598019, -1.6198058845031973, 2.9714294902493514, -2.4950981406707458, 1.4553320616096046, 1.2041451012215816, 2.06228075272409, 0.07698539958915089, -1.7232467824471687, -0.5733210704237894, -0.6014345419327309, -2.3403066404532713, -0.7065599071416115, 0.6587108138558235, 0.4230376863017039, -2.286658764344481, -0.011231427272571497, 0.6318881193019591, -3.576175746347323, 0.7106317855532215, -2.421859069301518, 1.3794992133518407, 3.136296880091423, 2.098996353390697, -1.2216679696211135, 0.9598725034960282, 0.09142628957876363, 0.10092249078011693, 3.705484895764016, 1.621811726557425, -0.2215093533203201, 0.9479645829557494},
    {3.5592387935899996, -2.5330365292793, 3.5185368958993606, -1.5009932188584496, 0.3529079963782037, 3.030329240846307, 2.1172834932873195, 2.1498341324190284, -1.8931984752786433, 1.0084884254574031, -1.158744502465056, -2.2416288502380035, -1.0742505377152436, 0.5642479197928392, 2.6683429242619026, -2.3193689936888924, -0.18558517741649447, 1.738329551863837, -2.4286317231618133, 1.482049694376889, -2.625684528010731, -0.07355979418495322, 3.752381734573, 2.22014109383852, -1.9648983847795618, 1.8546560793904774, 0.3290001795027462, 0.032869601969428223, 4.29718894529816, 0.5177468788889454, 0.5019728046939566, 0.4834784153328172},
    {2.258809160249121, -1.5359384016095436, 2.972531487232187, -1.7273596978137573, 0.8952616052582845, 1.3088406843644813, 0.9012053581030176, 0.48766704388867815, -3.6894729516763127, 0.020295119754837103, -2.369717057910891, -1.0136833251173798, 0.40527499609075324, 0.7828047560108239, 2.228678796752746, -1.7514220977544317, -0.5578858441110316, 1.0737874063127943, -1.6978016312527469, 0.17905394043999362, -2.3499712458151065, 0.8002687427946508, 4.367543832845962, 1.7213529935871592, -0.9826535270682621, 0.44779273770030914, 1.5350069901056822, 0.276009334580346, 3.8046886550496146, 0.3032963386139092, 0.3236709976103184, -0.174061050392204},
    {3.7116429473036634, -3.536073738231813, 1.8526262574489154, -2.786049274767234, 0.8289864300423414, 2.52419757224325, 0.30529856548401935, 2.035854472285212, -2.0285634384988134, 0.9774181966100779, -1.9597948101551397, -2.36872093753631, -0.9661092411350408, 0.13635503133078686, 1.5989368753582087, -2.902195390623443, -0.9057347348078122, 2.6776643634356114, -3.4591399158332443, 0.9156129403310443, -3.6038256374736903, 1.39930593684282, 3.7164020108949347, 0.4110034340801192, -2.8652206333378487, 0.4641176173590943, 0.834707790129736, 1.2454781681246023, 3.6696872686864417, -0.5486805026691534, 0.5316337298277486, -0.5424168785133426},
    {2.5206446404573852, -2.927376328631258, 2.2943433057732263, -2.128306769218645, 0.7761123306217188, 2.838779545816062, 0.4513783476085883, 0.13396755687052347, -3.2721060455889366, -0.10103863901791063, -0.41276432481684155, -3.4504041009388375, -1.2392515059903175, 1.1091577993729418, 2.0242277548279453, -2.6967486017757683, -1.2923320791250352, 2.0815670480888113, -3.016285277873303, 0.2588819172914298, -3.264175613547768, 1.3799416984546768, 3.5026263187234337, 1.288286426016661, -3.014847418589791, 1.7783066944216213, 1.2311876227933374, -0.20062509846611287, 2.5080662871785573, -0.7145494420213093, 0.05090013973675397, 0.8385853730177372},
    {3.1717418782356157, -2.079860053384426, 2.9747294343420374, -2.656506541521264, 0.1810933844918571, 1.293396930139785, 1.509108380128181, 1.3081725536877442, -2.6962207056001746, -0.4907117081939138, -0.9261887101484995, -3.51958866232577, -0.9282884445798812, 0.7963890989666649, -0.03041996991074602, -1.487367822042514, -1.2581527737592013, 1.0992411216015763, -2.994880644157986, -0.6054634807256194, -2.511938325869998, 0.04065587059884058, 2.9156816706132087, 1.3745224955438813, -3.1265292080623635, 1.0265659001872278, 1.067804556007573, -0.19945891323561835, 2.6494474730735256, 0.18664060233712462, 0.44291259213042994, -0.7663298651524737},
    {2.4367963678048796, -3.9307168207228536, 1.7036277253299943, -1.2478953294877106, -0.009965468699416485, 2.432921570114007, 0.4801905979108564, 1.7573171347027494, -3.6438133636353336, -0.8585302734729304, -1.4678362913271474, -2.2141227254327154, -2.318200130240431, 0.4185575721229686, 0.24050719939653442, -2.0816958395557705, -1.466980126406169, 2.9405963431517197, -2.7688701815400085, -0.9612020977892102, -3.289476115911757, -0.10182402636933438, 3.855327274129076, 1.8313663809224296, -1.0624391229582917, 1.0125270246634708, 2.923832586940099, 0.5964112362356851, 3.8097362677021556, 1.2271822376266581, -0.13598287066375755, -0.04018111311009497},
    {3.353670433438368, -3.8601797964184885, 2.4549237085182476, -2.462389373306102, -0.32417421107591843, 1.8444022134813305, 0.3947284048829271, 1.7861799447277151, -3.416769323658018, 0.3949467135985291, -1.9436862919006006, -2.877980452412231, -2.667420113174514, 0.7558865395181409, 0.7097351902576848, -3.1373509577263503, -0.8871992065516937, 0.9259789387016429, -2.062963782104719, -0.6051984699009564, -3.2993769942694615, 0.7184848491646884, 2.354093314754124, 2.1534042814051544, -2.2573523936057627, 0.026353019039158168, 1.8544971653994937, 0.30667136334482115, 1.7529769337453345, 1.121045588399235, 0.7704724382443271, 0.8386450162962106},
    {1.5628506687493156, -2.6980768706273732, 2.189707186082864, -2.7892334246631876, 1.5983852790006463, 2.016037858588366, 1.262864372445911, 2.1182656432731095, -2.645839020943511, 0.13978918304213137, -2.22677136381743, -3.3135969743280262, -2.6252024840828656, -0.1410617277942918, 1.2811280797466864, -2.07154033962321, -1.3354215933166012, 2.1278524453257006, -3.3105073110450145, 1.345662326859795, -2.0387807683115664, -0.5391756181092799, 3.0035264220113285, 0.7548187101995045, -2.0820629505010833, 1.319502166414935, 1.3386529907453417, 0.2155360474424362, 3.2031747661037104, 1.2937666650269994, -0.01739790826570334, 0.30352146866797836},
    {2.978862323927976, -3.385107136793842, 1.9218662551744297, -1.9059252947923897, 1.9119520908016658, 3.2252880117923426, 1.5300121301307987, 1.8163799315886135, -3.2487015228572726, -0.34767462229794943, -1.4125943172422888, -3.5827991691063437, -1.5709949499694762, 0.33956161186381495, 2.037161477143484, -2.548518500298577, -0.8751642667327999, 2.6340848752978987, -3.9767721151118325, 0.08659306027125231, -3.5172660688636004, 0.49937777415341866, 3.7005408235571586, 0.8069743391458837, -1.3050593464626077, 0.9405876058148358, 1.3128339888892968, -0.044963058136180054, 3.799960949385061, -0.4924091586602722, 1.4304673484280357, -0.49995538597695616},
    {-0.9033333719696611, 0.9182971830966611, -2.8039785345498363, 0.7026588195187444, -2.856710426744261, -3.146322973189832, 0.7793205105389786, -1.5023066751177139, -1.053752121079386, -0.7763184764383857, -2.317803066511826, -0.9419954873188102, 1.4278557860811827, -2.5325201972495246, -3.991353670292672, 1.6685404174391887, -1.8443576650279718, -0.41252473359292374, -1.0712878199482145, -3.5999121070039677, -0.8515059574220526, -3.1103272045252908, -0.3440950574332237, 2.1177099625775235, 0.06868466566286045, -2.793521378032272, 0.28733861985888265, -1.4902416176103188, -0.7360820136666255, 1.387330732036294, -3.022956104268033, -3.7567550247149843},
    {-0.8698778402013385, -0.9639019591604107, -0.711317043340449, 0.9362502452084751, 0.5206546196591373, 0.3027931528255244, 1.1197700657242238, 0.9046196714052172, 0.9409508962181408, 0.5809695212543955, 0.8780828907149284, 0.41720528466493845, -0.37049135335984384, -1.3524315884202305, 0.8837917075138968, -1.3395518672410316, -0.7086723203806946, -0.5703668896312055, -2.0901208855401303, 0.39660937432377036, 0.27497209307025494, -1.0449703897419098, -0.4805434976148455, 0.7004802462829947, -0.29321469277069595, 0.7225678050782476, -0.0329318456418791, -0.514663128898305, 1.1668507463776474, -0.9970139586006411, 0.21293094323779732, -0.2623904646716532},
    {-1.4917132013264367, -1.4272021115311904, -2.6694457176617594, -0.7203615243249176, -3.374618395454676, -3.440907161452771, -0.7610942933537069, -2.9178762973192938, -0.3640893198552679, -1.5596957383413117, -3.1469346844188837, -2.906792114544573, -2.44840311939673, -3.474781160433243, -1.9984822194417966, -2.4650504137070115, -2.66262809390265, -3.0347443310730142, -1.1690313474326959, -2.7333927041027257, -0.6795806333220012, -3.5601446723652335, -1.118868531239794, 0.0626026115138133, 0.012019341681810791, -3.9445826801210986, -1.3459177482854587, -3.5149515764443953, -2.4719412927552558, -1.2192147629341217, -4.356044083693813, -2.028351736616401},
    {-1.4527112190595795, -1.2112046958789582, -1.4468170422260462, -1.759230787040409, -3.9378362223818533, -1.7618285565211846, -1.6591712779707235, -3.402860236276837, -1.934859413502973, -2.324650660416073, -1.0046185315083813, -1.6956137178206088, -0.557163751293988, -2.406723152896695, -3.612769135878213, -2.587002243070262, -3.1159564217581157, -2.9007927933754147, -2.2857263635389407, -2.823187138953042, -1.8436934884862912, -3.020548528083814, -0.33795249500906105, 0.18938120137486983, -0.9861591549477544, -3.1828427761290126, -1.3796581791190128, -3.04997730449581, -2.1886376224855963, -0.9872958326977379, -3.4958755616183854, -2.3606033155674755},
    {-2.2293353874215303, -2.673147356424923, -2.390822034813494, -1.3194968922747965, -2.2359492852993363, -2.4442940277150154, -2.281362887855484, -1.1560672192511852, -0.46851833768061163, -1.9236275426076161, -0.1619840705226838, -1.6390204494342928, -1.156629506119073, -1.2223894633788797, -0.9831406206641498, -2.7506950124340523, -1.0883620930086826, -2.6221143476894087, -1.558887685718118, -1.0508346086592821, -2.7288392594704605, -2.995990051221561, 1.5608141717815092, -1.312876199056547, -2.09121649355231, -0.3559028175068905, -3.00190198497611, -0.8967980185254635, -2.140326247608328, -1.1775170823531584, -0.07131353808566862, -0.12117657230064682},
    {-0.5362255970202058, -1.414514553302469, -2.713181825711528, -0.8238804770479216, -1.3582029033363117, -2.0338947002570156, -1.6710021813033893, -1.3639938213463885, -0.4205324278206463, -1.706587408241663, -0.08452758199027062, -1.0004357075394332, -2.5739714110808767, -1.2325201807375457, -1.861594904364108, -1.5075641844370002, -3.2985338044762913, -3.556992800776508, -2.9305921387392355, -0.10557060803098371, -1.0646447508392147, -2.8900685356372104, 0.9151755706134004, -0.23766473936027432, -1.3517084827214703, -2.389704871395291, -2.784300565832659, -2.1473392099711592, -2.7805362953065433, -2.6576151189949364, -2.0434717477499937, -1.5275093605724435},
    {-1.1376031561729627, -2.977970713929031, -1.152733944470959, -1.763980379238431, -2.132527582746521, -3.1875899131124523, -1.6443979431936853, -2.271834854500689, -0.9169334457401389, -2.1944543752685495, -1.2130823364390249, -0.7375695924000859, -3.0626413482507475, -2.132495563446197, -2.018674186937846, -2.6570265098263417, -1.6003897395555569, -1.9464591133189921, -2.456319857487375, -1.2745773817980373, -1.0119197377959965, -1.746843524306553, 0.23680203243854966, -1.5601850064002303, -1.0226299920207842, -2.4760995698823853, -1.9948060832798504, -1.8191199330457268, -1.2508558216602825, -1.2966764283101688, -0.9403546093923277, -1.1637194143283098},
    {-2.2157821001884725, -1.6342246682007762, -1.3430929541526102, -0.9521771974119048, -0.8117068702164867, -1.9802229257955397, -0.7748524015278854, -1.3419779191308714, -0.14479504687057637, -2.8919359355953658, -0.40068885797528153, -1.1098798079948569, -2.378602204327815, -1.2304605289589083, 0.3784592402492574, -2.6407261790103944, -1.949106701674952, -0.6813923429933416, -1.4062332529170205, 0.9680641230827709, -0.5246324931816864, -2.4711930089797045, -1.0022504289089915, -2.6305545978217224, 0.5326104873007482, -0.20660440546779926, -1.3047330703945008, -1.5393115065298526, -0.26430513874879474, -1.1078595061875927, -0.9264423612172619, -0.8627237238361553},
    {-2.17737544645531, -2.174454699165411, -0.9816528007783981, 0.04208276910984815, -1.8822926417681691, -1.8030633629501385, -1.6037276879270919, -2.129995398489244, -1.1397666944692977, -2.4103616371758885, -0.05669544277517886, -1.1931351949469793, -1.9307205864199541, -2.209435554123868, 0.03529704345943574, -1.7336561188230717, -3.075338796667861, -2.021990738295552, -2.2005923293754077, 1.1312346353120908, -0.7708135576860974, -2.4520044196299358, -0.8223350385077381, -1.8247298664512699, -0.9908057831948953, -1.8623829968102588, -1.7452833450132568, -1.4630124602639358, 0.20450902792941597, -2.413054928175994, -1.6274498160886661, 0.753107748213792},
    {-3.1149762378137584, -3.0057403680817174, -1.9248256458213298, -2.248051300647153, -3.3120283962558688, -2.322809350975958, -1.2090446243751942, -1.2027965197176453, -1.3688878696144797, -3.269700253125462, -1.0730318516750008, -1.950682415271713, -1.946499658604045, -2.5694083465039377, -2.758210644751732, -1.0436129270659975, -2.0640552989348473, -2.098947784887404, -1.1141128653579377, -0.12339875702886437, -1.389559239224754, -3.2375878163557994, -0.04535388195687296, -2.2426633098279063, -2.6121377241039374, -1.873599338416862, -2.296425726781044, -1.5837801080668232, -1.810412755394111, -1.235486851841631, -2.2652971748826367, -1.4006022897256745},
    {-2.9712132723147198, -2.761434423606273, -2.9082943178051726, -1.1921979471317756, -2.910651191474537, -2.9121128840597112, 0.018936974425789566, -1.5216475174719652, -1.1049992122975978, -1.8831888057146753, -2.0407716931551505, -0.5108725741871567, -1.5102725775735244, -1.2268961484170986, -1.9932696905542984, -0.8093955570338274, -1.0425188687086024, -2.158847172972394, -2.554166334005135, -1.8106462152770895, -2.2953393282497285, -2.3896951547162564, 0.9245349950375948, -1.7061417874054672, -1.520471276338605, -0.7025645582163381, -0.6853291790060662, -2.8670929764382556, -1.6859580706535262, -1.2802333381636952, -1.1493393079701708, -1.0533457418922778},
    {-0.7022941153122101, -2.16153372483825, -3.4382727169888057, -2.1044259132020526, -1.6464236174754858, -2.9164950856003853, 0.029874405954688113, -1.9342405755846734, -0.5163938025060203, -1.791955812695343, -2.05441266402799, -1.3443856077403966, -2.031213277189865, -2.0570882395282553, -1.4795236290075093, -0.9769626322804779, -2.6235091050220194, -2.2553549655192677, -2.7494829891198935, -1.0380064352360934, -0.7604832613254937, -3.5246764392270507, 0.5108649151802062, -1.3172888868234074, -1.3502627983470892, -1.2356870341562214, -1.632331637072977, -2.3540353883542107, -1.0538485034129297, -2.667011548544117, -2.9919738402175704, -2.1020140168245742},
    {-0.416721672887877, -1.3841108402970348, -2.876688544275918, -2.5340007239496796, -2.3074965623632164, -2.489871398380112, -0.9047316173073499, -3.349329221585085, 0.5223607846651848, -2.3437743005874254, -0.8356094979265294, -0.7764970311916088, -0.8184259359418845, -2.7903737050705844, -2.012149503274585, -1.8644305740954854, -0.9294420666216914, -2.3582265959735396, -1.1815441287865531, -0.580568015953539, -1.5478202580828184, -2.543559065686161, 0.7800858742938531, -1.4467739893729035, -1.4531649653922787, -3.0193435485572593, -2.442327926269765, -2.6765312212062313, -1.070948304744331, -2.2782806479453654, -1.7504898970803957, -0.9789911581186926},
    {-2.2704809937994943, -2.0285309933009823, -1.6997426052704931, -2.05116120518704, -3.647462507568362, -2.4256534228531694, 0.043024815018849374, -3.853041558628836, 0.2319073022791684, -1.9862025111667532, -0.37906796368543566, -1.4655794387448267, -1.380375638294026, -2.3795599626108004, -3.1332736873898663, -2.3058260674690674, -1.8952866924500291, -2.774280498733605, -3.111034799132248, -2.211806085771849, -2.381854557063426, -2.535236033511099, -0.051933151923412954, -0.9547935165335926, -1.5796861631166457, -3.3307661122796888, -1.8815638991051975, -2.8939712543194536, -1.0596514860798987, -1.2231084390349147, -1.426435872309233, -1.09951319551911},
    {-1.1180528413477482, -2.308620883221723, -1.6068566352990352, -1.0977766020076387, -2.787000465719245, -2.060096195436077, -0.4010089864091166, -3.2650820172011743, -0.7418979385342372, -2.788967048449279, -2.3804869814090837, -0.8706772173409715, -1.995561603546066, -4.086421627347341, -2.4936909966530227, -2.834066459961462, -2.8787259855553717, -1.8370745843400595, -1.2492480143551972, -1.5837326249009565, -1.7461486399864414, -3.426308446757258, 0.2458678782149396, -2.071183411741801, -0.22487925653038088, -2.361088995627459, -2.218922073926095, -3.4001530535052438, -2.615735281599466, -1.3076598866902778, -3.3916896245432997, -1.8895459204111575},
    {-0.5333577517213836, -2.7685991265975405, -1.6583598266662405, -0.4096666464939152, -2.8664029841030962, -3.407654588104922, -1.486635292958143, -1.959371708027169, -0.11988789176884339, -3.58551448290983, -2.108147451373931, -0.975638496148294, -1.373795291925651, -3.3159105051278916, -2.1398823416674695, -2.742590656645662, -3.396671650574638, -2.6538465748003364, -1.1227317747392165, -1.6320696106288568, -1.1329657599172362, -3.61812187885677, 0.6995324413567225, -1.8207517329109995, -0.8022816525795722, -3.8258478738736095, -0.9521888101217032, -2.3716238328176873, -1.020159683914794, -0.38160912972511857, -3.991643025783388, -3.1394936712560706},
    {0.048143271593233394, -1.055175419537439, -3.128878498818124, -1.6325737576413417, -2.709220970616316, -3.197554403659469, -0.5685183104041351, -1.9866335823741506, -0.8653821502469107, -1.9868434727653466, -2.628609094277259, -0.327736873939254, 0.26266280149323273, -3.052819202297185, -2.7314330890239042, -1.5316247406393584, -2.6179120513019036, -1.2520133011960084, -2.4818070686667744, -1.041598451858161, -2.210411806129652, -1.6943941411263188, -0.9453526270339503, 0.33683134654962543, 0.5561639483841336, -3.3613835270095462, -0.4648154979992867, -2.05304942310647, -1.5974229808004383, -1.3174957465732726, -2.111727500083347, -2.026339288951321},
    {-2.1602490566260593, -2.1901520311362903, -3.3831091630977577, -2.0991080762629024, -2.165132051653094, -2.5396774268151807, -0.4773857269270838, -3.2996381954596963, -1.9324621263293358, -4.046908431123008, -1.4586987792045396, -1.899257949263647, -2.068496540177461, -1.4564141788817624, -1.8425338503451987, -2.79354767184177, -3.165620815367821, -1.1274764656891092, -2.8644384075531395, -2.621059984355097, -2.1922746597833944, -2.1567775095704813, 1.2444220577065288, -0.6003229033361999, -0.12405496630902946, -2.198701125037948, -1.7954063229374482, -3.091409260178313, -1.6159876117834535, -0.022497983633424805, -4.4103096883415605, -0.8866538184236149},
    {-0.9526856346890993, -2.015926343476095, -1.7967501185436, -0.4170979222144476, -3.0202347374523018, -2.156312518777365, 0.38315787195028267, -3.010686035200319, -1.0341023496801012, -1.6098447142287682, -1.8607417863310196, -2.177604226735712, -0.30444611878653216, -1.0953309539787441, -1.729876589011216, -1.0016476940017538, -1.906595012777972, -1.3373858914365868, -1.3472481431850012, -2.997194328879251, -2.6440686211183193, -1.9525959961412196, 1.2521125663443378, -0.45365978173788885, 0.4417217479452289, -2.3321566436358157, -1.5201723395134372, -2.5044178181914813, -0.48824004894768447, -1.5198136578104027, -2.8103406236599118, -1.022912465926422},
    {-2.909798323835268, -3.20943520058201, -2.119559555725663, -2.739960322986052, -2.210624464683753, -3.933416413209571, -1.5071160823616565, -3.4084520630831627, -1.4840511861490266, -3.4099215056026893, -1.2891912908475924, -1.9405530020972728, -1.7674128404343592, -2.6160005698541546, -2.831153141969004, -2.8196918435102565, -2.0654973387983695, -2.9049647472672095, -3.37729889044463, -1.7972477201916668, -2.1259203652007237, -3.3246435067625804, -0.4136090275189268, -2.2834061502996743, -0.5541260989405778, -2.918957058924156, -2.6515461884896436, -3.0627672903583365, -2.1732832997613727, -1.2083271849106754, -2.2631819985962953, -1.8253007284628617},
    {-2.0446595619668746, -2.5808184146449973, -3.32118746833401, -1.4973169227038425, -2.9389932220020385, -1.8900565243218799, -0.1850710043559982, -3.9622281485554174, -0.934501741483445, -3.2232207598036715, -2.7496947030816323, -2.0326319729483844, -1.4362610653203338, -3.461554587652652, -2.492318219916914, -1.6917464514125462, -3.3616441179929155, -1.8900886783144693, -1.5534256628689247, -3.0342952229653197, -2.934804605622808, -3.1405094609502813, -0.3687466034960842, -1.4378810662698882, 0.08889423074291534, -2.3854045986674777, -1.351456741924503, -3.7868489573367126, -1.2698618854926984, -0.16025043359462302, -3.2144111157410467, -2.2240007379287414},
    {-0.9306488337390769, -3.0045553298552075, -3.9241656974227483, 0.09973988475546416, -5.137666063029293, -3.18882906651265, -0.3199566367326395, -3.711317298055447, -1.1627595936539328, -3.6915953872708505, -3.4594444929214845, -1.511476978934313, -1.5574801332455137, -2.467705398828229, -3.197474713112686, -1.8163439454676575, -4.327856736315954, -2.191558192810794, -3.8501180732071676, -3.053190839990299, -2.235820220033516, -5.338184205323269, 1.006289258472072, 0.7818157618420858, 0.573942883041429, -4.783650471285695, -0.48195498541127074, -5.189616567994087, -1.782905840960101, -0.6621249523778662, -5.504531505082261, -4.194295800703921},
    {0.31646748969602445, -0.7922080851852205, -2.6910596365094017, 0.2110669756778825, -4.400092529193061, -2.8326423860425423, 1.9708041991251701, -4.917395558979224, -0.20663638699982703, -4.159002951888184, -4.402454820094872, 0.17276340250597166, -0.624489142118742, -2.5505006460401978, -4.984746837669012, -0.06955483343876061, -3.035722386859085, -0.718576389907997, -1.571043940004722, -3.0404774392111737, -2.642745824125906, -3.4266117757971473, -0.053682991468028636, 2.388767589402177, 1.2191668029649194, -4.38821577062986, 0.3136358537803992, -4.818978551165607, -0.42315834078412834, 0.17627823912165871, -6.218331324579166, -3.878844834596861},
    {-2.0971637325199013, -1.0986638080303217, -3.6705814599182194, 0.4122161762249227, -3.5037826135210013, -2.365463886633149, -0.3780032359656575, -5.533087080874217, -1.8389632347140317, -4.398866360979262, -4.346396252101825, -0.6668152658864992, -0.15304612544117455, -3.2819778393033863, -3.428290574553714, -2.2430601377129333, -3.0121600507221986, -1.3261495410486572, -3.0624183979720643, -2.3687589920203536, -1.2075118113596268, -5.360361822787662, 0.05342164882217173, 1.4685707734615532, 1.1016530234913418, -4.120733568141775, -0.8198819513512964, -4.63204260610415, -0.49243077141819724, 0.8902820312380997, -6.044255014033202, -4.826758006200085},
    {-3.00303334458896, -1.9336580481092411, -2.7899689853285348, -1.5492201404619745, -4.8072929935985815, -4.194791126133403, -0.4399085129047179, -5.553998745827364, -1.3197553754338, -4.17226146377555, -2.59237998433955, -3.40346512433881, -1.7108978472162562, -4.708865172961406, -4.48368596332144, -1.782027028135762, -3.42785319714398, -3.155689367789131, -2.9476461978623965, -1.996771025138418, -2.1851073216670973, -4.283640665806255, 0.13862246338029716, -1.9607143648120182, -1.5562626663688752, -4.1634955557960485, -2.9258019564640727, -4.260635080528745, -1.6864194088107491, -1.0214941961882082, -3.50600219263527, -3.722687398112431},
    {-1.0645015783629386, -2.7034046661564597, -2.187796042942986, -0.19958877350731308, -4.282863242102884, -2.7014203993531454, 1.5209031900059293, -4.749219202163697, -0.9618362891846807, -3.7662616903109094, -3.157530482463958, -2.060601052668884, 0.5106317961748641, -1.913152503793914, -5.211406910994725, -1.3121121587913698, -3.8414668742014846, -0.7761393247924454, -1.7629199353396932, -3.7123626793114144, -1.2677694363000755, -4.7464423350913165, 0.18819320174367624, 1.203840516001559, -0.5053092676700877, -5.037435630492111, -1.0036198668901521, -4.770294211443019, -1.946036459931959, 1.2402964628426794, -4.042242980238495, -3.95829002815243},
    {-0.3448931770557225, -2.2211706370766495, -3.7490526068076813, 0.7453765659577366, -3.4120580345493186, -4.393019896283153, 1.848733358734124, -5.249149642114523, -0.12091121592585713, -4.705222858815687, -3.2105932997584157, -0.32286831272652355, 0.05769393053987679, -3.8242037659480306, -4.4236581250295455, -0.9353520284670626, -2.4646803179570784, -2.2695453758086326, -2.8061404198057343, -3.475995681686088, -2.079023161514264, -5.221610395872601, 0.8782444590382331, 0.98471594849083, 1.047242615092491, -4.987602100344488, -0.9201864108011862, -4.258632591182697, -0.6078208762723233, 0.6913689078937562, -4.1062849950281395, -3.0055942517604883},
    {-2.159801615507605, -1.9469489010024774, -4.05740406148876, 0.2691372858625386, -4.349300107300291, -4.525478121053511, 1.1832890130986184, -5.367667812811154, -0.4077126075173644, -4.409363347465949, -4.877964785847064, -2.798705657921252, -0.7413683706014113, -2.584671529501197, -4.150818456715214, -0.7244575004675765, -3.542696903573346, -3.1611442742195734, -2.104647362113691, -2.6310930796426466, -2.535327561444095, -5.125884120555662, -0.3030432700674454, 0.5597446000521508, -0.47214980536075085, -4.780367792039812, -1.819317971725064, -5.728026523003413, -2.266423235085559, 0.16941960508626114, -5.121201172831896, -4.272642099541788},
    {-0.12252483295619164, -1.3987095559173481, -3.2410171852500933, -0.9483740465825279, -5.012159634284084, -3.8310007512625632, 0.12928827977553176, -4.657082296844177, -1.0849755973503727, -5.197557829425258, -2.822706676941837, -1.6408587044189462, 0.45657799708502045, -2.1672010328550693, -3.8613740295869707, -0.608824048363357, -4.124195584814582, -1.7690632327975713, -1.8110439434970689, -3.1260580674291876, -2.78282547264076, -5.670920283438029, -0.08468728841657808, -0.2880200150916576, 1.474955493687281, -5.929306021142971, -1.8019385393814011, -4.530836362123335, -0.9488655260859382, -0.14263376744581097, -5.324312677040844, -3.48976212172423},
    {-0.6782212270680456, -2.23986795872486, -3.498009448881755, -0.26068749707385797, -3.9611895881829384, -2.630931289932328, 2.3737912316969134, -6.427787271348796, -1.2857298958790038, -3.655098134215246, -4.344337619879146, -1.3848867386000567, 0.8603007469517592, -3.3806779952791297, -5.868545143163803, -0.18962654318680158, -3.7841804399289356, -1.5027806533519747, -2.390850127945256, -2.9219411666030024, -1.4490225881862353, -5.221691311089077, -1.4368052574313253, 0.2565311413645993, 0.31774558987201235, -6.088324000186364, -1.1809671710248952, -4.358734885910798, -1.8148364474326215, -0.100487674014794, -6.214845571268052, -4.968500952112828}
};

static const float b1[32] = {6.697698658388048, 7.050566779372405, 6.770578086142126, 7.215048102203002, 6.849577096025011, 6.7908678665381474, 6.761049581169846, 6.910096782566218, 6.471975163352639, 6.827253653446391, 6.6958501691474295, 6.968414092329839, 7.073293166725624, 6.7944474423878365, 6.469506899719517, 6.9085433970827275, 6.896012334923735, 7.122426276005164, 6.755378305407872, 6.75952939686924, 6.510648946178229, 6.924587263304712, 6.919470509687603, 6.724981510432066, 7.120600114582258, 6.920020401113561, 6.761520975100518, 6.343080344115434, 6.961829015266653, 7.085783205137301, 6.847032660758327, 6.423294308532104};

static const float w2[32][16] = {
    {4.735325640722736, 2.265468869630416, 4.093351040261597, 3.8724359233931827, 0.7204113083624264, 4.635383802621594, 5.41474941957992, 3.445193495158169, 5.789807575811681, 6.178740124775632, -1.1074470071471816, 6.503059375064474, 6.314188291070496, 5.470155782861072, 6.645697372033798, 5.281198387873626},
    {4.587472479589544, 2.44336447302551, 4.287439069467397, 3.878572232055151, -0.16617568702015661, 3.9808655824234096, 6.055724424229862, 4.221942188613118, 6.044508584927231, 5.981148504004193, -0.19889351617761306, 4.816705741562739, 5.148986842026512, 5.895931312107533, 6.280215311491037, 6.549906757290459},
    {4.811978363316496, 2.9982856539696914, 5.619780991485419, 5.319263707615495, 0.09432733296695034, 5.641619979935274, 5.347786467564223, 4.9749674198121685, 5.579625103048908, 5.893408434969895, -0.8808422019072356, 5.423653682132828, 4.978419337111332, 6.549403655901486, 5.897600429706858, 5.989043139761364},
    {4.440279486797287, 2.4785711035993936, 4.808217924052146, 4.937085987118403, -0.7709090476094503, 4.559886876674847, 6.1475770594096595, 3.3354038126262853, 4.887128047816788, 4.961416004245851, -0.5252499901022728, 5.0325977673323745, 6.300390760476697, 6.876747875409252, 5.038425087411751, 5.43472408272638},
    {4.621753369533759, 2.207484771723701, 3.982468258114307, 5.121157901421344, 0.28379606226173326, 4.6623118545136535, 6.168699100755505, 4.040768546979715, 6.289428893525922, 5.374437137336071, -1.0709481422696914, 5.4056597836281215, 6.171158840086838, 6.383660092366405, 6.689318078646825, 5.872420673126554},
    {4.762806391948279, 2.7671955087432876, 4.142062885366147, 5.146270985104712, 0.23859836364578013, 5.5737005959786, 6.232702664117109, 3.527469320217147, 5.084454888454256, 5.177765857159276, 0.8762202642190065, 6.12345173978735, 5.706094787771808, 5.937507257169136, 6.299152257818026, 6.015451802775298},
    {5.145057975074621, 2.5880871087861888, 3.842516968573643, 5.313465174135062, -0.9412351000672756, 4.907428784229225, 5.431347164420757, 4.789375441720139, 6.134760066923513, 6.198709137063188, -0.4339691094142781, 6.0768565692685454, 5.475555067914122, 6.046894244350125, 6.128990229577097, 5.3597373602487695},
    {5.49714022181915, 1.8110311151328429, 5.007929968878014, 3.7488603131666434, -0.646379287222946, 5.821607962766013, 6.608813216356485, 4.856250317401863, 4.8873335219483005, 6.3601662805226065, 0.7203599965000056, 6.029752924287684, 6.339802750776002, 6.283184836914227, 6.171823085929039, 6.369755551799737},
    {5.034701544000505, 2.9525044259103352, 4.2246638028616195, 3.785780438308343, -0.8221745667418441, 4.535574887891607, 4.421317933322219, 4.040018194054344, 4.54523204470198, 4.892524638729943, -0.34131294946395546, 5.431574764961104, 6.171759075012851, 5.3150990852448565, 4.830880537771589, 5.104637753316646},
    {4.025745247605299, 3.013888185662347, 4.3610183879443625, 4.186602164723921, 0.13860868348492242, 5.4690224582673075, 6.0509626907597625, 4.716912242305171, 6.118423668300707, 5.190800785924722, 0.3964528648890816, 5.471459846539242, 6.554297385023885, 6.8325348028129556, 6.194397119326212, 6.69783491021427},
    {4.350312636724955, 1.7619197277029595, 3.6521871737006517, 3.651382075228073, -0.09250248167146717, 4.5449984252038735, 4.967284598094492, 3.420608195897113, 5.658351946338148, 6.007887564110051, 0.6314391709640048, 4.959186600635147, 4.968208518712368, 5.385306201027676, 6.195914668404254, 6.650508923581997},
    {4.365710995420204, 2.2434362490398634, 4.336020304286646, 4.745960124792159, -0.11849397248672622, 4.090034356752168, 6.713906311926946, 3.763327646767895, 5.850396217710041, 6.280041779410773, 0.44125113292657697, 6.470536185352852, 5.429808292335437, 5.256819441142905, 6.199458456619189, 6.4719106152572214},
    {4.751935649738401, 2.4671920583177727, 3.9810797441794405, 3.8247163795874064, 0.19014212357391921, 5.443168845167528, 6.4709205424520535, 4.209779731629298, 5.793439358743462, 4.963376151202831, -0.22368404990126164, 6.542810361149502, 5.5578681480694785, 5.891832659558661, 5.142449235467512, 5.940207993569229},
    {3.4693894293181806, 1.2891868048841146, 4.825306604498882, 3.527498089109897, -0.22196115170594471, 5.4279912484934725, 5.919480890125491, 4.659877716733164, 6.093107297251767, 5.985006278068499, -0.031205025295906942, 5.9798535375005235, 5.844605345802665, 6.011690770622229, 6.137637703079173, 5.505139757675721},
    {5.180066040921295, 1.6686428778403901, 3.980651469016594, 4.170350771225947, 0.3598958207822981, 5.36507966961565, 6.017103873762657, 4.539470794149522, 5.773937588595429, 5.878273359194416, -0.09615757835006915, 6.870521694335207, 5.237718692237714, 5.523793289584225, 5.8128464764044985, 5.09562016059216},
    {3.4957275184583723, 2.5798509782035044, 3.752263133374384, 5.205351749879826, -0.7455095994825606, 5.5101278716992415, 5.68971797725178, 3.5404114756986327, 5.888809069721239, 6.109425862355137, 0.5799204314872025, 6.4836710006966785, 4.9364385291868125, 6.392684939047409, 6.37497642800024, 5.932685308803783},
    {3.8132819781815517, 2.3183147097815135, 4.016880002219672, 4.801783682104739, 0.6518171333867202, 5.688828901566364, 6.758929905686108, 4.110517789828461, 4.739644389395755, 5.029032699699019, 0.19881446351413776, 5.935598364840389, 5.051753514894177, 6.0070886701835375, 5.6066224516615355, 4.857291918079214},
    {4.7328331257250005, 2.939837124416462, 4.962146295254541, 4.149585404116564, -0.17739837637997916, 3.94813641236382, 5.18775552198217, 3.8244191284426954, 4.949303940300227, 5.558866817011034, -0.5025541007538228, 5.645026458417873, 5.6227762360796305, 6.360804355552034, 5.053744266320049, 6.085288119427526},
    {5.302637363732768, 2.2790748856298433, 3.791233132143, 3.746411801983122, -0.1333099996146745, 5.890187517188054, 6.147017132214108, 5.030958356389697, 5.954278215826584, 6.499531609264747, -0.8551646890247834, 5.804517201496537, 6.511763189716058, 6.411525040938358, 6.707031271145171, 5.305026244185253},
    {4.167213170011903, 1.8556439786252001, 4.081292192825757, 3.7471390974827283, 0.45047400892796363, 4.129273392804198, 5.824679349559225, 4.0388848910830975, 5.853345926608046, 5.284266276444287, -0.7244845224076321, 5.291167098588583, 5.323405413805752, 6.309722104737066, 6.044537399511175, 4.775958128365501},
    {4.990871443265904, 3.1821372182746215, 3.7968590914037548, 5.015135228076825, 0.4681708810036352, 4.785060267748245, 5.516374662359709, 4.635848887010839, 4.855002094245563, 5.189989236644701, 0.0459176597985309, 5.859113826714727, 5.421223914560732, 5.532791079333411, 5.595832385506541, 7.055252169034001},
    {5.03888389787242, 2.2496005907002896, 4.281006599149812, 4.323373665868098, -0.6765315120985382, 3.9881182216893243, 6.018506066628343, 3.981220098362577, 5.042630316929158, 6.259244547856881, -0.09730579189207704, 4.813289678007328, 6.034681066966589, 6.373716994043609, 6.461440422706454, 5.935461569829233},
    {4.309188950772918, 2.6743749517084825, 4.441076938926731, 2.8536687223193917, -0.842133704025232, 3.9649246257761304, 4.545068022857145, 3.0712101859800214, 4.887605747808891, 4.177046974129592, -0.7546658700393567, 5.132393221850262, 5.247255236845186, 4.959310407820107, 5.977445489335427, 5.966248911990457},
    {4.634234817040164, 3.196523593074097, 5.007656655373473, 4.782340515975731, 0.1522309637372221, 5.384259823749103, 6.426013217427912, 5.054220283512796, 5.309869393697547, 6.417380519349663, -0.7067842174611485, 5.260912325999183, 5.982465335426555, 6.138010812025773, 6.448440213444521, 5.177002784383679},
    {4.345128505891203, 1.7712756178945033, 3.988159618779804, 4.704552796695674, 0.1600676115059041, 5.79488269135844, 5.719337424573669, 3.58361161963707, 5.292810140208753, 5.926104056362896, -0.09485689978159499, 5.968686785149906, 4.942399084872107, 7.085396340501504, 5.287646770732692, 5.372631569974296},
    {4.335681944332302, 3.438991118580928, 4.396895274071405, 5.080634476796666, -0.3679875721368876, 4.883432611063504, 5.675198504032572, 4.198323759045679, 5.331018320075011, 5.96977897326358, -0.17017501403038568, 6.062465583194682, 6.195542849323554, 6.879192340546811, 5.280556011269088, 6.6831009032953785},
    {4.310278145913638, 1.4048410169090946, 4.890113543799145, 4.798447280633477, 0.49837409771366814, 5.069803532461447, 6.587086011653679, 4.355204195275268, 6.25250365356387, 5.590024625029777, -0.5994817059712798, 6.331559714971057, 5.469269767787407, 5.4400212891502235, 5.5771170697998675, 6.047019002313137},
    {4.002177898419393, 3.266092435073522, 4.692202620198926, 5.515753421571793, 0.2634068114366262, 5.551880642090755, 5.375689312089356, 4.1966081606276235, 6.251450360779844, 5.305186028142187, 0.1855877278824273, 6.6882552445466255, 6.287312137854503, 6.339593976793795, 5.325025239728862, 5.2627227116555435},
    {3.7493116413901997, 2.3800987195633025, 5.330504521932125, 3.8416087837448196, -0.8771171223750346, 4.923806660963682, 5.763592606284889, 4.840008134213299, 6.080566026313985, 5.996400242213031, 0.6727880379189214, 5.818059714098741, 4.918926391097264, 5.322300208925937, 6.176061181507855, 5.972576811346615},
    {5.016550975863983, 2.9961661370328194, 4.398907622986464, 4.314240049029707, -1.0830513581256325, 5.733920892186303, 6.372227310433379, 4.671316960678403, 4.827961316137849, 5.86272880494223, -0.464817874595972, 5.354507334169002, 6.220287283001143, 5.748744390509417, 5.496391450378731, 5.959877503269195},
    {3.833406742833522, 2.0300001308369238, 5.347516399961255, 3.9760443723474395, -0.11193759663760737, 4.533986113538226, 6.438606935478459, 4.200197121228317, 6.354828671065091, 6.233899108803012, -1.040866132245966, 5.744152251483722, 5.140946380026193, 5.603321033307409, 5.428984050050364, 5.633537114324712},
    {4.559206397234116, 2.9970763099734934, 3.7136917187649745, 4.221012106806237, 0.3454819887193341, 5.348750500996052, 6.067683411077678, 3.381130976981442, 4.497421904535021, 5.763259146184656, -0.17011929873856874, 6.265716490208678, 6.063645861806481, 4.815252317564178, 4.866444692231943, 6.381705354549466}
};

static const float b2[16] = {5.7641038244858676, 3.7437981894727534, 5.78983047471564, 5.27777996657254, -0.30370589546285237, 5.582660832963032, 6.258524910868917, 5.009291828591903, 5.96730475683435, 5.890165135102848, -0.22709067529000057, 6.205315153856122, 6.111417905791279, 6.06550826059738, 6.206424039960251, 6.128972031054217};

static const float w3[16][12] = {
    {-3.541948767215276, -2.375684245015091, -3.7359585605057752, -3.4668691229450443, -2.7491253969201357, -2.9967417973315476, -3.07410363640771, -3.2459774373159354, -2.166842538505787, -2.5613893719567895, -3.2643927100326597, -3.758256164836331},
    {-2.49159428483822, -2.5580523449952515, -2.616395397941507, -2.373994242547992, -2.404269198898433, -1.478677155767808, -1.933438504674388, -1.3145073875086561, -1.1244093001467277, -2.4756812614363204, -1.3318729183152438, -2.2227682308709076},
    {-3.071908050039081, -3.487226280857039, -3.451190968825277, -4.032548051619878, -4.26953778167381, -3.6756535094858402, -2.6423756851130604, -3.777316613456348, -2.6653273162386126, -3.040140641247814, -2.755179952996119, -3.067949868207894},
    {-2.6946027203137586, -2.8851302434448645, -2.6112290855658964, -3.628260146620192, -3.930942924871557, -2.8596667371011186, -3.729155669982101, -3.7169030579053124, -2.4555750209051648, -2.522270548095141, -2.435699274718735, -3.51998354440602},
    {0.10741880692358197, 0.1254223094623707, -0.3842615514841701, -0.3884105334048386, 0.07425547935100288, -1.0034644333722376, 0.40942878452000503, -0.12670518050176027, 0.17858151917654244, 0.39926758495820275, 0.2989676913061872, 0.44084631850359685},
    {-3.957762178655555, -3.506234994861259, -3.7208488815718157, -2.886403300231872, -2.9854358870944533, -3.1891614988804937, -2.9244334781101626, -3.6081940524354943, -3.6759561412438133, -2.8185015615778872, -2.69724126627726, -3.2889556787911105},
    {-3.6442210667834094, -3.141030100785057, -2.823704428072782, -3.5058042366968865, -4.011517434300204, -4.203014865713935, -4.2708927103133965, -4.279708736452495, -4.321284221610893, -3.462826281171958, -4.6528246673298925, -3.2545683026247545},
    {-2.892127916345131, -3.6592094408747844, -3.0680615498579886, -2.471787866683196, -2.6600113997988557, -2.3040624374724366, -4.0503561478391905, -3.1896449791515407, -3.88818651316912, -2.1627602130095753, -2.4134968143503714, -3.095217352452059},
    {-3.2495553012291745, -4.076395902986479, -4.004667390055394, -3.1637517829176547, -3.523313991049595, -2.894530241523584, -2.6911685915574886, -3.457955377078187, -3.26457656559496, -4.2818680404087095, -3.896370869547369, -3.7487207798079933},
    {-2.985658208300665, -2.9837469209725516, -3.8360875993512034, -4.340546904607374, -2.6274429367258985, -4.03513526313257, -3.660094608560822, -3.1388235480072604, -4.796069165597895, -4.292989026818639, -4.231280653931281, -3.8881319648101513},
    {-0.01999637747926521, -1.1430795899622952, -0.376536859862788, -0.7852892238208262, 0.4399453062826985, -0.7603018374919618, -0.05189819988635755, 0.6033621235182327, 0.8522151929601801, -0.27127482427354643, 0.10196574362336457, -0.6898472622558759},
    {-4.594539389076469, -4.3229409323679455, -4.652998663934079, -3.2493583698817243, -4.55617681722372, -4.613233877305063, -4.6551493357327125, -3.328706588286363, -4.025604535710394, -3.906272609929606, -3.7989366099761903, -3.931883906330982},
    {-2.901031189027909, -3.866326909820483, -3.5972749453171438, -3.683991842804057, -4.390077845252034, -3.861263662635075, -3.0818573266046534, -3.0623251737142128, -3.2367954322363466, -3.915006539939665, -4.376812270906839, -3.269586059371023},
    {-3.8482531231626336, -4.671291270338868, -4.448387273706924, -4.629855797306428, -3.5736553687367474, -3.895366648335494, -4.301271409205429, -4.38086690353451, -3.506308372572527, -4.899250705751096, -4.172796035878433, -4.304686046712533},
    {-4.311662223803308, -3.977584910223821, -3.127555152769759, -4.343602878577745, -3.022441050029957, -4.114747527926071, -4.54093334216129, -4.474637808265549, -3.7862937166379673, -4.45396337582507, -4.018307336391494, -3.6572254575076735},
    {-4.700400927207162, -3.513108663708121, -3.630551154479251, -3.2798010100097104, -4.409834269304608, -3.9817664815956864, -3.3163983006451687, -3.636779421913667, -5.012257762079734, -3.502398148052114, -3.8232254471284985, -3.9657006263410914}
};

static const float b3[12] = {-3.0168451732208337, -2.6841642700743584, -2.3907265016485204, -2.827983711591968, -2.6906862436868675, -2.7900938934757837, -3.570140579848915, -3.0549896997439068, -1.674310298828222, -2.7563528450926977, -1.792269241728433, -2.659350763183071};

    // Input Layer 
    float z1[32];
    for (int i = 0; i < 32; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[16];
    for (int i = 0; i < 16; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 32; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Output Layer
    float z3[12];
    for (int k = 0; k < 12; k++)
    {
        z3[k] = b3[k];
        for (int j = 0; j < 16; j++)
        {
            z3[k] += z2[j] * w3[j][k];
        }
    }
    softmax(z3, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
