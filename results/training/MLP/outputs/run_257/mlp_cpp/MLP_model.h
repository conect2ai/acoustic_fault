#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][32] = {
    {0.964422340261823, 2.4753867124674485, 1.735884749498577, -2.4470590916818447, 1.0442902877938705, -0.7734470324548371, -2.1857198896126024, -1.3140477539559086, 2.1019257409258247, -0.4095634657122278, -1.3717967337433472, -1.8688045684877075, -1.150947612682352, 2.598076586291121, 2.528419042018388, 1.048939493016622, 1.4303974995729887, 2.2763344903906075, -0.7985370712042745, 1.4322637913151475, 1.6929015877767368, 2.568484371820247, -2.272325232847922, 0.6306362731347849, 2.472567703958001, -1.8211010028697991, 2.0168844976219242, -1.7426370252898065, 0.8205778548701804, 2.9759166586341474, 0.8904723821524066, 3.185442743254141},
    {1.1948146161270534, 0.6359718094784652, 1.7060141741264783, -3.4683978976095187, 0.9936667837327099, -0.870848429966527, -2.6824680041137645, -1.8112615152598979, 2.5440750621069053, -0.7945153404059494, -2.6772509175318207, -3.2575805543117395, -2.17280502444816, 2.27552135682622, 1.8565095314744977, 1.3379139091274106, 1.6943943602127884, 2.4213838708791586, -1.8583682119194174, 1.489995823237682, 1.6531129902196218, 2.591059933211278, -3.1527372027662977, 1.1221769396292094, 2.6705593259112206, -3.3159515663905115, 2.4849768805469963, -3.356385479197584, 0.25275480464430644, 2.178684010950469, 0.1611654035688798, 2.368959064968868},
    {1.201162343628825, 1.4578259184392992, 1.7667376170097013, -3.3173768875149885, 1.0107916268753483, -1.0686071825587655, -3.0359268184310304, -2.2830012900392416, 2.9639297705548953, -1.3406251192156522, -2.309401653519124, -2.8784519988612187, -1.8939271620851466, 3.4552309688869527, 3.2424676574056663, 1.252560286705533, 2.6090485664663277, 2.844960202387934, -0.9590163077639762, 1.3747956428920325, 2.3914726921756295, 2.998009029241402, -2.876147003341512, 0.5056035411639068, 3.1841279851406066, -2.602596724754169, 2.9185550030020715, -2.6108269370967663, 0.10936415565216923, 3.4441238823100333, 1.2979460216287133, 3.7902587362465896},
    {0.3312797016776109, 0.8571688419357691, 1.37882616914811, -3.835766354556074, 0.4092103097461595, -2.5324538658658797, -3.8260755797340833, -3.5699110955301974, 2.606592079953702, -1.9645844581653407, -3.242822212596578, -3.6741364519966058, -3.2425175980845435, 2.8050766075513276, 2.589911156217751, 0.9996863058989519, 1.4902656154923037, 2.366322175318347, -2.4420946146105678, 0.5327686981826877, 1.3198644928008845, 2.38449249906844, -3.514735534321564, 0.017359427651362308, 2.674786614204947, -3.443785473102124, 2.3919342764607507, -3.705813465033711, -0.5172573232808927, 3.1793998265270926, -0.3463928612404949, 3.391825642969086},
    {-0.11306366536927921, 1.33638558706304, 0.9101299859379423, -3.8558182962926573, 0.019408067268821542, -2.765250004649632, -3.9573594309422115, -4.09026082219126, 2.0695368209362397, -2.3509217286794657, -3.48340123900956, -3.511030927702716, -3.4212932446133215, 2.8840398922641923, 2.923897393827052, 0.5198329614075504, 1.6662154860196663, 1.8607777156799115, -2.2997471599184878, 0.27164853992126764, 1.7617847169110172, 2.0736584756908685, -3.90827988317512, -0.24938000662531834, 2.277481843757014, -3.2856966389176954, 1.6870682983082448, -3.5329713354346697, -0.6595191899745216, 3.0414070443076646, 0.14694930679739182, 3.0061437619813796},
    {-0.5154457589973787, 1.0237578599901929, 0.6977799759056379, -3.727561808598662, -0.05279331495181947, -2.745755009143376, -3.892096608315919, -3.643402074601756, 1.437171696140814, -2.355858650456742, -3.388453594500188, -3.5053123301053972, -3.3859242364046103, 2.7707885477584506, 3.0198684174157573, 0.33000938741130276, 1.5350391266865302, 1.2609525275044358, -2.1132017834575882, -0.06503281965706083, 1.6165532292100182, 1.6776069381076837, -3.726850120839242, -0.37145775315249324, 2.1844805961517806, -2.892023564886918, 1.5441316950014712, -3.3455142330230747, -1.2239289209514979, 2.8797410958466814, 0.22237996674681448, 2.597092058005917},
    {-0.8050468192288297, 1.0638142272285067, 0.2400716056372947, -3.6265845098473206, -0.2513082236025267, -2.701036921524584, -3.887989782277035, -3.5105144293740165, 1.2971540118804086, -2.4351865910014348, -3.203179319089865, -3.205258857740149, -3.4448879534160652, 2.2805207696147596, 2.6501460854649057, 0.11657640173119163, 1.0630850519400121, 0.7458019312680296, -2.3701797186088682, 0.03670564970648286, 1.2164172490385354, 1.0614366618182278, -3.535999887987648, -0.7451704453899745, 1.7598681726654462, -2.602163409338484, 1.0019981309568333, -3.43316430694119, -1.1494584575546056, 2.586727584077339, -0.11102827717479956, 2.4098332049103},
    {-1.1664744046761564, 0.45968526503565216, -0.10734515699244138, -3.7000409576685716, -0.3110140027705689, -2.6024238301207205, -3.9653712816804942, -3.942316533138485, 1.0637144416023714, -2.481091686784608, -3.678764504267945, -3.467603599514212, -3.70413451352332, 2.1217269273991346, 2.5812635273063607, -0.02298457725616898, 0.6893767720568977, 0.8633588977938306, -2.794178294976997, -0.34902306919022547, 0.5366826440945077, 0.9993010793909785, -3.887116491067519, -1.1133811127444737, 1.7142344560875835, -2.4597515118907207, 0.5861395091008476, -3.7265031637017407, -1.168461572813317, 2.335212658938229, -0.8985430761102682, 2.4323004417571856},
    {-1.1835576629853857, 0.4537633775855166, 0.09423987424145347, -3.6756234554652782, -0.518494827400535, -2.561382601914906, -4.117468530600238, -3.5182452679820417, 1.1880822563263682, -2.305963498044688, -3.501872962586867, -3.613779245089983, -3.5751010908753553, 1.933080796745932, 2.461825600575337, 0.13529566287395436, 0.26384701208694034, 1.1670758595916542, -2.8179479578766653, -0.22522512023266775, 0.26427548756230124, 1.0190001692656534, -3.483259864613902, -1.012347077150529, 1.606238579483461, -2.817319511078474, 0.9673396220021241, -3.6638266252014464, -0.8323686760321342, 2.5648482716064724, -1.3895390008125854, 2.3248398544193805},
    {-0.36044094769531243, 0.7631106858505539, 0.8064362484421913, -3.720024231406504, -0.11152169537787354, -2.101204782689742, -3.6859470582644507, -3.798963567811632, 1.911398350690652, -2.0261846968634263, -4.129737917201603, -3.4940966824669726, -3.7037735124187354, 2.2717739183843797, 2.5375364856769105, 0.6851679827087075, 1.0055665083971448, 1.5546275745288658, -3.0801535287823514, 0.4566232229208694, 1.04036515677285, 1.891485686063836, -3.931191781372266, -0.1601372340052786, 2.61083423988722, -3.4200531822732763, 1.7870674422853159, -3.9073313373966156, -0.7596573499697828, 2.859420110185375, -0.9894767938722729, 2.7954116735660146},
    {0.17391570675354928, -0.17998459221894508, 0.8206627231495692, -4.076290741691935, 0.09907965032299772, -1.9510655627392115, -3.6313006849796072, -3.5109609022889803, 1.9688776167660367, -1.8783416827945876, -3.872217844676768, -3.4629981119060482, -3.2269129848034517, 1.359871588476572, 1.6609218713280267, 0.30427616236244914, 0.8958171707481865, 1.7121260428543004, -2.9404605150296215, 0.35610934759098034, 0.5906306786560119, 1.6701377697294304, -4.00024480756475, -0.2628630628674427, 2.4942956747974976, -3.5383844449771127, 1.806218579141506, -3.822419079544136, -0.5334848236525286, 2.2280970226348904, -1.6769188474056975, 1.8597129766561418},
    {-0.8199127340284825, -0.35571857395536594, -0.07844868177996624, -3.853743404168394, -0.508086557958547, -2.478077714382104, -3.4917701309557563, -3.4613706542715894, 0.8108772887680362, -2.1103745042362947, -3.7503442814018935, -3.678821532858355, -3.464053246987207, 1.0796282571361908, 1.3367022237886474, -0.5223587282494694, 0.38460127741737704, 0.8866593223359571, -2.7888788543275322, -0.6090994305613137, 0.1929639352005723, 0.9578172218640659, -3.8798642642089463, -0.8226451307495803, 1.4829418523229594, -3.452241472132273, 0.6936838283464332, -3.7346730771516174, -1.0511353798737928, 1.918660493893858, -1.6632071541219273, 1.3922545862344005},
    {-0.8470650652550359, -0.12168922300932486, 0.08579855178123663, -3.4629082142894094, -0.6131339452578576, -2.4290939946699517, -3.7900402939398234, -3.4856715174668804, 1.3582751854031538, -1.9092390416878837, -3.5214779568297825, -3.632466963066423, -3.21312104795718, 1.4398612267139228, 1.700631025790483, -0.25951347837051175, 0.6385035373171981, 0.997005663718246, -2.8342712250259248, -0.5618102455343853, 0.42235139281881234, 1.0899157907666617, -3.577544178889554, -0.9702275830379226, 1.8829763129650938, -3.3546357088460237, 1.088140222323624, -3.7267530198640664, -1.0221757285320576, 1.765300170077166, -0.967098038668077, 1.3254601109318112},
    {-0.5624117314645278, -0.23894580827445858, -0.0097365122130671, -3.8690159474327825, -0.6476213233035947, -2.153646821134039, -3.5937286807806927, -3.530014833759287, 1.2318747735163629, -1.9550599777586675, -3.459331171811667, -3.4180628036366594, -3.2506319156991537, 1.4524204807302084, 1.2185981405650426, -0.3262005500712191, 0.4215337592652285, 0.8464421459225182, -2.7406362215559654, -0.5489542856793574, 0.5742966312019522, 1.001324887761714, -3.6833454616429617, -0.7547442346629587, 1.7475117988902726, -3.6860687502762537, 0.794144971905204, -3.9737791988081423, -1.2198017061420106, 1.6826986827596222, -1.190938459614914, 1.637510532489108},
    {-0.13367274333193294, 0.3523509468612999, 0.7719887704570565, -3.6740819781826453, 0.3050258125637293, -1.6515820116235884, -3.595610091595488, -3.448958729881599, 1.809853307257008, -1.802171921783907, -3.7194364914568774, -3.642261684102296, -3.4596895863299912, 1.711493289884565, 1.7573942723982998, 0.7624899546738115, 0.8470206586090548, 1.616192036201666, -2.4608067553539374, -0.14832075529119992, 0.8474158350677768, 1.6091414034203129, -3.5150348178846706, -0.21251733119865643, 1.9954167862342416, -3.896119235229239, 1.5967667051863448, -3.848409240844014, -0.44953444696096717, 2.144306796126656, -0.6568467454803287, 2.0626972880989394},
    {0.12242876850580686, 0.5954131217121719, 0.872403070360557, -3.7968412876879114, 0.06485921285670912, -2.055865144286464, -3.6235407833426767, -3.5836260623946776, 2.2855905102438325, -1.7791334198798534, -3.811557240394358, -3.7986573682302627, -3.484611656804604, 2.5890465899205077, 2.297682051297283, 0.5769922115188676, 1.2712698686488544, 1.860006250801708, -2.2999499589761405, 0.2815137809737653, 1.629123189297888, 1.8555634103166232, -4.0304150422373395, -0.3289557107339155, 2.480176554281734, -3.786840889403117, 2.011279455642457, -4.017814461469008, -0.8569628619840971, 2.666887149560443, -0.39160027433487543, 2.5619996202756123},
    {0.3133657489980584, 1.2700462516903417, 1.065373654326824, -3.6839209055020383, 0.026821090558830203, -1.7077423957161009, -3.5702651086800268, -3.380559697688569, 2.508104700954589, -1.4127821262420208, -3.5345037719545624, -3.561132302340265, -3.3321944581771548, 2.7400260716252607, 2.6855902236669076, 0.7305588700966132, 1.7631970071588048, 2.104224266834738, -1.8944524100975515, 0.5938684039287969, 1.7184975444362467, 2.36968640597585, -3.773946536847779, -0.2049082838843718, 2.5709106982463537, -3.456408781609596, 2.3439963626063753, -3.4032286955171775, -0.6013561280899393, 3.298431757203075, 0.1451777956056232, 3.11057986220584},
    {0.6801915312960298, 1.7207937228231776, 1.1881072828952302, -3.290962686621226, 0.5969681181070459, -1.3118733580589348, -3.5272697014329863, -2.6691482866187584, 2.7143263837926193, -1.1267252406585997, -3.1829872490510476, -2.8376019989170573, -2.3304865193667874, 3.2537584853163546, 2.901625197647987, 0.9941584536759587, 1.9635914431409456, 2.4680275997708305, -1.2338466516177593, 0.5738728792305419, 2.315281424776769, 2.54311023635665, -3.055885167608381, 0.0843040481488653, 3.099701860871689, -3.2898701248340765, 2.783436913111827, -2.985737021405308, -0.22385785129275834, 2.845824332177783, 0.8368446209461372, 3.329570636426561},
    {0.39506905347529236, 1.4202367182402036, 0.9867308016503907, -3.208881919677912, 0.04863013258067791, -1.5775492901019466, -3.3892203077866796, -2.731239356545845, 2.7003612138027897, -1.2216652919305446, -2.7407427298947153, -2.3853063187254935, -2.0599541532763253, 3.262431619832616, 2.7447949384422827, 0.5467155604673523, 1.964902217444939, 2.0949894965072664, -0.7656332405059849, 0.22266658373000922, 2.140470061643542, 2.061302138059925, -3.133790031686578, -0.17074144409840236, 3.1133729120681095, -3.1177078958525253, 2.471441171458015, -2.8849459211023114, -0.4035694101108383, 3.127532518051678, 1.1863030911830275, 3.053564516490322},
    {0.39817112242038005, 1.237338384432797, 0.6826495893726056, -3.8057135302868432, 0.08733864545736063, -1.5994169412376367, -3.446190403395562, -3.155145450247383, 2.6541662548666207, -1.6888260855418538, -3.16565579774453, -3.2282054130167626, -2.5429370427397924, 3.090867856195617, 3.0290169639682842, 0.48530094489841263, 1.9482862758286155, 1.956327773529283, -1.181717547183382, 0.49088580699917606, 2.005858445105747, 2.154549988241957, -3.7595753373283456, 0.010680684608101502, 2.4202242822813, -3.4165556471865948, 2.117333617637339, -3.0573215774813214, -0.7070250710050627, 3.183009742395145, 0.7760724524541922, 3.148047549614395},
    {0.775568987877568, 0.7977463786442096, 1.1579580280304287, -3.7971831654784642, 0.24669219672311385, -1.452113010517721, -3.8387002292980967, -2.980930361168148, 2.9482720665796496, -1.4713152515631882, -3.367842129594412, -3.5010261528404745, -2.597005502612594, 2.972945004834675, 2.60740413261803, 0.49874280703185825, 1.646485056290999, 2.4609979599055283, -1.7928914748348284, 0.5733079724747506, 1.6771695690593522, 2.303333564217577, -3.9623416217129614, -0.24531226056067731, 2.6416573934297447, -3.816156520672761, 2.358890103413914, -3.4474441007516248, -0.42965976196722294, 2.561288366504747, 0.36594435603092235, 2.943720788535081},
    {0.7939571980612298, 1.7321667088813806, 1.4276439503437106, -3.485886537239509, 0.6237330646116087, -1.316772456157339, -3.403157493939843, -2.608003476601742, 3.180930474573373, -1.238885922636953, -2.694943004950032, -3.411977060334577, -2.2398524081488924, 3.5707233034451358, 3.0714791894871536, 1.2072977049004003, 2.028314604241962, 2.4807972088218264, -1.3155880964009266, 1.002647520660088, 2.1247221722962983, 2.696687950902441, -3.474466122064757, 0.3450600115360808, 3.1680348281506023, -3.3741780435062703, 2.903697824819782, -3.1313746818604162, -0.07183951341898788, 3.350762081141888, 0.9050839563486189, 3.424854536919989},
    {1.2421676220092654, 2.323370115084877, 1.7852264958504347, -3.086109907676234, 1.1646820514558347, -0.8527114558955897, -2.832529483860229, -1.8836797792207256, 3.066724202549172, -0.6565588569981724, -2.4024014421059747, -2.8195181249879337, -1.9607248153861512, 3.557022131949487, 2.780881256137461, 1.1980376729501292, 1.9213906207894627, 2.869081400704937, -1.2104821713203013, 1.1353161559281901, 2.0811553583240596, 2.866842844304888, -2.8730303666064407, 0.5503408549880394, 3.304539616339391, -2.947077837558954, 2.763457364321451, -2.9272144929913635, 0.35073758068446675, 3.222653228669712, 1.1316920580659267, 3.7575912905943327},
    {1.1944296491666402, 1.6160780403922155, 1.0407381812891154, -3.7027963606342205, 0.7257404028212369, -1.487321901433767, -3.4424039877924995, -2.9074671128603806, 3.027851983246075, -1.0825603755836486, -2.8797894832054345, -3.181206172006694, -2.2667572919613366, 3.0544255895419843, 2.7397191251072397, 1.0826622174338538, 2.095638517864013, 2.525428556872522, -1.7627750338954986, 0.5099328069179418, 1.9315245726423116, 2.765943243493296, -3.2781866988309476, 0.3723099821808017, 3.165315004661246, -3.1269872898780187, 2.708092664218887, -3.3923563233269376, 0.04854797333924584, 3.1908146691426946, 0.6234316796475272, 3.4648614564495324},
    {1.1680599621827936, 0.6083341063469097, 1.3531911370979846, -3.76616717334142, 0.4446061861797214, -1.5433148265397796, -3.391848621155733, -2.7762810631257455, 2.7081714197180133, -1.1017814699011395, -3.0891894674438, -3.2433862611244995, -2.6600674147046717, 3.004899847600264, 2.510617139572688, 0.7935850280059712, 1.8889714282188026, 2.5344627248631646, -2.019977319010367, 0.8372203747457999, 1.834742157263741, 2.525568485087252, -3.6203628515710977, 0.138501045770004, 2.934501172951464, -3.4699680964048136, 2.5538541392244007, -3.336901718973955, -0.16158042694656788, 3.072494133864111, 0.45213753141345103, 3.0623281350345586},
    {0.5439185446256213, 1.2638430046303533, 0.6982198657705097, -3.7462831492281623, 0.40755387126976267, -1.7901662855746394, -3.526928146708676, -2.485443755358105, 2.3398569891371928, -1.1042271823105128, -2.9006787669619936, -2.8408513137633564, -1.8286161637081986, 2.956875390224954, 2.6571828073437054, 0.5819533120089045, 2.051948667355696, 2.1117299966692613, -1.441517025339971, 0.4162343919988143, 1.8936443286741407, 2.4539411283009835, -3.158983097456631, 0.013038955280010495, 2.979470144071246, -3.4030544399634715, 2.4369318603214216, -3.099389431972422, -0.33644039367261436, 2.804198185023966, 0.7397568351043975, 3.0009496146435124},
    {0.9491927817007398, 1.6711329263417039, 1.283515425554897, -3.733993771267797, 0.524971601107574, -1.220732523037254, -3.3480214166142073, -2.8387011297626623, 3.094317478491212, -1.1436356034972324, -3.0747111082553347, -2.7753451980772033, -2.1510370752985715, 3.3539020995492086, 2.815071642509079, 1.1062626562432205, 1.862959618114672, 2.5622475670876153, -1.2026806081153123, 0.7866903271678144, 2.1508140769200335, 2.87338886268709, -3.285352465137167, 0.24505243302780527, 3.0732529344118453, -3.3605275720135217, 2.8867961851323023, -3.2333125011378336, -0.3191193300599729, 3.0200381853612974, 0.8090053385748942, 3.3771816106460415},
    {1.0237887472047948, 1.6778775750755561, 1.2690596990204799, -3.907479929115773, 0.7051254546173907, -1.3934070054414849, -3.474692857873507, -2.9765114963055557, 3.2220662729283047, -1.149976114057377, -2.8560044335303427, -3.1651119742322082, -2.4124310891371983, 2.939558203683736, 2.823632725651018, 1.2159283081730616, 1.9768961450053628, 2.8915897728697955, -1.4035685577730395, 0.9520993935145323, 2.0690706972970263, 2.9053155713791687, -3.741998936210614, 0.4236334055465659, 3.0627108506470524, -3.7302745616031237, 2.758812935172985, -3.6143297835010593, -0.07852058449913607, 3.157458120808933, 0.9991039117456197, 3.236910039847741},
    {1.2385902870345302, 0.8027191527468646, 1.6879977019569836, -3.557938100557067, 0.7087542635120144, -1.1670182889818494, -3.3949444423319246, -2.4713238628880685, 3.205222901292735, -0.873398055939968, -3.2322157069373105, -3.142022312243837, -2.199670963402735, 3.132064161212411, 2.6541966248462474, 1.0757057139464814, 2.030991556552434, 2.6667434836028003, -1.6907891263116661, 0.8661207377195371, 1.948907187873678, 2.743303164950253, -3.531207943180275, 0.4917205431713898, 2.911712616204981, -3.4701613100798987, 2.808802654128355, -3.6069927535966197, -0.16208799979974148, 2.910925947866822, 0.5597831641128016, 3.1917501355008437},
    {0.9260800776539546, 0.6361704094823036, 1.1365551605860165, -3.923604451552899, 0.679826035461357, -1.3910001294328465, -3.5070531366822157, -2.613871114897023, 3.104091205100559, -1.1602246968273504, -2.928153165114985, -3.335895854915323, -2.1749410411267682, 2.835997388056913, 2.4101660154282265, 0.7558506892154749, 2.0245475810861215, 2.3063632152435107, -1.6309689892039894, 0.6802013759714953, 1.885447428933787, 2.570366842417846, -3.555932246401153, 0.17497698075194562, 2.789076308632499, -3.7960585582735935, 2.5891150855477796, -3.0364780128562394, -0.425485463291818, 2.701542383733305, 0.3281648109146556, 3.1217102498179674},
    {-1.8400061247811599, -0.4730859841296135, -2.09913980241145, 0.9202245992743705, -1.61596947498138, 0.13265415373184108, 1.089130348951038, 0.5256908249329071, -1.8431599490988402, 0.11949697099002565, 0.7752929174290694, 1.4721570954876053, 1.3180795101093237, -0.1111607584585616, 0.10108042179478867, -1.446738445376724, -0.6673424299048445, -2.0555433575799023, 1.2425423580268307, -1.7629474547485349, 0.22484580389190148, -1.9429686504575518, 0.9118169213925761, -1.4470149053698749, -1.1911969248634415, 0.9511244940956249, -1.500102718701987, 1.2029396270210306, -1.7293726747200924, -0.996050738444489, 0.8327790395383912, -1.5571820354187813},
    {0.44291244713645767, 0.45424353302704473, 0.42340519297160195, -2.722072403061665, 0.7183990780352363, -0.9924405408203845, -2.0898811503997314, -1.6158157692191075, 1.1428771675437948, -1.0599128342853432, -1.885046278188652, -1.8629728930479548, -1.807301581549399, 1.2218957236912658, 1.4807514126224484, 0.6363100932594866, 0.14789324662029973, 1.2616806682366855, -1.2139672444309575, 0.6875027707873489, 0.004743591165147645, 1.2717212475238726, -1.999241478144899, 0.14745132479699602, 1.009478747696428, -2.1689364635308404, 0.5694657531492509, -2.2821571676740944, 0.2994043693545723, 1.4009981422035236, 0.19586847688001513, 1.7580338849635215},
    {-2.3378728756238627, 0.11337786180169056, -2.229688279883661, 0.432073296996486, -1.625005514821941, -1.5296453718574143, -0.7822480718761198, -1.4789411056995605, -1.916605446851782, -1.2848470400762118, -0.20492080627913017, 0.5939386483692419, -1.069334662295951, -0.35335638898929134, -0.21986522499611597, -1.9771105912768376, -1.7492299924796244, -2.1615644923139463, -0.15943277044037085, -2.146254721032867, -1.0414958416206388, -1.9881610504499103, -0.1868930143396, -2.2190458711368994, -1.4026138216483643, 0.4545199235824899, -2.3903680927776505, 0.3680737253092355, -2.0054180524906533, -0.518073193383403, -0.6569729280391716, -0.48657230280719266},
    {-1.9919188660281002, -0.1868925100517364, -1.8574178818781222, -1.0879267742647314, -1.9821366886763014, -1.6528490137685756, -1.3085236586899096, -2.3898058278410828, -1.3827663825403982, -1.38401026823911, -1.5970746162581388, -0.7919628202456644, -1.869635363387114, -1.3330766906148797, -0.9018401190918498, -1.682255867498351, -2.3582817514041268, -1.5213342283605733, -1.6323406556284379, -2.0443210228502644, -2.024272379174655, -1.7463072719043953, -0.8755657914672664, -2.2237804350887336, -1.4647802649398158, -0.39332530496517343, -2.3976393125193205, -1.6666051625672624, -1.5882853948490971, -0.3714936915183566, -1.5873302171364154, -1.002805689934877},
    {-1.2216979930321532, 1.0647172858226028, -1.0510618468775792, -2.240352228093893, -0.9033520530824494, -1.9911231981688728, -2.5201392750587712, -2.647554814639253, -0.2001037796996156, -2.2081406891183177, -1.608560973548367, -1.7552824607454813, -2.1061007772460325, 0.3390160586428694, 0.8268394114568841, -1.0998370895837177, -0.7529989105616052, -0.13251664293810253, -1.9163529047010264, -1.2454218753907922, -0.5921309175478601, -0.13566871247535706, -2.4442992137150585, -1.4214159844978866, 0.025052926694018766, -0.9229766452242711, -0.44717671423946936, -2.3424309307804805, -1.2959646331778547, 0.8237214843363749, -0.5820939534478159, 0.8420581147772533},
    {-1.6348963418021778, 0.435144067040935, -1.4440568119269561, -1.9285249219531937, -1.7004456143273845, -2.3293831393495776, -2.1292506880825197, -2.7405613099870725, -0.7360557693680293, -2.198660964852049, -2.050032697020393, -1.845821601366975, -2.514150872958284, -0.3390585385422522, 0.2491161636265065, -1.0878079768722553, -1.7176564623179165, -0.2759681827737404, -2.3293352627388337, -1.1786286698658528, -1.2280563275728662, -0.7885575934774116, -1.6445454148629806, -1.9242894769212868, -0.17510348363944123, -0.12537232912936175, -1.0669011649994897, -2.0585155385391816, -1.590358561238288, 0.9231023616824948, -1.2019539506119825, 0.40852493493468695},
    {-1.7418116850762664, 0.6303575440717868, -1.1922401045851456, -1.9009363524971419, -1.6645599676586151, -2.21486857319458, -2.339968018615168, -2.289049840484064, -0.8287162534805499, -2.451677370678116, -2.6153903003409864, -1.8071132159006797, -2.3072075263516845, -0.1998071340439786, 0.5482943037637569, -1.2782249110781838, -1.2300780004036422, -0.47201477770875433, -2.199591517217301, -1.0879991272279654, -0.8243379216762249, -0.9795424451762665, -2.1061177643225215, -2.1083967527681478, -0.20859501943100683, -1.1839683370948955, -0.922631795999759, -2.128272326035643, -1.8695175611009585, 0.7129247403861944, -1.3926326576121155, 0.5163038207644198},
    {-2.269874110458919, -0.5433986421502731, -1.2164011151433456, -2.1647425489954464, -1.7958320460671047, -2.087842935997276, -2.448773094050007, -2.2017213995160914, -0.8690988839589223, -2.534523614765873, -2.5247155885969734, -1.8510844012964278, -1.941429253731196, 0.008962746489949226, 0.5452746100612639, -1.1958512591355128, -0.9543685488684904, -0.89909780453044, -1.9896848469223214, -1.3298596649567815, -0.7742391598605368, -1.1255202696802864, -1.8878045665217489, -1.7907586935613764, -0.5625194523979559, -0.746901150503233, -1.360192312136463, -1.675671707475176, -1.6050337069458933, 0.37936279929346417, -1.358245564906643, 0.0012486569095577042},
    {-2.144987796151235, -0.19237008916425605, -1.2687470971105446, -2.104433506517951, -1.3658739922262055, -2.254535286617236, -2.0698654439275606, -2.3518773805473945, -0.9786211365377347, -2.073193254869957, -2.206365216208579, -2.07593064379237, -2.3900494931211527, 0.09863046394553805, 0.7878629465886128, -1.2928701248613812, -1.1333755829692462, -0.7999651518599964, -2.0776115028465982, -1.4195786654045397, -1.4023809871591104, -0.7588107435636787, -2.2604710254507405, -1.9680531045769278, -0.5410840232628552, -0.3972102109575075, -0.975052545826901, -1.9362027662042707, -1.5303565209289978, 1.0093346315536618, -0.7754533798213955, 0.27728803112471645},
    {-2.0795904308084525, -0.29162902993264816, -1.8586010568546223, -2.6091864174358004, -1.2456397430946418, -2.1220164154300027, -2.1663114521351003, -2.616131865341269, -0.93499632443158, -2.078695271649314, -2.43991471051598, -1.741167624164803, -1.8106812646187012, 0.4977444077654179, 1.221725504035874, -1.6263804961569763, -1.1267650653583845, -1.0886974076688438, -1.810117530130706, -1.7994994904214914, -1.3744692894000636, -1.0196858293950704, -2.3955685336514123, -2.288518418470138, 0.1374685710510493, -0.2023107646912382, -1.2702584244564892, -1.8473417817417492, -2.109862925360459, 1.0590634844184552, -0.7256495416291975, 0.9062682163767153},
    {-2.088326362341361, 0.08421827715301437, -1.6062287775737758, -2.087276437957821, -1.5800294397802372, -1.9517887663207822, -1.6438070823056197, -2.0271032549704433, -1.7467440574874482, -1.637164848456064, -1.748673922936922, -1.1407795094538138, -2.0968086260450574, -0.7978192063932634, 0.2571965031401236, -2.1293552692277977, -2.1592415134297283, -1.0603724541930457, -1.637750983738217, -1.4456930705212674, -1.8692613488109928, -1.1095202685893986, -1.6445281369287128, -2.1338027390322347, -0.4680050755864632, -0.3912667388752619, -1.7882259930945172, -1.9036671107788194, -1.46344577231826, 0.19043904671004322, -1.50498297266187, -0.22894140441014452},
    {-1.9379092522027197, 0.3960000452187005, -1.9183795845459415, -2.1974577556875587, -1.9580866260896574, -2.503690588784218, -2.6256829123825325, -2.7300978108585108, -1.1436071105234757, -2.2710046749280326, -2.354696009336713, -1.8495910295538174, -1.9831961529016786, -0.17744822165067292, 0.9352315870693003, -1.798088473031902, -2.019496290406508, -1.3924963481325394, -1.9407285278872335, -2.034951091000724, -1.5485244376362057, -1.4541990292368177, -1.9115754181504525, -2.22889509208486, -0.7491732854654737, 0.0011781618268080763, -1.5903767560822386, -1.919128797493482, -2.17279912188208, 0.898724532225102, -1.0433096780964648, 0.2090343611023168},
    {-2.694938827230503, -0.374431328218906, -2.2228139200848664, -3.0753420352687737, -2.389675466015067, -2.9840834300554353, -2.6530927008363463, -2.8146345318999066, -1.1836683964419528, -2.8535568100017783, -2.791084869655714, -2.574680928084074, -2.506540806633468, -0.5103036178726692, 0.8525133968157848, -2.4482421766840323, -1.6678979128159097, -1.6161815768601675, -2.3818992618663937, -2.3702095124320044, -1.3002581787865828, -2.0961804294054596, -2.4631998068316503, -2.242312316881343, -1.023033848984555, -0.7088328246876119, -1.565344597705345, -1.9755034299367518, -2.707184532170964, 1.1356132760711464, -1.1379509896415048, -0.19555215663405137},
    {-3.0138824891714315, -0.7451717010602519, -2.436419557645348, -2.5401905358165955, -2.262978396553504, -3.0669872173706016, -2.788549169535446, -3.2979240935684873, -1.257418413575715, -3.0058383944503766, -2.49891446044558, -2.1978471530669657, -2.6316262593258353, -0.6746914069491243, 0.004072254398818862, -2.5160565149569725, -1.9682297956029917, -2.105486359109891, -2.08841143209206, -2.795341948974977, -1.6818553081594207, -1.8328977371884267, -2.3132429068456832, -2.6193911083186148, -1.5126214679397407, -0.7569417487254547, -2.0722427831941608, -1.536629621525155, -2.6970575713281826, 0.4744999397645732, -1.4097645605373899, -0.28118034831065675},
    {-2.6745431169714693, -0.03450927572272302, -2.187124922413118, -2.256292877364934, -2.3118936149980365, -2.837659604756593, -2.5673430704354283, -2.842472814333944, -1.2121117902378116, -2.7307778013005564, -2.340914590991044, -1.715372503712505, -1.7482840805377573, 0.2230107906603438, 1.0866941389767075, -2.2106880319959497, -1.7276261208824284, -1.519609156997717, -1.3894499696297387, -2.105872338794443, -1.0923065718541214, -1.4977370758124986, -1.9613563749227836, -2.9407022242567002, -0.7745067993301478, -0.11332544279748853, -1.9003213072954608, -1.501514017358826, -2.5911467369085828, 1.1181982949754552, -0.8584837395655623, 0.46421547648479783},
    {-2.924116632053993, -0.008098458409593218, -2.4660416104774217, -2.102536012638859, -2.62694710118556, -2.7286680541750257, -2.0811698616806624, -2.938804180054415, -1.906055376892425, -2.455602207975708, -1.6740817806082349, -1.2918862246427745, -2.245092623780112, -0.3639642195749327, 0.4421115377877427, -2.2988882204017598, -2.4346404373656134, -1.855792280174246, -1.8627231430403601, -2.5761115292563215, -1.7975195897248, -1.9959720641618073, -1.8236039253672853, -2.8654229852005515, -1.2394934200567511, -0.2685302888547614, -2.1176530014553037, -1.622714975817119, -2.8087147232725744, 0.24443089122309072, -1.223102651619749, -0.18902237571198668},
    {-2.4747606486084854, -0.1080121538124279, -2.3059166927008303, -1.957915114153313, -2.2203279613227123, -2.494225496023172, -2.192039423246884, -2.7709249470865425, -1.6145834450407015, -2.183750928279704, -2.173397055414385, -1.6304259060624509, -2.593441651613791, -0.5833395691209488, -0.04516966960139035, -2.3030565405404047, -2.0740030253099233, -1.678998380118043, -2.279723757701896, -2.3112734168909594, -1.4296739086539119, -1.6462076975641855, -2.128489949765033, -2.5821040578327064, -1.1486178543454102, -0.8898519890540624, -2.071436851307973, -1.9819589537971727, -2.4041037398524847, 0.2573257692320053, -1.334676806871917, -0.09975388732208826},
    {-2.281172837884043, 0.33784077679169183, -1.4500198674930174, -1.912351743331472, -1.809946239722622, -2.113118069045679, -2.085273547572213, -2.4731096276547655, -1.1087951113219108, -1.9034679973776099, -1.4664779190594646, -1.205661718106188, -1.8229119017659774, 0.2922668177534542, 0.164536073784643, -1.683171639334254, -1.6838328811844558, -1.616561288695076, -2.1163466534303783, -1.8919999151143543, -1.3499023941040948, -1.2006266959653447, -2.0993320489866716, -2.5899808132211666, -0.7195666635505267, -0.5752301548864704, -1.3806040979655285, -1.9932427021019996, -1.59302720140691, 0.4886453358714307, -0.948514426736147, 0.3119873924061249},
    {-2.650431589020438, -0.2814683234329452, -2.3203387809511593, -1.6640646704587383, -2.3946673290330165, -2.2201135836984927, -2.150034097005441, -2.4983683002859163, -2.4227924762995205, -2.0975815967691944, -1.5702202469940019, -1.6395907761922008, -2.2766417352040023, -0.53335977170304, -0.39580201336772974, -2.514227467250778, -2.4091384927924064, -2.3797789706768584, -1.9668043603374281, -2.754946887205888, -1.7444499396968676, -2.2643132922276488, -1.494920657955678, -2.992598289224266, -1.7582675343044498, -0.28503282377821015, -2.5181787805182694, -1.6276505537647359, -2.284793464283255, 0.022505260362590606, -1.4109523946560947, -0.6813206506046962},
    {-2.9387589806786947, -0.0963768346454542, -2.7479772961614413, -2.250287833548139, -2.8941344214525158, -2.9149425181305273, -2.846080823577466, -3.180216643180804, -2.0173742261888976, -3.113034641162157, -2.5667170441956006, -1.9634672403037925, -2.4495106630921817, -0.3966176174724964, 0.4025857117864364, -2.765348393039672, -2.2575473587904225, -2.808894854125187, -2.1507925779712984, -2.848019928869421, -1.5750739792253599, -2.0935085430240896, -2.0437246004093623, -3.235261860562642, -1.5624199481689105, -0.6410931115482615, -2.316862720802613, -1.5307484715958706, -3.2099956318997074, 0.35452887943824685, -1.5265578056647087, -0.1308912431644953},
    {-2.667242836701105, -0.11982734981399625, -2.331619202874873, -2.6469992965576714, -2.4560815932322195, -2.931826303159656, -3.07979334913826, -3.0918416621480658, -1.4786864267691746, -3.1790799019160496, -2.507655840420694, -2.2155292488650167, -2.912455637579797, 0.04480771807193896, 0.6384976850467052, -2.3185133135789595, -1.705848231063349, -1.7627106573802316, -2.423784364692365, -2.6295531163356856, -1.4783602536766902, -1.6804578969545152, -2.2491276499484143, -2.578769926302418, -0.5291552074104331, -1.4634774912680122, -2.054844254801072, -2.0654076292081465, -2.7160297250023033, 0.5465430330448927, -1.5114436968605685, 0.17668733714424298},
    {-2.1322742036125923, 1.365474920968658, -1.2270578460805994, -2.410826344069021, -1.4444940004138105, -2.477704495025938, -2.998064561698188, -2.930073103466514, -0.00586142779132038, -2.4584877939136764, -1.8164273738481378, -1.2052112781491253, -2.3614398706108917, 1.7483122328585359, 2.459307695587136, -1.5193268097633676, -0.7164380072975773, -0.5464162971831559, -1.5947760420172186, -1.7877434478975822, 0.26084837153636364, -0.13006328104631865, -1.926182682997056, -2.318732755839778, 0.6266112610289758, -0.7371597554013274, -0.3429160490490247, -1.2537453783125867, -2.0321619785050906, 2.165480030024351, 0.43008076165832665, 2.1763599356715315},
    {-3.100137917427329, 2.2338700145397894, -1.9652962405223957, -0.4423643356724695, -1.878711705541883, -2.095745815270671, -1.459588169812991, -1.7007971370704815, -1.0906843889592346, -1.949931640097375, -0.031254400857240766, 0.4066357917405183, -1.0209229292376403, 2.1403594645098996, 1.9420761785792273, -1.6499782051352583, -0.7753609979094506, -1.664838553828912, -0.41555281183299325, -2.3661757293041386, 0.3500174843242946, -1.2351283315146204, -0.23144001347998114, -2.9291821360375847, -0.1767744970621818, 1.397365462095747, -1.4607485021513482, 0.7208009815180269, -2.119039249912962, 1.779752256414456, 0.9769962348163934, 1.83898117306702},
    {-3.37793258635693, 0.8756318431450713, -2.7798197696895057, -1.0546339107316565, -2.8804439018018777, -2.831538863384696, -2.1977994891323642, -3.214325568195282, -2.339097552587242, -2.6980724416591872, -1.0554419390024714, -0.4082841837928883, -1.9368338491494168, 0.29946154183656226, 0.6092634266466637, -2.773000520761115, -2.1367557563978776, -2.8689890852377706, -1.3316733000223862, -3.1477886069343173, -0.7669339246361457, -2.4371844459104484, -0.9945148170042618, -3.490860088441786, -1.5401627186810423, 0.5690813861582829, -2.860574482885441, -0.14318424779904346, -2.8278334468004434, 0.47283438142255274, -0.2586748254617871, 0.11439965271560693},
    {-2.998609664205641, 0.048204540061231066, -2.574795121210599, -2.247479437486623, -2.7666268622767265, -2.999839776551854, -3.0340965202921764, -3.2618248376353787, -2.0885632053667185, -2.7147912095541873, -2.3944382594319613, -1.5285242476619834, -2.636307021206468, 0.24366876353776723, 0.20950966526708584, -2.4200950910528394, -2.1419796121048758, -2.4297751433407724, -2.352082328575697, -3.0676297745284553, -1.7406583900066648, -2.399548796187894, -2.008733563635924, -3.4105252836491373, -1.188064474465909, -0.4695252501776296, -2.585628378723913, -1.675582156216257, -3.036364318286982, 0.35511277554358495, -1.1218209206786318, 0.10625812550376906},
    {-3.7355148264811397, 0.9976593999527283, -3.020370164090217, -0.3922157069924107, -3.1587541891686364, -2.872382280776418, -1.6587659217383786, -2.76073650467269, -2.721091072762784, -2.3056768196926707, -0.7741544793911412, -0.09793102131487488, -1.4936074474600503, 0.17524354061703565, 0.6357888968947994, -2.554070683651563, -2.346026016560711, -2.9121292100027802, -0.8516090844918884, -3.2700939978143917, -1.538464094364347, -2.7920975231754226, -0.31518938275651065, -3.333895550382122, -1.6524197557122977, 0.6511203832306367, -2.905699639904125, 0.02580979550218279, -2.9439203633518365, 0.17270233062898988, -0.20959501549941234, -0.034734907188721534},
    {-3.137221434495901, 1.1447206221663495, -2.71147371316231, -0.9490909445282955, -2.8310745434903954, -2.472561207810604, -1.7060077463240966, -2.847705153685261, -1.8691169943716701, -2.2388456869050355, -1.204246308822658, -0.2875506244433818, -1.3388283556580252, 1.0883420029789952, 0.9066116995475875, -2.513002681496941, -1.995670047026777, -2.256232483952476, -1.1481086909560267, -3.0601410959372206, -0.6809331945332835, -2.135333726632061, -0.7387005517370197, -3.4386874714268134, -0.9306969077599966, -0.12178370156934029, -2.288085278544892, -0.22325149550331957, -3.120361660047705, 0.5887296017889176, 0.44198904111299364, 0.5403727420852772},
    {-3.4827384793596172, 0.6315612738086809, -2.9746289734280817, -1.6895509150717425, -3.2774121605494146, -3.0630380749655273, -2.247248184563173, -3.1391517974535463, -2.4438188695651166, -2.785746849523909, -1.710839407219819, -0.8946427020766945, -2.2316192451709473, 0.5652871162576181, 0.8081168961386733, -2.884241033706365, -2.0609793066667197, -2.7503076614855373, -1.7275775023116302, -3.4862649381294606, -1.340408058535886, -2.497206665493158, -1.4886970914539701, -3.5642604118071017, -1.3985557862243616, -0.5014889109731513, -2.682082717054089, -0.7186464089301686, -3.1531019086669225, 0.4629858935261555, -0.188691915358516, 0.5428992816986689},
    {-3.61341158435903, 1.0879282667464276, -2.7593503554451093, -1.0412064828220322, -2.957702758560679, -2.783585937241733, -1.8787008121514468, -3.015965949028557, -2.4854162351608653, -2.846850708171777, -1.1255691761268476, -0.42724180042850673, -1.6120348498437325, 0.39437518646855046, 0.8034133706082681, -2.387551122687477, -2.1921838194964978, -2.9397765868899746, -1.4554464750385276, -3.1525477286386763, -1.6706361402323466, -2.5194413976766437, -0.6752533751592085, -3.466071022078016, -1.1030614905885405, 0.2230454261596742, -3.1523795430210773, -0.5237083882778653, -2.9048242294138302, 0.26954839998526725, -0.3025033641773305, 0.31360710902901634},
    {-3.5962820557060495, 0.9448472393217207, -2.7377262782462477, -1.1886628181118994, -2.7076626617624027, -2.630500849505894, -1.7853279680094862, -2.850421446921584, -2.5283839326941075, -2.4730882890476567, -0.7174169611771329, -0.37059724469373134, -1.386794313847437, 0.6702535222527874, 1.206952229800661, -2.6717115669175158, -2.2034937496776235, -2.788815986496216, -1.1120359244943265, -3.2136404656101907, -1.1480245125176298, -3.040185391894063, -0.7700635698253053, -3.500591039603351, -1.1847811607972616, 0.5928277199256466, -2.932005884376614, -0.19106499348212977, -3.1717506070810453, 0.5505288049949312, 0.13334979753481616, 0.3098996777115148},
    {-0.6077100443017374, 1.4093285121965755, 1.1084022944269294, 0.6113274452127196, 0.9364946915724518, 1.3009745680496085, 0.44072526643494175, -0.5743342748128181, -0.7768741102654283, 1.4254981994728109, 0.9382712163568737, 0.5125786275899448, -1.901503774267092, -1.8444445702099896, -1.5722289105247746, 0.9741914688032246, -1.8536408027598887, 0.47883466806540037, -2.065914454306326, 0.8028508809103112, -2.0829738938156943, 0.2883442397759892, 0.8620535917385013, 0.4464051578988406, 0.5771118701398227, 0.9641153813533947, -0.6569545598941157, -1.20149200722473, 0.9152244252385632, -0.7133382385870141, -2.4831448264757343, -0.9148694072155953},
    {0.2428491390715465, 2.5910555680561727, 1.7190474037406114, 0.9727959604556655, 1.7369329568230596, 2.039628280761616, 1.1494577676677113, -0.5490002319938613, 0.2476328254301294, 2.0416955776702905, 1.2315937994452346, 1.2023762186417344, -1.9106170633278976, -1.221030313259658, -1.4255060201773653, 1.819314265730826, -1.2501785638690335, 1.0340444418484291, -1.9737503997060517, 1.5974924854910075, -1.9453853944918067, 1.0631210694257813, 1.3384606522957734, 0.829628464555908, 1.6060976496082282, 1.0441721343452972, 0.3158391862549739, -1.066371226952652, 1.74459197095434, -0.35363181275432803, -2.2134202598151735, -0.021685034181498777},
    {-0.6220295644628191, 2.906824510247647, 1.310640875349627, 1.2406938012677413, 1.755174125617413, 1.9299077225892138, 1.3419744638614217, -0.7386215214485378, -0.636987640932913, 2.156698928560345, 1.6052659262214075, 1.5074284279499324, -2.0882439209524186, -2.2112629996165314, -2.2577283112349518, 1.5136063761937288, -2.512321126946817, 0.3777984129807801, -2.6938413671994588, 0.8850826944201019, -2.6166171421657634, 0.30640386064392994, 1.6497921273265277, 0.7678465359363779, 0.9495998206515928, 1.3512475377150819, 0.05591273197243448, -1.3832288093790785, 1.8565247778373282, -0.9714468364609168, -2.6985798832026906, -1.1862361103273438},
    {0.4341226362042129, 2.5226207396399563, 1.6076462509096574, 0.7511093904918332, 1.1866919927351929, 1.7873184313963555, 1.1625976953279955, -1.1367562358674965, -0.19991106352038507, 2.158315485772417, 1.3443172754045403, 1.4493234667031543, -1.635708175537802, -2.133943492271574, -1.9839974725178278, 1.6812604644377354, -2.0354268092349166, 0.3291759069995899, -2.681870876791921, 1.0856889392433118, -2.4864723069135035, 0.6420111404526221, 1.2154958745369786, 1.099038440640524, 0.8781280230468208, 0.8728201642107943, 0.2799356740920881, -1.5550786144372541, 1.663926348415315, -1.0492576684508381, -3.0705550717811345, -0.895790201848968},
    {0.620209093354608, 2.3943803528712313, 1.8645272273822007, 0.9922096574241834, 1.9569291443731194, 1.7917571473493161, 1.1642214369256114, -0.8822206968226575, 0.19507280913988598, 2.2307234600105295, 1.1375579981342507, 1.3221246473608472, -1.6087495636932019, -1.7023165909530424, -2.1404122950867173, 1.94353268739213, -1.6132862874948486, 0.9221304113664105, -2.6376073189029956, 1.2062687780595076, -1.846904200202849, 0.9259951992766008, 1.1994641537109725, 1.3722292056999836, 1.0115275012673417, 0.7495121545486563, 0.21650252201840825, -1.6485799919384208, 2.033164760521936, -0.7534308028548492, -2.3933457940683627, -0.22994820768692142},
    {-0.2597944632195868, 2.3236671546682026, 1.8873409993297596, 1.1827871639976824, 1.83373951938747, 1.9639794798429315, 1.452768723944275, -1.0470640335863297, -0.20413880009766316, 2.000404982747885, 1.3998179305331195, 1.5653770334775639, -1.7727579052496205, -1.7974600586093714, -2.080823523170341, 1.7288516824585927, -1.619906106689671, 1.2037735106567407, -2.582823878253097, 1.453922459147534, -2.5827164579298034, 0.9063869390988375, 1.453617411754426, 0.9853923658640499, 0.7831874653935952, 1.1226299698385906, -0.16879247394143124, -1.7870640987589055, 2.2587679412986934, -0.8764042980040442, -2.810879585304067, -0.5883159277529001},
    {-0.6593460088098032, 2.075875049082359, 1.1227520154753325, 1.3368254956247316, 1.6001543048357427, 1.870839178697767, 1.4045170184585676, -1.2178305876481554, -0.4882759956960727, 2.162024256050001, 1.5807127130820902, 1.822585129268851, -1.9143772469894136, -2.0624148690668327, -2.2362408853088342, 1.8077774186793976, -2.329418281161707, 0.575477044896275, -2.51355896924982, 1.0493639723753283, -3.1613880664392795, 0.3771905533778214, 1.6631177148338718, 0.930881572641842, 0.26504743551159904, 1.597825876884229, -0.3541134305352394, -1.524156845702396, 1.5615189436737806, -1.1478519839018322, -3.039975875561307, -1.0950185072886356},
    {-0.2517488915950452, 2.3772336261117277, 1.4295399513503813, 1.6445020970716206, 1.581004109441174, 1.8411043645128957, 1.693859503222422, -0.7780046299878226, -0.2798369504290103, 2.1729649166876, 1.6852156555370863, 2.1505452258014177, -2.148228466610857, -2.2825043565532854, -2.4361020690447126, 1.9105590303597548, -2.631517524700769, 0.19820113947503956, -2.5610816267970384, 1.188600529861449, -2.638092479064362, 0.1392814849261269, 1.47832163253839, 0.9709437299492271, 0.7189980839669602, 1.4472274167423218, -0.18628660322318713, -1.3890302903928395, 1.8638842756831424, -1.494318582128682, -3.0001440900224896, -1.1512566342800494},
    {-0.5480613553003687, 2.6122158293151205, 1.3649996535960902, 1.6201287680543095, 1.4845661558868757, 2.1869219986997233, 1.2437275025858778, -1.0004673384962721, -0.7017823952997718, 2.4586036370342295, 1.7825355588986684, 1.6190663767135793, -2.226729370676732, -2.3183344999580413, -2.404974415609776, 2.02843032176636, -2.493491387058023, 0.48260737719547314, -2.482373303306007, 1.3233478114752046, -2.708783429393996, 0.6318984642011581, 1.6632441428455573, 0.8160743314954804, 0.8881849190858642, 1.2241994485796341, -0.22629432713630515, -1.7580310809366264, 1.482852589669699, -1.3837864746054935, -3.2186973124752964, -1.0382101261068635},
    {-0.3982162553347403, 2.7029621353596642, 1.589368697441317, 1.403693865012972, 1.8137049011051678, 1.958939373820425, 1.6524463892161836, -1.6334447519342965, -0.6831385515511705, 2.2105635173152303, 1.7569171763517044, 1.7597152998019492, -2.2343725077472554, -2.161682957293722, -2.3960849393250916, 1.7351205780472656, -2.2560039453515923, 0.43960417860196355, -2.5230568308802908, 1.2596220500281166, -2.6552189792564227, 0.9281529461339209, 1.6541245422697277, 0.6309676853427656, 1.4694715510049736, 1.6506413484717257, -0.3343335977572301, -1.9633250308803005, 1.3877721650484722, -1.3479365355459128, -3.1507235327300225, -1.252623926042188},
    {-0.24334900604319687, 2.782785555508936, 1.4822426705488982, 0.9251943600824053, 1.530060681091477, 1.7360110738396373, 1.4582754565074874, -0.8691893368002821, -0.37010661973390097, 2.3039400939835626, 1.444028252031762, 1.6716080225266863, -2.0478223803944435, -2.0609032146083184, -2.1916179872455586, 1.695224654852952, -2.1720970667301427, 0.33412138700700406, -2.103672061802072, 1.1460203968577378, -2.4403980530030003, 0.8488559788674788, 1.562452334561238, 0.5690757347111457, 1.4789551722178034, 1.1740781146556978, 0.10365434984262142, -1.86707833562199, 1.6778158004420551, -1.1308190115576076, -2.591275240683123, -0.9495860860528813},
    {-0.18398348936602346, 2.723496662634815, 1.3898803950278054, 1.5865367860715747, 1.7055346567593832, 1.9332506627774602, 1.235809419253658, -1.2896866894508001, -0.4926929101199697, 2.177525335238336, 1.4465078860330098, 1.7865606744207199, -2.2749529586195543, -2.247804844477702, -2.575871402154, 2.0989736838735267, -2.3913764032401312, 0.4316269268869696, -2.935721308385371, 1.1580187970377336, -2.8305925528280333, 0.7291896299022887, 1.625577321135213, 1.0816422675772417, 1.6479909038699176, 1.5458963183127643, 0.2090036392479788, -1.8659832315380724, 1.794522721909968, -1.3864030634440607, -3.066747124774999, -1.0219545529443117},
    {-0.476777549141124, 2.509899468267603, 1.9653258685436221, 1.4997031348420213, 1.555130555079249, 2.0258011862792515, 1.6569953736320446, -1.1993784303503232, -0.7045851807575548, 2.5419809156771853, 1.5565368011218965, 2.0850828967899075, -2.1967602735560794, -2.6668485613143185, -2.56220615769569, 2.065722757846989, -2.2192257741748707, 0.35053207611603776, -2.8161759247671156, 0.7545837257525364, -2.611334667935415, 0.6107283946452567, 1.913531224799149, 0.8496292968394344, 1.209302842751566, 1.691276699874265, 0.004612113893481961, -1.5331077604481123, 1.7243008166708553, -1.023414063430262, -3.19277173456866, -1.734192364718231},
    {-0.3766448022349604, 2.728031101270452, 1.5972568511184246, 1.2331818899969442, 1.671094330726678, 2.1791956293295267, 1.2706731693556417, -0.7110712305209278, -0.43106430866956796, 2.4911737553316673, 1.7834048261275053, 1.921319884971182, -2.156268086799886, -2.2616263815135818, -2.1882394474062266, 2.0107843388069657, -1.9789163180090243, 0.30355300022486664, -2.5344693630274, 1.0651519024335763, -2.4547264630963435, 0.7320728004662248, 2.203140762357987, 0.7068091617047206, 1.3594178783227513, 1.5320317670070631, -0.17624790764048587, -1.6998698088788713, 1.799311518113076, -1.2099490320015152, -3.045132392842277, -1.4720611085409867},
    {-0.8510552755753579, 2.6133448297080295, 1.2826692095452938, 1.148929828169617, 1.69852169840408, 2.2128876933352055, 1.7581667257977527, -1.0448980507478323, -1.1374631484377113, 2.3039971611528767, 1.7672606029893, 1.7658460005581758, -2.1777021826708043, -1.8822421090292312, -2.2836617839895488, 1.8056966784105777, -2.3548212710137517, 0.3199555547388382, -2.664468642823294, 0.917100429460287, -3.0598284647026577, 0.44476606105617134, 1.9358119938254703, 0.5842390569344507, 1.1841923516729873, 1.4661467093155989, -0.6266480666383336, -1.876053657961359, 1.5790798048399477, -1.8194377079751196, -2.8425271250955197, -1.982750804171835},
    {-0.7862703771150703, 2.6086812918064424, 2.1947190524529026, 0.9202362398245331, 1.8920858239321727, 1.7223123150465058, 1.2476107059577757, -0.9538272235529015, -0.8090317903272128, 2.0751679782655463, 1.4824062683072354, 1.6735362211263496, -2.9194389031063652, -1.873204979530359, -2.0282112255490565, 2.2827231539014656, -2.4461545498504083, 0.4686456664848817, -2.958515470230684, 1.4787750443375474, -2.598483027269705, 0.7663713481842899, 1.8656639652816478, 0.8321705402712319, 1.6185465799713457, 1.444724481293201, -0.06802525051941218, -1.9499967357018213, 1.635674078976238, -1.6831512613501922, -2.96695616538815, -1.690276485296994},
    {-0.08312252886266712, 2.7146543152749874, 2.1426734489905748, 1.3166949725174864, 2.038404957467915, 2.1162697750758364, 0.9711307577601709, -0.9790181723553726, -0.42788600542769983, 2.4569926635073163, 1.696210388704097, 1.7639221264044302, -2.7585405170804935, -1.7120611161211126, -2.021333352477672, 2.3213165557356117, -2.2822736017075926, 1.0757435591158726, -3.030607431092917, 1.471799774716226, -2.2392088560115853, 0.9775936218842539, 1.508033129689312, 1.4880596444895966, 1.9771663139976912, 0.9765732346990722, 0.44576935933207734, -1.7564500957294886, 2.1111266407789606, -1.399770324781359, -3.110584787518754, -1.2930336676961176},
    {-0.6257039411962281, 2.749120419398595, 1.8437360182696945, 1.292510450646817, 2.024565084812664, 2.1082056169170493, 1.3735005466449763, -0.9542884697157505, -0.8072861765452356, 2.2262248287800808, 1.7467251864728963, 2.0129916282830562, -2.8276707423852847, -2.0231578570993403, -2.3428749907638786, 2.1147918211609626, -2.459967485076697, 0.2259621056792982, -3.069677088218863, 1.2898996931519013, -2.7488014473391944, 0.5583593503009472, 1.7224560451157587, 0.8825062564659812, 1.462718455875931, 1.023522472268338, 0.0996433984221039, -1.901341873306479, 2.1258963298584437, -1.5345878824115435, -3.3157539287846265, -1.7799363148580667},
    {-0.6742624323705195, 2.5752979380589665, 1.7509534008206211, 1.3736556000834752, 1.678597686548553, 2.6104437448738893, 1.306622643695914, -1.0122012690761026, -0.38244066407375527, 2.448944995469002, 1.3940444083083077, 1.7958049227246469, -2.3619471984518308, -2.271816885957905, -2.411433304460321, 1.9616665765655228, -1.9427630002787564, 0.33552030519800036, -3.155372102854361, 0.6834011492991376, -2.8642324660361527, 0.4285686976828483, 1.5984294155924317, 0.905432020047898, 1.1506776598563448, 0.9524208368317317, -0.01889964209015329, -2.0622455140572113, 1.7531035244162885, -1.8715391198062419, -3.3073826040494523, -1.6317300869253883},
    {-0.09696078304029777, 3.015013801987711, 1.9921931953757916, 1.4025372879181577, 2.2098662123399824, 2.3825139821395886, 1.910054724721611, -0.995177220277409, -0.7937757615197212, 2.5333619630232813, 1.777782514382797, 1.9697538640334968, -2.3920353145872086, -2.5111142980746997, -2.3485853706113677, 2.2991442304573546, -2.4409054553405114, 0.7252242172890092, -2.9916799237199947, 1.074399608524997, -2.800488476618458, 0.8807560587889482, 1.7418751116977838, 0.8939443706756319, 1.7261141409538108, 1.1551913203944053, 0.020127009193743193, -1.9052822495295747, 2.113671621364505, -1.7484803056992428, -3.252532955655122, -1.661619832587149},
    {0.13957621343060847, 2.753304929268782, 2.0929077868011645, 1.1470613659695288, 2.0144098975446765, 2.2431457295618022, 1.538252442066173, -1.1315908493535969, -0.7119574688356795, 2.419986002236932, 1.6204218234381884, 1.8112996646972466, -2.48045156512377, -2.5219711763576447, -2.503957277709166, 2.2587617775351436, -2.668935520415592, 0.8447706185466111, -2.7860386174208935, 1.6353062210738827, -2.761102750310518, 0.8796228206633341, 1.4602454272520928, 1.1687024599461353, 1.2780597460270764, 0.511061202749823, 0.1633829725127848, -2.056054284840487, 2.050129152093899, -1.9393366402067904, -3.1086094823814894, -2.0683642272023395},
    {0.20746702134553036, 2.8266798331057155, 2.0803073491070587, 1.459636140097307, 2.39294881334458, 2.5283959855166342, 1.6752354068826028, -0.7503003798031342, -0.2147291406856695, 2.9463109607963975, 1.9608245516845382, 1.8281772175225461, -2.557809319652434, -2.5135497010527676, -2.3517712572082385, 2.375291062686429, -2.5854346049871317, 1.1528843744734842, -2.827873379305725, 1.695269142728418, -2.5163601276159286, 1.277769176666149, 1.698003932375318, 1.6922083540821002, 1.9282686226664179, 1.416046547432563, 0.7377609409870716, -1.6374829108859983, 2.4229898013782076, -1.8567405313181293, -3.1976814641387024, -1.6408315793225525},
    {-0.2287210250906392, 2.654802567197688, 2.517904921186997, 1.5239715631737147, 2.440868545712061, 2.412922810070604, 1.5884266675863719, -0.9077955555657002, -0.7800821680746742, 2.959673374157904, 2.155519326311277, 1.9208208493986525, -2.55753124652335, -2.6948174180740736, -2.4572981263831304, 2.523365013428208, -2.8884240505600642, 1.011934539180615, -3.013304368165095, 1.3695142192210004, -3.137043085662184, 0.5145233949131248, 2.085767249684091, 1.2919252949245161, 2.002900489728133, 1.3365961274633629, 0.022200353413494814, -1.7974678066798102, 2.464972644444125, -2.1517883895951315, -3.4970444433063785, -2.217351484384839},
    {-0.5179827046357524, 2.836115884368672, 2.047202071658329, 1.5594358533978168, 2.0273353828778444, 2.5075657589858684, 1.7330467110116003, -1.397297947774392, -0.7793742783893003, 2.517354444594111, 2.0007749469117035, 1.7354591884982165, -3.060060994929221, -2.677202773373491, -2.7490328127947405, 2.3086948600241484, -2.666477145418706, 0.40795169468573084, -3.3634819860400818, 1.399424313376042, -3.179462604427279, 0.592489166439965, 1.8427576694489065, 1.3197708513454316, 1.3322537340280631, 1.2371747200714596, -0.07468055914839385, -2.231138652598472, 2.44842703801191, -2.2689729993728878, -3.7185066844659027, -2.208573775754062},
    {-0.33046539696000565, 2.9128303070287864, 2.391854525487008, 0.9222059127949686, 2.301196031968394, 2.1503697615189057, 1.137859982825109, -1.0702169300330797, -0.3374394316026715, 2.5501919610658166, 1.827567572244613, 1.455062956444783, -2.384479005451686, -2.5815745455360184, -2.4137043096960014, 2.287502126582451, -2.695340001988683, 0.3764355905962761, -3.108775059481896, 1.6521455518827066, -3.066180140040135, 0.64129892018036, 1.5658000733429847, 1.5591857561266516, 1.63286726202526, 1.040055151080199, 0.09009307572174864, -2.510568271436264, 2.4752823228117684, -2.038502991177569, -3.5055902087627704, -1.8760756403506946},
    {-0.6448128480024976, 2.840697768382474, 2.1144807909382277, 0.793858975311817, 2.0000811526213877, 2.0568144558241555, 1.2902930556960956, -1.5426683925319868, -1.099686921043408, 2.4363998942107465, 1.6733124278241027, 1.655003840205381, -2.9957886439873938, -2.8201927543689407, -2.665300462142606, 2.3771877449128835, -3.0034322427354723, 0.17250000273005178, -3.4152509513294445, 1.6032681983077914, -3.276358361261628, 0.669709037147394, 1.5725087514980216, 0.9370713776435198, 1.21466188053507, 0.8724735752645949, -0.19349041782336246, -1.9480194674002078, 2.3461394517200858, -2.222123596137749, -3.7604445977144536, -2.128368589311779},
    {-0.6753725356158969, 2.82739533441656, 2.120003263776593, 1.335790116580667, 2.4237119023069305, 2.35338170686998, 1.9340076670884172, -1.070897641884645, -0.892250801251505, 2.635657237525372, 2.1534142295877228, 1.9079360081297596, -2.8201079638851816, -2.863360467904579, -2.5642200346723265, 2.645074677956848, -2.9813546171962884, 0.3807772262224802, -2.9935950759114336, 1.5891092174488637, -3.0744160053669454, 0.7235005660531517, 2.1514031351335854, 1.5129207802445284, 1.699543070539528, 1.6114564646294272, 0.07332006763236315, -2.0727955869675063, 2.2882872118537994, -2.3989990740946867, -3.4420781758441588, -2.1215841405908717},
    {-0.716918459485209, 2.7760778061474918, 2.1219396181368553, 1.4303082678714258, 2.069400550434846, 2.1538768549723692, 1.6091861722579723, -0.9499752062481904, -1.0449352554188638, 2.683414223351957, 1.7898826723309764, 1.8374079268557106, -2.5154179234791068, -2.1911400729118125, -2.5034840190369554, 2.5806003806942703, -2.9663124114898665, 0.3337746668732584, -2.8946141321982313, 1.2581455690034105, -2.918532509887025, 0.32104554407334496, 1.9379892607574476, 1.5852981843996492, 1.3598110589028152, 1.4245347234060024, -0.052209232623963445, -2.2297732188809483, 2.2768545362621215, -1.9954179804037993, -3.5858693190745208, -2.028901606413768},
    {-0.886620400762958, 2.78623993166812, 2.044547327394966, 1.2744274546232857, 2.275489922279481, 2.3388457163898644, 1.3594986532861533, -1.156376356225636, -0.9353042373724765, 2.5832117196968336, 1.8863390775000586, 1.9250792824582499, -2.6962394411062656, -2.1789019913343086, -2.351673452834474, 2.2928330354134783, -3.1736681448361375, 0.23519277440222136, -2.9804054410295797, 1.1558085646438045, -3.2580722522863717, 0.4892736682405202, 1.8684203953138137, 1.3759207797802002, 1.7468324380289468, 1.6240240105476376, 0.07385494370785198, -1.8295264003652165, 2.2539639386562533, -1.9824862434893455, -3.6375040190431247, -1.9789867020953094},
    {-0.8226726007486235, 2.9972918159282544, 1.8537624159830293, 1.3627051127579235, 2.069712296295896, 2.022102270427163, 1.3408257879914378, -1.3230765393690895, -0.8872888242330649, 2.56033107133136, 1.8385334221392926, 1.771863234085966, -2.515596361488986, -2.6907074744991935, -2.3421531816320864, 2.508749211271276, -3.1125527824758805, 0.39611188248952484, -3.311312282173701, 1.4209907849452728, -3.3197503790156064, 0.6180669262216226, 1.9102997871631968, 1.3916939130031878, 1.4651184725337427, 1.4448160811880069, -0.14273214470612283, -2.039743221593567, 2.240290763032196, -1.7903373495140167, -3.693595053703431, -1.8285078370876942},
    {-2.170650125443235, -0.17302742718893488, -1.9845104773113542, 1.77419702951894, -1.5605523059846986, 0.04867342108934359, 1.5386200665469525, 0.5565593152775508, -2.506872544500172, 0.19601151349009252, 1.71755131665881, 1.6375901216588489, 1.426752865770604, -0.3717851065549007, -0.49594845703300294, -1.5938183461754676, -1.5788492826502925, -2.686252024024868, 1.4345364120325845, -2.1374563571704455, -0.21157607562629582, -2.652265801457935, 1.7947297274954548, -1.8057888250080467, -1.7860847234331794, 1.703042564163978, -1.742774115627258, 1.8025162177940206, -1.856457238061004, -1.546079436018844, 0.7126228776239247, -1.832665947356424},
    {-0.15232665093243034, 1.4174773969126022, -0.07558419393695473, 0.685053546117731, 0.34469888671940985, -0.22969714001957683, 0.31711940291999097, -0.0726194005191967, 0.10031511620906876, -0.22628734024669148, 0.22817207641271708, 1.0254748957001094, -0.692047226057009, 0.7407287916979701, 0.43226046745679314, 0.17242500125443375, -0.15891572783383015, 0.16554142253162493, 0.2586515275593164, -0.14264327090641415, -0.1984081322617975, 0.18823552703018237, 0.3561088813389809, -0.36790758294200493, -0.1480845239988314, 0.7918674907822278, 0.07746384484954245, 0.544679714032479, 0.546198417012686, 0.42402347528346546, 0.44482379046394244, 0.6852438324054089},
    {-2.45502103860768, -0.2750653982190704, -1.9115745023887858, 0.7114434212333408, -1.9014153631358137, -1.6196400140719922, -0.47760947405140564, -1.5171546670627978, -2.1620188536118388, -1.4783690637443134, -0.33538088105551106, 0.5940392050896225, -0.5110524156978508, -0.03475444178903469, 0.24640873786051776, -1.9117432268295327, -1.710139220134347, -2.4668310897179984, 0.37610872006777535, -2.209267044939378, -0.8823123435697912, -1.968023301441991, -0.2504866804801043, -2.3944757171782207, -1.6295463399631351, 0.9015269844376911, -2.203915248181312, 1.0081719899072714, -2.151511230331918, -0.14794654657378967, -0.294540687901868, -0.5210184116048036},
    {-1.984770580489225, 0.757969091178922, -1.7121489966584438, 0.2753085802902265, -1.9171671334443783, -1.2688499104321853, -0.6119190183693839, -1.359427870588698, -1.8341117592815335, -0.9509163479003567, -0.6634442593333565, -0.009622937763352872, -0.8022915138524356, -1.251221146332041, -0.7509451334697639, -1.6414252919965597, -2.157933944759823, -1.775466870727176, -0.8363309323364039, -1.608433031042365, -1.4569828884786957, -1.9548203179612813, 0.3215529762600061, -1.403339853163578, -1.8288994987921, 0.7771189944618077, -2.3005760048690505, 0.06310165340097579, -1.3331411673530018, -0.7034109183238445, -0.7015830147298622, -0.7369858335924552},
    {-1.5729763398404955, 1.7040377292744384, -1.0280842106439694, -1.146396854570033, -1.16428182300772, -1.7565194979349992, -1.6678716580842072, -2.020490408245693, -0.5119665390268406, -1.6076025878672515, -1.222098334869674, -0.7551994243992162, -1.2467733338363913, 0.6410768346167048, 1.4750174862568557, -0.8253565298932999, -0.8309630728920046, -0.7201121593783045, -1.07481421574874, -1.088301753281193, -0.4025676252190134, -0.4473068692576421, -1.220071870112496, -1.342899231614781, -0.08337403249478179, 0.06030181754852901, -0.9568671889314472, -1.5179026041992474, -1.2443776683402958, 1.190462290848527, 0.2468030657403255, 1.079616499766669},
    {-1.2062944685425556, 0.4767047216741978, -1.1017767569536796, -1.4890746762435632, -1.1842016449492379, -1.7799585110561793, -1.3827771413324208, -2.163093429424446, -0.5930694315229537, -1.512403155449185, -0.9106939545211606, -1.0044841824662338, -1.6991847279626626, -0.11235790281002075, 0.1885776932379081, -0.9342187391888102, -0.7102787353204995, -0.25747896508835144, -1.5171468307893963, -1.2133751973325182, -0.5898594842254442, -0.423433410324683, -0.9480741366452906, -1.3423029160382762, -0.25062628432758244, -0.4437207894024398, -0.8317920957298138, -1.333157458868741, -1.4631868782678026, 0.5310634893743925, -0.5889348638398453, 0.47771002880628843},
    {-1.7269863008012962, 0.26867848518490933, -1.278492297133784, -1.2325692733452192, -1.8649636702986372, -1.9990818048654484, -1.0278555409090446, -1.8310279263548372, -0.888967572288313, -1.8259532207657918, -1.3474008796206918, -0.743826242471627, -1.3206878131478357, 0.029985949882919295, 0.7839149900648673, -0.8237436353584795, -1.0503783951229486, -0.7228296924518786, -1.7146775136899888, -1.1191263257174495, -0.75833054113815, -1.1235488528013773, -1.1680957598227708, -1.6785611590108438, -0.3052602136427112, -0.5733584798731778, -1.1498433180749634, -1.7912039371281112, -1.4118022734077782, 0.7016594661199863, -0.9562826404602919, 0.21705222384712242},
    {-1.4546750861321232, -0.6384527508287111, -1.4226357603749253, -0.9719420904500646, -1.202798425119272, -1.7160827182593625, -1.255697464044702, -1.4440887099557853, -0.9069082147833415, -1.6147837364377813, -1.323433667559239, -0.6615027369060874, -1.0470762472497284, 0.0025345719275255605, 0.9413550748278672, -1.3102406207640462, -1.1896367576693918, -1.0805663582102245, -1.699336952457475, -1.1869954944926324, -0.6385490386010817, -1.2921265641988118, -0.7744897196122028, -1.6930066692069303, -0.41887196070046173, 0.3333547970731446, -1.2890914337411155, -1.1238977179780782, -1.0839048262056512, 1.1000935482710787, -0.8683792265697423, 0.02424911447854794},
    {-1.6865466203143091, -0.4380439551676692, -1.4784434513274214, -1.256283093968187, -0.8451046309528525, -1.717929338155929, -1.7348755520232013, -1.974181735652472, -0.9896132253709554, -1.5156943315476064, -1.5907439411454003, -1.0806988825387038, -1.8439808402446198, 0.5439768595359913, 0.6678316171896325, -1.1336822995854392, -0.8315394713918534, -0.6920375833723209, -1.420063664629833, -1.110847957706815, -0.9665411423865579, -0.823204831255436, -1.3682619154610167, -1.6879904321185555, -0.16780460211991388, -0.0001538724962421324, -1.1924553541057517, -1.2383684514404782, -1.2218273897131162, 0.9073672567219228, -0.506482515993007, 0.2899032320531521},
    {-2.207727139103787, 0.22063803031366502, -1.7044209303250224, -1.0303090582083523, -1.2248653984794, -1.5867437759867735, -1.5029719284187621, -2.1580336795326307, -1.1759209345577704, -1.1287700415439363, -1.1824710145508945, -0.3737376921196472, -1.0870152643496505, 0.5011859063348904, 1.3538201409634785, -1.4949112968960174, -0.8535488823509337, -1.127133047794363, -0.4889383674953995, -0.9894676817069532, -0.7712555455021672, -0.9942676934200319, -1.1346441612293139, -1.835716437916334, 0.18907168939586552, 0.2858423477733403, -1.2948727206524542, -0.6101551829720347, -1.5104016522780632, 0.630291172708569, 0.059207966615203445, 0.8534947073627062},
    {-1.59906388781793, -0.10480871843926004, -1.3148552700489915, -0.2889866442589297, -1.0704689293297474, -0.8376433055835576, -0.2946352032691498, -1.244581276965343, -1.3379788417271643, -0.8065965458158981, -0.1774065904253337, 0.09361039028349462, -0.16034725504541428, -0.14776843022721295, 0.4489097189249241, -1.513424318071254, -1.5478372683786583, -1.1253806437287386, -0.48838748905722623, -1.1653347813092167, -0.9964481066903962, -0.5244980051019238, -0.2842851266925955, -1.6767213868718303, -0.24376509265573748, 0.7794622089089924, -1.4258554096233549, -0.321772461453232, -1.1471914957765346, 0.15047110354707388, -0.5453028461129512, -0.32520709115682606},
    {-1.8263964874841396, 0.5395490487676048, -1.482195660692875, -1.0623395537573577, -1.4857310952211966, -1.7567008869210203, -1.0462208759792921, -1.6762804479542683, -1.6577395061721698, -1.3833022722819468, -1.054154033582472, -0.3659446905867086, -0.4464740111011111, 0.2346621885768005, 1.4246527510342735, -1.5229536188169552, -1.714376890709107, -1.4788751058455984, -0.8880670490419036, -1.9299082119989623, -0.7725179654106308, -1.409031633638964, -0.6768356207626488, -1.9644898507347377, -0.7450626533708142, 0.8468138050754055, -1.5410150090088208, -0.5482479632069412, -1.7452316371799248, 1.0157217172831616, -0.4005233016807521, -0.13024121354544854},
    {-2.3406235593644964, 0.3986798429880015, -1.7205929239350861, -1.2864522778658254, -2.1209181778454544, -1.907614236097852, -1.173875948914614, -1.8895765092441532, -1.3393835319440932, -1.8357079692762823, -1.584058943955678, -0.8126898766923357, -1.2819032480971975, -0.27555451311720935, 0.5431237971286099, -1.7610083475208005, -1.4050387030504543, -1.8364487902876616, -0.7775240298321469, -1.8672184701229717, -0.838159502039537, -1.6513707861173168, -0.668078949636961, -1.6415398660494318, -0.8520334947609844, 0.47104090625144884, -1.4261800886153748, -0.44962463449493206, -2.520472014225552, 0.9223807027790935, -0.756958868346018, -0.17346451939247676},
    {-2.438675679300811, -0.24031368717074783, -1.9693269566143767, -1.1758742431396216, -2.2238854486275432, -2.3791461836083565, -1.1927607959110709, -1.7487457162988653, -1.085983843409087, -2.11553342423274, -1.238584959200022, -0.7917204089950491, -0.8342254104803896, -0.19030820704574358, 0.6717937771857293, -1.8853778852760148, -1.038961915384161, -2.075292789777191, -0.7377841072973585, -2.198661152668278, -1.0265398339261513, -1.9080701223322436, -0.9277770001904261, -2.17242351909397, -1.0765413761116294, 0.5772307485950173, -1.7845028583156404, -0.26711673426602905, -2.1077069030669366, 0.6715055576410421, -0.37099180301416784, -0.23632858794671874},
    {-2.3185180295549417, 0.2790561383538968, -2.153693615106606, -0.41797517224220476, -1.9800513383774458, -2.365598050534905, -1.3220796145165823, -1.9348808388419427, -1.1723359404856422, -2.158254282358073, -1.153681128729432, 0.018782695289248287, -0.46186040356796193, 0.7611890256598974, 1.503873829815152, -1.7138761981890556, -1.272718225747597, -1.5573179083823567, 0.14531901117134216, -2.1858061692772686, -0.30424527688543485, -1.6459967617944817, -0.5461745629732634, -2.7611793378680782, -1.1566602014441965, 1.068068020736699, -1.6603680034794817, 0.6797582448451247, -2.2377162304995077, 1.1713477246909547, 0.5645069053944052, 0.6373012959447392},
    {-2.8036190198637025, 0.2718323091348071, -2.0604485180821883, -0.6747229236497494, -1.943676263128023, -1.8227420142707482, -1.098840428312292, -2.0296615469822887, -2.1396080416830374, -1.6526303653932228, -0.9371592975516092, -0.08345823119584407, -1.2609203745243267, 0.15337861725613988, 0.2887767110355585, -1.8056573197599874, -1.919438836681483, -2.0290990464778313, -0.9642806526702765, -2.144775090192161, -1.1348677046042985, -2.1005915237946446, -0.4831350545403565, -2.518346581447837, -1.1706653086407603, 0.45901633758614047, -2.1526843442980916, -0.2481539385156102, -2.212661111298205, 0.48786404721590193, -0.4264619876595248, 0.13933863612189262},
    {-2.874682698270515, -0.08489997194053545, -2.0529014262304397, -0.6065739165929291, -1.7602955898363988, -1.9204923341652027, -1.0486109186704977, -1.5414998703587277, -1.9948797468226698, -1.6799769831757427, -0.9789527212299292, -0.3155965321774578, -1.5711650342918189, -0.4805030022033974, 0.3048079968110811, -1.9258742776805744, -1.896754305763169, -1.9628822845858067, -1.7089154322846367, -2.3275847966865895, -1.1184031859430414, -1.8252288732093236, -0.7528346193601749, -2.40111497758555, -1.1495165944660357, 0.5270703143856641, -2.0672815261271524, -0.8425395821926076, -2.1605056596494743, 0.524899271608431, -1.0288383018765983, -0.5441278765541846},
    {-3.008484286387994, 0.7153159074032006, -1.932238805426701, -0.44728586730757514, -1.988865104977745, -1.8159892478631012, -0.8866430154903688, -2.1024099333648634, -1.9860410010523584, -1.3171919348762222, -0.5799136210182764, -0.1455423150834559, -1.173538484134368, -0.04500042563784858, 0.4800051092575209, -1.8326742637928275, -1.9468841358405178, -2.283127782388238, -1.2323047399098932, -2.172921322182649, -1.2989792372059756, -2.143101425409106, -0.5189231338732424, -2.7470228423815635, -1.2036869527885716, 0.8918451381721837, -2.1562956361582004, -0.2785812754098392, -1.864416380734314, 0.23978395975270028, -0.42158849685371064, -0.19770845340914583},
    {-2.6776694065509283, 0.8315360147974094, -1.7631333018055624, -0.07112475642341963, -2.083130433884225, -1.921436163003104, -0.7665270314383101, -1.5105601016158947, -2.194354141004683, -1.7833766499036843, -0.2620479997286619, -0.5616017776940916, -1.0289532850919816, -0.10396359083916996, 0.27946848487182135, -1.9433690777489068, -1.628351910896458, -2.1483001768943994, -0.827751143733487, -2.3671686448219584, -1.2718169211847907, -1.866584678238594, 0.007980788693298695, -2.483513037492082, -1.2304613312989838, 1.2580051597253568, -2.415842641236723, 0.08971017197204043, -1.6404310456314475, -0.20494036598006615, -0.8930512421604249, -0.15697681776512462},
    {-2.5211654655745748, 0.11833252908184083, -2.5759617120780303, -0.7553879591267917, -2.410779872480327, -2.0566495824290976, -1.4675165022263588, -2.290290955174768, -2.227830338344769, -2.1777398019556626, -1.3772101127259704, -0.6586062216931745, -1.79876420131622, -0.4346584386597484, 0.7208267112033422, -2.3477337971043726, -2.1199630256038846, -2.3980126049704267, -1.4401757065426661, -2.563957580006718, -1.3588374895400372, -2.1531015950540957, -0.874208968324145, -2.510326092270128, -1.3467730297761598, 0.4823439961943045, -2.4763924764183667, -0.22157890821714962, -2.5755419402875948, 0.28218348969295964, -1.0373479000510952, -0.4709135492027273},
    {-3.0019409068993492, 0.9528630444902628, -1.9303337999719978, -0.3325041181251115, -1.995454206804023, -2.2371928862203783, -1.55454933870497, -2.230150367370431, -2.2004527676775254, -2.2465769883769044, -0.6481422110955491, -0.26747353782322614, -2.0125544224729284, 0.10544934564689551, 0.8191669068332789, -1.9740611298018513, -1.842867362544067, -2.447928449299891, -1.0861728785479094, -2.532957638622452, -0.7154002570901155, -2.4192601195569976, -0.6457683617459173, -2.7982586441054247, -1.026538365601287, 0.4255809348054494, -2.534063761958482, 0.14217063074773428, -2.3801217696640693, 0.29033410521956216, -0.6474614628903145, -0.331461703784694},
    {-3.637562267842333, 1.8781393387691137, -2.5167266750561956, 0.8622606527728217, -2.601674164159219, -2.4102516813864154, -1.0585842585405993, -2.0856980717339, -2.761149637074853, -2.01930446342693, 0.45762414235735704, 1.1016476041429355, -0.3245485910970725, 0.9209260602497221, 1.6752143097345682, -2.330399689273615, -1.6964934579021518, -2.6976995910958963, 0.10852363610738668, -3.066354206934516, -0.12924801418648982, -2.4958356218917372, 0.6799020107792101, -3.5877780986940793, -1.6021330292747986, 1.8972982384025627, -2.7263816589854803, 0.9984443597747786, -2.6094547698815482, 0.824218406229123, 0.36235228190854424, 0.5344135918279964},
    {-3.677921579741306, 2.1260085929631614, -2.6103741972900742, 2.096297205604165, -2.774026845817038, -1.7129597909789704, 0.5385896654563939, -0.7505209060800998, -3.0836071477512195, -1.3022640051463041, 1.803315133588948, 2.155441867034675, 0.7017980439410965, 1.004339528258879, 1.373105780789783, -2.1365564905264667, -1.6810500272851276, -3.4340182490933686, 0.7398202890295554, -3.086891809501955, -0.15645080981093207, -2.9365809332861947, 1.89144946845422, -3.4778322780897106, -1.8208523317554142, 2.554799003905169, -3.100083643468363, 2.348462754271772, -2.1945579034973015, 0.18017609443009514, 1.0051386885548295, 0.3723597141452839},
    {-3.8607422944270673, 1.0763799317230083, -2.8101847961024453, 1.3306495802769582, -2.6458875530429364, -2.2099014873222296, -0.2316023579908956, -1.6198103951447813, -2.869220148906032, -1.8889706033467892, 0.4500645728446274, 1.3367843284581176, -0.08442598753872868, 0.218682220166039, 0.6773007869563648, -2.224190790040467, -2.0195997599265865, -3.2828580065916215, 0.12636350838610855, -3.302892655680158, -0.4167011014329834, -2.9337273815582603, 0.9334922869975701, -3.6986177282473336, -2.106704511255657, 2.0781080120801274, -2.804363944009442, 1.8099389143028923, -2.6474271671109926, -0.0037774867479578055, 0.46621638723722714, 0.0821166764492257},
    {-3.3221492038114713, 0.7710383048976313, -2.689662599048222, 0.060827150613282914, -2.4263230809597314, -2.3431080418547205, -1.5243236285128994, -2.3693934120298175, -2.547698588336061, -2.4268216254632136, -0.476910916955388, 0.5226328527627288, -1.0981478437708996, 0.043163030926449096, 0.6267711377589683, -2.3825339470297093, -2.16802429184569, -2.7177856970751306, -1.157067750135008, -3.5586786094850904, -1.2720560912182641, -3.0445626019605236, 0.09512236467032441, -3.3446386133740504, -1.8126974005414174, 1.3926117893415322, -3.056409372657395, 0.3816606052034897, -2.756397715719964, 0.06028602964336528, -0.346217408371136, -0.19124627459495452},
    {-3.7241269867513185, 1.400007587419865, -2.7897495856502514, 1.1799201175752196, -3.0277845817369546, -2.11402121058272, -0.31380615098758297, -1.4717367460403845, -3.287128210632167, -1.6440200334484307, 0.643828181359691, 1.5897031576466634, -0.056049215811156024, 0.22570760760887598, 0.9338116014160753, -2.2536584930616845, -2.2242877524271614, -3.2185064475989984, 0.06239838589369144, -3.5824745770638606, -0.8828302318330515, -3.236203629467087, 1.1831887587106216, -3.4187262583585634, -1.9694176199357742, 2.147937441809442, -3.142808406181151, 1.6209804401037649, -2.763714832634022, -0.2599786799239114, -0.07277424350642785, -0.5921987432780996},
    {-4.025101081293181, 1.0780455744714157, -3.02370420529973, 1.188751874029105, -2.792842383347216, -2.058310584912748, 0.05086172502384518, -1.285120569006729, -2.988181592802555, -1.4755705791886986, 0.7331405164972712, 1.4005244256229885, 0.3490966377088178, 0.9200310640854127, 0.94492135430747, -2.5589785991054104, -2.150493552222966, -3.434415234536053, 0.46769373265670316, -3.3984432729357557, -0.3810015068531337, -3.370677543698308, 1.1364391392384534, -3.7719200000454296, -2.4863962862198985, 1.73531461084096, -2.921935446432782, 1.523230755999429, -3.17075312906142, -0.45155575904865786, 0.7640629824884557, -0.47638705806204856},
    {-3.4883173738952116, 1.0016088031084647, -2.998884042377204, 0.9482967516601736, -3.142872418126756, -2.2870950675846573, -0.34178697756179477, -1.7139482101760495, -3.379466720989995, -2.0070799401525683, 0.4114594554353932, 1.2082305544675185, -0.07628677420579894, 0.20493281977266373, 1.1802524009831463, -2.742463658979647, -1.840453788830263, -3.474358557724623, 0.5254056165987714, -3.478696619023092, -0.7076749251849654, -3.260585004494451, 0.9552797936660979, -3.5012225386745564, -2.0529086673122254, 1.7270275895096754, -3.131060366315175, 1.4172161743396616, -3.2334615883790505, -0.19643751060443843, 0.5254001398354051, -0.3185707104943789},
    {-3.906701796453328, 1.3524332505165642, -3.1941197451288694, 1.3708465099683946, -3.01914762165548, -2.0885859901965795, -0.2735883991911632, -1.3567328455551948, -3.2675649099152317, -1.6452060147506506, 1.045259727693528, 1.7141887288637718, -0.007297737055414207, 0.24634958401108853, 1.2923109865834983, -2.735394977197965, -2.3909115896235402, -3.208069233836361, 0.2103713247088914, -3.5529936074142996, -1.089549109248076, -3.3383842924839353, 1.118102806627734, -3.3494180203361426, -2.083033559750815, 2.29151923855458, -3.1952370592263866, 1.7706495551719623, -2.751305311255597, 0.03315444374603275, 0.37530420544529086, -0.33509400531277456},
    {-3.750042631537003, 1.2253443671645972, -3.147879987458518, 1.9242689691732848, -2.7806308758892078, -2.063080019393823, 0.4190148094147589, -1.3301732253722205, -3.1254222466491868, -1.4395822001283594, 1.2123650613991184, 1.911423899810106, 0.35024230907970216, 0.49755790815814793, 0.8228012168234856, -2.7196264665872225, -1.8974391979567378, -3.539304812714524, 0.33635319382628426, -3.4232066344861134, -0.5785333745019993, -3.5713000301007147, 1.2526736410841137, -3.6616187155240922, -2.2873078162817833, 2.3923514350806414, -3.271424450069181, 2.05736864530281, -2.8542243186330776, -0.030899102148191627, 0.8909994246585421, -0.4755601570772555}
};

static const float b1[32] = {4.50765975155558, 4.45604929741882, 4.384544679945351, 4.531940294307595, 4.354849085978022, 4.324605740956623, 4.408532296780692, 4.612947672662587, 4.129403644010933, 4.43739237376197, 4.392486547889418, 4.470704321593158, 4.63166313277211, 4.567094808731431, 4.697268277062937, 4.3647167460724505, 4.55175650100912, 4.172931206827913, 4.633857226271641, 4.338692547605556, 4.48034642958094, 4.290746766427848, 4.503803930481092, 4.437537859524741, 4.291071361014019, 4.5375903855879285, 4.188072233159387, 4.709902696605454, 4.408243472015655, 4.332904614688251, 4.792981748540585, 4.303633860458826};

static const float w2[32][16] = {
    {3.847532905939559, 4.263864457489643, 4.007641986857218, 4.0303383776129085, 3.997324523660779, 3.6955973731290843, 3.839765771621052, 3.7133102410434495, 3.3273893241075423, 3.5195238486079634, 3.7010463365515855, 3.717846691159994, 3.8436208631071134, 4.045455679900392, 4.034705463194698, -0.03139186511075198},
    {4.144385466970191, 4.303296122561436, 4.145363134544088, 3.6678682943719334, 3.903609260488098, 3.641100767174772, 3.9636056313859984, 3.764770396520374, 3.0075997299628314, 3.512526891483579, 3.349646183570674, 3.8805637020397716, 3.87471909909527, 4.004651671072163, 4.151972920989003, -0.13897432475139584},
    {3.8299494486824828, 3.6455523862666253, 3.677587440852624, 3.668001694513933, 3.935903184909449, 3.8656226349540272, 3.929507461318651, 3.511950124661535, 3.1365532939531557, 3.31998126886032, 3.1299455025114096, 3.7664065101037827, 3.983144252314355, 3.827481554576466, 3.3997112994154577, 0.0241009225090623},
    {3.6324263658826275, 3.9359017715101245, 3.8118151995488097, 3.6603132027698297, 3.770083140649633, 4.21008739139549, 4.053633827742736, 3.690248289319752, 2.8335469263055413, 3.6238945137386867, 3.0125445854430457, 3.771733341122244, 4.533644051516856, 3.9383520621964796, 4.048278320683623, -0.12943795782848766},
    {4.090200359084971, 3.9272424316957166, 4.125195920324307, 3.8776604569247914, 3.461829994934154, 3.898667235537397, 3.8928813489611165, 4.125729198574071, 3.034796948908633, 3.407499997021929, 4.030306698270163, 3.910492784849003, 3.7043864127930513, 4.16094112681729, 4.435818842372382, -0.11659553797600844},
    {4.44192163489598, 4.124744835579643, 4.135944624537962, 4.400443352776913, 4.412871319568475, 4.164566255333479, 4.055708268046054, 4.57662747342079, 3.2527559391655303, 3.8416362612514265, 3.624929570858268, 4.250041786071107, 4.06314870614925, 3.7528983165667413, 3.923031257565066, 0.15788847949138146},
    {3.697046124804166, 4.231877556522152, 4.193502621024893, 4.209225268138214, 4.276251265610845, 4.209952006754157, 3.769246249692583, 3.9640095788634566, 2.8976346975266773, 3.524956774372959, 3.200634936192289, 3.802879423468734, 4.176803376783289, 4.135390501747475, 4.286320696645323, 0.09859867113087491},
    {3.7510386041302812, 4.569558288762093, 4.205963797367296, 3.978317580005153, 4.5309347161840465, 4.164295764519579, 3.5760221383680406, 3.5237439087095064, 3.523489367086179, 3.532269840956462, 3.335877764525553, 4.221905139637926, 4.071089842954968, 4.119154484930197, 4.405880768433621, -0.18454827882522537},
    {3.9701933158342206, 3.584810027284011, 3.4093494471074988, 3.97313915609392, 3.6062983604248746, 3.849899743968215, 3.560580307415045, 3.237129750759979, 3.061729570248006, 3.4814919884160287, 3.089339743539763, 3.802230833043002, 4.052109129079551, 3.571803254316789, 3.532550355118924, 0.3051757624945899},
    {4.321300093890843, 4.188073744675483, 3.979245535309176, 3.8140681484890067, 3.874704950520308, 4.263332182885543, 4.1850954316216225, 3.842998896705223, 3.6708240722376693, 3.448184866540901, 3.559069673607038, 4.025081723361931, 4.168790220809966, 4.0598872438933515, 4.212702889703842, -0.2714631378002962},
    {4.414316607482367, 3.743705157927398, 4.465152197287234, 4.29393183835214, 4.132592295978729, 4.107745878843504, 4.048035682961899, 3.306382777457098, 2.663471875596419, 3.612970019902009, 3.5593181565145873, 3.803380606463277, 3.92402930174366, 4.145218399099864, 4.384610260759559, -0.15997516237304132},
    {3.7501985703327048, 4.303040841454769, 3.6163146650086246, 3.7983998143088047, 3.855590657327852, 3.8142951682782833, 4.573235929133976, 3.4826329422274145, 2.723321970872158, 3.2358048140011704, 3.8118272655343155, 4.050780330813054, 3.9249742938975545, 3.857908110256592, 3.980019384318811, 0.02751017982758108},
    {4.205569952815047, 4.158404492714508, 4.19503615736551, 4.378094376917145, 4.650922946683324, 4.60831540037455, 3.859708479320911, 4.266227920828714, 3.276702585827698, 3.84311543874459, 3.7105182576590754, 4.312354668385601, 4.369156433611463, 4.4167234527464805, 4.28589983358459, -0.19282845530436468},
    {3.778746658295354, 4.250018729199714, 3.863951416247537, 3.544163512432748, 3.974845744104023, 3.767416971413798, 4.078585484755312, 3.8597154206774875, 3.396862899664674, 3.452629402103673, 3.3029495884741245, 3.812761559035231, 4.11003248912581, 4.021462146763047, 3.5425834813677604, 0.036704506691659755},
    {3.9267159492966357, 3.721484009418826, 4.003908384629715, 4.037371394682695, 3.7193681341363556, 3.8529671041777678, 3.5501706373115267, 3.426838637785654, 3.085109253671131, 3.6866423227711316, 3.108157911146827, 3.6450187565737386, 3.916360028080033, 4.061207227147376, 4.139554484554445, -0.2131241635590024},
    {4.161546041056278, 3.832807360554807, 3.7211065560915904, 3.968038059363775, 3.928129601675774, 4.3010939396796, 3.8274779979528843, 3.5399165643748853, 3.379262694175344, 3.471226690355638, 3.628024511473768, 3.851093499203554, 4.080331610420906, 4.08632825326786, 4.046968908196909, -0.40615055160628344},
    {3.963220521528692, 4.248847757727124, 3.7751682474920205, 4.154106196619393, 3.541404383552292, 3.5439774778441704, 4.125129917295786, 3.2281761730680594, 3.0856033183728067, 3.8996692616195827, 3.7969905104502977, 3.9294362193379224, 3.902987425613229, 3.7833033601628787, 4.656034659246768, -0.44289944896161104},
    {3.323416355836068, 4.323504086082808, 3.523180902022493, 3.410799779202463, 3.946936920473118, 3.70707425022413, 3.4339092312824233, 3.634652060965654, 3.137679942179786, 3.0727752396772328, 3.5846609802132474, 3.705970865931556, 3.649638766797112, 3.487244880276742, 3.7280230068105347, 0.21471457764342233},
    {4.2880286397409515, 4.852295888565423, 4.30621660109655, 4.326072219673409, 4.616364849152971, 4.186592251639511, 3.9646644105658435, 3.8601048385292382, 3.4467456558628613, 3.9452320125814517, 4.005706610082523, 4.683505300278633, 4.5761730678310615, 3.9835316047499205, 4.510795001475873, 0.08261316387776088},
    {4.180243491244026, 3.7859454085911683, 3.8334845235345263, 4.2187940015773275, 3.5570414030755826, 4.171200968476269, 3.747528108435286, 3.9756664124160905, 3.4121430591917585, 4.120179563143779, 3.331552573730356, 4.246689690449392, 3.7126811376291506, 3.6856008965182503, 3.9508055029852764, -0.18655464732029914},
    {4.239328638196585, 3.9052501726965474, 4.135019182060388, 4.223874910584494, 4.410705316591378, 3.9322030622626096, 4.343112639479557, 3.9999908448177512, 3.2386200222348, 3.380141174529539, 3.7025109944367616, 4.455328958099157, 4.325722411396557, 4.102425598596891, 4.104885342054543, 0.3206653587691233},
    {3.312377297420563, 3.553157468937768, 3.496611361040503, 3.7298388781361624, 3.8589929487598766, 3.17263497910964, 3.386523726405627, 2.950515104632904, 3.11239102871806, 3.281624181446397, 2.9729880880664314, 3.8263110419380126, 3.67441925814903, 3.898333584265254, 3.290227672031791, -0.3289120354753092},
    {3.55057597355257, 4.030173788197045, 4.126297981243097, 3.921622916926876, 4.068005898329311, 3.7584968631226228, 4.072854767729562, 3.4599260077034897, 2.870533418798069, 3.3360517325344388, 3.112195395166962, 3.7230171937918493, 3.710074220777769, 4.156731642804639, 4.065573329831333, 0.13186778943234806},
    {4.297816993204398, 4.128242151504417, 4.114134341686436, 4.139101146112791, 3.7403364987156635, 4.295522355747013, 4.2449833539554325, 3.8720853257687726, 3.148341236150198, 3.230357524476715, 3.6864176240124227, 3.9326084455784, 3.508939839682929, 3.9768712770384327, 4.044744797567168, -0.011236077006263697},
    {3.549010652061085, 3.727549231966027, 3.233700665339197, 3.498439003925187, 3.589355321598154, 3.5317176696256163, 3.438150433095359, 3.5043971030308936, 2.7206988388955966, 3.3690655906234013, 3.1247904209792816, 3.4241003476056973, 3.970906271150399, 3.8743332666356487, 3.496698485593484, -0.22976568322591048},
    {4.105976668339365, 3.9888012330210922, 3.8446249062460396, 4.437810151496376, 4.296477922755813, 4.260385017097674, 3.7258867942051777, 3.6854310542157056, 3.172150327819445, 3.5619305041929388, 3.7006264316586583, 3.873820916677795, 4.175794291064017, 4.047983042004299, 3.621920102795509, -0.10144031739774352},
    {3.9710978918819086, 3.8349459050674923, 3.728004426382806, 3.620576087893114, 3.637031504242152, 3.7995856751601544, 3.509204141447079, 3.4791618817622347, 2.856627373034588, 3.2337881929011223, 3.3767228237589, 3.779524010954495, 3.8299588046191064, 3.7807668531978735, 3.796787139847719, 0.26477697230589886},
    {3.7485698094969457, 4.3715479818674945, 4.239760002304339, 4.063243405501962, 4.25818617380718, 4.271032027106535, 3.870971190239578, 4.134302298303357, 3.3712447028747223, 3.683493509474611, 3.5464088309443165, 3.6060241361371443, 4.291884877129996, 4.172906389941903, 4.672837944710136, -0.16068742978895245},
    {4.102826770982016, 4.367355426386031, 4.204582462026955, 3.939514454691636, 4.129285919587273, 3.723481005368785, 4.068810195291822, 4.010317947857128, 3.3253602949732217, 3.095071310117282, 3.9131282558468765, 4.338730457919039, 4.408985447531701, 4.108859567263427, 3.9181977987142362, 0.3299244577137329},
    {3.931670740748277, 3.924448814321771, 3.660491533372798, 3.590811617358747, 3.4721690227898274, 3.896966350254476, 3.45149148275138, 3.4143387010700095, 3.0788863549904257, 3.094950238941954, 3.6324134906734065, 3.667932044641172, 3.977112727141677, 3.647458807053516, 4.307658031815004, 0.07596914697418349},
    {3.86548149397571, 3.9986161801613616, 3.8573558772913987, 4.395110432382357, 4.320761015405726, 3.927940815935654, 4.206027140038311, 3.6932466297273994, 3.2452602924492817, 3.567623958937681, 3.7439993691514175, 4.016928844508648, 4.474753196777925, 4.157939592892083, 4.413584160748121, -0.25108725275992166},
    {4.088733669211073, 3.6606142076999952, 3.649726068627861, 4.087457739224654, 3.85710455255697, 3.8564817930388124, 3.6514193752687207, 3.586298563090649, 3.2969113073211664, 3.536915418921306, 3.210314919573408, 4.002672645999862, 4.07313344949877, 3.458935308678076, 4.160405884022846, 0.042122169065972}
};

static const float b2[16] = {3.582797460347794, 3.538766449352581, 3.736033898617168, 3.7041939118998357, 3.6104460774388736, 3.6176474810455277, 3.4618639384605507, 3.6684022970056454, 3.6907062917144904, 3.848695451591793, 3.66969180817639, 3.689460612135654, 3.682750967630213, 3.6084356267795408, 3.7284599297202017, -0.06493235667663105};

static const float w3[16][12] = {
    {-2.6442157236316834, -3.1259196765833046, -3.213876611479183, -2.8574685722107294, -3.2187448064453608, -3.3343919791374725, -2.70420748692453, -2.775881538691096, -2.736683358644981, -2.4564121734573554, -3.0112883275555404, -3.3744866638945483},
    {-3.048369910631937, -2.6034274922519467, -3.012011818982946, -2.8309268098597578, -3.2733843255327573, -3.559776227662253, -2.7310146614785187, -3.0950951168142504, -3.3237048944880296, -2.4659272964126515, -3.0794004459073894, -2.7101195037996195},
    {-2.57163177904303, -2.786216223015416, -3.2303082190083034, -3.293597633154102, -2.910401619359624, -3.263695169059467, -3.3415159711744735, -2.8499448535298657, -2.649591042683514, -3.3662737955099904, -3.4739321157962504, -3.4038599829177176},
    {-3.1104119893848146, -3.7015625763866344, -2.9355552640749223, -3.5904626673726936, -2.8419473030722293, -3.202118966487604, -2.6914955673375975, -2.921207207664968, -3.0509613133290836, -2.6236535170251787, -3.2152946431990093, -3.1497575440973526},
    {-3.1385793232554833, -3.1399831545519112, -2.8676303346165444, -3.309060452447442, -3.056720701578728, -2.9346816824611657, -2.871065539236055, -3.929011659449482, -3.21086204188519, -3.4202962845601976, -2.3857976918816854, -2.539984420218546},
    {-3.756634461335291, -3.3103635074468647, -3.2560180024521266, -2.540107320612933, -3.1112872370310387, -2.8440251803755703, -2.827007234705597, -3.1371472734001404, -3.2660739565483676, -3.145454556862686, -2.8400511244306483, -2.9578899348759498},
    {-3.0984014535468805, -3.1706968072798345, -3.1603003660337596, -3.185059051225107, -3.4993331671567973, -2.8418663361153813, -2.8619228635658924, -2.817426135809934, -2.974028212364851, -3.0950515476916327, -2.3575868002383285, -2.905153823650495},
    {-2.737547732900842, -3.5924014687406647, -2.9729236582351213, -3.034160312620351, -2.8624206114686004, -2.3039694116429974, -2.937979891290141, -3.0629508120049436, -3.3367258381058096, -3.063601616344104, -2.370217061598475, -2.974451404838771},
    {-2.483618726832188, -2.4933462971193783, -2.5979945789133376, -2.473999119926673, -2.7684624548648933, -1.9310458554700094, -1.9120928665214028, -2.527583480114824, -2.706547614803674, -2.1773395201246246, -2.7538571754856416, -2.1686994560735724},
    {-2.5854254537594814, -2.9973986823308616, -2.779590580503925, -2.6214689679658787, -3.0482880029890813, -3.0635823299385185, -2.248464518035879, -3.1225282122147644, -3.074396847360937, -3.309822207834762, -2.7307170693322296, -2.4452371422414827},
    {-2.621842732870823, -3.0896670524311456, -2.3593462199932658, -3.111515662398517, -2.4740367404989576, -2.7963993706678094, -3.124413070053146, -2.876028538821703, -2.148926340380048, -3.0846680481675834, -3.5352848992867267, -2.748450237196127},
    {-3.217971814577465, -2.590522192307097, -2.9948270407781097, -3.077760662224068, -2.9994400751440433, -3.845892170865607, -3.49283849545041, -2.7908146628848693, -3.519620770454498, -2.621918823322279, -3.4045869064379293, -3.0277405211730692},
    {-3.1294104688572344, -2.2919595595630136, -3.1555933358886636, -3.0195675825070305, -3.101293499125785, -2.7421851540750324, -3.504845294539282, -3.1023730446042963, -2.9790925291099306, -2.9337466934334384, -3.047801108374419, -3.390358630648671},
    {-3.4016037788481808, -3.0303191767865165, -2.904466220151563, -3.1898079148242764, -2.9678096117752, -3.097270502583343, -3.545621365585726, -2.9709637211908033, -2.9769392138589397, -3.36086362614596, -3.066711322550097, -3.53328426546685},
    {-3.063324635786273, -2.8710737959549686, -3.2631559257472773, -2.582072984710384, -2.7560178870506173, -2.7991993264213026, -3.715988679333278, -2.6951656546071203, -2.879346255794773, -3.5865918874879745, -3.505893377061985, -3.224531814571043},
    {0.11447714793699605, 0.3043380747470922, 0.4708689038081082, -0.08364344243897309, 0.2177022866971217, -0.056786115453111574, 0.5880611949728354, 0.025208646966704402, -0.24587363071032697, 0.7265021882151346, 0.7498645018009046, -0.14777755345064983}
};

static const float b3[12] = {-1.698759618720226, -1.1548532568748062, -1.3343135487277946, -1.479348468607625, -1.140630890381667, -1.1821980662012825, -1.489039105135525, -1.796306962817018, -1.393115813137656, -1.5980839509583495, -1.4990066793371497, -1.2393196317406256};

    // Input Layer 
    float z1[32];
    for (int i = 0; i < 32; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[16];
    for (int i = 0; i < 16; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 32; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Output Layer
    float z3[12];
    for (int k = 0; k < 12; k++)
    {
        z3[k] = b3[k];
        for (int j = 0; j < 16; j++)
        {
            z3[k] += z2[j] * w3[j][k];
        }
    }
    softmax(z3, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
