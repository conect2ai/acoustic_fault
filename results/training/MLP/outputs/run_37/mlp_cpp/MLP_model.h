#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][64] = {
    {0.315483498843713, -0.1984800705903489, -0.01924916114314165, -0.9772050098266851, -0.7114748753652983, -0.009796464108421693, 0.23680450600025474, -0.9881759583428393, 0.2660714442388357, -0.08195854163737577, 0.6005918899426426, 0.11040801860165705, -0.5854548363526221, 0.6849790092290959, -0.5705037785461946, -0.684686692853573, -0.6162114368080144, -0.9410989177202594, 0.09820517754271761, -0.1208160127802869, 0.8962740834230899, -0.7729736967378582, -0.4876998641592318, -1.0696286821880217, -0.6180121134072613, -0.9992086635961941, -0.9005709586839745, 0.192815906158838, -0.3417203630622841, -1.0536157594967663, -0.27475576305844496, 0.08521388983691985, -0.7554944471202318, -0.24128631405773907, -1.2660136176898529, 0.4112415862967008, 0.32156338613339225, -0.056409342786862965, -1.0531293553548646, -1.112960552992019, -0.5930807841481638, 0.8628379193264849, -1.413474226857334, 0.404925420186608, -0.6895944273379578, -1.0108767211998457, -0.7287542798064021, -0.5305737992013321, -0.5146417318750889, 0.19896416949121515, -0.5090581671431779, 0.7501372335723872, -0.6419204106367853, -0.6640221770156908, 0.3771635064247192, 0.8916177468398923, -0.5008580925407977, -0.5609046482015694, -0.2803513324698273, -1.3803982271260367, 0.9702701103368475, -0.031562630339666005, -0.5931633254106647, -1.0552037306400484},
    {0.9471659363123065, -1.1093459182760321, 0.10813373780176268, -0.04786631006356691, 0.9283316051040894, 1.2007200112125198, -0.6101577254401463, -0.427199991568296, 1.3006552643428444, -1.1860025562760381, -0.09663405179925517, -0.09003748284636799, -0.0897062600935409, -1.0583477467366444, -0.1752564812430678, -0.9392890742838562, -0.8793491322118995, -0.33368562485693, 0.10658509109500834, 0.4986847863626731, -0.6013797390891304, 1.168455481157959, 0.44866967349847464, 0.6181583401148971, -1.0812410750018244, 1.253626959105199, 0.9702956149322813, -0.27092387431176235, -0.042293417355305736, -0.06980417404300285, -1.0549040776076934, 0.4599449973206897, 0.45984281652836495, 0.8398383480328059, -0.42659729863488655, 0.05206992932224951, 0.012989944527425827, -0.5619327945459084, 0.22137101386271782, 0.35885851584244494, 0.27148184042638696, 0.8576557679456432, 0.7984890362240669, -1.406884762054011, 0.8648766186526191, 0.8396149417233165, -0.08588852386359008, 0.9645743976352101, 0.11390825742765844, -1.0021128258860528, 0.5825588854735206, -0.6222734449178918, -0.22051335050166526, -1.1466215477340613, -0.5057417740668914, -1.1037151880947356, 0.32500838896231615, 0.3800457370464844, -1.0926740592092183, 0.7450385187735343, 0.8962338321290659, -0.9136035191232502, 1.3047059981055766, -1.0716354107854844},
    {1.128468449748603, 0.6939885159783921, 0.24434280197176647, -0.812615938443971, 0.010370176491504238, 1.0600422031092465, -0.00033639082682114025, 1.1616236404291531, 0.061961242516098275, -1.2021228978139076, 0.293247632537876, 1.3173475715371827, -0.9514332940671324, 1.0076202342283236, -1.0018047075937284, -0.6423952193297823, -0.3071430825582039, 0.39866660845260155, 0.02594582087430419, -0.26668670409663014, -0.1978701814287261, 0.5995050268000418, 0.5139066609816189, 0.18301658144752786, 1.2410177013568615, 0.6854226512931882, 0.3672568890725366, -0.7925965577213478, 0.7355136711942566, 0.14950212661156223, 0.8921886316497001, -0.13076450411775825, 0.5758163040564581, 0.19668292827000716, -0.900099374583887, -0.6743943306389828, -0.46676847625067314, -0.21951387392693425, 1.1929669615424414, -0.17366136996448764, 1.3268229456175433, 0.005195981262627951, -0.29893271671652083, -0.17002991463602685, 0.5944468211866564, -0.47314101169534933, -0.8610944744394178, 0.6849709591598334, -0.16206514996405813, 0.42489696869831955, -1.0217307881452882, -0.13096514533811765, -0.9553842409356615, -0.3936356953300563, -0.14385859231604478, -0.0873779739988461, -0.9438433885744784, 0.44905834542534834, -0.32965287784119307, 1.1044081356963784, -1.181221520719482, -0.28201008289529933, -0.37813699411990626, 0.849871794602749},
    {0.7048716464814453, 0.09662489095517697, 0.4264334193215072, 0.9943115042062957, 0.5568294540279035, -0.3333404380138839, 0.3763910225571775, 1.1639584517341273, 0.1749108174524113, -0.5709328291437292, -0.21900421428840555, 1.0405807659276742, -0.7569926046006108, -0.15697285190668436, 0.5862060166234507, -0.3057608056769625, 1.3107589620627347, -0.6225614449241349, 0.5283486627180672, 0.3119927311895124, -0.6812689130682426, -0.5352943452154879, -0.234926775314662, -0.11379801483259397, 1.3381758104156833, -0.3580578723197204, -0.4199183382686642, 0.9363869042757595, -0.43024465585676097, -0.7943500419791443, 1.4088038572596255, 0.5629656126202547, -0.4770387945162094, -0.030188992576867635, 0.6039693934044755, -0.6941636703264729, -0.09464793000614793, 1.1268703549279593, -0.4773616844094131, 1.4919495891931618, 0.4152312801186399, 0.3391741242188507, -0.15875636078848, -0.5141341495457126, -0.2728033221871581, 0.29517949746081235, -0.5405302888098387, 0.48118789407763546, -0.048828720229058487, 0.5682743358396675, 0.06303371965839108, 0.627848255725137, -0.9517328732528085, 1.0993923990445307, 1.4879602483765428, -0.5188746872640875, -0.7865770149750504, 0.7308456300725648, -0.7868297225421351, 0.7934665856653916, 0.3832256017732891, 0.052082087120852244, 0.7726497020474296, 0.8868326360919433},
    {0.7907563971129741, 1.4213831194178967, -0.6044741320148577, 0.3133975397242081, -0.14786418511746194, -0.3395784635550766, 0.7377028273878624, 1.3389343515822794, 0.6965376237316941, -0.5352135008683256, 0.5467317833613322, -0.6646428362060746, -0.8233083308354788, 1.303108164668963, -0.9420658281531489, -0.8764036400057843, -0.5911955144534917, -0.3989949842670655, -0.8355965577558158, 1.016164270542423, 0.7563639022657099, -0.11068245919387561, 0.6574688310262629, -0.2794229893583274, -0.003756056869361544, -1.0550992428433679, -0.8602895660041199, 1.5189402907267457, 0.31325441366356066, 1.1343467119694846, 0.8401629811051642, 0.5168143599099153, -1.1576418256901921, 0.8513358347341955, 0.4072111183954296, 0.40414328998629007, -0.02140221951876928, 0.8830503518007867, -0.25991487090578014, 0.5053896467251534, 1.0660439425876806, -0.41343244552987224, -0.8080992371462564, 0.48716401858100666, -0.1996793344023867, -0.5562232404801587, 0.9281602579068854, -0.17408521908790764, -0.588947488100862, 1.1124382534179735, -0.3806128445778633, -0.8707335858468557, 0.1001285465534054, 0.520955858020048, -0.8289987368946563, -0.05954766222303892, 0.869490716989189, 0.7527750361881805, 0.08788875290475316, 1.4251013288307026, -0.3893176262741795, -0.1642453989102562, -0.7127864386317218, 0.2861107315874102},
    {0.932899196800916, -0.1361398778070829, 0.6137418689730301, -0.45704671240559647, 0.9510096392803044, -0.27201455958337284, -0.8566869108254905, 0.6518444788832574, -0.2914507687135842, -0.35406378520331705, -0.8287376287207358, 0.3356248509326186, -1.0207060466776092, 0.7266815180184873, -0.9991630950942011, 1.032006672787355, 1.0657852111100385, 1.149049298166984, 0.6581927286419887, 0.1939923835308474, -0.7257256861771458, 0.8194357000319953, -0.017378970858567107, 0.32960234655194753, 1.1627275047341499, -0.3808879073765956, -1.2470930263552622, 1.3014035634531271, -0.8005545716520721, 0.09424823829348496, 1.2669778873878392, 1.2618210889342096, -1.0040879141601282, 0.008551972618039883, -0.4102612813340453, 0.5201263584014212, 0.43800730833637247, 0.4434639960186568, 0.06817476955360165, 0.2024787003890933, -0.3486048293467582, 1.1228178394589525, 1.1129085718311, 0.20945897422695212, 0.14227889084582498, 0.5959498310112078, 0.3709786856498893, -0.7963321311868489, -0.04009002278999784, 0.3827171213212038, 0.07906174593787707, -0.31223127664329875, -0.4947440547530276, 0.7465401250740453, 1.3736003790296007, -0.8753580828063824, 1.0418938316081245, 0.5214901783428233, 0.793195801787824, 0.9845071281054315, -0.862253375998442, 0.7043293424450174, 0.6681155473951821, 1.4063016673968476},
    {0.08600415373985974, -0.46558938506148556, 1.3959263389077705, -0.6004975896021731, 1.3108573800678893, -0.47369528137009265, -0.27102308272358516, 0.8105509825406074, -0.6661486741404884, -0.573912212660742, 0.477231744963232, 0.8616188019709526, 0.05259601543619614, 0.6168658517607141, -0.21775415199589548, -0.2676954881767249, -0.27265855822746893, -0.724119028568207, 1.0784655842449, -0.6377803768756473, -0.2865871173043078, 1.0984554458945461, 1.1581166290518812, -1.032466050885485, -0.011366471808615828, -0.3099673799672684, -1.1845074743300497, 0.6955220402084723, -0.6547390952139572, -0.0808377591007077, 0.3733719615115899, 0.057229116616264, -0.6793995875029518, 0.6539106159266355, 0.09390570664951427, -0.532154735245065, 0.015094887753929523, 1.230076286012006, 0.13862628223796883, 0.674550333942988, 0.04409816010172784, -0.17515529929347703, -0.7404665695994842, 0.9073273387638097, -0.7425092803862732, 0.6880830209382399, -0.18664956097813304, -0.5338243420001306, 0.21386867325668915, -0.18102949032123297, 0.8535187196126159, 0.5674299291162669, 1.141622152431135, 0.5300291285238222, 0.8430347331894138, -0.9628416304287727, 0.6513418959352966, 1.0355132770905708, -0.7167147598262951, 0.5773295498226517, 0.853348024712131, -0.6547592863333128, -0.7563993661956655, 0.42053650788995994},
    {-0.9787670759807543, 0.9416998984090247, 0.4170549460468886, 0.9363370835861548, -0.14119423280784527, 0.3619338682394443, 0.6918523470673077, -0.5806996863133069, -0.8888753162926682, -0.6212479214424382, 0.8328899820586728, 0.2533810148912859, 0.487169292968774, 0.22147731757751615, 0.4206444495219523, 0.8778912022378136, 0.5870872411198553, 0.9199252188127296, -0.044613437325062594, 0.6468828999870578, -0.6708268843130482, 0.4865197931297918, -0.8307047552957877, -0.9881967974010988, 0.9946193262122073, -0.07454296439545981, -0.03160588160365888, 0.8266091203999062, 0.4324497536144431, -1.112485212016486, -0.24310144796976554, -1.0157548408439054, -0.563119876491312, 0.006479077195729407, -0.10621358479543055, -0.7445833528986769, -0.34314616164063244, -1.0340155942574574, 0.2385430573117795, -0.06343752653231126, -0.560238947213281, -0.05006821493402266, -1.0886417002873185, -0.6766038900235064, -0.29024490539094183, -0.7937204499798889, -0.2634128639262719, 0.6703233209727868, 0.7161105960397647, -0.4104012827706022, 0.4825796266404289, 0.7040037516493027, 0.7585759094955536, 0.9194116129592297, 0.5110468058208971, -0.5857670879704026, 0.3614835505793102, 0.14298810556865243, -0.7921450599292329, 0.10595456202140054, -0.7288062777227976, -0.1729711565957841, -0.28633168682583915, 1.038950440383209},
    {1.0090636966688935, -0.534979484606765, 0.46480269193501506, 0.43986666566046534, -0.7470344974086253, 0.5176201645976589, 0.20994163437657862, 0.949632549598725, 0.871898108585535, -0.6289206706334253, -0.2379526971887206, -0.061392324725709546, -0.5277976537223925, 0.6936760566562523, -0.17238680823203212, 0.30128895826731333, -0.7530876868528641, 1.2298463740952623, -0.6226174743017069, -0.29852251087911336, -0.2299800672357789, -0.5910578193816743, -0.12394989615795039, -0.8939898492979396, 0.7406982752952942, 1.2318865053993961, 0.5698840926238703, 0.9049561629550267, 0.6209337696220194, -0.9641646489188427, 0.24388420968472377, 1.231091709027767, -0.21913014410822193, -0.5162305220506475, -0.8105126944090325, -0.018751191873226953, -0.8144034098778852, -0.43458130915626897, 0.8586281575585213, -0.901000722264797, 1.079207746862297, 0.9923657270230626, -0.16626438144454245, -0.28913042286758645, 0.03019402705530872, 1.1663852534302914, -0.748786948154903, 1.1642570309919615, -0.8154463664862459, 0.47962040859281346, 0.013750663657329376, 0.2548361915846107, 0.013919615157395064, 1.3701757979747802, 1.1188647083724337, 1.0223296166589089, 1.2305166403357934, 0.7179716088500733, 0.07451686631653666, 0.8250550932165049, -0.16964834575413437, 0.04770432437258847, 0.71108646030627, 0.8850796885989936},
    {-0.35032969399159175, -1.2568308404426467, -0.15158702070842248, -1.0145326787510611, 1.30250418358713, 1.041987543393661, -0.496498646345979, -0.9879507009775396, 0.7424439615568101, 0.605605655623799, -0.46924941264000136, -0.008453509920971774, -0.6080304581108388, 0.06873022260549147, 0.5177742660277616, -0.06516622471828983, -1.303220305979933, 0.2058136341648541, 0.781990712744491, -1.0404938084203654, 0.44800861377513596, 0.828197921807886, -0.6640199338888988, -0.5420479267872528, 1.3442449216427723, -0.8631184306851706, -0.20587801188573232, -0.5608690410904631, 0.45698168964665636, -0.3356198767565746, -1.0145677690927184, -0.27818244477882953, 1.0598787602375332, 0.8436030367582452, 0.5597427715681041, 0.6844387806251422, -0.37352021000823005, -0.33633024298606606, 0.2939298339997505, -0.5678743687485158, 0.6220415352696498, -0.7698146878128942, -0.36490527431012604, 1.0590809834982873, -0.16224020832098424, -0.6302832100857764, 0.018794549406572023, 0.35212482263108824, -0.10605228015292902, -1.1602789275399332, 1.0413257271791714, -0.4611757093427089, -0.46474639327073575, -0.16756807451280098, 1.098367531159242, 0.08385339604128514, 0.1142045316899173, -0.34982592455894007, -0.24867906380308846, 0.10501451721024573, 1.1520835610096367, -0.11554730625741876, -0.16773481814275626, 0.8726254313708055},
    {1.0988243965774973, -1.0287325831567595, 0.7279332223702129, 0.08443170744794277, 1.2836618441143133, 0.40875634021246987, 0.412428651030465, 0.8824271316972288, 0.4055162950631809, 0.4722833758383109, -0.6374840406995035, 0.9791650222974855, 0.02051889155688083, 0.03538150954071798, 0.006853747437737723, -0.7448857268069068, 0.8695721074659495, 0.1648298460785026, -0.971212867515165, -1.1844427734870804, -0.3363064364803232, -0.5253008092121, -0.9165914388637694, -0.64339923420293, 1.149220470376791, 0.401517819747423, -1.0292695106388563, 0.6673018530390795, 0.8397817133920664, -0.299202553322889, -0.2279868119117543, 1.1717182453637796, 0.015976288350062384, 0.7591192562548015, 0.9201535365854502, -0.17778669371210032, -0.8441971493215785, -0.35686054244725396, -0.47058897660730253, 1.1950827628525782, 0.22412737635724803, -0.4359945857378377, 0.8474903287633703, 0.18237141646164778, 0.3368131372552778, -0.3376247551001902, -0.02037731497874446, -0.011845863662725262, -0.946049018954886, -0.22448355806717118, 1.373374153087701, -0.2767060115454415, 1.013545694447909, 0.42092431198723074, 0.3951164646981049, -0.10065627586017636, -0.05380589126896182, 0.5126852704314495, 0.039173908917458276, -0.027979762141125793, 0.34743089289586576, 0.6576319048163392, 0.06573326521721638, -0.5890209221435182},
    {0.40131925632129395, 0.7139412375993555, 0.8957603240764646, -0.6145792433185538, 0.7751270430182888, 0.3129213237628515, 1.0467761863232277, -0.3305369726183547, -1.0110549132620352, -0.2967172489696366, 0.19316573483751598, -0.4076339715904889, -0.5008532250202998, -0.258475477727159, 0.9955548031039423, -0.8509376683183105, 1.0539231541092262, 0.8265605022340208, -0.09186320851893055, -0.06570331509355562, 1.1490809796636003, 1.0927926125288148, 1.1549847496566295, 0.07279419661749334, 0.2030863326901602, -0.5605747411948474, 0.010921594472664322, -1.002703443820989, -0.8462652583515322, 0.3475005972142061, -0.08687136809605081, 0.16935025077301627, 0.7549179199809848, -0.18914964913803853, 0.02690607763007618, -0.6006914199798937, 0.5611497871764549, -0.5674623889636478, -0.3010606174938598, -0.4789369583453297, 0.010875338910781181, -0.5856517485357878, 0.01202694382690255, -0.06329758274761267, -0.7853933355297315, -0.02511660488886523, 0.2802757570223606, 1.0208151161334529, -1.1401154612328726, 0.44987939593906195, -0.33657107946294906, 1.0762874918847447, -1.1142299733114103, 0.24644042725929405, -1.029604688805855, -0.6003328581598316, 0.7049822736303096, -0.3976465970463144, -0.529403963543369, -0.17184892437550775, -0.5483487752462676, 0.2254923190132009, 0.12516554536050212, -1.0108330771469736},
    {-0.5887922795738236, -0.06432574935898255, 0.7288584022869025, -1.289164862524889, -0.7738928254231329, -0.07864653941340799, -0.42002063837840636, -1.0588203703599672, 1.4419130735848011, -0.43217663113317, 0.8098616545970991, -0.3451506375378172, -0.9928646873504544, -0.15409440119221857, -0.9486827390845751, 0.6972569424793863, -0.2158327382117326, 0.3734549249297285, -0.6701415363172271, -0.15935151017290367, -1.185496481248807, 0.8338616806660935, 0.1460265674805314, 0.35940359214654005, 0.6640539000167857, 0.9046577663265237, 0.6527621129479982, -0.9593811257793697, -0.20814956728436074, -0.7586826964054598, -1.3432392695542663, -0.04892754580752766, -0.4938492712100176, 0.4191860999260537, 1.3776264983736781, 0.4534022476880274, -0.045474973697958714, 0.1110813834996863, -0.4382220457765123, -1.0527986544068746, 0.19357264434860333, 0.26707523575579756, -0.36883623096088786, -1.2749992397590826, 0.2718082370863188, 0.6370227661682663, -1.2725414365072136, 0.4704415481863628, 1.3187359277837654, -0.21337899257123805, -0.3295362804395935, -0.47927672807147215, -0.15083592665123854, 0.6813750230324858, -0.48263528956646795, 0.09246593065374363, -0.513168377365236, 0.19806156482203618, 0.3844085778769934, -1.0029877653621202, -1.0105144510371955, -0.24473867701335827, 1.008432238110958, -0.1395291194296511},
    {-0.32368329536126494, 0.5514745068364305, 0.9286312229033029, 0.41508514994813905, -0.9412133330485344, 1.0382978287421032, -0.9556576957905694, 0.4348512795659508, 0.16084356066042851, 0.4367102794516569, -0.08161457535702314, 0.7957520434566215, 0.7733197164236136, 0.38892884356436996, -0.47482911376187437, 0.7968233499387685, -0.194882168500715, 0.364126933914998, -0.33420653243438275, -0.324160512225141, 0.682658664182266, -0.6603940012218341, 1.1893538516624858, 0.47796726116605526, -0.2727618360065874, 0.49655381845383073, -0.9380838536183027, 0.12760772314394903, -1.0394252014934153, -0.45519778261787835, 0.34286513432753774, -0.19841681210268355, -0.3831871596247215, 0.2597938062503499, -0.7157162105568702, 0.3880363742825975, 0.9843156848889767, 0.9809321632489468, -0.4779738132985437, 1.013336269319752, -0.41667845429751693, 1.131868895631447, 0.8025352233649214, 0.35724016654433466, 0.16174482575440102, 0.9801163636811381, 1.3406307166465128, 1.338782273549292, -1.0950024130123954, 0.08480985134603516, 1.0539433720839106, -1.2219501224138483, -0.6712131280171432, 0.9761421225987054, 1.0231021165601795, -0.5471561586344187, -0.32732903179803635, 0.040616623353202534, -0.29988779619341227, -0.741918174438136, 0.9311701932453327, 1.246797711551443, -1.0314929504852763, -0.7259520961691918},
    {-0.8625785550545774, -0.1666583631151141, 0.8240156741690543, 0.7598134124301493, -1.2567755406529448, -1.026201501116182, -0.946321643521232, -0.14112360733921658, 0.06565784134771398, 0.9635982639110074, -0.5516422123657015, 0.9088265011146804, -1.278762690118026, 0.6996919699632389, -0.7764398715698564, -1.2679303804852498, 1.0488211554443592, -0.6499344012480216, -1.1087600143460201, 1.012413476315186, -0.9420375501990662, -0.5753705881997924, -0.3452485455885618, -0.04907786742770513, -0.672056813147503, 0.29443844237184263, -0.02899413412220851, -1.0574330978942041, -0.7186827145711175, 1.1216963154956683, 1.4639217177969404, 0.1085939710163731, -0.20133482716674364, 0.5235292185851353, -0.3862834450734085, 0.6488847286637435, 1.1475032307910333, 1.189780505942248, 0.35410192583990746, -0.09476910220987919, 0.3353738968746511, 0.5410623597473088, -0.7198511982875633, -0.2917366340801031, -0.12588598124992176, 0.18203518767918156, 0.9869813625600855, 0.972019929018101, -0.8680397359474354, -0.07383857941139439, -0.1934353399652595, -1.2442221182420428, -0.49340621686890507, 0.6369672632748266, 1.0522377925960553, 0.24488092486924273, 0.3446669477511984, -0.8470915412215733, -0.20903281733722834, -1.256099103824828, 0.6297217335179616, 0.9900786564073467, -1.1141976269574014, 0.385140776478212},
    {0.908438223680594, -0.5364427935702658, 0.5265220411502278, 0.5248298467513467, 0.02813068396574402, -1.1714626466750109, -1.1945363065098997, -0.3825617187474528, 1.278239906741148, 0.6385674364616435, -0.14479760238582767, -0.09682467927694, -1.1086557375368111, -0.6784454978576124, -0.6392542297824353, -0.7928574004449963, -1.0904474918336302, -0.21958536966266196, -0.6531360490715948, -0.45747282719691834, -0.12458877548283785, 0.5634146608797146, -0.4693683066324147, -0.91626636867253, -0.9231574656897731, 0.6206541636132311, 0.0707261344523254, -0.9811106799601275, -0.6529024549753423, -0.7358182868599867, 0.17830366392336366, 0.7263157729236452, -0.14166743062920079, -0.7963363943294508, -0.5163393038507073, 0.3369700723760628, -0.6774443047018911, 1.014449794933007, 0.46417983108897326, -0.795969999073194, -1.2293889701289287, -0.412089350688306, 0.9877287898781721, -1.2481962633996002, 1.014191546869077, 0.5294180206390822, -0.11905230311850841, 1.004010065154763, -0.8817211426389775, 0.4428199180280477, 0.6352592533060123, 0.4965358441430957, 1.0356378629689809, 1.129712516776491, 0.005275918290290566, 1.1002377825968979, -0.6247283863704615, -0.9672330815360742, 0.3636342499581879, 0.163635554410519, 0.017485481369759408, 0.24615911802174864, -0.9363034615884389, -0.41513708651159864},
    {0.07544709644299402, 0.5033119025681779, 0.7336384084008996, -0.8751644282322092, -1.0563896974474714, -0.34776823753021496, -1.011478974238154, -0.1407724246569781, 0.7703887440763278, 1.1620641671185583, 0.2749424244670179, -0.21515904685466675, 0.160754462545263, 0.368979084638801, 0.4107054175514966, -0.4594111151387844, 1.1781716395386423, -0.20715801645436013, 1.2127080152195153, -0.46480517712412817, -1.20525776160333, -0.04746020415353954, 0.42867665756801143, -0.11184301514235598, 0.34048573341437577, 0.8228261468124818, 0.1759774718402753, 1.2869418596540527, 0.39533801610970487, 0.9042142227315841, 1.436159142568436, 1.5792484406722498, 1.1470332726416244, -0.9676022316325702, -0.6895157298390118, -1.1067289931886888, 0.615399708313265, 1.2490098399160874, 0.5810089937720745, 0.835922761144932, -0.7374061346070677, 0.5884626015356813, 0.37622714482238817, -0.5997454544483334, 1.0280422010331158, 0.10110856586644994, -0.08212983124815772, 1.02038526492465, 1.1161238579902528, -0.8794705395641456, -0.3707110612240909, -0.3770905851684118, 0.9985634126510003, 0.9194677551249709, 1.5340630048353672, -0.4523275730656279, -0.2015865798676206, -0.5748176949576143, -0.7256010830035653, 0.16514684508778305, 0.7341267753616585, 1.3215457788967993, -0.4857462637079788, -0.14220349372673421},
    {1.048612553830226, 1.3599844705410757, 0.9200673762023297, -0.5139017530922353, -0.13060653613731682, -0.6692038436534954, -0.5190730251191195, 1.0906208928898653, 0.12245341369775616, 0.45496341898425, 0.46821833109434335, -0.43676257647529393, -0.7625463880842502, 0.8595658865300044, -0.7714586733100187, -0.9819359088458728, 0.7041982855153832, 0.4429266022282328, -0.8398754513602846, -0.795450716321775, -0.6261886655988897, 0.6030637517439557, 1.2621451848010639, -0.5948111402897664, -0.5904245272139276, -0.7448468933184884, -0.9123342927432287, 0.26709946720650674, -0.45981832690560226, -0.7334620903095979, 0.24630444636071883, 1.1997647017327007, -0.902653586820015, 0.2049636569791156, 0.7553637956279874, 0.9605707729061235, 1.1269297061904953, 0.7866491705898178, 0.4480623937431608, -0.005066799859497256, -0.8667764204049425, 0.4740741402134169, 1.3999344257217674, 1.3304154122068472, 0.828565282333652, 0.3677122217613596, 0.9122641697577378, -0.523008108650375, 0.8568656584150119, 1.0846167071224513, 0.8938196132924187, -0.7153321170836873, 0.5892288358840707, 0.8282622784197825, 0.5711200280493132, 0.6023028838341976, -0.11327666035583765, 0.8572047101367759, -0.5505477892730319, -0.23097831271679206, 0.6297975650414607, 1.3634811860563791, -0.4199994998892381, 0.45139688064520006},
    {-0.4244354555287038, -0.36167828681604697, -1.1397787928720193, -0.8502546679070558, -0.8487936171267466, -0.32022123440964334, -0.2760678819560297, 0.8868110113026496, -0.022561851933770326, -0.9730772260876563, 0.954927814286697, 0.9897503107731775, 0.32824698042954725, -0.47591643930953537, -0.8868921251695925, -0.3204148256340104, 0.5074503561895333, -0.5616375860270161, 0.80726785900617, 0.61734345207058, 0.2501349773389087, -0.9459635982681779, 1.0090217307324958, -0.6464941367382395, -1.1879462621554058, 1.0208275769918995, 0.6299480998468158, 0.14632463402291276, 0.13174975401516995, 0.06308659727751101, 0.43825876019096116, 1.086431852931574, -0.7199704074101445, -0.34642616867571485, -0.8951191555345644, -0.7353858136267031, -0.20018432200294192, 0.8888928984335117, 0.5049723480467389, 0.48334404323393265, 0.727434645227024, -0.12136155533758196, -0.5713295702562263, -1.3550242181299814, 0.4014774962785061, -1.0216381830851946, -0.6695931832477497, 0.3566344413618904, 0.5597437473165681, 1.0072333494131498, 0.8551341309003152, 0.04107472308899421, -0.6386239079449342, -0.4814676703752838, -0.13301583938727304, 0.24155551032803624, 0.4991879454431249, 0.3099111719746274, -0.06410504595713812, -1.304590260414942, 0.9476677242625037, 0.349203725836041, -0.10764264758386563, -1.2332384394661802},
    {-0.5354714358771393, -0.7978216968694484, -0.00960972486871336, 1.0610066984426103, 0.19055032526814414, -0.9419043480975458, 0.7056173097972539, 0.5821843400854666, -0.10629263657423783, 0.31490568414248216, -0.08554021530799899, 1.3980391977731748, -0.21307948538101332, 1.107231622178377, 0.005407624830248857, 0.7798551861861687, 0.5462891658717153, -0.6851216764923945, -0.9035033406868225, -0.4472724164279534, 0.43449241300628216, -0.20710106676366735, 0.21477623288134806, 0.8968104023749474, -0.16715791081879358, -0.001424202209664621, -0.9135219713592889, -1.120453926306359, 0.32657914969735274, -0.10243237702909802, -1.0195908929680428, -0.6048573037291569, 1.2158939112962663, -1.0648871517003495, -0.08866617831375653, -0.5122587733136547, -1.1185361096813977, 0.9902071720363893, 0.43684954444832313, 0.9969504380984049, -0.48443458055549465, -1.0081482611278574, 1.0999675340208772, 0.622804637356264, 0.30598116923306096, 0.8001331854235884, -0.5523780590963525, 0.35292634159046976, -0.6299222635122984, -0.4594146474534955, -1.0520486991403755, 0.6914022896105642, 0.9810261939423949, -0.25145599381390626, 0.3452719325980954, 0.20612164941495476, 0.9758088355867749, 0.7537456643241199, 0.5083325975745687, -0.32099619824956316, -0.8951217795562455, 1.2100568459083563, -1.028850087047693, -0.004101345162095393},
    {-0.9393717039873639, -1.1056625564770732, -0.9995074978818925, 1.0007312927690406, -0.3037977330694657, 0.1412190801529614, 1.052237379789026, 0.3700195323449057, -0.5135512755592464, 0.5750970237704066, -0.1832244346758687, 0.11275209409560291, -0.027469616241088114, 0.09372992276990241, -0.04504811804325888, -1.1025028423093877, 1.164489969444432, -1.441580277625752, -0.8938715919091718, 0.6790354606244967, -0.9618042950527915, -0.4628444022838206, 0.5466219903723969, -0.403488488603317, 0.7252400556940991, 0.17185182502259985, 0.7724944047928282, -0.770386568921354, -0.3054449076274093, 0.07890133394788706, 0.47507607662121537, 0.5150480878751704, -0.2380530651148546, -0.8196522180008677, -0.3953069766839447, 0.5891924022842042, 0.8516206622307134, -0.7278961891174482, 1.095240721073268, -0.5031247559225148, -0.5018602031991874, 0.8399865843775657, -0.43029333313367923, 0.5888859662816982, -1.0668694520642668, -1.1984411807421569, 0.18116043464915202, 0.8499002270176771, -0.8379067334762491, -0.8220357135659278, 0.9012336023092322, -0.3360718422760007, -0.9507002927979611, 0.26016391871988087, -0.6455313857221405, 0.007383351185107119, 0.20132860150495943, 1.0233795586087613, -0.6382640313952411, 0.36102747768859117, 1.0685036388551077, 0.5700196523922071, 0.29197194099792695, 0.16547574663178613},
    {-0.745012911284444, 0.507616617056295, 0.9635496540870709, -0.7899015358845014, 0.5486657441318866, 1.1384713912343734, 0.8821424280184221, 0.9021667737406234, -1.0300033104094617, 0.5005115222772551, 0.20114054133048534, -0.1132212605974683, 0.2561529508317137, 0.9352026423578874, -0.29818832635592685, 0.9527633571869727, 0.536050896706989, -0.7570472757978751, -0.7574817028260336, 0.5807034516347435, -0.3361975039682617, 0.7550210112057486, 0.9222646935713158, -0.049707396885892235, -0.14530195567729598, -0.612995177583198, -0.2978330446543169, 0.5270175513035574, 1.0542670716547116, -0.014232080061485321, 0.5852396775752293, -0.5773435701666683, 0.01202966680738266, -0.7780345758469744, -0.031090361065522824, -1.3361123960775552, 0.21653603397390056, -0.48552777268365704, 0.14793596980317475, -0.5586073756888948, -0.48315468437214865, -0.7029032347695051, -0.2875970401144441, -0.02120674029009196, -0.7700619465280583, -0.4175507785749499, -0.6571348568426219, 0.8265047119991238, 0.7712712909004306, -0.988687622944709, -0.8530959288988342, -1.0880819229766356, -0.29997682764855027, -0.24460319382699086, -0.2312251507490165, 0.7992459263827321, 0.6959269053256214, 1.0847362729221723, 0.15012412730485397, -0.5532610531463045, 0.6499229615941915, 0.38672636621074236, -0.5696753643640002, 0.6879903753806987},
    {-0.10776231044870306, -0.44006798468439584, -0.7070022219983896, -0.7982725614312454, -0.7704938112718752, -0.3148543866738573, 0.8868433184446938, 1.1417781582374409, -0.20320716355725, -0.8984190555206258, 1.0488655679447982, 0.05583465138773105, -1.243468102745595, 0.46154658430601486, 0.016602609240528806, 0.29754094673524645, -0.8576268799750324, -0.4189171660924404, 0.15372668886439908, 0.4830714517684641, 0.7458446017165974, -1.2483464133047637, 0.5435600717975573, 0.027550702722433134, -0.0022532763330756116, 0.8587977073840727, 0.3567240871631969, -0.7177001325279667, 0.8465828448689581, 0.0932088883078186, 0.6875764892081915, 0.7408371856982374, 1.047011603612667, 0.5795593391395785, 0.3071049160263097, 0.5878973577724349, 0.6276828794230973, -0.8232306888808638, 1.0017056276274758, 0.8016663448957014, -0.4668361480563118, 0.9921131288702625, -0.762379342200244, 0.5103588224829239, -0.3172371991031892, -0.4912704621796689, 1.1350838854711585, 0.858451021461572, 0.3172752967219549, -0.9816147269122246, 0.13828484367004937, -1.1123978683811744, -1.2908484827003897, 0.22968443958391244, 0.487257302385232, -1.2166650701156425, 0.11513477519883498, 0.8398942453980243, 0.10583938987842476, -0.6877811661026672, -0.5839655778946726, -0.2732441787194075, 0.025135499908269614, -1.088875117419617},
    {-1.1902806794860576, 0.5263838768499721, 0.5122563792291742, -0.7397050018733821, 0.45709657914689517, 0.5573097110731247, 0.3364475761794797, 1.1271454643015661, -1.35676784789077, -0.7554109425334247, -0.12325087220521032, 1.0262466736904798, -0.9808519353719464, 0.14250198066731937, -0.07730154999873584, 0.13681781296771917, 0.7314463914511079, -0.5797258747544644, -0.6682486060285467, -0.09166429467310645, -0.7545778423626509, -0.05382377527413959, -0.12235071579579047, 1.0564320006132863, -0.017107547694383177, -0.9469229549364995, 0.621895501189427, -0.48827692989046734, 0.7364668519390407, 0.1722782379124019, 0.9213232298070072, -0.9165979412188595, 0.6994440759920421, 0.5291567164470654, 0.6112887791661175, -1.3025874167401232, 0.6506929467216449, -0.8050844879051521, -0.3366812056059163, 0.1510335125840089, -0.10581876588835636, -0.4982303154991532, 0.9634177981995207, 0.3491930986152861, 1.0429494451885624, -1.040156503499342, 1.0566224798628947, 0.1255157544220963, 0.013802835987507645, 0.7089150737439995, 0.6799449456840485, -1.2633797537285076, 0.9664714576798596, -0.4971317113391981, 0.8611794618520373, -1.1103531124761818, -0.06911976411272544, 0.5501418607875743, -0.02183051890343062, 1.149960097443007, -0.9208745210535574, -0.6538900910516227, 0.1804030585049862, 0.7728238544786674},
    {-0.656745846734459, 0.2611109976705966, 0.6999460190323538, 0.6210245583633541, 0.03492494108867698, 0.03159273555376056, -0.4401570191422238, 0.21640983988243256, -0.8856979740974232, -0.540389407822173, 0.40289649129212285, 0.5994907334716693, -0.3820316672659306, -0.1283123912254152, 0.07006987319599967, -0.14057673658046238, -0.2715342557475712, -0.7804028362146518, 0.0986688246534664, 0.5180127340119729, 0.2956562129424078, 0.3575955826119984, 1.2917103584141023, 0.9586617577896999, -0.5746439412521321, 0.7565218447750743, 0.15807880315901135, -0.7278599805262582, -0.26864064526984266, 0.8188427885223101, -0.6248711767337436, 1.166772841987397, 0.03982204960341664, 0.2632839184838231, -1.1870529569186001, 0.25211755429166877, -0.24043459826723276, -0.3068495278967545, 0.9904844436080227, 1.4924195919222931, 0.6223704301458111, 0.41165830447000007, -0.04650212107020439, 1.1753071769003551, 0.5773185039369845, -0.15134445161701915, -0.16358527075135246, -0.42073876373848385, 0.023401535039421904, 0.5041680096360034, -1.0045316266378617, -1.0908548525228654, 0.8837298110056989, -0.8221516206792394, 1.4233431882656193, 0.1471494639628387, -1.025830481105463, 0.6170723469406774, -0.7838197718625671, 1.0344060756318187, 0.5341785147905797, -0.8423657977315399, -0.675777436619888, -0.3211607030771692},
    {-0.46272534276177874, 0.108368432144496, 0.37341503114987157, 1.0898682697633106, -0.712039112627673, -0.8871168355093622, 0.6225778856604642, 0.4340565440767361, -1.5432261693715823, -0.17129517216731915, -0.5874879959916027, -0.34270057417808764, -0.222670222916496, 0.26380659404317736, -0.9726292661373366, 1.0426536799879185, 1.0157695350585279, -0.8365238929978336, -0.6877787076165061, 0.3371379821130981, 0.46942779142765956, 0.70902427891146, 0.4707123373444605, 0.18297842507348622, 1.1680928442021743, -0.10340926491112876, 0.41182095851881595, 0.5453021149366651, 1.2487178489421233, -0.9892847894611334, 0.5387261275470737, 1.046616059210888, 0.08309363045041271, -0.2542857156432567, -1.1353853119528843, 0.24951929263228728, 0.8585242026169436, 0.7236560651940763, 0.5011280857660544, 0.9564403856420096, -0.623342205087299, -0.2841833821343979, -0.25519350042332856, 0.49523032175194226, 0.5075756645338457, -0.839514166226548, 1.0437758950310354, -0.9939915186912615, -0.24405331563958513, -0.4077318589087765, -0.7190986922126346, 0.3077126704665466, -0.7652054940019369, -0.30780945244654956, 0.5368447730416255, -0.4925192979081645, 0.4602249169214288, 0.6890767255790735, -0.633465687967247, -0.5604027116800757, 0.024018263770273697, 0.5211907593831948, -0.27702137160620577, 0.7372164164703895},
    {-0.7018417419248267, -0.2720574959072138, 0.311268938583744, 0.6827267178092378, -1.1807891777485546, 0.9661176092959677, 1.0925328330681827, -0.647747438905677, -1.0473072895223883, 0.4431344983038137, 0.122243651087415, 0.9408162432343831, -0.590979476013935, 0.8805380701477334, 0.6987572677817494, -0.6506664424112466, -0.15886739074773581, 0.5122253306654115, -0.023330778419304025, -0.607832490001968, 0.9870841145188769, -0.47648561338074163, 0.21836118507397811, -0.27548414462507814, -1.0677709113274332, 0.6948189226037997, 0.33524385347227165, 1.1271832407113154, -0.15985832358579435, -0.32966926354821235, -0.8940652497969243, 0.19938509344755745, 1.1403968210842756, -0.38209687365920003, -0.6445275521921393, -0.9568456178555508, -0.46404982991145066, 1.0425858213379435, -0.9213576437441561, 0.14456180213566852, -0.34572883042891417, -0.3708606853042441, 1.0181114017735868, 1.1553485620242223, 0.7756918042518627, -1.1797351627246997, -0.11020423130123719, -0.5706049645709822, -1.1263210710987541, -0.9255804421866666, -0.956333134699532, -0.390270576612455, -0.6761293660675578, -0.7958463681969684, 0.09017005034091023, -1.3235476740437853, -0.11991081607777299, 0.341884043241683, -1.1916663686336868, 1.0106022278866307, 0.4291006250031033, -0.18584691045986285, -1.0363747211976462, 0.4401044649289701},
    {-0.10934674967932886, -0.6086131176627818, 0.3708545313739442, -0.2916386198151516, 1.0648055681327702, -0.19967222313196192, 1.0100125559031798, -0.27655080043082, -1.3911894555042768, 0.15922775344707132, 0.07418603140125819, 1.0956644938978921, 0.6526606878126457, 1.0259610617363133, -1.3027490485412865, 0.1781623390496715, 0.13409897050195033, -0.9450204713465481, -0.39194152209494215, 0.5460108984309675, 0.19788649272415776, 0.22501341469230854, -0.8756296398925174, 0.15327004734773106, 0.44443631133529515, -0.9230928942648755, -0.9391357855570973, -0.4480278926144854, 0.8616807216753644, -0.8792879361050712, 0.5016717109946899, 0.48130167628556664, -0.6467675936735672, -0.6359178536753157, -0.9156598831564476, -0.5643521550940794, 0.3232710353611088, 0.7083775612213807, -0.003163194266222221, 0.8432992308382896, 0.363295661899214, 0.3744118539286714, 0.2286043602408136, -0.11807754650006397, -0.560647409915643, -0.7072104657428652, -0.9683747158441603, -0.05697441006152485, 0.32409304792236043, -0.11583445482773098, -0.051272576220133606, -0.5955124074652198, 0.730895740957625, -0.8603518232808589, 0.7073929697948677, 0.3585563718593627, -0.6829626676722822, 0.537775879881004, 0.9306389564345016, 0.24887724569658776, 0.7733534041773527, -0.6981088056782003, -0.12744645817350256, 0.9732600000700563},
    {0.1914722109591659, 1.1704251224263928, -0.7542322061556157, 1.131524800402464, -0.3416957360697464, -0.5413000805857608, 0.21561128889165299, -0.07809962560793698, -1.2887674854186861, -0.08845499240324772, -0.4004828973356989, 1.1731145789164432, 0.4421178187528311, 0.3450201147918039, -0.6626195372880576, -1.0571667898512684, 0.6947677443410707, -1.3029183873691839, 0.6138370267378886, 0.3882358873551925, 1.0210429253752056, 1.0563916493861223, 0.8800675521761676, 0.6993661880565093, 0.527923375527682, -0.020014194404268743, 0.14539100958631315, 0.16689876969427744, -0.7513172791139349, -0.8211246924314892, 1.1611133355622647, 0.753350004333754, 0.7555038882631688, 0.29218735659317835, -0.6776571397606913, -1.2546151271097732, 1.146780476589921, 0.0832437909551527, 0.3838909544812251, 1.1955364693791692, -0.30897375445704756, -0.5080508446687108, 1.2522679510229155, 0.17991344540855758, -0.6926427276193212, -0.13468961207791735, 1.2185706206013835, -0.40005029651623086, -1.1208889695611084, -0.6467279450577289, 0.8660866642491752, -0.40568201556746875, -0.5052207200972383, 1.014008090857602, 1.5222373557016051, 0.2889105285265714, 0.7559476227099845, 1.0269363491626506, 0.8263687002529198, 0.684289903839376, 1.1449799642309682, 1.2571448197571662, 0.7734103990649239, -0.6652519132881015},
    {-0.8774269108645458, 0.7198374045905028, 0.6916448279604547, 0.7355395071316139, -0.8569983523764807, 1.0643055189094006, -0.029088510036647322, -0.10643830598942611, 0.2635623761731853, 1.2924785317313487, 0.5975075962377615, 0.5620100894565683, -1.1873160528075466, 1.1201364896809463, -1.178222272043331, -0.03348975004253682, 0.9132432800856787, -0.010280700392044805, -0.9153966724656496, 1.1466728145655478, 0.01411469032399924, -1.0776809558941705, 0.6281577924622167, -0.46271448595482867, -0.22971379607194115, 1.0337945807738993, 0.43982024270235165, 0.3122716665836564, -0.43400594030703465, -0.049750542621278926, -0.84971364193936, 1.206165034313311, 1.1240446064800793, -0.6972043784138419, -1.128255936923909, -1.1910163598483756, 0.40356346112066543, -0.8313814704729614, 0.8018148246470908, 1.2026172224501408, 0.8209550017401299, -0.3470712423247346, 1.1822900942870616, -0.15065619395526444, -0.6927955491323967, -0.9087504243356397, 0.8585145289203905, 0.8625044183717535, -0.5872119822061318, -1.0445611066083211, 0.7027024263983161, -0.6912681854306073, -0.9586447958217751, 0.27641288214339477, -0.03300805981216177, -1.2209578041817553, 1.039579179268719, -0.4234035330766937, 0.0278970747392227, 1.1762989388928524, 0.16239465441661777, -0.12847518075064776, -1.0452229711817858, -0.1461432958089345},
    {0.14137933420322946, -0.8177777196507061, 0.28796136345458556, -1.2274586089477215, -0.7311845689548923, 0.3317485367792915, 1.024467387337517, 0.06807561278893132, -0.16425105132534185, 0.6032380802415916, -1.2333488127297325, 0.39911357340637527, 0.835942353139084, 0.9622231405887556, 0.8883788280123368, 0.5175163119213555, -0.948547844164068, -1.3380532413101314, -0.06496966134154925, -0.6149575879465257, 0.21847187875476998, -1.640015557031037, -0.14447591467836526, -0.35529684105963355, -0.7992142966275312, -0.925348693752763, -0.35655851164521524, 0.2043245754533659, -0.9293323032414396, -1.3754079592861963, 0.0028857808107906908, 0.5911358934382168, -1.3883736600800936, 0.05848290829422262, -1.476642653000369, -0.5725864159546128, -1.4932743532110593, 1.0322457323067367, -0.6036484581241407, 0.5731028793576122, 0.6219472288381145, -1.0986219231182475, -1.802412456821702, 1.0352390931034139, -1.1364910930627607, -0.21135390578165358, -0.4246830821907852, 0.4287143132834703, 0.05922565886583423, -0.20459108058138334, -0.20675145455903363, -0.6472600990773687, -1.2976194467649294, 0.4505334379147576, 0.08079646047781362, 0.6807278400319687, -1.401348101329331, 0.4314720961099426, -0.7395844173098661, -0.06737682962176834, -0.6418259722645272, -1.1078285164110464, -1.2952464654964146, -0.16862790639054615},
    {-1.2188635135851427, 0.4193721412850339, 0.14124620483474437, -0.36961261221246067, -0.4185332507566911, 0.360279182389952, 0.04866780179737496, 0.07087707925103792, -0.6096786365962824, -0.19142789748847572, 0.15419401493970702, -0.32417634878285406, 0.7541674666675612, 0.5862699215689537, 0.05715056633743022, 0.6064109529809151, 0.7439093644308363, 0.5181442995191888, -0.5816372811202276, 0.939438548594132, -0.9329115361827737, -1.0024793067226232, 0.21350918030556842, -0.7775608210171853, 0.8502113911573426, 0.020194861644837334, -0.3136386009651593, 0.7575903458177092, -0.9572281256977877, -0.9017563739146676, -0.03817923293421072, 0.6540244817433446, -0.5101193256926551, 0.1723356190328614, 0.20141922135395443, 0.5794560311005318, -0.3290116740349288, 0.4704493969803243, -0.510050319201329, 0.5874580755316388, -1.0048338773659777, -1.074143383257667, -0.8919943980750881, 1.0848467077354251, -0.3074167881916672, -1.405422932921046, -1.0377572692691233, -0.84350177951892, 0.35133912036778386, -0.7806472510190294, -1.2408980002235017, -0.47392604270790595, -0.6615452268114755, -0.5486584029467733, 0.9032665989646685, -0.2850685689355666, 0.21517306754336252, -0.09534351910714121, 0.6252958537187414, 0.6934695782767485, -0.19138872654732095, -0.31010639553839536, -0.4930477611570665, -0.7792631434791792},
    {0.10441227306091046, 0.8133445006296374, -1.2654727299477202, -1.3601675115003387, 1.042222106477044, 0.3491586855562456, -0.19337670219447714, 0.3447127988057054, -0.14035735237910213, -0.05976270272681885, 0.38261379946748203, 0.7327425791048265, 0.8133871997360616, 0.9070704590085621, 0.5545633763052377, 0.581358610408348, -1.0538263051575665, 0.3524069016961359, 0.3011436955416185, 0.20143630992654563, 1.0309180263150513, -0.33937046080983396, 0.032988501966907745, 0.5878832966872412, 0.776576600493728, -0.8988899973509815, 0.8224714543615361, -1.1520890068214718, 0.48717619621233677, -1.4297424488731674, 0.45338595018637207, -0.7613976089762877, -0.567835377409154, -0.6819229956487566, -0.9022564494773597, 0.2058386640303212, 0.02536149985152545, 1.0028489641247285, -0.3320994771526127, -1.0696216340877716, 0.3083244686988667, -0.37300934510886624, -0.7125987293033095, 0.9098521571311896, -1.3272853730877772, 0.19282807729891902, -0.8225271585692372, -0.4778050494537823, -0.6860978061232834, 0.5403463585347255, -1.2976232339514158, 0.8346753079927983, 0.1846545919532861, -0.4999902197249609, -1.3297364352260577, -0.7031842182158956, 0.6147982306572168, -0.010777504299230654, 0.2655038581282161, 0.058799737879406046, 0.2522941076723399, -0.4706888013396824, 0.2650776654316586, -1.319547317371656},
    {-1.0087459797498726, -0.8967192686240475, -0.18178709738505103, -0.8261672452011554, 0.3839763021063748, 0.5169167390706609, 0.5501086384268127, -0.15521226256683196, -0.2811740682845644, -1.0305866522202833, -1.0692073882501207, -0.13503669782370828, 0.426770755541278, 1.1369474450452826, -0.6162391664926727, -1.1592511159951129, -0.6647798040956059, 0.08995715301782192, 0.20829670943944292, 0.04805740890516792, -0.2837257952298905, -0.042822136349449154, 0.771399600422343, -0.5523663567603866, 1.1161849314543615, 0.8616409580648884, -0.09347433718466784, -0.2147629690730522, -1.0127344488973755, -0.5271200171481218, -0.5707872995906893, -0.21207539600477746, -0.8348706829467397, -0.9754441165294853, -0.5632094524355037, 1.068398450171594, -0.39374607702977926, -0.5193809126784548, -0.9767216509220119, -0.21333852472554193, 0.36220802495446675, -0.9670040305996844, -0.286196804788957, -0.055284205084519776, 0.525441191628094, -0.1757724732006972, -0.34740515544170264, 0.672506065086901, 0.18287932532287807, 0.4449650777931251, -1.2166768108534614, 0.5729639321462122, -1.553420383575684, 0.8466622571828385, -0.6618802984030048, 0.10508789488240203, -0.39624968249125564, 0.284418893357209, 0.2663302785239545, 0.5009396116455223, 0.38508013533107927, 0.4434790255715665, 0.13870781684444278, -0.81040601134271},
    {0.34863720449845476, -0.5256411674812937, 0.4532531522172584, -0.5214791786267493, 0.9458233731598049, 0.7110599940736679, 0.7214348372498021, -0.7835476731094959, -0.2957435635941422, -0.5109551080353667, -1.3366247870910075, 0.9341094057329836, -0.08680247777824429, 0.82213309444712, -0.6616123879386475, -0.892047148432147, -1.1072312168624086, -0.3248150361620251, 1.0402039605995026, -0.8225840747422013, -0.777179768790298, 0.9725691916037668, -0.467266345347513, 1.0349137418577985, -0.1113351032998658, -0.313369880176384, -0.6930073881212625, 0.017951272316542442, 0.8633537303807793, -0.5910894508128257, -0.8784214267464189, -0.7098654042796018, -0.19347308152486103, 0.29991575678161736, -1.3029812223929877, -0.5919182932724577, -1.1143698486124336, 0.9968471470802823, 0.7819039301554818, 0.8448544643951036, -0.8471308808056988, -0.26744035220078166, -0.8756347054467029, 1.0701532033492547, 0.43416903583621275, -0.521583194674186, -0.7281965576787575, -0.3007781541704346, -1.0463908844485101, -0.1660364063874327, -0.7731615708736376, 0.5669756593675265, -0.09729820764812012, 0.24969102772313725, -0.07921724470045909, -0.29367939717900415, -1.1427139293765494, -0.9439720480430701, 0.6762418602874464, 0.11867792853301501, -1.1282995787968604, -0.4003653924853364, -0.25847574291837533, 0.8979626500121483},
    {-0.426282224644204, -0.8605921792241668, 0.48136013588456006, -1.1396014941907298, 0.4193498564966968, -0.7157588554798361, -0.5546875038864698, -1.0012443400558872, -0.6522420412250078, -1.3468508887461632, -0.48801693532776197, 1.1923394618183958, 1.213804452371483, 0.47216524345109795, 0.9117503662980634, 0.0876671859325843, 0.7163383692248758, -1.0060690027280592, 0.3460017100877307, -0.9377932040864643, 1.0962812417714252, 0.9152751934003116, -0.777686384817183, 0.8356684630456274, 1.0850939583052617, 0.49085503688475235, 0.07234589035823254, -0.12142294608108842, -0.4771902535752049, -0.022699935517248214, -0.518670219896959, -0.3877089627215578, -0.944419121879408, 0.7406270197922977, -0.6128999334380969, 0.2518062038411906, -0.21109834811125716, 0.0012047317871735877, -0.11681473642471192, -0.5032482378861332, -1.0073684975495958, -0.6258609176072514, -0.5612796924282322, 1.153087958239886, -0.5308335358484064, 0.6167754038785686, 0.18128500889645185, -1.2623407758845315, -0.8722552892114677, -0.6016964894224137, 0.8983875477388278, -0.25768898623416825, -0.9986499292699533, 0.8516266842272489, 1.045919602770344, -0.5911972571340017, -0.9371857764442565, -0.7802216641886139, 1.1236420127923739, 1.2229851558377056, -0.7535240645960599, 0.011047085002448212, -0.15972675051604937, 0.6013379538991094},
    {0.1452260643393927, 1.1588123138693947, 0.38228876116775523, -1.1175711419071843, -0.5797230455458466, 0.8130449247573455, -0.8740609304160638, 0.5811633321756174, -0.9993788431883628, -0.9858119394352169, 0.37001442993153244, 0.5068414554202704, 0.6702764143519545, 0.5490354582631437, -0.5969055438091061, -0.29251683915285875, -0.17974576473012796, 1.1955477643875088, -0.8605299575383845, -0.5523687225796068, 0.23397409619544524, 0.8319893625390995, 0.8310940728803531, 0.7294295720913524, -0.7416180322029383, -0.9484113542564256, -0.06689553302212806, -0.6774413245079204, 1.0821637384120935, 0.7673842851708139, -0.2972475324552078, -1.185544767458114, -0.051424440244980135, -1.1431445838474523, 0.06687479375874503, 0.020192870991286097, -0.34495125345728944, 0.9411453935038158, 0.44470172013481013, -0.062281649349417066, 0.3939033010262734, -0.9190203757822999, -0.4189731403291075, 0.46565265998126976, 0.24279127577273327, 0.17989968134411283, 0.5458951388054537, -0.5183908222617623, -0.9416259856405236, -0.7347887014574691, -0.34016509267429373, 1.0590451282964137, 0.13903960727034084, 0.3003516254230078, -0.7701372101386619, -0.022254460859739335, 0.9032475285594129, 0.7427795264320518, 0.3940286128963565, 1.0026759715544529, -0.9472239789172657, 0.9589011433219168, -0.28909593216367774, -0.7025782101583179},
    {0.22515863691808483, 0.22262464034323048, 1.118446346228921, 1.0901253347203022, 0.7489192198118401, 1.258541485211457, 0.6375748500953302, -0.2447529678741618, -0.3465557160071696, 1.2680923168150968, -0.8564665633004637, 0.21859388881511713, 0.329390953681179, -0.3313383597830606, -0.2190757117459416, 0.38852190233508827, -0.6908733673859243, -0.22363689286478333, 0.4556366224024861, 0.4704116198939174, -0.889391495036602, -0.12093927969652002, -0.5801983731290168, 0.22245855004584705, 0.6596043473187627, -0.222618007530315, -0.07912065388496185, 0.4122886491591939, 1.118568050014017, 0.680377806898335, 0.9030074918762033, -0.6822861207330222, 0.41924122422723037, 0.38222163129370196, -0.8012017104848025, -1.1978447641201322, 0.9598106681403555, 0.08324828561252623, -0.19400230939016394, -0.04654435121184592, 0.23244201586573657, 1.046385398660412, -0.6238211368570731, 1.553472220173976, -0.6033160848103674, 0.7972954510720298, 1.20353700552891, 0.30494525805614964, -0.09413288875996137, 0.8582224973678774, -0.28584127882025556, 0.4784286209471121, -0.482088655321561, -0.1229657773993382, -1.0391591034403183, -1.0672736214709921, -0.9996095067551314, 0.9549638174500973, 0.08292352804618622, -0.6493581209571964, -0.22421868666348385, 1.0166762930393876, -0.8181051449575052, 0.9275445465113487},
    {0.8345842290512496, 0.8149176039602655, 0.1707348222576169, 0.36373701402482467, -0.6891229582394414, 1.180849271565456, -0.5009018266603126, -0.24410605211411787, -0.23592191154820205, -0.10799322618448798, 0.04832084199714031, 0.305182151298013, 0.6184769968959172, 1.1024428132901682, -0.8885948745659061, 0.09557471933045501, 0.4905293518543496, 0.3661447975056059, -0.6852823281694298, 0.2651056519755646, -0.01964979792721023, 0.1566107140017469, -0.12644256340427357, -0.33954778982169215, 0.6423502653351332, -0.24834055305636693, -0.38752087832901355, -0.46115942707396823, 0.5605236306130758, 0.2869451701157967, 0.1296467123023698, 0.5078371985923628, 0.500691455369683, -0.41680835975219055, 0.43042400497055916, -1.330695704679096, 0.5218114126795294, 0.49562071041915506, -1.0514553652026928, 0.21716348973168859, -0.3894000121467711, -0.006240216458282342, 0.8247447470279459, 0.12864623641080897, -0.7453631496877196, -0.0300082093111007, -1.0593965349904253, 0.5811992048491987, -1.0801794686220532, 0.766323585901075, 0.03785503875535151, 0.44502830151429645, 0.058930515105994515, -0.6971929357226117, 1.3469308785896026, -1.1787960274580933, -0.6957222201089601, 0.8114505454697782, -0.023416340135534033, 0.8038936742406452, 0.7307907424054999, 0.735437117231708, 0.3895403200367584, -0.6127249649059842},
    {0.4246131451556883, -0.9128580685304978, -0.5115879347538034, 0.26226393788963825, 0.8554651958999772, -0.9797463371832484, 0.4219487132391991, 0.8402638798341171, -0.0818508883437827, -0.40785540722054775, -0.2318650376051511, -0.6051663127463259, -0.7955742180475741, 0.14033526577316827, -0.8019949642862646, 1.2575840548067057, -0.9930787880135239, 0.46528715838213486, -0.265681083062557, -0.2981640441708219, -0.28911654806644804, 0.9006686561900418, 0.7469236925565148, 0.28593745586122454, 0.21314479150915058, 0.502215744703545, -0.8624704092919124, 0.5706127128210227, -0.39880083181024967, -0.2675474194001621, -0.1190978456780153, 0.9744861096539982, 0.5508201135280826, 0.9279006675556402, 0.2417742741045946, -0.26328339691088476, -0.5144377974133242, 0.3746354668851706, -0.8613591252103238, -0.1081503110129438, -0.8170439935964036, 0.4537374692762385, -0.7344769026346795, -1.0383605266502596, 0.714650687688499, 0.5591977025953891, 0.9385937844802372, -0.9665838897454285, 0.7825852050417476, 0.5649305647333415, -1.109876191645985, -0.43465967080507517, 1.168280309045067, 0.11972775289494227, 0.46122080494211626, -0.5540223578466599, -0.5345907226631843, -0.2999350257253307, 1.0109556110650733, -1.0549875208858062, -1.078951822184086, -0.28247753603876646, -0.43274095565789006, 0.29918192148988043},
    {0.6375105506328451, -0.1460038591915258, -0.03499205622579667, 1.0520553242082833, 0.8185420446448135, 0.22236620155458905, 0.5310605419876799, 0.9158873098540337, -1.1093690272435903, 0.12731391769396078, 0.6516626399686729, 0.21635926147048584, 1.020588971042973, 0.0005003080288269061, -0.8308792787009005, -0.7807474161584166, -0.8052212936890778, 0.26244885305672444, -0.31081501864940597, 1.2093605702718202, -0.4911518828163927, 1.020979086438927, 0.5854423003842869, 0.22338345841636548, -0.0360197644683804, -0.4596468871246809, 0.6849865448983299, -0.952516654551748, -0.2662001948433393, -0.19719507555929014, 0.15910180849320774, -0.2112707781598918, -0.216172069183937, 0.6441747131836579, 0.6331573312293728, -0.8745308610686371, 1.0920515808984634, -1.0054634488063638, -0.47445784586821677, -0.9223746228383319, -0.23273517542827715, -0.6809742052083314, -1.022652501717786, 0.06923183687083909, 0.9236598111741556, -0.6824289062207527, 0.6732704477856593, 0.35221420040329937, -0.2727027794499283, -0.05940480127086238, -0.5902199288451493, -0.9757922386308137, -0.4475053325265284, -0.4108880525330288, -0.14394418448259785, 1.0320858674038258, 0.10218129343317915, 0.5181895475538314, 1.365571074479846, 0.48726784156935304, -0.7690808377010746, -0.5641420777229261, 0.7737094040265167, -0.19141226192571667},
    {0.07466624565473134, 0.34278723459945415, -0.07511029721420374, 0.5161449158352442, 0.16681433581985272, 0.3951278741359382, -0.5262776809556222, 0.06210151667371554, 0.2366519684736939, -0.786748331425623, -0.8156538352089502, 1.1032738334068355, 0.798067153439128, 0.30191206125509684, 0.17703082264273712, -0.5784758605384761, 0.35292442079901465, -0.6218502116658446, 0.6834647056959389, 1.233074297240412, 0.30003998373041035, -0.6363455363812887, 1.0262496379757367, 0.7675364076167622, -0.25482596194631724, -0.4202361941232931, -0.6771311099436919, -0.3066270603786958, -1.089351218036228, 1.0828037650962818, 0.9096055567224672, -0.5887302499041079, -0.585212636171077, 0.5454313296029584, -0.15958706241947535, 0.3148415537624462, -0.03022998225557553, -0.5200339103639724, 1.0079955826725968, -0.20782061813980576, 0.26476152838469974, -0.3082594763376597, 0.38325291417248003, -0.8865582131640148, 1.2798355979766385, -0.4015417597445496, 1.031673090787278, -1.1631051779017734, -1.1912775518762369, -0.5748539432544992, -1.0901225267684425, -0.20715646502049037, -0.6570384067908375, 0.41926405944975226, 0.7636373298039366, 0.5648190391218458, -0.3978652380980325, -0.5242382948541835, 1.3303048774994397, 1.0100088296553855, -0.0890098951326161, 0.8417868773966546, -0.5231236471457582, 0.2307250736732024},
    {-0.1938054578279638, 0.19465208356015268, -1.1773621137196457, 0.010093208054367626, -0.004744292973854544, 0.5950803323432253, -0.653839640698862, 1.2657007100768352, 0.8341768848771627, 0.5491285059147905, 0.19327788381932204, -0.7468549210066677, 0.10227755849928725, 0.5247146952587487, -0.01611775070994115, -0.6979403728223562, -0.5530828790016243, -0.2141338954735678, -0.4894518102398972, 0.15262038627843108, -0.32677470251084145, -0.07319787132817385, 1.374480052355062, 0.5812384404083732, 0.4648130127775664, -0.11708233055090725, -0.01615343279739304, 0.7271903702643299, -0.10196666369210111, -0.7928061478634785, -0.48882343211268964, 0.24177857794731825, -0.8621579343490114, -0.6821419773306509, 0.9205507009244959, 0.2614706399128493, 1.2551329678111685, 0.35096308692260797, -0.9834470803649626, 0.2213352312910898, -0.13964877824113012, -0.9219444992514878, -0.7263367280535395, 0.1226205251312642, 0.8728198244410302, -0.040122525856360586, 1.0012640419751726, -0.46423709550099207, -0.9048651359748329, 0.8236567498547631, 0.23481921923368776, -0.3084783513937131, -0.2894041894578322, -0.1274345703978228, -0.30135560512707277, -0.018095228717407395, 0.45870399843348375, -0.5750360130925809, -0.9464961556475167, 0.272788489656839, 0.6374593168049644, 0.3536332307926285, 0.5039305747611676, -1.0804041082641158},
    {-0.07794501626203934, 1.146262675481423, -1.1543631032790074, 1.0138941404491613, -0.4734331887785823, -1.1879747216383743, 1.085193829819825, 0.061971513967505734, -0.2879984493562871, -0.37584456655634285, -0.7565999353334728, -0.5860281072733416, -0.9823824839090491, -0.4869504504530841, -0.28378698156144805, -0.6713025793134375, 0.1647314410451759, -0.573560919082356, -0.23639735960610367, 0.3156866734418709, 0.5865325511399678, -0.945557891361842, 0.1438848615162895, 0.25747547292336387, 0.09118110300475925, 0.16252298127964043, -0.33582463943017343, 0.9788737349873006, 0.2247372344171371, -0.09846625218414756, 0.07448991759925631, -1.063656935671292, -1.0300046307827355, 0.031636532080035244, -0.6817209929817658, -0.0278782121360421, 0.9291498076680678, -0.37064763839775444, -1.0861910826225374, 0.4696221635238814, -1.0268615399917953, -0.23195070628873393, -0.7965537805349574, 0.19081805240750613, 0.39786692594995693, 1.0620440424804491, -0.9275222388953055, 0.916174290647354, 0.06859491594298332, 0.46525510989692676, -0.8580871899553755, 0.9172645025680137, -0.9174445543586984, -0.8912845007141049, 0.8720117747222431, -0.8177058984025503, 0.21023575758146162, -0.8717776459019375, 0.739462620632316, 0.3548795798490975, -0.1563495384419764, 0.8267167274127928, -0.6253123876994781, -0.20503772792470504},
    {1.0387116955106945, -0.6435199318338595, 0.1402204111803481, 0.5397244649155925, 1.0529642280801843, -0.07296619236259344, 0.9534671399528247, 0.6322356826004084, 0.3908544499880474, 1.199264587510619, -0.5234304693702067, 0.858446898997828, -0.728918868886647, -0.3309108343917766, -0.264030053925835, 0.5483626707129237, -0.7441361243632582, -0.22139526675473753, -0.7944951502847017, -0.5849499007450394, -1.2411229266675878, -0.22291808426278903, -0.8418090979836735, 1.0478678770937946, -0.5572011244616542, -0.6704529907950278, 0.8407551555165845, -0.3333269035517747, -0.44238585617148696, -0.8166308076976593, -0.08184409019525048, 0.7225633778403389, 0.034867554316966594, -0.010380425823357966, -1.2373177768092773, -0.46376986804624437, -0.607985652454512, 0.058173632279883196, -0.717218427148594, 0.20265109101673126, 1.0468796773622915, 0.10663549925228491, 0.5894644425504515, 0.48649836953040493, -0.531233480239539, 1.0223230828613303, -0.4755422985898552, 0.7931296476265293, -0.7787617387971981, -0.6363463088779645, 0.16178567161756302, 0.10582121734825362, -0.12378161784095525, -0.11004516979968422, -0.8457644836043856, 0.7086778517232866, 0.5542167569033246, -0.8319266438019578, -0.05713136213556657, 1.165480435089951, -0.39055550643867426, 0.6906162035325333, -0.8263403677091572, 0.4655337093283592},
    {-1.1862904469446856, 0.6888617730597177, 0.4830699718720755, -0.08727503691913865, -0.4799926353054824, 0.2792836631724274, 0.54739387498967, -0.8009314517276909, -0.5220487762136613, 1.1245421102103956, -0.48910180811585136, 0.3322187775526015, -1.1485313185527255, 0.42631006956649686, 0.5244863686951767, -0.2190382015092271, -0.7590584790015995, -1.3062985731292514, 1.0325422626387382, -0.22116241168733883, -0.4317242142971159, -0.3179984075258822, 0.48790331997763275, -0.06367762802756889, -0.33287850515640705, -0.115192937119148, 0.41449197770554624, 0.047357154899546526, -0.6812349518873467, -0.021169363037836057, 0.824242924417246, 0.2472916813528718, 1.188674284456727, -0.48246176820129116, -0.7921446284764073, -0.7000379232475397, -0.5858709108292506, 0.20747629547578436, -0.28860033453417516, -0.4527824758280474, -0.8418950438223742, -0.06606427181598264, -0.5069252675089768, 0.010804874401492463, -0.18721643818076392, 0.5009667847019902, -0.3033214475111114, -0.3365008101276113, -0.03206936522750134, -0.7742998747860084, -0.9224393578818163, 0.1576192953449746, -0.24295447416593768, 0.5893384024701489, -0.3809941102249175, 0.33771870254325553, -0.7865788772010002, 0.8373624682747217, -0.04916414945565197, -0.9701178010300591, -0.2922620402714032, -0.3532845178684081, 0.8109087050255336, 0.329202911627992},
    {0.3182634142234547, 0.8192303387105282, 0.7426978850014956, 1.0770060533342314, -0.4566268175018304, -0.5427552140253146, 0.17149188023132933, 0.289674205908509, -0.05050747850921334, 0.921835930987351, 0.22085679086686935, 0.7893461556234871, -0.5734180185311417, -0.7650289169571864, 0.32046832175938894, 0.5016797107176517, -0.5864974044738664, -0.35192857223014246, 0.3736462864883211, -0.10209257259657208, -0.277006804029347, 0.6935554579073115, 0.10117420297943261, -0.5293507266377868, -0.3584884375835855, 0.017401317966405285, 0.9507839595666903, -0.28429731120749124, 0.2664172835060504, -0.31071885777211705, -0.006238413844337486, -1.2036612596836522, -0.609439453371495, 0.4633341519735445, -1.2274565567928946, -0.4221135147019278, 1.0577954027004937, -0.6788518984045874, -0.22410708739175514, 1.020472322154269, 1.1080616649968802, 0.5937475184979204, -0.8986595329122742, -0.5642266044191802, -0.2196759463697833, 0.39116514019560417, 0.6717783851288738, -0.042268323896079776, -0.5456882802091445, 0.2586241335635638, -1.077932721035045, 0.798725548373083, -0.8342864270183489, -0.6602969116054521, -0.9284812338649302, -1.2673241272272082, 0.6101180502092061, -0.9499691590467193, -0.7674884333876453, 0.8619329723161063, -0.7790264558854808, -1.2864436872792864, -0.6479607205829567, -0.12095950945594458},
    {-1.1808281629074928, -0.493501316459555, 0.1882779563866842, 0.8744601866044106, 0.8585423276492289, 0.5399311030886546, -0.39325076377042695, -1.1401231631998914, -0.4012753476277922, -0.47032523472365806, -1.1123563560341694, 0.2825052105652738, -0.30532221496546236, 0.5913435960453616, -0.16069171078409275, -0.21260593107202772, -0.8564308994424479, 0.6928660486704459, 0.07056485590550592, -1.1373536078751014, 0.5019557614251875, 0.22987260687499234, 1.125836196443927, 0.5316441152126462, 1.030708772361023, 0.7398010091212189, -0.6979859843174535, -0.44645081413878374, 0.6119859933765243, -1.3283632762852124, 0.44541684133876064, 0.09860579941011244, -0.16317291881997315, 0.7226254534531343, 0.6730054095963152, -0.14442337138822747, -0.590901071073521, -1.1484672059780636, 0.9345433969934067, -1.0268818158686532, -0.21043972371202765, -0.27727114811187537, -0.7906213128319776, -0.15324072528221, -0.48480527060341366, -0.6162740422743356, 0.6712228078872242, 0.8982255499903552, 1.1669978103443701, -0.5536197882412406, -0.9524094839060842, 0.4656877804857829, -0.7401702051188451, -0.651851149948091, -0.37920777130799305, 0.6386856402239015, -0.8678983761751493, -0.9271508107016548, 0.34483448085689816, 0.2567953608564802, 0.7714723299413578, -0.9622153043765638, 0.8787350794981063, -0.10076194608084924},
    {0.5459820448567372, -0.1590132212706491, -0.1943033006658912, -0.5790806055853042, 0.7198799862265327, -0.4808702111951827, 1.2154235629070826, -0.2528587784491489, 0.8585440351608092, 0.39539457680795853, -0.80181253947648, 0.8328481901962997, 0.7897338154995969, -0.5680530940702156, -0.014036351971396247, 0.8034257308806375, 0.8885858338493821, -0.978833054221004, 1.2049674729197015, -0.6212062905197727, -0.7637284636975571, -0.5447266807649497, -1.1223132765531596, -0.9802465521051058, 1.2406197495396318, -0.08441350103436605, -0.25766670652760487, -0.7630160006915523, 0.4272193865774624, 0.431395404963778, 0.3098956754347041, -0.9593595757263406, 1.1841419106208448, -0.20533566442296544, -0.35891362643723784, -0.6664476086825265, 0.08337858199765957, 0.8122477375548753, 0.21261544592392748, 0.2034979330158449, 0.6224046895179338, 0.9699857419681117, -0.25737096170178486, -0.9494397650901941, 0.08158488957734386, 0.8081956944526364, 0.747144494825329, 0.6063697617578245, -0.6024529860517605, 0.8648892536065793, -0.048659216531422175, -0.5123794936235042, -1.0145048231022797, 0.10563145618975861, -0.3893121089581523, -0.15199293228257926, 0.9465117065759749, -0.07352497454067394, -0.04219472616463481, 0.6252068399857067, -0.6722432658220248, -0.41189546868768706, 1.2788251733818221, -1.0287298673640572},
    {-0.03213840209949542, -0.2581550508454042, 0.9875811895243323, 0.6432919470057022, 0.9874533585250257, -1.1573407643889069, -0.35185532452355833, 0.2881686017060586, 0.5698687509692822, 0.662979428007855, 1.1435869834900088, 0.10182764590494058, 1.3134577547600546, 0.5348681444593819, 0.14658618302988832, 1.030372738106316, 0.24140466794696291, -1.05029612694524, -0.21897123309337438, 0.035560214794668144, -0.317324378642098, 0.23388545683256232, -0.6014498340885014, -0.7706984012416522, 0.36960405038887245, 0.6104073417336525, -0.07036637934093218, 0.5377165405542975, -0.28221941867804995, 0.421824446017838, -0.9488757817260034, -0.7926458029778098, 1.0798975485725733, 0.6066433267857451, -0.0025444878349617332, 1.0097136850699782, 0.24552454783683667, 0.7073669525830458, 0.8952423792366127, -0.3050032472199317, 0.026985609478494134, 0.5603025457471569, -0.03897309711442182, 0.03772850031425009, 1.307124343947704, -1.0973072509501154, 0.6804415139345668, -0.9525350315297787, -0.7416590910062223, 0.8783411582022127, 0.1903602411176885, 0.027302635987050777, -0.9648265150941386, -0.3757890924095792, 0.5271325314680688, -0.8550071760386648, -0.8047723432699578, -0.6272731617803501, 0.08602586790026406, -0.1282910792764478, 0.7623013114646595, -0.820126883106124, -0.5486841631008929, 0.068356864931959},
    {0.9398279774964851, -1.132119759059346, 0.37670543261036876, -0.7613999137917288, 0.48105743165796544, 0.9956709108771785, -0.49823360694280716, 0.5281427175921901, 0.8046320150391301, -0.40587737855222983, -0.9234264900086764, 1.1906492607365362, -0.8982617392901423, 0.8516098856429712, -0.9443753592835036, 1.1109031494883903, 0.7850534748738358, 0.24134083906075343, 1.1449907024623736, -0.519457907785299, 1.1081524879206364, -0.619898497880054, -0.812349411928906, 0.6119945710336268, -0.8442053123632104, 0.4564147877957621, -0.131951920599368, 0.07180986017374105, 0.21916562054346167, -0.4396294956036102, 0.9220043575433552, 0.47770154447683133, -0.33913190530758736, -0.8816694528183454, 1.0295203735724836, 1.1725836585432974, -0.15422967527017506, -0.32655137185557986, -0.9523322076549338, -1.0174197462972097, -0.6856633482302326, 0.9387260400581688, 0.49660724833912256, -0.009227508897440668, -0.8893790810152357, -0.6952485272484168, -0.13436719193888966, -1.0271725886958802, -0.7123329799346358, 0.2689119343827119, -0.5458386672439489, 0.2693710661711675, -0.986256922138486, -1.0996639665214285, 0.2583898233015333, -1.1597539475715284, 0.8017040605226836, 0.4618032728555301, 0.18858212697559393, 0.7125319698660849, 0.27603291806373653, -0.5957235068480821, 1.4318765875190997, -1.088128142532176},
    {-0.009694412795940806, 0.18982158408272398, -0.37233363854008134, -0.27485827718381733, 0.9437728761525096, -0.036457936224424226, 0.40863209797180405, 0.7708122885376023, -0.20080937579332775, -0.2550923674585993, -1.0680242267639768, 0.9289649432866753, -0.22686312889859905, 0.8480640513657248, -0.6769253172449087, 0.3153415478997482, 0.3715161250461461, -0.36821415342541786, 1.069073274856813, 0.801186401272091, -0.9964541706008344, -0.6326294924721577, -0.0019271202987446764, -0.3607725653627107, 0.7962730853443982, 0.3355660335503591, 0.22578954043874389, 1.0673261880236586, 0.5528428184468357, -0.393689732453597, 0.6918350784685375, 0.03413572170029043, -0.4605728781007803, 0.5245052543347565, 0.3403329530421964, -1.0155964948500085, -0.0348010448338948, 1.1456893515025734, -1.0248266628020608, -0.22277502430918283, -0.35485841678072605, -0.6349492897844173, 0.7983022227084158, 1.070087805029203, 0.47309061121460116, 0.8151457579189114, -0.6853083987200292, 0.5122473423069057, 0.9190199062617576, 0.4399845255723566, 0.7813623169687813, 0.5318161989833902, -0.9164784385159158, -0.12501100171424434, -0.5586547007095205, -0.7121581969238274, 0.0052153461707360495, 0.7482391530650719, 1.302757948465996, 1.1886126828113208, -0.5588999569473635, 0.05567460621593953, 0.4634090461313926, 0.01665106707750738},
    {-0.7086986404905352, -0.45444017271705295, 0.18331432291418287, -0.6703843059840531, -1.067793064293898, 0.16832155713643418, -1.0306151054252988, 0.5707797947905243, 1.0839892885363005, 0.4241059518789642, 0.3048974768025278, 1.222928250188436, -0.03557152832075633, 0.021278422307889282, -0.2513342646593873, 0.6478901489683375, 0.3919364030502698, 0.7813523456086128, -0.528633701046402, 0.09166460593459208, 1.0171624045724303, -0.5013552039419611, -0.9015263358407235, 0.6940639219812633, 0.4341095830383429, 0.43698035041805705, -0.7870730584769029, 0.47286998162206995, -0.06175969308699898, -0.679679344591678, 0.12404124608526075, 0.9073753030528701, 0.35513352761807815, 0.17173621388126084, -0.9025171391220782, -0.6270532803860037, -0.553901461666249, -1.095117037206354, -0.22607285719578882, -0.35102794768470624, -0.9714379336767626, 0.7682110051554886, 0.48345238246298416, 1.361162012926521, 0.9559451450869666, -0.9212797382210924, 0.721383894953017, 0.7853658489185852, -0.46641483072408557, 0.8126367455357358, -0.6817170370576727, 0.43376505492779044, -1.383943639686912, -0.9196827594464083, 0.0503935194502564, -0.70538018942975, -0.4632306421004932, -0.34558949958735424, 0.6521447037546001, -0.051161976831889985, -0.298430425050846, -0.005482375663044377, -0.7421882641370237, -0.13137923414077782},
    {-0.8382069966394381, 0.40714765758458743, 0.052184834149159545, 1.0417157121366403, 0.30228192402051707, -0.7992965135139609, 0.027041732403627505, -0.28768759060177884, 0.057113200153212106, 1.084605778639751, 0.7218680822022606, 0.04236568314505708, -0.7314001750362977, -0.7219032873761478, 0.4413426959819269, -0.7725666585760237, -0.2641804397488966, -1.1721633374697773, -0.4734739524175698, 0.7173814454094175, 0.727017867832455, 1.094220848683397, 0.5826674911498995, -0.0996191567821089, 0.9656234194176446, -0.46579047804851603, -0.838246661580893, 0.6270778758882645, 0.01858128682031944, -0.7956883067120772, 0.5977425516933603, -0.05164335738359183, 0.6067682229492714, 0.6634870238468763, 0.6211686707473439, 0.45550524103374873, 0.8765905362247687, -0.9626996176189052, 0.9477671396087402, 0.3874874821113903, 0.1461603957431301, -0.079943195770691, 0.36525758030079514, -0.23606015024529745, 0.939604551228799, -0.058847192172623644, 0.2781359902892088, -0.016419324578721004, -1.055700694603931, -0.7154173544135383, -0.849748856259593, -0.6766540809692468, -0.339344433819536, 0.15632152448626288, 0.558124812568445, -0.9251049444470668, -0.15745868134465124, 0.05885824832544885, 0.14745352755294241, 0.23523614502327453, -0.7292454326384832, -0.4397652218814668, -0.0757217291840944, 0.4615473585938437},
    {0.85403021726042, -0.5319825579772713, 0.7526133789256144, 0.4985139945302282, -0.03503849686691256, -0.4453545137155715, -0.8800931892444462, 1.1029122658319659, -0.7735179273293299, -0.7320847392051478, -0.6827195394009204, 0.41953563295686624, -1.178101171450703, -0.3813267158724092, -0.6497002195266129, 0.6206886777040665, -0.7324393981499778, -0.23206494280832027, 0.7767699942911337, -0.9286119853124069, 1.15938533249181, 0.7927237571014593, 0.49540511958756234, 0.3714241596992199, -0.012853003462606951, 0.11950547399098682, -0.12095085662250957, -0.8192200936721223, -0.0890300758157746, 0.595091083379193, 0.8528833636402346, 0.8985044167295574, -1.085804497550836, 0.5033008898142486, 0.31190896157474224, 0.5001378063215204, 1.0545955392643358, 0.5840490305910403, 0.7649105601426562, -0.29152002091584966, -0.8358582653572754, -0.8568911384760493, -0.05198253094344349, -0.17880207278542262, -0.36615823454366586, 1.0029495472912069, 0.2871179500572098, -0.14007694101384743, 0.07284180505663776, 0.07342921150469582, 0.8206416049477459, -0.5575804119440984, 0.6316733389739223, -0.38763407522620885, -0.5759849200659442, -0.8944113503942225, 0.09247839864949396, -0.452128360274962, 0.4504078261499545, 0.9479341572318117, -0.2443588876004968, -0.811211228977389, -0.5644533210601254, 0.6503118106839183},
    {0.061319136835848685, 0.2997940198006818, 0.34416514402912207, 0.7277838016994073, 0.2702737344670398, -0.4389114701101986, 0.3979685942599449, 0.7620389068854835, -1.3151111573022585, 0.8171027759325625, 0.4297145871248628, -1.1486597242962056, 0.3532683730429018, 0.55642807326166, -0.46637064346973583, 0.5130530446262493, -0.5171252498676573, -0.9628153619465691, 1.0944740022758876, 0.7019769598534132, 0.8007788441175181, 0.5847648209537387, 0.015388947212063422, 0.3696329069909535, 0.9249918830308407, 0.9631155611247151, -0.9796973012766994, 0.9460412009007532, 0.910456541818674, 0.027999492185456717, -0.00013293335232247792, -1.0163742962437115, -0.969657148758096, 0.7853551740079479, -0.9904290905012317, 0.9569898406700149, 0.8640755804705613, -0.13422328838575476, 0.8102952111820209, 1.206155572938606, 0.685283522633154, -0.667458399302226, -0.03874185948968578, 1.0532553470942676, 0.32897215369321875, 0.5931526816169439, -1.2143263634522343, 0.6137771540230753, -1.1563762942364775, -0.4213557295113445, 0.742089261073524, 1.233917028316259, -1.19861816622094, 0.41173629454690464, 0.9503151799184855, -0.8513517737832914, -1.0377761982949312, 0.9626574436284159, -0.6466856794358948, 0.06021598518011825, 0.7973118772295199, -0.3954670084475576, -1.067311652438647, -0.8548040095911678},
    {0.3730074644911848, 0.9441889224715554, 1.0172508906345616, -1.0186086973275024, -0.5172627986138574, -1.171334773944624, -1.1170557562174808, 0.6771475705942668, 1.050351464437496, -0.1460816255785164, -0.5607127906329773, 1.1119347877866428, -0.7830858851244695, -0.2945407694001559, 0.5563654193277185, 1.0549510222881262, 0.3423914174837311, 0.8618903458433393, -0.3841159447211095, 0.21809849561011774, -0.8456593758996291, -0.360717962108287, -0.6797453399599132, -0.4010661248137281, 1.3370476516069556, -0.9808688450771363, -0.05875650144840353, 0.7416511628016753, -0.1430971170593972, -0.1898967040596184, 0.4126183626860982, -0.040900451377957905, -0.25140611808203983, 0.19811979172172228, 0.9399601147483473, -0.5411187543533842, 1.240454779396621, 0.5602929215015087, -1.0514979173802275, 0.39293056397905257, -0.5661112977402238, -0.1563164458812917, -0.9346666714430616, 0.7120077743614265, -0.2528018329296797, -0.594797906875725, -0.8831536728083189, -0.19949773364492088, 0.8280985009328178, 0.27150535210175664, -0.17536552999635308, -0.6870239469144459, 0.8314327079913748, -0.7349320362177848, 0.37842706359883843, 0.8435618903453204, -0.36174063571180237, 0.9997606644053711, -1.2723471097747823, -0.4909493373306649, -0.22398865529403456, 0.9794131058117498, 0.990005778530868, 0.2445812699680813},
    {0.4575651417586109, 0.8432104054888342, 0.7861146354147673, 0.2575860169646696, -0.39696493063604227, -0.8400533664137555, -0.6720009049917205, 1.0632127249500283, 0.3707176704287136, 0.05428863947588165, 0.23916343826256264, -0.8040167348729441, -0.8709056855408781, 0.038742149900209924, -1.014937723659616, -0.34662581679914645, 0.8886869174776003, 0.31346973800981365, 0.73222353195297, -0.6081429784093082, 0.6852932760006094, -0.5794129193960207, -1.0962035303403797, 0.12035360719353494, -0.536898992933359, -0.6687152388658778, -0.03667580624335601, 0.14564069082246256, -0.6008142254553989, 0.6161830249359251, 0.13438730694600418, 0.03187169963210783, 1.292235310545484, 0.29737783525820677, 1.029258637312702, -0.5410139978392732, 1.2703154695616594, -0.4048104320580952, 0.48265144909509494, 0.30459694947342675, 0.7074267584551429, 1.0626885403710093, -0.8687561036361083, 0.15934210701222384, 0.3112304009130833, -0.3169587374031664, -0.2366124434161115, 0.506270448370612, 0.461728198723084, -0.737529706483372, -0.4357897179831549, 0.9636234989334322, 1.0321017674180533, 0.11955826052415552, -1.0758685824241376, -1.0011904844315553, 0.6741368966192764, -0.6185538803438935, 0.6251745156101393, 0.401233333999412, 1.2672510870119453, -0.4553466049351798, 1.199544851138216, 0.06656987943861363},
    {0.9233424057517875, 1.077529208088374, 0.8958867322936913, -0.49965996735660506, -0.020402542178232338, -0.3562495237597512, 0.5925356649094914, -0.5674649256152914, -0.4688674332448796, -1.1268380992884337, -0.7141613169427443, 0.685253867703543, -0.06803503767997472, 0.4483421342107062, 0.3450007758333635, -0.8552128349006579, -0.15298811913424384, -0.02913840534542477, 0.4097536939918368, 0.4068458323576387, 0.0755190395199885, 0.022974394104156835, 0.6880574598470386, 0.47289696130888215, 0.5900480381532918, -0.34892344192170344, 0.3146450049349861, 0.19623862199923417, 0.8870894979740226, 0.46416655256764766, 0.21674311318244133, -0.25172933609429116, 1.0078200822718664, 1.141774775484819, 0.0855609353525873, -1.1991798902348942, 0.5685268968784258, -0.2558036813513727, 0.5995974974894364, 0.671176817720767, 0.00593932742539199, 0.3731291241535029, 0.032172125950194745, 0.265705544448888, -1.3522562895483798, 1.0828434861129723, 0.5193093305709611, -0.6129514755751443, -1.0900894629178117, -0.6564966188937951, 0.6809055775223891, -0.43991323631981194, -0.23572019800509988, 1.1433124340162404, -0.6164275736959836, 0.6769816446117336, 0.5667927270906482, -0.08940123648502289, -0.8328767843138422, -1.0093944968261919, 0.20615962584379477, 1.024988063379584, 0.40334967440374886, 0.8223593574114763},
    {-0.5268967308682819, 0.8000537888136354, 1.0772970603268726, 0.7608415490307507, -0.17487334293293338, 0.18178740993623763, 0.7758183112747767, 0.985030803696812, -0.8057433503966882, 1.0127711295582176, -0.14036283655687307, -0.8158228134381594, -0.9722821965858748, -0.044483586746444585, 0.1700963591409774, -0.22094256534365317, -0.7663830344771756, 0.2217501799458083, 0.8772843122565155, 1.0868237040513478, -0.2213924492730238, 1.0397247655347863, -1.0714284782622414, 0.97737675957086, 0.7347594972826881, 0.650230409074686, 1.2589682887663702, -0.7514056612336883, 0.3737585811696187, 1.0930062619017202, 0.8595627596258008, 0.0944382992656668, 0.87482577027384, -0.4921146818250336, 0.35151545779287835, -0.8896519511546142, 0.9992758682613028, -0.9025604285083559, -0.0958754406889129, -0.7739671719980386, 1.1888057432011148, 0.1681072082036309, 0.8051235124230788, -0.4254466678549277, 0.582522186280324, 0.3965373208692988, -0.03911372303968949, -0.4388154507834554, -1.035909307115805, 1.0909410639848847, -0.7559757149845313, -0.8467244627767326, -0.6126518764136956, 0.5717812996259375, 1.23164420187545, 0.2201241069913228, -0.40269396556509146, 1.0246750543030931, 0.317224281466221, 0.29666053633634865, -0.6482837717752918, 0.6701926954136292, 0.44617756081798854, -0.5153441646471768},
    {0.7551416250702995, 0.8460608426113932, 0.5512700895041558, 0.08765486831545567, 0.209779225965232, 0.8130225645594978, -0.7160759121631172, 0.718007049860609, -0.27845321016458474, -0.8677416075782235, 1.2717583971901336, -0.37692123578898623, 0.9063625499418683, 0.15943277330524955, -0.09356182328161167, -1.016924745059313, 1.1631311232809707, -0.39378259906386937, 0.5267535962970105, -0.1458284703753837, 0.6020686157976844, 0.7705222978063736, -0.5074603247066402, -0.6143613056604792, 1.1177359966973572, 0.664887441160189, 0.6432262155879812, 0.7946201194145689, -1.016156443881961, 1.3140301344429086, 0.7766619212363582, -0.6084952439922546, 1.05415765625297, -1.1470907350963004, 0.4737115601149244, 1.1767797753315345, -0.3513980069770563, -0.28530910190084974, -0.22395118128789357, -0.7610224852023171, 1.0711965339949343, 0.1101605171742529, -0.5349768200984083, 0.29753803888461416, 0.15996790430914304, 0.876976684418419, -0.17092927794140736, -0.7559820519223258, -0.43686357783396934, 1.1563695067158335, 0.5604553361571867, -0.504565316103111, 0.508508714584351, -0.4449258973070473, -0.3559369586880932, 0.13252485729465413, 0.2250071691436388, 0.4542249583032921, 0.3823976405265923, -0.23578863147226242, 0.500892771481698, 1.2329693144111904, -0.5711568541179057, -0.2510917699948876},
    {-0.0804101096627466, 0.9559983667334416, -0.3478287730934675, 0.039305935706591494, -0.606293648898218, 0.9362573150399517, -0.12016526407722097, 0.7515143696772523, 0.16888268143961743, -0.9009372615440805, 0.49385036090976664, 0.6034608877007082, -0.8784264302089843, -0.6799884358250498, -0.027147983410381757, 0.9122133536142889, 0.5585584943448407, -0.7957216417560317, 1.0920560558629568, -1.0124494837228126, 0.29251277724545016, 0.747362831131869, 0.5002688301292639, -0.8633785333820357, -0.20278317134175605, 0.5725248237479245, -0.6551059074328752, -0.5491274369582722, 0.8220036074573451, -1.1439205317947452, 0.6382919322920486, 0.9226264876880453, -0.6214286618514455, 0.6440294654700518, 0.6665372502424768, 1.1834700687784656, 0.6721817516945963, -0.6870744623816859, 0.6632891121509852, 0.24089626934036412, -0.5842546066975642, 1.2218809642001145, 0.04062482385663259, 0.5824402871928657, 0.13282489402610176, -0.007189607382863103, -0.019934523908188066, -0.606615017040773, 0.5036698110755218, 0.4039546171863023, 0.5416147552317419, -0.7837089695726244, -0.26154091764385556, 0.3360194135481008, 0.2223089104118425, -0.6611792342478249, 1.0170722743465699, 0.5934986972011759, 1.1495759195691255, 0.40846178039115616, -1.037219156175047, -0.14589490605836997, -0.16971533190235846, -0.5563504000599192},
    {0.45476252122778865, 0.9487678873828224, 0.6822227047990079, 0.7808721278610621, -0.3231045782725518, -0.5717610272344774, 0.8741951137210088, 0.2778914573984458, 0.7830513398894243, -0.6540585960426601, -0.8079895562209508, -0.6535043046320238, -0.3388230263665724, 0.9861274225281997, 0.2887199248696308, 1.2218807006782426, -0.8203630952492231, -0.7657355627841033, 0.5284738673588614, 0.9314145730338759, -0.6316111719652695, -0.9186677743271888, 1.1580265666211995, -0.17844914901876588, 0.9421218632110301, 0.4512269076946736, -0.2717853639784277, -0.48475563746644523, -0.14762929479247403, -0.9334112872360754, 0.4339469328402436, 0.6503277254576852, -1.011137559440989, 0.7770189208901775, 1.062048267163158, 0.2799505347006505, -0.11569928232976134, -0.7597921563162687, -0.47811822709334195, -0.9155225353932241, -0.9602685771611917, 0.5773720056139867, 0.7896316587437014, -0.061161535631581186, -0.8629470439563076, -0.617207948417332, 0.8340428374099416, 0.6998443561537776, 1.2950205386290854, -0.2755115890235614, -0.03165248401160866, -0.38135849867248345, 0.7360846607364652, -1.045365183191379, -0.6027626387784618, -0.1690937282509288, -1.013298672649568, 1.1523082313777475, -0.8292879228396615, -0.7858664943224959, 0.45294806962400913, 0.2167217543274591, -1.0112916543816748, -0.5262171532497082},
    {0.5432395061663362, 0.21663438159470885, 0.6209885248258666, -0.6955946479872097, 0.34554985852308034, -0.27555543994997467, 1.0521369868745254, 0.025229725529330182, -0.6351700002648989, 0.5663181687489746, -0.5842895337007377, 0.5280684094515792, -0.9492704415266351, 1.1709476946149, 0.3938262242505026, 0.12975136535963055, -0.6464970452389457, 0.8124676304268167, -1.2132888977342104, 0.06359294166235194, -0.27719381760225065, -0.7470631455034468, 0.7437915262004464, -0.3021107836582001, -0.5938106125391652, -0.01288713735977912, 1.0155649401545266, -0.12113056472003669, 0.5429891045944847, -0.6918406315305669, 0.9137918581234685, 0.20571947104286867, 0.384009333984033, 1.1538952696229339, 0.3815980750081037, -1.1652207744740348, 0.4311773829259372, -0.6924502254463133, 0.5546743094928996, -0.525234744086934, 0.5289942641561648, 0.47532161673558254, -0.42928730238800566, -0.24039498812507842, 0.7253628295838582, 1.1649247295227454, -0.6063881708847036, -0.7836855130434646, 0.27176614525464426, -0.9349792820515102, 0.04499663758923807, 0.3836644394112668, -0.2084607559352613, 0.9381547431246211, 0.6548018709345296, 0.1343124834267183, -0.03303006495817866, -0.5400190219049731, -0.1679178792510179, -0.4530837827057434, 0.4817764994280222, -0.7138502305357214, 1.0950521530477246, -0.7685683361905277},
    {-0.502948750704409, 0.03132543688801492, -0.5886281031736129, 0.18932658297599142, -0.6133652074608089, 0.5664084084961216, 0.8675541014920827, 0.4400550251173641, 0.2538861514424223, 0.14708544183095312, 0.14681720315410152, 0.2913230721647462, -0.7221086814530271, -0.7711447134616868, -0.2906534917626861, -0.6330754829602983, 0.2890518214972813, 0.5358005571408654, -0.6038474366591218, -0.4075270530957851, -0.6854950865945453, -0.4434281709349512, 0.20736997720583697, 0.13158472601418916, -0.781313253725565, 1.2093755860217006, -0.5377898118491756, 1.1829411604554756, -0.3632168811004405, -1.045837397347529, 0.08494013084135064, 0.9131326836300991, 0.9141223739385483, 0.40336334045348676, -0.09396279891510295, -0.5992274710662091, -0.8546741269132367, -0.8721323265827771, -0.03160582445087592, -1.1414978414781465, 0.3799149173867393, -0.807754456266846, 0.8391887126580193, -0.4943509460945271, -0.6015364614802282, 0.5223993615995782, 0.5819409899093543, -0.9334398911067685, 0.1737232468141873, 0.22907253398704733, -0.4589942152514153, -0.8638880835953361, -1.1219344724555496, -0.8338523837431734, -0.7654861136211881, 0.378081825804202, -0.7383144741329695, -0.21953393312711256, -0.10533783629314065, -0.6798671608935003, 0.38336443475218884, -0.8958118809874749, 0.4510168299924109, -0.52068433809166},
    {-1.201977269182404, 0.7894026751711101, 0.6894011146187288, -0.8452808434392028, 0.918435967908961, -0.8702675102443134, 0.767628502200658, 0.32921787964116717, 0.4793121811756616, 0.5231520185775326, 0.5621118810894277, 0.27875866043955666, 0.10599027346637457, -0.39694304074549147, 1.0279261765153267, -0.25418658607999595, 0.18856205366216544, 0.05344250057773895, -1.0968706349883, 0.7282480670114211, -0.24798723638832582, 0.9452896130946277, 0.34363769918010545, 0.8631496480363068, -1.1205178055620566, 0.6130936015961553, -0.0743089680381307, 0.3987934309885017, 0.7946099978028528, -0.012421574184793753, 0.4084876470099377, -1.0490638899677887, 0.015342308884830546, -0.6254758568951811, -0.17140463682659035, -1.1837466027549495, 0.805668757198461, -0.8067754564452295, 0.6737230057590139, -0.7058533695276971, 0.1788459320766652, -0.39581120061651626, 0.533982480246436, 0.7442387539351999, -0.14105963071093125, -0.28088834846176003, -0.2931045293476422, 0.3247429180415405, -0.749254886441816, -0.7777405385803687, 0.428628825145385, -0.9032730037587388, -0.7793413164934421, 1.0855189475835474, 1.0594609594851871, 1.0012085661182946, 0.6733176322978697, -0.5579529519274328, -0.6299939110491715, -0.8546085703867577, -0.6316242002197677, -0.26696279669555845, -0.17730928794936457, 0.9920871281755157},
    {0.3905450535081719, 0.23809396524036014, -0.8715790066167943, -0.05414945804946432, -0.3554447289859758, -0.6690899305604835, 0.05482784912701502, 0.8137359542383711, 0.7904476324618316, 0.5861479595878202, -1.0749153282145394, -0.7164833169213785, -0.2775630424183775, 0.0787697067087991, -0.324156127264333, 0.9737556152229864, -1.1983169959885083, -0.1063929588433951, 1.086162655394771, 0.8293566513063608, 0.27739672205691057, -0.009200966670129563, 1.066263800244563, 0.5424137095707914, 0.5950641736102911, -0.4134121393784507, 0.4141673493934246, -0.27413019875515676, 0.014662983328478802, -1.077837614499285, 0.260034367072142, -0.03358185236850532, 0.7761873300596797, -0.14081574882527884, 0.11026765275530717, -0.8253665738205965, 0.9079838874483875, 0.538329685023735, -0.6094821153871561, 1.011784991551903, -1.1695141353390075, -0.1454379143240924, 0.2556675417103292, -0.3741427992485026, 0.08892927155554846, 0.830282673958171, 0.6958689727160633, -0.10965193444554865, 0.24235917119788786, 0.02323192496023461, -0.09197724654407298, 0.08557520184229701, 0.5907280271267795, 0.2010370848588956, -0.9622512300407906, 1.2097815819536215, 0.7276633718765175, 0.5467970567788839, -0.28980143989253704, 1.0879308010748847, -0.49703060595501264, -0.05176103565756842, -0.40172805349793195, 0.20989089109738499},
    {-0.606610316718855, 0.5648339204764474, -0.5538887870305093, 0.8239778187964728, 0.4284873839914101, 0.008813267362215655, 0.6956890303242814, 0.21006292667810061, 1.2025739948477296, 0.7128810992645059, -0.04869531582884759, -0.48941980087966613, 0.4587154200331635, 0.3760241122046295, 0.6523537556591116, -0.0014264422268553498, -0.8145195849407331, 1.12656096283978, 0.8402369138956397, 0.889102691229798, 0.8137880779193046, 0.5612043516033414, 1.1170662903400557, -0.4890466272594999, 0.38005440704323534, -0.9557353227258992, 0.2178798856032631, 0.3881635435478554, -1.1233956797622395, -0.892291749520937, -0.1619342029242238, 0.1410529032811153, -0.8216248265820245, 0.7214881413845017, -1.0727830154709068, 0.5630108145819179, -0.9481895405376559, 0.5227962246433043, -0.843567929441121, 0.46138487111831045, 0.6125760870910179, 0.574200583444488, 0.8234557018443251, -0.2439493786149136, -1.0138809308518357, -0.08369717012110979, -0.8521564073925146, -0.5615918018947947, 0.33769989765117225, -0.39466167131504254, 0.3213919777682882, -0.05704183931820435, 0.04984366360744598, 0.24345029815083488, -1.276632312071197, -0.4671549551938432, -0.8851763526161669, -0.3730258737204662, -0.8686362627417303, 0.2005708517165713, 0.9046267333232874, 0.5713560812948533, -1.1182493937902016, 0.7943317639586039},
    {-0.10041346781489309, 0.9795141910911421, 0.17476883317505296, -0.6328704299526285, 0.7858319993283212, 0.03773843789434148, 0.14308628692159364, 0.32794393155671603, 1.2388738201314302, 0.8948384799592815, 0.7164382512171296, 0.03864366778375511, 0.26057037224236074, 0.022900604625527565, -0.6839763933312746, -0.42695871190628265, 0.5147556562347045, 0.10236552082844652, -1.1236434140212477, 0.33457472727069404, -1.0817990295461124, -0.49262372639089863, 0.3448717180071345, 1.0733868479056512, 1.0627804777058252, 0.08165459795233404, 0.36093771854886925, -0.7896256181308231, -0.18489614722576495, -0.19001852201522126, 0.4716998469191703, 1.1192032230140943, 0.17484595587605406, 0.5815542161228114, 0.6145525408676905, -0.030731971115976565, -0.7137385543843502, 0.8904891803471985, -0.9273754574407763, 0.8068810641779312, -0.34051008865342974, 1.092942308537636, 0.16898416654053186, 1.052733580310897, -0.06583102986653483, -0.47972594712636607, -0.9991328090673964, -0.4413021907783623, 0.32229402904002724, 0.41526304724035495, -0.5263013982626801, 0.2706874081660577, -0.48337444569295795, -0.710950661606973, -0.9612751895546646, 1.1687585883236178, -0.6147043685978618, 0.687004620535549, -0.18447143684944015, -0.708324862251653, -0.17696895417621109, -1.018338640705333, -1.1372921807271723, 1.2300845672824934},
    {0.35601519152990735, 0.11263266684666672, -0.8501966774814927, 0.3897951083873612, -0.32813534525009525, -0.621908445308686, 0.7746352330898935, -0.6019660511780964, -0.8141023278397714, 0.9301418906080623, 1.1872071120632355, 0.8852165785802085, 0.8613291449631749, 0.7816885958803472, 0.038704192457706774, 0.9214299903299294, -0.16332803689376443, 0.44904981573442565, 0.2401899297607848, -0.4265061916788895, 0.6648360733359449, -0.17117287358530958, -0.3941585176233355, -0.8939437920621349, -1.0523369922702177, -0.32807427766503694, 0.32432762821875494, 0.6631908882856274, 0.09300342224851728, -1.061599075791614, -0.9768563910403546, 0.8901585172347765, 0.24583028877382976, -0.6028136743821491, -0.03889009060353218, -0.8144031853620604, -1.0697776014363058, 0.11473862080552544, 0.055603313860727706, 0.22683483949728367, -1.0641351611153531, 0.42052197282534026, 0.09165585196134822, -1.1306108078788792, -0.37700235069503174, 0.37996488659909633, -0.2719855760969493, 0.8130362097139539, -0.8402721901053216, 1.073838719374056, 0.5418229464117673, 0.9464410222904639, -0.6443742165481813, -1.0649708203672295, -0.8177351751226434, 0.645115399312052, -0.20950841690657968, 0.939831026672214, 0.7792424668492848, 1.173331511617692, -0.396827362244367, -1.0825778294343713, -1.0080782890144928, 0.8026229584977475},
    {-0.4863140348602673, 0.008117800730600025, 0.48631341233210224, 0.15696868826535243, 0.06201443153185096, -1.1604511528872037, 0.5936631721475053, 0.9877562345457463, 0.14325951662871236, -1.02690176847879, 0.46964696510757514, 0.3704853960761536, 0.6434267625760066, 1.0716341717078126, -0.07355654895635032, -0.7576758985217553, -0.4848644253937281, 1.1919864096137844, 0.2814920337633042, -1.0467785984828977, -0.14987090019581484, -1.249749372006247, -0.6990330274555967, 0.28653142685186256, 0.3029451432506995, 0.611103924258298, -0.8709202192068503, -0.14010599362543114, -0.3675308177937594, 1.096627039155839, -1.17160266774231, -0.8271707897964828, 0.6705161295214316, -1.2266660365670907, -0.003380866465899289, -0.24571763912460148, 1.2361303617709856, -0.9589150641284638, -0.18865101492334704, -0.6669859044873733, -0.6898382425070538, 0.5348431111293851, -0.7145949186698138, -0.9551238489172624, -0.14007578812125762, 0.03736444030001334, -0.9827512957439036, -0.24332533734554956, -0.13941085349788648, -0.8507352156941105, -0.39482009335225765, -0.9143180670169325, 0.34231739813646406, 0.3406109255488053, -1.1455349810011926, -1.04850333717623, -0.22487093870423924, 0.5954225429221146, -0.9899217457614757, 0.8097329494823416, -0.6714001719256363, 0.8881228133697674, 0.7311327967466199, -1.1835721891330147},
    {-0.24683114866979322, -0.12332258995759249, 0.8008941611640502, 0.5333722118035962, -0.4948758060192826, 0.6011388516633748, -0.8295711492812874, 0.24170132790110313, -0.2065636255213936, 0.34671207123163394, -0.9643418558819377, 0.4009681093924822, 1.1970008895656048, -0.25715703784598737, -0.21999464197746757, 0.48379089934233954, 0.26194304207558305, -0.3297754857688363, -0.8238571497104117, -0.8059740299928972, -0.4157605443258725, -1.0996555564130133, -0.5691576612968128, 1.2475323346754528, 0.6156846998290604, -0.8370142248803694, 0.2082753149751066, 0.7432548340522869, 0.18815240108242268, 0.5004806765062971, -0.13837664714425718, -0.6939787150402369, 0.6655378086614464, -0.9600616746697447, -0.33847435892837996, 1.0423920366155588, 0.19240460508233417, 0.10041439613325091, 0.23544237838350698, 0.11040587598982633, -0.9812797512569479, -1.1402956553974952, -0.7880669340040362, -0.5615599627550613, 1.0897015788127413, 0.9160857450014928, -0.18636691233967012, -1.1059056083058902, -0.12979278975502662, -0.8819851564051243, 0.1867794157978798, 0.9982175222981375, 0.06738546673427422, -0.48455395701542575, -0.2903550978665286, 0.37418759201770624, -0.5334123754864734, -0.8931662058268017, 0.2855297296820479, -0.3546700325407274, -0.7871631871522126, -0.13664898676304982, 0.8079842233286127, -0.1985554246613383},
    {-0.1970175337842448, 1.053232189473413, -0.9559912220773253, 0.6203447410111003, -0.7099670023935735, 0.9330857881114513, 0.31713965439408476, 0.5087462682160633, -0.85192292467434, 0.1892560793332066, 1.0785419148535005, 0.29880842233229665, 0.29234414194043323, 0.21742832777565446, 0.96294875998724, 1.0938834342307895, 0.4888535729172963, -0.7619007938189046, -0.9328957048771147, -0.882112691824378, 0.8050018542576154, -1.0603130315208933, -0.7585660635649112, 0.2386705670931513, 0.6844933044233075, 0.9528838602439567, -0.41728975265047724, 0.9178041463257615, -0.142396903779711, 0.7375468380385373, -0.7841629411824866, -0.1824181315375401, 0.533379036206834, -0.5953174666938827, -0.6728950006914967, 0.6547165734023291, -1.0914960936657963, 0.9435333526769729, 1.0081812751360857, -0.12586027581450787, -0.2152063072837869, 0.33968482559579394, 0.7799475945359322, 0.41645290063664075, 0.06017239898309679, 0.4703661965805025, 0.04373445999109081, 0.022330791315956233, -1.0753534397939317, -0.7752795616711853, -1.0700480087350595, -0.7954865834437898, -0.32077346036308735, 0.2568773265702004, -0.3235997240167162, 0.696551258921909, 0.3676908225413717, -0.376618796101193, 1.0095553093820453, -0.3313137300010789, 0.7093868371251812, 0.1147392776098079, -0.21288112838250223, 0.7902793597284197},
    {0.7146246299851933, 1.200526861647286, -0.23591584952978278, -1.1476416546324932, -1.062483008288329, -0.12692905010018438, 0.817976391995129, -0.5785987624627882, -1.1043600453923381, -0.27159743715120804, 0.8603004993616996, 0.6955521165117973, 0.5099699427705918, -0.31965620379533105, 0.17185611206907142, -1.2009269352675502, -0.029664142118511795, 0.5221045510543947, -0.8225798316238643, -0.7697823538261458, 0.8744627626143044, -0.08641533169150795, 0.0669228919085502, -0.2802746661081311, 0.7415909125568557, -0.27076587199447694, 0.6819050999539363, -0.954028845168826, 0.5341230643361748, -1.015368186315681, -0.9170469605110555, 0.9918556455358919, 0.8721153005011243, 0.48541118645801434, -0.13366409351678402, 0.9335870025335194, -0.09926208864291815, -0.4536802558270147, 0.0666973741462739, -1.0465966350891587, 0.09007864225444191, 1.062254557645065, -0.45894935414298627, 0.8685826689150579, 0.8735386750155868, -0.1442710492507086, -0.38930058159414543, -0.8203603917699628, 0.8269151708424948, -0.03785464491853692, -1.1916826818626405, -0.5720159946714908, -0.13246249158320006, 0.38805670704746237, 0.41653633830412934, 0.9658674389646171, 0.2693232578332161, -0.9338446603943671, -0.8896674175244285, -0.39212364297952396, 0.5070354269839831, -0.5157097919641689, -0.955602302464396, -0.33595539613735464},
    {0.8173025503370006, -0.7894906295610012, -1.2134477637970411, 1.0790547075732042, -0.5055741807250547, -0.4134416249126203, 0.5472202840831036, 0.059586246844877226, 0.6626572008059297, 1.034905402654992, -0.8802601778806658, -0.23390892891915954, -0.8932502186599621, 0.031460539542010654, 0.7101094189539942, -0.6712733845573722, 0.43580095200906016, 0.0696676302166345, 1.0796796714934744, 0.7713233407765938, 0.5863660142299211, 0.4182374718931685, -0.5401884266933437, -0.9091525176666901, 0.6923945032759169, 0.5803605473889337, -0.31538482121620953, -0.01706558125620688, 0.2931040173473995, -0.4968901067332524, -0.40996998766923537, 0.7682160387686556, 0.8914156411643215, 0.6316159116941793, -0.28483750615216064, 1.1781364367322107, 0.00030361732888489474, 0.6655050742284745, -0.379342352966973, -0.7401637346496122, 0.4162681558359107, 0.8477379303185669, 0.5532328694752586, 0.18053777225439666, 1.1830377913536678, -0.7743432110741413, 0.41827501060655964, 0.5786123380360453, -0.8749749589004654, -0.8605347316935338, 0.4982900752873327, -0.04097828643277224, -0.7443116770892987, -0.9335941259894179, -0.31711098599434867, 0.32888949196944, -1.0609895144643815, -0.8929038110627142, 1.0282743089764943, -1.0144119595134484, 0.058115280890267226, -0.2462757952790106, -0.7089467103004478, -0.4316303806098334},
    {0.4102630638783094, -0.9259610072297826, 0.5277007250019172, 0.33127779385068584, 0.16098088021513932, 0.7900917993033165, 0.6544900529819321, 0.561997596305292, 0.6638549803088545, -0.12676508591297064, -1.0402781372210252, -0.6706199819513966, -0.31201728353987923, -0.05805348320303657, 0.8720854932407196, 1.1688126923704671, -0.5844098381707943, 0.49269322082499045, 0.4216827820136547, 0.42554741151864817, 0.43581325492753087, -0.7381124086471655, 1.0794646123487655, -0.0037545869110033165, -0.5173114096054549, 0.3545588206774276, -0.8661266977224542, 0.7192981156163213, -0.8759486889842334, -0.4048654418517298, 0.19012868787416307, 0.11555029611951027, -0.9518079590319879, 0.8439865102501158, -0.5716232207342352, -0.23563203028981858, 0.20283018197063038, -0.53184301164035, 1.134625002267193, -0.17526386434530433, 0.9181672312165761, 1.0445318100655652, -0.15170413304951266, -0.08953477344753266, -0.5925512433197163, 0.44539568473741076, 0.6129026129309438, 0.34853623366137615, 1.0416628006306747, -0.1066014183669235, 0.0027779523490073536, 0.04320552490792231, 0.7639105727367391, 0.15294691464857005, -0.7706756051340764, -0.19110177414479296, 0.7116307666027677, 1.201840374083694, -0.7699202714188161, -0.9093505802869493, -0.3267256302610415, -0.47975245430604135, -0.5848122316308731, -0.7459620602624314},
    {-0.09964526693520201, 0.3214809749142477, 0.7911152142426987, -0.9345179770530679, 0.7192408874153491, -1.0529762786628287, 0.7050711492219027, 0.8649305845937973, -1.2732143307700785, -0.01636785858658766, -0.8689767400202009, -0.41015287940385176, 0.3746071061331444, -0.5246257326067942, -0.4255103385875071, 0.11116454046561915, -1.0794211029074756, 0.29540762978968593, -0.6391839520694595, 1.0460024383649855, 0.849079383666797, 0.5927585272814676, -0.09612413207882581, -0.8525198696355107, 1.177326029432328, -0.8035969722527072, 0.6087188471780958, 0.8655427172367595, 0.7871192157504368, 0.15442217683867107, 0.010431360806200898, 0.32773835704586457, -0.3764646812557373, 0.7001250243739645, 0.08395463884451326, -0.25539639202894127, -0.02520989691013215, -0.24785636733836533, -0.5660532657024516, 0.01582507660178515, -0.9008420603261726, -0.09552557175372853, -0.8382531763125558, -1.0147363694129345, 0.9400964071402098, 0.06257229292431138, -0.15644587961475817, 1.039438983931684, -0.8459478466194843, -0.6531941699023818, 0.3630972280170946, -1.1498563140125393, -1.0635381814468405, -0.2832105600518661, -0.10227768638594485, -0.5271004338242057, 0.7208879330393541, 0.16095757184382462, -0.5292775862241682, 0.27473841833621604, 0.29197038783073814, 0.7477043280949776, 0.42413408836593003, 0.21822252503785675},
    {-0.5319418577393805, 0.43711676639564584, 0.8496940148107741, -0.31887940543284304, -0.9952568939042049, 0.626563141497126, -0.7391673163557906, -0.8396909580518073, 0.5247269520235289, 0.4706682053657821, 0.8383028424915295, -0.810979381699015, -0.9625511664474098, 0.09561504724066193, -0.9874527674435992, -0.8464307952991855, -0.20293270432181015, -0.08152875630770555, -0.9661509756059361, -0.16448414862176325, -0.28465631162225963, 0.08509833869509202, 0.33250897558027775, -0.9408222836069299, 0.4220246592598591, 0.8906898807799767, 1.1041480506857246, 0.49757599094547905, -0.7189249231362862, -0.9096879824760705, -1.0349033678795716, 0.5071189581574862, 0.7833837081447858, -1.2227215493017802, -0.9491376987706817, -0.6520479968587112, -0.8938516633878205, -0.6806082564873626, -0.44326962505786793, 1.0662079191188019, -0.3106016184642156, -0.7469373277443027, 0.30602778137473474, -0.5181524872039843, 0.9058906267887449, 0.3312753343760139, 0.8590285496511978, 0.5997191892088215, -0.12124691751942608, 0.7429612576203882, -0.36002076772805297, 0.22552673433763892, -0.48869924268469533, 0.1256033690782055, 0.6019413546659034, 0.40708254495856294, 0.9547136410586147, -0.9798002152098421, -0.8928033691827472, 0.7699247041194226, -0.835534796208341, -0.9937057068351373, -0.9349288370253087, -0.938761402663401},
    {-0.5555439347451381, -1.275265148328973, -0.6268401844539965, 0.9544821533284709, -0.33951076169976885, -1.191997280301738, -0.12670597941111394, -0.807242407602484, 0.11620252223001741, -0.06924180267812638, -0.3658547693646165, 0.6580559018935533, 0.7823964600408965, 0.2186084078853556, 1.048177142572533, 0.9123207771571457, -1.1199261979763036, 0.9282481675684442, 0.44023457106488273, 0.23043167139037637, 0.248299472407211, 0.8957219990794898, -0.1555982139654658, 0.052992676532401056, -0.4731145174171739, -0.37408634021152365, 0.8497715160289865, -0.44991495466054376, -0.5597561882508245, 0.42331424868788387, 0.6923083309234422, -0.939044112341521, 0.6543114055806715, -0.7632953651297973, 0.6925994820896901, -0.7637507010951421, 0.21398683239689398, -0.9712518812035587, -0.9273580113473505, 0.9329772854808169, -0.6206461053927449, -0.9370715241559335, -1.1256779259616863, 0.005790276438221148, 0.8191371186847874, -1.100026521912756, -0.8877809933854218, 0.7530888158971074, 0.06134331075100649, 0.5573322311142727, 0.7389836396915266, 0.39528471489727507, 0.01627797676527128, -0.9513379827827532, 0.9211045620314199, 0.9105788388837465, 0.4429963928831662, -0.8503069960017908, -0.7936209846097518, 0.3976721945516892, 0.7478383488567043, -0.9005923003085557, -0.6396301820688218, -0.08786637107236124},
    {-0.8839697741083907, -0.7597296709466638, -1.2196161326664503, 0.9269076698348729, 0.8036332277687149, -1.1422065283698382, -0.32873477424576497, 1.009098579842267, 0.8139667135748058, -0.7800449481766835, 0.7311728966215965, -0.6332737077764798, -0.4410615863993624, -0.27222235957253765, -0.36880202731120276, 0.9541419823509991, -0.41892905492789473, 0.07320035942657181, -0.851368765875008, 0.30042807111601466, 0.08266515741922167, 0.35331431916892475, -0.8099636816122224, 0.14386122403542242, -0.11484369734552992, 0.06460248890302708, -0.16645817718232814, -0.3733189788070501, -0.39188820627923887, 0.6286360951807353, 0.929505172589538, 0.5419418116482227, 0.7615709046515833, -0.070141945641284, 1.0506476444267157, 0.8456679012707765, -0.48508268003679655, -0.16257701500606553, 0.7418232437022155, -0.5109281248794596, 0.031979707824505196, 0.707057687863625, -0.8835054363621456, 1.2236599442760419, -0.3493249139067125, -0.5479958594790117, 0.871101421049713, 0.8914720006968573, -0.8815562069770732, 0.03696853341499207, 0.8868772489591019, 0.8505043510409772, -0.38770365023269493, -0.2952298632735899, -0.7335086087765809, 0.41957284341892304, -0.5070279939722788, -0.14812760808100325, 1.0238981767592723, -0.7100979473449127, -0.9988370642110238, 0.7603253845549243, -0.9134607463880079, 0.9501199363451742},
    {-0.37461947497521786, 0.7411733575916002, 0.8313715625809522, -0.5155812691479832, 0.17643625896471177, -0.7851901066977292, -0.6502723095817242, -0.019647976608013457, 0.003915550179598344, 0.01720058409912028, -0.754622037008671, -0.02724877343505363, 0.2092081035742285, -0.016206268391731938, -0.9157083274984866, -0.5198880091200546, 0.3256768014938173, 0.7900810752521447, 0.608943447306615, -0.481817395202336, -0.9075491590550082, 1.1434549661838473, -0.14687161419150402, 0.3024352140775938, -0.8631399081779985, -0.16273200923476616, 0.5950293005390894, 0.031830211937964016, 0.0909533685268856, 0.7369624243167102, -0.4110805284779881, -0.6317409681653333, 0.9930288068166517, -1.0209045568366981, 0.00985385204624135, -0.1369196144395372, 0.13274938429469718, -0.540222875759575, -0.482785212529729, -0.5849174992346072, 0.6166787481983181, -0.09864925968313107, 1.1454173074834784, 0.2810010238587276, 0.8791742118592887, 1.1565301907877943, -0.16557643106236364, 0.6914367379555576, 0.7438171047068092, -0.15309176841337593, -0.37966920375949587, 1.146771489801842, 0.2717710922989932, 0.8064256752004709, -0.7657266479537973, -1.0231680352585792, -0.7706423267473517, -0.8243422765948343, -0.4149441433015065, 0.9750635042668825, 0.9970484988717679, -0.8460469473869093, -1.0139258520231962, 0.8602560735908997},
    {-1.1425225640378551, -0.6839115755134179, -0.4042001812832105, 0.8124405088909, 0.09509581450050374, -0.1579523646035971, -0.056166961850459815, -0.9893641719866958, -0.2619483457621553, -1.035083190041615, 0.4060647626533863, -0.2854644241639947, -0.7054323066300507, 0.847930426192853, 0.5133235399187641, -1.029877450441889, 0.7364819688960261, 0.8406193820735337, -1.166579183300643, -0.2428284042493468, -0.9776892241657331, -0.43762764312463465, 0.15825088478007343, 0.5157656687239452, 1.0193221938090549, -0.8100398754364954, 0.3576468104313594, 0.9391815829847967, -0.2842238452355837, 0.16119535483044634, -1.0853646382831434, -0.25923045300644093, -0.278117977545247, 0.7921297455252985, 1.0434256223793008, 0.9094348472424761, -0.39363874321637804, 1.0820118672759471, 0.7653571930442885, -1.3781829769397405, 0.4393458234509458, -0.22456122550918703, -1.3107365744353852, -0.4598287583819466, 0.28101784039750427, 0.1841366585860397, 0.4527193566290659, -0.807941826116264, -0.6289715851945207, -0.4788475744060311, 0.32195689089661517, 0.6429027858909633, -0.16939317148004862, 0.9819220258593311, 0.17979656945079775, -1.1014518753730362, -0.732177634941951, -0.9263693548420351, 0.7651602205470175, -0.38874660076325224, 0.17956934917749462, -1.0936373705548978, -0.8646441767145183, 1.0156217643167038},
    {0.2103373297903109, -0.9093512107321488, -0.5177603734090248, 0.7954865302754759, -0.09040067800921407, 1.0620844118084178, -0.07683885959730198, -0.9071829003665093, -0.02315268184658205, -0.8246802837538065, 0.6520233091628476, 0.015313937509809238, -0.33239692760196105, -1.1255268334218385, 0.1474071137812336, 1.1943317707510839, -0.7662155677649212, 0.05327257969207186, 1.1125179155353702, -1.010385746859758, -0.47200425616112474, -0.39383324522045654, 1.1492794732038423, 0.3008087190621098, -0.7422214320890709, 0.00839923900995072, 0.7003731611161522, -0.6624310048036409, 0.7286287929772863, 0.706176918342923, -0.08031087522782532, 0.37312541298109125, 0.7468245383576881, 0.11983925254383164, -0.42228134120305444, -0.17719613653857186, -0.41972772736598074, 1.1022468421203575, 0.42485059898827704, -0.8499382844185035, -0.43792722105069526, -0.9769940395884472, 0.5654584371764652, 0.49142092763624395, 0.12664836930248707, -0.3271172746567888, 0.9923069320357762, -0.09008944975719144, 0.8735170591600206, 0.10233539322368546, 0.41799196174929776, 0.2636223540282183, 1.2497036818541138, 0.2112381232582109, 0.062073503512804384, -0.1181572553049369, 0.9928689259919796, -0.6368692199168787, 0.021935585249536746, -0.7509775396533946, 1.062483889507585, 0.9974026875378325, -0.4638273903979297, -0.9918116659598869},
    {0.7451674033345618, -0.8018510400538473, -0.7835532948207062, 1.1448011744832498, -1.128855327315749, 1.1755052257252931, 0.2412203844269286, -0.683302222619166, 0.08748142725484714, 0.05891964928290132, 0.48152013168453806, -0.17261859930098347, -1.0430885352928432, 0.6273327809371164, -1.202390986029886, -0.20595660277121106, -0.8872577222101806, -0.48903836271734513, -1.113470014885957, -0.9448331326972239, -0.7754001268614882, 0.8689175522745047, -0.01589550227794862, 0.72437729357147, -1.0840375716678325, -0.5137600811176558, -0.314814202214528, -1.0862644022581982, 0.9250082476940562, 0.961132006620818, -0.6211361968101154, 0.5557108800367148, -0.009661278841355711, 0.7502291294963865, -0.6782334541313355, -0.03251629450638564, -0.9537468152438399, -0.21741317804556407, 0.28656826821601034, 0.5386988357159669, 0.5941148263584429, 0.4529361278834583, -0.6421558689995548, 0.29270148394904116, -1.1010705506655878, 0.7266310293381666, -0.2711595609376537, 0.4358668049047552, 0.1250695650674523, 0.8284470413600469, 0.6539664460133159, 0.15691137883465242, 0.8976917800124977, -1.0132436188232996, -0.4906374354219178, 0.054925143520133723, 0.12660187794811117, 0.2800420065617283, 0.07627875505114336, 0.6310724094073513, -0.20191289768191112, 0.10468282032559159, -0.8711408196964645, 0.5491488429916187},
    {0.3050882943533989, -0.773365140143597, -1.1762192347787754, 0.619666004495978, -0.9082620009045854, 0.9924610218846419, -0.6340059566057498, 0.002174057661996812, 0.6260146203776232, 0.32030514150361783, -0.45116791139935064, -0.5390873516358751, -0.24487485791941033, -0.3735307270620786, 0.2919559432594326, 0.24196093628894264, 0.7828441801368091, 0.7042145733617319, -0.1053303200303007, -0.47635345431656784, -0.8522094290614386, 0.5005377406266138, 0.7690651974481947, -0.6322551967870956, -1.233130564937551, 0.43088532308583766, 0.8370781480143932, 0.11884742942343461, -0.2839346818575096, -0.5466616936461479, 0.8649870666408397, -0.016293372605245632, -0.0404293543816005, 0.07732321708109147, -0.2477146237908863, -0.623762136890518, -0.5644023796681296, -0.14227321089627143, -0.9729206942568879, -0.8859128605068619, 0.2506536915888702, -0.2223225776055933, 0.34039787964496515, 0.8646737286181487, -0.8841746949986601, 0.9986707737095595, 1.0464996437242684, -0.9673515464862416, -0.5015088536863812, 1.0129939118229214, -0.6978946634506502, 0.7527769910731061, -1.4105808930053443, 0.15399457015490825, 0.2744687436768777, 0.25693194081824494, 0.421127069509427, -0.6152213425741564, -0.7077916266851866, -0.09925429080082024, -0.9603230695484373, 0.6171276337808769, 0.6584889765996438, -0.7941495316116823},
    {-0.5664947195552607, -0.5842453105539014, 0.48741572351681184, 0.5129956512786206, 1.0979122450305616, -0.8439246376372761, 0.6377174813276649, -0.9116692326390883, 0.2965159416508247, -0.6247653272785493, 0.694775231426764, -0.2313215438190625, -0.11025432698734942, -0.8376182697457881, 0.07246529025396, 1.0054492665843833, 0.19405017232878977, 0.24166570192574613, 0.01924795272862935, 0.8388299656860052, 0.3945494645660262, 0.21995286169743355, 0.3758620335200768, -0.7026865154830528, 0.947058425428154, 0.5487572215564497, 0.0993462720732083, 0.28024854424341034, -0.0030561860403169466, -0.3616527592963703, 1.1428072620209535, -0.2921715897205661, 0.17714761625331607, -0.044255561232674934, -0.6465347845647228, -0.8851063129841793, 0.7985409759042014, 0.7268252246395901, 0.02265784416601688, -0.8621657982054104, 0.944470897800908, -0.7019608195882814, -1.2859428534871629, -0.8131688508281368, 0.9126987704421908, 0.749729832250827, 0.2840530855210843, 0.3242349112461472, 0.986626341256092, -0.2066335998109769, -0.5108933980247566, -0.11968496369635212, 0.16383811583076163, -0.020104210363132667, 0.8617946996665521, 0.6360053772061606, -0.24673201589297297, -0.09372017738947175, 0.8404543991605766, -0.049305637624793855, -0.7623590842532519, -1.224167049049991, 0.6362653129432067, 0.7087353625714253},
    {-1.0347550540550976, -0.3719652423768333, -0.6373205764113741, 0.3338179532717254, 1.3404753987935667, -1.2184973953460396, 1.1398678421735498, 0.8348431067350599, 0.6516912125211447, -0.3552945552609987, -0.2745747970067773, 0.17861582255355732, 0.41339975899051973, -0.8060466829817842, -0.051447841735641806, -0.7085471780863655, 0.1324887443009327, -0.46862047572887644, -0.6441112544477894, 0.32776935539840746, -0.1767925522367133, -0.25263243893937093, 0.8787485222292278, -0.12392152592294298, 0.6211738716746612, -0.6719419562498756, 0.3914509483495331, -0.7160631979689213, -0.7605041999387202, 0.744080262329827, 0.4836355860824712, 1.0445561372357266, 0.8769822640901628, 0.9256242757781098, 0.03486667426514225, -0.7651656492882686, 0.4390444556994361, 0.7165446816099261, 0.9880828412004532, 0.494538164055022, 0.8739401219465064, -1.0071676072255704, -0.4255448918427963, -0.4509289193977621, 0.5539016617645134, -0.2195158166769266, -0.6922980945654744, -0.07189571841525776, 0.6380802877709005, 0.7634547883904015, 0.06995745890874122, -0.5293930832585608, 0.017745592953085337, -1.286095971601786, -0.6216716417204285, -0.7900930471558041, 0.279815559122747, 0.38391192908023003, -0.6303519250258284, 0.5113031448201484, -0.8522509119854075, -0.40404179944623647, 0.8427762457548302, 0.35174695741428585},
    {-0.5948467392979733, -0.14638419412736708, 0.39853707594454785, 0.8632853596466222, -0.8648051878281531, 0.16603144473462572, 0.9155879764779306, 0.7827607749629855, -0.9380478132095984, -0.12340260294016533, 0.13725456146940807, 0.4526553346255733, -0.19543772971697532, 0.2918056962832175, 0.9552461393577525, 0.40789333495530267, -0.006797631547441652, -0.4481485925076753, -0.979900359550325, -0.18985437118606502, 1.0609559526691317, -0.834344111556651, 0.7712221898391679, -0.604644231711563, 1.150311661401304, -0.660109907247514, -0.7358399909629644, -0.6275533213180915, 1.1125495185456766, 0.9203544874438498, 0.10380734989417652, 1.023199394482358, 0.8337697112848977, 0.32110002653777076, 0.4945445583425692, -0.05755170955724624, -0.1976419502903052, 0.05224754284948558, -0.32013473569312845, 1.2412396672843764, 0.9574307756395267, 0.5993275913297258, 0.537116323020671, 0.9041270882684819, -1.1662954812805906, -0.6095581108628505, 0.6489618076015581, -0.2837432218712494, -0.963480504826159, -0.13400772925727458, 0.6783530470470975, -0.5370858817180388, -0.9533828545665188, 0.7059615390582803, -0.9632082559309406, 0.442041206826191, -0.41951339992938097, -0.5145953796768712, 0.1647432267803922, 0.6998648881757876, 0.010023138751791253, 0.979525890923313, -0.7273234998089119, 0.5971778503679896},
    {0.5007920555110497, -1.135374860853296, -0.1561902556383473, 0.6073093454600986, -0.9528176425435851, 0.9048247739850834, 0.8732551466458138, -0.05589196393515248, -0.492345689667766, -0.20750231200831737, 1.0132354873505842, -0.2588753040707811, 0.5497085979574301, -0.8281644479647879, -1.1559382318495064, -0.5002281600280639, -0.6156063677541777, -1.2148485269342162, -0.2941820447632358, 0.7779965499156973, -1.2243463562309553, -0.6169324700299718, -1.0707811939571041, 0.31098977582615056, -0.5523169484402926, 0.19128939889692964, -1.1981430704314733, -1.1068986899887296, 0.8610992454548007, 0.6134411533007024, -0.3634398923651927, -1.0641640440599525, -1.262572392050312, -1.1390748451582031, -0.4567130807615402, 0.06829630229227593, -0.18380656488178485, -0.35963408514459394, 0.656253370063401, -1.1543023268868715, -1.253161883933187, -1.0696078397587419, -0.8667302538979551, -0.6614794848766857, -0.6773717281671944, -0.4951110755977003, -0.8388049955349939, 1.1781210459718343, 0.3896673673561916, 0.31314476921643597, 0.883735411076791, 0.45172272841143535, -0.7602103799053478, 0.6259704381581139, -0.34929896024408946, -0.2723858551235088, -0.5313768497740946, -0.726293331834546, -0.04567301637517716, -0.6418954106187542, 0.9282135114491747, 0.040389843848148116, 0.5112339610215758, -0.3266649999579246},
    {1.156035996709328, -0.684785623664915, -0.6241696147287539, -0.17983371972381432, -0.407592283352883, 0.5540272271864788, 0.25370055337588765, 0.6514239236475884, -0.29464772791031923, -0.47261831492833445, 0.1657701164450511, 0.426676358601657, -1.0873296835330277, 0.40973834825756517, -0.09325505341036175, -0.6929346050440951, 0.13279479074080577, 0.9545146336419112, -0.9246154150812596, -0.44676165248501487, -0.4892131821801048, -0.05606224314484389, -0.18805216825825988, -0.9694600983489478, 0.4472215562334272, -0.6115873671555252, 0.902788786266203, 0.42144164018913244, -0.3439682954414686, -0.640077046675468, -0.08587076510511073, 0.5525975729869644, -0.5911933008575174, -0.6793180721014667, -0.17855341742181025, -0.9152286726802387, 1.1749791608697346, 0.6791455063826045, -0.896692791041469, 1.1585710275470928, -0.5173768582217612, 0.12468246135956666, 0.6292626802212089, -0.16923638151756018, -0.10904956954625834, -0.5366662619816535, -0.7898131458022056, 0.8686533357841232, 0.9531504295829054, -0.13145659248024777, 0.8083476080796554, 0.8587039976195173, 0.6201500943003135, -0.6144716661439197, 0.5832633973469813, 0.44010537152433704, -0.001311898681422673, -0.997139699084386, -0.1229709055721041, -0.2912931509680789, -0.7684215919642186, 0.9205953079131357, -0.7658263788998371, -0.7486584270544238},
    {-1.083162673293894, -0.24897528649631062, 0.4746326906793434, -0.3292526889839907, 0.6033043479237077, 0.0013639845920203507, 0.6221267226107212, 0.33990972333614694, 0.05139378635912102, 0.29064047418988354, -1.4696342480040037, 0.5465915877854075, -0.39628898472856694, -0.32137553967159077, 0.618839452078241, -0.1518776480912572, -0.11713950923725276, -0.7522619198728623, 0.595295531297424, 0.8657168599062107, -0.6788741658668314, -1.2782632671521987, 0.5562353203113327, 0.9161115115328462, -0.758468774543257, -0.5131127251441495, -0.18717488399678936, 0.07410784451577196, -1.1196492688367239, -0.1620572614572935, -1.3586155965820632, -0.039547659818450556, -0.8964245407289115, 0.158923400579065, -0.6851741140054504, -1.3896029300913093, -1.0376626197941896, 0.9600719558671076, -1.486942225483906, -0.5237231966402864, 0.8187082503850496, -0.11107586195409735, 0.03428806648900271, 0.3971823077045041, -1.1865998301298952, 0.1696762866400204, 0.056809823733542555, 0.37348828876307427, 0.827036125490982, -0.930499711052226, -0.16879341431213327, -1.2418624369399973, 0.03831953483666808, -0.6926743509407641, -0.28200233693400284, 0.1414042262086776, -0.20818934594781938, 0.6214036385996298, -1.0817642358345236, 0.6159063144700021, 0.8637097761049262, 0.3600301544881598, -0.6122242475407934, -0.2621101483592958},
    {-1.4275843942799546, 0.3691314558105875, -0.9803203380759591, -0.6683263287956643, 0.7842340805911064, 0.790837212023357, -0.23783022134105988, -0.41261130394851564, 0.03634943898790763, 0.8403162351495251, -1.6235913820156271, 0.2722531222356763, 0.6300315199301808, 0.8874305114942013, -0.5411389958927212, 0.22667738510717622, 1.0740540811460186, -0.41735229168288246, -1.1013584424517942, -0.7005027843523788, 0.1928169319641575, 0.2978803374424259, 0.9115916173183408, -0.20023105672228078, -0.05926416494294982, -0.724089519261534, -0.8406120487558184, -0.5295102659571223, 0.7471756568738951, -0.4097848435653993, -0.5493175478971998, 0.4165173254037433, -0.6556492445107819, 0.0362837191745841, -1.0907197339252956, -0.6718158658006271, 0.8357462488955942, 0.4672803734221018, -0.6144384630749669, -0.7308203384917766, -0.6235539149463566, 0.05728645790330435, -0.6367961854704246, -0.5957842286980817, -0.03086137360223273, -0.013595536366242035, -0.9923835401353535, 0.9560336727013801, -1.1494929426705411, -1.2225830303734677, 0.3952139477904931, -0.9243623985552316, -0.973603870713586, -1.3481339954978222, -0.730767122636056, -0.8293799937231477, -0.11327881206451057, 1.0461965716856636, 0.2547355797829568, 0.5548515990167446, 0.6510946183048849, 0.05585963026254378, 0.04626415249709749, -1.0518578280744961},
    {0.2267897317481694, 0.9602330187432259, -0.516612821462159, -1.1445410129437998, 0.8966690442119878, -0.29212073257299215, 0.5759096803686153, -0.5969501072146813, 0.8153740082965792, -0.5642356181943768, 0.43037653819162885, -0.3571443171704352, 0.11902907473346132, 0.05031963980045396, -0.3784955695676871, -1.1365012367529768, -0.35442882176241464, -0.19228953912577765, 0.1532086920293545, 0.6251116487488352, 0.6990519118075974, -0.2721980626342845, 0.767781827828412, -0.1376181093662238, -0.7712791652220923, 0.5080602565258895, 0.32286113143204453, -0.7029973276770048, 0.6506969530178727, -0.10720679719637836, -0.2590008782424369, -1.082823812511101, -0.9169681407875476, -0.5472494664548934, -0.5397026531708172, -1.317731760068901, -0.9913610930323874, 0.07321452434407788, -0.7591619451680385, -1.271846058022049, -0.12728298130155197, -0.026135746845301906, 0.26301857241503035, 0.5490417885788906, -1.401157997606482, -0.5760863571213892, -1.0017575094664177, -0.07511986804143198, 0.876147826002849, 0.3047783692007991, 0.7654409317938884, 0.6048072182285693, -1.1080526600192508, -0.6451772468476386, -1.0546783995196691, -1.2881384881784932, 0.9212553458266787, -0.4424271034797011, -0.14306400209352285, -0.2506353003942476, 0.2961806632709431, -0.7030035225630701, 0.3565466317160439, -0.28349529529255196},
    {-0.8935055316209953, 0.25069324898637063, -0.881170441416656, -0.11443778752654797, 0.22177890357731017, 0.6110064581975742, 0.9059622485228834, -0.643597169086844, -1.1737546248320703, 1.0744877591004875, -0.09542207530397054, 0.2789510056884869, -0.4471911109304794, 0.7657329334735096, -0.6818510666117962, -0.3840326047522396, 0.7743979577870662, 0.7758958530039558, 0.5968257957620244, -0.6949978153331718, 1.0921532232020712, 0.6754713903422771, 0.9278268986788202, -0.7076939512380959, 1.1405093708632108, 0.5032250127421533, -0.42364327035575317, -0.5546913293621265, 0.5456000470821604, -1.08022284446261, 0.8053908456791272, 0.42988932259738716, -0.28791976651786566, -1.2962845547006254, -1.2132600985711484, 0.48131998821028205, -0.6658350147908629, 0.3591349409648874, -1.0971949539898378, -0.6293111308961669, 1.0767895744751395, 0.5508555352749216, 0.06433518865465962, 1.1407796795600529, 0.81396374136925, -1.0427131906479767, 1.0751949389496045, 1.131931006107363, -0.2964245981038899, 0.9235539861692218, -0.5791757080559252, 0.019369410724723653, -1.3481997325177975, -0.7174705537573879, 0.9451349612471531, -0.2991044417213633, -0.36836500824687846, 0.10038686326392464, -0.36325082812845744, -0.3400405123593576, -0.180914723744486, -0.8210637125970375, -0.5680094334829577, -0.9164785747992349},
    {-0.053556202015323455, 0.13129299652638618, -0.9990298857470423, -0.8414435220680644, 1.0324352860970931, 0.5527602862711186, -0.6858063246094621, -1.0774822222042972, -0.010233478697933084, 0.23722472406261066, -0.8306021121140325, 1.174884293243553, 0.8768364981979239, -0.2595758380184202, 0.45763148638632795, -0.5455257286628482, -0.19402067340040752, -1.045126336249805, -0.2575054570672956, -0.31236725249034347, -0.4653064283075581, -0.20092223284229135, 0.43733892898834803, 0.9479692435346495, 0.7915546776574274, 0.18944803459433326, -0.5875122314740038, -0.03648560170150342, -0.686443841243896, 0.9966905414310367, -1.2347759670409495, -0.5672694079097229, 0.17575771394007347, 0.74127061658177, 0.02198108479419094, 0.6075586953219543, -0.6094298923521176, 1.0878931284454194, 0.12079554371028402, 0.20913382827061305, 0.6646638643775538, 0.9301010541202998, -1.307573250573837, -0.5219232233622645, -0.4896650325202079, 0.12574338849634636, 0.5285664253537083, -0.22476206719769878, -0.46057830371651337, -0.09816969795238098, -0.7204772219263131, 0.8965821506414835, -1.2764438850005158, -0.9350858980345204, -0.5525375865037496, -0.6848390137706609, -0.9335647903743147, -0.6286867176463776, 0.8887563682046427, 0.8949286048634316, 0.5303637972545774, -0.7288656821510456, 0.5432740949592493, 0.15454425782974068},
    {0.875333530938937, 0.304719318827334, -0.12729611731634763, 0.05570196063152803, -0.5971459942987368, -0.1862213610061297, -0.27299135959583704, 0.3704216461980503, -0.10517591533593965, -1.272387075043626, -1.2704419996600034, 0.04947405046846097, 0.734535676131969, 0.12030316918982951, -0.9681193106763344, -0.5945207178809285, 0.03097317084718874, 0.8261285182133664, 0.9434584846326923, 0.5599284356167401, 1.0674363004801626, -0.3662903951430237, -0.45764963656466534, 0.15295383283342906, 0.858477618656726, -0.7426409290969579, 0.3685624501050683, 0.09408696156372552, -1.2143034354830056, -0.8510812333638291, -1.0793650798406618, 0.12084754947630325, -0.7302529487673588, -0.15208257716697962, 1.031978310179262, -0.5141479358237512, 0.563217266922126, 0.680461973995376, 0.3941555253726434, -0.6726387923515299, -0.14919697055416822, 0.3164696518313857, -0.7739293238196, 0.007630534872942753, -0.7268512946439466, -0.12715352154357804, 0.8079056937012608, 0.0985644218219591, -0.3902652768342683, -0.7336176369641005, -0.976713608122002, 0.28202428065630025, -1.0645849441395148, 0.9883281574445352, 0.4814127776119213, -0.24989138281860415, -0.8813448261472351, -0.580999331585609, 0.2786857554559413, 0.5598139126241716, 0.26853655525908376, 0.4946667650527514, 0.6137174196995426, 0.36053549074416436},
    {-0.38018948623034016, 0.781405696474463, 0.8198732893581553, -0.5307054695028636, 0.9772173784534638, 0.4551825953264644, -0.8724002393727988, 0.579523558636547, -0.9003169261228254, -0.3007386695220323, -0.38896756015704276, -1.0111480128256984, 0.338304515758979, -0.2517846848927833, -0.08029275123069551, 0.5742693011003882, 0.45598110495481997, 0.9909288136779346, 0.48903095942790326, -0.10359141765546409, 0.11881379492451334, -0.3582471010558386, -0.9444353695732417, 0.6158374013245155, 0.41960250941389776, -0.5160411592401881, -0.5816435194289594, 0.7809028252098842, 1.196451819842582, 0.9583300657219948, 1.1731484379456187, -0.08251005977383134, -0.19668974592299074, 0.5779486912388788, -0.33220958752492324, 0.36037367230685236, 0.8165951613117036, 1.048069975229902, 0.12202812129810807, 1.0263800521298228, 1.2628930062877846, -0.002077415726221526, 0.21631215144372448, -0.9725228782890373, 0.35884244937108034, -0.5824800352637104, 1.1098043336084578, 0.32242351664991015, -0.012778757847947969, -0.28741864436666287, -0.3266699442861658, -0.9403737407457238, -0.7085733372044206, 0.1698031141615959, 0.18057355438044628, 0.7831000916731641, 0.22506110137809818, -0.943578950774538, 1.0783888070849483, 0.2179475509653556, -0.799694086923941, -0.8798523229387551, -1.0269374302499943, -0.5580515477190767},
    {0.9818605185769096, 0.3951384263423598, -0.802019195858844, 0.127498119194581, 0.9728884819061744, 0.958022004435645, -0.826388444967246, 0.018863895474714752, 0.40361428974907504, -0.7930106310124252, -0.7313107405341852, -0.8048800841528202, -0.6206806689188037, -1.115862035309881, 0.3178972685106188, 0.6343290767229797, 0.5300613454827837, -0.7557814250076939, -0.6462082942586418, 0.9856412469754225, -0.7431906436835016, -0.6918764696382064, -0.49600952326471903, 0.5527583973583408, -0.4403718223959044, -1.2197898678914583, -0.10978248718364646, -0.049656875600959376, -0.1274626571761574, -0.22430105663328057, -0.24175677730080655, 0.3456906626479679, -0.6364137336021037, -0.10580230376381011, 0.653194386678682, -0.28445002849891443, -0.7528674907360671, -0.37294758066259287, 0.252873490950207, 0.2968748414427184, -0.5133080500238091, -0.46481749676712986, 0.40063034347184473, 1.4441156865202278, 0.3086279107513859, 1.1622944072981098, -0.6784219454219854, -0.8509663111608222, -0.6671106007202354, -0.14776997161160182, 0.2921155190990019, 0.9681907790559434, 0.6533864593218217, 0.008623505311835745, -0.16052179046883372, -0.6927525228603918, -1.0516208783698848, -0.2740169501359208, 0.9940007992160389, -0.43147743809325734, -0.24130760840064577, 0.4359159791773092, -0.5460098696314524, 0.2878864043649376},
    {0.16080935911348923, -0.2479696440932567, 0.613436592437073, -1.2019519884237788, 0.5729494586356534, 0.2748336871204672, 0.0033736903749097182, 0.5071603449684541, -1.1936857805744796, -0.6038498562248692, -1.387765767733902, 0.027592330681435517, -1.2102213943174582, 0.35465027427839874, -0.5384095117549671, -0.2191000394351179, 0.491389679283279, -0.37508315431879735, 0.8555712601367581, -0.978891144301255, -0.9003922428308766, -0.4688423149619465, -0.6121318731792691, 0.3669301300902144, -0.6746834815773137, 0.5487732951848877, -0.6351212396420161, -0.2877940363867446, 0.16130924810314481, -0.7328104218950738, 1.1102609111986155, 0.6023589497107339, 0.17200915105085215, -0.19666369869009573, -1.2890282777158772, -0.24853323395301463, -0.570678928529164, -0.001422823071552064, -1.2359593003856397, -0.8161155153914158, -1.3433444390862819, -0.23491376064769948, -0.5543759332283018, 0.7362263637856065, -1.1588146401638437, 0.31779925752115235, 0.6693420019435766, 0.3002704179667825, 0.9338288875184055, 0.09788550324263905, -0.7382108234549422, -1.24650534138827, -0.6643207800611546, 0.3437526914283992, 1.2466420932838256, -1.2444789653124262, -0.8069703247910436, -0.4071440631120334, 0.6064513814176473, -1.0486097973688917, 1.1434271624007042, 0.5221365230953888, -0.2874032806397903, -1.284708843947583},
    {0.09738137461277425, 0.6431324682360147, -0.35992335568254213, 0.35399883422682715, -0.5174313708722823, -0.11962033852631204, 0.9208077339995091, 0.6708472662349526, -0.1988507432114076, 0.11377845094660285, -1.0030091437060193, -0.9570355067685886, 0.5219025049712549, 1.0799127997029214, 0.8239824499816047, 0.8518225864902315, -0.9481527469610399, 0.18725833011714116, -0.3165980516648153, -1.2385790802694723, 0.24798330341174993, 1.1177367802691, -0.8809140310686937, -0.3029460741243071, -0.6901689918946746, 0.3412509526198367, 0.6378086185398093, -0.5874748670081963, -1.1623617862934776, -0.8594012115202686, 0.9474677594864148, -0.9511481832426807, 0.02305302962150167, -0.4646962500589999, 0.9925351687269607, -0.8777577130743418, -0.054276629991272335, 0.6275476997897184, -0.19542574075232677, 0.5002439852584125, -1.1051915929769989, -1.0919189280897732, -0.1858172021030833, -0.44469941534869695, -0.7219194257837217, 1.2782846378071804, -0.7283328583292741, -0.7696239802276125, 1.2290621345265718, 0.32129862957682664, 0.5445086564846123, -0.9004548417831071, 1.2560251393225543, -0.0016026378456379165, -0.7563092144554538, 0.7132198645290766, 0.5515068831976602, 0.9840822166086545, 0.47025477710283264, -0.364198069151374, 0.7326189911610549, 0.670928577442851, -0.2840768279828907, -1.0336261590182934},
    {-0.7561631227620004, -0.6943253904870788, 0.5188678090380736, 0.6983495648166826, 1.0680485541800153, -0.8480344376786491, 0.2510892041888303, 0.4971904237567138, -0.8877987380603443, -0.6284746801944092, 0.7767975706121042, 0.5711340561054877, 0.16436809797841906, 1.0817662555493541, 0.3567828335861559, -0.4770048427202717, -0.6450388445668912, 0.13759650711101315, 1.015896156265757, 0.4895828335475252, -0.4707682617474622, 0.9886113298654904, 1.0361242586283301, 0.9921681043924166, 0.12259161463040769, 1.0866570527737935, -0.510654222390548, 0.42882022031557426, -0.5320045234455218, -0.883867358326416, 0.8122328479791421, -0.8969768612034315, 1.0092806812569448, 0.26369488236087507, 0.6676156339726848, -0.11819893270630755, 0.34451229360364427, 0.9876629627766929, 0.04383396131996648, 0.6473116456996816, -1.1905644877826942, 0.2529341209091001, -0.7361661386835213, 0.30828454799191257, 0.9339936365301095, 0.05238439408314198, 0.6050407237391106, 0.12770620025195023, -1.2067139654074366, -1.0153322349014324, 0.49391798491117384, -1.106358368983785, 0.01759877402542698, -0.30401155336171465, 0.6203678968652662, -0.2712525050261873, 0.13313992295398996, 0.8666069564129265, 0.8725365557307263, -0.401772080244251, -0.7395583880107509, -0.6784293172740845, -0.35615443472399333, -0.3660406676414474},
    {0.8155263554731141, 0.09165552066651815, 0.7364720979059673, -0.8330399351903973, 1.2342720626817203, -1.1526858626996483, -0.7371538748817791, 0.014349949658449374, -1.0125754851740556, -0.14014070473554846, 1.0479351577569713, 1.0835318095192015, -0.39627489956174305, -0.7965854689896393, 0.4953438434581354, -1.1337880911765623, -0.0818923365028119, 0.6563260234735507, 1.1361491946112772, -0.26387446307794254, 0.24580276363099432, -0.8285949317825658, 1.179669681144335, 1.1901295010373942, 0.023407649670556103, 0.5434399334448577, -0.3420419416872813, 0.018616015409876993, 0.11645447907004987, 0.1769501370311905, -0.8159199673398504, -1.2099840694362296, -1.0475698965223428, -0.552027760153993, 1.2256598192753327, 1.0117143295275508, 0.3237135117669773, 1.0942393639215107, 0.6437278981059272, -0.22805704055172263, 0.49629469125582043, -0.8814858687551715, -0.349052920887755, 0.8078393988204952, 0.9228580203431, -0.15315850862749544, 0.557362118821039, -1.1166949891502274, 0.1750585732193932, -0.8349708176374487, 0.13209691947216276, -0.35053597136343406, -0.5635523256574813, -0.2896197970870094, -0.11414683604213097, 0.768383531041554, 0.36219180364778053, 0.05227112553850514, 1.0443350865753807, 0.20718296180373083, -0.36508891991408327, -0.3963831417385588, -0.32922903291285655, 1.1189688605220136},
    {-0.5091772724169109, 0.40833133600867394, -0.11379112552869411, -0.9744221570815849, -0.690033663436247, 1.1476438559310824, 1.0963544415703432, 0.8681399077345135, 0.4240940018379893, 0.8560573712395955, -0.5834138738825594, 0.09875447867388155, -0.16995531382487755, -0.4943822751585424, 0.28811189844482776, 0.9866229950889902, 0.4950864400986705, 0.6155012713019743, -1.096030678171039, -0.8951764437318329, 0.6320614460629561, -0.9587203177789908, 0.6033904233676436, 0.6412748304431057, -0.35053955131619596, 0.4508470696081762, 0.7812789150102032, 0.04821537987071787, -0.512138241974448, -1.091824761504671, 0.23315429230059448, -0.32300027938061837, -0.9011732990958636, -1.0462610002906356, 1.1004312393022921, -0.05307081970486505, 0.7596488874956158, -0.6096289047621614, 0.19671193919399277, -0.06403666522072261, -0.1757320769118319, -0.2850456630256789, 0.8411635949806476, -0.06452654646284364, -0.2259865811254526, 0.9846271216855302, -0.9149318198766063, -1.0833077323322533, -0.7441115530808089, 0.9510906441402951, -1.1443377690311005, 0.7237837066183904, 0.7930046542730262, -0.10730169185733293, -0.51336145295469, 0.2920031453037583, -1.0324941981142313, 0.5300856324791646, 0.8827042821825536, -0.6596798901751078, 0.39187450596653695, -0.8570122737462675, 0.2714314995358697, -0.8593789887583458},
    {-0.8005696593713167, 0.19216440301772877, 0.3253101752338906, -0.12391957670804156, -1.3382879912783303, -1.1171870835493871, 0.37367468292861916, 1.0605750409249872, -1.3027295186078502, -0.7934378332851608, 0.04429735498335032, 0.012027862154096925, -0.8515762354554195, 1.0874876442312318, 0.733203585600598, -0.0699951327459013, 0.19620587414237825, -0.8331811152987894, 0.647862903689675, -0.4623533545929502, -0.38847638260167117, -1.1575853614296372, 0.6616882179664783, 1.0715745939613686, -1.2459721879071424, -0.9851188463002364, -0.78290476577115, 0.9007719822520448, 0.3291441204087849, -0.9959425514661158, 0.20515432723345442, -0.5355851544776378, 0.3721032052330774, 0.721335771889243, 0.6633960285759131, -1.215820439978687, 0.7215714376893502, -0.43807576944988685, -0.8680785439501474, 0.6655111273415368, 0.5625895153237591, -0.644147007132957, -1.1139840137513453, -0.318303370808855, -0.5776031893773668, 0.24632584070639443, 0.46262692616199524, 0.4441870268503497, 1.1574618961006138, 0.7342965253528273, 0.2856932067995203, -1.1087157301998682, 0.34518642641766323, 0.9451456663009143, -0.23438866796360808, -0.13037103594277524, 0.24066943865282003, 0.7151304558882672, -1.0303818836632734, 1.0368313960923294, 0.2711201806414934, 0.7396422557506508, -0.09247376506720399, -0.11132029904963985},
    {0.06146898601789315, -0.5782953788703864, 0.5281654995168222, -0.22484207049597546, -0.11955444811157327, -0.21415761179882117, 0.16884277931577144, 0.44315097144045007, -1.0782606632307805, -0.4935842809086733, -0.47991000625005836, 0.6763716261436773, 0.40201416506765403, -0.5145216911605197, 0.47482835559433323, 0.5129005224933607, -0.01700986485281538, 0.12727932653601975, -0.47193387030794637, 0.5937699780034947, -0.9204609045739696, 0.20956454920874984, -0.857320888471621, -0.7823803267671909, 0.493613894008107, -1.0046099850013623, 0.18657435738950034, -0.4747688878940812, -1.2026528301449504, -1.2337160700234224, -1.0593340932194857, -0.839819156854609, 0.933994991182008, 0.14054538465533487, 0.49620192001828967, 0.08685109043393745, 0.8818881700132611, -1.0623987037923306, 0.08744030125218784, 0.8032391046750096, -0.9982546527617512, 0.923218195046309, -0.44077490014695336, 1.1454742940553724, 0.9952102537096646, 0.8784845801147938, 0.658844341500166, 0.7111496759780078, 0.7428455689343731, -0.11615540556498821, -0.6215111040045753, -0.9572317965900963, -0.6257225326251481, 0.07318613323698549, 0.22073208468698344, 0.307036414333802, 0.9308582445645865, 1.012238906520528, 0.7439730091765947, -0.5404026381825957, 1.1466708493521847, 0.3037184930696746, -1.0951828316638905, -0.23085413680307973},
    {-0.6473943373452258, -0.47113527390095206, 0.9828482762552853, 0.8204241249655692, 1.1115954303235975, 1.2584206004301242, 0.9728568246019413, 0.0737407198582005, -0.23038868217082276, -0.6419948965019375, -0.6833142348510206, 0.9416744785323283, -0.9429596256546574, 0.8813657930433065, 0.32842533717881534, -0.918119768527277, 0.9382427405969948, -1.2015388607775, 0.11073984722853214, -0.7417606358173978, 0.9181439523672872, -0.5839678612604117, -0.7276270691816364, 0.1421652485780434, 0.8715700769392714, -0.7126319920157947, 0.47218782525771663, -0.37723745918465423, -0.38325170225924454, -0.5357649017251672, -0.9322709948851009, -0.5205343040818449, 1.113157815482114, 0.38310588441416127, -0.8948915585129299, -0.14692787960551962, 0.4981182994570535, 1.0547222641875242, -0.0725061254076617, -0.36883785204063424, 0.5119591694629201, -0.939807212453543, -0.1495757558627485, -0.7512204110806823, 0.5693860368166344, 0.9659296338690249, -0.6159572008397296, -0.2982991980266662, 0.1605807950309467, -0.865379760848906, 0.16444712420697358, -0.012297175005170219, 0.9433576330996722, -1.1312499549673602, -0.5484568076617659, 0.26100551707570896, 1.0079401867650346, 0.5829260708698915, 0.6399662471945917, -0.5625435051125125, -0.9009275534031084, 0.36629950259963984, 0.16697885592974757, -0.6162880323724984},
    {0.6438451725073876, -0.0460758877137977, 1.1309625961879932, 0.32554758904546366, -1.2272555879667584, -0.7249950844131818, -0.4838287327694969, -0.683342858954685, -0.07827840267806217, 1.0006370816427046, 0.4005163729752918, -0.7668177544979703, 0.5687316606474424, -0.44634199760958393, -0.49703142030642017, 1.0115805629738872, -0.7098338440018014, -1.2597843443048125, 0.9881183435507916, 0.4660121825200703, -0.6532655126673734, 1.1150297197699355, -0.11303682581349332, 1.0012360175384267, 0.3886956283603368, 0.8904183950608955, 0.407915875359371, 0.2865415430788448, -0.9390958574664481, 0.0043039855244382825, 0.415166206064767, -1.2534651334027118, 0.09556381090035307, 0.5761460268868451, -0.3482437451161288, 0.2518286865702893, -0.46263487026233013, -0.4623433962883204, 0.12646897164008086, 0.223287216292392, 0.2454983426356784, -0.44242323113263526, -0.3001898603451849, 0.8268272106066641, -1.0753336990138331, -0.0698946163900061, 0.17189556427243996, 1.0360694884093975, 0.12386071940546431, 1.0041899724607162, -1.1978716527370317, -0.739816672522347, 0.7784232054062091, -0.5788697943045897, 0.012640981439352703, -1.3088431632004198, -0.9756508482538533, 0.21425921735798548, -0.5065409270370269, 1.207229769759282, -0.47986607971833634, -0.4839837514281476, 0.6165011600757528, 0.3785317250507476},
    {-0.5902820580971665, 0.4017949199697742, 0.4407977495125475, -0.0276406768243615, -0.13553299552582196, 0.5440427806292872, 0.053856341927552266, 0.0625874033854989, 0.8170895686704474, -1.236906242294479, 0.002422355704133629, -0.18782435746293077, -0.28112774417258996, -0.09435053346843929, 0.6659627802481644, -0.9315806217355058, 0.49129226098845463, -0.9786979611329923, 0.1351705256914877, 0.8876467295156147, 0.6231182131848337, 0.6644890940341459, 0.16315112118285968, 0.9666938588322836, 0.5891928767393138, 0.5939894915548606, -0.1094566920204263, 0.35109627609453, -0.2717195714093222, -0.4018105574814035, -1.0611321016513628, -0.6912739101911829, 0.42593703843425973, -0.1647648434147726, 0.7468792415832832, 0.8973092336398938, -0.4119111401564897, -1.122190281448764, 0.941413665009594, -0.811859227861443, -1.0042533174786812, -0.6324019098518965, -0.3694860484714681, -0.4556157208339884, -0.8307398997138568, -0.015771615979130616, -0.5706977264902308, 1.065748810986889, 0.719559464894112, 0.6046311552684979, -1.1851142949372397, -0.5297101076794966, -1.1250195662163338, -0.8507289100801767, 0.12764772134432584, -0.5032150097540473, -1.3576896031660368, 0.34979681778412025, -1.1815666326006653, 0.5930526149219167, -0.23326438458849155, -1.0840314543789946, -0.4473792554155938, -0.5627280803379809},
    {1.1435589954004277, -0.36978672887476177, -0.3774689031331275, -0.7474105476743182, 0.7426981632678475, 1.2654624444240663, 0.5761082376683668, -0.4378753678843363, -0.9704870668982496, 1.0029390386776837, 0.0731999317319732, -0.8016033452549157, 0.8035815891483272, 0.21974960886495945, -0.4927695838878719, -0.3299521765718519, -0.2779048057841631, -0.02413754765764774, 0.6526135905353377, -1.0789929945961962, -0.12731519508658673, -0.3374675175786018, -0.7636710935310027, 0.18277855369049986, 0.6944121379844048, -0.3245708975888963, 1.0566419846883688, 0.1563633304773354, 0.08158112227719991, 0.513313616543033, 0.7497443025418633, -0.8650408066187601, 0.43261480936228436, -0.3234329553469621, 0.8335886321904474, 0.9584960292410943, -0.3825318783293109, 0.6091798648857989, -0.38464282585742876, 0.02547792173633244, 0.391940688810566, 1.010754880687411, -0.13327892425446325, -0.4467687992070149, -0.21018441476326677, -0.777495790145743, 0.5042279741031042, 0.8998399350068244, -0.14919307094923065, 1.153208131587653, -0.10020595674528668, 0.6761702978415342, 0.8299854937434072, -0.5580236657222912, 0.9104233880412993, -0.31695070872520187, 0.39944976448640795, 0.9325524762013381, -0.9529164658092674, -0.8546545860663696, 0.4164331834148235, 0.31671686168212687, -0.7136721952308596, -1.2756730961034795},
    {0.3507346011648622, 0.18691981733830657, -0.0017507929270187204, -0.6838133054671649, 1.0742646503225286, -0.12928676550997792, -0.9128688917059093, -0.46136750707940144, -0.7791793373371702, -1.0731809958710359, -0.5561935771015446, 0.44195820240595984, 0.9117630180630217, -0.704787520046944, -0.12403072334161681, 0.16321865054159376, -0.44169001942025615, -1.1640664888020356, 1.1037566331841995, 0.7716070354158124, -1.0680280879581305, 0.7250350594186806, -1.0660521621675654, -1.1182779090167252, 0.8715263271746533, -0.6339985447716718, -0.9984251501518091, -1.0350024408295793, 0.35377667660201084, 0.4955735296265587, -0.1993114947044253, -0.2997762335228422, 0.2746423175510661, -1.045637165377567, 0.83831079120204, 0.5474439038208834, 0.5362855941117871, -0.6034164029556077, -1.0187204756984218, -1.0864289514751693, 0.8468721540799679, -0.6174561695668827, -1.09243911851629, 0.13710087673756488, 1.3115070398043156, -0.4479101976518064, 0.6483541106212702, 1.0116493562720132, -0.6173309735699855, 0.4325937831812885, 0.028130030182916797, 1.0686533653320949, -0.4727109728443663, -1.2157135923769307, 0.3796545010787326, 0.24809472922805345, 0.7686680030604484, -0.47796561820799277, -1.1183317020967949, 1.060209643987897, 0.40828179472022336, 0.373067214045241, 1.096069201782357, -0.5326991373668776},
    {0.4454505155523089, 0.11828542403518597, -1.0465465133154566, 0.851238223536557, 0.9551599829134674, 1.2321092397398898, 0.23055962181188822, 0.5591990004785651, -0.3538869177535764, 0.22949781244967896, -1.1494893385294167, -0.047726669794024394, -0.060609059187372194, 1.1411797654958309, 0.054980743963721476, 0.16611758785961742, -0.1518681409609399, 0.8281729884879898, 0.44783488089402895, 1.0444728462798234, 1.253619608142253, 0.9163664471199501, 0.44975798617561585, 0.9426305505014462, -0.38423036724767917, -0.33111672225983435, 0.2131245967721554, 1.180971213249773, -0.019166631850268387, -0.5046241094394607, -0.21637607942784268, 0.6605500027096175, -0.5996420761869398, -0.546129201477264, 0.11032687332717878, -0.09106387891230458, 0.3545668115538197, -0.20499549779556736, -0.32030689297163384, 1.0273306648275238, 0.3611569156652637, 1.102993002113843, 0.6048826094265254, 0.5167612036272474, -0.9082585544578088, -1.0575651471712135, -0.050931445610378996, 0.023004290999831922, -0.7245538712354231, -0.3254981700471492, -0.023491936714870727, 0.83553650101717, -0.814238301970959, -0.7328814130051637, -0.7705095629084963, -1.2474549150044323, -0.0040684696310690355, -0.9705001258189355, -0.14288798089373625, -0.37515908517910374, -0.6368200218452189, -0.9297077862737338, 0.7791821744008702, -0.5426254023938836},
    {0.5986270069919911, 1.1517525039627237, 0.9837239127498549, -0.24376538024830574, 0.6277084249481719, 0.39573394090288055, 1.1629546743411727, -0.13541713977086914, -0.8273931417602098, -0.5414024215426508, -0.020921891132500633, -0.46193507635096803, 0.24061073673149377, 0.8536563159962754, 0.9262418364111673, 1.1662427459816072, -0.31878726428158954, 0.3682261195340087, -0.644915610476405, 0.6300603855461661, -0.08339244772766848, -0.9345774803280898, 0.09827863307907252, 0.44771378323378125, 0.5829281339907083, 0.4511797698543132, -0.288930554980753, -0.013924877224800217, 1.0245590806294322, -1.0389790875525011, 1.038092197054873, 0.2095427035235068, -0.2886193791507398, 0.011746089518682199, -0.26427524644207584, 0.8804662609647781, 0.47742329413038165, 0.8348397645123535, 0.5594635150818926, 0.19143042351121614, 0.4073435614072635, 0.6692769077370473, 1.0121395184160098, 0.6756160172432629, -0.8152404343830646, -0.6186016892106697, 0.5142974267226934, -0.8522182533195622, 0.41683729005394143, -0.2436831674536279, 0.6597827950206431, 0.9860614842249666, 0.9545178912538361, -1.0705984962655175, 0.849039045238584, 0.9220940646302214, 1.3057610257846337, 0.36685079990511504, 0.9396402945649008, 0.8857974590051697, -0.5210801608660922, 0.8036099304380442, 0.37536105997127883, 1.1981775064452196},
    {0.0324002030757971, -0.02822763160654533, -0.5562060423154611, -1.019612065135502, 0.846051277918886, -1.068403710457693, -1.1771675522486256, 0.8719730788956005, -0.5053764518587949, 0.49559810141463456, 0.09781004887973399, 1.2234171199861268, 0.8984526425578179, -1.1148710701417792, 0.09448878576845782, -0.32328559198290846, 0.046219489375536896, -0.6103247246962518, -0.7838465926676206, -0.8889130360877693, 0.8581084666953547, -1.1608245170092588, -0.09596190943846623, 0.4447031632236739, 0.6066242542230058, 0.9003635288954308, -0.8315999622367137, 1.0256001627413247, 0.9508324879685212, -1.08744943410468, -0.9240735786111934, 0.3171688326343567, 0.4666168822734163, 1.0373038780839339, 0.23072785566526707, -0.5947480078655126, 0.7319967298803766, -1.1209339479821019, -0.24056919612738104, -1.0540366677223976, -1.1622394746621625, -0.8177529371016862, 0.5383490200293697, 0.302615117291528, 0.9297638631461429, -0.2871115878874049, 0.07230445207331748, 1.1134607100360663, 0.8724665568496622, 0.6038062146772439, 0.39821323053297936, 0.6696866582846315, -1.2426730302616193, -1.0368650547976213, -0.1872474580332062, -0.1597875291156696, 0.004146312909440692, -1.0246096803928042, -0.31290005604846066, -0.6202234339975609, -0.5107230951727386, -0.8615267741654492, 0.31637961308068085, 1.0196584340249129},
    {-0.3432283055514264, 0.7824352062305587, -0.35683265234435113, 0.382073843812394, -1.104881310662055, 0.5435476780850714, -1.1664704537223198, 0.5425616475121696, -0.7096428258675908, 0.4515709926776803, -0.6627034231672362, -1.2277499131316214, -1.3946818548170554, 0.304904886195034, -0.9180444148615244, -0.5955367693065864, -0.18408896144144699, 0.0020487657868894973, 0.08491634381742645, -0.5593939960189583, -0.5416511173338285, 0.28405870414660656, -0.6618692834776774, -0.8271518110776515, -0.7994431012115316, 0.39334169273621866, -0.9717463816324416, -1.0354960226430943, -0.7287902367582534, -0.30833516764390223, 0.8967039998622639, -1.0092366956815122, 0.5778144762500281, -0.8327361169208221, -0.7876569744900678, 0.6678435997812006, 0.5048942754475865, 0.4293574508977483, -0.568648376104965, -0.5423711400235368, 0.7625996838050066, -0.8242387917247402, 0.69086249636418, 0.5369924899387665, -0.14265721720101476, -0.5656162207085106, 0.5973115948947912, -0.12854742563373858, -0.9739311822975193, -0.3286625659950615, 0.4594549163604973, 0.49598478726336376, 0.008930696698376019, 0.15860784656808244, 0.4300612750738837, -0.7901762641076053, 0.0831450535256646, 0.11058221490060349, 0.9767917159579359, 0.11031288480931316, 0.6714393401580083, 0.6262684235501693, -0.22242307112088844, -0.8376586037434304},
    {0.12638799567857442, 0.8312272930471026, -0.18237583634361748, 0.46624257603758096, -1.1055152505774168, 0.6103372808027332, -0.5690174821531037, 0.8866031513080973, -0.0346552695622428, 0.61645334738442, -1.1621105918574886, -0.6006855507004641, 0.6662108786292217, -0.7675511977088068, 0.9028485578170852, -0.2813435494557022, 0.9657675180012663, 0.6056468656839834, 1.0673335844608256, 0.13017430215523482, 0.803680653525103, -0.1418070568747979, -0.4848047211738704, 0.6007657594688053, 1.1315112000812315, -0.31457430833400934, 0.31620877332633196, -1.0632989617225248, -1.0964977747432822, 0.19663499940576964, 0.34858281780909434, -0.1779673139621915, -1.2079332159503575, 1.1019540862891644, -0.4611992940289498, -0.6252770330507106, 0.4655338242444913, -0.8294762340364066, 1.082974336791019, -0.7749255732795785, -0.7212496606435167, 0.9430616025677777, 0.469851349228726, -0.2101148254060904, -0.3842956438383973, 1.1296798478029235, -0.30006184906972805, -0.373832323865285, 0.37559194380498745, -0.25142570043471735, -0.2704200075739784, -0.5268142502225496, -0.8641805796319241, 0.8890778605764119, 0.2443132502101606, -0.6573426380476789, -0.3647530828879119, -0.26820772144516924, -0.4319383205512149, -0.6586159470580519, -0.0947301622055365, 0.8370596862628338, 0.17622148810957503, -0.24369105318137857},
    {1.0431187059632314, -0.24010521376189942, 0.6864588860307338, -0.05027581872634148, -0.5419199824691385, 0.9493804775009765, 0.24201560873799624, 0.9602725874860705, -1.2349363605298553, -0.31863355796122045, -1.000734775788573, -0.7066362289550326, -0.7889371039391352, -0.03211012707431264, -1.2430582432527921, -0.6133237302802349, 0.14532337060784065, -1.0624746127392166, 0.4955179110348652, -0.02179956415417288, -0.15389662769030366, 0.43221414866138985, -1.1845620797720013, -1.1174494855056218, 0.5220657794244751, -0.1608234121977987, 0.353590207444038, -0.06084150798159187, 0.31286098562042153, 0.5133062025219952, 1.0863404059905235, 0.4976177451243268, 0.43314369174165096, -0.12213303393073999, -0.8165642298396264, -0.1513895516931528, 0.8696784609287873, -0.02761487096253923, 0.9737816395996804, 0.959976238983858, 0.12604038499814904, 0.3283788368262308, 0.11208569893344258, 0.2329224626754636, 0.044066531121643174, -0.05857275064156711, -1.1524581982565207, 0.0429147525518388, 0.4397372426041622, -1.1343959640694568, 1.0222674926829611, 0.6793688948124901, -0.7479656036199727, -1.1128228424779703, 0.9006114647048282, 0.24784666802853902, -0.6030320643794225, 0.5301377660007687, 0.5773546543374152, -0.43184941876678457, -0.7914300324940594, 0.959515547404844, -0.3621260491274989, 0.5419836684995629},
    {0.962861412817863, 0.32807078034742565, 0.6767976602218896, -1.3197128353990966, -1.2791412033120568, -0.013749674593753338, -0.9862966293246574, -0.004217670118871515, -0.6836105482309739, 0.3735783849357985, -1.142072849795589, 0.23115669342853107, 1.0247218148735457, 0.10447444200895789, -0.6415038457213663, -0.29930403502163505, 0.4918953041136745, -0.8726179581352113, 0.21105137331299775, 0.637966941421945, -0.15738978845137241, 0.883969376944488, -0.94049207931857, 0.5709805518329301, 1.110640004581322, 0.5944837578947937, 0.015421359211019586, -0.703089847447866, 0.08339084133333116, -1.21618850576358, -0.2906201355342715, -0.644533396950706, -0.4661486030341226, -0.5845401872004117, -0.9771590137408231, 0.2634761825219133, 0.3060753035275255, -1.1306792866630757, 0.05120144323205033, 0.8809371920349895, 0.030449571224829226, -0.3907982454364334, 0.09568385090620528, 1.1042777222673257, -0.29682376752748696, -0.13710872999831755, -0.42129015627718336, 0.7603372204797, -0.10140876863044135, -0.7674068499599017, 0.8033331380924965, -0.3791252040455314, 0.05463019065338045, -0.744411315942538, 0.6630004346506548, -0.41577343943259115, 0.8779665314744687, 0.4911552609164868, 0.43846417645975766, -0.7052485078760001, 0.25045701599207754, -0.7438057567448105, 0.4887946614251439, -0.040137485571125425},
    {0.21555951088809971, -0.1934676782521373, -0.9857211302973595, -0.11045776938967665, 0.5861667036718248, 0.8636883437929876, 0.7630342726320188, -0.042886772330650774, -0.7961657600332169, 0.6043882400855878, -0.5119254460694663, 0.6465401709616795, 0.9425760357331487, 0.23096973663547538, -0.8997956687664546, 0.9560638919832634, -0.7402436745099744, -1.2414942472901749, -0.6088176854831076, -0.08189033482342313, 0.8650090515700151, 0.10149294282349759, -1.311780605751477, 1.1736952458818144, 0.7364515899233235, 0.20842887389055642, 0.5483028685249249, 0.5999765906701854, 0.8014142700896894, -0.3111270390917057, 0.011220015208596019, -0.06465739252334866, 0.8160831304455514, -0.6312188509774217, 0.016545705273587855, -0.966817400661525, 0.8929950928313107, -0.7243295455321392, 1.2464082968395818, 0.00525457294806006, -0.9299763664490689, 0.7583006085918759, 0.06932871071426994, -0.9339538732094361, -0.05353877746800814, 0.34184471845579883, -0.2172816878921757, 0.09224512382657485, -0.4825198357181191, -1.0941764769318645, -0.7184235445769829, -0.9814741625652112, -1.0549040320355187, -0.23920391205994632, -0.9626396483137898, -0.4728080470039966, 0.017357739064887336, -0.130243245073051, 0.269968547164877, -0.05017651158263804, 0.7077832942236251, -0.20865882917576975, 0.08460879312794424, -0.7935381942965527},
    {0.39156629301657325, -0.5319677501168478, -0.9537503803102886, -0.7098573548939368, -0.6672156454849022, 0.3793625921062702, 0.9693970791769833, 0.8276934017764723, -0.07443441375374753, -1.184394900876348, -0.9065028343572827, 0.8927890873179132, 0.29158812321414074, 0.9451038121644575, 0.5561530854007083, 0.5946667248676005, 0.3969330571737715, -1.22583526749466, -0.5502057725628038, -0.5285648377250242, -0.8241039870455691, 1.0389270504770962, -0.37109550160173466, 1.0514293169505209, -0.2658575292265748, -0.8682529052923533, -0.41725437092581275, 0.6104735893120325, -0.26163961711035666, -0.07421116663812986, 1.0840052799992637, 0.6492435440394371, 0.93229617178822, 0.5309231331106451, -0.924673978680385, -0.7734610793919862, 0.08590005675304543, -0.104056054867298, -0.2791748458548516, -0.18057801305301974, -0.6761253959125728, 0.04932331722330576, -0.8250013691751028, 0.22626981775454202, -0.902869632908202, -0.549142434519654, 0.675291579420711, 0.7300231484911847, -0.7171977504414392, -0.5291767986853213, 0.10149380437770177, -0.4781184967194767, -0.7558911680733532, 1.2206853225438523, 1.1002682285975076, 1.0089573867507589, 0.3796110643628207, -0.9386399477988061, -1.3330027454014113, 0.7039292961052762, 0.45667409295130323, 0.973903307233618, 0.032871773395188514, -1.0111351399510973},
    {0.9538253702849435, -0.6112795360819496, -0.4604106821006468, -0.737853515422853, 0.3252626976862717, -0.0525100791723363, 1.135812457875791, -0.6700887692369469, -0.03028806283587088, -0.07623444300298633, -0.2742031409840564, -0.868983395756719, -0.6575856673080231, -0.3370369225191014, 0.7520384502305701, -1.009361562648322, 0.3819399661013825, -0.24875986378051174, 1.2786863405988098, 0.3687818683127992, 0.46136787446889105, 0.7728909361914308, -1.2355079954039154, -0.2323167493269135, -0.18227825546059748, -1.097180826171549, 0.8668560651806577, 1.133923146954215, -0.16880499195615375, -0.8537798619131641, 0.4791031866466122, -0.14220622048996684, 0.09777278071329117, -0.8195136144402894, -0.5079150963467097, 0.6372750753961862, 0.9479284586369352, 1.170174936842912, -0.4694301954585325, 0.7672380943797524, 0.22763131050229513, -0.17726632289336322, 1.1651692161045297, -0.03632751337396062, 1.25767352004394, 1.1873150092241609, -0.47679690296401545, -0.8378713770884344, -0.6210610777875942, -1.0350303561359675, 0.8819284399022361, -0.43294531785162954, 0.925296067897028, -0.9470352655013937, -0.8140676976012973, -0.8164414345049203, -0.9863777314524965, -0.05968899797614252, -0.33905433334251556, 0.30809551691936554, -0.9813653976704072, 0.20215899795941042, -0.6755324215860365, -0.23777983330402513}
};

static const float b1[64] = {1.0921932681789785, 1.286264025831659, 1.3403759225135772, 1.095993498980787, 1.3558293329788635, 1.2602299600632951, 0.9392552238430567, 0.8953943880144957, 1.349652171906827, 1.36395308802374, 1.3495610409698962, 1.1808118423478209, 1.253759692017757, 1.2439373860428087, 1.0170296353444108, 1.336241576361502, 0.8540808624715496, 1.3675987268353038, 1.2793587208045787, 0.8870489485069113, 0.9823584186834603, 1.2788851239273455, 1.3957510523984658, 0.759430453847847, 1.3460686434729932, 1.0222077102946385, 0.5702358038141896, 1.261713389827921, 1.2746029317115317, 1.2259944588004843, 1.4643029544981252, 1.0740992015451594, 0.9309632460245647, 1.0666663866597774, 1.3043046307257427, 1.2360886803487514, 1.2344328447790234, 1.1949761519878042, 0.9629368645229069, 1.261014118434375, 1.2934506900164695, 0.8180981099972334, 1.393141704788323, 1.4704827638156504, 1.3772825316671016, 1.1869930968247988, 1.0953437708584246, 1.0182006967462367, 1.2472240735667413, 0.7551655879524254, 1.0122202499548696, 1.162525370306783, 1.3337075996694252, 1.2195956506966754, 1.3155464575610454, 1.1920338931854786, 1.2164871707626237, 0.7419314817687785, 1.3001946925610246, 1.2828469511961533, 0.8682905696268306, 1.0117743820056362, 1.06350107012127, 1.3894602756184455};

static const float w2[64][32] = {
    {0.41293523744090727, 1.1088274026571094, 1.3543787572001666, -1.03092406897114, 1.183747276629827, 0.22308345762525994, 0.8997721422383285, 0.33026815842246704, -0.14786735497887984, 0.9833177792196554, 0.377734238502071, 1.3380093632739918, 0.868554221040344, 0.9124298178638159, 1.8319997585500956, 0.578751249264639, -0.3339240619815858, -0.05098534702236404, -0.11636929173981365, 0.9995720568105986, 0.6260705335445144, -0.00796754507878344, 1.6221264633565178, 0.18111708648966438, 0.6632795161641986, 0.21712886928941272, 1.8657455506062413, 0.5985702223905438, 0.5456377905475701, -0.7592244895625695, 1.219210934237853, 1.0507587987691223},
    {0.9439823530957051, 1.4787547173202165, 1.083394158139032, 0.78476795426424, 0.9307412949179961, 1.0928359385601238, 0.1352399843384346, 1.521046541969776, -0.26463981565013533, 0.0007115672009320894, -0.13532429517812838, 1.295511181118042, 0.7938693586587166, 1.87932369265902, 0.5016261183443862, 0.5961136294606559, 0.6986403830952476, 0.07177376381292058, -0.4377665037126074, 1.2033950557278041, 0.18487339805144257, -0.7838600781546003, 0.18726122523255698, -0.07639169785456189, 1.3355494828553858, 1.5353760482141912, 0.8224402408211818, 0.4319473055201614, 1.4249313643729533, -0.8414496276620897, 0.5327355619044828, 0.7792228139494002},
    {0.9250590470002481, 1.6735959364029116, 1.718233541871158, -0.8015100270308833, 0.8176992377337248, -0.2519437378747163, 0.8822714957523098, 0.7570142865279641, 1.0273712147743896, 0.505065872308643, 0.04150908831927389, 1.7392203787373717, 0.8456717519141987, 1.779509703374307, 1.6462490406023111, 0.5567885999203559, -0.17668306075932455, 1.0799606509174873, -0.5147778904479565, 1.3295922283925345, 0.7415504622849379, 0.009988447020587344, 1.795857462812339, 0.29913953442503144, 2.0053841288299106, 0.3374062992510062, 1.1901828304352007, -1.0533866896379784, 0.004706551159416957, 0.06601650695333262, 0.760276853420904, 1.0463519508820198},
    {0.8239678342187743, 1.6203134729328386, 1.0935163259770888, -0.24824192675259082, 1.2258398607719492, -0.08799277225556314, 1.2927622405742338, 0.3178741235759226, 0.3759997770776852, 0.9131203903698321, 0.5369137024570064, -0.09016333960863512, 0.395148196489603, 0.2599241720816661, 0.5966503320944805, 0.26213722379230664, 1.2349412101362887, 0.7481856391300898, 0.56120383044686, 0.16984850108751942, 0.9319464839408688, -0.14128803530030593, 0.6498704605831087, 0.8017216278529388, 0.8821530110792459, 1.8379629743468664, 0.3996414266498738, -0.8767743845265148, 1.256901593259034, -0.2647614803802298, 1.7808945013519648, 1.2645843850426814},
    {1.309796524410581, 1.8818651050790671, 1.574926836169699, -0.508138901710976, 0.5413541833381288, 0.5502726016529536, 0.4644682835272382, 1.218159232677606, 0.07275704408029175, 1.568265931621489, -0.21799684088435764, 1.2078745829745248, -0.6765896229063072, 0.8841432777170593, -0.016810241045332467, -0.6002005481288728, 0.9583067120596008, 1.6713458651871864, -0.4447733742580365, 0.01949903254021635, 0.3375302851783432, 0.5833861791048957, 0.28424336018235724, 0.5173187202962575, 2.0025659045294897, 1.375945166107058, 0.4866406900057998, -0.08756020017319857, -0.08511211117790818, -0.21070841903340534, 1.680545497764637, 1.3714627862897468},
    {0.6677337337394155, 0.10785879262150772, 1.7727688946024283, -0.504908984654623, 0.8225955433030985, 0.3587808508570893, 1.1343862614282043, 1.506221028296971, 0.30644302902557125, 0.8052588024393302, -0.22799119981917576, 1.4995881451432025, -0.01022623720543, 1.085155048361355, 1.5407174106796964, -0.12679024781559875, 1.151301750304747, 0.45000269870756665, -0.19345873174865283, 0.5534670539118787, -0.056468406433117936, -0.3312393629025687, 1.9172893049522668, 0.9102646180903116, 1.810344264167421, 0.549069755049138, 1.4968570694622672, 0.13318530975994855, 1.2736168838535316, -0.7693651031100277, 1.8743347737468312, 1.375295476378786},
    {0.8219536344659022, 0.9554500048082127, 1.1140699658813842, -1.0100114691269133, 0.11726444618919799, 0.32135597539733335, 0.29920017958839085, 0.23022921649256292, 0.5343684135891809, 0.5582607845509987, -0.7227791040392516, 1.6233201616642534, 0.1453514163192978, 0.19955096618353144, 0.9783732211144157, -1.0806225494759856, 0.14744893494110278, 0.6932337365331477, -0.7607657313958507, 0.745533852381785, 1.457991096881788, -1.0839221597359319, 1.525122165851707, 0.9026294569211442, 0.3689018904691361, 0.2968819615057288, 1.4006414479777838, -0.7096540420273627, 1.4457187211155538, 0.1529979804420399, 1.8869798273251404, 0.18925049297821173},
    {0.38440949552728576, 0.6622567608469653, 0.2289649729694708, -0.8343370289772989, 0.3547044049317577, 1.2164155391864633, -0.19887326611779527, 0.24902307719547653, 1.061075762919348, 1.1775907288311178, 0.3112026730358328, 0.07398420567666365, 0.1462084888606585, 0.5782832433104445, 1.4485497682157058, 0.4685051664272994, 0.3106083926227006, 0.7497237426910005, 0.419903170531743, 1.4609365704135844, -0.41351566287250985, -0.7510303604943553, 0.4062659744456733, 0.14087623685971212, 0.6152981887566731, 0.7437302971904494, 0.25765848241129585, 0.5905508611204338, 1.0774452664022758, -0.42854239497266616, 1.834514989263124, 1.6671339107480347},
    {1.4073800212157952, 1.0444282527368558, 1.0977378215399125, -0.5801923705372509, 1.2518548169198906, 1.473844336085162, 0.5581869901745155, 1.010551609567284, -0.25537144959551256, 0.4799466571235755, 0.730659730426551, 1.2330771767733286, 0.6128252660006882, 1.5939823261349024, 0.2778491445135246, -0.049992870064993186, -0.15681100921188046, 0.9334702790248973, 0.48572247275716784, 0.3687917395902914, 0.30206003103528684, -0.2638351512288993, 0.5884546365946296, -0.7258889623508483, 1.6711763045039494, 0.869676040838117, -0.08868995037099163, 0.2334302817065758, 1.4274954371719972, -0.010515532284500424, 0.7798614399056191, 1.5685942776835657},
    {1.30645453242343, 1.0184234571061712, 0.6071799226719571, -0.23245024464724118, 0.227248170747369, 1.1451517352323248, 0.26405563751555616, 0.5700669129057105, 0.7610742448398841, 1.5209835141345958, 0.4875985494445227, 0.09225101314993378, -0.9432822971529573, 1.331991432495762, 1.5548533329638003, -0.3647337049558793, 0.15423999411067796, 0.08252940346309652, -0.8264034133645073, 1.2989688959479333, 0.10360160443094817, 0.7394158528808619, 1.125110389329457, -0.18072649705347224, 1.4582890814548568, 1.5052391804412482, -0.09246338209040662, -0.04851056228328207, 1.701410387843565, 0.9165096290019135, 1.4456592589680586, 1.8317351520986473},
    {-0.24570808205536476, 0.49833925216477387, 0.2707008664385897, -0.3463210891150752, 1.6784437349288348, 1.4764218437993826, 0.9476062122486003, 0.6236693116567683, 0.8026261667060326, 0.9099983547517518, 0.5352306256710455, 0.12602592249134045, -0.8712737408067515, 1.3923507500442982, 1.3194719412778853, -0.23701032838966932, -0.23607202990950402, 1.6777061602491434, -0.4658382966781964, 0.6368194631492202, -0.27491211701777857, -1.0318069131119738, 0.1700287160343542, -0.4238995203462973, 2.0069506180218197, 1.6214079469305331, 0.48102644909093234, -0.016902893741287058, 1.2740804186960932, -0.49569135758216915, 0.07849887094624826, 1.9448121637257436},
    {1.1154449168926628, 0.21363523869771484, 0.19890673537556378, -0.39971380753155294, 1.4189856161871397, 1.0683139593296866, -0.011692652054549368, 1.507934802430322, 0.8859347618890006, 0.2018004619939046, -1.077649333785767, 0.005498442744791698, 0.1631538837552375, 1.7951958515512079, 1.0759412587834807, 0.6866359257047542, -0.14048019803024445, 0.9826702117191339, 0.1266275933679161, 0.2912455686558796, 0.6167298490801653, -0.10464713750585689, 0.4289671174258343, -0.3544486191243184, 1.3220699202157613, 1.114704790442698, -0.004530482380771669, -0.6975334323940181, 1.4310250245705969, 0.38986674639000723, 0.2328292971152463, 1.804338230042963},
    {1.5339437113787244, 0.4233285029200998, 0.810595529388132, -0.3701869406993297, 0.4798100843917308, 0.1605205867967462, -0.44485791042426803, 0.9044409092948348, -0.2155460611548865, 0.4860156360523817, 0.7157452375099465, 0.04908699985942747, -0.862806418926376, 1.1957895714416347, 0.7395964731836969, -1.2645834851751085, 1.4225458562178437, -0.181601015619927, 0.6827041309834624, 1.6476740589275207, -0.16935940985276515, -0.8831125352370274, 0.7305770472274262, 0.7124297745732596, 0.30685256004881234, 1.6413189526563745, 0.911132034319389, 0.7447866033126236, 0.649566047395855, 0.4447530270224814, 1.8922390163692033, 1.965896508383542},
    {0.5395492640919922, 0.7336218578070135, 0.8823540077244884, -0.9685895420072325, 0.4064147899099995, 0.5917655928317618, 0.491822640160716, 0.6586021828844115, -0.49771779687560286, 1.3718293225284568, 0.7036389956537865, 0.4353424404488027, -0.3799993388109272, 0.8710206589958271, 0.5951035943318053, -1.0228421278553268, 0.6457057707999265, 0.07124394888284759, -0.7474207381585959, 1.757847564574103, 0.18546861841699697, -1.0618593727895302, 0.047040538874548996, -0.7031908351610716, 1.1890874292977658, 1.9914920660234015, 0.9352363587503429, 0.16640919620184338, 1.3161873847980832, 0.36671931586636103, 0.3973405769138999, 1.369315641524641},
    {1.0243765578525705, 1.3378486400101448, 0.7072944970341727, -0.15285849655207523, 1.8270231422033203, 0.6345363315345444, 0.868053725328522, 0.5103574380263818, 0.4360141374446527, 1.4253169736003988, 0.27022067537891914, 0.8679699839361409, -0.0476071605963307, 0.247225117136199, 0.4900898097117974, -0.3592095295667567, 0.4076824842383542, 1.2632099311523892, -1.095439301417262, 0.47684221185163544, 0.7226991044601173, 0.4002975400726868, 1.5911786168853828, -0.5290870558166599, 0.8716188223464814, 1.2458014796183858, 1.555203269347383, 0.4383952623693475, 1.4060945979850896, 0.776027637120534, 0.6732106576311917, 0.19016443470254332},
    {0.16476889379085582, 0.5197457664771417, 1.3384980157569002, 0.21473501611797477, 1.2587716281644221, 0.9035675128200481, -0.5019912009777284, -0.04848406735403423, 0.13804413915651903, 0.6975310508968097, -1.126606874260862, 1.4930711021997656, -0.07935435621855054, 0.6409940588495663, 0.512644166022728, -0.05813757299859354, 1.2920750551657751, 1.3548280038446192, -0.7409249630163375, 1.482331500731706, 0.6671735214003344, 0.6758087655118765, 1.6697489331550315, 0.043384963596524086, 1.9586296058559027, 0.18585909655320565, 0.12123757330716871, 0.3021761493905619, 0.407094615775844, 0.04160642392289595, 1.4571012932656988, 1.8866745069765543},
    {0.0866657960370929, 0.8003896782372993, 1.0308023489201597, 0.7759660426558617, 0.008559446524486012, 1.1405765199628861, 0.8868812382459409, 1.3497053720309011, 0.9414939221418042, 0.43841355423560424, -1.0874986362949022, 0.8961994086521295, -0.8213115410687893, 0.7563415905861474, 1.6381626782690666, -0.01130345562542242, 0.5965086455378894, 0.2987027739276394, -0.29584126681622, 1.114288587247387, -0.08001922284497462, -0.9162167770674124, 0.9761553231847683, 0.4957339060027248, 0.3941918760437342, 1.5600813891822687, 0.020961827495014653, -0.27258048134203827, 1.6286709321235753, -0.08531727871894554, 0.1696540798420321, 0.12597562502585793},
    {-0.25599790433478825, 1.2633923263846718, 1.8505456937142903, -0.8365159295564222, 0.6324334133268814, 1.0958432001867453, 0.9873137528431775, 0.3184808889625285, 0.7952939575592416, 1.6870562163291456, 0.21007181177110798, 1.691707346836606, 0.6490481944430148, 1.8428699738416783, 1.5326592403235075, -0.5944849287329307, -0.36585746276536535, 1.3292683509647392, -0.6077538051137715, 0.9512546957995744, 1.1455155250410782, -0.11002493112502285, 0.45613943228493836, 0.5602002328728999, 1.7637309757808546, 0.2915227923629471, 0.5976746172708661, -0.6749870159162004, 1.7798421038332737, -0.9881218670253648, 0.15061307514354746, 1.7733663797566712},
    {1.323019372138601, 1.1698872022809692, 0.756138990896355, -0.6019356640296543, 1.4686946069794626, 0.34925957784143413, -0.3905993889074449, 0.2470775320300326, 0.9008139729339419, 0.7591929542107513, -0.15015701417548777, -0.13460011583550083, -0.29498424641670823, 1.5519396640460064, 1.811451406160259, 0.5375261993713752, -0.2963951382643654, 0.15138933525200593, 0.2714207354623837, 0.9629486610177619, 0.18957715195497016, 0.11929488638660056, 0.3348362270123506, 0.41625223196570604, 1.8747657657745618, 1.1359299445684483, 1.206482219852252, 0.07990548565534474, -0.13140319070318543, -0.847662731756221, 1.762389736859002, 0.5133443875334405},
    {0.1778347157249882, 0.29930089095188256, 0.15766968904856193, 0.9412022754802228, 0.6263739671096236, 0.851137229944853, -0.3164780376810596, 1.125112112740667, -0.3222918759365187, 0.19851050347367946, -0.38766943806552034, 1.1958346063386451, -0.5335143455534798, 1.8545084938233445, 0.36552373656122605, -0.42518426011740634, -0.3507629837586885, 0.24390793475250502, 0.31121283333698335, 0.2958298553465426, 1.4327829140852042, 0.7532811455945253, 1.5091422315170042, 0.9517579095524702, 0.20802804357326904, 0.6123321088842331, 0.18334633209651474, 0.5078382205746773, -0.19389323998621455, 0.5854805182484674, 1.2325150082094514, 2.012720110780785},
    {0.6486082323338147, 1.7999319414250712, 1.108866854847599, 0.577629624977255, 0.5394286687895341, 1.0156722061603365, 0.08931845235593024, 0.5831383692156379, -0.4940265033425521, 0.8141861937572545, -0.6125832070683673, 0.7978789661992683, -0.19784319354516144, 0.57468691810537, 0.8981446504849295, -0.9996838489391716, -0.39486494143910994, 0.4576382195445068, 0.625483860992092, 1.168594886482932, -0.40764686307143316, -0.24587693873202734, 1.8743755370938802, 0.8195426098812226, 0.43437500333846, 0.7896326538879715, 0.40300132192005467, 0.2005305510110823, 0.0628287508545035, 0.7130002384965062, 1.4771143918249017, 0.4413527410222816},
    {-0.1864767973774598, 1.568874707239884, 1.633682893201731, -0.8092296965510605, 0.37985308615565866, 1.1078209228742648, -0.07059210149494233, 1.2858018360232113, -0.37457047535042265, 0.06626244079439667, 0.045010380058728996, 0.05351221614657243, -0.1209661891855325, 1.8208236764484047, 0.35421706542031467, -0.28350677930748625, 0.593379118660949, 1.111135763047977, -0.8435308180294168, 1.0218170479700046, 0.3597681266598237, -0.46703579033753007, 0.8392159517896021, -0.32058857695759996, 0.18621218698670453, 1.0836984302925161, 1.34703736832118, -0.13865216802360622, 0.9454700482306387, -1.0128154018572295, 0.1754443590017649, 1.5242976322370556},
    {-0.02092153401969821, 0.9755860560602758, 1.6651423100329112, 0.352944590768108, 0.8437578654827049, 0.7360873366889397, 0.33480124740013445, 0.6988622324186053, -0.4145141968711014, 0.494845040021453, -0.11301928156154858, 0.8999807284284603, -0.7091704098737205, 1.0996979595748697, 0.3354004194726048, -1.1028366968288277, -0.06828839466873682, 0.732350457448166, 0.21553067220012412, 0.42532946957979356, -0.09427529421119744, -0.9591287045881375, 0.16196782720142708, -0.35993515493730177, 1.4554846090661775, 1.6563617532965065, 1.3940026578484588, 0.07159531615963474, 1.087311860229816, -0.8647953713203643, 0.6600995589327198, 1.8047201288176364},
    {-0.15910222409444247, 0.3479110519535267, 0.7566867793523204, -0.14110976813089832, 1.8154879206496235, 0.37302552060707467, 0.24276628201607214, 0.7212084364233163, 0.12708969404370077, 0.728216931603924, 0.12626938805567678, 0.3740445587347013, -0.18800736780167995, 0.3557817849645928, 0.9596037418375877, -0.024330215459103167, -0.34034728202410436, 1.433858321781389, 0.395142607713348, 0.7012223487422186, 0.3586094805698169, -0.6560090470223874, 0.25180447317466365, 0.8669967238362766, 0.40402404376696877, 1.1339989422610541, 0.7742570684870326, 0.2983134451871312, 0.8020722873761714, -1.018342508690177, 1.004809933969033, 0.577867570034484},
    {0.286186206027427, 1.7054061171438806, 0.5715567921429836, -0.4490665337626851, 1.3207666173387236, 0.7603732821064169, -0.4709513112499096, 1.9251129971887484, 0.27246461988518866, 1.5091158303811156, -0.9333366576810985, 1.715214314469906, 0.22906606653823783, 1.739927342127971, 1.534970433638104, 0.5198959523019194, -0.4476370374020762, 1.3710234824926544, -0.0535678558926628, 1.0284585760801341, 0.18564328732025148, -0.5263105783955662, 1.7852822908276524, -0.16342125746643124, 1.4269076889165893, 0.1468623247140204, 0.2744654364282238, -0.08537782993684896, 1.2681029645586113, -0.2364789623244601, 1.0105566273342355, 1.8355332390902321},
    {0.7631467993703395, 1.7067130486864142, 1.887792743021779, 0.1371453312195545, 0.6915146952062552, 0.8388869158716019, 1.054622067029912, 1.6158610610554611, 0.40988627944604894, 0.9270619894275234, 0.4337415659199556, 0.8685293550326202, 0.21039001823451997, 0.8966664612611904, 0.7184226376425248, 0.538897668353974, 0.1323890125438376, 0.6094752072471236, 0.2737623969746699, 0.7293186948901443, 0.7583836654919911, 0.7291904415962789, 0.16071525637595685, -0.24061858495151647, 0.5315251458861573, 1.8881972564392275, 1.2580489120375882, -0.49984011082065954, 1.0899309165440652, 0.42342418655857755, 1.0378043016704, 0.16320452981857203},
    {1.5247080071948267, 1.060234939588362, 0.29832817447453325, -0.8907245991131233, 0.6353108362486374, 0.8891578850004037, 0.9223018706584035, 1.2327175603152898, 0.4457384002243883, 0.25907264812101377, -0.7466068571087703, 0.2574963478241059, -0.749247637639373, 0.6850110756463885, 0.27511474349516735, 0.43977098777999035, 1.5359345684318157, 0.8072827825449989, 0.6519215518937734, 0.7327827800419418, 0.44229353982139397, 0.42220544061657206, 0.15475591428641464, 0.2770278060305118, 0.9197866655872949, -0.030621112174691063, 0.5425447263549452, -0.1958969435000183, 1.0206639929714947, -0.22981471178586238, 0.27066656029585395, 1.641505359136771},
    {-0.08919141000007903, 0.01801792321879212, 0.32158280692236807, -0.3068601826303612, 1.1291239783802074, -0.03804476293949216, 0.9517736331443504, 0.026155261370910645, 0.1178671278757448, 0.007144168766292544, -0.5730725867104809, 0.7161209767301512, 0.7729485764356894, 1.8973270302674148, 0.35973551487040395, 0.22457264109558517, -0.2228117804340702, 0.883160696248503, 0.5831017015934574, 0.037843729352662, 0.16236623955816942, -0.2066367455458972, 1.7566991345975684, 0.05635614415948761, 0.5996925556284268, 1.6332776909482285, 1.138557641653863, -0.6345161806274984, 0.5451925915751149, -0.8146982443280135, 1.8502145532185152, 1.6465081395888033},
    {1.1308314779254356, 1.7392329834709221, 0.9656115923139902, -0.9595871956782329, 0.8393990577494327, -0.2924100257731154, 0.7509125243900184, 0.5161714946416381, -0.28846745630408105, 0.2667495213628141, 0.6693930533465862, 1.1330035704253072, -0.5754150843777005, 0.9466010743188406, 0.9948437289677223, 0.12629784705674998, 1.4796639547893606, 0.6986293624043992, 0.2502899730367616, 0.1477087134938673, 0.47988423767357324, 0.10504190182327888, 0.5473212518182675, -0.45882647031985535, 1.5775182560895054, 0.4584493751442028, 1.3008896991692562, -0.043866258963706196, 1.6065246889947993, -0.38457979059392466, 1.9062402859041792, 1.7346903947169687},
    {1.3256237923377037, 0.7394394736753302, 0.2471004946792516, -0.5900285680075479, 1.049372860877925, -0.30910435835436495, 1.2038663387414197, 1.2865384425499444, 1.0346245558941267, 1.4095660435904385, -0.7776797923817914, 1.6462341987639995, -0.6284986271802072, 1.46583013514411, 0.26970800591262506, -1.2162029909405077, 1.386038454631659, 1.0368663329686272, 0.6470207736053851, 1.2579559176631916, -0.37007530270186845, 0.587173174986606, 1.2285603405500478, -0.48549346365920865, 0.6243793552554605, 1.5286152189790605, 0.6423574311134124, -0.9329678086436698, 1.4825269495753877, -0.2198145950541131, 1.5396430742822387, 1.5953928005572688},
    {1.249633374048134, 0.10762128139439057, 1.4101194918676372, -0.17446197937648136, 2.0027331176196252, -0.18022149377164925, -0.35607758157886094, 1.2290786288825153, 0.07836610403871024, 0.22923671797661335, 0.26704590313030996, 0.639408486260847, -0.3852456772336468, 1.7315413162558222, 1.538999059992292, -0.18242920121994793, 1.0601794665844373, -0.14964400799826758, -0.8797049961680633, 0.9147682816546923, 0.1403847518681224, -0.07086897816425425, 2.045051331631155, 0.18080017178032684, 1.511702153361091, 0.9360476828598491, -0.12446665162867612, 0.13368212019445636, 1.0282777590747485, -0.37800625820491474, 1.0744861693212076, 1.5671291678096186},
    {1.0688890424879791, 0.7558260790939516, 0.825110319517034, -0.8427495421368347, 1.7153456744771487, 0.6721564044991051, -0.43092920359007686, 0.6688632886903132, 0.29048110782507564, 0.5920155970507801, 0.6905240855038152, 0.1104977713078873, 0.020813183725086, 1.6972960843359057, 1.2067156493249267, -0.608083996720169, 0.09163503807153923, 0.19590088472124337, 0.02915697367939864, 0.5981346818397536, -0.14311924409583263, -0.9236349718712173, 1.1945056570270267, 0.312251847282568, 1.5801984212151738, 0.5914091796340042, 0.45953650440478083, 0.5656531753092007, -0.018456255265038243, 0.5385763674750165, 0.2811588693068845, 0.32096735690235595},
    {1.4710800872066103, 0.6291168565688849, 0.4805666189533288, -0.5258105196198526, 1.9262047596309357, -0.06551209586063873, 0.3010068583818131, 1.5538062598785045, -0.3211011991048611, 1.094330002446842, -0.25795346567041916, 0.6907276590253396, 0.658708844596969, 0.5330219620588257, 0.6296403944673847, -0.483265519969544, 0.6980087326078486, 0.3466689684445618, 0.3415427599346671, 0.8394979557024905, 0.7312274043707834, -0.5324106901142254, 0.1865463262440945, 0.5696335918525688, 1.3443375794795376, 0.03767806316290532, 0.86100088882067, -0.11625277051897812, 1.035941112740227, -0.1301062787221574, 0.6562499883715365, 0.9629019050366786},
    {-0.17722959766544139, 0.7774784606029274, 0.3715911774119398, -0.4160380164290585, 0.7403300582988532, 0.8847185277351072, 0.7862916677319597, 0.1209825471002407, 0.853898582025894, 0.705441564478373, -0.760645967511219, 0.3738514108384352, -0.9554734533463987, 1.4486749083061343, 1.5474329124175656, 0.2025764008716175, 0.016742095418841328, 0.8371954765009415, 0.0022698056691240584, 0.8277197914407265, 0.5506030889905172, -0.7947352409242137, 1.4372119087838076, -0.42250799427336594, 1.2046448337094082, 0.11340542395392776, -0.006457837347102481, -0.5450549086376881, 0.8603451176746476, 0.348973496331236, 1.9003931498380577, 0.3341559577956275},
    {1.0734383451527585, 1.6112270985547072, 1.492825773756471, -0.7221565701468378, 0.21563692090364367, 1.4875217864950274, -0.06834192479709164, 0.1036355899819595, 0.852859498629119, 1.4911971140412321, -0.14277173649678299, 1.3887924687076136, -0.042782722277674205, 0.5397971356333945, 1.9429044512045264, -0.15009307414930198, 1.543170707337752, 0.7836397206858617, 0.2831708622467349, 0.09438955301833911, 1.5488397142345742, -0.6577516146158161, 1.3147632812472074, 0.2718672142363578, 1.7719547608709565, 1.5638740450243025, 1.5120117423495294, -1.072211854925468, 0.14877810435534944, 0.5622247110017299, 1.4896298681233848, 1.2842152560504057},
    {1.5397593734543606, 1.7910795736148637, 0.3542028317912294, -0.36895224150602673, 0.22909765384505001, 1.0871329914904313, 1.2025097031928011, 0.6109150776223964, -0.41816250036406977, 0.4814908202906179, -0.7241245605181056, 0.048748372423992874, -0.7567706819058339, 1.9730908336290562, 0.2540873325290939, -0.23524275939653985, 0.5694819370062707, 0.17090150947115654, -0.9191522153790832, 0.3037959245471131, 1.508013037984181, 0.2932633069591367, 0.47547916197424506, -0.007025144649159855, 1.929296384255949, 0.8877297657998761, 0.6426649230830441, -0.8664363516420999, 1.7098219681460365, -0.5831436133736094, 0.03083906827989306, 1.553228920948364},
    {1.2873726084853332, 1.3139845861890502, 1.8093463194823403, -0.9681834520123233, 0.7249719876861273, 0.5161975293084929, -0.38535894905865914, 0.5424057236671139, 0.9490873620923989, 1.0109795817504295, -0.07913372334447678, 1.3017528401575365, -0.24312538350911791, 0.17437728833154276, 1.378299795042933, -0.39454213568187424, -0.3284242357915263, 0.6979105528231213, -0.0131870559023252, 0.20160781827275293, 1.2884613250151473, -0.9049512636899927, 0.13828958854430087, 0.3932923608812243, 1.2965940165953755, 2.020163604494904, 0.6628059508119223, -0.7940863341811005, 0.6670400843365041, -0.3586641230021979, 1.2335787974966643, 0.4364854257900966},
    {-0.26932883709442257, -0.03866362196350836, 1.6286903208807932, 0.7744827287087618, 0.8981141081003026, 1.190141110545893, -0.44510684779270965, 0.8473202273245439, 0.5174181919993361, 0.4075515610745265, 0.7171735019193795, 0.8681042732158694, 0.3975682256596135, 0.47725732657067843, 1.3643424680609382, 0.6335667488496904, 0.524750240619886, 1.569551974012106, 0.1245491868137183, 1.0223924502586008, -0.17932598297211969, -0.9241969149929443, 1.3842806387584288, -0.5015260108613581, 0.7980259686240871, 0.025067315923550215, 0.5189049680973946, 0.43479427365361173, 0.1979179170006358, -0.0639389704934798, 1.515292978379134, 1.5092074655076004},
    {0.6495598843624173, 0.5313071258902218, 0.9573282799411861, -0.690788073962767, 0.9847358917385622, 0.0243374093362476, -0.009886747315732417, 1.7582404066596984, -0.3658486344581534, 0.767330633850829, -0.9765777350236425, 0.6279153955664178, -0.3586514149142077, 1.4881137969905514, 0.6042218320148868, 0.6307308863159314, 0.6647869544228168, 0.4870315340462229, -0.11788522253814233, 0.8979009859793913, 0.5983750388289139, 0.49994247673123376, 1.1033512171985427, -0.19665943120749008, 0.7759409404167888, 0.9182754294559752, 0.5261810014368977, 0.37276740841915723, 1.6607796328914524, -0.10790227532507313, 0.07160116807919525, 0.4946821124835119},
    {0.4148886884613531, 0.6126350397774618, 1.7993679842208603, -0.052363047626842456, 1.2993859568881017, 0.3866589115705072, 0.5254511724831176, 1.176051936791896, 1.3187041690134693, 1.4901064066583816, -1.0154288724617457, 1.4157686398943674, -0.8128206763824295, 0.5426671802705971, 1.864811645816933, -0.006188206369179728, 0.7451865362610182, 1.5048475967240125, 0.48699379942318616, 1.3196914305989542, 1.0970772984390056, 0.17686467492680014, 1.3020244362806808, 0.3426217156510043, 1.5874315473901695, 2.037827459246402, 0.9917556652052295, -0.9353847937188726, 0.8536766153978017, -0.2567058862881814, 1.2859841253967195, 0.5662068293810257},
    {1.2840564581825806, 0.24625773870108564, 1.5680164873418525, 0.6153649433980134, 1.2882432003333208, -0.11178551633538975, -0.1319348087121489, 1.724905576304928, 0.2670031069420127, 1.0574962783388346, -0.9072920971185234, 1.8119170842439998, -0.4729406021321737, 0.671751065078693, 1.3068781404647907, -0.14720281432447377, -0.02456401198826499, 1.37552681161323, -0.4628481830198171, 1.6023366942925557, 0.19683081585162218, 0.06921855249924164, 1.9485318793505935, 0.8466451739027719, 1.9657162178806578, 1.5186835173771798, 1.2734667678959646, 0.4184350212107371, 1.496775627242101, -0.5158921387150117, 0.9075424144569515, 1.1294110427394097},
    {0.2884067739653881, 1.300454592872932, 1.0872570959123877, 0.3085285903814721, -0.004900413726725229, 1.1745314471767252, 0.17538382856445447, 0.1374586316466037, -0.2765420410847658, 0.35657746411505964, 0.4326981106418741, 0.44173238017598726, -0.8390875095459084, 0.4613364841940304, 0.515867695002186, -0.557339917593562, 1.488667502689914, -0.16870440663031772, 0.5871425196141005, 1.7541455646127728, -0.23354678074859644, -0.7019306724507367, 0.3816773951252745, -0.6372125913175872, 0.5449219989678571, 0.03764680630358297, 1.7639403000893181, 0.02114349318439329, 0.24670157135603982, -0.8017875365632077, 0.6252791683434548, 1.7757212113552647},
    {-0.14652279547328756, 0.6429343050140628, 1.1793808384626918, -0.5241623405150372, 1.7556708212727845, 0.15919247527411268, -0.386838622837497, 1.4172693844964928, -0.03411443352336861, 1.3790589978601253, 0.7300674050433136, 0.4885561235999461, -0.38842013507458784, 1.9875864534171823, 1.8979104174909154, -0.9139145642113427, 0.588925204111852, 1.1167717823348329, -0.6697643284652375, 0.9118400215124957, 0.8532882529977555, -0.872140587068313, 1.2960939589797564, 0.27804222968958886, 1.502011668271421, 1.0115854912371571, 0.9871109031195371, 0.709710094586699, 0.8107608882714006, -0.26845545698754497, 0.461070372860218, 1.9783467754223236},
    {1.0187808820687978, 0.9039437496481432, 2.1182716559862316, 0.33384793412544816, 1.4999919867378968, 0.7885589105334735, 0.5115361897363218, 0.8215461589786497, 0.37712531786652304, 1.119121867203736, 0.19062612804766427, 0.4372289329875222, -0.022634391232453942, 1.2614412230724568, 0.10317440393583406, -0.7196830131019797, -0.32463789125539066, 0.24393729316292126, -0.9307039211076632, 1.348915518376469, 0.5544835804245027, 0.31840841288587296, 1.197082693701522, 0.7402885703352601, 1.6237426180942676, 1.8752114644593203, -0.10634917954190472, -0.37393311338453405, 1.6498048296121999, 0.6278415642770747, 1.9620460942769669, 2.0633392151564127},
    {0.5554186338915325, 0.6489704915740092, 1.964304394723127, 0.6563957007188693, 0.34591606232296623, -0.22280328902350643, -0.49468047771392937, 0.8924552087746057, 0.48618883304011845, 1.4476443249249569, -0.0519195104833525, 1.7752845038427332, -0.821375355038961, 0.8774688598025975, 1.1159808427299984, -0.663726276230664, 1.2496037797963049, -0.013771928193249657, -0.299571858834193, 0.7925428676387778, 0.9000910123396388, -0.7720520631504558, 0.22256534712217388, -0.7287844965346247, 0.5430762463176454, 1.865996046021868, 0.6018951740658686, -0.08557687850108839, 0.9226389291605276, -0.13879622583118076, 1.0574433654111621, 0.968533522797895},
    {1.0512777701514622, 0.572831684304867, 1.2157704827138518, -1.017344319574351, 1.644866067322777, 0.09901689764561236, -0.4069829188117772, 0.06626229050753105, 0.1315236392353664, 1.417907024704022, -0.23416565869223757, 1.069368766312023, -0.5971367091640992, 0.6005990820134387, 0.47814972361355257, 0.19712407922390654, -0.04944940815069993, 0.31954571945323335, 0.17373370489188228, 0.8444514050375165, 1.1624530775834514, 0.6167146415151545, 0.41535506383628235, 0.22044327770477948, 1.8558660351423164, 1.6725331260465026, 0.649372068067264, -0.8201598660925982, 1.1994819490743778, 0.024483033290815727, 1.4866413861315764, 0.30031760521776435},
    {-0.2164780232212593, 0.46882663265876645, 1.1632566307053338, -0.7145782653708727, 1.699337647255995, 0.05401641252352517, -0.3469999368051114, 0.05237296254176047, -0.4847619140313694, 0.11867565622715315, 0.36878742325902847, 1.7083774158573501, -0.5947756375769263, 0.6725686080338777, 0.8025692086715681, 0.3962974217325935, 1.2898701529891923, 0.16248658078086306, -0.41590734658869366, 0.8136204797423743, 0.08221906389510862, 0.4712141555074323, 1.3640284738607895, -0.6117483745090082, 0.3851237002903663, 1.7587029247877763, -0.03379745968114367, 0.033074197347615526, 1.0618562599004522, -0.6043070347436791, 0.7409007381266154, 0.825264919622465},
    {0.026393044077608455, 1.1767496113925666, 1.0804143925580498, -0.4164557231814451, 0.989974593584065, 1.1137441199226754, 1.1511838688169882, 1.3126024206947553, 1.2553925702424569, 1.6024590585986338, -0.23258384761449769, 1.4347549862696805, 0.6900990914590385, 0.07717338823492273, 1.0636850930889745, 0.5856460059203145, 0.5586058811002919, 0.37793056163983624, 0.6968053999809419, 0.309692800948228, 1.44392218377295, -0.3960039821236785, 0.1168000223526205, -0.7538460718298463, 1.9416331727055098, 1.079511152769741, 1.137126920837992, 0.4678252580687095, 1.022605382126547, -0.08976222372598161, 0.9292935613674571, 0.5395119319575246},
    {0.5018443277336877, 0.09751288393254672, 1.433845314360933, 0.7434558404261824, 0.47498163723708253, -0.09828692428005147, 0.06999755238463395, 1.2596875654531352, 1.0301775132360418, 0.5296309589913618, -0.5315232964119324, 0.8257839540012277, -0.06398706884789804, 1.1027190517357055, 1.3743240509539278, -0.5744387841990668, 1.5461533590089411, 0.30957109595017046, 0.5500197696814363, 0.9589875444042517, -0.2070527468813893, -0.3014773813694786, 1.904056799045909, 0.7333060720025756, 0.6541722961953023, 0.7991139558846738, 1.0956446683370642, 0.26720276635843393, 0.9736323333023433, -0.9306231089745012, 1.6294262891841809, 1.1554952724329528},
    {-0.1356993607006781, 0.7837972580093397, 0.9472586983263273, -0.6477916217080842, 0.6283145554028852, 0.398098886748823, 1.3270395962475734, 1.6544837718891443, 0.35231037930171294, 1.6838837404567646, -0.37801926593144974, 1.421227020593856, -0.06850356142823433, 1.5635570098236702, 0.3099377189079444, -0.0671210165741464, 0.7327811248025489, 0.03247157415316487, -0.561678090672601, 0.9708116689641101, 1.1658489676674066, 0.2865957149378054, 0.937432657869126, 0.44615804663900377, 0.14635443055691505, 0.8495432245509603, 0.30968109325438914, 0.0031469968699129602, 1.6817951966387856, 0.34309369780480836, 0.5319394074172155, 0.11390784162277622},
    {-0.08135289421965597, 0.1382184024539611, 1.335028660980904, 0.8260262814055054, 1.9477505378723736, 0.6492531834603913, 0.6599696046077126, 1.381649503466091, 0.4071572325693724, 1.323193533263111, -1.0475335936924222, 0.7682860588630317, -0.6677497271477142, 0.9041199581228075, 0.7533170677390244, 0.5529279324156297, 0.49173196482870796, -0.20450216161256615, -0.7123512622405859, 0.09259103273651842, -0.1911217396574782, 0.5489990575992857, 0.8538872073465499, 0.571974670843629, 0.4158200175341006, 1.4093500545206188, 1.768480833566593, 0.4309128661952286, 1.0331144808354367, -0.8971209510518275, 1.4890462825050281, 0.1599983446750449},
    {0.8530595867126292, 1.7745448566439692, 1.871642168042403, -0.25890383843886705, 1.600388378334026, 1.022803938497178, -0.4684689123168898, 1.1429645124659122, 1.2764060635465078, 0.633746917725693, 0.38168894478085347, 0.9352357792361965, -0.6763416844519669, 0.7533208749694609, 0.1225980991674924, -0.3944110076751015, -0.46571824275015605, 0.6738387885519012, 0.1726559410745544, 1.2086830855374318, 0.025548092335796732, -0.31927224832365697, 1.219646448683517, 0.3851413055004619, 0.5255228200363712, 1.8480405894837704, 0.05235603669792644, 0.44519773548637315, 0.1057306446645681, -0.6331991907754647, 1.3813817464304439, 0.08625686878483912},
    {1.1592599281321008, 0.22430277816043234, 1.8930693587417196, -0.7452125929360106, 0.4389505659654756, 0.718556055686481, 0.7411418145318984, 1.8523493559420807, 0.22763090310820247, 1.5200305682330117, -0.2706892662732652, 1.0203623407361342, -0.3724064153257914, 1.6088428405455713, 1.0663459346823718, 0.39776701811497345, 0.3243221277848812, 1.3129115774066509, -0.942562054397315, 0.03331372527472009, 1.4230582351531955, 0.4151890869739262, 0.4551911280139535, -0.7370568462310477, 0.8242610200929038, 0.2275555022135614, 1.2608550677800803, 0.43447025603419087, -0.015854165935594768, 0.5287683000229939, 1.8917765703530403, 1.902623427091177},
    {0.20534264168559044, 1.3427841366341147, 1.8082605604013078, -0.6330982285746568, 1.382696680756874, 0.22987260416424968, 0.6616468732525731, 1.3841009098597474, -0.0038827248482343757, 1.2105407899947682, 0.06973650420930945, 0.7811836564568445, 0.34058544520881906, 0.8160409996783068, 1.5933385305950831, -0.5720512278515649, 1.3699593864184028, 0.5146399128429572, 0.7340176599292202, 0.4167556784577532, 1.333029158536504, 0.38366973566316803, 0.7611642930447342, -0.39495320797890154, 1.2519693206992366, 1.9145966244669437, 1.3030152403281952, -0.5325912867436378, 0.670027561061474, 0.6483676490307607, 0.5725143012112991, 0.44533932255589825},
    {0.10479082468832744, 0.305427653985855, 0.6851673259469325, -0.8274071735027413, 1.1589195337902962, 0.7950985918580431, 0.6212940651748105, 0.9410539376843009, 0.3141766595533484, 0.36569275127128925, -0.4530238718960358, 1.3800489333187564, -0.7634970267615714, 1.119146097536764, 0.21072734725058243, 0.43641595307337105, -0.32238714628224585, 1.7655488275156017, -0.33231449029718435, 1.0267081925149553, 0.04862421507456755, 0.601902088090642, 2.012577651200936, -0.6110413298499972, 1.9252617139402906, 0.8918994486081727, 1.1402581893857868, -0.3637415348674876, 0.8243940448351572, 0.4570303893261107, 1.3281865679687939, 1.2853895390637042},
    {0.7116899179591937, 0.7851449191198544, 1.5865670619223282, 0.2021422763950094, 1.7019613368455095, 0.8122451775004645, 1.0248519788418513, 1.0570500447418796, -0.16964828401217985, 1.2761838299178516, -1.0600647560693373, 1.582730805523602, 0.43726725943935363, 0.28966976716016846, 0.9646191035492717, -0.29307154813534536, 0.7186397906902054, -0.07340216939758899, -0.8877015890690528, 0.309683223033598, 1.1934684284593042, -1.086528948785153, 0.721304129144172, 1.0456755284875678, 0.455322006979709, 1.646369840020939, 0.6222449863427245, -0.6940084436234357, 1.5892684568031001, 0.45218753490649016, 0.35859374097984326, 1.6338593308385867},
    {1.6280508301346222, 1.0523839570538422, 1.0016643029893244, 0.7158020832817875, 0.3125971812164948, 0.0008339871409312327, 0.8825029429602533, 1.3232501504822263, -0.4839858603577035, 1.253559155978826, 0.5100400608357308, 0.19495879474209094, 0.012823768910707379, 0.5982693812982038, 1.083343796932073, -0.7976970070512285, 1.0689185380864206, 1.4212980015949064, 0.6021261723787796, 1.5025564323943414, 0.05660730749383413, -0.1718871445756294, 1.151890668221234, 0.09879974546272424, 1.9674334995760643, 0.8521492042629453, 1.7365309876262403, -0.3461307291654773, 1.1644249072807893, 0.47027794283907526, 1.3550391457397626, 0.829828136345726},
    {0.9320724298225475, -0.03166607559224965, 1.4330794926018564, 0.5644906344671587, 1.6430863011015404, 1.3564241237487689, 0.5687118349792653, 0.2100794261238076, 0.1630699273456278, 0.18049768772085065, 0.21891204651576027, -0.018820984385907992, 0.5711725734941892, 0.4498967810172405, 0.1762331392010252, -1.0963564218473272, 0.13704075168447716, 0.19229226317171053, 0.6978390049005113, 0.3660821794866099, 1.1030895718381357, -0.5323572620742657, 0.2689903070983703, 0.9983363510545329, 0.16887892197978133, 0.25033645776962415, 0.7910648723294076, 0.06464956945399024, 1.54544476014949, -0.7098949491948917, 1.0217995987794941, 1.7769888299110272},
    {0.2688062326397099, 1.2817073315189236, 1.8421653031415968, -0.8428336103815128, 0.6435669000393077, 0.08912760511809321, 0.007618083649983817, 0.8467769436000678, 1.122809712476581, 1.1303965859350107, -0.23427663326494208, 1.568131775966075, -0.13518319037945664, 1.9404830062497924, 1.2130972192597882, -0.6442662569807058, 0.9071844027638151, 0.02942353181907232, -0.40057544414008284, 0.6431957331689409, 0.24029166360213794, 0.6707715587400715, 1.1561459811407402, 0.34335918202376703, 2.062986449531133, 1.798235952942407, 1.5293482091062651, -0.7342469572202024, 1.6457427952567623, 0.5487650726823049, 0.5077119038788184, 0.47235291458060724},
    {1.4825087995757507, 1.5578266436367854, 0.8966757854449884, -0.47669540845530994, 1.2224245447611715, -0.19759114229302718, -0.4618897006490941, 1.4970078666998499, 1.3007835494479603, 1.4711000645301502, -0.6116608695648499, 0.29591007653214, 0.0077079791497595305, 0.4718053498353333, 0.49021633883252486, 0.1659093731972827, 0.1589608139461, 1.7242932728524343, -0.7488935760319885, 0.21277375452827466, 1.4459500105147054, -0.0328570510868483, 1.6932451223128824, -0.7504512480838593, 1.9504793168146157, 0.4936756584870589, 0.45507409557880374, -1.0284290559667888, 0.2097324236031267, 0.4397898425361853, 0.5319163868182201, 1.662838481141156},
    {0.37847989219952716, 0.1557933119627741, 0.18492087354402797, 0.6378533045148236, 0.3882402323408708, 0.631911274213747, 1.105699790025276, 1.2266544158953223, 1.2509094976406077, 1.322953836411485, -0.7658737565169811, 0.838380947515599, -0.47950506855686514, 0.37965772764369815, 0.377377525573788, 0.3645187011895393, 0.1707113535412608, 1.5075219843177725, -1.0134222055902178, 0.41092958203795527, 0.30160385016805347, -0.6578710255731686, 1.550044730528193, 0.9516654874548698, 0.3723522132015879, 1.964250876689159, 1.547542107947886, -0.20707583676629873, 1.4999208802642263, 0.27609987250755297, 1.2534862899223087, 0.7068263884612556},
    {0.15063333282402816, 0.4660548100331351, 0.4003193416874741, -0.2269769652257608, 1.1013267605484145, 0.19621352768335032, 0.9462182001779068, 0.7844085778802767, 0.6941538758147009, 1.1961063231858224, -1.1168862642622364, 1.5184548586837556, -0.4883887139777549, 0.312994964783068, 0.9781026460626975, 0.30948707693077515, -0.3820031867138522, 0.26082416038528705, 0.14130986049648922, 1.893824976513877, 0.8312970278746263, -0.669900314960206, 0.17963352259637647, 0.22099962192048142, 0.4193214223375795, 1.0163561316572525, 1.4130440041669874, 0.21377168659841747, 1.2198147302911049, -0.16397238877647577, 1.8223240455726208, 1.4096690064744652},
    {0.5521150086653273, 0.038464653527906734, 0.17148816648861898, 0.46470866058381527, 0.5016796290201698, 0.673051865044316, 0.5317121638362323, 1.4600529366704884, 1.0472135714858164, 1.2584203212321277, -0.5807573038169496, 0.14704438132627962, 0.22583645718085216, 0.23015871958236284, 1.4143954246303416, 0.28043141295825214, 0.27061981694816256, 0.6452545422848708, -0.46563905422811314, 1.5992635100878967, 0.7552142780182779, -0.3682142672965449, 1.434425894929472, 0.10909101969774591, 0.8304736948640603, 0.8410454572180388, 1.0262857650980548, -0.34912769317428083, 1.4442197591597414, -0.9079266396769856, 1.09708346831831, 1.9640242412136852},
    {0.7057464544356733, 1.79738315391676, 1.4845265005967307, 0.18059555994480744, 1.2006764787209852, 0.3344163197413373, 1.1146529216492715, 0.5479729057113973, 1.0637553939458038, 0.8601232874209394, -0.9265498314851263, 0.22532532224294538, 0.787585832989986, 1.6672276865487925, 1.7345240532008575, 0.5499242235920762, 0.1481382484945514, -0.15857894288265523, -0.47045227562634884, 0.3022386391116573, 0.9172427321677646, -0.26058548186999336, 0.2089899326831226, -0.8536076590412323, 1.3083373154931977, 1.876033498215687, 0.37576120240042854, 0.4969855948247283, 0.22554957672892392, -0.7521932250148946, 1.4008853759234812, 1.0785750931791538}
};

static const float b2[32] = {0.9370653517137535, 1.1496198101030042, 1.332997369680517, -0.08590691459045335, 1.2602618386557394, 0.7075237654976873, 0.5236345362527729, 1.1267580538052688, 0.5593719667900564, 1.132338013820293, -0.2675820150136207, 1.0221992911716307, -0.12478686161633792, 1.356113171479809, 1.1260584558004847, -0.43450982811430217, 0.841012342867604, 0.9650151601290715, -0.2510876232753398, 1.121394440760802, 0.7356503446459586, -0.25990954862388005, 1.327569793733051, 0.10698530854563645, 1.345569269203479, 1.3425739013375226, 1.0623543175315728, -0.24864169033247063, 1.0461967574097828, -0.14972789094936384, 1.2304275007404095, 1.3025362906434963};

static const float w3[32][16] = {
    {1.745276717873521, 0.8795428391341877, 1.4377469587946792, 0.9759478490188429, -0.7935564832003179, 1.3800286272769584, 1.437592678499144, -0.7965857530133176, 1.126764150733928, 0.19331656254928284, -1.044079653150182, 0.15627820414956042, -0.40670661639643135, -0.7601942311940534, 1.1696832287771015, -0.09471249044647385},
    {0.8241269583898484, -0.3968792961435954, 1.395469632464058, 1.9385785006752119, -0.482772795449315, 1.5207364363624343, 1.7845369996765303, -0.06759591305018206, 1.5238479393050528, 0.775447920913578, 0.8609442775385713, 1.8645373115361112, -0.9388117003165782, -0.149844472892421, 0.6406400542082806, 0.25479641484531695},
    {1.206058534433637, 0.830356967756417, 1.4992784190596156, 2.2183135423494496, 0.2801929701873718, 2.13209939610137, 1.7626116950435962, -0.9179314691130985, 0.3732572418756337, -0.25311547131272366, 0.6460386608203039, 1.9283739839820928, 0.3007833830906027, -0.8501380346529048, 1.2011411904465914, -0.7930779537172392},
    {-0.27016016575152857, 0.962016467338471, 0.70452104528888, -0.8563458279915247, -0.8835023333424824, -0.8363397077384667, 0.8477028626112494, 0.5174111178575873, -0.7264010438432047, 0.5152520671723392, -0.16796117075136474, 0.6310503901188464, -0.08216804239127032, 0.07279334560423596, -0.47359883934751995, 0.24049213031890213},
    {1.8727237304604225, 0.3144190162432817, 1.0065077124400237, 2.1852802877290625, -0.9328508661545217, 1.1210252939814118, 1.1465748581080484, -0.06451433287146056, 1.1651032394265088, 0.43768549542512963, 0.7291013874027412, 1.6353636608700999, 0.32489467994599885, -0.2773271738046458, 1.6252415781317113, -0.4251045372199355},
    {1.1230963121944872, -0.3109006388670429, 0.28713898730465887, 1.7522783701208906, -0.7387475336897406, 0.37043709759935695, 0.30074002135106276, 0.10307271587137948, 1.3818394282393043, -0.8464336986593631, 0.4855770229239567, 0.47222694730775283, 0.26363952559193893, -0.5325234636479901, 0.764415140214816, -0.041328279763304665},
    {0.5840363807705082, 0.4163216501052057, 0.7378959156571407, 0.6635701742637246, -0.9435177765342155, 0.9354699893777145, 0.9994590305682448, -0.8207967496552581, 1.5709563495356382, 0.3052207701170458, 0.44585423193157164, 0.1785308266205704, -0.7069011514210845, -0.6035634388033718, -0.1966563290509796, -0.8512627405818923},
    {1.5341975137645796, -0.5065909357958788, 1.9550490281872008, 1.7601699814159093, 0.6997448160675919, 1.6066831084442956, 0.710713909533841, 0.6843391979797139, 1.2584148375344766, -0.8464898279035125, -0.08603374638407413, 1.0659380929272244, 0.5946254184324787, 0.8587363092757608, 1.4770811399948238, 0.737651820287967},
    {0.08477125796642296, -0.9467296143056729, 0.5283367317289678, 0.5286298456928827, 0.32105321343378584, 1.553579807328128, 1.0902635977345077, 0.10174330211395766, 1.2429458510291957, 0.643125036419182, -0.3494212872277913, 0.19382349261089674, 0.13550006618492969, -0.2108000056096644, 1.0628715068116084, 0.7406578641047917},
    {2.114361893503376, -0.7644755542654316, 1.5285736761417283, 0.8435503224253857, 0.6474200292303097, 1.2860371749504567, 0.18303634949883735, -0.911057336810676, 0.7443476074467256, 0.3673129356366397, 0.5666524122289126, 1.9681540162582796, -0.3939608517719064, -0.4176730302698817, 0.5792807617038227, -0.14440563867013329},
    {-0.7478365577438295, -0.6093735571805072, -0.5753307957312062, -0.6773592104866696, -1.075818131460919, 0.745619559585784, -0.2903054429291009, 0.13540772727779812, 0.32418730768953713, 0.17542905832551803, 0.38205308674037025, -0.23331948212633985, -0.970978957566029, -0.06023158242701663, -0.7317630079380315, -0.20818470211559384},
    {2.0583880563762578, -0.32372311708215257, 0.37303396485663615, 1.9927834806952, -0.14483649060047898, 1.158402528480012, 0.2949358161703004, 0.5690328045537351, 0.8221054134058333, 0.6143384722739746, 0.03618061440245981, 1.9039598484819709, 0.4907016314188119, -0.867153832099316, 1.4494675863684505, 0.48861744053615114},
    {-0.24396664169594118, 0.3723473760516565, -0.4187640185201349, 1.0683256828628271, -1.0056863812588361, -0.2934498928711887, 0.08829233369080641, 0.019302872515922716, -0.0896184665716823, 0.6942121552949594, -0.4658543566355997, 0.07932266123951123, -0.8752475349057378, -0.6329729077867713, -0.6724380219908961, 0.21127004490443455},
    {0.5700974718660131, -0.8919186281144907, 1.7178074285407252, 1.9707985758765196, -0.21678353755362226, 1.0661851577197234, 1.4372676638216153, -0.9200736969731372, 0.5716436528998942, -0.4620534282212088, -0.7044459328111152, 1.804562466614149, -1.0160967402330148, -0.9706482364451202, 1.645830538250059, -0.9567941437549864},
    {2.1450271738922737, -0.6700024177708327, 2.0643006915507445, 1.9845732856898526, -0.5790616975097204, 0.8096933286253907, 1.961051207185753, 0.3371899131844669, 0.8195448838591117, -0.8140790904550051, 0.18314962931744927, 1.4922093741954237, 0.7936735045671834, -0.1521730225762784, 1.2500717940581223, 0.8361947131892277},
    {-0.0849152617192819, 0.8751416581919922, 0.5162856614807901, -0.5610616833502402, -0.6047121624044391, 0.17675834967969534, -0.4219599818446282, 0.0024255431895229096, 0.18972254115122347, 0.6332707942141376, -0.6361094155436576, -0.6872435337304541, -1.053007718855334, 0.6050372438717889, -0.7633110330743091, -0.34411553214582724},
    {0.943761598712205, 0.9725504810885957, 1.7601324489837524, 0.4479087884768136, -0.5254456348703045, -0.08116145299246631, 1.7700956248988398, 0.1756808808463399, 1.073940925764278, -0.7063917939001821, 0.9419314185962022, 1.331069790450662, -0.9165499729451763, 0.14051633076251857, 1.4906016738584549, 0.4211396698058565},
    {1.2662470289115313, 0.25967232429543824, 1.671885344385877, 1.8976657166127693, -0.23671251353667788, 0.254632744560602, 1.9934007838758743, 0.5136279921748618, 0.26532852231830206, -0.8443471510823564, -0.6004105431204768, 1.6333681081187352, 0.698635734724804, 0.07782330136404741, 0.741193499220066, 0.7119956327021232},
    {0.7873606450397851, -0.8769342807357636, 0.035232183681638746, -0.41057186827333736, -0.482355202780916, -0.28452045864181885, -0.10466800303502896, -0.0737763437925444, -0.5964765060820753, -0.09951651911590152, 0.13351212492508308, -0.4540605356893898, 0.34954458100322094, -0.7754111347884277, 0.6277216081079792, 0.7663651199859056},
    {0.7289031052050827, 0.24092992604538685, 0.8639340264175113, 1.6768272731566571, -0.2811203828576962, 1.0008948515608507, 1.5670154020044045, -0.05356519102176934, 1.360587348356639, -0.5635389492635319, -0.9804671419413526, 1.652464418299101, 0.5773855968790055, -0.718141693825919, 0.2578049283348057, -0.44145254992790345},
    {1.6827433458159613, 0.3420188212873322, 0.3571077891795786, 1.4699973256023962, 0.3753296443388498, -0.007785967143189102, 1.8909605288669395, -0.791160656431286, 0.8313937967023853, 0.27743993505879994, -0.2132339201022825, 1.3072930260141657, 0.10284806210652263, -0.5670446167285503, 0.651155532391143, 0.616293201669226},
    {-0.7479082256886186, -0.8991192158345628, -0.4244420203287529, 0.6168445630076146, 0.674989115260628, -0.6649014346221455, -0.8093613926059657, 0.355747491056421, 0.5920666755989203, 0.29216946960937573, -0.508165517596529, -0.8859116899506907, 0.817326728844835, 0.08008009646476541, 0.07656042020678246, -0.3141152203844157},
    {2.089029132435711, -0.3488979096611887, 1.7628104452686286, 1.820416400000061, 0.0740885875499322, 1.6486032631893441, 1.1121286024675925, 0.5768040622341086, 1.7482147397033567, -0.7512965278131736, -0.2800968365432901, 1.2903008660558015, -0.12363810035522275, 0.0024648896548054317, 1.7442954087032112, -0.6316217575050138},
    {0.42359978423153716, 0.6736627125382466, 1.3049620075585013, -0.017131832560018823, 0.12550464871777406, -0.13321773162566475, -0.2521425589700445, 0.8126998994469392, 0.06890262519777338, -0.01315825508363126, 0.22388701390916482, 1.3553775179189187, 0.7425557719399584, 0.0035558049087522103, 1.0749509023927308, -0.032566518400974485},
    {1.9828094680311232, -0.5988623796249343, 1.7101413863145787, 2.152553536961069, -0.4065896934471474, 1.370339390434277, 1.1844606401304256, 0.39581016934650237, 1.9610341100015711, -0.5248500251413432, -0.7376882169329674, 2.0137981978614135, -0.022469984674617853, -0.8122386209024837, 1.3419156115489606, 0.3093835707547864},
    {1.5879389050281953, -0.484652261912365, 1.4165704769695966, 1.5935106891449375, 0.2805485989085579, 1.385276421755214, 1.6597842072618973, 0.008289487078560902, 1.9210979095625151, -1.0597625324719884, -0.4805170525051386, 1.9158660185220533, -0.7418836502797832, 0.3424640852564207, 0.3955036794638809, -0.9423426415976469},
    {1.3786988121426578, -0.664197805208996, 0.7680374093500928, 2.1446218696653436, 0.5747626776678899, 1.7192117020133066, 1.2580892834131008, -0.41031362642039515, 0.5782061830540122, -0.46851081967006986, 0.43108976983400404, 0.8189450635951542, 0.5550001455855846, -0.0243980068591883, 0.876865575864452, -0.7964703791125664},
    {-0.321361400311617, -0.5020248702427312, -0.5954661101625088, -0.029634736304653034, 0.05967479816156158, 0.10879279748455561, -0.07292963235702164, -0.6068891584343423, -0.4544759101947694, -0.8707138527185135, -0.9929285443740287, 0.7476966875999492, 0.766314591191076, 0.2749404765814249, -0.379828557002881, 0.43245804106894364},
    {1.6338473064811088, -0.3009920782982123, 1.5715550985554443, 1.5274578020141263, 0.13419229568119945, 0.8578731913622197, 1.7892773963732658, -0.28357235461497665, 0.6243637507427364, 0.058089183607748285, -0.8179147153200932, 0.5188106834538514, 0.04489506649825244, -0.48123944080891484, 1.5134970651853994, 0.05438170239318819},
    {-0.5986238207083511, 0.309005282227008, 0.2768644605354598, 0.32466478616361116, -0.16584196466641749, -0.11830401817392246, -0.6264844763911701, -0.6812667556712927, -0.2336780658247719, -0.9896668316048942, 0.6592169931807521, 0.9578369143002575, -0.11073527407708922, 0.8184439580058156, -0.4731795131767733, 0.6021766738544451},
    {0.7987538949922232, -0.1715814541845388, 1.7514612286514233, 2.254017061679537, -0.6398260338689158, 1.5341126984014604, 1.5794424436197536, 0.3394862795497338, 1.7272214470812681, 0.3115471599662779, 0.06432778605476032, 1.7405439206106366, -0.4664291273596222, -0.624540212175774, 1.1098990357250507, 0.3062064248144765},
    {1.578598351056166, -0.9652660238132861, 0.3172242935609835, 2.0246870526873137, 0.09516023941013728, 2.004723905762383, 1.1356045531041479, -0.3639445828567216, 0.7522280835395425, -0.10958797542279627, -0.05147317387710874, 1.3353218414877832, -0.3975611762201448, -0.21103563485189514, 1.873723339298889, -0.9326269621126175}
};

static const float b3[16] = {0.8881645855145257, -0.09266409322811907, 0.8769766593065095, 0.9130591305721661, -0.1833659048126083, 0.7025638525397518, 0.6196502125242975, -0.18127472453475504, 0.8424991286501646, -0.14236844225001113, -0.17545815410527568, 0.8330492434305107, -0.13908988154876517, -0.11942429925398641, 0.62738179443365, -0.10291639962221956};

static const float w4[16][12] = {
    {-1.5338825792699005, -1.508981003193696, -0.7657942135606862, -0.4429264146469853, -0.7289944703055352, -1.2324438685275019, -1.7828065575922176, -0.712660836319981, -0.5983119160853314, -1.0556485680837446, -1.3830972789180327, -1.5173528987485276},
    {-0.13668186517188463, 0.5134568121214373, -0.7206514406577688, -0.937187407872348, 0.49862843703850857, -1.0132330143308965, 0.26692329026135553, 0.3139168965973437, 0.7487572786817476, -0.40595002429991944, 0.9074457795729515, -0.12012691651546821},
    {-0.3414470078995742, -1.1972877993951145, -0.9565922871107013, -1.4257415078305695, -0.07335960822278474, -0.9755286438272845, -0.3274075662671152, -1.407547556128529, -1.217598766810002, -1.3615778409322323, -1.0885623253643326, -1.8356429507065324},
    {-0.7181790591772239, -0.48976139967789606, -1.4855797224600575, -1.2949482162735593, -1.9854276523368668, -1.2810577392879683, -1.1406758678596127, -0.4756897881499178, -1.971346480143579, -1.038090817754363, -1.5604408479908332, -0.8075257091383052},
    {0.08705532215836548, 0.8522242250120958, -0.2862365556855945, -0.40334148192433616, -0.22093307865268755, 0.1255836006484361, -0.4796563492513504, 0.48831131300993175, 0.2041584414428307, 0.2151658661515985, 0.8958881076178716, 0.8276040925623493},
    {-1.9325487407355197, -1.5207679585234979, -0.4114066824799181, -0.9563267636456936, -2.0158843652713454, -1.5656044099206314, -1.057878215981463, -1.879734310910868, -0.5052601137284539, -1.145084427304558, -0.44877579102982684, -0.10099274725942367},
    {-1.7744098150508698, -1.4287971769209258, -1.3211376865746034, -0.6326751580282737, -1.2024069015705936, 0.023245558046022328, -0.41257403988322433, -1.0376839547887857, -0.4747761622286831, -1.422396788331016, -1.0399448823159048, -0.3568482942102798},
    {0.060440467867663016, 0.8156938016036256, -0.6694555865524388, -0.9391721871920712, 0.6058719275230522, 0.9653351975967678, 0.5146096430340406, 0.7564869005862253, 0.21359266327943355, 0.7960713793614118, -0.43143776368623427, -0.881549706435503},
    {-1.4398057831070419, -0.40321557243365597, -1.151227660583621, -1.0741051744511583, -1.7075937087579411, -1.4966196578447468, -1.4798223215177366, -0.9336813865460521, -0.8974458684534884, -0.9159788166209466, -0.415364993422574, -0.5156788912601178},
    {0.8397906131638873, 0.43982982466591347, -0.9625998189875199, -0.7013483803898756, 0.12160696807167741, -0.6938361558337962, 0.9094963172882219, -1.0135951063514494, 0.41948615430133385, 0.13116387525122156, -0.33577568131971325, 0.1080269098786792},
    {-0.6315785330161305, -0.44857622050740487, 0.5563783643502526, 0.8157556590391911, -1.0231242044400135, 0.5515057382991436, -0.33110630726316476, 0.7554291372755053, 0.7071354061811893, -0.23620862889604816, -0.024049520852961002, -0.2529702433222554},
    {-0.49421934261697875, -0.3595448085086202, -0.7702859380525237, -1.0648076309669532, -0.1679077093478795, -0.3121567598743752, -1.3766495013036935, -0.767046848706292, -1.8594089570744723, -0.829853852298271, -1.634020335994667, -1.801348564254802},
    {0.16487748128846913, -0.8145372269217865, -0.345470701278793, -0.9785684233593401, -0.30540818005477766, -0.40943766027952316, 0.10772464309828583, 0.7840012446965874, 0.8582795772445034, 0.09498095000301991, 0.589106978990468, 0.6646391823564788},
    {0.24933195749186446, 0.32899888206854433, -0.721070882167125, 0.634969464837859, 0.7158437516819478, -0.3748347166305705, 0.30604847506921307, -0.653819824637576, 0.7493114306904297, 0.7554500070155774, 0.27279365788109194, 0.5089573500868794},
    {-0.204784145873148, -1.6933060600892809, -1.3234955080296502, -1.4531151940200637, -0.2914145337348623, -1.6212172992481373, -0.6908828821100222, -1.4728956508502402, -0.34432309405498424, -0.5096687787872424, -0.2808952984857642, -1.2546244308048204},
    {0.15223966074936243, -0.7770554165698051, -0.33448520372397494, 0.25792519160017435, -0.8874645775502694, -0.5874464498333529, 0.8506036585521515, 0.5156945025006239, 0.7189995979208377, 0.2919360492630459, 0.13015204806841307, 0.34202952240885265}
};

static const float b4[12] = {-0.5149722200750143, -0.5024531504247038, -0.5060933419505935, -0.5318780881465011, -0.5858654545141173, -0.4757495059001115, -0.44542705733063226, -0.5173089168475011, -0.59346163276647, -0.4415998835356767, -0.6454229745475032, -0.459785409331855};

    // Input Layer 
    float z1[64];
    for (int i = 0; i < 64; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[32];
    for (int i = 0; i < 32; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 64; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Hidden Layers 
    float z3[16];
    for (int i = 0; i < 16; i++)
    {
        z3[i] = b3[i];
        for (int j = 0; j < 32; j++)
        {
            z3[i] += z2[j] * w3[j][i];
        }
        z3[i] = relu(z3[i]);
    }

    // Output Layer
    float z4[12];
    for (int k = 0; k < 12; k++)
    {
        z4[k] = b4[k];
        for (int j = 0; j < 16; j++)
        {
            z4[k] += z3[j] * w4[j][k];
        }
    }
    softmax(z4, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
