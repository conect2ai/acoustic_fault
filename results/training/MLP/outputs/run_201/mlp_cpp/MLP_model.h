#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][32] = {
    {-0.9991597704877387, -0.9181774675094315, -0.5500941046933516, -2.138685356210237, -2.070561230707961, 1.9720076642036959, 1.893404375236981, -1.4419107435633824, -0.45096369012123194, 2.908457510646473, -1.1092029821610039, -1.0940199800898236, -0.5568131645407531, -0.25358279927231653, 1.5452547931923881, 2.558665230961691, 1.8246430742487003, 0.039212581373790086, 2.649773237027265, -0.07337142721272083, -2.0574879111067013, -0.4726686134096787, 0.9526962993962907, -0.8289243962494576, 0.6127574118994094, -0.0060071097334577234, -0.9933290561366508, 3.8697266249739855, 1.30767023276191, -1.4687954234236134, -1.4694220656482326, 2.5361055589466805},
    {-1.8676704001950035, 0.12142814679429427, 1.2706972908034315, -4.332656246602826, -3.2363438379426794, 2.353309906844439, 2.9365415094105103, 0.02514018348001734, 2.196210884772132, 3.2374460016321756, -0.05754370008746473, 0.2955724715804939, -0.411502564871291, -1.0494637630947512, 1.0459530307663825, 2.060208258311879, 1.7661022919883593, -3.0284253931678533, 2.746093883044813, 0.7579580113583413, -4.327493915451471, -2.037741184296898, -0.4376771205389039, -1.8684798942269407, -0.15699100677957914, -3.199850156794816, 0.44051715490738447, 4.269773440276924, 1.2398130024190162, 1.072959758646865, -1.728544619590685, 2.854908655603716},
    {-1.4460968461691572, -0.9876732291148659, 0.3639335668303455, -4.26804148813106, -3.4486978715286276, 3.3190291230225215, 2.9552484892268946, -0.5773474489641345, 0.9751411053988673, 3.961617577593313, -0.7651240897096527, -0.0846093841212273, 1.0749633109958519, -0.7750179417269267, 4.42050275852269, 4.0491434891036215, 0.6161357677396496, -3.5271239138034547, 5.209564129058937, -0.5875014012633563, -3.7781019469071055, -3.6846334746797544, -1.5731965354742212, -3.0937724471812778, -2.158678235312458, -2.5653897703817132, -0.9649998831306659, 5.571895105311565, 4.65080214318219, -1.2089579489428306, -2.710669831183384, 4.474783453287413},
    {-3.5778072294246575, -2.6952298590271537, 1.2939659679368016, -5.825301644742861, -4.686760838201258, 3.1166218023819723, 2.150697042293329, -0.37537192561088145, 1.9302837447268142, 3.294895993685235, -0.3763843275278179, -0.3782960255046175, 0.3842741079376034, -1.2752971786210134, 2.903754911524235, 3.8295976363779487, 1.3043729053853341, -3.405939978908301, 4.2921465467025675, -1.9298538196658546, -5.698315124632467, -5.416578227521564, -2.107360529510801, -4.648274812039028, -2.560346618472895, -4.561606308863495, -0.5589791758572895, 4.016362261312373, 4.533165625087409, -0.15443029156928356, -3.130628038702673, 2.6593078697456667},
    {-4.490173806258512, -3.3562324713091902, 0.5017694594155779, -5.575357250824354, -5.963314551996881, 1.3228955378075573, 2.1268633247630384, -2.2802197320229336, 0.9670239818059638, 2.599740463034246, -0.06051538341975713, -1.6643579349833268, -0.17825840406298468, -0.5459327389710141, 3.6523513370986116, 3.0910418948082103, -0.9537055229239654, -4.10586147209633, 2.9064800701172135, -2.1192228790711685, -4.925504362130579, -6.252136086601503, -3.477968074339203, -3.9648047837804223, -2.912050435924304, -5.027803951206649, -0.06521198528677627, 4.391920258788781, 4.065095048862535, -1.2529277594926473, -4.65212433299462, 1.8513605265659923},
    {-3.721330030098769, -3.6267885459013387, -0.8779956836803218, -6.587805891743618, -5.467719252089632, -0.3033626117218663, 2.2678818667828273, -1.1358713931501478, 0.2861496465849448, 2.210762058594485, -0.7687980328371432, -0.4089401947441944, -0.974350849239799, -2.417989559873825, 2.83459987611291, 4.087317261782011, 0.17201015528270946, -4.1366273809426755, 2.3827009533421646, -2.3868784731857438, -3.936547378684381, -4.504338181106805, -4.189695259212496, -5.5124190122981025, -3.6285717956485435, -4.502162683323811, -0.7509137437957919, 2.666439436876998, 3.3529983410531936, -2.0575200147251986, -4.186069149555457, 1.1196004890870617},
    {-4.742422564697556, -4.481235790414611, -0.35963882903253913, -6.096570779186429, -5.9501135814324835, 1.070582562707844, 1.9555255653075012, -2.8009720954693162, -0.5018418832714031, 1.6647045917361867, -0.3325564538659649, -0.2565156209652051, -0.5990581342553151, -2.4068775144922605, 3.126101595692528, 3.643650694944052, -1.4538815309782258, -5.563838086554112, 2.229469736673589, -1.85427783365836, -5.399127668496963, -5.114668726228965, -4.09037539640357, -5.251916194982342, -3.1713698607514167, -4.957685221842157, -0.26036517635039536, 1.13617388929392, 1.6466323338067743, -2.632204372937659, -3.2071380876559616, 1.1151480588290097},
    {-4.984106978160291, -3.4848924692911023, -0.33200243238961685, -5.631307087615736, -5.462781202219326, 0.7739146630495635, 2.3829770739249025, -2.275164675557242, -1.0259718757751632, 0.8750324149757086, -1.777970364051123, -0.3161626150966341, -1.9498894369659316, -2.930993854573558, 3.628699427986506, 3.6106711666273164, -0.45278036423912665, -4.368560311136393, 2.356790097979095, -3.0711601977243155, -3.919231594506175, -5.005982231294518, -3.515608776596571, -5.359290914296128, -4.089536698935548, -5.065111355418246, -1.1725366707473923, 2.371724635734434, 3.1750529584307037, -1.0673116677409513, -4.843297896227617, 1.7274060392917296},
    {-5.498452063856968, -4.547169770817062, 0.007064859761528345, -6.482328121577645, -5.553006756851042, 0.5915533405453979, 1.6410137428298381, -2.6660533234790718, 0.5898457357307366, 2.1376429032748505, -1.6138561224343397, -1.7443801268383614, 0.3371251050930044, -1.2428656709579806, 3.828444012551759, 3.236412180503885, 0.539661040481516, -5.873646171765913, 2.068516282660824, -2.4043340201601273, -5.275055481560585, -6.194831910809315, -1.8840394310528996, -5.8641587025417286, -3.4064920464068273, -5.655842636824823, -1.969998815140812, 2.693010473441903, 3.5456767965818807, -0.260520557494996, -5.061961367039676, 2.1715642189681983},
    {-4.910680256856169, -3.1127885506149653, 0.7971923775547292, -5.818864800810041, -5.506091468262257, 1.4567946002460113, 2.060240385805011, -2.2416667680012474, 0.7224560285964917, 2.4646506068728566, -1.771787744088718, -0.34434561867814006, 0.14104965305971753, -1.0583947581562676, 1.8045383205554295, 2.794768549756406, -0.20841165452195398, -5.847020762848468, 3.7621056392913315, -1.1064534746136212, -4.660877952600231, -6.458799212907289, -2.9965838850564457, -4.883886801473229, -4.405437371869756, -5.510920287921076, -0.5125925719963575, 3.878015350601512, 1.9929848729173107, -0.2977136391302832, -4.461966097254222, 2.4046847373838425},
    {-4.764868216451611, -3.2413010695522106, -0.1997387517428586, -5.044459812986092, -5.174385875328237, 0.9105947956659817, 2.266393829560217, -1.6539627244111532, 0.5324647271260329, 2.6549698528469836, -0.9898418574751452, -0.9760529473188143, 0.06672559830156094, -1.2031962086670125, 1.3073124191322651, 2.4307963485409907, -0.7942459093748773, -4.406201592253313, 1.9293136040306336, -0.44861627852507596, -4.742090022699851, -4.925042125791305, -1.7621750354086112, -3.593719499385371, -3.473328479918503, -5.137567423588057, -1.8443420305602534, 3.7574503903211296, 2.315126463193795, -1.6386384698871825, -3.455659138138889, 1.1313871610944788},
    {-4.5495318611755025, -2.7994013258260853, -0.15213830604719844, -4.443702675968602, -5.74056542363369, 0.18772898595678952, 2.4611960666087507, -0.521588442533589, -0.5848111661029022, 2.2935843245086964, 0.21936511575654308, 0.03482802295748397, -1.046491603511139, -1.5297675482713686, 1.9778804421793232, 3.156712433624521, 0.1939949161757885, -5.263221424877556, 3.036005765371598, -0.5303118851543059, -5.157808664708746, -5.778983637625995, -1.9260564122693116, -4.546203490938811, -2.5283602777174683, -4.803688118835264, -1.7922351076551513, 2.4510848352430212, 1.621118367749273, -1.5316725721237743, -3.552010817582958, 1.6768211411564822},
    {-3.781971564769579, -2.6753010582183543, -0.010302887548065773, -5.5187732719519715, -5.415560000708986, 1.348786700934661, 2.0149931373518344, -1.796874248477725, 1.3681428256194208, 3.144950781479063, -0.2568505345661892, -1.2081534586657758, 0.47901766001934676, -1.6037999567366399, 2.9553481794394303, 1.7480288924856615, -0.09966629044708472, -4.827419181424769, 2.1326952116901623, -1.437850942131001, -4.443096189690332, -5.29148299020424, -1.836750884612676, -4.937082622562688, -2.481262871749369, -4.209630962609165, -1.0292799629936764, 2.155622053147953, 2.997993522509866, 0.4232295019506203, -3.278251761354926, 2.246430757987704},
    {-3.143896241587686, -4.017095472655679, -1.229870328654608, -4.922697331434712, -5.609750667754938, 1.7975394103172064, 2.592649110755491, -2.0482687843232354, 0.7855173382079063, 2.8063267949358806, -0.290273367326846, 0.11500091986841454, -1.1907532630910445, -2.0368973723048382, 3.168914273936339, 2.6598512409560926, 1.4231903531271632, -3.9988569010491504, 1.9219495966392783, -0.506475594281328, -5.188605508448212, -5.843049582854637, -1.7075758123471447, -4.780794704565353, -2.5939663106605804, -5.41045298184423, -1.0916528322366508, 2.500311054205647, 2.7347468961018806, -1.1435164516671237, -4.302656632066969, 1.8129384063355372},
    {-2.772567053389272, -2.907767957220862, -0.5034401884442561, -5.34667347823469, -4.435948083769353, 2.3548734626647403, 2.4488761458272745, -0.8476326797711553, 1.2592953722209692, 3.6393860992975697, 0.32834365852819447, -0.8464233729186348, 0.529839571190682, -0.7622927730048689, 1.997164816798802, 2.409940900212421, 0.8357623989692465, -5.332446865817074, 2.49196953515105, -0.08026910992574597, -3.9298465449048448, -5.453169359101754, -1.2352814765741205, -4.6480373765104455, -2.0019756494193555, -5.407016515592568, -0.403870260157561, 2.336135902400881, 2.1511560616829466, -1.152263225662602, -4.0170776284087975, 2.9079575680836633},
    {-3.132755950016262, -3.7102274002621924, 0.23942719503490667, -5.2595287939586, -5.370439553122818, 1.3845250047892816, 2.26970248053324, -2.144289730104574, 1.2778106910380704, 3.9621507091329784, 0.22794033264303185, -0.010398832807556133, -0.7972014828600038, -0.3310117011577485, 3.3698054361228085, 4.379234581869739, 0.2974913104237718, -5.165856953139783, 3.4205860469717035, -0.8438419434770371, -4.653426395798931, -5.243800032516579, -2.262009682265287, -5.149891536663596, -3.8111040173394364, -4.098118605358848, 0.40090370476454845, 4.558245733615933, 3.4225961211320612, -1.3371232421998607, -2.7375545148924822, 3.5248148444050376},
    {-3.5037413615239434, -3.3949218241509844, 0.3354053101734154, -6.289538001704574, -5.4519023802121716, 2.0223120919771276, 2.7269454343963107, -0.9263409366946898, 1.6225294605193632, 3.5362906193517554, -0.3865123895932071, 0.008582788848763382, 0.16873773710535625, -0.9711271692237158, 3.9016992532304777, 5.035801200623147, 1.0159658275228076, -4.972221717615853, 3.8801338588901424, -0.8696507890388374, -4.713780218137359, -5.671501557275236, -2.1917124227876847, -4.904599476229577, -3.617219546611004, -5.239058641229556, 0.8521132538886177, 4.261838305163994, 4.583710056418373, -0.28837854065514207, -3.1603095439861097, 3.068261626718461},
    {-2.1554419161488325, -1.9741590453978108, 0.561513069556053, -3.8204154271014277, -5.049387156759685, 2.622013290865057, 2.808705915257009, -0.2312445942708205, 0.5996175238754764, 4.1967747733438, 0.6944013787107477, 0.7026449036820267, -0.6111110269295769, -0.7376598918384545, 3.9586885673394288, 4.801116712792446, 0.6065770664218774, -4.092467444549155, 5.5544220892694, -0.891902129367376, -4.6700940761835605, -3.553704411300347, -0.6899957328620878, -3.481576470780114, -2.728019972514589, -4.5642013640858865, -1.0277067236447737, 5.748996759727045, 4.344078732111728, 0.7478893098316243, -2.0797469164099134, 5.253908323993325},
    {-3.518018970786076, -3.020899148013583, -0.14728337914887382, -5.2899491912654675, -3.790303304040649, 1.8468482416748386, 3.087397928916861, -2.090377213742541, 1.593814527584246, 4.488339317097169, 0.08565388021123796, -1.6993753469530393, -1.4120395195226179, -0.3679791858530976, 4.458773192298472, 5.063186085058363, 1.5108018014299622, -3.327099177453419, 3.8183438547165305, -1.5322132258589463, -4.299810976396197, -5.358397782475649, -1.7589069332501015, -3.495327873898999, -1.8308644249610402, -3.377659732639191, -0.8395989175478052, 3.690411379033676, 4.388660381231518, -1.4245913712214424, -2.23496422827043, 3.388399040371871},
    {-3.961902849579967, -2.3958958621279285, -0.20597189850019076, -5.024070229036448, -5.546087814351555, 2.1111352785081285, 2.378605817986623, -1.3552117379164987, 0.21513408392794908, 4.791948111016561, -1.6848230232520987, -1.9136355474103548, -1.4214570934529736, -0.6651792547893166, 2.711889022389575, 3.0855419742050127, 0.2931868491622154, -3.5781794305999752, 4.95941256385219, -0.6304678294674629, -4.57774052798848, -4.378378176313143, -3.663474977673164, -5.029759932188764, -3.865046501920525, -3.9639817153455903, -1.9249529808491508, 4.396147984033427, 4.355514568407023, -1.4083141760922406, -4.216508183498283, 2.62688186452647},
    {-3.4854363509168285, -3.126777066377584, 0.36543608707181174, -5.684280891464994, -5.796931026224051, 2.604708782129823, 3.614335096865221, -1.5966959623627337, 2.2163943564672133, 4.940455657923747, -0.17240852840295448, -0.4396527107838987, 0.056533968258507344, -1.0381222163078665, 4.072923588170016, 4.806438347693022, 1.7138279044689222, -4.9402584562802225, 4.29168444594541, -0.9186443041157799, -4.387758008946403, -5.203393566527437, -2.473171264041794, -4.826701619940987, -3.492861637533841, -5.487354972184583, -0.9094008441736751, 4.350432265007051, 3.54784381162783, 0.8198936153176274, -2.6349238381770084, 2.5850187837120595},
    {-2.8444302049671526, -1.6546196845761703, 2.0008587411404526, -5.062545439316326, -3.6834809573156018, 4.226991256907743, 3.5033022236698654, -0.05664743778663017, 1.2448716055207585, 5.000539530811585, 1.3222416793467078, 0.9129209479459373, 1.4913815945877067, -0.16713918878554138, 5.002630120090957, 5.5055916733323045, 2.001120531422515, -4.183757366903659, 4.265074475120889, 0.29380244275825845, -5.491523645175902, -5.187259460875783, -0.7166496328556667, -3.1679658825325014, -1.9497935750105904, -4.3928076516513155, 0.7709917035122419, 6.254240439346289, 5.7030521717573395, 0.2248286130412268, -1.8953221969771246, 3.9028073997252113},
    {-2.1201869274703995, -1.9442260718529345, 1.8342953044123282, -3.30109854090074, -2.7606406819643876, 3.3738484032951335, 4.545207646498751, 0.14636037753633072, 1.8412680080723889, 5.703640875482881, -0.378156213958059, 1.1952827725924176, 0.47935361274785776, -0.5308983259752234, 3.9404669110179382, 4.903704197731959, 2.4862704813774488, -2.637326281895312, 6.035131796818826, 0.4440998515918267, -3.765192333475412, -2.9848904284565805, -0.5357532788675521, -3.8605071417421724, -1.8992207974011934, -2.905262901125248, -0.5697404884014051, 5.731289265260257, 5.800305692302108, 1.3462548112004489, -2.5015866757900715, 5.591775759632149},
    {-2.5836850593029794, -1.0629045672362791, 1.7685160424653414, -4.8569729333221, -4.926836067727762, 3.995583187550593, 2.6460560438214933, -0.43936571187572826, 1.3958038055120818, 3.642582069464796, 0.9109287097459785, -0.7343051858645945, -0.01297144521186433, 0.0452696037849203, 4.741359020678599, 4.105010290867143, 1.9235209029784104, -4.214435848252101, 4.7991149132742335, -0.7482374520690308, -5.237834989000245, -3.8080565825575454, -2.021442210295991, -3.4860606880974188, -1.168867679279978, -4.7509374713733274, 0.9180098309959784, 5.848838812594725, 4.286985991653404, 1.4203646169872335, -2.7502813422748833, 4.772552583863931},
    {-3.1350085941866492, -2.7673362332831917, 0.3894832475504137, -5.312963187459219, -3.801380759480723, 2.634018722274283, 3.5389093907305136, -1.37872939376009, 1.1926193039685804, 3.6019218731401916, 0.5794338958553196, 0.44969934327375005, 1.2535581132605458, -0.46398047195828623, 2.4383004027045327, 3.7215283589594264, 1.7939371576423941, -3.41668248988566, 4.576869127068789, -1.258729313231263, -5.326795181429276, -4.031340220111036, -2.2735496609966734, -4.231782159046086, -2.290990268328706, -4.516269444411067, 0.5058588045171692, 4.181054291695713, 3.2867656342960663, 0.016527560494513763, -2.1090102049137447, 4.2422356609606355},
    {-4.076395125751957, -2.9424908607877196, -0.36977889553897897, -3.5743460852232665, -4.344546334516089, 3.1586971333703135, 3.49123464949521, -0.38014949215022253, 1.7015970272870027, 3.2675151819162873, -0.16417592605711906, -0.028372084190656226, 0.14601730594430057, -1.2294850340546362, 4.583700006602255, 3.5782351379393806, 0.4713834529183545, -3.567768825104873, 4.781852235038848, -1.4009551469775332, -5.093739794225782, -5.388299233254004, -1.0264999976321967, -3.968698936625073, -2.4597338852170263, -3.713335191541417, -0.4368840143753401, 5.517012926451766, 4.658165531846045, 0.890583776210645, -2.4907793764653148, 2.7493589447567355},
    {-2.7382684602517187, -1.8369672670722819, 1.280107829920801, -3.8688163050636084, -3.9793563983960563, 3.934976856973542, 3.7206264148540553, -1.2688318359482025, 2.3671746286797695, 5.169933444114207, -0.6992652087797449, 0.06713364907767365, 0.9113846710243926, 0.14459687246892505, 3.747886612289112, 4.352703621654334, 2.462245094546639, -3.7859097484512536, 4.991383802413675, 0.4387112668042737, -4.507926301713676, -5.029807952292678, -1.3086254955101273, -4.405137206585097, -1.6762372052728844, -3.482185286434225, 0.5186015601339838, 5.855976024369914, 5.2228320414691645, -0.713440657301611, -3.135734733236197, 4.660154960578876},
    {-2.7939795366189695, -1.7416084019379483, 0.3490474086475738, -5.262645383215664, -5.246033828213277, 3.465740212522453, 2.7200341420527314, -1.713766674626487, 1.1367817140642675, 3.949830143167411, 0.26349034862142945, -0.5637240998733238, -0.11941491476038368, 0.12418303009477456, 4.006288541920339, 4.818732601923916, 1.799504486027763, -4.478601763666802, 5.549236289520944, -0.09083580719724568, -4.101371954568032, -4.204558551045201, -0.7101228667574921, -4.314724607869345, -3.388022661204588, -4.800618549868375, -0.1791473063644438, 4.751376934820562, 3.9118198128721215, 0.09427659096026107, -3.2222570753103397, 4.953216244539444},
    {-3.5260036031854254, -2.953647709589695, 0.7716309721257497, -5.6711110047766, -4.841522416894297, 2.8408889416020053, 3.998049949274695, -1.306088803719405, 1.973420359707237, 5.137150974852652, 0.17784943151264734, 0.7905169875621246, 0.7894416310642843, -0.37508512250832476, 3.2622083404326956, 4.5108630687351825, 2.1296049591334953, -4.591187092585714, 5.198275529687082, -0.1978763102377443, -4.151755629358798, -3.9101240303184723, -2.265490232222964, -3.4879161035675232, -2.6496601812014826, -3.486775998372477, 0.7074932231206733, 3.996438188880414, 4.836408629677638, 0.019247274608457036, -3.652106542369284, 3.962206219525134},
    {-2.919076255485413, -2.048393675656071, 1.5850963136074094, -4.651147012762245, -4.270467173272994, 3.073020511160226, 3.5382816422700767, -1.2479205226722523, 1.914943295491068, 3.9653142247322366, 1.0136486282928487, -0.8500915768002533, 0.15681755171378273, 0.4985980334610795, 3.742677344181907, 3.3743824390697505, 1.5701405215890558, -4.555808235952717, 5.50806969122887, -1.1413900490411146, -5.951731293912961, -4.487366655901726, -0.2508947737520762, -3.52983942597721, -2.1941903873849693, -4.453916527691081, 0.3702096612397409, 3.7618237214354187, 3.5419571541371537, 1.3925493734244678, -2.7587949376584255, 2.925266509287515},
    {-0.8592785579258522, -0.9690878195658561, -3.272583913816345, 0.9074845819146476, -0.30627714220472835, -2.0454364117628896, -0.11222404003211385, -0.9994384987812861, -1.9937858433091966, -3.6308350009242774, -1.5809307154526309, -1.787497882638207, -1.7137132745825907, -1.3465296079562095, -1.9688096022606056, -1.3832948418575026, -1.4898346709442654, -1.0736951023436876, -2.2417498713414186, -2.117646269677028, 1.3811470658024427, -1.1237689525875063, -3.3707623140868814, 0.8083379198189891, -2.0292290042295362, 0.5419205829439967, -0.7651703678039302, -3.1842770741215576, -1.1201969541726353, -1.2631261441671942, 0.13476111373431093, -2.079476760681684},
    {-1.4630690648358338, -0.45075160620287014, -0.33000340510059206, -1.9736608597720815, -3.335237173257592, 0.5336654013105824, -1.0747110511456113, -0.9594863010090937, -0.914551451004795, -0.1097752813938209, -0.8046590426193364, -2.4967569741498425, -1.1698292918769664, -0.2151750588971757, -0.9994937833724384, -0.03967457942134229, -0.14315802686128326, -1.6164071760745478, 0.2528022637937807, -0.052001179519660594, -1.8728281655997494, -2.450878319928577, -2.3580450855309296, -2.5229973764907947, -1.8272562234422611, -0.6499358006472203, -0.39330241117383025, -0.6166509941350534, 0.6251557494778013, -1.8337643880502, -1.9680809630071652, 0.8157472435454226},
    {-0.9953344280845694, -3.9397013726065664, -3.3355093073167645, -1.3163522723930876, -2.225365290368478, -1.6824572989629876, -0.7038052556216404, -3.2393740173664556, -2.737942831513638, -1.273050660628788, -2.371143265872396, -3.5700096214127135, -1.6902612063238929, -3.328857092055409, 0.7870284536847513, -0.1813419015631072, -1.3399696641332481, -2.6616320878876634, -3.1429775563889937, -1.7891396471222767, -0.8876759629147024, -0.2457359340058866, -2.705994217897378, -0.7444537035083124, -1.773231640944779, -2.185853325387187, -1.6867878475565083, -2.3532912452592663, -1.6735224772706947, -2.7064907267420217, 0.03847284524074926, -0.90862303720387},
    {-2.2592033511644236, -2.4863188205470133, -2.1172052882057844, -0.7535618647284557, -0.3490362407115935, -2.8924015330983543, -0.7790956134875223, -2.7405404887467104, -2.739989829141365, -2.902999639093949, -1.7085034458627504, -3.4691222363329697, -3.314163677553372, -1.7963709973428517, -1.8463475000203908, -1.3592242770124905, -0.5331078789732234, -1.8903428718751278, -3.5905722703853904, -2.3723929391175638, -1.2013466077005346, -1.4830785163213702, -0.6491785156828729, -1.2844217765604249, -1.0810750996817196, -0.7651344236703124, -3.3378714150692885, -1.2894924312555591, -3.0431833444427503, -1.2790169744295032, -2.044279718934247, -1.0875177631004003},
    {-2.3514507770722126, -3.834943772061649, -2.764710248994595, -2.3506548440471877, -2.601144867348841, -0.13715253242275133, -1.8207904901409255, -2.4041129922286246, -2.6299177445110855, -1.0797087856580059, -2.4038641111684753, -3.300436762629926, -2.2116921962664193, -2.177120730489791, 0.24694945475250404, -0.01865001516201842, -1.584948903911143, -3.107215635344508, -2.1254239269064703, -3.115152102783644, -2.576498041691615, -1.2749515677019965, -1.5876504456143294, -1.7674536371471294, -2.102742107951893, -1.661396877525967, -2.3380328409508837, -0.30607683027579946, -2.4327245914926445, -3.4108789405346407, -2.704602339003633, -1.5620855583932753},
    {-2.312041394468199, -4.205545612891604, -3.213115225588572, -3.0464077112810393, -1.8587956014060796, -0.9276561665008134, -2.8967059915451654, -2.144792072880093, -2.2963828451705397, -2.4488655082180175, -2.976996387193031, -1.989055184218345, -3.7639651368121845, -2.3467157164925565, 0.4880364161173843, -1.211362580044137, -2.2454814213309184, -3.483143710919163, -2.9001266578218234, -3.2512021647658824, -2.8741296303037918, -1.4060526785767402, -2.862886716742452, -2.677430646393157, -2.852975124897357, -2.2183870459757675, -4.100147413335239, -0.5059191471054174, -3.0208756346576178, -2.7493593824576483, -1.386082854331472, -1.6414673742655115},
    {-3.260175614294989, -2.882693373032021, -3.2975894353837707, -2.3341582106675576, -1.556083544644044, -2.244792523036222, -1.1718122299340805, -3.098831315387635, -3.419883024731501, -2.48834750783532, -1.7383338023137946, -2.8838222623376337, -2.4669600084551893, -3.531991181061414, 0.9003496707652754, -2.2413146165262474, -0.7349617709316506, -2.3216717242987497, -0.8891084408855009, -3.3164389516718673, -1.3624588508085722, -1.8835244943197529, -1.9941791886969984, -2.1224761128199616, -3.00130284047241, -2.1461358594968583, -3.9795233308064675, 0.429480248153885, -1.2559480166668848, -3.340631896511277, -1.1853526987644412, -0.37422740445038244},
    {-2.579886213985181, -3.1731451794646315, -2.4956510334635906, -2.2518427897225366, -2.7040570116276172, -2.4097609415390764, -0.48979586579587653, -2.4244782548258677, -0.9499400152441285, -1.0839691291122697, -2.5086337840279334, -1.5493864087848044, -2.5442087985725848, -2.2817940322026575, -0.2945986500929386, -1.4901195848139754, -0.9792722132844461, -2.476749628275365, -2.0563790113343274, -3.7059089239568475, -1.4827033689766667, -1.61303537217407, -1.6331985946591665, -2.647467112805339, -1.01063566438244, -2.2485274147197014, -3.254132244472559, -0.018697988867208536, -1.9208054376711847, -1.5878838002745967, -1.3756259538119355, -1.4709740308905335},
    {-2.8674194340000088, -4.179602780031875, -3.5165518398173226, -3.262947100384059, -3.1257679042874127, -0.9854438709095501, -0.9815806357816509, -2.3728528182310864, -3.202020100007484, -0.0004049651886318577, -1.556322511912721, -3.7625957993886905, -1.7221856785329586, -2.1603751475804898, -0.6578226593166411, -0.2672640563869934, -0.881485160432262, -2.1636064427020365, -0.9232546352743954, -3.178653939822881, -1.2088394774093745, -2.388826126237647, -2.845551254405366, -1.09637277944584, -2.0098631738665333, -1.8937041850322665, -2.500732869593691, 0.08530406370437156, -1.4570154470651657, -3.2425286782000837, -1.228242552627083, -0.1005481643534435},
    {-2.9527201519559525, -2.4848882528192675, -2.3621751717183086, -2.8570478707621927, -4.011821933228999, -2.0261544974430348, -0.9879528675919151, -2.42741623302599, -1.7463558310525198, 0.1031215313723494, -1.9461872061764538, -3.669798372372634, -2.9742351101217066, -2.1193645452266554, 0.20793088982137176, -0.6357075210693455, -2.4038996509701067, -2.807663956358633, -2.343458960143019, -1.8793096397586324, -2.7008177336812382, -2.8974504902286067, -2.4270507764281612, -2.0264544687774815, -3.1563285257010425, -4.049579370785355, -2.3210468257318553, -0.5839150735230866, -0.8539606694778001, -3.8930034562606384, -3.2140622145908653, -0.13537707293889167},
    {-1.1248047855476841, -3.4659361182039916, -2.360343104372637, -2.3181611833636495, -0.9364561062367676, -2.4139587340745816, -1.5886769564743288, -3.53395941533075, -1.2729551454157333, -2.206265752359735, -2.167829491514926, -3.0039062771264162, -3.2165958334262945, -3.185029646185571, -0.36931442711455686, -2.047153444988598, -2.857367221503234, -2.4733880423553614, -2.5012282082727997, -1.678210284490665, -2.7878068046632016, -1.6322560736258533, -1.3716257563989085, -1.9565339191629916, -2.407632663227303, -2.9159909748703248, -2.9411647643152183, -1.0613203697200966, -2.8359183925479154, -3.125193271934044, -1.7780763839262639, -0.38770223530996617},
    {-2.103396517696017, -2.881969186770277, -3.755844995373578, -2.7824084267015183, -2.1712567631656543, -1.2331981706175805, -2.8998772226794793, -4.187448982838518, -3.14310575872558, -0.8449522353337968, -3.7870579142464695, -2.631365994986217, -3.139667157773779, -3.0207528154378354, -0.8481776400097168, -1.7396096210957506, -1.0900328007453677, -3.887220077104366, -1.1047164098926245, -2.1189394975111377, -2.074895720503709, -1.95187507306283, -3.2934411366769285, -1.5141263939235325, -3.397080031244624, -2.3125969834238997, -4.145592304103671, -1.2081216424954766, -1.0393665300340968, -2.864987013565646, -3.349521829949632, -1.89565135800486},
    {-2.5532798247961783, -4.375463769695068, -4.0386478380895925, -3.7371295145410035, -3.1844679690355164, -2.009925384227931, -1.5760496596404663, -4.361155064392905, -3.5239315113441996, -1.8516901039817548, -3.435190728730925, -3.843821479795971, -3.257858681938896, -4.015279057635684, -0.8968186178573955, 0.05584765182797297, -3.4815762668404795, -2.4188104577260914, -1.3089452736156784, -2.547570207025714, -3.4860313410012758, -3.647478969990736, -3.2603590830727396, -1.9582436828075052, -2.797613223894772, -3.470758917988663, -3.4580364172657325, -0.34991585859806407, -1.5146258482804564, -4.098783578915701, -4.506835417011995, -2.321636744156482},
    {-4.051788260117054, -3.142277174294399, -4.149967028739652, -4.353905109127865, -2.8140033968559846, -3.08021337657354, -1.6415411305980012, -4.357712338182238, -3.210903597432152, -2.6522460497267097, -2.9702392350562894, -4.400562446309492, -2.6113634252029785, -4.471030689149478, 0.09182789948308942, -2.0318205797128597, -3.5670104193412224, -3.8634018698589334, -3.5204445683961922, -2.7989865816030974, -2.8723651457099217, -2.5231624649490745, -4.655517314874106, -3.3336282429163764, -4.160282667775904, -3.1651201575478902, -4.552612438256234, -2.0974546092986253, -1.5038321896917006, -4.1116942076546374, -3.9339209826067214, -1.598842348505545},
    {-4.280944460952423, -3.4774000492194683, -3.6543246616767115, -4.187576795675274, -2.666655996027574, -2.8328476464687617, -1.7743196179901481, -3.4314641268993102, -2.951333852164247, -2.470708266406593, -3.7217440711316714, -2.9890399794150926, -2.1427154446256114, -3.8238325775258857, 0.48080688901020024, -0.8703695325179153, -2.3216040465086705, -3.778151518003044, -1.4512520397832924, -3.818338998951261, -1.5195088964183718, -2.423828547011735, -2.4295658521770807, -1.8433365233873635, -3.737964092265941, -3.9442131605416697, -2.6709901089346095, -0.7960650177980857, -1.148139874372044, -4.111319776144518, -3.114030723958842, -1.044363306990529},
    {-2.495306055435556, -4.027428320497194, -3.8662080499347815, -3.5633224531480305, -3.78081074010819, -2.309236902636038, -1.6384675741519457, -4.253424070162763, -4.557123754377418, -2.1773518210933682, -2.0727622761404176, -4.266434980354111, -4.160896906125639, -3.686160603809019, -1.403731497210343, -0.6988958162170638, -1.5278986967371313, -3.5593002384068857, -2.0021940079600604, -3.71377021320892, -1.5936760918863655, -3.1074756694286347, -4.1149863063012715, -3.5983515964908546, -4.644753779294237, -3.30975875690762, -3.5718722842037303, -1.2740818409073786, -1.634532655240943, -3.623298597742515, -2.6260046473450283, -0.1489354789173488},
    {-3.764803998804515, -2.278812916963868, -3.503466208411224, -3.612550053192605, -3.420297745448396, -2.1252264777330483, -2.8207851223976417, -2.309994824666881, -3.075291411207721, -1.1521352225479906, -2.8345621833251577, -2.5850513955391756, -3.268161626569872, -3.199962319038252, -0.6657284176868389, -0.2996072304897429, -2.4727737774388094, -2.8575698667829617, -2.812340601826765, -2.9763281884929973, -2.293023321533886, -1.9374074274114033, -2.336620739631746, -2.331633097260966, -2.9012417055028203, -2.1273573026636785, -2.3736655156898285, -1.055371888237064, -2.145919379850878, -3.5122116557609973, -2.1184487421218647, -0.6486499534367519},
    {-2.7291864656318667, -3.6204995882538946, -2.586413308078254, -2.187487137236324, -2.946823268469229, -0.9266000413116975, -2.3595613255964687, -3.5512582867763416, -2.6365423532893004, 0.2229725085772301, -1.7746479349314497, -2.7735386064193177, -2.5846832930073544, -2.6316165348326708, -0.4083996720946037, -0.6180821280779417, -1.6187237560194914, -1.6166415278936292, -1.6034083923952087, -1.9596065902228723, -0.7659264614215457, -2.8126357557195316, -1.405775199123534, -2.571062220042004, -2.773968123265973, -2.2298401170266673, -3.2444372479133405, 0.3122197169908234, -1.1985263033673517, -3.458636884508892, -1.2929114534876613, 1.0667009420971219},
    {-3.4457310531213445, -4.22872809902758, -2.890703043590231, -1.9768542393155117, -2.107093375927901, -2.808436877527872, -1.4821960369110108, -3.5752601753531894, -4.083097195669004, -2.649247063064804, -3.545579192770273, -2.6022410213711384, -4.467179540805299, -3.10865527421435, 0.038110986430172855, -1.2444450073183682, -1.3615625444516988, -2.98073679439123, -2.2420619376538298, -3.653829971771665, -0.3277614566074133, -2.9126690813242297, -3.5758868670046127, -3.1418920500284546, -2.4448206613653936, -1.698631513615805, -4.632313473055078, -1.3887390007905906, -2.8574433905002388, -4.232750198800859, -2.4017562218656194, -0.5670496192297431},
    {-2.9978336773108185, -5.087687165649824, -4.762410023680613, -3.4776149822155955, -2.504968051034997, -3.45643808934007, -1.4533795479903988, -3.5114905909615524, -4.273768488457591, -3.117677332845367, -3.2324685361084184, -3.5863054025285073, -4.629241802270511, -5.169291798997859, -0.3855182989930974, -1.9709157963261634, -2.7025011271898505, -2.4820055227317734, -3.507229294818811, -4.083460964328446, -1.8746905958732132, -2.706150080112864, -4.41930870392147, -2.408231614833518, -3.8362516812044296, -3.344384498788494, -3.163616382510493, -1.6765071657378283, -3.2719843906752275, -3.8657456718840835, -4.006573393103663, -0.7397766431338608},
    {-3.25880489613315, -3.970890227407151, -3.6188623319559317, -3.789157219607065, -4.296997852310287, -1.561350181051759, -1.5183014249111701, -2.958798939894562, -2.6284650153928677, -2.7480018415073117, -2.485892438465681, -3.1386943695480722, -4.1776167374379645, -4.180649391485496, -0.34490275472197385, -1.2352124587378326, -1.9645142271455274, -3.250141479210766, -2.2275493416578263, -3.5673742730471996, -2.92397104574784, -3.123376512163683, -4.1837564576611435, -2.818781619350047, -4.929179279199146, -4.12277604890044, -2.761229815842747, -0.708371600137219, -1.234706419362279, -3.444517229953001, -3.921539134024614, 0.07300363209735923},
    {-4.030515001115324, -4.5042191179331, -3.0315802267648344, -4.344246931733099, -2.702798910694226, -2.66186831200408, -1.8514823948300794, -3.5223089805107235, -2.3590983110845043, -1.0816431057172078, -3.289026709436158, -4.237092434642279, -4.054175420093057, -4.2200936525998785, 0.9816949788948938, 0.8472639193778133, -2.6564315294713614, -3.935545107590244, -0.380290352504723, -3.1392751252946316, -1.6920789460985468, -3.1532892652744153, -3.3011962912813466, -3.692605605904495, -3.8736454745751168, -3.6020464716024336, -4.377627756905036, 0.8979911983694467, 0.8826470004950884, -4.62902589727346, -3.0602511069074287, 1.2675753761192015},
    {-1.592916188303628, -3.5792104805488716, -4.8311565116018444, -2.2396789440003855, -2.004404366801902, -2.1606775535529166, -0.5055485043751594, -4.207900706496294, -4.75746509514732, -2.9325396754516397, -3.370886665301885, -3.370088241736546, -3.18223745439878, -4.348799214074476, 0.9809146738935962, 1.047902739920149, -2.3833677471414116, -1.4705337771551605, -1.7997263430303116, -2.9072888659560414, 0.6211310117679797, -0.42085476842589337, -3.588705799109021, -0.9087902871427869, -3.2692548946608366, -1.9279380613323491, -4.7899906513528885, -0.4732632021620213, 0.8021472725650305, -4.905792254019258, -0.3702001078612582, 1.965107434379927},
    {-2.552365770231499, -4.867802467865717, -4.698175896409559, -3.0251625181713644, -2.1924973824394383, -3.7319122005947687, -2.513551563390106, -4.570280809429086, -4.7485314860368, -3.1201949877381465, -3.827922802696889, -3.145817487881481, -2.978842071487672, -3.63004863621364, -0.252305843087973, -0.15031227482937576, -3.160655206204576, -2.111241067874393, -4.137463580336649, -3.4908380052354167, -0.06626713168660459, -2.718459649437451, -4.974284560266042, -2.096471386864268, -2.955513230518669, -2.0657958148210236, -4.962383556599829, -2.2782108917603865, -1.5937005642595876, -4.694569967104123, -1.312929689858997, 0.48332082737253557},
    {-2.9407723140503936, -4.241425390198002, -3.4812967976025364, -4.610001264662133, -4.216667351656447, -3.1343511133593225, -2.107723897440531, -3.466859343905938, -4.526576517157975, -1.9348046919569006, -4.1021738322143735, -4.323245987923666, -3.1336883614658384, -3.104657719864663, 0.4154189401925367, -1.7137803401336402, -2.759058524282739, -3.000915654762519, -2.8188801556104734, -4.038342335223582, -0.9273540449981335, -2.420577023224267, -3.854231498081658, -3.4537320507412033, -3.7490870796708275, -3.0939592394012516, -3.4398398614128856, -1.1644294569671236, -2.316564448099958, -4.809562483067236, -2.883500875564636, 0.06763818876940876},
    {-3.937230032945801, -4.32182719581821, -3.9615236336048905, -2.7856103058193433, -1.0021463123924288, -3.9100835851992595, -1.9635596714741055, -4.966571966009789, -5.154815554217917, -4.022308965712575, -3.7379460062984196, -3.9816047263140133, -5.432947013616111, -3.1166182309479664, 0.07577961435760829, -0.21751253364829498, -2.2892127154418485, -1.7977768079947676, -4.658958759546708, -3.7820323421521684, 0.2597072176010637, -2.2050772150384166, -2.5201631712581882, -1.0083096716989062, -3.266095319586917, -2.078507721263018, -3.4369441319371123, -2.4863054659679804, -2.3282121336550676, -4.0381504492219396, -1.755680027121791, -0.06725723575561418},
    {-4.291712815050039, -4.5125408136648355, -4.906527467133054, -2.019110223334652, -3.037045407868759, -3.1761575701997464, -1.2060646629175078, -4.761041046677419, -4.097046664687968, -2.213972541713897, -3.005792591834965, -4.403391455302479, -4.403349759256078, -4.625850797372652, 0.9848841587879344, -0.3716893469843651, -1.549619702409341, -2.186087569879437, -2.454842272103436, -4.502212971768961, -0.8713349234900959, -3.2768751020316333, -3.5651535218795596, -2.7264359819754094, -4.8281191742218965, -1.8272563678010678, -4.760547213132628, -0.831648100400714, -0.24100391791555284, -5.533000554138256, -2.0835901002286716, 0.5720520647454534},
    {-4.718446137148402, -3.371441702925174, -5.340856913373256, -3.0120471532466944, -2.486896415263302, -3.755476547633925, -3.1207817158487465, -4.719488997526402, -3.671015234120747, -2.539946453390349, -2.8772902797378763, -4.450601436257714, -4.957978705187723, -3.6970972588783857, -0.46101983106492944, -1.1078632650572788, -3.874966867639764, -3.7725659514228034, -2.2390763041226207, -5.188453620141644, -1.8987701755260176, -3.1792870584875335, -5.07969659250723, -2.0263181332799802, -3.8636497075907705, -1.71037058508377, -3.5268718594788666, -2.6097474333952597, -2.574698780162213, -5.64871877645517, -3.0227013448480977, -0.593698177420124},
    {-4.146139905487194, -4.239057284779884, -5.7738840657097645, -3.2093871704518544, -1.747100105138291, -3.289810352286523, -2.995036832553672, -4.665661384194796, -4.778330864859801, -1.8527651013882704, -2.688492614543751, -5.254027636095756, -5.716763127925552, -4.546653523685869, 0.38698954162946914, 0.11990570800491304, -2.3328195705239914, -2.094190327693787, -3.4063513547922692, -3.897621870802106, -1.449277276307122, -3.643740681661127, -4.1426563457630285, -2.844218102968738, -5.064525689381954, -2.4779214005219607, -4.413429241321146, -1.0385536095355037, -2.4181906915853855, -4.900356579022616, -3.1267208500592902, 0.2034396888417127},
    {-3.5046604214202284, -3.80311501437246, -5.367303035781116, -3.1509621947775472, -2.65097848450721, -2.9191989262938796, -2.8164900514741564, -5.540045073638391, -5.023560389976432, -2.2205892009420114, -3.687529105966417, -4.386013130645577, -3.436272867785743, -3.2323842516040884, 0.5080483601610236, -1.4604073660011665, -3.82609764194531, -3.759666151972446, -2.9025877086738467, -3.833119321723648, 0.04223171324297299, -1.992432623883875, -3.71738686612704, -2.3676857290746365, -3.1857413570796247, -2.5286301972416214, -4.166498753251326, -2.6633005289178238, -1.6069683451929007, -5.1594634962054515, -2.847985479989899, -0.42720728815984416},
    {0.6071911034097544, -1.436572021346191, -0.14786619503337248, 0.8250974056629886, 0.35125670663293906, 0.612525091348247, -0.9419996892638522, 0.7055709511054601, 0.5964945406088205, 0.5162865725784909, 2.203877876864481, 0.21349413650322868, 0.24070372308693241, 2.2821462977018667, -1.6610611835900442, -1.9767259654144769, 1.966115232780458, -0.0030134470233147267, 0.350894394331859, 0.3842909293142143, -0.35486010735107465, -0.9555252848710527, 1.077802832287667, -2.105802368778524, -1.5605395493688015, -0.31015489025562076, 0.5238248611540025, 0.5514702408469528, -1.9562499350547182, 0.8133497009893187, 1.5339838628974425, 1.563675025074103},
    {2.19688822045424, -0.9500307239016329, 0.8309822149533752, 0.5619505684175411, -0.8589368151047065, 2.3237309048648234, -1.4275721571799143, 0.3830530511549547, -1.3748449052838914, 1.130584518607372, 2.8270871846285615, -0.09034187579543536, 0.16570936719086965, 1.7825125264817787, -0.24261932583313445, -1.5482504766148726, 2.4969456716812424, -1.261420446909242, 0.951054040776172, 1.9714959794230689, -0.563696420750968, -0.8320661270383414, 2.6269796842351187, -0.04403728120751713, -1.4059613514115459, 2.4028340063221254, 0.06309299712313503, 0.6478281008820963, -1.7323733347253971, -0.6664622932287765, 1.8140762422410939, 2.2141803303005863},
    {3.1664978394973446, -0.29542663319617773, 0.841876109261585, 0.732744649086998, -0.8686523724131895, 3.108579111561684, -2.2686818986034325, -0.7161443877034, -0.14412022918327014, 0.4533467821786359, 3.3558329949979804, 0.09232746116678961, -0.058696297681218965, 2.6183985000748353, -0.42762377032160237, -2.899676772369655, 3.9073405840851962, -1.590207353324745, 0.41700187849706516, 1.1932250562205193, -0.7777931274448736, 1.1872937221406668, 2.1678629170052135, -0.8903706029299884, -0.7424797228402508, 1.9030335811416637, 0.9656042283031079, 0.7083856934480216, -2.606288485210644, -0.4067027408474928, 3.4407196573925773, 1.5759741418054571},
    {1.9711889099631512, -0.2763826441831824, 1.472424871237902, 0.3253624599426132, 1.297774460240656, 1.665121797805498, -1.910442776215442, -0.5780699587353035, 0.36529140303162283, -0.8938186620269327, 2.7662563372861984, 0.19335261053974656, 1.0711404150733195, 2.279762037307939, -2.4795394769116696, -2.5453241914588323, 2.790142600933185, -1.1361964265325168, 0.6264909516057137, 2.616883217610609, 0.3882158723312772, 0.5295629063889542, 1.584246187383587, -2.137537572850048, -0.1206511390828724, 1.4875050007857926, -0.13458461661316237, 1.1636175376568823, -2.555556137669064, -0.49262963313718067, 1.7595629625172664, 2.6881283313435427},
    {1.7294682012817795, 0.1854205262640914, 0.8046694978463859, -0.29269679979135943, 1.6614259907965363, 1.4206187983711183, -0.6450664403285415, -0.1999370816508905, -0.041978545520760586, -0.7606746300784851, 2.3621117255259074, -0.8870524716093888, 0.07769217873392228, 2.3536300686503555, -1.5020349153430854, -2.106198427181776, 3.4476439416594915, -0.0044761774542445955, 1.5587175183663688, 2.5166605186723943, -0.5932777076120033, 1.2156562249009053, 1.509806346491161, -1.1375336537571035, 0.5602793832213262, 2.112665162639883, 0.43338891207760505, 2.1885918090998775, -1.711207242768777, 0.2352945037077496, 2.0559736632428316, 2.338344793574478},
    {1.8048056512600885, -0.030966760599202642, 0.010319357753379327, 0.1158653438414157, 1.7185199120296017, 3.2639921984272644, -2.7704662066899903, 1.142996232384061, -1.766861402317017, 0.5127679054670564, 3.2139465480225793, 0.5473629506332225, -0.6461313061786093, 3.1463538149547183, -0.23511515134685232, -2.443166621665422, 2.431237911838072, 0.4365472626445729, 0.5009782041048894, 3.2923961393025327, 0.2711732848859835, -0.8089866438709935, 1.6880975072159643, -0.32483349057714944, -1.2921147504825965, 1.5519897637640483, -0.019716632853074827, 1.0237541166188253, -0.7713091236836165, -0.007753064530211008, 2.1175810426415076, 2.074789514080912},
    {2.908972313801731, 0.731281239461633, -0.8670291714718705, -0.5781732813035456, 0.6322051780332726, 2.914539596105164, -2.112025932027761, 0.558097132990491, -2.362266656720472, -1.4402284483344312, 2.7027557983910935, -0.9561295263962849, -0.19397654532993555, 2.452172288428033, -0.9806404510939003, -3.681531871093537, 2.8105128445836027, -1.398625850468502, -0.25461526169445625, 3.041412573925527, -0.35590069856791334, 0.35417527372533253, 0.9625678517210157, -1.9397094841540394, -1.7783470991947568, 2.214015730450693, 0.5271363158149333, 0.9460705043923745, -1.4351133870636625, -0.5653225798924788, 3.352727853788839, 2.9089014525860564},
    {3.061262793794481, 0.10194610811444567, 0.0008131017876064408, 0.3815188959700984, 1.6377799073219668, 1.6809264921759925, -3.256996690538164, 1.263828950789172, -0.0892775004790839, -1.2703978172485786, 2.8468093506945022, 0.8480578110303162, -0.3697757797011779, 1.7719595364480638, -1.737214985990138, -2.8326701394892573, 2.7676664071983645, -1.5390110221631625, 2.033616666193932, 1.8384884622112474, -0.31455358807371736, 0.8028482142571349, 1.6126536953338657, -1.320620689814136, 0.43784523723652674, 2.4131751568793804, 0.37165265509729795, -0.9547123041308776, -2.0578824838996104, 0.6272523292250747, 3.9572071754221483, 3.0759468031036583},
    {3.624693334468789, -0.186612792757865, 1.4021452601457787, 0.5226458382412226, 1.5725997676187415, 2.2773114466025937, -3.535050165275453, 0.11075296548492838, -0.4765810235242542, 0.48721692885766077, 2.2553033645380793, 0.4898741738943042, -0.29771011077324394, 3.3353805430448866, -3.1013111753121905, -1.3169667226298043, 3.292424892899559, -1.2420775066683651, 0.660753391454488, 1.4605678034611294, 1.7654350573635342, -0.03158809967218733, 2.617590498284417, -1.735018246366267, -1.224511093490232, 3.352279581053785, 0.7062368857356289, 0.675833237967076, -2.3705569492440595, 0.9652527394872702, 4.391865338176853, 1.7811958514939574},
    {2.8926050502529916, -0.6469214446953173, 0.9550002864886156, -0.08767325741452259, 0.8668497059704837, 2.3879221367570937, -3.5756788558420265, 1.524036622572569, -1.7707140907348218, -0.7006400590227898, 1.9546378913194258, -0.3820486888998222, -1.4177340020655282, 3.0368380636185086, -1.2076539195638734, -3.07077260471411, 2.78916121143844, -2.6013194905631503, 2.1074538024129805, 2.920972531401762, 0.5202784178273558, 1.1015137954486356, 1.3862257146726296, -1.4260042191940365, -0.40397947118296035, 2.8665759921489484, -0.08083814931086662, 0.8524859610214295, -2.6109063002776516, 1.0686208773006594, 3.6727446607283096, 0.9027344607374078},
    {3.0245272020263627, 0.5533970559949452, 1.2931557275803647, 0.11603990165780123, -0.2844524270627901, 2.5149773926759282, -2.5330500348013363, 0.3490699029034029, -1.505680969359256, -0.4398774515173173, 1.3205287378575294, -0.29432923405682004, -1.4710762597020988, 2.8486065014218447, -1.5976038524673164, -2.4095287859723267, 2.888998344403674, -2.6412319995995497, 2.0107435470664097, 2.7258189265866375, 0.02873270372874361, 0.5125899956197764, -0.009953824059862748, -2.6305416665798482, -1.1270751026935035, 1.675978169396026, 0.31182104739369937, 1.4455574597080811, -1.0926268511646018, -0.29044272716433733, 3.155496632360455, 1.1016695641060956},
    {1.9018912718278735, 0.9704421652873261, 0.15583594853312677, 1.416400212488518, -0.9489237372618755, 3.3118917724852484, -2.4232355213882375, 0.34995000213245314, -2.1510530981815004, 0.25784793319750726, 1.952140507748152, -0.9911584491766898, -0.8464647343002788, 1.4459484398258518, -2.0219140111538847, -3.1464910374054376, 2.188746781769579, -1.911863681332178, 2.17487932428023, 2.7249533163891884, 1.304191221739182, -0.3680153674413476, 0.6421040223836896, -1.3326557323189463, 0.06489252586385383, 1.7436448892865886, 0.8520305091414551, 1.591941238008918, -0.7613131250661445, -0.03408637255361112, 2.9377508634277314, 1.787758997720531},
    {1.7760054388995707, 1.352817469259479, -0.5719659854887377, 1.3091664172069855, -0.3016330242003009, 2.7901068540578544, -2.422656128062519, 0.7249440731634472, -1.6276512581491291, -1.0749339970934213, 3.3201364452212894, 0.7040852480048269, 0.2809309949459503, 2.4089145591214507, -2.021113638180495, -1.6062135454809825, 3.6287122982005116, -1.9910934929171906, 1.6917888394764053, 2.923947440345936, 0.4057756757908397, -1.3811433036878742, 1.1970027608993448, -2.894242948305115, -0.07407257217719798, 1.5257164484671255, -0.03109307086896254, 0.32451895248414553, -2.1123293784354913, -0.7481403582989508, 2.200893580808125, 2.60124312119598},
    {3.218963301756623, -0.1162302524782578, 1.3511165403472212, 2.0041653125811454, -0.6160238324667143, 1.8229576868085369, -1.482472149913162, 0.22237289469190444, -1.4475430261390607, -1.921960169207636, 2.790656634064364, -0.3143563888867856, -0.32839420549171533, 3.1481499988781936, -1.571333262183901, -1.9439164603988364, 2.4777312086702232, -2.214816638941069, 1.5437802999570163, 1.8652132779738233, 1.131785963717933, -0.24288903067595935, 1.2051178186930727, -2.1144152700342023, -2.071637279567312, 2.7275266156833333, -0.15502482569272122, -1.1736955007959875, -2.724945273762662, 0.39100392537358536, 3.7188565764087476, 2.6942965276288815},
    {2.4231206576938105, 0.19062467843699846, 1.1608142233619894, -0.2657470608010847, 1.30011231651521, 2.5322742775885, -3.222161257317868, 1.3132007989507009, -1.8175526216491313, -1.9872150804339, 3.136447792907904, -0.666845221380485, -1.4702899129781242, 3.129217546383394, -2.9369036358807032, -3.5872015775035218, 2.537281397991494, -1.867352902324229, -0.2634074258169371, 1.231939880867683, 1.1847093977414507, -0.9289372477339177, 1.0119099727639802, -2.5399993199935347, -0.8507761956898273, 2.7201843286002427, -0.9268485487789004, -1.6124086168461584, -1.7292139840364011, 0.9583568441857443, 2.1512271805228, 2.107709499378634},
    {1.7046387519727373, 1.3757140498444271, 1.4972831843523937, 1.0779128568147829, -0.40962032052849406, 1.7872389278177856, -3.255731073730076, -0.10658949023286514, -1.240844621859641, -1.282406403677095, 2.456043966781536, 0.40134879272060364, 0.006657373448258707, 1.7186394396183577, -4.059779406305226, -3.6695079684962573, 2.2082272228428232, -2.240998314843653, 1.6157994171325787, 1.8845352336790924, -0.5309216346942546, 0.8763909203609193, 1.0886329837299953, -1.463748024383687, -0.02129080874361443, 1.2628249565657599, 0.4697367619526929, 0.15615260887728458, -3.4631632273196202, -0.784775904214764, 2.8397485455626748, 1.68416295941652},
    {0.5426998006528139, -0.15139062131079994, 0.5172016764252332, 0.5906347580254468, -0.28862751381500357, 2.8341423853688803, -2.143083064622819, -0.0579773955301711, -0.8301997822048498, -1.051373888437219, 3.62602408335242, 0.5485711275440776, 0.08568230778641367, 2.689630552106638, -2.9726102568629167, -2.511348820537406, 2.053880562531839, -2.3521703896405217, 2.2123625892049814, 1.4405978690955823, 0.856009895005499, -0.010742597769253705, 1.9900587725418641, -1.464833571790838, -0.32064084323654835, 2.734752188863727, 0.49236427646553427, 0.7637007726030043, -3.0903704668719945, 0.27779231286548445, 2.4627009417182233, 1.7464736466047237},
    {2.364967934038443, -0.5380036537090048, 1.5065130787568919, 0.1995377750795748, 0.9283479313860014, 2.638336327000005, -3.177352401673303, 1.1236130697841673, -1.8582648417718386, -2.012451726292156, 2.521946784876055, 0.1906145196653861, -1.5507408979463266, 2.0854667259921715, -3.25591044124303, -1.535287047768939, 3.8562643822571885, -0.5483349665553378, 1.5260630651991434, 2.4929455067088493, 0.22559521276457667, 0.16128317201693326, 0.8241019097588111, -2.6347740032964544, -0.83847497691665, 3.3592500988286886, -0.7085118281854309, -0.8235473476904084, -1.6513827966276649, 0.7913492995777698, 1.5262707604487535, 3.4063543496806},
    {2.488386132827909, -0.8891569265897242, 1.7961671249633326, 0.7794317670011129, 1.371274117881268, 2.567251591712622, -3.107687144411054, 1.38580656993636, -0.47606788205905665, -1.814758560294412, 2.405465025239424, -0.8067648728579204, 0.1925546975084277, 2.9262966220192386, -2.79744327477402, -2.416698203523533, 3.2393666730016855, -1.0999764195417212, 1.1310854513356658, 3.4058087054141377, 0.7347918863880577, 0.8635237618702428, 0.9276637505322374, -2.155530050100751, -2.119581957551266, 3.452112358429247, 1.7485404261750603, -0.05515636172132336, -1.0463282850580222, 1.3229792049068927, 3.068241913951964, 2.962581478696437},
    {1.5082675601881412, 0.06405473850389283, 0.0012862035349489008, 0.16928833810331753, -0.16788411656259392, 2.4013764682476157, -3.100190397949127, 0.3456393553337771, -0.9322773600568992, -1.2786679672979255, 3.5666633502353067, -0.525841224211701, -0.4571718893564527, 3.1572511359875337, -3.255578587749596, -1.398485186676355, 3.6898066428284757, -2.3133473286766506, 0.30399828073420476, 2.7867159680643945, -0.6620640735286998, -0.6526776382291958, 1.2868593395636378, -0.26347262549120787, -1.022116567300651, 3.1742951590902084, 1.3639061971060178, -0.8324786257805715, -1.881167149237526, 0.5567852058567931, 3.976062193364594, 1.8137325635597943},
    {1.9322296568196824, 1.8841011260077942, 0.37828529625176444, 1.089022911661858, 0.9118738772241289, 3.4083797393555293, -2.998765080720998, 0.9453242208994675, -0.5959521892496518, -1.6962845653694552, 3.056790321062654, 0.03864853672211042, 0.32728008578602463, 2.2249320931481438, -3.019288870435088, -2.169506926316049, 3.693517750240484, -2.730250957888136, 2.5449210639327706, 2.8533368070227305, -0.5261807276743942, -0.7186060778454865, 1.913174143053812, -1.4206659408632627, -0.7317250914090331, 3.2377590011988393, 1.3479031473099203, -0.26994632683670294, -1.8582422642828897, 1.1345395515482786, 3.8164128188035646, 1.635254726554246},
    {2.9978219023168418, 1.055091927621769, 1.4035802119056895, 1.5926304145306587, -0.2347683744982058, 2.04077925335266, -2.942082291865227, -0.23542707505786892, -1.653925475820656, -0.11556471385505036, 4.348137441097828, 1.481964314074751, -1.7337411735200414, 2.8307878514504186, -3.837836712538056, -3.3144339550959336, 3.8449183261179876, -2.1913942832836426, 2.7515798303158308, 3.874783773974083, 1.267390899841726, -0.7036130518238499, 2.773732157342595, -2.3699833654083866, -1.5981044105783575, 2.303397551980744, 0.9637576314820115, 0.7103755872404321, -2.448269429325182, -0.15050339964010587, 1.6811156493687716, 1.3017878411086035},
    {2.2571575256505576, -0.8503521688259595, -0.30354925182502657, 0.9438389425240274, -0.43293418648273113, 2.665259711999889, -2.910416299526576, 0.6075128595677552, -1.2951915667879272, -2.4548933374114217, 4.356782558940688, -0.702415023140966, -1.4325483334332412, 1.9024122072592908, -4.036180285985025, -3.1627877340629595, 4.431542526598725, -1.3956450336363135, 0.7105380939053852, 2.407309043395379, 1.390050746909849, 0.5809331421252233, 0.8775968023655066, -3.145614637400663, -1.3204906046045204, 2.6636502497853223, -0.2113844797494783, -0.528549701038614, -2.2869440149524194, -0.9533586739945757, 3.061855078896815, 1.861584970786183},
    {2.0566746194408947, 1.026885210041066, 0.4665868295277445, 1.22557790710836, -0.3461949945809832, 2.022935062089763, -2.3047218549013726, 0.3488266432523422, -0.46527714450129143, -1.9944008679747285, 3.371318877165757, 0.08929942545029457, -2.051404727402282, 2.002175051207152, -2.9567641715105237, -3.4739285088743475, 4.276738535608601, -1.2173652163959034, 0.9119645775366513, 3.6076310660279898, 0.5383067773335886, 0.18619256904564577, 1.6792710546771454, -3.342004529993505, -1.520713255136028, 2.507206103362579, -0.503329932613148, -1.0603633326575417, -3.5992303607568816, -0.5652783686059161, 2.945101814636472, 2.5887143468514515},
    {1.3184575321285532, -0.448111068564704, 0.25532365384787714, 1.54196771376692, -0.6169099516664388, 2.788859233896798, -2.7074888177799994, 0.3600922660793104, -1.3827318570763463, -0.6854520436268698, 2.682255842603462, -0.376497429432483, -1.3540488500372916, 2.3347864608814777, -2.8251133242796618, -1.8136745910393646, 3.9730529137861677, -1.772575034252411, 0.608687987843339, 3.692507080357141, -0.44965155933759, -0.6665777385106104, 1.6055858195097108, -2.958971078855082, -1.6593436300493596, 2.6799356876718714, -0.44893085974580316, -0.3699845090110631, -2.529967830638143, 0.4161701662597857, 2.4527591872225663, 2.785029919395319},
    {2.1354098926044416, 0.3419990046543283, 0.25567448758825306, 1.369214065701957, 0.28101613512145346, 2.720860626819411, -3.5683064182800037, 0.6614926616411306, -1.1548203033652724, -0.7936564476161194, 3.3154867279836253, 0.17439579749625225, -1.6931366073712542, 3.3336363055805402, -4.331098732635461, -4.200424429605005, 4.5572657389274935, -3.5140362682497535, -0.17140700149389576, 2.4583302724530016, 0.6911308568592535, 0.05081580131383213, 2.5006999923294013, -3.24808529057511, -0.8890935209925628, 2.083408745043929, 0.4826825829710301, -1.22071062128208, -3.9798473155865963, 0.2989741957440704, 1.4546282080880961, 2.97668739728232},
    {3.4274234222873963, -0.9184290291279734, 0.4076901987677486, 0.2941804903338181, 0.06337127165117083, 2.3937344618700376, -2.92749900022785, 1.5490809359564364, -0.399757168532077, -0.7413437882267114, 3.3623876791465186, 0.6531348947946902, 0.11918868155904129, 2.0895193061711184, -2.568438105323848, -3.7860892315041488, 4.584712061486218, -2.5687199587848677, 0.8487819260722405, 3.3363330840089582, -0.1879765899489656, 0.029983733343676277, 2.7209313989679638, -2.714775815278386, -0.6929694428963455, 1.4869003093610997, 1.1052802358839995, -1.361979336478443, -3.2381442549810515, -0.6290388991371553, 2.0385988529661474, 1.5149299185444556},
    {2.193970779515103, 0.11696829575406409, 0.13214950564712705, 1.6221151820820963, -0.6630711890876143, 2.1953671678710025, -3.485862275302246, -0.1805360990549854, -1.359659295731525, -0.6126908904088547, 2.2484111534539224, 0.32921286022841634, -0.5170070432039222, 2.106925909508975, -4.07471868513485, -3.765636125871507, 4.558961891521148, -2.224284185665505, 1.9346090482466078, 3.2329374476165107, 0.8556905080831338, -0.19166583421158453, 0.5642480318626313, -1.2069577643769827, -2.2766253742354903, 2.268425786070086, 0.24721121351193376, -0.3695859348663951, -1.4009634443702552, -0.6509428550173597, 1.7061231599530864, 3.646168024474129},
    {3.251844564916954, 0.8780104783575554, 1.3523831758912481, -0.295810827605454, -1.0517240226474385, 2.8127591565249457, -3.525302851120277, 0.6700942676807704, -2.797123454774778, -1.4512147061600178, 2.8240912933793596, -0.19299333997707396, -2.120736172999853, 2.9107780502489087, -3.9847898298188555, -3.332681560098108, 2.7221098778020534, -2.0201214695533434, 0.01376452360147962, 3.73841617979743, -0.20487934559036827, 0.3592071702382382, 2.25952188647358, -1.6829220472598296, -1.4778957339159944, 1.8752402901133385, 1.0083460227613328, -1.1075637876988444, -2.9996811508284327, -1.1204384045624924, 2.338561628173103, 3.237388894064733},
    {1.3569302272283013, -0.9337859517729312, 0.43246396009278154, 1.2621539340217909, -0.9539925614371393, 3.6342048090665826, -3.4091124295743604, 0.8989920425633482, -0.8370373240134239, -1.8701258431307084, 2.238537558171795, -0.12128387948462242, -2.4209320494757463, 3.6166737876720965, -4.100802551378794, -4.19029166339927, 4.124100544602016, -3.020708230929377, -0.2738613964302976, 2.6180931179726388, -0.24837311716205246, -1.370605604928994, 1.2581071019132821, -3.3391495490111596, -1.22201563092572, 1.2327709475726216, 1.25058032199913, -1.6332860149325639, -1.8051008600789618, -0.569134989391887, 2.8911329318629626, 1.968350654195464},
    {-1.1101344491300207, 0.303133950310885, -3.1378490545256117, 2.1665638187093164, 0.8093156209970357, -1.3250799514127, 0.15134178064696838, -0.9473585852741184, -3.7428392939920245, -3.0978207475415918, -2.461921485802775, -0.8476697102533799, -1.7490677805456907, -0.5730562904452552, 0.04299405546994106, -0.649663369365791, -2.3132244743511743, 0.8145378024761933, -1.756777830709492, -2.3410258593090782, 1.7995002477567557, 0.9232988054894354, -2.5383994078682774, 1.2258265535533248, -0.9036430000627267, 0.4787625093980798, -0.6142959449082188, -3.1432171249085283, -0.258700543520445, -2.3128804571863206, -0.7183546442201064, -2.2530638259235714},
    {1.0307499684151757, -0.4796951623986656, -0.41650514689217005, 1.7714156072811624, -0.32117798571724504, 0.2797752209763982, -1.7387179749609658, -0.0950079253470889, 0.026025023574806284, -0.251274791401897, 0.6281206068555589, -1.1915249772273553, -1.3568519764187377, 0.0822786568070384, -0.23980169474657198, 0.9288057016039695, 0.7455654238790426, 0.36656936626873027, -0.8650883353355849, -1.5885009546737263, 0.610434936125022, 1.2179899262243912, -0.16400379543428611, -1.0664084504947473, -1.3367151452841992, 0.8043048565374604, -1.0394315280623978, -1.2003565079583016, 1.087066439067128, -0.5873476625283165, 0.6024238360666485, -0.012705462647473461},
    {-2.1002967054265813, -3.3658414320942804, -2.981180452335979, -0.7095173205143339, -1.1735449604714974, -2.0996357950549163, -0.28519651855760764, -3.1494865218472707, -2.463454057599478, -2.9633829357001145, -2.975736723603526, -2.2055555847532085, -1.799274130404442, -2.6308558656110965, 0.6173519145030419, 0.282856902860819, -1.807243931230506, -2.6661084437334406, -1.5577497059451877, -3.854709430527222, 0.1523932177082207, -0.3345139325427954, -3.0409526338244777, -0.22964699643269895, -2.3668967319252157, -1.8957323736708784, -1.962430941254872, -2.528484375645451, -0.07362815223878508, -3.6750909030876087, -0.26279231701560485, -0.30036196080816735},
    {-2.206896641640253, -3.084194244337913, -1.7136121457008773, -1.342812751385359, -0.638401019117792, -1.4159245270919658, -1.0928127354496, -1.0201612352739249, -3.308662969539589, -2.7311041242698075, -1.282481373611086, -2.9420884649153676, -2.3791637143400512, -2.4777462835007706, -0.6977407752476221, -0.28791013524465436, -0.28414656141231753, -1.9467620321854502, -1.9304454523129773, -2.050029043114731, 0.36758315350322807, 0.5705244921036644, -0.44103216189738276, -1.3994578721932047, -1.3449110678085203, 0.24403547280979257, -2.7860713895494795, -1.1776693974870498, -1.9161667186167313, -0.9509020135449965, -0.8009742488189439, -2.0240639008655013},
    {-3.2505257475626506, -3.0228187858695375, -2.96118114556382, -1.853188965069869, -2.062930608742154, -1.2215068977670318, -1.412897500096476, -3.2371706124630117, -1.27645582972875, -0.4817604183895787, -2.019275464310682, -2.9452217847059283, -3.276391599846308, -1.3638175414965599, 1.2182692225620282, -0.833867468694992, -0.28359502429751865, -1.788179440419739, -0.34838098520412497, -3.1152792867656176, -0.569310631139725, -2.033624894103061, -1.6090898134490517, -1.3219140103760336, -3.1130789311715477, -0.926444848407269, -1.494700857254979, -1.3485022521113912, -1.825884203144896, -3.1538765275591114, -1.2518496441265305, -0.24325341271788292},
    {-3.0345760164923976, -3.4801013826769887, -2.5541629861770905, -1.580361704805369, -0.4297590034521224, -0.9055466382800049, -1.3838867019564538, -3.026209611046787, -0.8352612672574857, -1.4413757546304442, -1.4224376052530572, -1.1742428326341245, -2.481161967756268, -0.5927690169822796, 1.1982847594176995, -0.7576879762437556, -2.038912116009164, -2.3613259142393246, -2.1839658832356403, -2.4276348036401325, -0.617685407687714, -1.242258373032081, -1.9919094370460393, -2.6623189897570523, -2.1173740934965806, -1.361144999155893, -2.332182227925562, -1.7518185172475451, -2.5678069901536063, -1.4639752449090209, -1.8430002089794812, -1.4529730555236697},
    {-2.4618007904631876, -2.3395504057590335, -2.503808937358247, -1.4825991923926078, -0.621025754436452, -0.9774939209411774, -0.5880875005332127, -3.1356210045409996, -2.337603300573341, -0.8991428892216584, -2.1958000967221465, -3.1171671996319685, -2.5477282667365615, -1.91318246911465, 0.6713511444547757, -1.2455865843832823, -1.9511770493340226, -0.7889392296309842, -2.1319934196438446, -2.5691588926916786, -1.3012442691939976, -1.4015276396197116, -0.8280739753621589, -0.48864815761470337, -1.0604104417682692, -0.9968015123376268, -2.5794637469981514, -0.9685666119196898, -2.8331408817532386, -2.570055899062375, -0.4723145658864844, -1.8961142212724575},
    {-1.355130985631353, -2.722748299060162, -2.0876533940871487, -1.863593437407457, -1.5867024045107216, -0.24567380996548693, -0.9643624436922019, -2.2596137903833613, -1.122951061715828, -0.981899976866855, -0.8128575795531958, -2.291255678167545, -1.7756646651083607, -1.935543416262256, 0.11354974695045456, -1.4314598420336626, -0.6914739558017823, -1.6502032352197549, -2.7148547275237793, -2.2187591856198163, 0.026042040057225803, -0.5833399955423093, -1.4230334664426418, -0.133836348692807, -0.835888825757769, -0.7120385695084583, -3.1322786820047264, -1.2399630964183368, -2.6258999624463844, -2.4519650527936903, -1.244871030041924, -1.8189333613458771},
    {-2.303924710753755, -3.2133680364880965, -3.011974699251584, -1.4576284942240254, -0.9101343291225347, -0.14669782980384202, -0.24065709892202075, -1.753324699598632, -1.088655596233251, -0.35971015771674714, -0.19587874330892963, -2.5645473377731625, -3.047220705338038, -2.484909165871453, -1.4879695227151506, 0.42046948138040807, -0.7408480045904235, -0.44558388796849563, -1.7622601659404578, -2.436005571208671, -0.32335953907116194, -1.2694651473508676, -0.6362703900431808, -0.5522851491705753, -1.3446002195606601, -2.531025564098561, -1.725116104129547, 0.2059543110522121, -1.9308272976597247, -2.168325685051563, -0.08401919345172587, -1.4230613330471902},
    {-2.5749645518942827, -3.309749330021662, -2.4413632162113035, -1.9617649791451015, -2.6887828661712097, -2.3536981217166506, -0.16222298017881362, -3.8813020669332996, -2.61084676693386, 0.02631558712882556, -2.284500233890246, -2.9029013372250607, -1.6146963442608304, -3.207128652285088, -0.5387221130519242, 0.13765225548620882, -2.5016140020541977, -2.4439974381887124, -1.2730555365352152, -1.697288273056725, -0.7028154296235267, -2.4496103702093484, -2.63542043383239, -1.8272331311611552, -3.012866931106033, -2.9034136698914037, -3.840305265985115, -0.8453766443517008, -0.6592293539085718, -1.8557721575083759, -1.4599014576111895, 0.9820323813172247},
    {-2.017981147868276, -2.545547787846097, -1.2987468825141457, -0.2692275265020158, -0.21200233225522994, -1.9526347980004017, -0.3122614430105099, -3.053329653602304, -0.9291798537633554, -1.1844743762637489, -1.8395246770800522, -2.421457357985062, -2.5379364616795286, -2.005733905334474, -0.728851632729774, -0.3844731316639057, -0.8609132919124776, -1.6543181063330727, -3.25240320494421, -2.2021933073630797, -0.8286922296935059, -0.6633784880449077, -1.5509556839705672, -0.7831829396761599, -1.070537675172226, -0.11012863415251105, -2.3793490004756666, -1.0783304652845425, -3.239177942137908, -3.166158496516176, -2.0385187606611592, -0.01577164205571012},
    {-1.4444411744054302, -3.4234504229860745, -2.241661808088024, -1.2679093338602023, -2.8328982727491616, -1.2986628683483514, -0.8200976674797248, -3.292069895962992, -2.3081124291183217, -2.123099743128655, -2.4492673522334796, -1.5763360001472746, -1.515396712525211, -2.0682113780774927, 0.4969219478268524, -1.050747444419772, -0.6424066415138037, -2.49705821076205, -2.549578112906512, -3.056994034625223, -1.2227921320171227, -0.6789505628727719, -1.5842732165787803, -1.2649189561647418, -1.6287391619072462, -1.114436899003381, -3.048869216964137, -0.5790448486497116, -2.4039088930815953, -2.805643216691468, -1.6711160861489023, -0.6524386860436392},
    {-2.6436720306140957, -2.5590694237685034, -2.6934628889337335, -2.8265651388266844, -2.817560541201011, -1.6142684240190504, -2.3740030122641156, -2.9951511945929137, -3.7510589472587483, -1.1056341594002979, -2.250367315648714, -1.5900905221144874, -2.602174797005361, -3.137401952310592, 0.9247512215083449, -0.5652922031165797, -0.9394842275971448, -2.1951194342828484, -0.9093869252085683, -1.6504147924422472, -0.4116031703823098, -1.2644995604284, -1.4432146705493305, -1.3974060818173397, -1.1982143770390659, -1.6845044060942744, -2.8710374921738895, -0.6945133525082702, -1.7772816791672619, -3.1888195299130193, -2.3486200433659548, -1.9426382325030587},
    {-2.376201472760127, -4.020122765920483, -3.893654956106002, -1.847322412592359, -1.4268148541398404, -2.739519086190273, -1.545890656647918, -3.782462023139975, -3.5373592870840493, -2.106179556312665, -3.1177965274242174, -2.8154281681435487, -3.349105921398083, -2.9517517053397, 1.4241897800443477, -0.22591272628189998, -1.574274072514389, -2.4926721377155623, -1.1048321225764781, -2.8996334633729655, -0.43193031759887346, -0.892603929938226, -2.1322870085799925, -0.5673133174113326, -3.91632007528768, -1.1700962638346537, -3.65428206610773, -1.0860278944672945, -1.4709779499587536, -3.014782575880342, -3.4430865737705916, -1.1337616710364264},
    {-3.347376581792647, -2.7165699411235766, -4.148596061603239, -2.432946444433029, -1.9237946551760399, -1.8094176504916988, -1.106692196889646, -2.3647951606417235, -2.3606927360671675, -0.9967462561695268, -2.8927845221503277, -2.086430811239525, -2.0275182817920125, -3.010459553991707, 0.4886821518799508, 0.5941816968846454, -1.8701861867251286, -2.2605341974426123, -1.1241175538795471, -3.1130637994371226, 0.03903307874182001, -2.4412174524932113, -1.85978320204275, -1.504726199723894, -3.449312335012762, -2.3578181371448648, -3.08272070912327, -0.2525997959490953, -0.6794970772269547, -3.912336993851431, -2.744676311195268, -0.037149792223933664},
    {-0.9029101249254776, -3.116255106046034, -2.6476481299500896, -1.284257232283631, -1.1156443940449605, -2.2596279934985786, -0.6550350931821656, -3.6572261184696013, -2.4139666851599997, -2.7058609768818345, -2.3062813179605945, -2.9559516921435574, -1.9098750558605677, -3.6573105448211907, -1.0258873151257477, -0.6654288638439354, -1.4058520936801209, -2.406304448650589, -1.8500639062326296, -3.376989957327702, -0.05367309823016382, -0.8906129814635917, -1.6544356615830285, -2.3166074170281035, -3.49367478972956, -2.393022042941939, -2.097614769825975, -2.541614455496376, -0.7652284437140374, -4.001748012131894, -1.403125730599411, -0.45648120202326575},
    {-2.4085893693842575, -2.624223349002128, -3.2844559864223797, -0.7950007894587323, -2.6711690646217705, -2.695201904690989, -2.6733685360173225, -2.6902057242869613, -1.916852392986374, -1.8932089895061666, -2.722890399718412, -2.50338142674551, -2.947597597285358, -3.699225721098104, -0.388299226865663, -1.7442807989994173, -1.9654231995148144, -1.3085555835878746, -2.0584568907210548, -1.7440058236286031, 0.22095058024812364, -1.6605387091671737, -1.4664874215304367, -2.07394049514665, -2.737583937677637, -1.723741525281051, -3.969088336064566, -0.8216237872630646, -2.46360217438036, -2.0010066378896916, -2.0583113609777857, 0.4905895508660738},
    {-1.2773305472481258, -2.415803305029567, -4.172635661860172, -1.742976422814245, -2.4239039803204028, -2.8370761731403653, -2.3548529104436375, -2.4587736309335186, -4.227796597239771, -0.7916082511689593, -2.6159584712774757, -3.4669287826191275, -3.4995797881820914, -2.1654862504867936, -0.37013430869621916, 0.6609128956608733, -1.6018106164623627, -0.3981276025467046, -2.7829890248969624, -2.5759320646911323, 1.1733028667632734, -2.1568085019604886, -2.6181235918211128, -2.4841937057699455, -3.2642934880333807, -2.5362993642999383, -4.046252389801443, -0.7872349847920036, -0.7957978539341426, -2.3131591141915946, -0.32815761674325433, 0.7977603361447415},
    {-2.0278245617998074, -2.9057361843918503, -2.8224518463189, 0.11183016472950469, -2.051627764215634, -2.1962239264632406, -0.7206440188245443, -2.6883314512257592, -3.5840174117363772, -2.5551672236056775, -1.6375810743924168, -3.591853928406673, -2.839324010200381, -3.5028740738357325, -0.6574845302876375, 0.01604327476574924, -0.891289995820213, -2.597835759371891, -3.179799873902136, -1.802801031157213, 1.472883838997665, -2.05523992191377, -1.8127809786275821, -0.4309128130896582, -2.9816798874554102, -2.142593032588635, -4.303215793093382, -2.454890137066663, -1.5564047847265696, -2.1738103010772263, 0.045341183837195605, 0.05810625455636648},
    {-2.295601282952303, -3.5984417398303608, -4.42701359805194, -2.379925792384016, -2.6436709657226536, -2.6364804068520433, -3.1911425024060622, -3.732052480062015, -4.252378938913763, -2.971880668440487, -2.9774343569571236, -4.2393907222376646, -3.3699699668459644, -3.7184299127587064, -0.5105775027310879, -1.53928072054231, -2.634264533107247, -3.1536165406817256, -2.8788374633284914, -3.3737120219390837, 0.2933649623098318, -0.7768438358129983, -4.0081426955215, -2.3024214149626343, -4.374173017932623, -3.084970317958554, -3.974175605795589, -1.5995659049225157, -1.3112059833702165, -2.7399530569064416, -1.4357343691924225, -0.35596910205061133},
    {-2.4688414828714014, -2.8919516178174995, -2.9661547992928883, -1.2917565210813775, -2.4236742495980184, -2.9409405218215094, -0.5853005364475574, -3.473438348128871, -3.538092900778656, -3.4538432646455437, -3.5641414297345806, -3.8976972803197047, -3.5065597693472927, -3.032340308289433, 0.8972546900477595, -0.4587164079268108, -1.0395219930099704, -1.6353035509013154, -3.5762896122410024, -3.183260041406127, 0.5789807571530948, -2.8112364680804887, -3.679461278445806, -1.4458298917710064, -3.6068066444458924, -2.734259716429655, -2.406112306088939, -1.223200683276526, -0.08018935934818026, -3.2908072525804326, -1.858907317460742, -0.6032245437866275},
    {-3.3545835697750763, -4.320410276181525, -3.6972335979719615, -0.6182442947485954, -2.3838332071131485, -3.7673953192563827, -0.9102259836712799, -4.174801264465795, -4.61293987020901, -3.7645010119929343, -4.311310634704311, -4.89488752470602, -3.0705652582990246, -3.2238718696367057, 0.6319755994462146, 0.3986843205068634, -2.7143183637616017, -2.519240716829988, -4.292132564369486, -3.538874872611572, 0.7973987605895989, -0.8551103270412567, -3.7316844700854315, -0.14872165365383586, -3.887016763631305, -0.9465320778583545, -4.274552490149746, -3.2767253923128035, 0.04316503136365158, -4.390801825586429, -0.97555015764686, -0.2969287440487448},
    {-1.2589244326161801, -3.306211432306901, -5.4417155973920615, 0.49063801583579053, 0.7146107554525757, -4.417584202030884, -1.3979883717336206, -4.752715975650522, -4.051296306337215, -3.3842054397898265, -2.262263610353572, -3.6500200614938207, -3.1569443722544195, -3.528197825378716, 1.9761843980391962, 0.8665690765668159, -1.23452084464741, -0.5746890861171899, -4.559623165706673, -3.35762590566392, 3.4208121249546974, 1.1283755225390097, -3.78641529393266, -0.19858914402372838, -3.076935004547763, 0.6007081665925732, -4.373369016010111, -3.3002942566168896, 0.4120022172779597, -4.645530538359462, 0.26813825878673087, 0.12267086934506313},
    {-2.5066852887591136, -4.2666246663551854, -4.3553641056323205, -1.1567085551572618, -1.1298914556163773, -2.9195553371517184, -1.972036270406016, -4.603257489957814, -5.470195174632714, -4.028794872802904, -2.4385425708637087, -3.6062758042429763, -3.476765467156815, -4.224486789948881, 1.7805468682626429, -1.0413503789625091, -2.9218616144292935, -1.8625810506979221, -3.5899001350230266, -3.6633065126840405, 2.3378983407100127, 0.05798801635109714, -3.7955923590468346, 0.22223593618727483, -2.583238624298591, -0.7801391802845332, -3.4880674346259406, -2.417810084826958, -0.8753647437594883, -4.850444032084114, -0.008687279862283702, 0.18565519151674423},
    {-2.7911575952467627, -4.919614231152023, -5.3616312058351125, -2.0914257872475837, -1.5824476069702433, -4.368439580510853, -1.9330546165237665, -4.161075925208091, -4.139371618835416, -4.53381227831853, -2.261809740508849, -4.786344241185547, -4.454874208303297, -4.63935639071813, -0.0027587596946337754, -1.4564246619437053, -2.9246942578890587, -1.9365206807642927, -3.1942116530176947, -4.63589777010456, 0.47685458289870697, -2.12001817505364, -3.852152838504065, -1.1367172310175928, -4.385486798425052, -1.1656004791029773, -3.1596562204271494, -3.354375004938065, -1.8974011390533463, -5.0899477713366466, -1.2372889048473048, -1.3225330263982331},
    {-2.4358412332676034, -2.4504556129929846, -4.129785241837741, -0.3602457641029142, 0.20264775619760533, -3.7484973100697965, -1.6470137375919762, -5.159635236976656, -5.4753984349867295, -4.727223013780249, -3.061607727741517, -3.9548728082803373, -4.887261582163811, -3.6192194137304057, -0.591364481680092, -0.9380617590161855, -2.4443488201203682, -2.2527614742661366, -3.431280044844433, -3.9394560886529, 0.9131648296232068, -0.6663799593185961, -3.601378554496677, 0.05183573722782117, -2.841123388145364, -0.6162613531410083, -5.094316670255769, -3.525030112575074, -1.1179020950830625, -4.271807569156344, -0.40251779777702645, -0.36369610596193364},
    {-2.069814520440643, -3.5917862676960994, -5.729097990663452, -0.9207351446590857, -1.7912518916373568, -4.672716646703285, -1.388042901794933, -5.345248823976512, -5.523245886072668, -4.949069301155288, -2.3237775219651255, -5.103704645802883, -4.286573671771683, -4.175320657867654, 0.6820912437634812, -0.13760386643840258, -2.601428888255051, -1.3073240983105985, -4.50365683822877, -3.7559462783792124, 1.8038043056568638, -0.9373909628514628, -3.9958471588821816, -0.05458324832949715, -3.1016971720755704, -1.5058036736544074, -3.785055274229299, -2.5639810615007623, -0.018748958293432056, -4.777654000998824, -1.714980458558056, 0.9830369101124863},
    {-2.7296909978162196, -3.543707058654311, -4.637263195237637, -1.8490026497737437, -2.3462065924582456, -4.538451344198321, -1.4983330411107807, -3.6872565018635837, -5.376986469478367, -4.899783728301964, -3.832887736910938, -4.254222422485168, -5.333269830378058, -4.0870351382709025, 1.1085564558471892, -0.1912675346371372, -3.63874727039516, -2.5536674300897775, -4.684142781575321, -4.794975041558044, 1.1117908469888074, -2.244740381542743, -4.017134894406672, -0.14185359105313874, -3.9399655497525106, -1.1774519326061732, -5.053434826408249, -2.8439997725208324, -0.5600139072566579, -5.190059893598451, -0.5140635865323164, 0.3158008034185257},
    {-2.4208296064272847, -3.1955624704386776, -6.1621959820493055, -1.5391316412929696, -1.1983662814854714, -4.760463871017347, -2.7479314881959738, -5.357868174577772, -4.859545004570156, -3.218691910209082, -3.935890899301311, -4.686656616779631, -5.431241692322698, -4.432628896934348, 0.6383920204993969, -1.4373504225343905, -1.7754318991849167, -1.7345238640053704, -3.589476499043353, -4.215130654117605, 1.960296792612573, -1.9964796347197928, -2.8848314866324496, 0.20060625688803016, -3.7758232686873243, -1.0147184238987703, -4.589536009197076, -4.02870020815376, -1.1066456883743576, -5.818982204868563, -1.052437512156838, -0.21948234801052083},
    {-1.8598715564759118, -3.94863469107905, -5.102050809935531, -1.5416995865148004, -0.20167442446636188, -3.345897758504716, -2.3040007217408016, -5.071040549269853, -5.934058399161465, -2.960225844036503, -3.3301764021484503, -4.72076442791616, -4.431124314368482, -3.848533243330095, 0.47524097308350527, -0.29075172270614563, -2.5455612471757734, -2.3417705344741186, -5.392659353726599, -3.7696821815338626, 2.646753458275119, -0.49520647955632496, -3.4407747562788256, -1.1706186748892307, -3.0455002852933677, -1.5080505456928093, -4.41789785992587, -3.3522638167281733, -1.682236403827427, -4.319445274969311, -1.0847025488944215, -0.4645406811560279}
};

static const float b1[32] = {6.867017923395989, 6.8365468470879405, 6.855205520941377, 7.015841720517745, 7.0332854269116485, 6.707291230279267, 6.8697805367411195, 6.759095229482304, 6.871735993338913, 6.666651900343928, 6.957673480659563, 6.72260380040382, 6.749053143862516, 6.994179580794913, 6.981713810707687, 7.162766985089321, 6.6142800029372895, 6.878117106735159, 6.92676414044611, 6.8319964453059905, 6.401157583764929, 6.937020911667825, 6.763836853455585, 7.019383425183539, 6.931427699649976, 6.69857545684779, 6.9203839660187985, 6.6515876697826215, 7.120338502298416, 6.863995632651231, 7.012527608186762, 6.622427703098029};

static const float w2[32][16] = {
    {6.202588143973172, 5.612300655988218, 5.736914681995407, 5.36388832933981, -0.3480589793294564, 6.106100725784552, -0.8779425013097288, 5.0315444007228045, 6.413466372627221, 6.366516130025243, 4.404428082076196, 5.236483334783887, 6.437716592352753, 5.426900977120419, 4.946532237652018, 5.982161276918195},
    {6.279256245163256, 6.157513873090666, 5.7348606440167265, 4.968693305049396, -0.5069698762559399, 5.822626783254187, -0.5629953984681553, 4.970548408411024, 6.342598125424347, 6.355669019512877, 4.40266164978472, 5.2780134605324935, 6.200088978267295, 5.0799639915444645, 3.299794671080284, 5.775419648689861},
    {6.538587804927415, 6.129986622789037, 6.785152425023335, 6.091801712712893, -0.5878771083719193, 6.832148818288101, -0.8998976034006034, 4.849023087508597, 5.5743092122245965, 5.5651839192987955, 4.699414927973477, 5.511827377961863, 5.263787088995107, 4.8765740338722665, 4.192347210500943, 5.534997632495874},
    {5.833473228279195, 5.978054389277706, 5.562208233080057, 5.423774591927681, -0.7982863539655728, 5.720751292202673, -1.0012617848732515, 4.667165855374061, 5.658746233354101, 5.47041866257842, 4.516647097184852, 6.020047013756877, 6.086838328788687, 3.956143558191421, 5.078836454376653, 5.645137298195663},
    {6.060175216770307, 5.01784067168415, 6.30643422101177, 5.9355498684118615, -0.5942151716620979, 5.928230697789628, -0.5231378628488688, 5.449639156473071, 5.28016438940393, 6.389547605037979, 4.603592675850136, 5.9461960632866475, 5.380997987132446, 4.417856741922853, 4.8059513655643835, 4.783087937898593},
    {5.213759908018136, 5.229350975314331, 5.613281661464737, 6.768736528601409, 0.7337213528349782, 5.709787520201994, -0.1147477724951665, 4.132923331804683, 5.979369324298323, 6.597058983361002, 5.8335269786282025, 5.518693144776524, 6.04742410291188, 5.137712947937066, 5.308815170495097, 5.38855961191651},
    {6.016115580547766, 6.784503694056154, 5.659370894426028, 6.950686523258519, -0.43023688587339753, 5.597485473963815, -0.1868386587885151, 5.500058195464651, 6.464505739504611, 5.056958642306959, 4.67944300131741, 6.505088682571295, 6.428338231719037, 6.115664880522148, 4.8575217758420095, 5.887933824577479},
    {4.888304375880311, 6.670432070258363, 6.126416927347705, 5.784031538853313, -1.0231228444839764, 6.206946772335112, 0.7057378581119061, 5.861931407420551, 6.0698264855901405, 6.572897805917528, 4.199026348668461, 5.12465347482024, 5.9484086306782205, 5.869040467271078, 5.324260609906824, 5.995836134416918},
    {5.833069171170997, 6.917498821992125, 5.51067379231988, 6.598140570514914, -0.38328763955169626, 5.860903003486111, -0.8548355500595248, 5.326785667969847, 6.480180772677335, 6.8276141564905775, 4.575076518803523, 6.113867554354679, 7.000350457381496, 5.18060837551959, 3.8798194243103477, 6.718283482999901},
    {7.037732391315738, 5.44116329955027, 5.061434501284831, 6.286395152552255, 0.1146071431202349, 6.023063610853583, 0.0017446396961439067, 5.807208615873341, 6.051289979995139, 5.3420040109698315, 4.657397198482604, 6.546785488715158, 5.339423270535057, 5.924042816843434, 4.457036039230611, 5.575760554171143},
    {6.128925807713475, 5.812841505255704, 6.921304906097439, 5.566275832306299, 0.7758414734111625, 7.0356881082972, -0.3451919472899643, 6.338730210278229, 5.757728972278864, 6.4913104688479155, 4.8620916448880624, 5.423049105330704, 5.808830907883049, 5.424622826661007, 3.9232107204145588, 5.474166362724709},
    {7.060554798130044, 6.060623926622625, 5.492030066643207, 6.71658656423562, -0.4056960967729142, 5.588066803834964, 0.0672213154526183, 5.948566692004541, 6.1769553411791875, 5.562377844259514, 4.709217519078593, 5.62787147076372, 5.165559029896533, 5.043989681484585, 4.962519645791511, 6.52032324737474},
    {5.679557798968399, 6.75538576823328, 6.9812594699960195, 5.529190630990622, 0.1672280434435781, 6.91738398334768, -0.09756602612977414, 6.381844838373826, 5.401884997415183, 5.828491677077685, 6.355713870902987, 6.348364357994861, 6.1742439461230605, 6.248734864792594, 5.567914646983425, 6.826003549698435},
    {5.847867425716622, 6.653579815152033, 5.593450467616288, 6.296915865320181, -0.957824412036742, 5.557011490225435, -0.2692466191636493, 5.226498773927846, 5.946371585727755, 5.998673900839091, 4.695366599174691, 5.413245230309899, 5.47885370998428, 4.884654650514055, 4.927068303238898, 6.646132805186713},
    {6.074361798853183, 5.005847058976282, 4.930386768659421, 5.498928935176647, -0.19719952007845726, 5.698895325185404, 0.048767767026698404, 4.699666886762425, 5.598540527893223, 5.5058148218378635, 4.63447368573879, 6.251530494437311, 4.81066636198985, 5.680587133037148, 3.732181214696761, 5.021888748450717},
    {5.895044184793773, 5.371117741748971, 5.729447486266124, 5.875324435985023, 0.31051880143860716, 6.627779846603341, -0.7002420960391027, 4.109499461548042, 5.686330059213338, 5.547503578865839, 4.736563821434537, 5.976108800743169, 5.028055289396436, 4.717339548156501, 4.946516171927002, 6.374534465940775},
    {6.315810702181183, 5.1499756569118205, 6.924544407743978, 5.673949660098034, 0.34568177276663076, 5.7174240727150725, 0.160663149519571, 5.340926598216614, 5.852542266054321, 6.16510718535034, 4.8587585389182575, 5.326203433613193, 5.303615211833634, 4.715242526563314, 4.865481550407802, 6.571268536562917},
    {6.321760428489482, 5.807248589128015, 5.819618501086363, 5.3187547934331185, -0.5220888019219915, 5.4882806301321425, -0.3346576433584914, 4.418054294238085, 6.580747539001995, 4.633849829480978, 5.448607895518224, 5.066580535029511, 5.993247242802359, 5.394722069323833, 3.814612874219294, 5.519047942743121},
    {5.764468146246326, 6.450606463490499, 5.8600928985955205, 5.309677049378487, -0.6827922863629597, 5.378714338912414, 0.35332186312224256, 3.888695083516861, 5.98953363329867, 5.736022519231548, 5.6136812058753245, 5.06526602701761, 6.319951588924818, 4.701983793204647, 3.7953850638146975, 5.126360074658247},
    {6.098299310112668, 6.56087390110825, 6.314768181945147, 6.699982578982111, 0.562702694250631, 5.516499862732052, -0.37645560831395514, 5.338829726326895, 5.676551329804799, 5.862973085354673, 6.137017499704994, 5.348123898814933, 6.142003958879645, 5.0166617209381, 5.20359837230152, 5.844027424100998},
    {6.786128805270814, 5.430518248882598, 5.605990804651141, 6.752249188767215, -0.006790063481818939, 6.142918322996652, -0.498794038432774, 5.65399571408635, 5.3344765837239345, 5.1904389402635225, 5.480737726327296, 5.912256116501847, 5.423370072364829, 5.93491786767568, 4.844138704321922, 5.5825513272346905},
    {6.683391847054752, 6.26246990818086, 5.9377283806158605, 5.750285639139513, 0.12538391500274998, 4.862344280459343, -0.12986268001302315, 4.838261280816393, 6.591379787704114, 6.704610756888758, 4.749183789882368, 5.1620060672532455, 4.984156298401866, 5.498882044932391, 3.937222128292981, 6.380520278271786},
    {5.371248185140987, 6.746538872311048, 6.1070009723963485, 5.258425172877076, 0.2740919607353148, 6.329697010875993, -0.5277697083357332, 5.297729729252126, 5.773724142662433, 5.886207263076382, 6.035358940825785, 6.13519953611147, 5.305614739643795, 6.152275049266886, 4.176704920316068, 6.0041847927649385},
    {5.258114749169546, 5.782979388191851, 5.929966632759218, 5.507609729102588, -0.5337053507700364, 6.40026100962141, 0.03353700237622098, 4.527268699914681, 5.32763468787217, 6.366051598175619, 5.041860306572046, 5.418393313605747, 6.104294841115719, 4.4460090904516285, 5.148249983359387, 6.729988592447063},
    {5.483370873693343, 5.638618440153171, 6.212688381505585, 5.261270183472017, 0.4799217633263649, 5.927609035704086, 0.008546386620549025, 4.961830048772117, 5.391903263256531, 5.918508206295023, 4.44490970153058, 6.6936269559217845, 6.481821902724095, 4.141422982803446, 5.160902897808708, 5.261591766513886},
    {5.756460046055694, 5.212955416272697, 6.734843933984856, 5.205820168788386, -0.8552802653319593, 6.053890162669407, -0.523790256262172, 4.855136585800148, 5.756044650073561, 5.006188840735594, 4.114848953147362, 5.898033781039752, 6.649852559612027, 5.748218732366921, 3.579528063022349, 5.797026700491318},
    {6.9486468139847775, 6.614653346959879, 5.80750316196148, 5.929458849801422, 0.7656948815400598, 5.911740518201265, 0.18628749022957045, 5.0933195300939476, 6.5925925278969855, 6.614061215028656, 5.596991376740526, 6.903298678541426, 6.901933245528755, 5.727211107661103, 4.493746982670543, 5.202416216368507},
    {6.037218080557686, 5.624590622138568, 6.021414786004273, 5.293163666829891, -0.790623106103786, 6.775480919976868, 0.14802307775938572, 4.797749995083836, 4.8114006099889375, 5.041617801717846, 4.326646023001867, 5.903327530047947, 5.567312808419291, 4.718946110840636, 5.069770307695377, 6.263570738625682},
    {5.713613157999653, 5.630524372235052, 6.300356539745927, 6.958343558360247, -0.2820943638909554, 5.347575883107794, 0.09763267304798459, 5.741008343528331, 5.475810536850284, 6.544015899269451, 4.587752055138622, 6.489593941579655, 5.4914275044084455, 5.212593139451269, 3.7759739352154296, 6.44983782835565},
    {6.760467276458491, 6.1420044571989285, 5.987175002538566, 6.136977762357144, -0.949592081155101, 6.119966198441576, 0.6693809569666573, 5.854822379428361, 5.08395486197023, 6.369468893534575, 5.745439349898323, 5.199608752659514, 6.616992628422717, 5.499971026307114, 5.157160278744209, 6.4774930942969045},
    {6.478335371888014, 6.875827986249161, 6.020262790325719, 5.271250839250091, -0.700039890572294, 6.5866644283393505, -0.2573223011206428, 4.368549645662427, 6.656108466155554, 5.166771741046677, 5.242625936333185, 6.192561510805522, 5.995135171391352, 5.383706639202417, 3.607730911745945, 5.427228437989307},
    {5.464799891215472, 5.239600508397051, 4.952418110816879, 5.964033974428824, -1.0225369071916943, 6.756334441345502, 0.15903433525717312, 4.823936160651134, 4.816034907996254, 5.583948058475448, 4.096144591515621, 5.014278112402686, 5.303344719503132, 5.715124007509203, 4.587499405683279, 6.341320728817526}
};

static const float b2[16] = {6.29404269461152, 6.337257862250321, 6.392239475305202, 6.4203875575454, -0.13212928310447433, 6.435443490486632, -0.33029949741248044, 5.942937825929205, 6.400808529803968, 6.203562741268906, 5.998581902090016, 6.309796838583725, 6.283555654351214, 5.877720397787168, 5.363943919896453, 6.255444272834437};

static const float w3[16][12] = {
    {-4.414199856504794, -4.637777602018272, -4.620561043958074, -4.191184957610283, -4.442832185192046, -3.3096023424080165, -4.8331771041677545, -4.692175046264591, -4.064432659722993, -4.505955220287481, -3.6929963708735802, -4.5363698066592875},
    {-3.6075746016888695, -3.3625573641671855, -4.3338744282304935, -4.134414391319162, -4.563261712203005, -3.5033727662125678, -3.2419423644247343, -3.1470140006783036, -4.654621606411815, -4.253170393585082, -3.8973185939665935, -4.330258340136978},
    {-3.518639460928471, -3.549219186559817, -4.242580276070482, -4.285622100602853, -3.3726116663100734, -3.5502533892853774, -3.606476551297553, -3.62436789089643, -4.381180033283977, -4.441207621511404, -3.8126322738362046, -4.335631088413156},
    {-4.449896363083986, -4.4993731062650415, -3.860102390770869, -4.6433867629051, -3.988354630657955, -4.251999214596434, -3.901849919496895, -4.276915953717143, -3.3620585645799137, -3.512140800760062, -3.3149933047974924, -4.148819198011198},
    {-0.22595976602948906, 0.8685266314405761, 0.22756323080343543, -0.7753488177330029, -0.8432138628367368, 0.7663545508227043, -0.22289332675958048, 0.7564440098844766, 0.5236844113673413, -0.23255803040517636, -0.23567424345343943, 0.7197270833948819},
    {-4.566512479457687, -4.004742742894644, -4.65444424817092, -3.509513637516831, -4.524234462420608, -4.445493899265398, -4.238104970179668, -3.75528543367797, -3.330525668170988, -4.662619435557056, -3.9593058888937485, -2.9908286813751075},
    {0.13353339500185885, -0.2852328768831807, 0.7142159406984516, 0.6357876242489618, 0.3384009288354669, 0.1925588151902248, 0.4403349793957004, -0.490444088813621, -0.20291064739937514, 0.37669625357972064, -0.559081956433722, -0.7194582723474987},
    {-3.0355301142247146, -3.56741525109787, -3.831608810605871, -2.7759413556256325, -2.823835647634655, -4.242828306229706, -4.011606150830516, -3.9549289043578626, -3.3557548186196673, -3.7826270750580493, -4.177129215089006, -3.9853976155205193},
    {-3.317825322116373, -3.62773667508955, -3.6557193617329635, -3.534261769580646, -4.130946128572221, -4.8986327423173535, -4.9356174009718705, -2.790998467331696, -4.7448797021315166, -3.3057588536531384, -3.857014523670399, -4.2911672647826675},
    {-4.696475622381043, -3.941655495043214, -2.874143626737773, -3.8855405161266687, -3.862544412408485, -4.607837032269081, -3.429746707628571, -4.293518233195725, -4.132052824438738, -4.590944441552624, -4.7224699710658795, -3.4432448258818416},
    {-4.266048432544675, -3.7587781561989604, -3.5045987545980295, -2.8031055880939535, -3.038449702460855, -2.9299192784809063, -2.9496884996111286, -3.464873429878181, -3.5575452193476114, -3.3137940337783913, -4.14526971807757, -4.279642537109546},
    {-4.86784650910725, -4.486878636758922, -2.855576994750291, -4.742289132084448, -4.058946934318032, -3.8329183399338147, -3.3985830877789356, -4.118056635133487, -5.127343463223512, -4.645193231328163, -4.02095322731363, -3.552395119731837},
    {-4.296874375427624, -4.346701241434426, -3.4413220560154434, -4.305688168248725, -3.8099774269892035, -4.724838753156026, -4.502694847742382, -4.55436950553603, -3.034848675923409, -3.1213622323962453, -3.761581839255459, -3.4693247379011374},
    {-3.5139296725968614, -3.4218911793386972, -4.431961007790708, -4.613691000721474, -4.0597608946250086, -2.975743732558768, -3.435366855559841, -4.083287554441734, -2.8496439472593873, -2.9220112705960224, -4.239988329712208, -4.543461349229727},
    {-2.67744152575915, -3.418815233740844, -3.5677260723118986, -3.217266047874838, -4.255299824735143, -2.697509737251646, -2.9130059477321857, -3.1719650881528096, -2.97714700973249, -2.752409882497992, -2.0838078910841227, -2.524274069365977},
    {-3.117247128265803, -3.8705309906707317, -4.590337590826328, -3.6947868081841104, -3.562610954659047, -4.307863966967643, -4.914841510473908, -4.5905406275672735, -4.758382260927298, -4.392534810336581, -4.7709795620389, -4.07374904685482}
};

static const float b3[12] = {-2.7576118750141307, -2.821169905987866, -3.259415467366676, -2.857596661366181, -3.127433892349364, -2.689307297605554, -3.00275315767728, -2.944774855253652, -2.267747411206208, -3.1491502530384534, -2.413111633304274, -3.013976371085418};

    // Input Layer 
    float z1[32];
    for (int i = 0; i < 32; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[16];
    for (int i = 0; i < 16; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 32; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Output Layer
    float z3[12];
    for (int k = 0; k < 12; k++)
    {
        z3[k] = b3[k];
        for (int j = 0; j < 16; j++)
        {
            z3[k] += z2[j] * w3[j][k];
        }
    }
    softmax(z3, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
