#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][32] = {
    {-3.150593683075324, -4.210444248464867, -4.434917534869832, -3.1313215261078176, -4.465937046216195, 2.391704966407686, -1.5853422621329918, -2.82933004503776, -4.142137361021648, -4.677516062438658, -4.156295663570674, 1.69459405780815, -4.063972958590085, -3.0239369948650796, -2.1909834476695464, -3.7283881762512263, -0.14433554411205174, -4.261530583914409, -4.320449970929042, 1.7829797336327502, 1.2781768169420875, -4.354725218388274, -3.9729045060391366, -5.29614820002163, 2.961104325516314, -4.556740158229681, -4.280284977032648, 1.3898514807551798, -4.565150459778329, -4.363666423243624, 2.3533254840057234, -4.132061520327209},
    {1.2103980075447502, -3.2723661511098463, -2.888055815110762, 2.934412288554741, -2.4410178038403707, -4.3464405000809405, 1.09876751933209, 1.535729460076183, -2.733785424082838, 1.9963226400533731, -3.1577692674780895, -3.550574198826847, -3.9473845541552723, 1.0828483063600152, -3.483705581450508, 0.8873630501734698, -2.3840699901593347, -3.1581050061857137, -3.1245770605549317, -3.775120047518461, -4.826556182502183, -2.842945936652107, -3.0529740921827977, -2.213821932055507, -2.6237195240157596, -2.4263219859275504, -0.2753183332285716, -2.999068062191777, -1.1703757786399651, -0.23759987828868345, -5.471290869496664, 1.2390066683523586},
    {2.5790813078993353, 1.1344610332680425, 2.038069282080316, 1.3073853840213312, 1.55017580922363, -2.5660991097891523, 1.8371797043120375, -0.4622689894793299, -1.128339005048587, 3.357540941447874, 3.582468016301459, -1.7475546725175406, 1.3343917629058515, 3.904789859782941, 0.8447296756734595, 1.8336472126968593, 0.11250577000060565, 1.495230358530319, 2.2571292108520002, -0.8185540219335977, -1.9838643841576085, 3.4709845349762105, 0.8077032630490516, 2.058333390911782, -2.6246926432600732, 1.7255371050323414, 3.0527270935871584, -3.2546490524511924, 2.108519191097632, 2.2613761905692, 0.5824182798126578, 2.7624088333519046},
    {-1.7296549615770245, 3.897520471385053, 4.555820916150676, -2.333242978887244, 3.9612829715619675, 2.5344953366118164, -2.714478945594587, -2.9003313699549946, 4.146908028088806, -0.7870292476253676, 5.05753977301688, 1.7704554421818952, 4.66559878673038, -0.47780343010727455, 4.182632883762696, -0.08044233295780659, 1.6033028979871256, 4.457170243096606, 5.018780089548096, 1.3673018408282314, 2.81576424994154, 4.756188617914879, 4.050938016644837, 4.290062742235532, -2.814902013567777, 3.3303426694274445, 3.0445720359997708, 0.24536796331475785, 3.437331633224214, 2.083013999165659, 4.419525613596374, 0.1704145350893717},
    {2.8284344943286444, 4.465543687327661, 4.599395544202279, 0.8079385299540355, 4.49143717860632, 0.7853796824858337, 1.013618659841501, 0.035663166184991595, 3.3743176204716163, 3.420210488153988, 5.012475647761624, 1.4888944100676131, 4.977567576999306, 2.8332109289303253, 3.8303858127341295, 2.4282551588837555, 1.7685241679133172, 4.320096399977445, 4.270147504162705, 1.1422164793063316, 2.7589790462780583, 5.005463636116214, 4.433740891955908, 5.232610999098818, -1.166934882211164, 5.3686160157482155, 4.289490195230289, 0.7165974754984257, 4.584413373354481, 4.138391112887101, 3.0038854729591407, 3.0221245321795696},
    {3.856540457251433, 6.635802087359316, 6.627062668676758, 2.975438995701116, 6.366521023394885, 2.570058599966868, 2.9461109292080105, 3.257978452991497, 4.970937206140848, 5.136952656440955, 6.413974345010096, 2.6180299468919275, 5.8938372029739305, 4.184818411173746, 5.529241683556751, 5.349983271297573, 5.572702610810741, 6.517779278795521, 6.456661807689441, 5.760164318859359, 3.9167934191909435, 6.550479621924317, 6.3753246580320075, 6.560940330235089, -1.6392536044168702, 6.452189275589394, 5.922202031628011, 1.9155962355190053, 6.716213771892667, 6.353265772617087, 4.6326712610640675, 5.911784660511235},
    {2.596666336425086, 6.295833194282948, 6.2901575044169125, 1.6968805919265617, 6.332294414469344, 1.5634758033819085, 1.1851915329141558, 2.0283614340775173, 4.758148893216231, 4.368070744968966, 5.419126408670182, 1.141439376068778, 5.928906386709643, 3.3197031823640333, 5.626824665999113, 4.633779541093155, 5.251082647248618, 6.357132485687628, 6.331653892358038, 4.633944252847943, 3.35402255763854, 6.723273321735227, 6.239120368592918, 6.136116023117425, -3.2550408780504116, 5.219961272613903, 5.139728126172258, 0.29064242136634444, 6.568361471471986, 5.962707282063345, 4.504016138535875, 5.3742593580708125},
    {2.1221446599534173, 1.3357070999917908, 1.3875766808196037, 0.6431553222442585, 1.3271512283436755, -2.3864699590200615, 0.943518188783723, 0.21654892366467318, -0.9768084862791867, 2.8804678977730016, -0.6261058732699561, -0.39618276066192326, -0.7050475570178606, 2.694211077740135, -1.2854211378139608, 1.4969752424632627, 0.5651110665572674, 0.3119969885683211, 0.7171694555720095, 0.43790746331212643, -2.150193554133273, 1.0024877417663522, 0.5965646685074298, 1.4649829843017506, -3.1369583067144866, 0.28541192221238393, 2.102103626367349, -1.7752868885055517, 2.101820272049263, 2.3618088830590014, -1.5329688097152308, 1.9848137487631055},
    {1.0154265405412075, 1.527110807275238, 1.8232978348558768, 3.1312589118381675, 1.1885652417113577, -2.6797219308529354, 0.005670663139539102, 1.5052408461025057, -1.2540408020413587, 3.057821879284321, -1.6774442374687675, -1.2822053476412805, -0.6765120019805347, 2.170589568574281, -0.19133993496460655, 2.29620753015464, 0.6429889891200611, 0.9511186982690982, 0.5183785441313937, -0.13181900304638403, -3.2176566107578863, 1.6344150019393182, 1.4335582647224383, 0.2164730607323177, -4.433162870415343, -0.6676623715592142, 2.079143806783159, -2.7324710792220386, 2.037218232846791, 2.464580162116584, -1.6463510877658591, 2.8124253888901927},
    {0.5174633906537721, -2.8583789851367456, -2.7661493816298135, 1.860595684284685, -2.407583706465186, 0.0393690699219051, 0.07467452996475483, -0.038275647080343665, -0.10313333612051331, 1.4901453721490228, -3.2986707594835787, 1.9853508690802715, -2.8800005279003855, -1.4603700185788344, -3.6104510923778537, -1.180219482450002, 1.9888549363976553, -2.5133294418793524, -3.070159971499267, -2.152083415574864, -2.35005546416846, -3.0603204089918044, -2.164232061207268, -1.219973632907856, -0.13990834036527663, -1.9495867058011926, -2.3908431384337927, 2.8750146858559336, -2.1186199821025125, -0.7061973313806857, -2.8624823703716205, -0.8861751221519403},
    {-0.07112084978572955, -0.0304363692505889, 0.8445508115696416, 1.7633971721119497, -0.10809278516043154, 0.4530418820806635, 0.3659336032731248, 0.45139897193704004, 2.1788762637856443, 1.6683469341241417, 0.46287300535331705, 2.3196952134406565, 1.0970853060343861, 0.4563766847373421, -0.133678184897162, 0.5540583199084558, 2.3216922391773402, 0.7853221244764569, 0.14530737624856874, 0.7844049652206875, 1.138336428844927, -0.15642905759835132, 0.607695923293175, 1.1620616418527157, -1.0783007939323173, 1.3736084552689858, -0.7912793023726774, 2.0801129691729128, 1.0123441565540645, 2.014989817575703, 1.5024361599441496, 1.878079001996253},
    {-1.7675148647540544, -0.9773722644446793, -1.6367292842372414, 0.8658309981095694, -0.9481512512628919, 0.39565304280895974, -2.355853593762737, -0.6927155899056987, -0.05641861712769616, -1.7704170626385114, -1.5943097771723098, -0.7194833350584797, -2.1490708737140034, -2.0674316877065726, -0.722692839179137, -1.963512829346519, 0.34899995590165395, -1.468195793052806, -1.2816439944605862, -1.9911299205992876, -2.8838557366745747, -0.44833721678754573, -1.3248890693550952, -1.9633012532898404, -2.2337651765293143, -3.637056121586742, -2.395183186981932, -1.588534370064268, -1.2572752777935943, -0.9174378458990184, -0.9433090450673909, -2.0593202190355684},
    {4.3582701085651845, -1.5736285969198371, -1.9333611213799504, 4.041059160045325, -1.3099950518594619, -4.439420738615224, 4.527271298737201, 4.8505330930640005, -2.8399656978275414, 4.076112705032002, -2.7831147273107573, -3.9721012629105763, -2.728056051660528, 3.9807215833259266, -2.264448779180099, 3.715105857524989, -1.139827703320424, -2.21848586250763, -2.3658870919071333, -0.18329220920794445, -3.8691051804504846, -2.6638673534569977, -1.690714127965826, -2.710489893109805, -0.4335557264775855, -1.3069904465423634, -0.2741796952527447, -3.336424626185713, -0.40625927122870376, 1.6542329624172447, -3.9227481853974635, 4.2782208646428215},
    {-2.9083536277134625, 5.174397237570114, 5.238935939724116, 0.4610455687333635, 4.764764595378077, 2.0643131926062463, -3.130219541910555, 0.4906356021781731, 3.6079912767563007, -2.1983968005803174, 0.8483162868035075, 0.7687023551205052, 3.560447945352211, -2.0099336112807467, 4.808532576441223, 0.7010342113229956, 3.681277906497119, 5.496099298994532, 4.902458685851678, 2.264424081411924, 1.567844261000111, 4.674656429807832, 4.356269934109016, 1.8014329844295243, -4.275933290133961, 0.537275073174643, 1.1215424072113365, 1.400192382134509, 4.225056089842752, 1.5733763181178324, 2.0000426835809884, 0.490620220892722},
    {-2.8583745021651774, 5.966696629523421, 5.852935032129299, 0.864826972775294, 5.269330910750962, 1.5564770753918278, -2.3346028032109607, 2.119223711013459, 2.5402006050401202, -2.16978141354501, 0.19505185380254278, -1.7947881212157086, 3.9905921471776056, -0.6499448365724513, 5.3973693792625745, 3.057889211949065, 2.3235156537671555, 5.86506186245203, 5.030189052209175, 4.7976122573353335, 2.3951200242224693, 5.005103173258385, 5.312244596479479, 1.3351620241171325, -4.349166055513961, 0.7169492375420474, 1.9965639401159267, -1.5030547877937421, 4.82258620648348, 3.450944218716901, 2.410864231069088, 2.8423705510139383},
    {0.1764212563679338, 2.982265534232893, 2.552421019061036, 4.090845799484728, 2.289029263571307, -3.468375558400394, 1.8170104172947954, 4.987866753558385, -2.0988794407211975, 0.8727276015478719, -3.1375806274753626, -4.4758364109045745, -1.6681459932233829, 2.899163754071496, 1.4832283427458923, 3.956230100240959, -0.46078778248985514, 2.3182471642346565, 0.3194460201234094, 2.5342617798925047, -2.3648375351772546, -0.06985847394855187, 1.8565327208506017, -2.5477903015704286, -2.2934954443909223, -1.6509268951080918, 1.0259807546355562, -3.923710773030783, 2.063926029464848, 2.6497873473776203, -3.9448953206591066, 3.7171231606003095},
    {-2.9587565486520706, 6.119553063429414, 6.123730159026951, 0.3006211722688076, 5.725212515127133, 3.110250350840661, -3.3315440939204786, 0.8290017987149432, 5.390430623516387, -0.6466446987174066, 2.841343333198506, 1.2032491040926552, 5.082524101765547, -1.7522874907822679, 5.839741138477015, 2.9061701236845425, 4.776510404960986, 6.252420786446186, 6.059418495473138, 3.646731110152885, 3.3083616186890987, 5.6419021554073225, 5.634632716924022, 4.787166872091147, -5.237170927553283, 1.5269613177249324, 2.634121769558864, 1.5296120764355188, 5.449255911083309, 4.033745840649914, 3.181988137454041, 3.1886918534351407},
    {-1.4300028345449072, 4.961860757729801, 4.876372398481311, 1.53648079247613, 4.678351700027811, 2.9363766298383034, -0.9003152997809424, 2.106681801373108, 4.121365779446999, 0.34081448700798556, 3.491670430572894, 0.7202031932301199, 4.562283612121314, 0.08857209861696577, 5.035764417563625, 2.925035249070904, 4.224602358925457, 5.170274962631073, 4.861435416723469, 3.4300533001096842, 2.001741061000104, 4.624251886478776, 4.83511208796669, 3.4194721914543016, -2.8321854916534783, 1.804600867447176, 1.5899639300218422, 0.5122776919545232, 4.502236610140123, 3.6583099008919784, 2.5426841354518843, 3.1736646408117406},
    {-1.6750654408338046, 3.1728080533710323, 2.9578331428212263, -1.2786920761418623, 2.4755578267776035, -0.03045129185466412, -2.3252212810391786, 0.35282979980659973, 0.8291636401906635, -1.5181274702916498, 1.5363713756310708, -2.383814012306726, 2.038688894764647, -0.9078720065436774, 2.6705263398406096, 0.6937522957489747, 0.9683677810393928, 2.6359428815839028, 2.5873764800693486, 0.39248698193451625, -0.3566370589950635, 2.994762699762406, 1.9538370877376627, 1.1960066842602293, -3.421233424162208, -1.42540528832314, -0.18716477738991744, -2.4609059323857037, 1.774970323584061, 1.802206949544539, 0.7015772366319368, 1.2035379840184204},
    {-1.2303099108726854, 0.7632814995529963, 1.0910171495996757, -2.1318214767135393, 0.58757990608602, 1.4861175173447947, -1.9193550150937144, -0.5843963226922729, 2.8437233976871026, -1.466705417166616, 0.4963336438423852, 0.8141699368196543, 2.0182145768427566, -2.0646223328153392, 1.3219653513161924, -0.5670562507347745, 1.8034786608840543, 1.1108649643241524, 1.839232906187205, -0.8777264494741057, 1.4168140239354916, 0.8701714088177442, -0.07948025573849432, 0.5710487179850164, -1.836759971072677, -0.0016379883319490999, -1.5637020530648862, 1.8311948272885459, 0.30094315872634797, -0.7488482675851087, 1.6935040058336466, -0.6132825676918886},
    {-2.966070624775885, 3.5129083328792734, 3.1953013817898226, -3.045948640131663, 2.6648697059515416, 2.6696085240217275, -2.2694929658963603, -0.8532089422297817, 3.5620377578497493, -3.333042373291124, 2.7240874143970646, 0.6757217175512394, 4.073206866804199, -1.894360703667219, 4.282536551029734, -0.4072132262774975, -0.971689546359828, 3.3978966447136822, 3.432059483621071, 0.7534918382494311, 2.6797687197995703, 3.0549234873727853, 2.5051252025606816, 2.061415189778717, -0.9982382114028623, 1.17392764431813, 0.47769633579260196, 0.4036410169544942, 1.5983367320233983, -1.1623856077457686, 3.156606107358647, -1.1264808553375671},
    {-4.1990444583037565, 3.8453683015082163, 3.509853465174491, -3.6183274975104345, 2.7535515177381376, 3.317969626139985, -4.724973849238765, -2.869247537990912, 4.064548483865413, -4.027665295217618, 0.386013372256063, 2.1715221873717376, 3.711093180920266, -4.3163982084084775, 4.214194695355736, -2.21344547555151, 1.4973210948061113, 3.7342984464902944, 3.820038135581712, -0.2773829641258933, 3.9880160235175497, 2.640598921319155, 3.1513244311963993, 1.817167531133851, -1.9002675496119281, 0.6588927710498835, -0.6141412790363445, 3.64623689011834, 1.221757010588321, -1.6940599102695275, 2.728629544257168, -2.6838518235111137},
    {-3.436029054925509, 1.8857456387015588, 1.2749344898128758, -3.781222248618423, 1.41660935355437, 0.612846116789398, -2.719521966691313, -2.096410118358145, 2.8012770264176647, -3.44781285333116, 1.9635905826905498, -1.207921546547732, 2.860817579098065, -2.432600607629367, 3.2956918165864493, -1.4254052285755083, -3.102644971101316, 2.1968595408136804, 2.4676873053609687, -3.285482377662491, 1.9330045843177572, 0.7633793480916364, 0.2605032012294978, -0.15562551643526462, -0.21655920585468436, -1.1358312696556492, -0.7356051845786655, 0.5179590850798068, -0.16011756395038643, -2.663090082497272, 0.09074711078626098, -2.3662557618584965},
    {-3.1388314532189114, -1.407860417228133, -1.6354128701868094, -4.907536318030058, -1.327523232219705, 3.5276405223173906, -3.3298852721638132, -3.751627577834469, 3.6683073313117167, -3.159190253616758, 1.7764203961001608, 3.564154133718573, 1.7402843178750715, -3.870023238237449, 0.06284269989831158, -3.5429837454050426, -2.4368151303563272, -0.5422626803880595, 0.24782503275378492, -4.3528819001278345, 3.7377723079971017, -1.5042109597154847, -1.6027298468309852, 0.9924775076152909, 3.3471791418113788, 0.5461439795021598, -1.3907975397369459, 4.872181005620738, -1.7068098507379983, -4.045355132367272, 1.0052799264062309, -4.29566719737504},
    {-4.08859179350529, 1.867392771691528, 1.6685735577699659, -4.3465024015566724, 1.0791952587648397, 5.637031598989807, -4.051126710386169, -3.9446009774121804, 5.4402846669492915, -2.9515140117442047, 4.35607294555664, 5.187962355451159, 4.2491285141560855, -3.623235254794849, 3.3508810408485052, -3.4870675205654615, 2.2939535291974305, 2.318869237800168, 3.2833286018314705, -2.374184018902867, 5.382321859057885, 2.3987861095420024, 1.3235015977320355, 3.292918751975373, 1.3159205464746782, 1.6504092653441191, -1.1693844393136572, 5.794586412101143, 0.053911019129805476, -2.5492872104642768, 5.030489715136126, -3.605870884134177},
    {-3.808063738768851, -3.5706477280987285, -3.3227766916552675, -5.370337317559435, -3.277724384370423, 4.497552696337169, -2.900053812508784, -5.398676631544282, 3.261110321406558, -3.457188845026525, 1.7624467234181973, 4.224130758738033, 0.94464045339777, -3.8670096747825196, -1.6907773672842508, -5.020011967419444, -1.5126392000077546, -2.95395777034942, -1.805372482913524, -4.314146414533546, 3.7166046489337066, -2.815380296528845, -3.278536406397631, 0.22748991467697635, 3.388556960513873, -1.821617892952154, -3.414434138927381, 4.598717540855035, -3.8457571827657895, -4.452726559135675, 3.446203893880464, -5.210763312790338},
    {-5.6452806566054345, -2.465855526720857, -3.03704712163472, -5.484516105314153, -2.7672165188804945, 4.42814983080844, -5.283977051825189, -4.960670872533492, 3.506314715000625, -5.201806644049731, -0.32484128756729885, 2.8373386470274693, 1.2551008359039286, -5.647785608765439, -0.266334315159843, -5.551917146582601, -2.3867282539530037, -1.7191711620238839, -1.6816739411850365, -4.138414420504716, 4.181787065609202, -2.781218417676733, -2.48446416322492, -0.711634651312423, 1.8728605344267648, -1.9039449017631078, -4.2980816566076605, 4.439746662575041, -3.809983741007975, -5.172632249444607, 2.76713148980845, -5.825971024482946},
    {-1.1771377899805988, -1.6729047168539821, -1.713964003274341, -3.9423862581405587, -1.6978479947401348, 1.0460411243820893, -0.9412786793366053, -3.181458009862147, 2.9121474370488603, -0.641583216435929, 3.1518713223474553, 1.692919260961698, 1.8850341189873756, -1.2382899800775795, 0.0020716971841460868, -2.476721579299474, -2.231715815042473, -1.3637632218589875, -0.6475335392308981, -3.9969771165506716, 3.9310812862391584, -1.5118317303624669, -1.525113964263658, 1.6365116698974542, 3.157873343305791, 1.9678507347526188, -0.5653365486603278, 3.503695935066503, -2.4279715544937464, -2.3871166617207327, 2.6415224661246723, -3.092875464602684},
    {-5.27312770013854, 1.3130148547631706, 1.1662805940002685, -5.15195963453751, 1.3123186619578842, 5.153664095665685, -5.464486738093386, -5.164472039578217, 5.714407168790363, -4.467409729397648, 3.9115085031132013, 4.271514634868306, 4.327626392601764, -5.295499290664187, 2.871492980230683, -4.0240430835008425, 1.563561232772463, 2.0222783168925575, 3.024012547517507, -1.0608932411475949, 4.691941720385245, 2.2683982877598194, 1.6252460882847062, 2.8013350817412004, -0.43033989472636025, 1.4543809525400506, -0.809464813662921, 4.808109045209829, -0.049999412299838404, -1.7522119035439006, 5.095343794082787, -4.380842878771651},
    {-4.14880207546115, 2.822157542448629, 2.242534229677154, -3.3140748864666785, 2.0218541892911244, 2.9217347844860098, -4.238448434120021, -2.9528183828374606, 4.015432082525925, -2.4569334819103457, 3.048606061888542, 1.8138785610857455, 3.5838764568385595, -3.986615016366318, 3.07190281704435, -2.022628857294716, 0.5874861864062171, 2.8439426489097412, 2.9415394210378567, -1.7563314209453746, 3.71451627356656, 2.3584454616354686, 2.7168995268987404, 2.688246625733553, -2.1185307859968523, 1.4506156404294497, 0.150849266819462, 2.8414989945331666, 1.192700563830321, -0.5415795008492397, 3.0576519568456173, -2.4165276746066913},
    {-6.244248759154435, -4.241624753599503, -4.857450055594492, -6.726543714019977, -5.214886996848759, 3.145337125040321, -5.34579128326858, -6.5680205801664755, -1.4005074164940359, -6.053497569974147, -4.064631825464309, 2.9886406010854016, -2.7616519483197397, -6.426100104459375, -2.5912701375829053, -6.071341368552733, 1.9241378935472764, -4.637740308123942, -4.006352720838887, 1.4701928541960305, 3.00900185974724, -4.699703979724996, -4.635546534990795, -4.560581700335829, 1.669960637896963, -5.37182529453611, -5.661397340286099, 2.8091668209550944, -5.644686999142114, -5.217681848323252, 3.062299190455819, -5.497587368640843},
    {-4.540543745035333, -3.7818056323255753, -3.3903148816807023, -4.716845031476671, -4.735002587436021, 3.182616987698134, -4.9860301917795224, -5.774237864060502, -1.7268354460762345, -4.517550809085376, -3.937159525566652, 3.760501845147048, -2.69801625104143, -5.190206189885572, -2.8714899925282342, -5.602131874129133, 2.408951539756608, -4.151722603588818, -3.2839933306350915, 0.9979264833744881, 2.5786116912433226, -3.9051701891695543, -3.999439906677949, -4.425865613392569, 0.37393689202306196, -5.262281696419108, -5.337973086756876, 2.9737897584165935, -5.023498986294068, -4.632183461713113, 3.575819475817353, -4.886359347236005},
    {-2.4148054925517806, -1.6294701830029945, -3.0397319116452723, -2.0953763053772825, -3.352840641139947, 3.104401150861488, -1.2517863811372458, -3.7728665226055154, -2.64146643865687, -1.8684325882251016, -2.036842322134062, 3.6667754220766713, -2.5459003947078216, -2.181133420514249, -2.6661151920879793, -3.23653042310084, 2.409840360893425, -3.29829309336375, -3.301985666199566, 2.6060698414537895, 2.4968624203714285, -3.1488388455829734, -3.6825035451954067, -3.3716692236673915, 2.6956207784436392, -3.9249965619552403, -4.013647341152805, 2.7188307951395516, -3.876121083664701, -1.9455820642916997, 3.294644403930956, -3.300150922721297},
    {-2.34685577063891, -2.2559085561774785, -3.0616879261866545, -2.15161489782311, -3.4834897135790115, 2.974148051402772, -0.7288673888638783, -2.7016383636600287, -2.7890177209720646, -2.2821366132528715, -2.4498860851392807, 3.0236741816920474, -3.156769720767738, -2.518612940656071, -2.833728103113006, -3.7842771162933633, 2.274781737698476, -3.2095726977389814, -3.4904802488306377, 1.392576319716162, 1.5130868410468798, -2.49901095365807, -3.6852131179867165, -3.077316926111973, 3.2474543711170414, -4.0659760491303265, -2.7804013825484395, 2.724007048865613, -3.60672555387182, -3.662563312841007, 2.5556105223875885, -3.295758706416518},
    {0.41350879314885897, -1.8936949477015868, -1.5504488843453499, -2.292509903500864, -2.000253113935089, 3.1667160436601076, 0.5058727909881366, -2.4604825421947756, 0.8754323118701158, -1.9726346481398018, 0.9727925041433151, 4.016041999898236, 0.3750462840038439, -0.556684733209695, -2.4052338834933416, -2.531027071668327, 1.6265945564782613, -1.9163561194342091, -1.8576342567220825, 1.3223378091427371, 3.3043917665278983, -0.9156650648297804, -2.047647196428591, 1.037194930403773, 2.953472774757729, -1.1576496611176874, -2.1091943582382813, 3.3171017149777704, -2.7663324778276825, -1.8113403464347397, 3.4440334755629283, -1.626838692894056},
    {-0.8424392547976243, -1.7998045725908058, -1.9919017488042847, -0.9035576977980103, -2.8072420808385665, 3.7770414746098244, 0.6105112497584726, -2.3871739496752546, 1.0065273340476268, -1.187074040232919, 0.11821863854034298, 4.292098377746042, -0.22870829910380575, -2.707415564556811, -2.2346779501955254, -3.0659904587816658, 1.9001677909759342, -2.1482286030521003, -2.1298536311682628, 0.9967181040327284, 2.235125428475655, -1.371408171458454, -1.9550328755963395, 0.49718627487607275, 2.428098179813678, -2.0233366075318506, -2.836057072228408, 3.625532145684495, -2.5615378515084277, -1.4571104149490945, 2.9718756366518013, -1.766753349942489},
    {-1.01019230598109, -0.5115623019835406, -0.8213744285171211, -0.9011982370051029, -0.8213314130214717, 2.178758995435938, -0.425402228665959, -2.2167821824083638, -1.3513458696100704, -0.5105965704046466, -0.20958034941300796, 3.6978896143551974, -1.1288144820877763, 0.12391952819097984, -1.4807011070614353, -2.542036511895956, 2.5527129710302288, -1.6679056086335724, -1.5541964254084668, 1.8501138912867692, 1.8956686002517735, -0.4268675037771186, -0.5302180564309624, -0.5729860218528319, 1.4210758743211023, -1.8377164407783084, -2.6599578890768125, 2.290926934394726, -1.5909300736398935, -2.3777755755503835, 2.54634600790935, -1.7392169335711853},
    {-2.5649630718737284, 0.6053274992540255, 0.9307509093491618, -1.7186120155210238, 0.9049793036534524, 2.765515689146004, -2.418733213216992, -2.6196739573941534, 0.11618962455689659, -2.6845818300463886, 0.6328260369527728, 2.6334706998261495, 0.9651683169643589, -0.5158932589340001, 0.22259638363243056, -2.8592214970769287, 0.8280346779085397, 1.20060581610528, -0.6961543900263988, 2.4732799554893776, 1.632391587088707, 1.2727083216799542, 0.8796109154647399, 1.1934710160258803, 0.2204247073523844, -0.08963774148106607, -1.0932014358134479, 1.7516091791386503, -1.2960848613504858, -0.9432452940828524, 2.638258221102269, -2.7750447093257216},
    {-2.347862147882287, -0.2511893114033335, -0.06567051499512765, -0.3010221625488117, -1.0434052594309562, 1.3271114842502243, -2.061182058930199, -3.1746007096463047, 0.7669708550201052, -0.9831363455295627, -1.9875560734934288, 2.6027687136827335, 0.3044911464578955, -1.3628488233070513, -0.18848944393768738, -2.017135470332051, 0.5786919317563836, -0.2708671143749588, -0.9479233464492355, -0.566463686805941, 2.126285999457464, -0.14980464705483518, 0.1057948825611922, 0.09325751115336389, -1.2306591592665699, -2.4711091829125595, -1.273333424622416, 1.828844024063602, -1.6406018075217015, -1.0318130692018166, 2.0625658731520295, -2.0654089073916593},
    {-2.29409629869738, 0.1036594484959997, -0.11263015192596226, 1.4358136829007178, -0.19965809768858458, 0.2824825374153228, 0.3984479796883029, -0.8695175839881879, -0.4062275357847697, 1.3728265977516594, -1.7180591154416327, 2.2975334626547554, -1.7642560335417858, -0.33163420307698893, -1.303669971582717, -0.7250372084710044, 1.1523263562341715, -0.23845702269060362, -1.4230895661297904, 0.55998008436437, -0.19436748586970812, 0.6125430679275882, -0.6679257969639354, 0.4848426923738238, -1.5252177636783464, -1.6154952931595243, -1.4487779384688233, 1.7416003059613572, -1.1207427886505505, -0.8936759275601374, 1.0815587307242183, -0.4380862399173851},
    {-0.14743680744144821, -0.7935507032434187, -1.495734459808194, 1.4330348221615952, -1.5629580567273214, 1.2921767689364572, -0.3238660237515553, 0.051757481908418695, 0.021231932874792612, 0.019726436824975945, 0.6878608703107236, 1.4776515987845096, -0.4893491585553421, 0.20210936520959924, -0.017489349594340675, -1.790127795811105, 0.795794239870113, -2.093004479680612, -0.8627291449200093, 1.3546491955128936, 0.4905222595905122, -0.8683676019366328, -0.30116640489865076, -0.5341631038936654, 2.5191808204442254, 0.04860253778339796, -1.3562366162316948, 2.102040630397756, -1.4226092789357832, -1.0326766284446869, 1.070058655064791, -2.008951063774355},
    {-1.6074655250509244, -0.2875855501456012, -1.0229089318226707, -0.6257087671457005, -1.1905146991924263, 0.024428191834011265, -0.8048807971589462, -0.6974013164773434, -0.10948427844945373, 0.22282646815889948, 0.8473903528958925, 1.273356159210765, -1.3644440961429412, 0.3505901327292767, -1.1773015417338535, -0.043807436658517995, 2.105633130438869, -0.8696945039738984, -1.4691731400322758, -0.2550390335921387, 2.0520557480757704, 0.1842628495522571, -0.8832204381040735, 0.2494756655322126, 2.2196051644466195, -0.46458968525639305, -2.7814332430455178, 0.9035902504497362, -0.8310496479710361, -1.6040380233033134, 0.8930566855174661, -1.9791615055006935},
    {-3.401740948312118, 1.3195577138724488, 1.341196304668929, -1.8049697932188429, 1.4095718926428131, 2.4823189182070666, -2.225013934231681, -2.7336390191201168, 0.9931862487228635, -1.0760007306017592, 0.6487074338878868, 1.8392831772866005, 1.3193895961610278, -1.8759564523405015, 1.8257097025932514, -2.1168511159539745, 1.6705185924871668, 1.7111714979431687, 1.3334695613876706, 1.9588880268533222, 0.8170054044022564, 2.0163902750975993, 1.4113065629513477, 0.5188686548949946, 0.0848875217394625, -0.10074591069663716, 0.09012338411213473, 1.305514848529599, 0.26187376777693566, 0.23309598085983646, 2.1422660170033665, -1.2841334503197623},
    {-0.06878172661570071, -0.2444765179054772, 0.2383415871817568, 0.8086634949379552, -0.26603275302148893, 0.12621457578726406, 0.26885792302384526, -0.7074397548642993, -0.4985213566296111, 0.023511090599056192, -1.2562400656297126, 1.020718480484055, -0.4570572248787499, 1.3836749569955202, -0.5815376264255145, -1.4099890164739572, -0.5766591696010221, -0.17549206412903492, -0.48829398700330345, 1.2641714063907405, 0.8901826319656566, 0.04688264241367972, -0.179575830596784, 0.013351796900756236, 1.82132444424945, -1.960540821862777, -0.35527591537446496, 0.7219814208306077, -0.6637648415318095, -1.244723182852016, 0.7505482484042945, -0.14253945862812384},
    {0.48141535503519073, 0.3736867561534722, 0.3819591390975501, -0.4926072414929857, 0.2519973902189477, 1.9182079786690143, 0.2651100977297315, -0.6608834619620986, 0.0755687188829691, 0.13519109741931828, 0.07823940111944644, 1.4930290575710874, -0.714254839573727, 1.765344048359802, -1.1932531075427137, -0.9041057205657107, 1.5226061680885574, 0.485412698856143, 0.10147916264662539, -0.2324381972914921, 0.5097183822332694, 0.8641642290449602, -0.1776097426890534, 0.34842276790715215, 0.15245328694615953, -0.6963707956460992, -0.183124379299912, -0.6890636084956162, -0.6201163292967538, -0.22506110749581235, -0.5887672334347425, -1.1316610158932445},
    {-1.205259222321016, -1.3677352951810156, -0.8787118667666265, -0.8386107423608884, -1.4309167549526942, 1.231112528887773, -2.991457557206939, -2.3693663892925017, 0.8313675547464766, -2.528989732649728, -1.432541041093681, 2.0632219715063966, -0.43675251564803785, -2.474133876796802, -1.8650424047936123, -2.0340617286028575, 0.924128064356589, -0.6304780535658456, -1.1963112197545658, 0.30004567378754493, 0.4681226545520439, 0.42910962231569955, -1.831913229556156, -0.08354965864246437, 1.3753521065519043, -1.4797473576657232, -1.5358554026260718, 1.418999948280646, -0.7261249544064463, -2.0175868815588265, 1.3768006778387292, -2.5038797776917856},
    {0.4094940778957135, -0.9863676962105682, -0.5216542777969149, 0.6155275859130271, -0.5041189905110841, -0.40192200500001773, -1.5831923340619245, 0.5605019568192253, -0.7103453579685188, -1.9284026218580657, -1.592987229780261, 0.24547082546413573, -0.29391055041885683, 0.10975060260221715, -1.223322409249405, -2.0293760899146522, -0.7338304694476656, -0.7669956939543388, 0.36898989108927444, 0.07547434918917927, -1.4851431751043023, 0.7257445623100848, 0.1631991585415492, -1.6392014271811914, -1.8119044142116902, -1.0548081602892134, 0.4747296401309507, -0.9607648917973804, -1.1380928241257469, -2.112707359670574, -0.6510635679155524, -0.8414017677158818},
    {0.8468315650061293, -1.7119727982487258, -0.8840482938475271, 1.1248946332815217, -0.3564107672010682, -1.1997352881466201, -0.034015494931572465, -0.17384749422175325, -0.4386113760923599, -0.01663433990316847, 0.02081077797957997, -0.3813353625147009, -1.5716896734167165, 1.2827792041632897, -2.534149597678525, -0.9672998683029264, -1.3871640757315518, -1.4173956995751875, -1.0588436397808745, 0.45612379408347825, -1.955606742200023, -1.378294707774054, -1.9690066162286648, -0.6371633222305041, -0.08447636990508493, -1.4945977679742302, 0.31637976557645425, -1.91523364869181, -1.511594670090365, -2.0458616220333408, 0.2706053722336064, -0.9512132528172117},
    {0.921639637798737, -0.20780128094547856, -0.15211255887228817, 2.833036391468335, -0.311527677950347, -0.25046905622487475, 1.5524370892171544, 0.5767246484312339, -2.5484278298696528, -0.21646866887112748, -0.06278949885363463, 0.10575321125476998, -1.6462015705350135, 1.2660508030898592, -1.1420784296190643, 1.1226832988293531, 2.275200597442702, -0.9653289260075092, -1.1903157717945902, 0.9318457226490506, -1.119485955117829, -0.442142717041136, -1.1067362942629397, 0.043631646627054585, -1.694345946454559, -1.5264237391163311, -1.0536359146267575, -1.011166301456678, -0.3957794848995858, -0.23239631952250134, -0.551907905269432, -0.8226375057177763},
    {-0.06346906571078365, -0.9806622639896434, -0.3234089542398022, 1.833982792240334, -1.00670703507676, -1.68274738831577, 2.320587207980709, 0.358006766637672, -1.17799139106718, 1.4663772129824082, 0.3070193723607398, -0.350567148219252, -1.2272938064385635, 1.3840895918682983, -1.3161702500679637, -0.2809208803583237, 0.010480844707441886, -0.6193123565538435, -0.9974176450733719, -0.6295535284126669, -1.8224457418316184, -0.9101664266857281, -1.3617859863887083, 0.7444627891581451, -1.0570503893314949, 0.11500425889545553, 0.25367411791160577, -2.1229229349451284, 0.07407940666895296, 0.04808382450907596, -1.0785012854685425, -0.026217651617814943},
    {0.8989066126556007, -0.8042182683557345, -0.4595128788308532, 0.7938215139316908, -0.1739472074609062, -1.444999254616327, 1.4035082363301594, 1.222714451473285, 0.0063800525454442, 0.6235041111050449, 0.3027281271090708, -0.0951931141034617, -0.17576689994305045, 2.205367159339298, -1.0198003237209754, 0.7424111687804624, 1.6632466387776268, -0.46966896740742325, -0.3575207578883165, -1.7026002244204999, -1.2125977006921633, -0.8877857416653447, -1.5381063008863105, 0.3844680261519382, 0.4386461732243503, -0.4581823324734272, 0.280888743675265, -1.7845552323362044, 0.1759458996772092, 0.940198366728513, -0.11953640837428592, 1.2785471216757427},
    {0.06716303857059984, 0.016412979094085907, 0.8376754234356217, 0.569766455646483, 0.11060250511684677, 0.8955717849802063, -0.6925350132512696, 0.5314762729848922, 0.9533752340729915, 1.2710241386374024, 1.4104912499980973, 1.3811992629837018, -0.37850125620682595, -0.2071771191168581, -0.31948194246258527, 0.7363069852246209, 3.004796145226696, 0.6560344545077248, 0.12896252168540256, -0.4518670648338802, 0.8840489597132871, 0.5518207833956811, 0.5630099732233868, 1.6122101221215004, 0.3392456503925538, -0.6729039305332883, -0.8392530786166574, 0.1432802079572165, 0.09445279969534232, 0.7369566880335375, 0.6521464459725363, -0.3857900112522825},
    {0.3254766307357601, -0.2586042917125923, 0.45378870225018225, 0.10475332136119124, 0.2873068731981057, 0.5414288566438552, 0.7857319058126131, -0.0256174618159122, -0.49781781865362074, 0.50000778341355, 1.1567978158310408, 0.8695076587778857, -1.1103727718441985, 0.6151447745982518, -0.8322899757995857, -0.7698987604671607, 2.6166659547641737, -0.1612050264472431, 0.42808275030789344, 0.9437461959884799, 2.002385220257415, 0.7339419567186776, -0.8610116334539265, -1.1525403771660696, 1.0937246703707115, -0.242031681030076, -0.4684401974552724, 0.29035303202103946, -1.0581787278033603, -0.5144441189238539, 0.7621162354782445, -0.9783225054897812},
    {-0.7745738976180178, 0.3155001842884565, 0.12707009722422566, -0.38573183515100135, 0.6288754286598709, -0.006776271300154299, 0.04889218963146758, -0.17443544976011735, 0.3852082369470244, -1.5363224510190892, -0.43438032971388724, -0.8574123900697972, 0.3559081176182059, -1.255094064207083, -0.3136412253826663, -0.41621583471873186, 0.6837654206483391, 0.2874914789786867, -0.7153638422638404, -2.303390276635633, -0.17538903154511865, 0.5132630874903377, -1.0766588505012582, 0.2792165880035999, 0.14992584943781917, -0.29561549168006007, -1.8264328940689418, 0.33291819905230297, 0.4042235440012272, -0.22657102917016006, -2.1153349113168094, -0.9268182265303957},
    {-2.274158320763842, 1.0883311184889846, 0.7814896868428673, 0.5482985454825482, 0.8245633871519567, -0.012356668787072424, -1.794261731641544, -0.4913347298992009, 1.0204895420183144, -0.5388416591893305, -1.2794403074980047, -1.2740007184825457, -0.634366010251833, 0.7732769504563803, 1.1936826308763153, -0.16142432888898248, -1.0665921513534733, 0.7970436356623111, 0.8929768908205992, -0.1526360014044629, -1.6406821642528349, 0.40984339149799676, 0.26021117831054863, 0.06562367111580736, -2.3957653652362954, -1.2204354014866303, -0.5090384226733654, -0.1598773194819103, 0.40681673924600525, 0.7824233883646743, -1.2075176146226687, -0.08815201621371392},
    {1.1782958575310047, -0.3990440566729548, 0.4077543506229675, 0.4758999491616916, -0.11920257220918477, 0.3516960236646579, -1.4462440578280096, -1.7923257603820149, 0.9225820581011289, -0.4623032717258353, -0.05864768095120252, 1.711883559454208, 0.599363172307498, -1.5130008828790649, -0.8016482994699257, -0.7852598669457163, -0.18031129739067223, 0.32296687110813066, -0.2847348894740791, -1.0934774466731474, 0.15650153014240878, 0.18731274426887226, -0.2555880528775885, 0.06268669832779274, 0.7559384889183786, -0.10884975898756713, 0.5698992086005157, 1.11257892769242, -0.5896230659475379, -1.1477883654524295, 0.532062955622656, -1.5540507952726725},
    {-1.8144039876912266, 0.38018137684933834, 0.6212379537540273, -1.6001882482363756, 0.7278257598752528, 1.6179649236204816, -2.51011230494426, -0.5375866101646527, 1.666002478152306, -1.7462968197110813, -1.3200590842736677, 0.11660851172803997, -1.5629613361374592, -1.6647978029753303, -0.8092591161958328, -1.2501344728208343, 1.5947399153361723, -0.3275669470745986, -0.47661477986617723, 0.7826983958653034, -0.31972450158287613, -0.08914987479443513, -0.0035819479852855756, 0.09650456356217335, -1.169341863802249, -1.3176738352765773, -1.0221095799675188, 0.12045929480648962, -0.7746773586434961, -0.8930885045942387, 0.4073554902296576, -1.599284539647129},
    {-1.4560637843252726, 0.5355895788014561, 0.5222491838617261, 0.4300364864908437, -0.026787225537697114, 0.7347269689984021, -0.7078643894240096, 0.3419644223589935, 2.3435863431716943, -1.5477040537513722, -0.4508611457737389, -0.08801674418496837, 0.8410273999340805, -1.41763022718893, -0.42271749808001585, -1.5619949504625934, -1.3785064195876306, 0.5619000485090031, 0.6406485914243805, -1.7949430733675524, 1.395154200847608, 0.9552348915445198, 0.6590176742565735, 1.2817994490942783, -1.1673543566904299, 0.7314921527388635, 1.0445122010980135, 0.23345725724018285, -0.27505236000451355, -2.0588699736558627, 0.7123262533192027, -1.2725956632548674},
    {-2.314867552359351, 0.3894279218565548, 0.38715756693687053, -2.012840520403461, 0.2844262510047404, 2.630665846456638, -2.3728621359676683, -1.8199529957859482, 2.6832936185708607, -1.831508621398895, 1.2744242497829648, 2.166091076464658, 1.3037765421586145, -1.123349713389437, 1.0398846413050176, -0.48082095929384283, 1.6420012533783168, 1.0129417159117213, 1.2727007573556357, -0.416187295864123, 1.0628932858670255, 1.2668216051171521, -0.06349959368445023, 1.1907640749171322, 0.20437396089915505, 0.42439713615675984, 0.5208536393744515, 1.4606772214264803, 0.011024200517156153, 0.020897171027032264, 1.1974652015185292, -0.38370931772918054},
    {-1.4245474960653006, 0.8857012056758574, 0.8111906001365122, 0.5760678360203674, 0.9130474480661877, 1.1196113704967816, -1.928603999625499, -1.815138313196122, 1.5600214524514209, 0.280756023632875, 1.1624126184331602, 1.8734802452277588, 1.184063672508881, -2.02757335156958, 0.6630151986410291, 0.4059234560618944, -1.2372885460654073, 0.8346582087481361, 1.3957295958581015, 0.9914498088804017, 0.147747000636109, 0.5656352938166854, 1.7209215671551106, 0.7220011355388195, -3.170335522671614, -1.5188305770830326, 1.6163174492787895, 0.466070662367494, 1.2140199141636632, -0.15716608465478166, 0.7060548990501372, -0.8235824690742608},
    {-0.03517439190010034, 0.9483257907099976, 1.1296090188594898, 0.3560516474504601, 0.8561097846818266, -0.5221671278990216, -0.7505482765903895, -0.5442709970002071, 0.14521026408393803, 0.9014769092993553, 0.5367814762679372, -1.01520415414894, 0.35354166227991846, 0.7032035968581786, 0.2694318839165057, -0.16050627113173355, -0.7920147206415181, 0.8369096432019061, 0.6035279321862167, -0.11291886696123689, -0.6690007590300487, 0.01630021592040342, 0.8897247520502102, 0.9871565552542402, -1.1128603584318533, -0.19711804291393803, 0.9851997023825474, -0.9103137397069655, 0.6965217008695833, 0.416508875300712, -1.0791126820738914, -0.27589445041157423},
    {1.3726612532373637, -0.3295035306202353, -0.15656619082343579, 1.0600481910787418, -0.9957847015857516, -0.20374094289937136, 0.9659254062118185, 0.48171259991472676, 0.1607260499540671, 0.8630133716311391, -0.050877653325281325, -0.012739690213222136, -0.3158128973611201, 0.40053117974337427, 0.0305908237795844, -0.1793188044791672, -0.5795177447402122, -0.3657319457764232, 0.3754952392913068, 1.1972349041319534, 0.1163209484262733, -0.34189643750286447, -0.20221420559096936, 1.0139959007574135, 1.3066408772336147, 1.5745063702468727, 0.9813038916880201, 0.3333476264131461, -0.7937372165534932, -0.4397507693868403, 0.5651634684585618, 1.128150181318188},
    {-0.23120815143799603, -0.050958613699559986, -0.2959284779001461, 0.0825518418261303, -0.7387711585485558, -0.07045141116940123, -0.4040437508042271, 0.7677372130811816, -0.2018203735458122, -0.7381804680322249, -0.2838572637745212, -0.20691266404042927, -0.49225270616337713, 0.048596703385426335, 0.3871927556301062, -0.6697727596765661, 0.2741638420814231, 0.01821681385045069, -0.17846810642878616, 1.2308589273107713, 0.16520582385204968, -0.7648315633233967, -0.09288131778437848, -0.3440799833847738, 0.8217928783756886, -0.2607314277418342, 1.0924515530221455, 0.8906633773801507, -0.07121019370346605, -0.775063707835576, 0.21451035735848847, 1.0747348600827116},
    {0.12861798148583253, -0.01707721505132248, -0.2198011872739199, 0.06396427202663697, 0.15023996237499354, 0.7445380476451637, 0.23926559993094806, 0.5726009073748168, 0.019769187036727833, -0.9882319476532259, 0.41450888897007415, 0.380269491033329, 0.26078845803498846, -0.35965047077480394, 0.10708095721545631, -0.06642141048180712, -0.25842138090392186, -0.16338311944770118, 0.6100978071242521, 0.22480408726596293, 0.57230467406616, 0.7840824608448678, 0.23497401737893372, -0.6679987314938186, -0.2135911148402498, -0.5483441045428566, 0.4980964394160814, 0.8059413489022271, 0.6935585624354836, 0.20591469596863493, 1.1437661005551842, 0.3513208231144379},
    {0.5443858933834146, -0.6966165188947925, -0.7517552448193539, -1.1535887866925507, 0.3774037707002799, -0.6267807373063754, -0.33273042830129274, -0.7147458618761279, -0.29256501643672406, -1.207619692259949, -0.05353075409962929, 0.1946381938195114, 0.19203148354097674, -0.923161862514757, -0.3217765016460053, 0.35975191989174216, -0.6371951083744957, -0.46832808596382963, -0.6855344163008986, -0.3197281862095318, -0.7435575013595553, -0.04774130612812297, 0.15148123154137177, 0.07411552804671913, -1.7486098025757693, -0.20729724891767193, -0.7653263287362125, -1.2643275332141024, 0.1309050554313023, -0.8984621598051608, -0.0007615641733386178, -0.8115644359328836},
    {-0.1852698482890959, 0.47186771694777935, 0.46352241045648906, -1.3794947371983532, 0.8309520189858185, 0.8292087013470033, -0.0952943474013164, -0.03629009398943971, 0.06367270979489105, -0.6961302599719853, 1.1867072180824207, 1.2538002706923799, 1.6805746523590173, -0.6659251300905995, 0.853909885603439, 0.7880111673587037, 0.6113580804137582, 0.6104268181474413, -0.4722505032973794, -0.11920160663875254, 1.1923131288536684, 0.2400096867178088, 0.566798234400959, 1.2095338673005342, -0.9290369228686222, 0.026658666805865126, -1.4028790245199592, -0.0866467312476388, 0.910959095556374, 0.4577935201632159, 0.3144542777607703, -0.6083208935431615},
    {-0.7772897903786059, -0.4792078426035462, 0.02336741965803109, -1.0954525706598908, 0.03340882137560447, 0.956276756694734, 0.7053332487495715, -0.07557791588347756, -0.17824101469579365, 0.4229847033853686, 0.5777913789596292, 1.664448624950723, 0.20670877542288205, 0.2474546648661016, 0.05629396319980427, -0.09729176760800573, 0.9318921817467987, 0.12457742071029493, -0.8469453887148827, 0.3134443237759683, 0.6892184600513284, -0.061478176841277835, -0.40881184088393757, -1.0501934083284745, 0.7599237446133912, -0.7440715544521657, -1.3740047587098836, 1.0036215534128559, 0.4643012521346809, 0.9671583720935824, 0.7937518740341426, -0.6012214923129631},
    {-1.1667241371251307, -0.9570911535694056, -0.9916053672515821, -0.5379577156933639, -0.21938718037324978, -0.021038139765856216, -0.041680542435953746, -1.294714568032608, -1.1915023867939103, -0.5369855754518875, -1.677713672314249, -0.12072111558542808, -1.5379079056535356, -0.46832069874487986, -0.07617193344314327, -0.7036739076550452, 0.02626492289754354, -0.5342883280973593, -0.32292789510129327, -1.5126806265976176, -0.887766724477084, -0.36035890760026174, -1.104638449979292, -1.3177014602783517, -0.6063524381637354, -1.7717649255093433, 0.2651605142198323, 0.022533151084092, -0.860859909111492, -0.2629689741303384, -0.44743361188872255, -0.9257953622163831},
    {-0.9391223084905213, -0.7166220194569962, -0.9242548676603765, -0.6405240235274603, -0.19986957176050962, -0.42315540685588304, 0.5607426928486875, -0.8230563673986405, -0.16459801953220338, -0.49478428828376125, -0.3122678753791637, -0.5860886035850004, -0.1260521557869387, -0.3052761491492562, -0.022576992768019208, 0.03323194482268561, -0.1085123393381904, -0.4312629079633238, -0.33148286735371874, -2.5848390000608297, -0.42591596028853224, -1.1097473175080896, -0.4416239068952251, -1.4316155136711015, 0.7647313592772976, -1.1581922082874638, 0.399209878884234, -0.07368139179369237, -1.0906457936727136, -0.19256903610781498, -0.8983704943406811, -0.9223285940317864},
    {-0.015368922351822816, -0.4801464261191734, -0.7117889901043404, -0.846468623150955, -0.5890733823014632, -1.2143065533121375, 0.7572510030724146, 1.030049640727132, 0.026444117306870577, -0.07356202342426797, -1.237453027538867, 0.06011117709669839, -0.5105906123417391, -0.08059352101370948, -1.077305967788878, 0.6552692685185535, -0.4117323550357855, -0.5433215834556464, -1.3628737074006008, -1.7535123014296468, -0.09841710950706377, -0.8834614141654472, -0.4923030930787138, -1.6248557834070267, 1.5473682658312748, -0.5500491399130251, -0.9143371528502184, 0.09156088993081574, -0.8313780755074532, 0.0980185798248411, -0.863148441084942, 0.3231020681635739},
    {1.3135065782279784, -0.14477298876944822, -0.5387107017585264, 0.23774695214741737, -0.27491698784031515, -0.9893039768049695, 1.2967259095663157, 1.2541839356503655, -0.0618397868621561, 0.4796654225578211, -0.7777271869076844, 0.8083281739283376, -0.5535150097939467, -0.6187835770213989, -1.1263707676384074, -0.2791633549905065, -0.34427206346307604, -0.7586146784609094, -1.318223756057409, -0.631034864587986, 0.16409221670759022, -0.05461196962286601, -0.3170043705688628, -0.4344717416194238, 0.6437537032635088, 0.5380614447625182, -0.37772252335593065, 0.4406923275819364, -0.7638268940447627, 0.7173343731843104, -0.6162259417544486, 0.3142715559582743},
    {0.4143334135830254, -0.7659821845127818, -0.44205218959572345, 0.5104991357907939, 0.2951679803817023, -1.0576744608508064, 0.5987458370483303, 0.13147384476096446, 0.1204962278607732, 1.4868934413854102, 0.6479298045093784, -0.18278478075719456, 0.039281459699334345, 0.8535071814375954, -1.0560259414439641, -0.12562657652685524, -0.4520832171250026, -0.03602258056650179, -0.45017110971246554, 0.38980648444764, 0.27120127052297605, -0.23993551772328056, -0.2769661149191527, -0.41325578937854696, 0.331278445546548, 0.816210240732169, -0.0730626890401567, -0.2178142608169186, 0.4049492158920184, 0.6844928388214802, 0.2387858177068651, 0.6302236254452225},
    {-0.7495735240948257, 0.048866313139481976, 0.44023718358948594, 0.37372585611969455, -0.17237018923572947, -0.2022186497921064, 1.0668046584818376, 0.022669444502026535, 0.44257986798982396, 0.6980747788862618, 0.6669710829460224, -0.11610094458123685, -0.43801138125554356, 0.6694925709919013, 0.397561583318016, 0.22380511938929112, 0.10332681733487008, 0.6161959242525169, 0.06867705047077785, 0.19622252610579857, 0.22454338931311568, 0.7287083045546299, 0.13822026657060357, 0.44724063115628465, 0.14084614821543812, 1.0757545258070917, -0.8058623674542341, -0.1985676978947689, 0.2662301822999154, -0.24567289428220124, 0.5146038772874822, 0.6545470562512908},
    {-0.7987241220255898, -0.41703883980990764, -0.07683167594945123, 0.09437709671479373, -0.3417036953440167, 1.0162273736473542, 0.8163240064342502, -0.24819574865247734, -0.3206712728016736, -0.7071672243216642, 0.26722162611417105, 1.0207809117027091, -0.24843467439689323, -0.690082447631212, 0.1772755513572289, -0.7592288910076773, 0.1915246298018892, -0.25810730123185605, 0.48192930116444965, 0.17856225355675767, 0.6358243755944849, 0.3991224361890127, 0.5522691299257152, 0.26936206264522633, -0.46602447647541584, -1.056935996938984, -0.2551747776717914, -0.2502489406015684, -0.3683569933337703, -0.7844793965446847, 0.7555759730748468, 0.32346450704886637},
    {0.45204525291864733, 0.6973351686316387, 0.36772638512773, 1.2837653261017616, 0.031107966849682533, 0.2157442595734805, 0.672176906843931, 0.7433789293795087, -0.13994299386170544, -0.09471347934464482, -0.5857611800991027, -0.7259690786671821, 0.3676451391841771, 0.4236889449557784, 1.3895516491390527, 1.2040044070581175, -0.6474819480305132, 0.37488567832132125, 1.1701697383848668, 0.39332077709450275, -0.2854566229218147, -0.12149739508282213, -0.061810531694051554, 0.47510842984267865, 0.08032177115683808, -0.03250091629624079, 1.4851167110143633, -1.0895507750804123, 0.7476370840780912, 0.35744529578053436, -0.8114206437593656, 1.0193836920909036},
    {0.7063628616678002, 0.7303241624283671, 0.2934859067917777, 0.5677195776117426, -0.18949148214845882, -0.35866815667713725, -0.491338658736298, 1.2853055288938111, -0.8214517793455979, 0.09708940880033616, 0.5033135451856766, -0.9745689659401989, 0.29799561124926416, 1.3930346311360038, 1.2342803105009879, 0.5906688350249035, -0.06832753807129066, 0.08822484408969405, 0.01443556270141016, 1.3466989772619218, -0.9709236124709799, 0.06289622540926455, 0.210246574339806, -0.3735720672406801, 1.2363150327635228, 1.618638133231046, 0.8061293655808199, -0.10476356947745372, -0.1924949083841675, 0.20111670053101827, -0.5004180451254074, 0.6986399885189118},
    {-0.5678023002213924, 0.46510312544978033, 0.5629889176596589, -0.9810161273135362, -0.1055803708194244, -0.2853315906784128, -0.9301487210776593, -0.6616840381946896, 1.1060850867967056, 0.4324610580390662, 0.6752108285469275, -1.475413026184445, 0.4396692071866034, 0.7383090145702256, -0.12427371297327379, -0.07249725131038506, 0.3901372481498614, 0.23331078680277456, 0.49849662897198727, 0.051179228434272195, -0.3918803860030447, 0.7648385805254332, 0.017935412224738802, -0.15269763037659279, 1.1427979089542746, 1.1332330353617803, 0.4137059054324355, 0.187857226227015, 1.1657090497355662, 0.2231610674582727, -0.977760975394914, -0.008470593646165772},
    {-0.3394139195835696, -0.5287811399644824, -0.33401114527346093, -0.8486905875793912, -0.8720662867368035, -0.02527927058557113, -0.89207137276795, -0.746250045711249, 0.1218129506447588, -0.47335552230206496, 0.053070859939782576, -0.030040637083877532, 0.021652322181837685, -0.28178927505355345, -0.4862266534867423, -1.1004965849831307, 1.016288441819195, -0.1297260429288854, 0.38679900123661054, -0.6666210455891619, 0.8967970744393674, 0.5727662429006385, -0.558520264537589, -0.5803518697276429, -0.1868496332491692, 0.47277101569913726, -1.0323127783733974, -0.03158738213126215, -0.6130872234038067, -0.9286309422120349, 0.8295951934260872, -0.9856035963557944},
    {0.7243365153475256, -0.22755367311751148, 0.2943441240615849, 0.2484761021748182, -0.417796682349138, -0.0019377654034596155, -0.13796132523003588, 1.3224232962009803, 0.46443037516342145, 0.18894478664489184, -0.15416381547040514, -0.1377318195207574, 0.7751719130882128, 1.0020244186499732, -0.47247965867750924, -0.023853519495929915, 0.7940149475830375, -0.3460809749991514, -0.5031412557776699, 0.436088449398918, 0.9453755305400724, 0.0020103537059760327, 0.0921877678052471, 0.34211010368694955, -0.23220757660212935, 0.5471968620202156, -0.42601820138214286, -0.6525920032262955, 0.3806915474357124, 0.5945451435975769, 1.1667659565125426, 1.295802512801794},
    {-0.9165176944978615, -0.22835385995414564, -0.395804274812228, -0.4584478104550928, -0.403056860028076, 0.14107121054931884, -0.2213920105467846, 0.24450015919335544, 0.2047285948356925, -0.32500521416381645, -0.07593001635311732, 0.615123261733082, 0.16349931251204686, -1.3060763977825665, -0.37694067312550994, -0.03838127391824138, -0.5535491840762252, -0.7480270020217109, -1.037840758920061, -0.7687333124805948, -0.2948714827289971, -1.303192793744831, -0.951073942763237, -0.3901720684456276, 1.1187691811467049, -0.9828266631548132, 0.3621323538929287, -0.13526954676501035, 0.06065810216392109, -0.027168408618642927, -0.2725574454053626, -0.9527709379920805},
    {-0.6250215494778022, 0.08043532116521801, -0.08280517073985968, -0.6960414228099736, -0.6049833327693441, -1.078191688009889, -0.7749227081283866, -0.9533354611966613, -0.5101851023879072, -0.1641249247106076, -1.0496358282616916, -0.006810908615263499, -0.2852514343936674, -0.27016709333144934, 0.4929357096572185, 0.26274770021161975, -0.6237888427805889, -0.8247617613827339, -0.9279536992295886, -0.8188421015811552, -0.8299562444787864, -1.2577386715110712, -0.9828277764522215, 0.3813637036699986, 0.6303093452066914, -0.6986491544317097, 1.110698407183003, 0.35342094067584584, -0.4409619544876013, -1.0494995617612721, -1.49016283381017, -0.5878493477778668},
    {0.018001158419254943, 0.5533354386168216, 0.4910581105719735, 0.24349627758947232, 0.4062297757815051, -0.6442528687730732, 0.07119683258010025, 0.2174044299816511, 0.5381921521135146, 0.10576298235197278, -0.9355870209506496, -0.5087707221665697, -0.32139297662100336, 0.683448221236372, 0.25782876083675405, -0.015262116967976544, -0.33285311007487867, -0.3181872168613113, 0.2237800323739212, 0.24630808116768813, -1.141001280904414, -0.0367267735446091, -0.04653622101897336, 0.26598389144467055, 0.1847776542309836, 0.091749472701648, 0.32333429755307586, 0.3663690666896995, -0.036295002994668694, 0.4735617698563152, -0.4122293832566635, 0.21062085071309722},
    {-0.7800239253503749, -0.6619977619297684, -0.10901762144774747, 1.3805075852094142, 0.3175964457205785, 0.8781305791571596, 0.46545156087173695, -0.4820402309223574, 0.20930325556208346, 0.18446112006408585, 0.5051218686350751, 0.10530028263835396, -0.0993650250016474, -1.027819951532115, -0.5523975370286841, -0.3942693848536216, 0.272714104564399, 0.19791583421425882, 0.19505585184654822, -0.3935643173148996, 1.0750085395497544, 0.5484706713114058, -0.34303579300768333, -0.5348288199076076, -0.910514231515048, -0.6224725760530567, 0.1709770038789774, 0.3754707744348121, -0.3585749982593139, -0.3084829097164768, 0.5840617462047002, 0.002832758838287646},
    {-0.9246276188627909, -0.6450770492080122, -0.2165276515803164, 1.1415712309812238, 0.32145790205915103, 0.7813728938126379, -0.04659438526555474, -0.8990034543183002, -0.3290865176624935, -0.17768683920285794, 1.1528321105656054, 0.2449565490631959, -0.24593219478464498, -0.9660062226562361, -0.9195433025417883, 0.28535469038618166, 0.033443587554854444, -0.17561601476354655, -0.13104960027884718, -0.4611074383450865, 0.7334594664311747, 0.1135490253459264, 0.26941790844872954, 0.32917855055892786, -0.9361718229983779, -0.1272414084181077, -0.9036775131891948, -0.2919213862771453, -0.3407712872984253, 0.42486291747242294, 0.1998486599154771, -1.2462935052798203},
    {0.6375695416074046, -0.8155986740657792, -0.6199274732650283, -0.20646330016330455, -0.6263198525511351, -0.10966978590751492, 0.06472099140920429, -0.5785976306154, -0.04570805999511497, -0.2439360798263411, -1.1001988931721118, -0.386589763792693, -0.17097777276724951, -0.9288647597607517, -1.4728259872692329, -1.090626787017327, 0.3382272673960097, -1.1562430292476287, -1.0605772063516397, -0.42357950679985257, -0.6832233442063559, -0.37027338548767397, -0.46638060263725206, 0.4791832798775193, -0.49824826148148593, -1.0434808881359512, -0.833616521699707, 0.3127683406909447, -0.3655415937303266, 0.25979325089366234, -0.3864912240216322, -0.7750909981198716},
    {1.29010731029655, -0.37451029137857195, -0.6301799124441425, 0.01955566125878686, -0.6508134191102197, 0.9059304437811894, 0.18127199641902908, 0.3392077789186437, -0.023318525372501463, -0.6951903424773239, -0.7552194631110039, 0.5581085855411768, 0.7226671314788189, -0.486932594477213, -0.7238155479009418, -0.5342692500271201, 0.5080681964667088, -0.649962843014803, -0.8076637023150163, -0.054579057700262765, 0.5122852520697102, -0.2134820788893141, -0.2737665772291029, -0.5226170224072185, 0.10808248270647286, 0.5506658534404543, 0.129767231360292, 1.3935050275737737, -0.9793646497621712, 0.3278026525048509, 0.5395923302291304, -0.25673500419982737},
    {0.5658095940622664, -0.4843772548091154, -0.15118936764051444, -0.8964309918134491, -0.6758239611436901, 0.9978916798912669, -0.791049607849355, -0.4268841474413129, -0.14012468000923675, -0.2703957351537195, 0.2858773240315446, 0.5230952060908507, 0.27701444102989353, 0.3669223911485826, -0.935135353942949, -1.4626537130320458, -0.7530104630981211, -0.9759051486604736, -0.6614067423780244, 0.7576287330901128, 0.22313107291452902, -0.6955622353348564, -0.6409950125361323, -0.5495040995692398, 0.8488916364604673, -0.7844238485834861, -1.0335698265691429, -0.20476337767765143, -0.9013545312517444, -0.4753330315793872, 0.37031931503465887, -0.7988322507744537},
    {0.08188361308548721, 0.7537810799250599, 0.6111405455766449, 0.30083930455882085, 0.13708168012776767, -0.393749730172651, 0.435771688208151, 0.728167134320087, 0.14308257436044938, 1.2216921596491155, -0.399849560487712, -1.0851163768418486, 0.23297553694106796, 0.04595406391523395, 1.179352071070491, 0.2906421657303068, 0.5520070872204924, 1.0178498572024606, 0.7382647931087535, 0.32872915183123025, -0.7839188924689339, 0.5714360961255627, 0.6706336125464204, 0.3291918975437988, 0.5402304787203565, -0.35515679951242324, 0.5757497845240579, -0.08093551342850079, 0.6954910189451908, -0.2731429374699847, -1.0205516647197697, 0.7923019196551516},
    {-0.5159394033302254, -0.6436739911472533, -0.676680726316937, 0.1670268694116174, -0.0833889773209165, 0.05770714071948072, -0.5669093877179278, -0.6477172782303131, -0.9533055121585047, 0.0672455016751523, -0.24132191541722223, 0.08677023470506542, -0.48688225514503275, -0.3939714127811969, -0.17687138953898077, -0.23500917746928948, 0.7645210782110433, -0.7580429459223805, -0.005963943505982591, -1.0207185313648843, 0.5228223086464002, -0.8402138911566596, -0.6198940109292306, -0.7672084300530054, 0.8903896805217364, -0.11733051936092123, -1.0635356890680612, 0.12525620068470428, -0.7370538148130996, -0.4309688709257466, -0.0625282464266335, -1.0105222318023295},
    {-1.4485012189810318, 0.22247046035746731, -0.38887899651375846, -1.0808935900540315, -0.28214637509781354, 0.2017981012472661, -0.6039147658564652, -0.6336142601589564, -0.4333816636642604, -0.2727155621886739, -0.32465949137559513, 0.9326325352033024, -0.6787245585977245, 0.4056899687552563, 0.11540604718218343, 0.5069539385174427, 0.9336273263853904, -0.3522180120568789, -0.814232831379785, 0.6543619107813419, 0.903780328578154, 0.23754296421579937, -0.9894648290581398, -0.32648132588759526, 1.1135332011117018, -0.694103790001753, -0.09795996035298933, 0.352356518073854, -0.4696459011650773, 0.4754169090497577, 1.020708218743516, -0.27520415251147257},
    {-5.439206192152459, -3.8144388478787765, -3.948073224194652, -5.391697573508398, -4.408886689311514, 3.5135867699916474, -4.861759075730183, -5.765651889997759, 0.00830861120824571, -4.828013171128371, -3.089161599779972, 3.5221762363377778, -2.3456794925231508, -6.081865439295266, -2.5719896049733624, -5.797082801489946, 2.5961386549881076, -3.791677695372269, -3.233027859740377, 1.3078915869921153, 3.328632595513599, -3.8699759057818945, -3.855619728400195, -2.7693922882250166, 1.159198802363292, -4.810034953489816, -5.351593384424003, 3.433613545656193, -4.9062065127557055, -4.3171510126544455, 2.9305842705198626, -5.1899386892424495},
    {-5.218099232513804, -3.706551298756935, -2.8890662096838287, -4.698303907517449, -4.3488062565520185, 3.0718714358005696, -5.5844304151587805, -5.643500140894711, -0.9201066849867687, -3.9434199635170177, -4.322032760120599, 4.017583408635071, -3.0283785581907097, -5.880016845993525, -3.0894998274421406, -5.677994879122246, 2.2571526425976773, -3.750936065267047, -3.1417659584401334, -0.34383543637646274, 2.683679277805251, -3.539465690048371, -3.8749535257180563, -3.7685960032495394, -0.9332123684285023, -5.507677143076856, -5.215934236910517, 3.46147393192792, -4.865534291646208, -4.644337142442056, 2.503356489916255, -4.847333551249046},
    {-2.1456706862183648, -1.35661098947288, -2.149776865758747, -2.076415318535763, -2.872858754401319, 3.130393296182268, -1.6197992475790588, -2.6178900211880043, -2.0452417975522352, -1.812374928212485, -1.5151739952302739, 4.050288296843219, -2.1995047222752833, -1.969226362787546, -2.38757688678919, -3.1391101936907253, 2.2854202619888033, -2.8128735048888265, -2.6983404314529156, 2.053046746703198, 2.295062370443319, -2.700593386909461, -3.0262804243197214, -3.0475516604191775, 2.413036424057994, -3.4194742006100456, -3.39988680945759, 3.084119843479114, -3.2635265496541, -1.8566537212586471, 2.7858896857229642, -3.0174464885997185},
    {-1.1428595109488073, -1.3400137542485657, -1.8079018666341062, -2.0573040428659657, -2.069751570660932, 3.0348745276477826, -0.11835078905917051, -2.4478914222132864, -1.781799753277318, -1.0318691054246625, -0.9813488005447724, 3.4272174380993046, -2.49114185773178, -1.915376094110319, -2.122541182221479, -3.079878863400354, 1.8702098262379656, -2.5089691365894025, -2.5633620415534355, 1.6760891518995118, 2.068049168886226, -1.3204338120276242, -2.458360065474918, -1.5330266129345038, 3.4834874132322287, -2.835573506358145, -1.2521027419238766, 2.800182990815989, -2.834067989699709, -3.155479848909368, 2.51211432839046, -2.821152493883033},
    {0.2547253895931239, -1.3893400736718244, -0.8773805892472925, -1.7349790909099025, -1.2798999337793826, 2.2624433599820657, 0.5754932616732653, -1.673421033165625, 0.03321071220085709, -2.593023018325386, 0.2328929609167445, 2.671423004658541, 0.28722089236209447, -0.42794055066125936, -2.1703008850244947, -2.1709767553855346, 1.0593551878685044, -1.551377476183085, -1.9164558612256726, 1.6955755682402558, 2.133233877620395, -0.7366246368107143, -1.0925334308573933, 0.9319454888578317, 2.0979406542115355, -1.467929593801105, -1.617170281798112, 2.5214945049278414, -2.5887030269524556, -1.654152620689654, 2.8578036028959612, -1.525854271460887},
    {-0.7824056777019743, -1.056990611433169, -1.1780861147733939, -0.03501381536624995, -2.0117927876604034, 3.587926560110948, 0.39389551538875694, -2.3516691803179923, 0.5881950769739039, -1.2885544548981696, -1.0057269720223134, 4.216265175317903, -0.7384914262479899, -2.6780864563285176, -2.289637391180045, -2.9920157983186497, 1.9874445478394736, -1.9867283129630047, -1.6158384740710976, 0.6423678096518136, 2.238078110393506, -0.4744079653910664, -0.8601720632293999, -0.14795558756188765, 1.4451513295399756, -2.1314700510741424, -3.156839697273323, 3.566522848643874, -1.9390600022393507, -1.4910465667734358, 1.9393451740664442, -2.0179064888228693},
    {-1.4647966020582983, 0.5914455894099289, 0.1373554529037833, -1.0076732118169276, 0.4089518874864251, 2.025500979154938, -1.1912530553876106, -1.768250483688263, -1.0256408694682764, -1.0241170775671213, -0.6127253544910531, 3.12868025706269, -0.17367181787867103, -0.6881499757890277, -0.5978643191234182, -2.046500451335462, 2.1092144610865455, -0.7367864228232845, -0.4024166632364274, 1.9849605560543568, 1.432642748785568, 0.27884879749346897, 0.4330048972971397, -0.6791378133768613, 0.28055666835050547, -1.7275060323341256, -2.3619520358051336, 1.4389227705682877, -0.6832163921521505, -1.3733304602113836, 2.0289387015830243, -1.5416983625749334},
    {-2.9001478332922375, 0.7862753152947877, 1.0129088123326968, -0.8130309507429034, 0.8940931176392369, 2.2968626941634906, -2.528138986780786, -2.4904641536736074, 0.22084319192531454, -2.5136049274691032, 0.23596930478153055, 2.6710428492332072, 0.8153963923721, -0.16402664076948525, 0.20681590149011242, -2.6475188612939564, 1.0613689108481779, 0.9415868127128588, -0.4126635027146482, 2.522838921589833, 0.8898520353941268, 1.0204688710963894, 0.5163679446380046, 1.0694056008530908, -0.6210266431598529, -0.6245529603838226, -0.7679928760863783, 1.824098742738778, -1.1651218636688654, -1.179636150859838, 2.178847327070208, -2.2188771517270793},
    {-3.2382831837926576, 0.11810991394207854, -0.05965601634163134, 0.05100946305336527, -1.2790709674543164, 1.7997134553667087, -3.2541232958868083, -3.3592776417765884, 0.7622846055614777, -1.0390714496504518, -2.288835465766366, 2.3776559633998544, -0.03681761112989693, -2.249705227139985, -0.874204111727018, -1.8144752448321575, 0.769757873128433, -0.2406486472850298, -0.9068638872857215, -0.7026444281997019, 1.6006620536800245, -0.6783725851960907, 0.22756033323930436, 0.03590777559097977, -2.4553433520388497, -2.9092062962521457, -1.839291978217541, 1.8162579269459487, -1.3722117939995988, -1.0865016524582185, 1.3295213707040907, -1.7273978294101424},
    {-2.0002374179733375, -0.22781402078221524, -0.05230207564328956, 1.812752721374739, -0.1400223979703315, 0.4183158189562391, 0.4489583224379215, -0.6089774927227696, -0.9508613781794533, 1.6462557343438806, -1.4101395399229322, 2.084903849085464, -2.0234458896938077, -0.2112555865028586, -1.267403965802508, 0.01728586713900492, 1.8168149206490853, -0.7145446791151348, -1.544378748188768, 0.4915436126617735, 0.10740470112751976, 0.04611936900747598, -0.41435434676512384, 0.006958514606242984, -1.5613084808614288, -1.8634402135546524, -1.5779511067771403, 1.6352085135462453, -0.579187143134972, -0.8511951175415055, 0.7374082401265153, -0.8847578437182237},
    {-0.25702608136218436, -0.5579710976569949, -0.5874487709213202, 0.9525516957576147, -1.5800606958892707, 1.6664758336952348, -0.7363697134641132, -1.0616809927024953, 0.5693560628097406, -0.6636791697739826, 0.1329649931797164, 2.288095343902644, -0.8187356340969264, 0.15401051622395934, -0.2569236038238799, -1.8415812024650755, 1.147429937152724, -1.610639472033172, -0.6420785311037768, 1.260315589052507, 0.1857844322603313, -1.0414198712424463, -0.10163133925188175, -0.2527508405295049, 1.8914028049349538, 0.49869062145392035, -1.269738634174979, 2.266114563862765, -1.3609022919766631, -1.065906409983906, 0.897891076293284, -1.2331829471789957},
    {-1.7951520175315006, -0.31941437920021315, -0.35406990881259415, -0.9421351059330735, -0.4933433292896965, 0.7174396724512444, -1.1883122461085454, -1.0338602720976364, 0.6246561792835695, 0.5408603470842841, 1.3740860638921968, 1.5226051999746872, -1.0158107235261233, 0.14760460356498328, -1.2602416745965306, -0.12225635128791103, 2.5016212936090354, -0.6040362891091193, -1.004240536397552, 0.6135283951581876, 2.2129979692274393, 0.6588702122481562, -0.29610070765909147, 0.4110585147927358, 2.067605864335433, 0.10058777959142197, -2.595045519889913, 1.0602401170661766, -0.5921241939918155, -1.0654313557801542, 1.7280711483731537, -1.5605727641062168},
    {-3.714690832801146, 0.584971599708709, 0.4998632809751924, -1.1459683048011433, 0.5395841812439822, 2.3454608727808437, -2.5158108033354, -2.567167039149982, 0.4578604453516321, -1.022885837620966, 0.30248533653365917, 1.9696185505178356, 1.070442254203234, -2.4214393541407127, 1.1022084692605267, -2.0882186380313508, 2.3644172945707487, 0.7921758898131211, 0.09990619606883958, 1.9683786698566303, 0.5154353740613734, 0.9515879012175376, 0.7093168452990519, 0.5633077238588955, 0.39646084072263404, -0.24454142026896644, -1.2891781018855526, 1.5736405231812112, -0.5252801461143127, -0.46478616043049326, 1.9404429932836957, -1.951649260292364},
    {-0.4140687190914219, -0.7646930333903973, -0.33339594094295943, 0.6184882224183413, -0.2312924680602066, 0.22506075577651014, -0.1433131179404787, -0.6464682597125834, -0.3275039528760592, 0.10732972196348448, -1.1088782232869208, 0.9856782474556933, -0.6909205241914409, 1.2009257761252823, -0.7906432478424859, -1.2400376873256496, -0.902297625218308, -0.45688913789277935, -0.9299908011937554, 0.8534658074422431, 0.8041889625611927, -0.4466813199795343, -0.21160998211320056, -0.9072043704882279, 1.7804041839366218, -1.8543734396588047, -0.07832392997303593, 1.2778684656333257, -0.8243465799495009, -0.8319401151011087, 0.2580507529268783, -0.4034932854830171},
    {-0.5389649074987504, 0.25217084171380905, 0.255730029684602, -0.5226515326492442, -0.23437562792228206, 1.5133459501700575, -0.7536777694908284, -1.0080326751162287, -0.32925741266341335, -0.23344379378127678, -1.2425616144124196, 0.7597828581322066, -1.4068948161925814, 0.5027591504016152, -0.9076527081722087, -1.1359431617699145, 1.3606851406416496, 0.42885397876264464, 0.1410153475303038, -0.2559770139637277, -0.08745141101109705, 0.08911226525085152, -0.03231610873997893, -0.14939021352450682, -1.1364360271111147, -1.0807637623482567, 0.1684470376380012, -1.2058458882221352, -0.7285560135061208, -0.9614757524886172, -1.2934931480550675, -1.2033054218608787},
    {-1.377878643626249, -0.9777653087804685, 0.048442482492694214, -0.03995923229757419, -0.5574037239814497, 1.3796331961920227, -3.144046168268443, -1.778335855984629, 0.7487365621411336, -2.7578158541321045, -2.348910069011861, 1.3664197571375887, 0.19590092856261826, -2.761788762165353, -1.6801566023518344, -1.8899509123581242, 0.7174552214345983, 0.21261619609078866, -0.8379819634334926, 0.9816183856072388, 0.639708302816442, 0.5804840910699293, -1.1832058786973125, -0.08021204415809527, -0.1991063526962232, -1.6238900204671645, -1.3005891628950539, 1.260969861054728, -0.10460913993072726, -0.9726197643308019, 0.9544024555773298, -1.3768162323016127},
    {0.33282079344817544, -1.9841020586478815, -1.3208096143344517, -0.05591691700607566, -1.5256484671066601, -0.16448418426678782, -2.0604599249792384, 0.131206826393288, -1.2753481570838143, -2.3995323636539436, -2.1263462925520025, 1.4374211829714882, -1.0098248375026977, -1.4651246933875235, -2.094566914209908, -2.7957319776720917, -0.37027035481229204, -1.6788431087739228, -0.8869527771827869, -0.6032196334913794, -0.7309521147690732, -0.4876858784034594, -0.8015810902475798, -2.1249247705960723, -1.3590325214162897, -1.4955648514437034, -0.843019725442398, 0.5722026291606396, -2.2639487040380764, -2.439621646050817, -0.8612302871862715, -1.9168005739609604},
    {0.5607388438133746, -1.986007229148663, -1.2656109094206798, 0.22959710824063914, -0.4690781659289697, -0.6833226553712519, -0.5210008212778784, -0.8249693680574185, -0.01355462306515334, -0.1718762507483932, -1.2110996495497206, 0.5891093191615051, -1.8494745261987657, 0.7017146014631429, -2.5818113765259083, -1.005505816726689, -0.47001607817643204, -1.4091948991600736, -1.6406816373726856, 0.1930699571462649, -1.2806414115846962, -1.9819606210358802, -1.7769043030377747, -1.4683094625061759, 0.7092516182345692, -1.1474957317739607, -0.10202320673230646, -0.521074962151836, -1.3256279020434, -2.551292256272749, 0.2796910179161587, -1.597447408576314},
    {-0.5934964892826988, -0.4097650501059628, -0.4377650458867242, 1.2542825072374362, -0.5674171624634954, 0.8482651518844817, 0.5896370635160477, -0.3341003913125428, -1.8006252303934274, -0.8485204644842675, 0.10728431854402412, 1.2024129341123442, -1.4829565694586093, 0.18197139780705768, -0.8257561103333213, -0.000603355804390761, 1.9181557306292165, -1.2634662129011227, -1.4414739879382572, 0.9240087535964054, -0.2424461195633782, -0.7191542151469537, -1.0479800480505848, 0.13474773504784612, -1.532637412325761, -1.2746778053766556, -1.1470498911684504, 0.10486091655902022, -0.9207854096603938, -1.3703016658993792, 0.23330268495684095, -1.604056650524708},
    {-0.5047221934450121, -1.4725436688826845, -1.0162061510506615, 0.9898628713329936, -1.6728111697668477, -0.8708355609070749, 1.6209314574687537, -0.6388586391284018, -1.3718306379633052, 0.5623079406698929, -0.26411086218790797, 0.9841409841263858, -1.7112781497309701, -0.16228254089986666, -1.7253876078951713, -1.2736417222625485, 0.018310210533801052, -1.7021740661900646, -1.75613620084341, -0.9503528758732909, -1.2059768824997932, -1.7160496305832083, -2.1213182563411217, -0.1819620414360241, -0.6133893929052749, -0.1051596631848394, -0.7740883426266023, -0.46671805346487505, -0.904035280917494, -0.897492248343517, -0.8076899801733922, -1.5870402590866424},
    {0.1689175757576743, -1.5746314993695345, -1.3886318942586153, -0.6624422910845027, -1.4400390796305242, -0.4075302794950262, 0.07526370095128466, -0.25218813574375293, -0.2813799496496392, -0.014888593463440942, -0.22687331271934033, 0.7922472027260491, -0.4815009564987311, 1.5139548692298517, -1.7173095686438549, -0.09883809499666861, 1.4907492935591182, -1.8501715439681532, -1.2478747022805434, -2.627549882732146, 0.09074212782004261, -2.106324326329337, -2.4199794793857596, -0.045913161803323214, 2.056420064003832, -0.7830385617143287, -0.9733817079115197, -0.6839678941206314, -1.0137984506321156, -0.3226453712942697, 0.18106767582876673, -0.3661202620474378},
    {0.43857509156023505, -0.18070481923691617, 0.41354233007073665, 1.2046281518760076, -0.7947328092719536, 1.726074103848776, -0.9982936254972692, 0.49554410442785607, 0.8212847253629385, 1.498185281096602, 0.9221656436666589, 2.4219541592858906, -1.097474096471511, -0.41219245152469475, -0.8730947606154837, 0.10129598448154623, 3.4142238123824598, 0.04453983453260967, -0.5131699671310744, 0.6613229089581678, 1.9626531799981097, 0.19527910892130876, 0.24464040640449833, 1.610046953864627, 1.6592253631753646, -1.0331455036625243, -0.89737327169349, 1.4360686826700182, -0.2845069209318329, -0.359164442114829, 0.852990241836301, -0.29321274430377003},
    {0.10977365999311489, -0.5807391703507202, -0.3422652859900666, -0.4828507620508177, -0.2705551504427352, 0.9110232660844529, 0.45052627930920075, -0.1149162989743221, -0.9368566105634054, -0.8247909471073148, 0.08441800476671894, 0.8321759620858213, -1.6713530149399771, -0.5732221523248419, -1.1937091667470916, -0.6822869847008582, 2.3747998740581657, -0.4257476291090275, -0.22023473733670282, -0.4853126920030906, 1.7578081004650292, -0.04925745216924285, -1.3045836027166406, -1.6245854951737437, 1.4520176736113972, -0.852951639915836, -1.2288571852230055, 1.1621616850285068, -1.1824668542773282, -1.3279328846460954, 0.04123101323221505, -1.8274845315263066},
    {-0.2895707708542406, -0.49245937022960157, -0.2942911969074408, -0.9289953437271866, 0.5515831975266176, 0.06996144930835374, 0.6583880740827567, -0.3819629518729119, -0.6133869896591513, -1.0106970334502938, -0.17556301265387317, -0.4514947422840202, 0.25152529577254346, -0.9305704212388377, -0.5957000365674948, 0.023771044254555392, 0.5421026451239465, -0.0438917204843187, -0.6168826656836621, -2.579375023401733, 0.6276233942126709, -0.1971505104941831, -1.6790470209396515, -0.213862562567051, 1.1690596665953605, 0.5217832426717788, -1.6764300763665845, 0.7056312902607991, 0.14296307106233516, -0.9679515647435808, -1.8468765512167569, -0.9748279181809099},
    {-2.6416113784518918, -0.025408309713783262, 0.032423134463199374, -1.2459394772207886, 0.2630247534850526, 0.7621823573065493, -2.262345727670509, -1.0785945165190587, 0.6339778470833013, -1.1977156696540203, -1.7241811325467502, -0.9177634798214765, -0.9032950526479596, -0.07399373150641886, -0.18158713195562545, -1.3903603145310948, -0.8492460692724002, 0.30672763745145426, -0.43909975623157055, -0.5633311325505733, -1.5435809082208134, -0.24895318350134105, -0.49123815123087256, -0.09209368726570899, -0.8654193463510096, -1.2609259878687888, -2.0595936562649144, 0.5689573041111119, -0.48040513615163405, 0.10720589556037731, -1.3134089973980365, -1.4285633578030104},
    {0.6373468541879492, -0.5179741374424804, -0.005062073540240242, 0.029240788911152286, -0.43328599654633915, 0.967328720923655, -1.678206636063191, -1.9741085716571753, 1.019856558573163, -0.4957290273354121, 0.08495509350575257, 1.824167244972719, 0.3057658098414311, -1.0499857909619439, -0.48209608591981584, -1.699233964406949, 0.14413125159184456, 0.22743569128579685, -0.5124955033144336, -0.40109421391170963, 0.2663836836373964, 0.35437551992367056, -0.017849010972975116, -0.5941757475098076, 0.8593674293170255, -0.8983671144015585, -0.2838087194513673, 1.6638180185051048, -1.1708471744364102, -1.704761212667179, 0.5770851893541451, -1.6235528591906614},
    {-1.8788458712005882, -0.36691012783473764, -0.6037088122518108, -1.5775342161546106, -0.06665540867160843, 1.497531533895051, -2.3748126167051344, -0.4892846235828403, 0.9343443759811326, -1.4978948984619764, -2.1792738973279566, 0.09484546491111363, -2.267096387061159, -1.4392440675470586, -1.479633332493196, -1.6597557400230722, 1.3061171813296402, -1.1587160612159781, -1.0495709996146874, 0.5326387113134183, 0.18971048515024166, -1.0295834936354462, -0.5833346785647023, -1.02983877781428, -0.22439715937517857, -1.430695174668088, -1.5221316349071872, 0.46214498017148087, -0.9289709263427567, -0.8375623955540702, -0.1356244416748401, -1.3756827278483261},
    {-0.7944876593280145, -1.2546224250494875, -0.9716926543220414, 0.6029342516309871, -1.535978175759942, 0.5644373418327348, -0.6217297810721667, -0.6782134322631611, 1.3832388569112564, -1.1542180250476055, -0.6572445316827802, -0.17774263329904397, -0.2703026305992518, -1.5227723203086851, -2.082726482135468, -2.2033245664782015, -1.9455566897714378, -1.4541816235779337, -0.525092388288717, -2.2061779930298537, 0.8679329199940564, -0.5188269920441535, -0.9062331861426055, 0.6793934496362176, -0.4178283529111478, 0.4187008190561408, 0.7147022933869999, 0.35192626564318974, -1.2943838991076568, -2.825507847652999, -0.7120862877892421, -1.6329123221735},
    {-1.7504000809372984, -0.05681061176515849, 0.22231592389745514, -1.03186526376877, 0.050879663765409304, 1.8559487820351477, -1.8937818945947666, -1.8347626974946036, 1.7977108056013673, -1.2567638702436619, 0.9296319946259036, 1.0887973808753462, 0.9745193941660071, -0.4634547435838686, 0.18996465686037428, -0.5507076949804389, 0.954878451078349, 0.3747043811478916, 0.8702920046185685, -0.10865966266661123, 0.35619470550459276, 0.24251717834050546, -0.13947679232600607, 0.23951368763192213, 0.39113127742076026, 0.3562153372061948, -0.33568289821238506, 0.5191780434633434, -0.475013392239978, -0.35160379158277855, 0.11362209509009284, -0.10978609173839346},
    {-1.3900014361974578, -0.09832277185171912, -0.2445947718441936, 0.39939779813355153, -0.28103113275941244, 0.2593205236536731, -2.1330244741895554, -2.194279475030372, 0.649206526082454, 0.11999814694304978, 0.0211216187947382, 1.2069761905350245, -0.5662208062252488, -1.962311641679096, -0.32551710640948006, -0.0570852443778851, -1.5426074990570178, -0.602403722496062, 0.3135239501058664, 0.10561226177473042, -0.9371045499307732, -0.8231098124887778, 0.6675391811537541, -0.7483347726168184, -2.4141375872821857, -2.5643098209703385, 0.9125666576103753, -0.10643315910682069, 0.041626139666722115, -1.5662983704758162, -0.37341368892338966, -1.0925101308635008}
};

static const float b1[32] = {8.022348157935038, 7.573951634928802, 7.361897863694242, 8.056749878008462, 7.511635839526743, 7.932264538276914, 7.9096086558106595, 7.841298279145989, 8.010127438390429, 7.9469643158347125, 7.877734377863595, 7.897534171092723, 7.5817068265041705, 7.922271359325673, 7.722333083636512, 7.740500325898509, 8.051534621220629, 7.624390650355225, 7.631675490994202, 7.730110292121933, 7.892508155984555, 7.65528333498667, 7.590491375879287, 7.762240352682275, 7.922500937776953, 7.9091448289462045, 7.764131277037264, 7.720976364079504, 7.783491780264809, 7.686382086550507, 7.910143470642965, 7.7693357690398335};

static const float w2[32][16] = {
    {7.1512843671539645, 7.075569578878524, 5.116362903311333, 7.348449564812487, 7.340816251635119, 7.352646434587292, 7.457531667324991, 6.75285536371972, 6.79059304440318, 7.2052279942274975, 6.293614042771373, 7.303633348613808, 6.786266004793837, 7.109369686290902, 7.115492129572053, 6.732123897173377},
    {6.892782246378333, 6.818519132759734, 5.461451776347845, 6.920308782893044, 7.077307829235643, 6.951355716028011, 7.203653684869465, 7.00512222647465, 6.83232698284439, 7.172128026074041, 6.52237379721742, 7.118279056282091, 6.875315320494673, 7.126163897787998, 6.770281785989003, 6.768725825778541},
    {6.773122603843859, 6.927788050472526, 5.488282497364248, 7.304362990798027, 6.851935522500467, 7.094220553463199, 6.803635616788624, 7.158102170169447, 7.1445747939754725, 7.08127113875325, 6.074477068033941, 7.146064852516025, 7.1041578531459235, 6.89754117872922, 6.996320550982895, 7.22906656509367},
    {6.900754359158555, 7.171283202932577, 5.281238517580217, 6.884133997329502, 6.978955872304443, 6.868410308489808, 7.181998075594702, 7.09686317119998, 6.976066932173277, 6.590046172472545, 6.251626201835963, 7.123045577757929, 6.902666394919779, 7.287451707952723, 6.814606508464263, 6.6744860316951975},
    {7.270384674958479, 7.194174640019727, 5.435231398046848, 6.993865400947641, 6.800800721906904, 7.464597989543003, 6.991753771310569, 7.409553298441139, 6.968119274789911, 7.118422069009625, 6.246343407681911, 7.1238039101025015, 6.716622685878763, 7.358685440042135, 6.8608850114978, 6.852195339568197},
    {7.0069535398006035, 7.149986994407735, 5.428377490142518, 7.060731394103098, 6.751988363290159, 7.175498032826604, 6.696282213765634, 6.950819570396097, 6.731829426061555, 6.601966168612397, 6.20057605193255, 7.132619764852134, 6.36665493183062, 7.0103285501839, 6.829430207425684, 6.926242403514344},
    {6.929669705611798, 6.948998454968109, 5.433878298393775, 7.096895812440823, 7.202292208049763, 7.33254708861732, 7.388552221613011, 7.172098821345486, 6.671480508123313, 6.892497252017925, 6.4191536042915995, 7.088147088703246, 7.191771004972657, 7.247902339395651, 7.267980591685224, 6.946726456044193},
    {7.362527281301187, 7.189033398374968, 5.5896761001210065, 7.239132728919712, 7.312029103477647, 6.758596177148331, 6.88554965998465, 7.293103924728374, 6.981655754986214, 7.1688086245508655, 6.385099457862429, 6.690647036465283, 7.104530726970864, 6.928717810948916, 6.750622848275109, 6.667981052045377},
    {6.559711894399809, 7.343397546998396, 5.216735284430291, 6.991769046763574, 6.7426524573286235, 7.287115181543379, 6.645619516327009, 6.867717667371737, 6.471785477897157, 6.715538047442002, 6.804076750605046, 6.560601441972757, 6.569426932400227, 6.9163701877956285, 6.998910105593248, 6.6252739025922},
    {7.125999390679617, 7.610020335489404, 5.48022557111372, 7.492037059142525, 7.381866748915454, 7.390863211077533, 7.40164459486056, 6.883343087546887, 7.161508131116189, 6.9899292258961525, 6.29270068450659, 7.364239153547766, 6.868984944404093, 7.07528648132905, 6.93045204858966, 7.161728831056006},
    {6.971171609955263, 6.942430630099926, 4.881439365470571, 7.07578446630789, 6.6658995042481495, 6.8279828266029705, 7.013722084990152, 7.069370967250141, 6.588400590164991, 7.219352884917558, 6.139313757932253, 7.146988103683015, 7.105709746405533, 6.771426381976627, 7.102416179698125, 6.704880767163842},
    {7.030307025311667, 7.350620355114871, 5.1123116308292635, 7.04619714383794, 7.047262546940977, 7.0257867847701325, 7.114647780492873, 7.389520604936763, 6.561050196877583, 6.757287593293747, 6.588321503866678, 6.670454238494781, 6.796268297881712, 6.863839069028387, 6.917391417869376, 7.194392675693144},
    {6.734899673743314, 6.6358547046718614, 5.522715312189573, 7.305898613462676, 7.051138048150638, 6.853878841378055, 7.135805152290053, 7.070905938683124, 6.796115881572639, 6.735332853493437, 6.498827179273035, 7.029720616240809, 6.561987321982352, 6.752142607155493, 6.807468830516702, 7.11719803001475},
    {6.889641891626897, 7.007630012261092, 5.220843634919816, 6.9607361955266756, 7.37612222409494, 7.2887506185685424, 7.420507564453673, 6.791079172223037, 7.107966494339661, 7.054585770107943, 6.618092144330993, 7.32739959424848, 7.150490540431154, 6.907984159825798, 6.792681208425624, 6.729030659190468},
    {7.066256353240675, 6.872909445345942, 5.186758308246114, 7.215425496516806, 7.2242251099501065, 7.087209123717037, 6.843078531960422, 6.689124115066529, 6.40759483270664, 6.692879521474859, 6.315198994714257, 6.581010687636747, 6.451931787133001, 6.982089103549291, 6.967058824914, 6.959936291471912},
    {7.283414008450463, 7.187420608287458, 5.313085665430938, 7.172268069462275, 6.941972077360288, 6.799998778840407, 6.924281865074429, 7.3194017592295415, 7.21709965919653, 6.744457057244776, 6.341720210705045, 6.762294972086239, 7.269168240893407, 7.211289904915768, 6.8310832735646905, 6.668728194703968},
    {7.054267385131962, 7.543370945268268, 5.104181631036315, 7.4324172326436155, 6.947044656850473, 6.988917867957471, 7.368453786587892, 7.121620044429923, 6.751262067206688, 6.96276320059474, 6.676574629871406, 7.49880390270938, 7.11945340938337, 7.398350985454727, 7.060796647098473, 6.830740064908474},
    {6.55916233290672, 7.3209631771932315, 5.113054567357613, 7.048969560817636, 6.601797878415853, 7.060198915325929, 6.933002600080464, 6.809898877652458, 6.731365693398662, 7.155214039385947, 6.460361530329772, 7.157824884439041, 6.564420288345472, 7.266072857069972, 6.963751232861959, 7.066371504180277},
    {6.9817547549437435, 6.919760186386296, 5.460345360250048, 6.957441202960708, 6.6747782620804506, 7.1048705676976285, 6.699620712415713, 7.370737403934384, 6.729462056904625, 6.7964552707922214, 6.594717923156551, 6.609615991293203, 7.01237157676893, 6.818011431783495, 7.233936464790904, 6.8521167873438475},
    {6.838459490166538, 7.311153339885329, 5.5835808566782035, 6.998231384785382, 7.267968001208072, 7.024148817634336, 6.878006253180584, 6.943305212043944, 6.798597048901732, 7.33063244391691, 6.311707050767402, 6.771977864416823, 7.004225725298848, 7.349060942244044, 6.924096982401862, 7.232689409809752},
    {7.097268696418612, 6.902832682396637, 5.193622226148865, 7.311892984459305, 7.171104205339055, 7.461013459651453, 7.14436758012757, 6.930239647647427, 6.6855972365105, 6.828666263397791, 6.653024310081314, 6.776936379703896, 6.712586105695278, 6.8755254754521795, 6.7441118492032235, 6.73263942854326},
    {6.692808855107138, 6.919289298913994, 5.460576664835019, 6.9684969308532345, 6.8888724384811795, 6.734204738948974, 7.06644448308013, 6.893999452076648, 6.850585313232333, 6.738926462167259, 6.352916874012848, 6.740329404798249, 6.661655577396432, 6.922940982220299, 7.179735775687588, 6.843857484953028},
    {7.160422618041646, 6.757021967560922, 5.3605549774418835, 7.150216822781945, 6.732013195911559, 7.00970470489797, 6.902028329807456, 7.186307271835575, 6.998603909640815, 7.095786181908121, 6.083263347007474, 6.787809330443022, 6.9980638265486155, 7.331446390111298, 7.054245806380966, 6.9165436249524035},
    {7.299692019915554, 7.03791090625349, 5.485713865123952, 7.106043011453829, 6.832340133835869, 7.2657440998482485, 7.400631840113723, 7.409443595151945, 6.915714941081119, 6.7305590020972454, 6.436203536952498, 7.092533789195992, 6.612116586719966, 6.889893092457738, 6.807693858533303, 6.832799228046414},
    {7.448563304705812, 7.068908430287055, 5.837083654688028, 7.014186159043267, 6.86300116479001, 7.444492072784132, 7.234849534217896, 7.547008531477531, 7.070292904625341, 7.25656494739495, 6.256750729469243, 7.237110212256782, 6.729615340135377, 7.329544785509777, 7.381251827176994, 6.934883724410776},
    {6.99180669603511, 6.9935362785618835, 5.020240625589705, 7.097055451592192, 6.82106668441843, 7.310300956948328, 7.246201106190676, 6.926355838055238, 6.785541036925797, 6.949627854591723, 6.071343208728239, 6.787027857873641, 6.648626251048206, 7.08991323685112, 6.863540674395768, 7.242429596228626},
    {7.21889286192572, 7.338554385513528, 5.241693693259642, 7.1600483262929755, 7.214807624705515, 7.01848447560815, 7.2850892194846, 7.30561987640826, 7.196380333108897, 7.216622712750098, 6.155239903753772, 7.192540494438639, 6.907899697854781, 7.361069898581772, 7.416037937274269, 7.065151785763728},
    {6.907463859448619, 7.166910326730048, 5.010903609056383, 7.33655864957379, 6.9525719988070005, 7.258729440392373, 6.940166302637315, 7.099414855426954, 6.946684845294702, 6.9368888696915105, 6.676272388079604, 6.886107016991591, 6.875732326946197, 6.752500850803665, 6.879245619865503, 7.13898605210725},
    {6.966029186052176, 7.073851443219819, 5.164706098698034, 7.229700119668823, 6.955380510674972, 6.804700050157686, 7.093111518234373, 6.840588353416173, 6.893246433321549, 6.7128011900954245, 6.010901881365294, 7.14811552484668, 6.644066183239795, 7.188340668848081, 6.973965390129632, 7.092133132742227},
    {7.263335220086073, 7.307794802205566, 5.496042670772997, 7.101408803199787, 6.951119229628289, 6.813175507279699, 7.029867005942537, 6.997922351156415, 7.06517161459473, 6.846101913597895, 6.293842299310384, 6.969786157262562, 7.0600427840842785, 7.140948635858371, 7.2396900317662025, 7.133359855867868},
    {6.6705099027267325, 6.821534405591199, 5.305263052930139, 7.234838380533793, 7.369135862875854, 6.790231195559114, 6.984267414233687, 7.34827357532952, 6.833042159723968, 6.951252312851271, 6.4118151855744285, 6.77408496096292, 6.951664439966888, 7.0194732336689505, 6.852644018844395, 7.361682844231123},
    {6.915508710097013, 6.918973776381954, 5.0481874373065, 7.297290563734573, 6.883286545223104, 6.786165385749431, 7.0387651541588685, 7.07425593143022, 6.694633836777755, 6.883262501796097, 5.904475011023344, 6.5889470220854385, 6.974530954988974, 7.186904803903346, 7.064709988841166, 6.7439136157446375}
};

static const float b2[16] = {6.682223748782638, 6.757529282658113, 5.834296628432044, 6.752441356608358, 6.692225162509165, 6.8141673486942755, 6.612022511399584, 6.780142993935589, 6.649887682277007, 6.683381298219377, 6.752452329063676, 6.70706702596823, 6.811965667827716, 6.574210031962538, 6.551748810582928, 6.678783134668613};

static const float w3[16][12] = {
    {-4.945847336641095, -4.908736842587066, -5.252374302393051, -4.69157217214022, -4.724963214485475, -5.488955093542298, -4.859754687989236, -4.761867663389823, -5.375661351204965, -4.698977000679988, -5.224898411740913, -5.0268039578310235},
    {-4.88550883272379, -5.096782912497242, -5.310723463251029, -4.678525912542371, -4.833107385691122, -5.06349982349465, -5.248136113228129, -5.03306870877642, -4.574429691401126, -5.480648197648997, -4.942378028657243, -4.407131524883631},
    {-3.348992422371309, -3.852587560635657, -3.9073150248502073, -3.446652881834518, -3.9890412639623847, -3.27900065940764, -3.7133037944407565, -2.8331700002024327, -3.5174804418792616, -4.0262630040806195, -3.9787602356665985, -4.092150786203396},
    {-4.739799143089431, -5.110721711557465, -4.970417615646843, -4.64464813730993, -5.257178561360824, -4.9938221391051725, -4.80752460863922, -5.193127501876628, -4.572937109700737, -4.784349143335859, -4.7819598277919635, -5.291951774411759},
    {-5.4065537728543385, -5.004168479173508, -4.700289240028299, -4.660649995740546, -5.213263965279811, -5.364237231539415, -5.339529293122359, -4.857843309372851, -4.592523839544811, -4.601132339344444, -5.414064650565056, -4.941275790578471},
    {-5.114016777401146, -5.182117563396573, -5.13733755445862, -4.758421204807221, -5.372947525202193, -5.340221561072247, -5.067293680111098, -4.743460630890294, -4.570904484397731, -4.891495231613647, -4.705058616399208, -5.196369990054341},
    {-5.0753494420342, -4.981218322333688, -5.268442255765911, -4.5680147257197445, -4.517842982891012, -4.95491347740282, -4.87394677030216, -4.995111819363142, -5.155739990874946, -5.253345046874875, -4.672495909349299, -4.654575131390154},
    {-4.712546440610081, -5.192277237692774, -4.692540022673366, -5.408009745733726, -5.300921891328401, -5.330342165640786, -4.6238198761705736, -4.8691949681057904, -4.7628242849808275, -5.303083540154508, -4.780266979174164, -5.0078616181483175},
    {-5.27562146314967, -4.534780328625949, -4.466542263471536, -4.366839328768489, -4.869346824704815, -4.483749758200932, -4.64856659922053, -5.450758890540071, -5.325733683550375, -4.629846258215147, -4.655693899156305, -5.165115371331564},
    {-4.8642705528986045, -4.506667792060714, -5.17311910826696, -5.241119551184817, -4.889018790797334, -5.332132106970968, -5.142789347322555, -5.105391293214268, -4.703652491870541, -5.38215583734036, -4.568598868433908, -5.070295232283937},
    {-4.319913484158112, -4.236224255089593, -4.50575614429282, -4.765579108701113, -4.15033429094843, -4.233619885773577, -4.37600412426879, -4.967424722597159, -4.343337330138642, -4.199289698637736, -4.432065715934054, -4.0875503994770614},
    {-4.981497353770443, -5.084041183287331, -4.898846829317655, -5.226212768852078, -4.826489690549183, -4.558010862325054, -4.894086020744027, -5.151095499685077, -4.835462833218482, -4.669052148401614, -5.337950035537293, -4.520792198229669},
    {-4.6381336311799055, -4.96611387454219, -4.442817189180596, -5.142491560809789, -4.682702290945179, -4.865274186423361, -4.929668479853558, -4.648952597633723, -5.265973519105784, -4.377733336147023, -5.191741214543138, -4.816799321968397},
    {-4.686588130731657, -4.577750317207808, -4.94679751807231, -5.1641138826033774, -4.462679288356101, -4.693559017575203, -4.926422965499097, -4.539382269457092, -5.372564427341695, -4.929842224548686, -4.995312523173637, -5.200608998224681},
    {-5.202459878031661, -5.1173917552749915, -5.126608404655185, -5.151220598285964, -4.902207359732626, -4.59353179026506, -5.001873212893252, -5.250766974656536, -5.094621970976551, -4.977707725210174, -4.775407855956758, -4.537512255251506},
    {-5.011731105177724, -4.942392383510136, -4.513234216580076, -5.37939361832816, -5.41655409791898, -4.61223564567406, -4.787575297477356, -4.785434661327144, -5.25355050579404, -5.163880801941666, -4.942752397050379, -5.369402963142858}
};

static const float b3[12] = {-2.756940272543421, -2.9315567116369925, -3.2189671540318416, -2.2379342890759966, -2.921487177984984, -2.713909509793102, -2.8706600778002067, -2.0857262051867598, -2.071579768547819, -3.212724256977949, -2.2473305457849087, -2.425727405187131};

    // Input Layer 
    float z1[32];
    for (int i = 0; i < 32; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[16];
    for (int i = 0; i < 16; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 32; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Output Layer
    float z3[12];
    for (int k = 0; k < 12; k++)
    {
        z3[k] = b3[k];
        for (int j = 0; j < 16; j++)
        {
            z3[k] += z2[j] * w3[j][k];
        }
    }
    softmax(z3, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
