#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][32] = {
    {-1.1462036963388111, 2.998010529146943, 0.13765026637046074, -0.39523763586919264, 1.4281303327795265, -0.7855058624297456, -0.25960478956684924, 2.443928093709734, -0.007772594274051079, 1.23544791305168, -0.6804374254682471, -0.8751731396424712, -0.2705418345847598, 1.28622238168028, 0.5541403195025075, -0.13707085194423754, 1.2567762859785383, 2.5252768661334977, 2.9879060607092485, 1.2010728982956582, 1.2079645649752804, -0.7330976505733701, -0.4491482018712545, -0.46352493158255326, 3.1604887142461076, 3.665675453650379, 3.586534255938563, -0.13258336027491, 0.7615923120559476, -1.5741552502454506, -0.29639865450121966, 2.601710989514508},
    {-3.1945446144505585, 1.3839580605103117, -1.1259924272499666, -1.9709907172186258, 0.5880808738517505, -2.176775788636703, -2.3009492436072696, 0.9843127944689885, -2.235999203438029, -0.3761837218674061, -3.1327190460268084, -2.6570554571147786, -1.9135543177007373, 0.16262799160422506, -0.5418151920289999, -2.251609533744322, -0.06194650656803399, 1.3956298048851101, 2.3913830501285833, 0.44882834576226666, 1.3194993808199988, -1.3572022740040974, -1.1369345456527487, -2.5752325248958523, 1.7190663551864325, 2.485301126930068, 1.8601154699176874, -1.7687809489691142, -0.02700663423757868, -3.697490792629623, -2.6476901509899338, -1.1836456851177966},
    {-2.3017018750957416, 3.413983679419662, -0.9251214769351729, -1.1100492012047665, 0.050495002009957476, -1.5679112093895378, -1.5650968187099321, 2.8136115778242177, -1.0934286160860944, 0.5715025310704233, -1.8806417050088824, -1.3425511353496162, -1.043341185445138, -0.24851995919567127, -0.9691272176237388, -1.1830119471558973, -0.531032729892193, 2.7999155074150974, 2.452386615180281, 0.23807894103713864, 0.5670847106573887, -1.5895842708385384, -1.3451048428308456, -1.558910853672782, 2.4570654911688696, 3.5935410929238603, 3.915089490125, -0.9313800183784017, -0.7455990265083307, -2.2568358916631737, -1.5435162301347287, 1.2353934756756684},
    {-3.264121414653344, 2.5966588311875736, -2.6674628604988215, -2.8755682707222334, -1.1839840887490285, -2.923230387070053, -2.765564595560162, 2.0645830367839815, -2.969606845562018, -1.566084746317064, -2.810850013398043, -2.997240670958815, -2.6207506728085703, -1.341851234183301, -2.61916350360312, -2.8152408256660726, -2.311767524115841, 1.7147229112182538, 2.387647724874646, -1.0770864136980123, -0.6994875404120465, -2.985094009138673, -2.9076589968154134, -3.061525888851217, 2.2474475231737725, 3.536439048517046, 3.267031013346703, -2.7795606425095367, -2.541431856730905, -3.425332745776374, -3.1450027422440052, 0.29687089571774705},
    {-3.389969319061986, 2.451289645689267, -3.3232576114635832, -3.0963112693811565, -2.4940088485190635, -3.3502704104937187, -3.1910457228686835, 1.4702724503352569, -2.752805608841446, -2.07757075117036, -2.40645627780862, -3.0001627078287068, -3.1424120382770786, -2.6571066674479695, -3.521881535852596, -3.260897486005767, -3.3195068109909407, 1.2669664049002327, 0.7949398125820656, -2.360206990591308, -2.2738287667987382, -3.6097689966045086, -3.250298327655404, -3.1455380603352396, 1.6931068622982284, 3.030415342457094, 2.7240647592834053, -3.1331399313611996, -3.422135543334598, -3.0577715168164543, -3.473916990922849, 0.2877749578011225},
    {-3.0372751970360623, 1.8427611695268271, -3.3314478581930254, -3.185250994533171, -3.1981448194487627, -3.1514665111416114, -3.454892952166182, 0.6765465051609192, -2.8213767232911766, -2.470137436021599, -2.454307924939934, -3.26141018490989, -3.3394807688451102, -3.099359473720335, -3.6196653915474317, -3.3614578641281763, -3.4082014392965188, 0.5148151810053838, -0.6009987062620664, -2.728574092499169, -2.780435187783097, -3.58920647063382, -3.3887506332869988, -3.0552215334896546, 1.043911021190508, 2.2482280434460202, 2.1941123354819254, -3.133533161961262, -3.287397168174319, -2.8805345632588764, -3.340960958706639, 0.14950195121334203},
    {-3.2712011085488952, 0.9182233283690908, -3.659556106099563, -3.713147672208888, -3.378265342588598, -3.466043989316592, -3.448425684567844, -0.33217491652396647, -3.2776468626144353, -2.875195861921384, -2.8473498742812846, -3.5517633494633083, -3.5695064844469773, -3.2657285813326893, -3.364667461100262, -3.304150178528177, -3.4942717636303207, -0.5470127025886008, -1.1593091070732142, -2.9553911759433387, -3.035196440419045, -3.809198278050484, -3.4378706883467, -3.5616384581741496, 0.25739633503358084, 1.8417511682505865, 0.98379376254386, -3.1687404501231535, -3.398799647697426, -3.1073230500881897, -3.463500902309944, -0.5203412400723617},
    {-3.772692161801435, 1.298166939651356, -3.856676061829573, -3.9043059845471264, -3.345663516999948, -3.834914011684519, -3.6502986732093765, -0.2694567572837362, -3.540011523391125, -3.2269836152709295, -2.817169173046742, -3.6715754083255328, -3.7745055946936708, -3.4173621566796837, -3.598909599873153, -3.6932112843945677, -3.6490533952014825, -0.11988162830295637, -0.9103895294356564, -3.143110931547071, -2.8485695505217206, -3.782110749572948, -3.718860479732375, -3.73043054983095, 0.1444547735300934, 1.7810031615527782, 1.1888215804288855, -3.453710028032838, -3.5530953561615672, -3.5699403458844614, -3.5261134842006525, -0.36270692441283914},
    {-3.7755740692156747, 1.5255731672471633, -3.6885704328641413, -3.4214657274717037, -2.7506829864135915, -3.6301702005552583, -3.410839053118536, 1.0106592377902093, -3.3104617988189546, -2.8968591774521903, -3.0717721512705127, -3.6369213818824426, -3.649847398089154, -2.8964914303711, -3.345261494860027, -3.414870169575871, -3.2308717273389647, 0.7525070228497084, 0.014671122132678013, -2.5188487802004893, -2.3719892195180723, -3.602299977343061, -3.5150880308484664, -3.748494101048521, 0.731644060085852, 2.2466227764426785, 1.8868964058819986, -3.5400290965017587, -3.5137389962013654, -3.4808587871610137, -3.4346622677514804, -0.235915896017392},
    {-3.9815022865383884, 2.009575355515161, -3.3064413389919083, -3.48058685995247, -1.9901724091632629, -3.527470122136328, -3.485414457490234, 0.9876401979742052, -3.6877115945674483, -2.630102383069337, -3.2770018799650216, -3.470396441598055, -3.564398074156392, -2.14720083004209, -2.842360653210379, -3.5170294519698864, -2.9249330439052903, 1.309650866845446, 0.922587540596815, -2.023530932555489, -1.7149483953869917, -3.5492085086188108, -3.375587182439788, -3.889524799828858, 1.2308800397226445, 2.387327470951321, 2.1973890329688355, -3.4640800289475147, -2.950077826881212, -3.8124729052262136, -3.856222151064175, -0.7303564377831683},
    {-4.125041738870933, 1.1868377253363296, -3.060562868337594, -3.205252920312272, -1.494805265676416, -3.3421380205301348, -3.5198134492246194, 0.696333655845299, -3.5433657067427995, -2.2721523683254787, -3.5418057203509945, -3.7359033524376812, -3.361906367423001, -1.7497983218868884, -2.589400881697156, -3.213596679478948, -2.6856279944532497, 0.9173835738808483, 0.7241181392505106, -1.5917050127303103, -0.8852843406091959, -3.210046919769421, -2.805866127250856, -3.4397601143439425, 0.6882414839205657, 1.5120912037699203, 1.3069918133799856, -3.343951477409417, -2.669040196281321, -3.9211064853741004, -3.785435099506584, -1.3038688250586254},
    {-3.792672781042618, 1.2848972288985434, -3.528800718942102, -3.464825691815021, -2.0203395959069472, -3.4759378584914056, -3.6186793922651974, 0.6439848602260242, -3.6721798726883175, -2.8268336192618535, -3.2933958454650827, -3.583569509641771, -3.4255853232364646, -2.0428165698552396, -3.003900725120295, -3.321257537674311, -2.69813603327295, 0.6943893607788368, 0.3053396062759026, -1.6896774456303976, -1.1105742241699077, -3.3355950785212896, -2.983205011095727, -3.5719023913335572, 0.5780052350044975, 1.3450887994337566, 1.3393782238877627, -3.4990243709283533, -3.0506512125266414, -4.105535378984951, -3.6008700742205475, -0.9808167217645546},
    {-3.9940372976724348, 1.0336106138336052, -3.238295713928534, -3.5151536100819376, -2.0383573073172996, -3.3636089895907078, -3.419971621103151, 0.8658931368410044, -3.705494168447173, -2.577089598016282, -3.6065762457988493, -3.4410898516047204, -3.489110171535665, -2.0055456082981693, -2.947406292663592, -3.3315988978126816, -2.84056438518055, 0.72168155059227, 0.604863176186867, -1.9492575896971158, -1.1906085172999585, -3.360943167448684, -3.159732031792039, -3.5120391355745664, 0.44124500338046796, 1.1431077575405486, 1.5299682375088393, -3.4728616455763026, -2.832224572120768, -3.7495221525993174, -3.4298979901244104, -0.9398919515773642},
    {-3.6897631104962954, 1.0292577016393896, -3.485993136385836, -3.201531821347839, -2.0000324330549706, -3.385215583696892, -3.5375720816952008, 0.6968609677332275, -3.5045720645009784, -2.873096088864686, -3.621423853558989, -3.7153807667440524, -3.301304538122042, -2.202112429052639, -2.790996723897516, -3.325831609278126, -2.813905644300902, 0.23616909588452614, 0.38288133273352554, -1.7902032770499767, -1.646989611800091, -3.133912690004923, -3.266063113496971, -3.8274614571488783, 0.59942096739071, 1.0751458061865828, 1.3331430002656361, -3.37411028884839, -2.999096647198871, -3.8862072883961702, -3.4714139562275457, -1.1143588983335426},
    {-3.6453527681123803, 1.4622201756869857, -3.4256883065942385, -3.214887720141185, -2.203329687244119, -3.2683293458846063, -3.6084970943162067, 0.9379429801421502, -3.416857810138244, -2.5982918541776936, -3.5415476872531735, -3.4549296691312583, -3.4034687148174885, -2.252847185697647, -3.029019356079118, -3.496247137035009, -2.770137897119115, 0.6900607462559228, 0.281143377052366, -2.0324044698884483, -1.695733507437615, -3.2221814159024853, -3.045507956702624, -3.7370660332993477, 0.751056001544475, 1.4986339155040884, 1.8835137501854595, -3.4611617680326128, -3.129584454863567, -3.7000293089295377, -3.7032192609204104, -0.42397083826583304},
    {-3.7348229747947586, 2.0225181441653217, -3.5377226728748488, -3.4510393150282392, -2.1515234352311943, -3.617924869782707, -3.4122364271258556, 1.0565592585890136, -3.5260133604638355, -2.8149119633303332, -3.623213493739205, -3.5637557536548274, -3.3103616615313243, -2.412033447763236, -3.0422102909983115, -3.5976390056044845, -2.975541780913726, 1.0100054120442945, 0.708045782206535, -1.8754294330330687, -1.650259509457363, -3.3045293483114375, -3.5029884308652823, -3.757097792511425, 1.2189662333777893, 1.9344350085248339, 2.492619689879066, -3.3973428349192383, -3.080555915568612, -3.873114196082541, -3.5733364885645553, -0.36539290767255744},
    {-3.6552818113362684, 2.6507257431483704, -2.7777528667561464, -2.957164873615624, -1.435458206051597, -2.890433246182125, -3.245565268652486, 2.0358194135569656, -3.1099596160165817, -1.902458919282641, -3.4736007940681306, -2.9835670290418976, -3.0842697444392866, -2.0906097831983694, -2.723409925197936, -3.083688070556445, -2.576066369928611, 1.8820299056197045, 1.6082786489426752, -1.1040968811566552, -0.9074111519911054, -2.8961331303447175, -3.0951256761005057, -3.451952417009251, 1.7659461899054358, 2.9605477628459482, 3.2583056932985976, -2.9171789392459706, -2.9447792616645954, -3.5444185346337918, -3.3351817924443727, 0.30054429554130946},
    {-2.689262295354195, 3.5848943194663248, -1.9493021103229757, -2.0665958031720897, -0.43210815755643023, -2.2590309823994175, -2.2958935588178337, 3.025444348034024, -2.0606331270968696, -0.5892611203803269, -2.8563202596022577, -2.2157278009556016, -2.0301543947541654, -0.9213941738962376, -1.7509631305107065, -1.8879154452916864, -1.5354293912802375, 2.6769077343567527, 2.2929586282541696, -0.16950096787346244, -0.22754531352287152, -2.0744200695289803, -2.0914158845696735, -2.492304377360857, 2.3103701952312226, 3.4306999608917836, 3.7909957999308617, -2.219388250543329, -1.697678024739486, -2.7352280528353927, -2.242522030804209, 1.7153429978488197},
    {-2.599911766739416, 3.407456669161428, -2.01194456528466, -1.8668073127543336, -0.8775721236778167, -2.4015797522363647, -2.0793387125829956, 2.827949191046718, -1.904422551526218, -1.0104777211273905, -2.5419476435292463, -2.4724290755593348, -1.9784036568336643, -1.081017509494158, -2.2105413497329987, -2.0798479762216653, -1.9293108587888836, 2.5405164850954227, 1.839348354226846, -0.8728256520958313, -0.6657130285673101, -2.1573844049178796, -2.0511983292855187, -2.468628345154668, 2.364008067563845, 3.248624688433319, 3.5061648192084753, -2.123411496455948, -2.1034303468828854, -2.5440978148834907, -2.477100099342832, 1.8469830128235125},
    {-3.361667382195262, 3.0041694555917684, -2.7511538660987105, -2.718121863900136, -1.281261844525035, -3.011968126116807, -3.110205147439595, 2.2811305251546448, -3.0403515596495425, -1.9092798788466394, -2.7845106364112158, -3.0740392695223684, -2.8465468466488777, -1.3409286798135183, -2.206077761315733, -2.9041593787348496, -2.1584137914432935, 2.0229238683770605, 1.8085643231947204, -1.0062935049443218, -0.9108021655506312, -2.6945527076581848, -2.5368777252818258, -3.1677796261276208, 2.285371197302835, 2.992949101253199, 3.3580368637413844, -3.024443830878433, -2.4311583492576614, -3.457331407339841, -3.1107449677713683, 0.8589249695598349},
    {-3.692525410818185, 2.678952012686324, -2.943492881962828, -2.8369891877836437, -0.7439001493343186, -3.298488426318979, -3.282519409310046, 2.000130499611431, -3.439483392223097, -2.0433028528465336, -3.343277372978927, -3.124767853011238, -2.8116171396074736, -0.7186476778068138, -2.159171477264441, -3.190465288579743, -1.8777127457712255, 1.9449487671107648, 2.1042911244401807, -0.23582395853873983, 0.14533392241787935, -2.901122104982208, -2.7839631376027874, -3.3055120740055997, 2.1416078751251177, 2.975481504289386, 3.3384625424256953, -3.1657170111599626, -2.0919011748285774, -3.659308144765986, -3.2879439273747915, -0.19273649033000148},
    {-3.2459615406071016, 3.4809166237794034, -1.859504497272249, -1.8340527915036475, 0.5379623195327021, -2.105633990922837, -2.2709710784506267, 3.006351816573392, -2.3805127382683624, -0.4269032260170147, -2.7542524228953194, -2.521501109602909, -1.8218903804001074, 0.07706479440973578, -1.394606881338225, -1.9899326250990594, -1.0650395257830643, 3.0515476803641204, 3.116263572674697, 0.5570888069410992, 0.7572051949526811, -2.0614926795855166, -1.8390306577860458, -2.624975706474836, 3.0853918242138354, 3.5371657171640165, 4.076526284116149, -1.9883285501407018, -1.119132201463373, -3.151422357225914, -2.3661217166811364, 1.4907605792650926},
    {-2.585601428330444, 3.564093967632677, -0.6444925757929393, -0.9474621703963183, 1.4231848816992765, -1.3802498815955788, -1.4086539472057096, 3.2331532287220006, -1.405737220123233, 0.5161822318237308, -2.6690301887112104, -1.6528316748427887, -1.138058539589294, 0.7379439328783405, -0.7199766066844314, -1.070335515843814, -0.17660671679715784, 3.0806359974120507, 3.34853944308895, 0.8330880961376088, 1.5838059820694352, -1.2686889345023022, -1.0111779264555756, -1.8387121228628323, 2.9801409121497078, 3.859623373243471, 3.880753991558681, -1.2306110937456065, -0.7648466648695702, -3.0187314940259906, -1.4801530926953466, 2.0565866827420596},
    {-3.142878814072769, 3.3293199271505713, -1.7521028645183894, -1.7802595092449072, 0.4246570274084168, -2.2685461938749114, -2.2305400764376713, 2.8745508171682967, -2.2413625153913292, -0.32384611367242033, -3.229808422815454, -2.6474795852303443, -1.9363098425673972, -0.3452023222391621, -1.5115141115074684, -2.025062466619676, -1.1238384723168346, 2.5624234356401274, 2.879183567814763, 0.4282246396522528, 0.6088073754375567, -2.0516253907596202, -1.6980973185415118, -2.5910725220663697, 2.65674069178857, 3.456507336761897, 3.5747015822889483, -2.1339823506309177, -1.2741745344172724, -3.305704753775404, -2.3757982063153382, 0.9037046683574249},
    {-3.6188433651270264, 2.6628069789727213, -2.031310858063572, -2.5020701809311925, -0.011531372519721347, -2.821959247505249, -2.8083834936356364, 2.4187949034496254, -3.081352798252909, -1.0288603671228826, -3.5615781677002607, -2.784914742010833, -2.2954596178082243, -0.647227798479704, -1.7742676742401768, -2.4540360055706545, -1.393309221218541, 2.413006237387427, 2.262007597792825, -0.09614969780216291, 0.6748932624592238, -2.150878437249788, -2.144957099385219, -3.0074245540251963, 2.3094788190627953, 3.1100529579349376, 3.258375366396899, -2.6672974768245252, -1.6004197570468146, -3.737224629817908, -2.963165303505422, -0.07391686554544259},
    {-3.3466673968873755, 3.1523409968826934, -2.1466009039835736, -2.2297278374414153, 0.13346498766140555, -2.4715955375423, -2.447688686736441, 2.446195689510237, -2.7715038114391817, -1.0180203701776755, -3.1463224287705653, -2.6017625260390376, -1.9676446789223694, -0.5508379703268849, -1.607319489851168, -2.26567635299004, -1.1537305589691815, 2.2766759983752505, 2.579015945434926, -0.10866415687744234, 0.8157545363737493, -1.771979659647616, -1.6494413574979705, -2.749799778939667, 2.5341068381665575, 3.07335078757259, 3.4323210355665315, -2.156983266295651, -1.4460665011533334, -3.342841925116206, -2.7662536710700083, 0.7670583989923904},
    {-3.1401778950064907, 3.1559124947811674, -1.8861718463915247, -2.308838954180562, -0.04312636094824323, -2.5412306147140553, -2.475361249859659, 2.8625743051787316, -2.5805439774193597, -0.6625996901163201, -3.222310357483018, -2.7357251475003763, -2.086770153037736, -0.4994951583063333, -1.7865511130051837, -2.0474275604375123, -1.3212508776292957, 2.550996769060171, 2.5142108188692767, 0.015598381259571838, 0.47058467978061375, -2.0116804551181113, -1.9270813396546764, -2.8423117855859, 2.5273335863554998, 3.374395267746973, 3.784785969073646, -2.09885900326792, -1.7121240660209753, -3.304660340155352, -2.669716877734813, 0.7935899836402865},
    {-3.6716126586666324, 3.2219135406566974, -2.139031802889799, -2.4566493817057213, 0.03340011079989721, -2.6208380560362, -2.42362430839571, 2.6538950384382614, -2.706067964204805, -1.0998354755554585, -3.4193127930147464, -3.0086254698324946, -2.2277634418604535, -0.44715405997456176, -1.6597331981077983, -2.4376026066672223, -1.3464972810031641, 2.600713540248178, 2.764102893720693, 0.028581735574567904, 0.4619832002883099, -2.054120542917405, -1.9477855118838627, -3.0118481355309488, 2.6349831314203978, 3.2069084598241093, 3.4454705621980595, -2.4221449242752326, -1.5220229239966796, -3.6463485199771224, -3.0368145090431313, 0.4763982797884565},
    {-3.5728732349990584, 2.8352424926852153, -2.0078851511439013, -2.179807637769207, 0.006274140805498845, -2.639608372846551, -2.4122776330989253, 2.275440061690313, -2.8663176989016215, -0.9698743533468532, -3.2507172501033335, -2.964948446976233, -2.5140643005962033, -0.4080131266092478, -1.5563762022709817, -2.2744438824802486, -1.2620710425102755, 2.3755414313957837, 2.566629095095567, 0.3114696069605829, 0.6294728884605555, -1.860673026108989, -2.014357508962134, -2.820981820254227, 2.2248784857710215, 3.134934038443003, 3.3602630565442246, -2.295276660985515, -1.3439821952911954, -3.6673609979313877, -2.686299973649372, -0.3106024354625134},
    {-3.8030946637242775, 2.9162783100070016, -1.7520826687114444, -2.063935854248921, 0.7340236947734023, -2.5014667841912823, -2.524765214789766, 2.590994768756834, -2.678163845680044, -0.8409021077060498, -3.351493289086251, -2.9747818662732333, -2.0970103067917867, 0.12945139540909914, -0.7848469003551408, -2.133482754020934, -0.654354644231277, 2.3157858800540017, 2.953454384469286, 0.668709888131317, 1.1765393021835555, -1.7928829482216275, -1.539480086663999, -2.7504796549794626, 2.668902942970717, 3.320632587648896, 3.3945146468154044, -2.404849253543306, -0.7865932761543698, -3.622135641356856, -2.6987869199867234, 0.007675694217054863},
    {0.7823235418669942, 0.8373665612035336, 0.8160063574582158, 0.39372022808525436, -0.036830362050545185, 0.7863408944262622, 0.7491721550194003, -0.2724216259725892, 0.43845359882081775, 0.6669286564070803, 0.7227731176395035, 1.2284194913695332, 0.880087313337498, -0.601627864913272, 0.14958746752611274, 0.8649802244780465, -0.4997353900125869, -0.07758646561424266, -1.2437276904356411, -0.8879291607004474, -0.44530108563483506, 1.3453363137296375, 0.5675141962169489, 0.573922273978742, -0.6343784013187381, -0.7274094823463643, -0.6834782218586021, 0.7042468757848918, 0.21054639032691488, 0.7805679892276516, 0.5828179480285554, 0.7704486720297896},
    {-2.772132435158259, 0.403637773251199, -1.6506335384261126, -1.8768450075492416, -1.2059820444983207, -1.7742503984911757, -1.4877172454190346, -0.7619603239528866, -1.608610180264961, -0.4096232391064805, -2.1668862301148777, -1.7764000423094337, -1.5742406945464393, -0.7491080438766065, -1.6961557324235081, -1.946682464906164, -1.2242677130005628, -0.014636151809081557, 0.70029009254474, -1.3104939128075945, -1.0645482896658702, -1.9122792747515014, -1.7031220065733808, -1.937554564654493, 0.3590677204952798, 1.5839965060924568, 1.3351892036457569, -1.2449178281305147, -1.4954945543098597, -2.8068968627905386, -1.992641627279416, -0.01150159958225435},
    {-0.6826251789034776, -0.25692483356750834, -2.1605182858487675, -1.7548304239603565, -2.984496935967493, -1.691964517607331, -1.384259744457454, -1.2648621783875533, -0.8861129901491798, -1.9953777566136393, 0.2644725357742708, -1.5051878905195382, -1.5249567528381762, -2.327937594341526, -2.159566125889758, -1.5972210844102144, -2.2523048578342073, -1.3813296523626037, -1.6722656263472022, -2.666964554803705, -2.9988043562402327, -1.9883135810520944, -1.8266257023722654, -1.0884058828718433, -0.48063034478578953, 0.1617894161694559, -0.2621495005755429, -1.6762900759433461, -2.3756777168464325, 0.6376934135025883, -1.2245904544884196, 1.9194358078591829},
    {-1.1589522163868673, -1.0524737012329437, -1.968811499808384, -1.6590464195271444, -1.923045408555431, -1.9580239921271851, -1.6245099259704234, -1.4184888524463468, -1.6334409301557142, -2.1069717595868274, -0.675871670413715, -1.8519986282236511, -2.082689262704583, -1.86317062428364, -1.9002767263207045, -1.6141898237040317, -1.7901746440669548, -1.9862295094521905, -0.8772036700901623, -1.8032420504613504, -1.6820237843749146, -1.684117131849799, -1.505306929195972, -1.778703894931093, -0.2282346613376689, -0.27814274711528536, -1.3666249954167753, -1.7978219065899126, -2.062325695258096, -1.4925342373871737, -1.8736501025832528, 0.960322008943957},
    {-2.373782282257741, 0.0011089626727482213, -2.5986260015728653, -2.4182738932381698, -2.0476379574300414, -2.4062228909603762, -2.386598896100301, -1.3338113812379981, -1.9666702597782266, -2.2235687434837152, -0.8327586397645146, -2.550784504784986, -2.4954040786993392, -1.7505893092411229, -1.9782679528487268, -2.533861964204923, -2.35969259521297, -1.5258815311120786, -0.5912274372152296, -1.727667479246661, -2.14015902630686, -2.838613396264902, -2.6093426082197726, -2.2713940320480583, 0.15521258009148695, 0.3684884557756343, -0.08292256108511518, -2.322690441103404, -2.1180628848256156, -1.430139476295151, -2.677321013853721, 0.6844742609380112},
    {-2.056032828859931, -0.7231307787920613, -2.862906037171088, -2.3373622799499887, -2.8224328211354335, -2.264265774494407, -2.32831186825637, -1.8729906821881976, -1.6166657137219735, -2.12306659208772, -0.27339922118119536, -2.526616521219878, -2.568708594920766, -2.6130995855579258, -2.645623214228259, -2.5709813959650725, -2.697209228133183, -2.2232180750909216, -1.0671394445947058, -2.5078888498836283, -2.825231730601552, -2.9380168556128905, -2.8184498188661413, -2.297276671963368, -0.3480741785026213, -0.002682374192303466, -0.7816227519556878, -2.287779815741517, -2.5873147456269217, -1.3537496339104353, -2.611187596914385, 0.649285606914566},
    {-2.165203279989103, -1.2595065730844799, -2.3740432791495634, -2.6103862674492437, -2.8452735446997615, -2.6851599856161728, -2.6364305709559583, -2.008390080303224, -2.137020239661119, -2.318091698780612, -0.7821190623110715, -2.310689768611347, -2.174960317024216, -2.688033480364474, -2.4304878381098596, -2.2510633402679283, -2.7257437130282387, -1.9693051117023503, -1.1869954190872094, -2.789945815424429, -2.8972097525401663, -2.4446890145667086, -2.6265171150045696, -2.521595407948148, -0.6905345551196591, 0.12427203347510507, -0.9274929090069397, -2.173930306731657, -2.6034838097567663, -1.5653525161400568, -2.596428962599321, 0.1548294067125204},
    {-1.699821588048952, -0.9614431473033122, -2.438666158413494, -2.3033130878792285, -2.7531220039804793, -2.423622129265697, -2.468992469431783, -2.2229844801280407, -1.6899395062244411, -2.322518537659451, -0.524427050599571, -2.3919843036846817, -2.1527396967283443, -2.341543638815392, -2.341393505229212, -2.2201808035862545, -2.3207643292907876, -1.9268375208556734, -1.0381021978112797, -2.454182739759046, -2.2646552148175085, -2.4897507519809516, -2.5204704845716157, -2.146114520430497, -0.7423679819389675, -0.4124139619657425, -1.2979064709197186, -2.2316817560559916, -2.327591458919332, -1.7456407977376645, -2.235695965926597, 0.4293808924230584},
    {-1.671872147923231, -0.4713986970872727, -2.910041137817246, -2.7771080188688333, -2.833277546689767, -2.638690325881585, -2.4018106690964536, -1.707735715889685, -2.1161308167734774, -2.6716907084225214, -0.026407555059970285, -2.5488514836025, -2.444949321408591, -2.574372640812969, -2.4290722839155725, -2.2772936884161834, -2.624152305609004, -2.0279564596771116, -0.9143489297653502, -2.344940160677731, -2.6986953623179852, -2.8679579993910918, -2.4524482875961695, -2.1886383385497585, -0.9801174560936448, -0.05777880984210593, -0.9265172594901065, -2.5773223280132744, -2.6155294903432456, -1.5466009937118566, -2.7811164340743457, 0.658060210177366},
    {-1.9144564353077798, 0.21525372035439286, -2.6871658820524855, -2.601932832223514, -2.774816403090459, -2.7251005733435822, -2.644526205485253, -1.9899237911084562, -2.1846257233115756, -2.635205934564593, -0.7230010676355717, -2.3563233866869164, -2.4464833818106664, -2.1004106653127588, -2.1642358101122494, -2.7028499079999295, -2.6187272751925015, -1.9955715286714681, -0.8936764890360969, -2.3372118354791374, -2.71034648093076, -2.627521750134182, -2.6373056275516644, -2.4523330495440403, 0.2778147340813977, 1.0162986857647764, -0.11324924420393287, -2.698649297031075, -2.662552838623672, -1.4340033704215758, -2.834375976882444, 0.5714727927045843},
    {-2.320521153745808, -1.2704015251024792, -2.400746824902035, -2.466785136622243, -2.3809260111884534, -2.23722173147507, -2.2618762894447926, -2.527978802675103, -2.1975768358305787, -2.236353611495107, -1.1192075627396036, -2.0376500513047375, -2.193534969893868, -2.3841405708950574, -2.0107876262301416, -2.3992601452856053, -2.3753389691377538, -2.364537942151414, -1.1628205486633947, -2.3329130267258256, -2.4506342981387497, -2.4485337780020355, -2.0066525322881756, -2.186342356090907, -0.40698018299793537, -0.10884468113918748, -1.0941771539570824, -2.5893258216135653, -2.086452570017613, -1.6107959881415872, -2.357067049027449, 0.1652042435619812},
    {-2.3544131756145443, -0.562516507793063, -2.7763589073265917, -2.4621883450669455, -2.6639011449557586, -2.5868075709168337, -2.568015688348831, -2.1345489452136395, -2.343167519492509, -2.8815692753900457, -0.5743473991499835, -2.4581414589895156, -2.5058848645782215, -2.8750143840722124, -2.8436924501840024, -2.4678715389208397, -2.5798874137434047, -2.1597866777859767, -1.374624901435436, -2.9453148201715913, -2.7514333757615024, -2.6147122880625426, -2.711495149677287, -2.497814577771341, -0.6198498019255854, -0.18629376635035383, -0.7577896767629174, -2.5845906034959913, -2.7382468657489993, -1.3650025367106238, -2.460216015518757, 0.7804913835112116},
    {-2.4008138103790353, -0.8223358802252073, -2.8850949467516336, -2.6608057100601523, -3.092073782071666, -2.6936936452405944, -2.941965533280291, -2.182906088090841, -2.4796987359239346, -2.6845878991724668, -0.8004814228688883, -2.485225537640861, -2.585012755366045, -2.6275411852407795, -2.809461869270111, -2.8329373548318206, -3.0193922289832353, -2.4318205179813766, -1.3683142302493903, -2.920872111760994, -3.002607684208859, -2.69777181239272, -2.7755377246092134, -2.674248377436293, -0.6460020342373703, -0.11539988812000565, -1.049482736997171, -2.7898931356183962, -2.9441510564472217, -1.5276299772576782, -2.9377302390176645, 0.43213003295966634},
    {-2.3823318537270604, -0.9169054903198088, -2.6676209685394423, -2.935231344923654, -3.315198075354146, -2.5427823892893024, -2.504108465487791, -2.4707167655306392, -2.431940601053507, -2.7235595084797004, -0.8722892647335561, -2.405990417368051, -2.519046993536098, -2.989115781321538, -2.8171203826054882, -2.7040187092905263, -3.004756410025073, -2.4241958410175837, -1.2991665059034272, -3.0457237535252295, -3.0457903566375673, -2.973031701514208, -2.7124037481169734, -2.7567050063151672, -0.517784115242634, 0.08756483534377342, -1.1557453968960076, -2.625984204813802, -2.978015946715699, -1.6837169919271342, -2.4962893279549943, 0.5429675198009716},
    {-1.505194068344756, -0.1943690975449974, -2.779136309101615, -2.700859136049231, -2.9574101197516063, -2.5751482241384376, -2.2495306779593505, -1.672185311993054, -1.7975946830865939, -2.132160178595505, -0.0675152902113358, -2.19438411987343, -2.200882268172115, -2.808070727615301, -2.822021152642492, -2.3126135432558397, -2.754163214398519, -2.219469613346104, -1.345630041722728, -2.878714414709845, -2.8577129826036756, -2.9868910285803008, -2.5604196113947255, -2.123560176582407, -0.4541766611401045, 0.5558449566636268, -0.5663068911716156, -2.3488964412535336, -2.4420040619435435, -0.6443999622354865, -2.4039195695579987, 1.2280523460728427},
    {-1.3736306745198914, -0.335336277911999, -2.4297953151117344, -2.387180655207826, -3.2144267715876103, -2.0084373436720613, -1.930135120124121, -1.7141506068884411, -1.4572592183241662, -2.172872315092551, -0.3244340853836758, -1.6342980024964087, -2.3567101546528204, -2.801212025881122, -2.7343610356575945, -2.075428712182752, -2.6778664481252386, -2.286500820149761, -1.4711927192923018, -3.040253373546657, -3.2020988392490537, -2.506744531134569, -2.6992289795092734, -1.8963500940756268, -0.6581971972018927, -0.08946035811848364, -0.6096597244753763, -1.9930225071216479, -2.899456784834937, -0.811978407199123, -1.9531636499479068, 1.3268010582747611},
    {-1.05181041901464, -0.5316633771223256, -2.2123112007545025, -1.9327299848609916, -2.5722807770640426, -1.9045880936923938, -2.001904287365487, -1.4762362226693257, -1.5937929359389156, -2.4542716543051433, -0.6979314115045604, -2.1604098557917086, -2.1496662206610333, -2.880072697441898, -2.8136434844902545, -2.0890966776309194, -2.6048788790964124, -1.856233710244363, -0.7325537335349208, -2.702748611806406, -2.8366893130119655, -2.5516018227891992, -2.537451378036558, -1.7867276724944048, -0.07236197873533129, 0.1962064461542507, -0.4654807285182021, -2.28749003174851, -2.5692545366738493, -0.9301998736735936, -2.1213016181209814, 1.376633733990978},
    {-1.1037975699451932, 0.7448342672207983, -1.3476491414440719, -1.1297119769054915, -2.1804186697531205, -1.2740703958688628, -1.4401428620589147, -0.7693990423137562, -0.7822124908108568, -1.3575687294071677, -0.30850211082463935, -1.329000396459729, -1.240046488252004, -2.1924765950616796, -2.5766827127368668, -1.2593945283686674, -2.329926503057469, -0.9765293177772034, -0.5609186163447609, -2.3149069427988853, -2.4994712625335707, -1.8420016889981135, -2.0075493943327825, -1.255179458580731, -0.35107927924868576, 0.5205547013120894, 0.6699993116300934, -1.4405857967578528, -2.205673594938556, -0.28684449621693703, -1.0436408741183505, 1.808757564931661},
    {-1.0021986045806974, -0.6999063210151859, -2.2742017802110204, -1.8459328989106498, -3.017130935485655, -1.467453363951073, -1.6404311783379846, -2.329101751153166, -1.240339506705459, -2.1685638777390364, 0.003714319234431651, -1.8229765965576517, -1.7034017973851243, -2.723183666838416, -2.909869089570376, -1.9461995735234427, -2.72530663043066, -2.1500398543266375, -1.316877417976573, -2.952273691551036, -3.127360355804159, -2.3609919898129856, -2.5144220090536114, -1.6057168238593507, -0.8279233789491794, -0.5366953708016803, -0.9267072227899741, -1.6673740935997008, -2.780800839924795, -0.3245518917521473, -1.4322458462926795, 1.4648116383555594},
    {-1.9303264802347524, -0.985359514585944, -2.6859811663347335, -2.7537913563560372, -3.548353738563421, -2.5519914144706095, -2.554953999012733, -2.709016243804223, -2.206102061820958, -2.8383472163624646, -0.3213616251461245, -2.385500085864393, -2.5214419413937215, -2.8250249865086836, -2.6795191478901788, -2.560583554367581, -3.0996683174064326, -2.7426004581414727, -1.2739098511709863, -3.1189688723774385, -3.3476876846789536, -3.2661970975635257, -3.2484551228508454, -2.5594161274262586, -0.6659273242117894, -0.347970859311515, -1.1067084534871332, -2.351775381067342, -2.8018658403722814, -1.329878341480258, -2.4896873109515227, 0.9259554348250404},
    {-2.5611471913186277, -0.7906024861624568, -2.7824064552930743, -2.9652425907008415, -3.1852790158646207, -2.8543320036239033, -2.5573610094579284, -2.078880652098024, -2.300949568948448, -2.8723769109566315, -0.6586848416964073, -2.497170267063618, -2.5808904937113475, -2.857418257950645, -3.1343673418473594, -2.739286249363205, -3.082249630987227, -2.281300269432095, -1.169778274433252, -3.118812947331951, -3.0715779790747253, -3.232167153900282, -3.103953442852555, -2.4329223552880097, 0.0014392218678916857, 0.3022475111328137, -0.7756150069828737, -2.473569610834701, -2.8133611350238232, -1.870606803641242, -2.711635719090217, 0.62861438344871},
    {-1.2035976468234475, 1.8437445066099118, -1.5223849911584866, -1.4803340010026562, -2.1569914300650903, -1.373032134037808, -1.2925483332730296, 0.5799187898068714, -0.8325682287833487, -0.7275488647680448, 0.23114626406173358, -1.3144046385909942, -1.6152625838375396, -2.20599366092932, -2.4214223963637607, -0.8747330374135204, -2.4425006543790637, 0.1416525234807343, -0.045976141992521626, -2.4303183277381426, -2.7542939930741137, -2.166162103924953, -1.9229534733218832, -0.8504775949472013, 1.48307265412492, 2.108131765481933, 1.9655940012582136, -1.1260183967137976, -2.0317128907671926, -0.621129090257777, -1.2022230252670585, 2.6557200468512576},
    {1.325500418212737, 2.1573787405385803, -0.7483522439864563, -0.4920874191632774, -2.3870855274077925, -0.15378355013353529, 0.07587960420849754, 0.871675800134022, 1.0653919242899939, 0.10644622174872745, 2.1528316050760883, 0.6241834570676918, -0.05993356281325867, -2.7354564006537916, -2.209728670493905, 0.21055484312799405, -1.8816177583706162, 0.32431612707619184, -0.36402445285128004, -2.533524211279788, -3.076842479567745, -1.4853364306837866, -1.0321614936435053, 0.8211903218157125, 1.291463000607778, 1.9727700694598855, 1.8665352679890264, 0.3882921183766458, -1.8141306345782546, 1.996580205232652, 0.5364962558927879, 3.4382246097258524},
    {0.08007367573078793, 0.45842156619322, -2.286821933959838, -1.927319969314664, -3.682165514861468, -1.4456267988811051, -1.7403923302339668, -1.3046322946234639, -0.5954683523412896, -1.9009209655869692, 1.3124926253447322, -1.2189049119722533, -1.5112625354217553, -3.1326733849113246, -3.3173692363269964, -1.3486692791037533, -2.926241168457195, -1.6461030022030698, -1.757196559637175, -3.4566146669312925, -3.758268410294145, -2.859916276032669, -2.7018506247197354, -0.9738240073006829, 0.24717169389598542, 0.671239381445324, 0.23972969762697877, -1.6494418455105555, -2.785347497623773, 1.2137615844227085, -1.3237632701761703, 2.553203712459264},
    {-1.5982341978262142, -0.26809913553054254, -3.0272975608468777, -2.777711605557773, -3.4322692758748286, -2.597621005851281, -2.639186461032172, -2.2003835473633653, -1.813318295755798, -2.996630356279312, -0.6237171363594172, -2.0949447315965877, -2.278608081329013, -3.408256053271543, -3.2945953759066318, -2.5165113556241994, -3.165015886350881, -2.558830904163701, -1.4707643511116706, -3.3883314822072133, -3.288543563243471, -3.067920532073966, -2.905413089872196, -2.3903446313600036, -0.5209538621861316, -0.18280746049176558, -0.5784926483912137, -2.6745262830717835, -2.912041360495375, -1.2252945873396632, -2.3352108409667256, 1.555554709645878},
    {0.5951910901704139, 0.6800663239993621, -1.2690482712993518, -1.2840087573155563, -3.3055187624284224, -0.817906223123669, -0.4919918026123922, -0.9374911984603104, 0.08875988177324336, -1.3638972722086589, 1.0134934958953232, -0.011789611730824722, -0.5447220182370783, -2.893794820426161, -2.535053800059597, -0.39537836531800163, -2.7103171591271873, -1.727132720979674, -1.5265089332891362, -3.249620367641126, -3.2653190596958823, -1.684941048540044, -1.7247016178246815, -0.017271766672672658, -0.009599944680758213, 0.6457558091406919, 0.6275345846455253, -0.6135486211026742, -2.4677294540010193, 1.2230484787706861, 0.02024206642827155, 2.757230532892593},
    {-0.09108394789635152, 0.5183560463887412, -1.8830955517267305, -1.5281565330858005, -3.129571410084548, -1.1161896176037573, -0.8629229171068021, -0.9831401854538915, -0.6511892354107092, -1.7578039002094996, 0.5085858509336675, -0.6491356821837205, -1.2867742890736231, -3.1607622242011515, -2.8548401205187823, -0.9853638697749928, -2.994902472987425, -1.6124346097483142, -1.3217796016690595, -3.298914673718583, -3.3983606973381453, -1.932244904508688, -1.866720364330327, -0.5581415255839168, -0.14498588422934477, 0.7033307963925243, 0.39651582528949597, -1.014138592491916, -2.4095567616234486, 0.4110028343710579, -0.8474537133305238, 2.3921188856418216},
    {-0.8854345947125973, 0.38810812799432126, -2.147336137634555, -1.999607772733962, -3.4605137713000085, -1.9135717624296973, -1.9154687737318208, -1.2584805773089895, -1.063471740921735, -2.2019588936716183, 0.08182394545425437, -1.6722846963150286, -1.751271498652764, -3.3600895148455763, -3.233423224507702, -1.5161451004010285, -3.064683275442575, -1.8935933664174824, -1.3065316242061171, -3.3439387448332685, -3.384700497712032, -2.4892338685889603, -2.53372133490061, -1.4206006809302303, -0.17116056300844634, 0.4342189544302694, 0.4835061475921573, -1.878539192399501, -2.872709031116425, -0.2680508796642435, -1.354245242467275, 1.9484277647154569},
    {0.1057846529311215, 1.1479303539950434, -2.0284677246326406, -1.8588843587966333, -3.354947616872533, -1.3551225234370818, -1.0501009371182406, -0.9932227865673637, -0.23058781831154682, -1.6660156797344419, 0.9224447419024762, -0.5719123800082107, -1.4711444481631322, -3.3773202083245066, -2.987436820366882, -1.1908853714340752, -2.8339305866926416, -1.5619126292724923, -1.6891477865190234, -3.4865610912943925, -3.4099689127211916, -2.2172120465368623, -2.0452644145892127, -0.5732620319113009, -0.0954496301087336, 0.40326060409801295, 0.8499943436764295, -1.0212988313619358, -2.75239633224973, 1.0281727256666453, -0.7815661772261796, 2.797171905944063},
    {0.3991772697819418, 1.1113904903913199, -1.4021383416481195, -1.3699727378894389, -2.9785655016105697, -1.1279372670398327, -0.98904493339667, -0.20232009943208923, 0.04709954391617381, -1.0976246767299251, 1.2444103592295017, -0.3281046618838716, -1.1055960764291755, -2.996095456209328, -2.239941836889961, -0.3584031398532419, -2.5489297134998496, -1.1092927078109358, -0.8039346833681417, -2.7332020628704705, -3.431041931437134, -1.6723624099664052, -1.9834614288815764, -0.32830645911640066, 0.9413320478630881, 1.4624513618594541, 0.8201501371733623, -0.8709423069784572, -2.272791657384884, 1.3783968556114055, -0.43145937630866343, 3.15353158176868},
    {0.3063144071585674, 1.5678857682165377, 1.1104802418314745, 1.165102345469066, 1.147438290817239, 0.9345546278428288, 1.0698143831290912, 1.7444766303278187, 1.2259194903251203, 1.8603071102929452, -1.6413340457188703, 1.0601511791040028, 1.5788858760812603, -2.034922695856533, -2.318938155306527, 1.2394471078604068, -1.987733632287537, 1.46063875604814, -2.4540113079991706, -2.0413981659637592, -1.338377182706171, 1.023335254933133, 1.520503647993973, 0.6385886094548305, -2.9045076734476507, -2.5409531246684796, 0.6553658246488916, 1.3723073542508557, -2.0017806732475014, -0.3524141639648212, 0.5731436513620233, 0.40175413503235624},
    {0.9188730929389658, 1.907860966905322, 1.8201744561646116, 1.611665134546992, 1.2731229695751085, 1.521715047458902, 1.4810734598876745, 1.7519146330875384, 1.9139504234774805, 1.9228826040035112, -1.0815434677373015, 1.3238711469243905, 1.9880794865998195, -1.7204889641755887, -1.966289431747309, 1.8210225087460084, -1.4520107688674788, 2.1789222674201527, -2.323279313401822, -2.06009411517469, -1.3948864249638668, 0.9138886302566409, 1.8347212578122438, 1.021157632738729, -2.485088315527596, -2.3623905187853116, 1.608451751257953, 1.7912132690908542, -1.5159990954968372, 0.02544937822495763, 0.9521923913422896, 0.9288572540253229},
    {0.8464166678294627, 2.3455254220002875, 1.9524082462718562, 1.8781710279561343, 1.3060003258023531, 1.918835028782364, 2.0876927227034674, 1.960989461057093, 2.0537365726327375, 2.3592866660792446, -1.4900314744329648, 1.8885972757014189, 2.40186554676195, -2.2298453857136598, -2.2431175702304946, 1.9702694316548457, -2.322633582685423, 2.073521266900064, -2.7680664223190132, -2.5920828086432732, -2.28879895269201, 0.8833066291102509, 2.138950782819851, 1.7021862709645699, -3.1295276221073216, -2.7961920117399055, 1.2788344780374177, 2.0248841231620007, -2.0284433792831633, 0.4399953133599316, 1.7696765948041722, 1.5593541978704044},
    {1.2290472055282813, 2.4904019197609943, 1.760438560973462, 1.8032663722552855, 1.3643903666925241, 1.7111184622634004, 2.1108035987243885, 2.4613370449137526, 1.6863773383477925, 2.321545303284268, -1.2569843177825053, 1.6916572082072396, 1.960999171109944, -2.1209917275427013, -1.9202585201028486, 2.1093066247890153, -2.285695452394658, 2.1517167860309168, -2.524756983672816, -2.1859327092718983, -1.528874423216656, 0.9813469115584577, 2.060598822645971, 1.6166931454864875, -3.03659120284075, -2.6091894355174503, 1.7620722669949278, 2.1860491211329647, -1.5313811594379, 0.4800715292424393, 1.7802763656079086, 1.4826523502355795},
    {0.7401536756341952, 2.4428201340177, 1.657404971408927, 1.701194692690169, 1.7848513963413544, 1.7364103681152223, 1.862451454303086, 1.9765667885661953, 1.383267013890495, 1.8577350955061993, -1.431011636889924, 1.4233395215518831, 1.6034154976173953, -1.8983309584645522, -1.4987746477629573, 1.5574059932801088, -1.8555680161009633, 1.8201739398226653, -1.948946772101682, -1.7743494579715382, -1.336843669209516, 0.8871739139247213, 1.9405525213095511, 1.5783797479768182, -2.6561366031851192, -2.0433517976999327, 1.3119867347665621, 2.0098042806483525, -1.599424913196282, 0.02875147618412342, 1.2468043802659226, 1.081344710678007},
    {0.6649133612686987, 2.1606299507835134, 1.6358989335943435, 1.674400986642141, 1.548337233792047, 1.5894484534163182, 1.651076465724876, 2.000853121770895, 1.541045364970509, 1.947025522222049, -1.8987093504097488, 1.561298176356572, 2.0806785083359647, -2.4699105562401775, -1.9177082847979683, 1.5841662909135132, -2.3452623340189125, 2.065080198831827, -2.2757660398138544, -2.5117583817121734, -1.5149401004860092, 1.0168527293622056, 1.8317468832152926, 1.5902608541705305, -2.8597599968075382, -2.425747860234913, 0.7956539066780073, 1.777346836663816, -2.040908962494139, -0.211679957858746, 1.66963365790192, 1.3185754378337005},
    {0.9334910183064993, 2.1388240025199714, 1.6097944364176937, 1.4434406666729958, 1.3061339913464576, 1.4624755292207068, 1.8994972012214002, 2.1180165673515887, 1.9722203251142625, 2.2373461215883923, -1.7347351834771083, 1.9574283226861184, 2.0750126105158175, -2.3881129290885412, -2.1504641624381966, 1.917025833902056, -2.2909723305885707, 1.6074590033537866, -2.9431944045138656, -2.499996519045354, -2.1258840002143367, 1.129878425508906, 1.8296784516952995, 1.5086424316294766, -3.3551984070691874, -2.800004157941867, 0.8635157452788067, 2.1027821244320393, -2.162144552059111, -0.14168704522097125, 1.6251538011887647, 1.5316103981270877},
    {0.8580539863317501, 2.338202437444191, 1.7831487995875965, 1.647418028866314, 1.4626814885653132, 1.5447513783461586, 2.005488825673702, 2.556642571246213, 2.045045373607956, 2.370881000789187, -1.6911618505986348, 2.112872360601846, 2.192389308345207, -2.1767615132553706, -1.9851504011081968, 1.8735183730639209, -2.204238582378172, 1.9943072525363585, -2.8055177233615405, -2.493219414766158, -1.451948982983108, 0.9763119110736267, 2.0403140528892387, 1.453763848238678, -2.9399848977531575, -3.0317944956433234, 1.4106042797287137, 1.9351494592923466, -2.1157259549025644, 0.13994320942355865, 1.488799141584857, 1.03321655575002},
    {0.8743773321687032, 2.7671361512934722, 1.8079451539092295, 1.928633849140158, 1.4524624472943621, 2.0574520775087364, 2.3460316981838036, 2.296028172091107, 2.0321417321862674, 2.3344098661820167, -1.834622066290402, 1.956060305453412, 2.1384700892115296, -2.5953208905710894, -2.3862262900142, 2.168231901920676, -2.649204203490618, 2.176513687085064, -2.906604231382994, -2.581499576092817, -1.565906772217183, 1.3373381392961392, 2.278436847889116, 1.9263585934715488, -3.2718039067017375, -3.023083384408976, 1.506421620730104, 2.075800374496133, -2.406272728400439, 0.2651716127730548, 1.759961104635078, 0.9596993123537786},
    {1.2891226569009135, 2.646910597393058, 1.9424311696363321, 2.003068794138765, 1.4903694612234806, 1.9789657618933851, 2.468895066307445, 2.4753610985516055, 2.1663635398159338, 2.6146034580261657, -1.5633436144769706, 2.0890516492492224, 2.3903422010613427, -2.5112932017951946, -2.1429703866670193, 2.1978112567660175, -2.6059673373104704, 2.200325273023153, -3.1547156670390653, -2.7041004723501194, -1.833944635343308, 1.4957564610635032, 2.302309962786157, 2.095414014756803, -3.114384962985334, -2.879511655434143, 1.951331443165949, 2.5701055428104813, -2.0829490393581898, 0.2845571605282828, 1.766282644778598, 0.9087847208313944},
    {1.2889903413003814, 2.7387598988157267, 2.073582027783258, 2.0655892755069676, 1.294402634401501, 1.8682639808493406, 2.1486187049281606, 2.532967751484062, 2.2596630846913928, 2.6850567388560918, -1.3574212644024266, 2.01890922025042, 2.140357194544826, -2.517655821032215, -2.1403157940654887, 2.222772259689201, -2.3153767572661272, 2.3631985652756144, -2.7838136778772116, -2.3360953254790626, -1.6572911494915425, 1.1016262209032008, 2.0335129061907273, 1.746357657990502, -2.9652914361185383, -2.774778482361222, 1.8536007365254015, 2.267065988001496, -1.9960937546292772, 0.43105624184477626, 1.5390480915212126, 1.0212999050190745},
    {1.3534994584943925, 2.735793789039216, 2.2049421419634867, 2.320449461202993, 1.704861141098347, 1.9525915820464772, 2.277020960413219, 2.4903628375156135, 2.2596926755226905, 2.5527162841114652, -1.6140414777207497, 2.232095496583363, 2.554769118360572, -2.507465138097623, -2.5354608415625433, 2.382157912656952, -2.387033140377863, 2.2624408616045897, -2.8656392359263823, -2.5187552075123296, -1.8493924548263627, 1.636317305309147, 2.2729316954777117, 2.238420383972435, -3.1310730688866597, -2.5945116038451763, 1.5588717430850652, 2.3227620567083007, -2.4369877611305903, 0.15976381838727277, 1.8375141642209507, 1.447339389566682},
    {1.458836748397787, 2.5663048100448633, 2.108958009063321, 2.372848832173026, 1.4474954112872496, 2.2164614987521443, 2.199510433090687, 2.3736364189512225, 2.043786290472262, 2.3200605040285356, -2.2710172703056375, 2.119134454819429, 2.234135819045572, -2.548322384999295, -2.740730547692925, 2.090965788000607, -2.6337548493915874, 2.2492122900016525, -2.8866446408376722, -2.697412550962907, -1.63516342009888, 1.6957786274456375, 2.3211576847567854, 1.9022098830778609, -3.302013694765007, -3.145253427980312, 1.2365909539533142, 2.6022070227905827, -2.4870737649653516, -0.047225332693179224, 1.8080297522791502, 0.9464037171367392},
    {1.2970713734546877, 2.6547953926052914, 1.5144302725360959, 1.9120095977400327, 1.57470505897864, 1.8647587860249788, 2.295385019139498, 2.424196879429968, 2.3222890505488905, 2.643737752090969, -1.9880541167115737, 2.252883024138979, 2.2640559779739013, -2.565690191545961, -2.259890901901837, 1.9429325021335229, -2.2573077977743234, 2.0155172954787925, -2.9324873096416533, -2.7157131711335967, -1.9394438558265894, 1.1667228393783224, 1.879606888888558, 1.7348951646480857, -3.4290012982370097, -2.774971687412442, 1.4348870477216769, 2.335314790219105, -2.1380216568131676, 0.027925624072540827, 1.8086743160887877, 0.7089537363820521},
    {0.9016005508586615, 2.069103444101954, 1.9047462286244388, 2.0574995879627274, 1.8409447654732154, 1.9978518821889146, 2.2584828847250966, 2.170834776350786, 2.0258641207937704, 2.5617457049805243, -1.9620492442041115, 2.1734426868514825, 2.146796869466848, -2.5845975953394027, -2.234924362195381, 1.9415937270507386, -2.054982879303378, 2.0792203774773865, -2.9592269762103176, -2.533138938322802, -1.5270036734450745, 0.8828444118529943, 1.8870116866732716, 2.1271863839856993, -3.1363875313035567, -2.82065668161093, 1.1639775939317376, 2.2803233427734164, -1.820457408901467, 0.07809411360508049, 1.6414784783773464, 0.6101436683796857},
    {0.941219612082618, 2.577321252518472, 1.693033268009683, 2.2535350486049337, 1.8412702178650888, 1.7622462413013351, 1.9950773238243622, 2.4916039123712492, 1.8657933945171141, 2.670087938129136, -2.1631392558612186, 1.8898429478802947, 2.2615052130435394, -2.6830178874073822, -2.80818461547084, 2.0266286403749345, -2.5310703865544846, 2.607079321719782, -3.1965952373245363, -2.5728678397254083, -1.8452258375129198, 1.2792612815732731, 1.7089606199176604, 1.7261518411374699, -3.0030657074912037, -2.777383181400808, 1.4951666217516952, 2.0005598165157883, -2.3070898268119864, -0.39841915930229793, 1.3417766574980827, 0.8635236993267461},
    {0.547453888775927, 2.793583552638583, 1.9925630235706508, 1.9450280472032566, 1.7753746552487626, 1.955439348024431, 2.196917834470307, 2.427369843464897, 2.120634176962007, 2.5155180085628666, -2.0675103968971094, 1.7416062920267805, 2.4233443439030737, -2.516067459271598, -2.550249886328239, 1.9038060642172745, -2.6816163937893878, 2.7053044691245356, -3.002825377092997, -2.7597759848749455, -1.8564291766580885, 1.163160835534578, 1.789469467388318, 1.924801307506557, -3.0331003117246946, -2.829731925716941, 2.0994465613968774, 2.394641827195213, -2.294843575019331, -0.4782356275319166, 1.1752523687809122, 0.855967450746963},
    {0.8531166689278766, 2.849437796236608, 1.9814874117381152, 2.2721242471372807, 1.7680412241958774, 1.9918312097599862, 1.9029246989427706, 2.357650769640556, 2.025720822324736, 2.461219666135458, -1.9883370558703728, 1.6541717454392757, 2.4599833199967205, -2.688813650570773, -2.848581356228079, 2.188020082557901, -2.7172227483925138, 2.624756909282766, -3.0864886835405225, -2.7261838208343927, -2.1830017222063645, 1.6272527531670784, 2.3418882101160814, 2.1145296935985223, -3.2963654091421093, -2.9881654200873733, 1.8803819085177735, 2.507887894723679, -2.5520048857348234, 0.18097314532081307, 1.6932331089432748, 0.7038695701820077},
    {1.217426735552304, 2.946738722744212, 1.6720544685413017, 2.0643912662214166, 1.714847596849792, 1.8745599226630527, 2.2765424901763, 2.4338858940307193, 2.12325799148973, 2.811914068707506, -1.4888550274136234, 1.7082635431554751, 2.105844376257974, -2.6473561370990173, -2.6581614066962658, 2.057970944695165, -2.749497109792367, 2.4381703468212557, -3.20491366818363, -2.666090875254142, -2.146205336819778, 1.781354909028733, 2.4571268708330614, 1.829463629420324, -3.6513340805689944, -2.9563455093520403, 1.5410087304264768, 2.413502886645504, -2.242284307051757, 0.5583058220084589, 1.4493998751832953, 0.6232805497818258},
    {1.3258433000461114, 2.7070264500343764, 1.9184347086327085, 2.1491385995925074, 2.000986867973411, 2.207205388756516, 2.2013262346710807, 2.719208053259095, 2.6103158737038656, 2.914796400426751, -1.7204532335944978, 2.231655458091778, 2.5667641673930697, -2.6087383608237626, -2.536156882920142, 2.072253203734468, -2.336350804424234, 2.9155183648664504, -3.18707771707106, -2.4708962061510187, -1.8799242967283871, 1.7465328031325666, 2.4101160964851074, 2.26025912930491, -3.4636586165396865, -2.9106273303801773, 1.9923267393277062, 2.201884948651589, -2.1945611337089552, 0.29312551996028413, 1.712922616664685, 1.049977688199278},
    {1.1357121110516695, 2.6146209697528944, 2.0495115121790035, 2.1163085147344463, 1.9432216017686958, 1.9674550429980575, 1.9277933838962802, 2.595928892496339, 2.4655084651954855, 2.8393883822871326, -1.8566045948440428, 2.1234928958354695, 2.314974705480187, -2.6019949431660754, -2.523299923939691, 2.1709792467386593, -2.3545199467483213, 2.5555293471900677, -3.100390793004406, -2.475433888819913, -1.7679306633416114, 1.8782651397859147, 2.083537502764253, 1.976566779169264, -3.412586739143815, -2.6951279073856345, 1.6637329354946393, 2.106587168715581, -2.1676250479243855, -0.06692531634456232, 1.6014019155991457, 0.9831176719060108},
    {1.0649601290819728, 2.8898820955948716, 2.2081518026013365, 2.2137597450777147, 1.9390914623924203, 2.0103202588494615, 2.405388004906466, 2.9710168432158683, 2.1794892950614613, 3.1311190547327454, -1.6995510703232166, 1.947331957730822, 2.643252735588991, -2.9726023712994936, -2.985870810068409, 2.27468556799836, -2.900205675516315, 2.625004092743577, -3.3101569994335556, -2.962709999501603, -1.992873809965173, 1.696664567594448, 2.091334749907712, 1.9712126682544788, -3.4334448310831376, -2.845594863771763, 2.144780368202607, 2.2188908285714266, -2.277282933719025, 0.22033356850644503, 1.5154014590028153, 1.000807325773563},
    {1.1450341029970608, 2.6350650039493715, 2.1176864167877247, 2.480402226590289, 1.7828118030230693, 1.890618249628364, 2.474727407342723, 2.8955944359391648, 2.5219478975571477, 2.9963829470662393, -1.2750146576676786, 2.1932602760202613, 2.6952366805198964, -3.1505633361490677, -3.1367005095520772, 2.191807149793957, -2.77485343896753, 2.8475125852619168, -3.6778849390585777, -2.969896901546933, -2.326242398186234, 1.3689719371686486, 2.231158971367275, 1.9716773475007876, -3.408993345354871, -2.7952991590273357, 2.120900087756786, 2.3030962621282924, -2.6134831001179593, 0.5841489657619096, 1.5805403908741993, 0.8906476908117821},
    {1.1753640713317823, 2.4692358407343575, 2.1107905261419666, 2.2418047789468902, 2.229157718106413, 1.9232097649613005, 2.1198902314035424, 2.729286672517454, 2.577552205112592, 3.06094399290842, -1.4137912681453546, 2.277855158633565, 2.613778129537545, -3.0808751771900376, -3.0440019067884707, 2.347342818368593, -3.0773861742815916, 2.7548823335084203, -3.4548450973152196, -3.1500759842104715, -2.5233028203808003, 1.5364859312094374, 2.486824467144264, 2.166480161181291, -3.732159115701805, -3.2830182741579095, 1.997754853426576, 2.487991171139773, -2.6756729103040287, 0.3145791110075627, 1.5497247894507704, 0.5570825898849745},
    {1.3637701528499733, 2.9380902714254655, 2.1997124083379824, 2.2011480222543325, 1.9420528408989495, 1.9488862828110312, 2.233766445229233, 3.027623740223619, 2.605550014557169, 2.6840219679138855, -1.7560753747796911, 2.035432399770881, 2.7515730902872297, -2.972825704264029, -2.6496818267061117, 2.2163334605683094, -2.7063181217703787, 2.9321873918624477, -3.2369500386555132, -3.1175864360087187, -2.179050702135685, 1.3338855326137344, 2.4549650494814053, 1.969818363359561, -3.3155510536249198, -2.9789369356980924, 2.1794056486551456, 2.2271502422897957, -2.3901823741877903, -0.09114755468061297, 1.545696146375201, 1.1300878385503974},
    {1.219450069529024, 2.5778692736839264, 2.1481868993178934, 2.3248335509683504, 1.9953073389308065, 1.9622508127683418, 2.2917016878799807, 2.6926949480224964, 2.2706608505107346, 3.011032221548515, -1.9670529091276145, 1.9432367531845125, 2.7994940398596144, -3.0364612235624855, -2.868513476614427, 2.3621925177390524, -3.103311291984746, 2.8908619673539495, -3.507865805013401, -3.4068969625428616, -2.522108138529917, 1.5632419367044845, 2.5781013497005567, 2.2513820749098126, -3.791682507047769, -3.2446085644302287, 1.7954311100363032, 2.6025302783283446, -2.6906128215391223, 0.023938650203470305, 1.7610694440033312, 0.9196005036286101},
    {1.2027999118292148, 2.8251416573674812, 2.1417556699641964, 2.523863388162205, 1.8824498607604694, 2.1916013952190583, 2.252667998233532, 2.8282040056610476, 2.453837803810202, 2.9143167945184576, -1.560479259041513, 2.1118305258859227, 2.8776615221853974, -3.134348189103062, -2.917360971362335, 2.446899865942412, -2.8290205630224143, 3.034197423299425, -3.6996280129858716, -3.3292324012685954, -2.4698959836970396, 1.7859563202585247, 2.3557625847442076, 2.070464435112676, -3.7008356900067065, -3.1628674135854773, 1.9712968439285352, 2.4577732821082567, -2.547778500587946, 0.2128012293534616, 1.4815441676050587, 0.7910724265848559},
    {0.9875205119149248, 3.040991545995893, 1.732269292793142, 2.09580459292753, 1.7262109597512003, 1.8698173921936898, 2.3116223122759867, 2.8168611609098844, 2.5209177380388064, 2.565063835803827, -2.069627769632508, 2.053467332320187, 2.6112607826988454, -3.32620557811351, -3.1491091369117603, 2.0524136318696597, -2.9986363827381237, 2.855985550243616, -3.6298747150983286, -3.203774083701217, -2.845417369201249, 0.9054835329531314, 2.12493351654351, 1.9374294794514517, -3.381524201052524, -2.957716863561693, 1.893606706485022, 2.5545312464855687, -2.969115014648735, 0.15897334697581522, 1.2312092437687638, 0.9353147496011184},
    {0.8582509745025407, 3.0259266020296676, 2.2263939946036393, 2.556937804974049, 1.6181214007056521, 1.8961659531111612, 2.3443922685407594, 3.0270071373214957, 2.3862650613070855, 2.863990396657363, -1.665555013181364, 2.1761240675311795, 2.6724509055930645, -3.044647973016026, -2.8670564250240784, 2.463753616643922, -3.2013187861303916, 2.867404712241992, -3.3645640347112407, -3.201000692405972, -2.8366485852401726, 1.208353516314872, 2.3881883118588867, 2.223473282930819, -3.342776346068448, -3.1355292671517674, 1.9146519550738705, 2.3333126536431137, -2.793733657283625, -0.13250916765316184, 1.2804092697252223, 0.786393243719766},
    {0.990359515420523, 2.672232611278441, 2.1609088044646616, 2.3985016388526823, 1.7893893518359434, 1.9893110548863004, 1.9511437433687755, 2.67595154709267, 2.0558000659524565, 2.603422848102148, -1.8203191904159464, 2.067071560786068, 2.186788541368392, -3.293344519660409, -3.2303243388128164, 1.926349368859353, -3.155335298895929, 2.869465039311656, -3.410969821049183, -3.1582724990884343, -2.4832409378108515, 1.4163621629816219, 2.4711927255936645, 1.8731051129425047, -3.710714466844565, -3.1723840838362203, 2.086346576174535, 2.396417161653061, -2.7495971889105353, -0.056382764222393966, 1.2583765582427093, 0.9231774288997354},
    {1.6827520712967885, 0.48742168972022837, 0.12173120466789694, 0.41537595921458614, -1.2431485808489906, 1.1452186621582496, 1.0160601450457571, -0.2490043765573697, 0.6927038746127074, -0.17793315187366643, 1.6136464583505215, 1.622433403256846, 0.940584714495232, -0.8351394537136441, 0.17042458894309903, 1.251795718506968, -0.8616101632895639, -0.5916662275544178, -1.3792514646808103, -1.320143240816899, -1.2212496791464524, 0.8838624256852784, 0.6210417338352867, 1.3639449642545929, -0.4332739885582799, -1.0686012378163658, -1.1636774012396158, 0.5578846788586201, -0.15898926328631952, 2.1515341832063464, 1.2426501938937646, 1.4209302038191245},
    {0.7248538777383602, 0.4733694601241665, -0.3403285319030474, -0.06484625975565307, -0.9663170641068733, 0.32062757052316776, -0.013558409152262271, 0.10711156267552853, 0.8005869281822093, 0.25442505506640417, 0.37074942641138897, 0.39253045761444605, 0.09505216732550927, -1.0322623838427976, -1.1351410968759612, -0.553228176424611, -0.5632608511849009, 0.09112217700123056, -0.3434515890654339, -1.0279935352348961, -1.2508573131232044, -0.5692700616734814, -0.6720422047847636, 0.4786912288620072, -0.5112772991380592, -0.057553134290928135, 0.8385120072029819, 0.12833381616144326, -1.2316370056222072, 0.6959334173806955, 0.2902421610877505, 1.0604549604725122},
    {-0.5826037569061657, -0.3761912760498531, -2.1140522097443593, -2.17206236708696, -2.983408547188161, -1.761131543915074, -1.7144067021072649, -1.203605138745874, -1.3479662509209738, -2.317444294101321, 0.6363281930577044, -1.3040495058505315, -1.8754044249501536, -1.8630433420392678, -2.0539803600692967, -1.8837548649722164, -1.8506832954191554, -1.8686846087905793, -1.2569543702782289, -1.9700209627193712, -2.375731409845174, -2.0975369632997203, -2.0189159339147493, -1.454173081295476, 0.4680944472198103, 0.9853243493470685, -0.6322461558940567, -2.023893702934186, -2.028124972489894, 0.7327295253114656, -1.4091338084462761, 1.3306269018640777},
    {-0.3984528503037101, -0.7741870774835231, -1.7145428573480903, -1.8809318334073404, -1.895781094949828, -1.4372570887585703, -1.4073624470292714, -1.6131914531756362, -0.9788788840662804, -2.007598179345176, 0.19307854976433655, -1.5115034737902335, -1.824179136953017, -1.7853008360306541, -1.7691063611340803, -1.4794626137206606, -1.9755619323126645, -1.7264411749688702, -1.2760041127642703, -1.7635753489758086, -2.0899048724181566, -1.8807551857787035, -1.6015167712571645, -1.0579571528650762, -0.3400029024551411, -0.07886620202966586, -1.428457456295696, -1.841514194233447, -1.9389055939419755, -0.15794906121113642, -1.6420808656223291, 1.375962921674211},
    {-1.0570089240598275, 0.1740390626196759, -1.9868997092310536, -2.033081519755999, -2.1493597131113127, -1.8880209310197889, -1.8665036425366586, -0.9794588616793436, -0.7043667254803937, -1.9282704159206756, 0.1859989690230002, -1.4589192029897324, -1.5455046607399663, -1.6463323027563534, -2.236086383145612, -1.354701886464129, -2.0279248423188827, -1.150494380222163, -0.9572016692258056, -1.7918424321734099, -1.8880668829804343, -2.264962769134779, -2.2034256314338054, -1.077949679739673, 0.1336703057133445, 0.6297097676681156, 0.03536941981748636, -1.6808729937675344, -1.674649883887027, -0.2776428675940701, -1.8767347268973962, 1.4599752126327041},
    {-1.1065366217072061, -0.5093141324598959, -1.8620721759481145, -1.5281998584178786, -2.345615906699567, -1.5014730514458787, -1.702349076339503, -1.3662467824709714, -1.0927389907718412, -1.7703677911739357, 0.09227295669796944, -1.7214344659340746, -1.5923569024749615, -1.6905944208705552, -2.0516481814301364, -1.4817421139311338, -1.9170780400405596, -1.3063321915389217, -0.9845157142340054, -1.9938890879949092, -2.12163959830095, -2.12729942470456, -1.7655059868036995, -1.014182845999829, -0.5237921026073017, 0.1110029194774401, -0.5059229479969238, -1.4034850249971926, -1.7601303787591758, -0.5560550893404921, -1.4006601560735723, 0.8065853772341465},
    {-1.6387665563107818, -0.6680104800489011, -2.1018847578279956, -1.994397105374064, -2.0827929519014994, -1.6790726597979986, -1.6253797009057411, -1.5558158540913098, -1.2830389970902052, -1.7354328782817092, -0.03946895116121876, -1.502543580369778, -1.5690388420387436, -1.7612164829556645, -1.9596424855355197, -1.5681317579580314, -2.0499765282522007, -1.5685106100304556, -0.8198165250213812, -1.978158126083106, -2.205494501978095, -1.8243775986707633, -1.6446672492674137, -1.3896023545441565, -0.7993740764450823, -0.10031220444834178, -1.0866864824773355, -1.6017490360342623, -1.8319492896756298, -1.2692108587863133, -1.5936356271706904, 0.3148077455731322},
    {-0.8156657710049059, -0.3448876972814923, -1.7465529266377435, -1.5901896596455285, -1.902791930339535, -1.2107042162311596, -1.201030952980189, -1.5909184892439336, -0.5697850859867635, -1.4234815587210083, -0.33778459376951925, -1.1986028962185364, -1.3934516921309943, -1.7457375288087884, -1.5239766609032037, -1.3329024300578671, -1.4728507887977529, -1.36737681404605, -0.3803398622774453, -1.6206131137004476, -1.5892198349439637, -1.5898928489075037, -1.5490737683934466, -1.2985290580849895, -0.3528535707374149, -0.15905882499078747, -0.8210708465305708, -1.263265651478586, -1.6348412153240315, -0.7243166000250791, -1.2964523287837157, 0.5903074775059254},
    {-0.5231780467707253, -0.1897886452019491, -2.1875845302502785, -1.9030717306384326, -1.822993959814549, -1.7353252255728984, -1.5720348424900694, -1.1149163930614832, -0.9016750183097377, -2.0068839360978967, 0.5138008879354946, -1.5840850373143858, -1.5377247223471966, -1.8327747229309512, -1.7178435076695875, -1.4636007634244823, -1.40507029041526, -1.2642324231789612, -0.6021582679861249, -1.6026617959605054, -1.769322648875342, -2.1855236591629534, -1.9462722416816198, -1.3848734144920853, -0.6778335801053502, 0.3649591896410915, -0.9006355598664225, -1.565467744319936, -1.4658045380873226, -0.47816061528770404, -1.9310493274386502, 0.7239657510252991},
    {-0.3409802341756224, 0.6604035580704487, -2.0319611274229246, -1.745251317752908, -1.8907295759125677, -1.655237370555907, -1.5962287002813682, -1.2755455635303503, -1.3249546854442877, -1.7809763698691579, 0.5030344505659878, -1.3132051723099953, -1.3940871283527623, -1.3716320398744604, -1.3735962620652302, -1.555349549444974, -1.822296234445356, -1.3614382711033803, -0.7737352549113851, -1.603161874315289, -1.9247839054328642, -1.6162806122267872, -2.0377121052713982, -1.731669575082346, 0.4530602767465511, 1.108610489963783, 0.02316844895420105, -1.4114339752671246, -1.7957621529239263, -0.23359606021358473, -1.82690425474679, 1.477248839053305},
    {-0.8351718372117959, -0.6665039788526774, -1.0339076476677054, -0.9875261343812224, -1.7689831073859308, -1.206260131675532, -1.079312164318904, -1.735267746434839, -1.15469871996103, -1.7562524831215354, 0.23637608588269812, -0.7143143780574914, -1.0870193694561094, -1.3601424477196833, -0.962580093238695, -1.4142171528088863, -1.3611161481546872, -1.6206218559575511, -1.1031049625406046, -1.6124774866154161, -1.9168425853194666, -1.0477341489797598, -0.9987286851894559, -1.0649454954187672, -0.4115619858058592, 0.08879898406112952, -0.679821485102306, -1.418266862890552, -1.1605060449840072, -0.40567540218720316, -1.2995312700875792, 0.23374465361581762},
    {-0.6307776715891459, -0.1370177608689644, -1.5904370554633585, -1.4725362656522192, -2.3527299841744584, -1.5345862603958202, -1.472526750748047, -1.8627999592247604, -1.1913573663146912, -1.9119755781777754, 0.18175071877554058, -1.2533431177758219, -1.1781234644427963, -2.23687296142019, -1.8171488183505473, -1.3656401054318414, -1.8456387610017528, -1.9112674577458255, -1.2559430908805298, -2.086559894336681, -2.135642178730007, -1.72619771617446, -1.6666807551910932, -1.2574588621541902, -0.26090300269902894, -0.15531669857930977, -0.8745049620226574, -1.24179836609243, -1.8647088285022628, 0.014361720877367042, -1.2142389139298428, 0.9884750291046224},
    {-0.7074045746563524, -0.20577799961006701, -1.7397788845516655, -1.3103535104706856, -2.1008108919933615, -1.40369875644286, -1.3252925958875672, -1.4138723210409059, -0.9565042876962184, -1.5588621042118633, 0.42674361240072817, -0.969296008590626, -1.0921896678047083, -2.038676198070143, -2.0603447811568425, -1.2076438100210392, -1.8921911107801452, -1.7152953154732644, -1.0886723336772999, -2.4440962364113488, -2.412889769336579, -1.5903319055159475, -1.6360870013453377, -1.4459255197284222, -0.635888678890301, 0.07380202779876398, -1.1014287775935003, -1.0016978816726276, -2.0092365897580278, 0.12527716111323836, -1.157103613007355, 1.06736716917549},
    {-0.3105635121707927, -0.46949456444012994, -1.4456935238255537, -1.7666536707088174, -2.399851920617949, -1.4630756423770568, -1.3722124796666724, -1.5475798561441871, -1.2473624200001823, -1.5633380392792933, 0.8218862422715164, -0.9009950576240361, -1.2983749252520342, -2.423953328384958, -2.007371267605874, -1.6108652163007287, -1.8960869282771684, -1.8880310837466472, -0.8664838636504165, -2.440912872745158, -2.439299412470784, -1.9746178481648864, -1.984253782516875, -1.3476800387805157, -0.4013717122118661, 0.34198433972828424, -1.0152459170764812, -1.1973090799634896, -2.1780142854154336, 0.2210506113155825, -1.4263388628621605, 1.6020492917361155},
    {0.5698625754258497, 0.18335814722159446, -1.512152737845626, -1.675092663969308, -2.693056074856903, -1.1031827777880274, -1.1089839401860202, -1.1210568487246708, -0.692237478367155, -1.4256239536733173, 1.2937637882378386, -0.8660934138475693, -1.1087689398058913, -2.2165047530065003, -1.6927576849966797, -1.0918248925824698, -1.8141831273342959, -1.545512535151074, -0.9966265154446157, -2.4149090530915847, -2.716011651763508, -1.7694409433434821, -1.8372212706961384, -0.6745828432204557, 0.017116372676552125, 0.5376255663345446, -0.20246142489099606, -1.193007214039725, -1.531143485479817, 0.9382482258476219, -0.8400452576457412, 2.2100088011376218},
    {0.3875832644746139, 0.21866476308932212, -1.3955093550772946, -1.358823326374922, -2.547769304332725, -0.8761033300840083, -0.9513063736923804, -0.6949007906520757, -0.32257755945223165, -1.1301726184699095, 0.6048571796416298, -0.4240942196859127, -1.2092063409944953, -2.369935914104143, -2.0294259022583114, -0.5884567609531207, -2.0420311102938538, -1.1927044698230715, -1.237059042933255, -2.3267240388009562, -2.529995772602963, -1.4296154416270286, -1.612552507722928, -0.4528840577224527, -0.3199050474347772, -0.10557250420636159, -0.00924956548824661, -0.6581964038446911, -2.090662950652796, 1.0305101553642844, -0.8799559622904102, 2.107568983009248},
    {0.3240922981928044, -0.40236095751783296, -1.1074163568052007, -1.0371292463607766, -2.6741059603460426, -0.6967527159439362, -0.8347138447613279, -1.3036710434030303, -0.4827536767361647, -1.8511802374830233, 0.9020564804933361, -0.6701829939395528, -1.3151448530967889, -2.0439850299983506, -1.5781192941292281, -0.7694385958924603, -1.623553527326681, -1.776737302337505, -0.663626798686908, -2.15914153663337, -2.5680805483277043, -1.978257347021046, -1.6005184859788006, -0.7116824514744123, 0.51940210186173, 0.48584278918746115, -0.860483955859742, -1.1743164783172275, -1.6940729520867932, 0.7108461092637174, -0.9935652903978791, 2.000701105737046},
    {0.9205171029915238, 0.6877156396618557, -0.9919732240318857, -0.5092872807434732, -2.3078522913056188, -0.39218769533158415, -0.6342653529826471, -0.5499599683687754, 0.2926305162863408, -0.8720672633260724, 1.2497794158779767, -0.05174654120398583, -0.6093446089308457, -2.3843915688814326, -1.8190942593751314, -0.5503553824193498, -2.0940138525209377, -1.148843736191072, -0.8936112455244376, -2.4403259531352695, -2.656167246231332, -1.3491131501506939, -1.6661150269239091, -0.2574985234427491, 0.24799139971488704, 0.6263792652794894, 0.1687670783177779, -0.6372916140383601, -2.196283014546524, 1.5675780464222482, -0.12189026974685455, 2.8666354367728575},
    {0.9136405423078392, -0.0067266512833926905, -1.1129271321773169, -0.6562757118020882, -2.1952378559419587, -0.36458197152149274, -0.4458141445278543, -1.4698667389874815, 0.09487895952011148, -0.8590213853781874, 1.0554149386330354, -0.4032189969981057, -0.7641582596851717, -2.4407455415632415, -2.2057587616035117, -0.4599707657995786, -2.113991846282254, -1.323773051797839, -1.6242929231159007, -2.6072988041723013, -2.725411329499594, -1.287510820126975, -1.5482737618699185, -0.15691057608751266, -0.41010893710913277, 0.18589863470712142, 0.026898717024092033, -0.6583037682725201, -2.0126474569756123, 1.5532540307887017, -0.04567182879988934, 2.604225515126674},
    {-0.023040737877179727, -0.8046394030902778, -1.6967702583251747, -1.883236405874784, -2.6646713787014926, -1.3944005243808544, -1.5404365929447006, -2.0573593910969907, -0.7691344023081241, -1.7613896681693308, 0.7018319973521209, -1.1210741947642624, -1.6147210017598637, -2.795354257326106, -2.3137073700968105, -1.2368563393542575, -2.411273207688332, -2.3941531060859935, -1.7187139127633446, -2.794752244085891, -3.0640998855052004, -2.203727781621516, -2.216064510533492, -1.2179776876385353, -0.6561943744671714, -0.2245310583658249, -0.83072630831239, -1.258328688040525, -2.085343274285285, 0.4138777942645587, -1.3448520293971595, 1.834348964364882},
    {0.9339721315324813, 0.10446394460094806, -1.3505634035363978, -1.4360468993068698, -3.3767707571227623, -1.1798250817725906, -1.1749045242917122, -1.2050197979884576, -0.09856871286333425, -1.9065437817958202, 1.477200032936602, -0.31357996594856086, -1.0816452766960947, -2.850387624695927, -2.510626471725131, -1.0697383238695781, -2.4785386250658106, -2.0101651147296304, -1.6197448305722093, -2.7139164970292073, -3.3025398227387903, -2.1329376290774205, -1.8297711189037322, -0.5829572352901402, 0.42855808298409115, 0.3780233054624402, -0.5306225313182279, -0.841876273302574, -2.5196143566039093, 1.6115120541895733, -0.6988987197690318, 2.3527618835347957},
    {1.9242345733701833, 1.1743020196315284, -0.4633461315452188, -0.7022487912066164, -2.966010155037118, 0.5134930464066337, 0.4600556090832413, 0.2950309476471769, 1.1915643725449507, -0.36897310188680427, 2.5680084598681834, 1.0187504049907432, -0.20166375518167656, -2.790802314227919, -2.1613182561110347, 0.481916871271393, -1.8241234094181358, -0.369375079931874, -1.1775219447845575, -2.594336041054794, -3.683814530402726, -1.5232540428792556, -1.3512829003291449, 1.2046596932513085, 1.0637070355305933, 1.5410813835957113, 0.9997126197612011, 0.283043417929101, -2.1246987164651165, 2.9087476344325154, 0.9041170780462665, 3.56812139729207},
    {3.0031383561706564, 1.7457142189877903, 0.04064829689529168, 0.5681987906025274, -2.757302999285659, 1.279526068573836, 1.5421729721417359, 0.7281183747209647, 2.3371949951167657, 0.403391257557295, 3.123739580077371, 2.0821322835084497, 1.0353032452732325, -2.099699461604015, -1.469528405428047, 1.4622700170750644, -1.2135938242910898, -0.020477771351089743, -1.296533811149923, -2.529220554753863, -3.5292592228821946, -0.5621615363139288, -0.36278537323944116, 2.1595196774248517, 1.136916525772339, 1.5335474619281013, 0.9899958644963972, 1.44769796867976, -1.1223215913954245, 3.4867953435449377, 1.6356730400190265, 3.9502723129217},
    {2.1044078848098113, 0.9303005982243411, -0.8241940546053613, -0.7108839568023418, -3.521865720300509, 0.21572623126543314, 0.06410175505476025, -0.30541548178767114, 1.0247035221317216, -0.8625168224686627, 2.8842907317539197, 1.1138596651933934, 0.0026486746524553516, -2.778171226190142, -2.3226604651100726, 0.3936549701260121, -1.8854069652303578, -1.261757163581398, -1.869598776554491, -3.0693545526267862, -3.717804502514736, -1.5279956433855797, -1.411283864332935, 0.9394998208802536, 0.6881585546056354, 0.9211101107199879, 0.0941897270317801, 0.2912750511619718, -2.024339615599215, 3.158034751416445, 0.9083368189967771, 3.4297710814444886},
    {0.913022345796039, -0.19432641426708994, -1.646415325253458, -1.8841127198960432, -3.567787131237436, -1.1320797088436594, -1.215439627574521, -1.8591866005598168, -0.07609774464274358, -2.0926762850334253, 1.2526122848893977, -0.6171252201637051, -1.2080055928944216, -3.3227064281081535, -2.873395081732106, -0.7824070462728941, -2.8549405419356497, -2.248776667051849, -1.7445038038653076, -2.9610804521579355, -3.6387600536422253, -2.3476628899908936, -2.0631690213000025, -0.2840167561652474, -0.21145318957797726, 0.03183442660860688, -0.9218097511448851, -1.0867449925934443, -2.704685033471804, 1.569136653666567, -0.6308761710730604, 2.7877371606952672},
    {2.1847714002817193, 0.999140305643968, -0.15877087234367593, -0.02229752070404829, -3.1390896415435408, 0.32044500418429067, 0.7094191824723672, -0.5903277415903332, 1.3438664347828824, -0.5374985799187341, 2.599499260531267, 1.0923257444134762, 0.3567570695235768, -2.9739164040023676, -2.2991497739264113, 0.866056509092134, -2.025611932402023, -1.3882441795156868, -1.6606641091413086, -3.0465003356407774, -3.6099068834096455, -0.6172387171173331, -0.8019156313042805, 1.0944004755379424, 0.41259004030528296, 0.4162625818215305, 0.4310752007215613, 0.6230064954883927, -1.7685064409996236, 2.796357201027098, 1.1174704056730418, 3.3718495013456153},
    {2.391604850639722, 0.5886581806035208, -0.7740180163068696, -0.6124157828105731, -3.522206105017277, 0.5059394392713807, 0.5671659625036464, -0.7380686268841932, 1.205605866493743, -0.8855796848570809, 2.623806307254713, 1.2989662825822128, 0.2548226111704404, -2.8509561323992356, -1.9900384870015269, 0.6145388206639815, -2.2145079687097655, -1.712967594513207, -2.1287349136001814, -2.9512097953676433, -3.4576313359788107, -0.7137714052393831, -1.2350678043412546, 0.9423040377052292, 0.1476156088289791, 0.41685732421006727, -0.1895323130914734, 0.3226771082287794, -2.0236593179606426, 2.7612502087263664, 0.9874005989608068, 3.3920026654883224},
    {2.0307792914837686, 0.5583236645269932, -0.8911795981636119, -0.7259856599817008, -3.4232603842481395, -0.12549509686383237, -0.014201942594786339, -0.7041760468653048, 0.88968899300485, -0.9313543958707136, 2.50086902318684, 0.7963106078929525, -0.06760586186294439, -3.0160537699943073, -2.294772987825294, 0.2675327157428626, -2.65793737771211, -1.6247859930738258, -1.705868997327581, -3.022787294955028, -3.5361213308539137, -1.1694468126686273, -1.336528017431717, 0.9164993345203553, 0.44780911751826785, 0.382579331143982, 0.2614409216007816, 0.07204351905100291, -2.3918438438844767, 2.6006333791764065, 0.9187262595360983, 3.1537068900503678},
    {2.5575029097201036, 0.8196911734281861, -0.6081580902766303, -0.1757907438245017, -3.1725194041624762, 0.6890565737437163, 0.5008601524428636, -0.808107026638089, 1.5737749671826893, -0.7171349914475188, 2.8526374203749048, 1.4186227436949652, 0.14582674246872693, -2.946922098334598, -2.104506247089695, 0.5211736819210041, -2.197882638538341, -1.4043174278676873, -2.1231487384006145, -2.8690178304352716, -3.4105681970498347, -1.1249719207421847, -1.168783964339236, 1.2003179398296748, 0.050921589716003884, 0.29910320883413466, 0.12655910746193566, 0.6280456622565852, -2.2054300140088907, 3.038121705992151, 1.329914483351758, 3.625894201590856},
    {2.739700922981148, 0.9782262181466603, 0.10573806991117804, 0.0883015541210274, -3.235992512236239, 0.8711072287420262, 1.1301686098850947, -0.16353842842896718, 1.6651327547037538, -0.10537265633581186, 3.086551201198225, 1.897243642382454, 0.509226257031026, -2.4446812304914975, -1.4857423735368531, 1.3471765598054148, -1.562016546041729, -1.1117181735299626, -1.4269615817559325, -2.397715993349266, -3.3025203781535843, -0.4209777995522379, -0.5035321417001267, 1.6410489756084903, 0.7290795962456362, 0.9060521805945827, -0.020547043704252203, 0.7143549837080932, -1.190819528463151, 3.3153741492933904, 1.4643489332304391, 3.626116988505928}
};

static const float b1[32] = {4.655547603144224, 4.939602872682394, 4.64323906444759, 4.611247366331005, 4.764075523641557, 4.403887792409997, 4.55285154233226, 4.929389597403323, 4.53828252280107, 4.685418078206519, 4.856905850627592, 4.559688768836756, 4.567850373747034, 4.897437498229387, 4.877460707154972, 4.460830360481553, 4.899392786275638, 4.974386717232507, 5.022805257971213, 4.954376417106932, 4.919743925373817, 4.661690385412531, 4.594078170323526, 4.586608109534914, 5.027687923967426, 5.0396469577494045, 5.016692992782989, 4.540500558264493, 4.7664311381812166, 4.735166535795073, 4.528819941031562, 4.702922140586247};

static const float w2[32][16] = {
    {4.040970578604417, 4.084032597911844, 4.122477446722856, 3.9700309986902105, 4.032977090328649, 4.105529129275102, 4.071228951405956, 3.729074860541458, 3.700440456855224, 3.6790211978958967, 3.786645835293965, 4.25265326858212, 4.0152084691798064, 3.9980396813951913, 4.255892643183155, 3.9424461115463743},
    {4.454808852087824, 4.137671111710844, 4.371629298233205, 4.16038677346341, 4.187433763169539, 4.207085439778134, 4.23682363805232, 4.428735425073355, 3.9654181608341545, 4.459411570421229, 4.287091554957656, 3.846151721908911, 3.777489872777335, 4.076489391764375, 4.402039457663235, 3.894045572428429},
    {4.1933767760098775, 3.762353967507563, 3.9360809645606327, 3.8020442105342536, 3.8777493271455397, 3.9711758240921737, 4.2771257597851084, 4.133781784678838, 3.9741537431603895, 3.83934473704981, 3.769840725734482, 3.9466145337889973, 3.935763812436467, 4.221938990025578, 4.29588348553962, 3.7526451015496467},
    {3.810152839480613, 4.26723783655802, 3.840698934987574, 3.9181857185362845, 4.304067845298885, 4.216967563993081, 4.104570666824259, 4.28695347239323, 3.8344295192037765, 3.730079002631473, 3.9611689431541595, 4.081312505624557, 3.6041800524967234, 3.6311778827450203, 4.037136169524144, 4.021637079292512},
    {4.502746454027142, 4.139039704868659, 4.386962659077478, 4.225445751349515, 4.592705578782841, 4.3724506371208545, 4.089865873434725, 4.3272833645815565, 4.051845029032129, 4.287698452775531, 4.297693595875652, 4.566898650029317, 3.9650676099751476, 4.175426320216614, 4.352685946294858, 4.316930202641504},
    {3.976553032779432, 3.987273609716997, 4.03782246716988, 4.088559668949923, 3.9084396486938107, 3.7504190718834467, 3.8107245335789, 4.0730163952357, 3.6240638524286735, 4.048975243331188, 3.9798310757104405, 3.986670872933589, 3.72785837000604, 3.744375695556298, 3.735791521885143, 3.9385441882775893},
    {3.8473163622006443, 4.139101309485919, 4.206383050578047, 3.8634844317300114, 4.287030658322445, 4.1079671891526806, 3.9178126799116724, 4.216796750879926, 3.9160231905263303, 3.7043949869452075, 3.554424647970295, 4.195680434707747, 4.192733032096027, 4.105523593970189, 3.9531972685654786, 3.737096161074795},
    {4.421983913578831, 4.2287801762680335, 4.220027039576194, 4.674254163232144, 4.610607851708332, 4.200528911691211, 4.621362705125009, 4.284174694860403, 4.2745473100294555, 4.538131792002377, 4.494439193026751, 4.172996412093527, 4.676890839906863, 4.462694148563435, 4.56192688130064, 4.693819859022129},
    {3.9880170253531473, 4.183136180787786, 4.001984603850468, 4.233060700471621, 3.806451999364375, 4.2869127677774, 4.207741573688205, 3.9447867840406423, 3.8444481477798793, 3.6842602096618977, 4.293884742638941, 3.6634160675595755, 4.033239326948105, 4.291494222860743, 3.834415704917909, 4.025309194465407},
    {4.431832225312041, 4.209576672761027, 4.30543538067214, 3.7791239399358973, 4.043664916843139, 4.2729514822737755, 4.3660306250862115, 4.271486086606696, 4.32812322574386, 4.047435702441755, 4.295519258658582, 4.27764121361056, 4.210396943914804, 4.459231364042367, 4.486160054371619, 3.8809204252903524},
    {4.093209636310202, 4.347574528392039, 4.332840747761299, 4.185335326249235, 4.261661145681297, 4.238699209200127, 4.6700521812530535, 4.40757881406831, 4.590234297511936, 3.9961679786480606, 4.050129937140637, 4.097895786894413, 4.0946807031449035, 4.179615496756347, 4.2595298760578455, 4.043164147561029},
    {4.016050728655698, 3.9223731172113543, 4.2294617431038075, 3.95004180977058, 4.135602319323792, 4.0364757724095215, 4.218343020641976, 3.9655792478228644, 3.785062785938387, 3.5412225301211318, 4.064148124771152, 4.147956954466082, 3.977769376232617, 3.8588460045309882, 3.905992881420288, 4.1120197345118426},
    {4.126743654475643, 4.031661714171346, 4.297553510754185, 4.107915672005866, 4.121239039036075, 3.8583424457862763, 4.292723055235434, 4.120313526213168, 3.459492158569525, 3.9107615703379435, 3.8442023918742003, 3.9853102341087223, 3.9211714403029823, 3.785706085379274, 4.044207369068395, 4.062639144602196},
    {4.522100476358666, 4.761133953241945, 4.416940080369395, 4.201217029080134, 4.709428684340977, 4.40018310840476, 4.610802786304631, 4.373217936992623, 4.1510048043322385, 4.069915637374082, 3.965915087660167, 3.992094009966813, 4.436138354171165, 4.064892848737759, 4.632225556225281, 4.413458612654448},
    {4.247183068315789, 4.446593329690642, 3.9573833996367007, 3.9164658426949006, 4.252327522215889, 4.0774087818938645, 4.373585972652987, 4.170825865572835, 3.8795156404609776, 4.100840106435119, 4.000447798050158, 4.119253424961011, 4.417782325364821, 4.068159891131768, 4.42944514292029, 4.354244026234808},
    {4.239220958181489, 4.386526994768376, 4.233186726303771, 3.8189885892678404, 4.01068269283612, 4.026160367317981, 3.8727577463330634, 4.166545864462689, 3.7403105200339297, 3.656690217897533, 4.033154547396231, 4.223195002073206, 4.177714037019782, 3.9918160762358035, 3.762335203013364, 4.334120753895004},
    {4.175929138609154, 4.563226308584842, 4.128517592363458, 4.266876427098467, 4.020888299598362, 4.027304737286141, 4.3722702464055825, 4.269449990180406, 4.121176831647759, 4.016298114295745, 3.9425965629221316, 4.461525372035394, 4.136672319923606, 4.338982507270815, 4.68290742897941, 4.125321080509569},
    {4.401086683432094, 4.467641966236389, 4.486327086111307, 4.351529581722594, 4.764914821695425, 4.169760545511382, 4.6264460508386325, 4.211202224058225, 4.221926143906767, 4.756268384665889, 4.80551904804444, 4.119210232184605, 4.1381664856556775, 4.293267539820249, 4.247204353716048, 4.4664975588467675},
    {4.821947975836919, 4.720817549352424, 4.692586754794741, 4.561290378681413, 4.371360784156449, 4.351657230896686, 4.457480244758837, 4.524134839738711, 4.26414994048421, 4.750533946296191, 4.683367487224635, 4.347363572607583, 4.263612344082569, 4.55872877100849, 4.436742723963581, 4.3914630058240895},
    {4.590108692212115, 4.483644027284286, 4.103522291921447, 4.429444134354399, 4.203493565363485, 4.242901718112147, 4.225161792005935, 4.402571841644832, 4.398964715642118, 4.602259337843691, 4.346616591677628, 4.127283818649413, 4.052158230500911, 3.984283681912068, 4.631428602228581, 4.683581267778092},
    {4.454310674339396, 4.8443545647874195, 4.726798795082111, 4.49220370428678, 4.825126162925108, 4.523183209995459, 4.305994287634863, 4.138513462092333, 4.13913947977244, 4.668823474068727, 4.4763798981233975, 4.343451775224768, 4.213365694578961, 4.121673095323547, 4.577499983770459, 4.220443388305547},
    {3.8086096418400763, 3.7571767522307296, 4.406607237053638, 3.932637880178283, 3.8354440423842986, 3.797455586706723, 4.121852309786735, 4.182940292595325, 3.7216877541472093, 3.897133669118075, 4.025214139320948, 4.195074494745689, 3.9704873199345707, 4.2779993060453965, 4.289151266821072, 4.049063602168535},
    {3.7979140359775156, 4.252407654014649, 4.132286018485657, 4.19503084319455, 4.045315145678453, 3.9318041621591657, 4.28842066710132, 3.648285438411816, 3.851608345404212, 3.752392216902533, 3.9805897526471083, 3.639762720338641, 3.6693691379277236, 4.08978755884006, 4.12687188195198, 3.7954930554845885},
    {3.8277792179581644, 4.22354453985985, 4.287888280528546, 3.8324283419394582, 4.297881061688757, 3.9505022553231113, 3.940628584937053, 4.150609949518475, 3.605877444715259, 3.7364234252157424, 3.7892558005847845, 3.714068077851775, 3.7637688468137718, 4.002842606885433, 4.183955740801904, 3.8133179750251167},
    {4.366286153194126, 4.332899980179358, 4.703139635675794, 4.11201642408077, 4.553197239813264, 4.196183487376628, 4.565181468112015, 4.500379863967353, 4.201288190620875, 4.738919036228255, 4.212130582210617, 4.391490471552837, 4.284487523244944, 3.9469323800375773, 4.622174136790938, 4.7415319247318655},
    {4.217224492851974, 4.171784401721865, 3.6927499132766424, 3.7951241809997174, 4.350629999590643, 3.7055759833499247, 4.06357303435203, 4.174029027904784, 4.173262317658782, 4.194329451048172, 3.7682997509087226, 4.19164214196107, 3.6213256697351723, 3.967530900917079, 3.9576499888109415, 4.0173989171605715},
    {4.2798431872241265, 4.046420591010382, 4.182774634668445, 4.440007412568211, 4.288463795037642, 4.062105005140701, 4.309806658594521, 4.115774241423153, 4.3159326474979185, 4.629632733431788, 4.042962891345993, 3.836139270302284, 4.235257227355069, 4.449133772803156, 4.539729887727427, 3.8343840805259966},
    {4.030931703155174, 3.7936080521318227, 4.338564297383642, 3.8854841410285137, 4.02874767696809, 4.192574948165083, 3.9735807424621643, 3.9296055366216778, 3.726791247286357, 3.935873805056676, 3.7213112645033455, 3.9676089157462133, 4.225233483339538, 4.233762352544312, 3.925673103425522, 3.964216993577416},
    {4.5094376521579065, 4.293961651726618, 4.494074175839274, 3.9372881625203053, 4.225794915646035, 4.573048291995487, 4.619801078044452, 4.2031010373501605, 4.372214727957144, 4.0104795545044984, 4.274968415652214, 4.130491195684051, 4.027086214673882, 4.550363285741252, 4.198562257054019, 4.441512820901413},
    {4.038698109117121, 4.450971386684133, 4.169915368677088, 3.766070870931524, 4.104336637146737, 4.026329993990542, 4.126738419955152, 3.997118277609515, 3.775822537797704, 3.999991367750821, 4.2277054429872996, 3.9835160893207036, 4.273337627088925, 3.9451844190739234, 4.08074274627053, 4.317093009353003},
    {4.052227734539252, 4.333665686791182, 3.8804977057440344, 3.6341486087999373, 4.27430697182285, 4.003234605982094, 4.08499002144844, 4.229136972613503, 3.550090982206061, 3.692655496143926, 4.1659393525003905, 3.9014802400672073, 4.292999251128367, 4.108826200920102, 3.890928464726965, 4.278179487000048},
    {3.8040874058976026, 3.7465611715086107, 3.918592717528397, 4.136267474704938, 4.2190580798580015, 3.7732714979898963, 3.827672110584473, 3.9852102374581335, 3.664940066635367, 3.9656624216821283, 3.9904644512133034, 4.112626199067206, 3.891291656967653, 3.714254425535058, 4.479793485976282, 3.966862946059082}
};

static const float b2[16] = {3.89241503525346, 3.910487903378731, 3.9864209722869153, 3.7892637937741265, 3.9239132265770285, 3.900308030349787, 3.8420110033870083, 3.898428078912318, 4.047583843206729, 3.772678950728314, 3.912552263842914, 3.9944028049183973, 3.9687667944593814, 3.7385082485408647, 3.7307245876066135, 3.9096763813635182};

static const float w3[16][12] = {
    {-3.0081926925620324, -3.2509180491782805, -2.725389997643247, -3.407599102598196, -2.561437060052625, -2.552338080335602, -3.1774392340296704, -3.1049836133306554, -3.349728694659895, -3.0994734694939976, -3.149157692688853, -2.4751676973820573},
    {-2.601148262515103, -2.6268741126319917, -3.0580496861681525, -3.208831842391401, -2.6609160383511625, -3.1279022099731275, -2.7954838317677586, -3.130996207197724, -3.2264784614338713, -3.3741689818439338, -3.350463224006405, -2.9137009824825735},
    {-3.116661285049387, -3.1480748483832848, -3.3834398463409125, -3.0110253525110826, -2.61598923656541, -2.9524007651404336, -3.1327446364589435, -2.9396965225768215, -2.6853907436392372, -2.953430588581889, -2.6222238966934146, -3.1068139978929583},
    {-3.3442698237885735, -2.8400281374063763, -2.5656108853295825, -2.892659993651199, -3.4252369510454597, -2.7211670831302857, -2.670586567294123, -2.6388186712417614, -3.4769058929770016, -3.065472418647474, -3.5253796080227984, -3.1149883093976776},
    {-2.628854849263509, -3.037144027329666, -2.8792368528900187, -3.1924496300118577, -2.71227845935589, -3.389425718763649, -3.161806263882507, -2.9444870931799865, -2.9678272742022123, -2.5425822716771385, -3.1116766608849376, -3.093945265859315},
    {-2.55937372617619, -3.2891753218219715, -3.1269271866809643, -3.0267804008658854, -2.8704841562863987, -3.4193223693825967, -3.4235294556242626, -3.1820688218128965, -2.711439992525944, -2.8382298690035244, -2.9797949771899583, -2.9732829173959283},
    {-3.2177711692680875, -3.1046137720156075, -2.9920933287137736, -2.7523868079249416, -3.023134073895894, -2.913235877896402, -3.392276120153994, -3.062851199422985, -3.205836468648256, -2.996057835955027, -2.785088233500677, -2.518129537499378},
    {-2.6284226414953924, -3.074598506243729, -2.7421445785635576, -2.714506223881265, -3.1698919767312894, -3.10822941376839, -2.7234294413633995, -3.150754604385459, -2.962327115040987, -3.4176755295378074, -3.1294006682063946, -3.2697941063204192},
    {-3.023976423685394, -3.175043270874706, -2.948999528220836, -3.347163718256143, -3.0116447758527864, -3.031223019680875, -3.2778286690447724, -2.7277783435390437, -2.887307070848747, -3.382279834573037, -3.1750666883197822, -2.5025381646927767},
    {-3.4784070000848444, -3.268899609533046, -3.408477608361112, -3.319025953520295, -3.5710313691557043, -3.4826467780186947, -2.726973463114364, -2.8483176644235906, -3.0269445026145814, -3.1965361376497627, -2.788857968586399, -2.7782762054210224},
    {-3.420227526515934, -3.053217380393136, -3.315018836406084, -3.3836931358783864, -2.699053909535313, -2.778095733652423, -2.735002388171468, -2.832692603825731, -3.145420600303016, -3.049779005767156, -3.1068235482038022, -3.329413605282818},
    {-3.046380988447159, -2.62530425045584, -2.8134334586694454, -2.7998346688594875, -3.0601423601662714, -3.065419953026673, -2.953003523549024, -3.3601486233694766, -2.680698743329742, -2.941601644932739, -2.6386443342236707, -3.381018967170197},
    {-2.789181368392157, -2.7285230725171137, -3.2410965074405045, -2.837295539551941, -3.294092565221269, -2.9325364449886906, -3.1822570981974225, -2.999279098049459, -2.924019239349536, -2.7340702445737914, -2.7211367610274775, -3.5244993308722163},
    {-3.0404212152482937, -2.7464026850977112, -3.4350929325720276, -2.717372712789962, -3.2566925601243955, -2.48219392067564, -2.617531665463352, -3.3612266386800953, -3.086453680033093, -2.7684220003884508, -3.526837316949058, -2.6436488040723747},
    {-2.9904893293986303, -2.8000836704644385, -2.7837817826512707, -2.6542833721173777, -3.381955204086925, -3.3209593581935635, -2.8192902366202013, -3.2197382383823503, -3.075022154694782, -2.8872125821913124, -3.0017368209428312, -3.1465423254143676},
    {-3.3606178623455745, -3.4637221197820023, -2.8527871177986595, -2.935607733769443, -2.921265065444367, -2.8966742502297262, -3.41288169480619, -2.7006777212409947, -2.736692414956505, -2.845814263677713, -2.659034354235197, -3.4448888866983505}
};

static const float b3[12] = {-1.494267250633761, -1.693506526572797, -1.3842995812138619, -1.4469567273790978, -1.322996625923361, -1.7400522436399948, -1.513439175240974, -1.5000634138697755, -1.8256399367359883, -1.3844088657737288, -1.1828870484997036, -1.1325191375206152};

    // Input Layer 
    float z1[32];
    for (int i = 0; i < 32; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[16];
    for (int i = 0; i < 16; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 32; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Output Layer
    float z3[12];
    for (int k = 0; k < 12; k++)
    {
        z3[k] = b3[k];
        for (int j = 0; j < 16; j++)
        {
            z3[k] += z2[j] * w3[j][k];
        }
    }
    softmax(z3, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
