#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][16] = {
    {-1.0529411618526812, -0.188073306857435, -2.1549443866009406, 2.4512681532932867, 2.919261571822514, -1.1043943032440706, -1.2307806610092686, -0.7699250094809006, 2.815628222386095, -1.556599998434684, -0.9819490824128176, -0.5166139698277689, -2.2375683473147396, -2.74032971489829, 0.0668254546163936, -1.3918283601718076},
    {-1.6385437909836595, -1.215658785877763, -3.0446263174921184, 2.8186401091501905, 4.560527019728162, -1.6697388358824687, -1.7346339069896273, -3.058424207454635, 4.609614754818246, -1.7518866720659856, -2.8388411120666976, -0.805891394821637, -4.994400396516079, -4.216600638486506, 2.0647816302546738, -0.37906095080244057},
    {-4.938253080416733, -4.192396174743353, -5.135338641769536, -0.022951311554966766, 0.9097224753556892, -4.461959162946339, -4.849628513481887, -5.553312842654572, 1.9314562373864608, -3.0886169665866534, -5.219162494892151, -4.092047814120909, -4.5131545905167565, -5.881240775168522, -1.8989975005543611, -3.9056711201601892},
    {-3.5900528040135797, -4.012495320443867, -4.588591041308536, -1.4922821037596634, -0.7392045066184567, -3.564698185770826, -4.843312444214279, -4.896960611648126, 0.6878483048436745, -4.374651263965044, -4.472175100090972, -3.391265029470933, -5.237409900851446, -5.516602513559063, -3.633394499829905, -3.328621083848847},
    {-5.017344310958984, -4.548868464980875, -4.875509419305638, -2.257846720225042, -2.4006813243787386, -4.763911594276647, -5.039424317471777, -5.357203200134938, 0.09737165024228214, -4.999437488018051, -5.42020696584777, -4.4114844313643164, -5.526377455752924, -6.291907748005115, -4.242070571602631, -4.336124756596241},
    {-4.660148534738428, -4.128060477658841, -4.4812290832695885, -0.8906002403767406, -2.0809426183988116, -4.417955915724595, -3.8162360201135463, -4.70760986434116, 1.289356207960896, -4.349440879882166, -5.310117774309471, -3.917536103410227, -4.130693701263532, -5.6857160257232096, -3.366763756313721, -3.9451869955723042},
    {-4.470365890115262, -3.955584302301802, -3.5144027761908645, 0.4710221114674204, -1.2220196997017874, -3.7895588735382226, -3.100647548712535, -3.6035683451481146, 2.0350727925047574, -3.7824884477000844, -4.927205181825493, -2.8051228877077863, -3.830143162651677, -5.011718474894888, -1.6507022552238053, -3.2725730192533202},
    {-3.68334601812496, -3.89807095421593, -3.9838376435624134, -0.7658166816177644, -2.079544646900598, -3.523965612788835, -3.771106910396449, -3.4236868087860737, 0.9369967573812052, -4.170626167067575, -4.061348743925287, -3.1133390229945173, -4.423163775801504, -4.604169843458466, -3.0503951137505703, -3.6917069994806244},
    {-3.1145850886602378, -3.8028373276875573, -3.9000015796459904, -1.8344506425428306, -1.8955871244017843, -2.900887257028006, -4.355884165047967, -3.479435562379091, 0.3894746374381219, -3.946828024690247, -3.7199419974120875, -3.0548776435846228, -5.076891036004124, -5.118414578270995, -3.2075399678487106, -3.165097865985811},
    {-3.5196562267334066, -3.4774893486762712, -3.8385319306384997, -0.38609608194917994, 0.16630837690513375, -3.4492861832496295, -3.895956758005198, -4.196936792893457, 1.66101162269853, -3.9540190423966557, -4.057635552159812, -3.117821992747518, -5.6909015630775714, -5.356206992851513, -2.3328662144540657, -3.2469606469401913},
    {-3.3982728942396228, -2.157062102976393, -3.1445331414615216, -0.298376142482155, 0.4572528417470708, -2.6097079514919193, -3.0708857902506517, -3.8053673312029406, 1.7789273789464828, -2.7928969663405683, -3.632049515486538, -2.1123801523333205, -4.8478451488363135, -4.628377226444723, -1.9293861793586558, -2.2011940033021107},
    {-3.2483469349176213, -3.2844276951367144, -3.212128220001617, -2.1532935135215694, -2.2404944386139185, -2.6287347776818697, -4.051511828579605, -3.5838799690261838, -0.2563275750586216, -3.161568550080197, -3.3438730126203535, -2.7340504963680163, -4.759450553885827, -4.061483274291161, -3.2768196636399933, -2.8078922387416054},
    {-4.133991689318338, -4.208528318674434, -4.162188290409691, -2.9781187222227863, -2.9757008207974964, -3.804128732656171, -4.911016077778535, -4.593273506872599, -0.5300365731484209, -3.617362635701945, -3.9782372142238374, -3.787114253291782, -5.4569169199895855, -5.006482422035629, -3.923382541582343, -3.82705535575165},
    {-4.695853549654545, -4.663921098362757, -4.615127805634533, -2.7992423161148543, -3.213211946405871, -4.450568257357151, -5.183138639363642, -4.845760437385367, -0.4092296726774661, -3.977016275099984, -4.642150020218085, -4.202941996852468, -5.557210025359643, -5.49880224574425, -4.052796024067326, -4.341406660570534},
    {-4.394362367310531, -4.153242806089814, -4.3141674383808555, -0.9340826840751311, -1.955414128663273, -3.5813046580048007, -5.00655314403539, -4.526807486003085, 0.7840633826741464, -3.785015262127659, -4.446030379110211, -3.8230228405046653, -5.265595491490953, -5.159599835523521, -2.920552773768269, -3.899066811485286},
    {-4.056083019623496, -5.0584680777548225, -4.137578039413046, -0.7243290961458874, -1.6331570367725803, -4.09792621090335, -5.207089795499404, -5.201118059126281, 1.476947008854154, -4.507361838438545, -4.716752431630022, -4.324904486089537, -5.666861947643148, -5.7963463810064795, -3.2527538430771865, -3.992089545420719},
    {-4.078061539249122, -4.681155193812604, -4.426928775414904, -1.4809590450638137, -1.625365449118001, -4.065210747786784, -5.611739525575053, -5.257925832279935, 1.1298110787173448, -4.267398042254859, -4.83434305014944, -4.609241094130052, -5.4285124301940275, -5.7571206537595945, -3.264620734495274, -4.034995117468079},
    {-3.8979261512896897, -4.4751496444323315, -4.51148200966543, -1.1053455719594736, -1.4937163261764668, -3.558200151017372, -5.290766293833375, -4.892995865166889, 1.156349936764628, -3.817773409413653, -4.361449424992955, -4.17501493762484, -4.7724275737608295, -5.249899616947566, -3.476632469377883, -4.117852197693089},
    {-4.206185233281828, -4.602428271993957, -4.496113536425947, -1.816375534907318, -2.7456263352880925, -3.506457098413731, -5.195796317460503, -5.076014706417422, 0.2801272161567784, -3.924885882662328, -4.47452195556021, -3.912587142354633, -4.514045137062786, -4.901071034179688, -3.9530358882599788, -4.09816926414445},
    {-4.9571269380689404, -4.679146890546708, -4.502186634905877, -1.8120189514494367, -1.7914582533821575, -3.6612358610768165, -4.948173290403693, -5.276163386962402, 1.182561612113204, -4.980510766106107, -4.597003904968513, -3.757957100387775, -5.302919749567902, -5.596673811947388, -3.8452941841881323, -4.505194127621703},
    {-4.142511710111467, -4.2932618259258755, -4.276213351737574, -1.614953889062827, -1.1522222899224925, -3.04743981904447, -4.844473326456241, -5.253308764239906, 1.679531097257475, -4.472578747028208, -4.4609090632794635, -3.278884599543878, -5.682592693035797, -5.712350751866468, -3.5834669063235123, -3.931008117810173},
    {-3.3054132541968704, -3.204246110029556, -3.8500487014485496, -0.6638711247439916, -0.3396785296733858, -2.5595824709961272, -4.189999793234619, -4.4943632512289495, 1.900841521429911, -3.3232529390646066, -3.5986762351414767, -2.9696521694022784, -4.897643671180421, -5.007253566538724, -2.684863411904007, -3.2051101657295096},
    {-2.8360796215755855, -2.63764642776205, -3.5557846319582818, 0.17032553827529318, -0.01625478756265937, -2.076485479430192, -4.273193883184767, -3.705864138028486, 2.048475360491517, -2.885382407284552, -3.1519513016542873, -2.8208136745077037, -4.225136698632625, -4.272979036200737, -2.1845618208856976, -2.7396626788448484},
    {-3.201343530508846, -4.005471380494353, -4.308557360737504, -0.7344279210925932, -0.6392738487331161, -2.90345850193464, -4.8229890370398545, -4.62689934348498, 1.2332899436869385, -3.707241288613547, -4.0413245045096575, -3.4630011498728015, -4.934657215547066, -5.071115011911262, -2.8307768380231466, -3.458015027111033},
    {-3.534501094921604, -4.332206468821294, -4.5631747908145295, -1.6264188290817942, -0.6372070479149681, -2.8711481638261884, -4.780680732908674, -5.122403313189486, 1.2639329739205427, -4.0097491175201645, -4.47668635764567, -3.1440531517579364, -5.071291232735087, -5.347041524533246, -3.0056069590213608, -3.7499415725451937},
    {-3.118732039891611, -3.9052851360165053, -3.998416849286905, -1.317994929291972, -0.8384481521423456, -2.731244930813245, -4.40303366347039, -4.6503441139084485, 1.2715866411838743, -3.44151690527034, -3.82131770431273, -3.0458048457153106, -4.446154400841033, -4.389034855125354, -3.1739541691232507, -3.17284719621608},
    {-3.1250684803140025, -3.6899437698248527, -4.273525098006888, -0.4885674778585144, -0.050524445966906806, -3.45582025559327, -4.821620879011531, -4.828699580137014, 1.5546836800311523, -3.1780143430776104, -4.2298217094481, -3.843490535413378, -5.062704370413231, -4.9674028092561215, -2.7324150798336544, -3.2155478779845845},
    {-3.827840285507037, -4.422617934953585, -4.631571200106749, -0.5531947921355058, -0.13907697970983418, -3.17082750451646, -5.022610516633557, -5.284924203495988, 1.456721562882774, -3.7914310481900744, -4.663596876749796, -3.5510972624497206, -5.2584994400660765, -5.099903896669655, -2.88961778113075, -3.532531563904441},
    {-3.8964957518382795, -4.4502547064232685, -4.080461523443738, -0.4364776078681033, 0.5148455513200736, -2.876247191230712, -5.389873516252886, -5.20587927232598, 2.27177757247115, -3.959443995326007, -4.710290354272273, -3.5090776246642292, -4.908936402914563, -5.540444695211416, -2.7615317239346675, -3.3075185974119443},
    {-3.0866656190932007, -5.058911037478857, -4.241155484706075, -1.405161363201192, 0.4062105610161775, -2.764099536809789, -5.114533481027829, -5.590865628397666, 1.8099437021072395, -4.276391615730366, -4.499328077656418, -3.5171191036126714, -5.499582023078334, -5.435114434960576, -3.12460221737426, -3.7450294774650796},
    {-0.4467139232786077, -3.377040195432719, -0.18077970153492573, -1.4407164144518656, -0.9508061164016186, 0.007387558285132167, -0.6430958349083089, -2.167856340865942, -2.374605643732319, -0.8023499957737716, -1.3511271181631248, -1.8984764747069973, -0.1903043773035534, 0.27175470103536337, -2.0654183096184786, -0.3293761462830388},
    {-1.3775496943876062, -1.3758322478292417, -2.5548982904620883, 1.520307908961732, 2.7008932029538397, -1.336595114645077, -2.3689177934479395, -1.679253860792238, 2.1300246995158507, -1.7162944860389602, -2.556919941872241, -0.4249367026939027, -2.213091681429884, -2.0438356777396156, -0.009335852801592675, -1.5895352311027076},
    {-3.1332202138803456, -3.5049261803355605, -2.726060461505872, -2.8625997861500547, -3.471132665536647, -2.428192756634731, -3.2589728977420855, -3.3138863652532877, -3.2364947119329783, -3.3254031347215918, -3.0516641123089108, -4.092667525611602, -1.5096898987509282, -1.5830537813314045, -4.067553189716107, -3.2250939218126824},
    {-1.024722483891499, -2.452244808858785, -0.6187102290101442, -1.8393352425786336, -2.536511696497804, -0.9454004163905539, -2.371914432605087, -1.4116738989529465, -2.246337485653852, -2.6726193562561367, -0.7415575986896478, -2.0705402895839975, -1.0706105347842065, 0.03222959850685786, -2.4675495508066105, -1.467234450101437},
    {-2.1758737642378416, -2.2175596766947616, -1.8857031938230797, -1.0595883930436598, -1.43180492404368, -1.9387327660929328, -2.6992362340977842, -2.8166954935935906, -1.1076976046911609, -2.389045162279353, -2.3617498134713886, -2.2628855267994803, -2.1260117811331347, -1.7554480018960261, -2.3727491635777542, -1.7621119199713333},
    {-1.2778480931462126, -1.7646528869475764, -1.0364443733541977, -0.8240000405061539, -0.3593759352738351, -1.4882284696593495, -1.7336957097860364, -1.0612840471144949, -0.3320346322121915, -1.77105434468902, -1.3045928041652028, -1.9417467295334137, -1.2258155481769828, -1.064895541586315, -1.3026615752062591, -1.7298056974363745},
    {-2.4417062133183043, -2.4972812587535014, -2.245346547246159, -1.8788355713406721, -1.3675750626464622, -2.575186371175131, -2.4580374534661065, -3.005785016460708, -1.2312871159124397, -2.72589887239621, -2.980087425290021, -2.7164329864467054, -2.240414350159061, -2.1589798508609728, -2.0609619833817976, -2.7991138489979215},
    {-2.6876405037007745, -2.2421466620979684, -2.130042593185801, -1.9385725323113177, -1.5569975688191398, -3.037060431363884, -2.444304166786069, -2.2424375811985384, -1.302071053452007, -2.3721360531998466, -2.1127649692139134, -2.4079937124196595, -2.637087792934897, -1.5744062682762356, -2.0919895490395386, -2.5354852433632993},
    {-2.3480360633700945, -1.7860117153312423, -1.5772662547919378, -1.301420882194042, -1.48968874508695, -2.477117582990407, -2.1709156431472425, -1.6277929899048569, -1.1745959229252052, -2.034416367159174, -1.9901008517896288, -1.929031942323769, -1.3699566240671663, -1.3177930511066123, -2.1775353902022676, -2.218425254431066},
    {-2.640303624741477, -4.064054837610924, -2.773601264264619, -1.967293458392256, -2.721320570863468, -2.739802330486448, -3.6279908586223644, -3.5011681921496853, -1.789339656851865, -3.64710217871247, -3.4724156303818594, -3.3616636897309826, -2.8101958196703833, -2.919868114889414, -3.268965274013149, -3.142885899963756},
    {-2.8676611568140546, -3.1603585299140047, -2.4116104280891895, -2.270611167039905, -2.4030931818446515, -2.669521992325549, -2.9414509065124457, -2.9455843998969766, -2.339702456902072, -2.963005096235233, -2.8590719912115343, -2.8208414427928923, -2.9345805964638676, -2.765635489221269, -3.0794257400075287, -2.609471550734155},
    {-2.702706361526013, -2.8487637859258617, -2.042472127664588, -2.808574325948555, -2.5045240069932238, -2.5547041505079644, -2.6937436370668673, -2.797943587349747, -1.785466590093076, -3.138388351396626, -2.470224916988146, -2.7735209720452825, -2.9768747779113, -2.2750477347821922, -2.5233820669122164, -3.178531710450814},
    {-2.5584088620554115, -3.3922967445018695, -2.331121316455842, -3.325273635250943, -3.2048184636203323, -3.017362381201805, -3.0040662083166496, -3.1350730959394966, -2.8394746556912103, -3.2274442733849273, -3.1211153147831787, -3.184320971873448, -2.090612283861079, -2.0113967546485654, -3.2639343883316956, -2.814659790571805},
    {-2.2076556787484063, -3.8731243322916327, -2.0909465519533272, -2.9945614768406132, -3.2758880050536883, -2.147996038527601, -3.417048303643377, -3.2296917066609416, -2.967833229865644, -3.7036946879998545, -2.657884366154182, -3.0357407334437676, -2.393556468088777, -2.3962956094247554, -3.258823671321664, -2.581719098477921},
    {-2.7117814100954516, -3.6643656932383646, -3.0453765165789997, -2.6064320449010463, -2.8379393840906015, -2.8688429668495856, -2.7515691845358656, -2.7023272933162787, -2.5027284856220966, -3.3980818211760733, -3.0985303967263262, -3.4304239827239087, -1.5463094187058963, -2.09598692098583, -3.1837896449788805, -2.9840562910150417},
    {-2.583766630769832, -3.9936623715809394, -2.592102317086747, -2.789146907203073, -3.6526554738995682, -2.8363227690273884, -2.944365457013944, -2.765120309537836, -3.4829400217745654, -3.896416283353288, -3.3763291211238955, -3.730815046126906, -1.7822669082139475, -1.870064912162608, -3.417875767771622, -3.856062547752355},
    {-1.733268254424905, -3.0176975824506447, -2.379615181069253, -2.098044636743012, -2.978133952008182, -2.1368775216663547, -2.7649070707530807, -2.4496544004605454, -2.97416200305288, -2.9306546144255, -2.5473889811360277, -3.4724177967520484, -1.1663760201770093, -1.289053308583701, -2.5567501475086782, -2.845069594639795},
    {-2.808213798307552, -4.122524075446245, -3.3684109105728104, -2.109382379958985, -3.2334305206337373, -3.1595516818705733, -3.938420374533919, -3.330594328899772, -2.7594735010490905, -3.695768255132609, -2.9848675366810644, -4.151728256909621, -1.8273556265464512, -2.250956008364862, -3.373204346617855, -3.774279777687321},
    {-2.739957948449468, -3.139799129655924, -2.367039517609274, -3.2436784174130144, -4.386094551694631, -3.1950016856086627, -3.019693256650624, -3.177722396923153, -4.0688380790241245, -3.2224834474907964, -2.8160160067798694, -3.7255800668030226, -1.5730501320503514, -1.4849949794767539, -3.456079010381882, -3.4276628176624735},
    {-2.577751621011407, -3.729150408293774, -2.412390711862466, -3.03887191344979, -2.8972238200106113, -3.033212840513878, -2.5596557471536117, -3.1914122614909557, -3.397066449199727, -3.804981569702825, -2.9360804196238357, -3.800309909336199, -1.6651088818867783, -1.686700811340359, -3.015549354147211, -3.584733353050319},
    {-3.636246919693755, -4.32035635218507, -3.186971958266855, -3.933127210006414, -3.924753573080643, -3.7203799284565675, -3.261555420440724, -4.139687343346837, -3.389987282619631, -4.497095456760751, -4.004457720478967, -4.310942478442137, -2.956168256949333, -2.6651925049427048, -4.0238386779554824, -4.263874409213683},
    {-3.7917796668012076, -3.9781567486477742, -3.6021224695159053, -2.7676195935194934, -2.7630184851874966, -3.6886127520300658, -3.2838787160359306, -4.130111076705712, -2.2931426609961076, -4.2599294659307105, -4.24548376911941, -4.029611187394607, -2.409807972408938, -3.2867204817303386, -4.098210045036457, -4.154821305296083},
    {-3.4184941936421946, -3.310197708963379, -3.4797761739288897, -2.7548131432714458, -3.8471076950909513, -3.869599968370893, -1.9313072726331049, -3.0578263414525417, -4.357590598812358, -3.1117477348380693, -3.8572628193397276, -4.524834584410139, -0.08565298663092268, -2.0368369790240197, -3.9501552502727617, -4.004106733972041},
    {-2.916144327578054, -3.7650476025470305, -3.680835432070548, -3.976705683329341, -5.126050672875087, -3.8706784894121777, -2.4322843662446982, -3.3319201652009127, -4.835056630210784, -3.7657061543939636, -4.170634681969912, -4.779520301805522, -0.4441912305221663, -1.463340213726019, -4.130694028325275, -4.201001361396481},
    {-3.5070806270436425, -3.9977691760291014, -4.059327014209609, -3.7137990352682797, -3.891395314810127, -4.2147495204401215, -3.5713216668255168, -4.262829584568499, -3.8906854074917714, -4.06019050509351, -4.537912567814045, -4.22746158569752, -2.2485231837742146, -2.099188598636006, -3.830359392624482, -4.55228773188665},
    {-2.066935658182395, -3.5476665148796265, -2.2679412242616785, -3.0146969062806317, -4.563359441856058, -3.1646088988166996, -3.0286602171151493, -2.883363172658493, -4.959511106217609, -3.761838626721449, -2.6740231207034024, -3.925629319015114, 0.37644477167249973, -0.3915673436636815, -3.8681497971293504, -3.2956255161918167},
    {-2.8494544498794743, -4.619235616839845, -3.315937010653303, -2.086349772126299, -3.6739936439501966, -3.844448122866543, -3.554499121722877, -4.123125157533307, -3.356686839583877, -4.3895701737776385, -3.9362428495310144, -4.567278536246077, -1.1146782565587163, -1.3985568364040533, -4.129214915818655, -3.969264108348524},
    {-3.340981039777388, -5.088526559186375, -3.879424452728862, -3.613433788851765, -4.286184864853755, -3.9436005843933573, -3.879955871483101, -4.436085045304409, -4.715242291224536, -4.6861034277609335, -4.726925959211138, -4.933195224048435, -1.375930581097507, -1.8314396959814694, -4.618285284100798, -4.900457910526857},
    {-3.2054730324356173, -5.108968104446874, -3.6505822753360992, -3.4005527000305245, -5.133773484505883, -3.9700276360802573, -3.702315351152382, -4.275796371995374, -5.090604722510547, -4.601016318040664, -4.482453936216641, -5.083135591763254, -0.4219673342834933, -1.5489348891191614, -4.625575927235534, -4.921589420572047},
    {-1.9038286932280983, -4.970056717438799, -3.3151731032864786, -2.939484326304427, -4.3535825783223006, -2.9502981321867554, -3.144356292363607, -3.473585182225445, -4.558383255038416, -5.0962838977816505, -3.372125691533946, -4.753418509353308, -1.0158123658135334, -1.4236036180822127, -4.453402677384495, -4.39683335222991},
    {2.1882354708838787, -0.7155235978424735, 1.7831305452761237, 2.1718595061592043, 0.23950126437090966, 2.393695387416842, -1.1072307501585124, 0.7246970676976273, 0.28646913378636507, -0.8294104519243554, 1.4634844388333779, 0.9029499935608934, 0.6866139816675937, 0.8748930219543914, 0.787954174838009, 1.6480595811024983},
    {1.8455438689311994, -1.2291936948601496, 1.467902753763022, 2.643098432821601, 0.2105111741543072, 2.0938274069678804, -1.769189287182117, -0.11287833725902506, 0.41904142513090803, -1.1699510967073563, 1.4426938517020849, 0.6043798954151591, 0.06669488749857615, -0.007559713656887561, 0.3757458850623862, 1.80629996680903},
    {2.382090351969961, -1.5011524815130373, 2.122025013825817, 2.6389583138923878, -1.3169975250019879, 2.1180487130034322, -2.207153884323882, 0.43678512574783457, -1.2115215610347057, -1.2476603632583083, 1.7017727861887266, 1.046468132346784, 0.4115918377178297, 0.6256798577620474, -0.3306216443467503, 1.638128551512115},
    {2.607310552254351, -0.17413469337665136, 2.0436042572955477, 3.3243127488468796, 0.08266202701691498, 2.425878862883052, -1.1636051688205513, 0.919782192942391, -0.0024429532320246147, -0.530207718495844, 1.982882900683232, 1.6004649412452405, 0.8860502126890725, 1.4241363822544308, 0.526548456370302, 1.797424674725937},
    {2.1799457467354313, 0.052643267316758106, 1.4918484126063256, 3.4011483678684606, 0.5896160564358321, 2.682060729269247, -1.070070993234124, 1.1052629840590344, 0.6826350648174433, -0.36122009934312466, 1.6266186101336566, 1.678312734840393, 0.7579868257571317, 0.8245287933979573, 1.1189596007839175, 2.2489905999296504},
    {2.7294630864305574, -0.09087026865932613, 2.068898992910794, 3.327926069986667, -0.06804837771800548, 2.6534847248345654, -1.1100229609035246, 1.0248784634295447, -0.12077223825076679, -0.6936999894519638, 2.1310075032290925, 1.7097148040363517, 1.8031522201141252, 1.6023197623601297, 0.711031976972741, 2.578143995782682},
    {2.970809181912446, -0.692586553032915, 2.4467653585299995, 2.7573868349835213, -0.9904655051650377, 2.8440321816473673, -1.340667240969724, 1.4799279526960851, -1.141792232178395, -1.0068165711171524, 2.1747264457749598, 1.299371903049568, 1.7129389203452066, 1.8200537274850817, 0.41687990897479615, 1.9623547025094263},
    {2.4123430068045115, -1.1294753870338756, 2.069949111924322, 2.706144121514205, -0.5556504904859082, 2.373514125307863, -1.5986731053852572, 1.0291936002812403, -0.310717666133962, -1.091319255243539, 1.6573658089180776, 0.7586384572946134, 0.8626673855496093, 1.64193621967621, 0.1286095817800394, 1.835756597263666},
    {2.7687734462219855, -1.102690506328032, 2.101781242128019, 3.0645240097096424, -0.9258719979382976, 2.591631868462443, -1.6582027686674041, 0.7533042046152587, -0.526205570121365, -1.5581824709452528, 1.6975279214672696, 1.0338014431016398, 1.1345864382146131, 1.5262905704938676, -0.17723179697388045, 1.9028492895105653},
    {3.147828366961265, -1.0293879568482776, 2.3781514094680656, 2.968543601696367, -0.6340597789346518, 2.7254740550776684, -1.495240631427676, 1.0356787007172028, -0.31225094853259056, -1.367321495273262, 1.9165544667477088, 0.9963368065696017, 1.0307849145525119, 1.1370895775022158, -0.2287177346270429, 1.8786456009133985},
    {2.6894781045357794, -1.1752293493183572, 2.2001510666754145, 3.1339163687569265, -0.4650140660397696, 2.889096651499864, -1.7706663441529245, 0.8250025533593012, -0.1260204528498668, -1.5961634128913966, 1.9583957894753328, 0.9775746936157335, 0.936385444777443, 1.6137897138471342, -0.16625572201787675, 2.170125776560183},
    {3.572938968698185, -0.611654832786038, 2.9116190148449594, 3.8860922226774828, 0.10061932891303965, 3.4511107373751706, -1.3683109431838918, 1.418113054951165, 0.05685935999496046, -1.1375499401848144, 2.6406320770312783, 1.473623664077329, 1.78243663862868, 2.0933020198066625, 0.6944412635090385, 2.693505571407015},
    {3.757893452160499, -1.609626301063052, 2.7645693534095335, 3.246826159413018, -1.1000713847899946, 3.45877516393137, -2.1829971830415857, 1.4562926107930843, -0.6558658445749052, -1.6846690310736787, 2.4428099082948758, 1.2863651186812353, 1.5064497012175166, 2.2647362647517877, 0.5300341208065338, 2.6908534073930985},
    {2.431188574058307, -2.0851864267965023, 1.5534325138209, 2.209290696942176, -1.755447562368566, 2.181973845682111, -2.497660204303296, 0.2644951321351853, -1.7032440466431353, -2.059538720459879, 1.080818386692341, 0.47280069317880774, -0.01985121488183522, 0.7823914571667093, -0.2705181618551995, 1.257899915239473},
    {2.854578259984802, -1.6743554255090425, 2.0985747717379586, 2.6031006362181515, -1.24450171962106, 2.9626468887722877, -2.1367466094976812, 0.6643020374514419, -1.6126461881330345, -1.658566660221321, 1.5739583202855323, 0.5391945659950547, 0.5403817628501381, 0.8948801865441915, -0.30098061279798016, 1.8375869352584089},
    {3.208236470416213, -1.6295415102254753, 2.148985659713859, 3.369067734021102, -0.6456348857727248, 2.9387996232082316, -1.8950725613459256, 0.7608893098947556, -0.6719936708591291, -1.4148767573346483, 1.8118570696834262, 1.0831616697350328, 1.0754990321526348, 1.2862787183885622, 0.11205624966849458, 2.032896752889707},
    {3.2343247043757413, -0.7577136271842512, 2.317554251905804, 3.333316506235581, 0.13565547581420953, 3.3741126470374976, -1.3586057075289235, 1.5684705735854472, 0.35173815793877855, -0.14771253162816347, 2.476800819671319, 1.625259904230641, 0.8581724708167275, 1.0822406601070738, 0.9939622659970657, 2.4013939910304067},
    {3.2836624930618825, -1.3469802681378367, 2.437899048154969, 3.6388018717766704, -0.9631721554230024, 3.0228965611721232, -1.7746289174875083, 1.2116133359969548, -1.2757663803661206, -1.3923391337510684, 2.1993608451360154, 1.4842378403930119, 0.7197801143630091, 1.4545038090699112, 0.2800206373642842, 2.1492201334270487},
    {2.900515773335808, -1.5768360047715615, 2.4116991644039545, 3.1521891665348964, -1.0531871842652685, 2.8355680360247586, -2.1551492160930077, 0.5969608842273925, -1.1474279699799157, -1.1240575271002369, 2.0013202345846306, 1.0928784798652507, 0.939171883672028, 1.4591069722772223, 0.12951985321065496, 2.132489667078805},
    {3.36264955004666, -0.3357505686407979, 2.8658444354098935, 3.3383778612216504, -0.1286667305541483, 3.296590699892291, -1.5847777699869605, 1.8093044827719351, -0.289618978853689, -0.4749634579115972, 2.634994567785002, 1.941251726830269, 1.4808105179603084, 2.049480454125551, 1.0315216027534377, 2.529456961711026},
    {3.3625445569925527, -0.42511539861889397, 2.7809268546408306, 2.897219906727443, -0.02057603767494746, 2.8619922606083223, -1.2466971956309294, 1.44396149154989, -0.31835686679683756, -0.44103462506333857, 2.6839070297021417, 1.9223203510002593, 1.5917079745109957, 2.0668675977475983, 1.0403790771930794, 2.4983597385394987},
    {3.501001328763242, -1.3219196483135431, 2.809832372234499, 3.920129153284, 0.11006682138589444, 3.393734066199653, -1.8416288399051475, 1.18099273520501, 0.17980953324016963, -1.2977338071225182, 2.5363054375606837, 1.5475889551365642, 0.7093815345095537, 1.6248923719181385, 0.3447566420745668, 2.729224017797593},
    {3.5754841462706763, -0.6028316984410524, 2.794250582105542, 3.863238952938303, -0.18474971595918144, 3.3910861768088854, -1.5124958268312936, 1.2659036728829967, -0.2595234344613975, -0.8165508719852043, 2.5633968005258616, 1.8430262477571804, 0.7258459671490199, 1.3256566150925364, 0.6688583273646187, 2.914489123750166},
    {3.7845724922577526, -0.5365594919695309, 3.2696939331279653, 4.129287797329432, -0.4517592287423165, 3.749903854167797, -1.5059350205282092, 1.8269801994379944, -0.4987068286256137, -0.6461760979880499, 3.0441513825368856, 1.9513206033059338, 1.1398599268394942, 1.7919771278727312, 0.9052133056839319, 3.068990851065302},
    {3.786096533995738, -1.0101302890219415, 3.2045418370638568, 4.391785315959348, -0.25842422494894035, 3.455601240722122, -2.058513134606867, 2.0111253311964705, 0.08436394936877793, -1.033982418328772, 2.8826748205341652, 1.8402054236167704, 1.2107797205489277, 2.158434518632025, 0.7811379541961987, 3.051194702501942},
    {3.552395921222311, -1.6775405508525967, 2.6856682081095338, 4.010527253192958, -0.7234391316896254, 3.541958080104712, -2.5273006593915044, 1.028074817933831, -1.0048680138774844, -1.6945207194371623, 2.3186441031262794, 1.6164066822492495, 0.599531207938679, 1.2227098832954904, 0.6224246083715306, 2.6333286358891828},
    {3.949028644372703, -0.9658612852283154, 2.9977272928969, 4.288897376730809, 0.001669995354661761, 3.881096562388258, -2.0515862225825865, 1.5099444434135778, 0.11753936214417382, -1.0693660294185796, 2.7076132435473794, 1.953662221153138, 0.827815735735984, 1.610658568641125, 0.7683762427554284, 2.996711390608407},
    {3.9021301316642694, -0.6109181891244342, 3.1936935414003282, 4.0355554465516255, -0.6479416030258687, 3.8751252785247177, -1.8800566956827969, 1.4033794002617215, -0.6731127550873411, -0.9536204294975824, 2.5758732527530603, 2.048114347876956, 1.241106329759183, 1.8238315652949968, 0.9703293716049216, 2.802044521436987},
    {3.7810000223605207, -1.681940843516021, 3.0209212741948144, 3.9178943034173015, -1.2992661095102116, 3.553788538314538, -2.49678547827443, 1.330615052429037, -1.3511935968060482, -1.182440090959293, 2.5131631118976303, 1.6891383645132987, 1.0138528026858247, 1.6062633588995034, 0.13397778161525672, 2.625479541789987},
    {4.2939808842469445, -0.8368048972621692, 3.094581617729651, 3.9770229571003406, -0.09463224729937596, 3.9543093323517056, -1.6514182889428826, 2.2380149456377123, -0.33015570709027264, -0.5782139768879079, 3.119216471333309, 2.2207282502426535, 1.779809187379615, 2.16982868023465, 1.1773238439933562, 3.088047054728262},
    {-0.2617328160695042, -2.527971519183993, -1.0055350177501616, -3.1490664192000093, -3.9782004051239, -0.28831453531288237, 0.03771257131543475, -1.0031184970635505, -4.459694388253799, -1.5266380641797999, -0.7336781868940087, -2.477763548598131, -0.5998751178015885, 0.43207508341963763, -3.279497626673766, -0.44300112028890765},
    {-1.7304245684388153, 1.1659789177136994, -0.4390602272994292, 0.6946687045399095, -1.8574550723609122, -1.4582177758162596, -0.7123976734874772, 0.5645963871439941, -1.0578239247124868, 0.4190868798211069, -0.9700388619672229, -1.2491635201801254, 1.6924150402743563, 1.0413159907806744, -0.871216900508875, -0.739723152963506},
    {-2.105626318132575, -2.889706533136004, -2.3504219073099586, -2.992337451135124, -1.6309437250132721, -2.3452944314622233, -1.6752640945405137, -2.2484843775676087, -1.646950551526926, -2.4925670415855516, -2.546217505975954, -3.188112494769741, -0.5944678587184873, -1.3442602908970247, -2.8387627296037943, -2.559342370884654},
    {-0.9628682171398943, -2.197320967644115, -0.6984575037886365, -1.3514848064985514, -1.780591362939826, -1.2846177816695992, -1.7979126981808475, -0.7587927709345027, -1.6953627072706752, -2.549302590751032, -0.9384916503609096, -2.1337146803659297, -0.132794032581667, 0.46979939185883235, -2.400838625687178, -1.6278363449420143},
    {-1.6921396597422909, -2.71265674833237, -1.469251726847071, -1.169694155114349, -1.7177189333761425, -2.352801605308402, -2.608869552224085, -2.427267497761678, -1.598120203516483, -2.9530490284691715, -2.3654784518307377, -2.2593491740868594, -1.3244518528538083, -1.3219424043575758, -2.479575856612027, -2.201517054329305},
    {-0.913092172692811, -0.7940284779044964, -0.9130180550662959, -0.517617425965116, 0.058449369146652226, -1.0192252242763455, -1.4215977732798257, -0.9117874640214582, 0.42607086318863974, -1.3761221132325498, -0.5485070336404595, -1.3181313998484936, -0.9115049975273979, -0.1468821315087744, -0.8776775384369965, -0.9993061979330813},
    {-1.4137093745416627, -1.6531842952436826, -1.2264951442567225, -1.3976175289299875, -1.4519013178325093, -1.8446337882099397, -1.601836656423132, -2.0372037937069654, -1.2063919844553543, -2.3476720300677596, -1.6620213908824124, -2.0364891112717163, -1.5438679174362062, -0.6369874483125252, -1.9033525199902945, -1.5874370022402515},
    {-2.2416965650816967, -1.721666358707059, -2.10840960700232, -1.9242125171021143, -1.9225113333158572, -2.4932639818260762, -1.9961219239043078, -2.6422121148660462, -1.546190118852455, -2.1777052414519003, -2.1555957732890927, -2.485188712262306, -2.2140275675141945, -1.7784483680079466, -2.097178365101743, -2.5108943100001966},
    {-1.7837733992771367, -1.9650907676097455, -1.7571092083792015, -1.0962824976028127, -0.9606501252110186, -2.0777014360105035, -2.004932557690216, -2.047882008954605, -0.8008474364587189, -1.990310579111955, -2.001142978020707, -2.1130243890063007, -1.2016063019674266, -1.223374631688002, -2.491693703781196, -2.0657504195711276},
    {-1.4401294136663059, -2.9520073607355, -1.7073622625069815, -1.1980922540717909, -1.656808054357022, -1.3705825086302121, -2.25017223749561, -2.3850952049450713, -1.009794212109134, -2.357192223609005, -2.3936605925377092, -2.578965423330517, -1.4119169168167602, -1.5781950088922643, -2.7433230009212544, -2.120728749804633},
    {-1.020861593755861, -2.1562922856124223, -0.6340375290014711, -1.2709952469504149, -1.6889699222819015, -1.0411842914218845, -1.3476265230285756, -1.0828854184267744, -1.803958424704786, -1.8728401358359983, -1.661014815494078, -1.6223538328567204, -0.12966921491856206, 0.09940504106174701, -2.005601692259615, -1.5212856348562047},
    {-0.9998188612933248, -2.605747783963519, -1.2006716056958175, -1.6054832828272083, -2.1614241452440357, -1.2204840867492206, -1.8638219730979184, -1.90342752929257, -1.7970565673638461, -2.771642303563806, -1.8108851130062527, -2.368214487406752, -1.0180319241895206, -0.5405948849520252, -2.335368068650064, -1.911091040128919},
    {-1.8978259741752814, -2.5386394319145813, -1.5724714264490154, -2.6482041201123225, -2.6549086898803718, -2.363578109755181, -1.1621845594822053, -2.1996158591819444, -2.602650742181432, -2.315963715640249, -2.0688071323696002, -2.745063108797124, -1.4768549892949163, -0.8458369947293192, -2.0891784863051424, -1.7075348391723513},
    {-0.7447784813446819, -3.048611559656528, -0.5660206124280233, -2.26119943873176, -3.134392305351156, -1.1330622989738628, -1.579863657638596, -1.6175832753413917, -2.826044536807006, -2.911957104780404, -1.1208656263785612, -2.269451686712273, -0.02733263803937403, 0.007517496577889097, -2.4769066488071596, -1.5872770192108538},
    {-1.6287216772683262, -2.7599520139576015, -1.347419553135484, -2.2922961875566625, -3.2661010724514266, -1.8666737118619028, -0.6405772215981952, -1.6353248240071359, -2.5847709389482985, -2.2256875456019016, -1.7426117563644725, -2.652504725878906, 0.5520787955860936, -0.20318448779810644, -2.7427642190207413, -2.196791788942155},
    {-0.6650383235615247, -2.370545490204155, -1.0665718673288438, -2.2564197639622856, -3.5347242248549238, -1.2687701287469526, -0.7813065375430197, -0.936060086332375, -3.1838220907734294, -2.257492503227889, -1.28350952187704, -2.1278182483341244, 0.4649951848358357, -0.24523831315159877, -2.071553506974566, -1.6922802288572238},
    {-1.0335319222865198, -2.653426630905529, -1.6362795108942632, -2.0197969314364324, -3.3123335635027047, -1.8060267361215934, -0.9819922560643195, -1.5377562729116165, -3.500016158664267, -2.9075929709403527, -1.981519046517306, -3.0270673639704238, 0.06776939397140443, -0.36281395222376, -3.089952877545856, -2.304674805121194},
    {-2.172403612840848, -3.4023066424685067, -2.391536575173565, -2.9424436396639297, -3.9948242268875824, -3.049104963364525, -2.175227489478041, -2.679397459736742, -4.161937492090488, -3.4181168129356116, -2.697873044468517, -3.8233343262050195, 0.003974156941583568, -1.0390234490927852, -3.667622303054239, -3.2087553887406366},
    {-1.5786542656253761, -2.5237782966042865, -1.4271701905106844, -2.201033709040837, -3.774192101517102, -1.939276788424487, -1.561170343385153, -1.945518660829886, -4.06266514576353, -2.3757977920309776, -1.891543218169368, -3.2534457321166332, 0.9214445402615392, 0.10266616287319956, -2.9288667786937523, -2.6039328981228693},
    {-0.7513576170263632, -2.624965915090751, -1.1148947173672603, -2.105221570804871, -2.9806443119221426, -1.6017273013302074, -1.2862674153463607, -1.3050484596393093, -3.1828150381631466, -2.613641187249203, -1.9070868004910333, -2.8736381904884007, 0.5985016592938067, 0.22559326440252989, -2.679970001182266, -2.247506766771113},
    {-0.45454733440016487, -2.378531636731514, -1.3494137163082436, -2.481403589211822, -3.7460858049602996, -1.5299805755976918, -0.337993156956195, -1.7142910034745544, -3.6836084978059485, -2.9324252105257536, -2.1118360086699384, -3.4648591971960063, 1.3030651477983823, 0.8947645305324875, -2.660139128185044, -2.07771873813486},
    {-1.5467033100048484, -3.3015880179911115, -2.0077752406620823, -2.9178838522891453, -5.326568299657468, -2.4902312651670893, -0.719769967489296, -1.7564076627700491, -5.331128446273994, -3.8126692923686956, -2.54460784772051, -4.42133962625651, 1.8496485176511002, 0.08256012453152813, -4.6280999637700155, -3.3216997292761254},
    {-1.3136821840511133, -2.817323416228448, -1.4957446090888429, -2.9474319302461924, -5.507204814445468, -2.444624399992295, 0.16059917050650643, -0.7859486230298381, -5.728099052743987, -2.411953284560867, -1.9131523209523653, -4.41550850979503, 2.681984913943519, 0.944792807591827, -4.405725393541575, -2.990075034492827},
    {-1.5030248653346447, -2.907399974740868, -1.6313081173953972, -3.3159024082579984, -5.441586802886739, -2.6273977298335396, 0.2114353681792841, -1.2651287492493435, -5.583603928797776, -2.9084798184335026, -2.1072960413933517, -4.459168213372326, 2.204943798730483, 0.6836487105869643, -4.35483738536559, -3.061274485297442},
    {-1.876983632707875, -3.878735266753792, -2.6619385033930407, -3.191370161400576, -4.726160691229556, -2.811658252864871, -2.159265968155821, -2.724382799989852, -4.454816385371422, -3.7973823264259177, -3.181266614633837, -3.9310102990839635, 0.38359466815774834, 0.13868515173389181, -4.249843314447385, -3.4774512490296194},
    {-0.8009870370238801, -2.6879671127398463, -0.7133128383231148, -2.6898367715972897, -5.39602605534757, -2.193997239327919, -1.30078365996234, -0.9129900353080989, -5.721560636339453, -2.938443239793476, -1.3738819333927352, -3.0840971668227617, 2.3340329365599284, 1.1440943068460456, -4.077744392763603, -2.4063097226331007},
    {-1.7874928646193573, -4.173926472943337, -2.2233485230820897, -3.0868404554348543, -5.562292170426135, -2.97539536193921, -1.39852122371792, -2.5250434634127314, -5.859606719060328, -3.9314897744257378, -2.951723272380482, -4.700440102732348, 1.88395437500641, 0.5612084386436493, -5.094957013883846, -3.606975579477083},
    {-1.961989654173858, -4.5261345799476995, -2.8032391825446568, -4.211194507517715, -5.815660248432306, -2.999212596763409, -1.9821610385110635, -2.7239030824847856, -5.900128580622585, -4.166020634005042, -3.0895814689933383, -4.806973831031901, 1.0536218763203553, 0.028621454037135494, -5.1603818661994385, -3.852804571409367},
    {-2.072373537951783, -4.439807810801391, -2.517063177182625, -3.640910689682736, -5.903929037901219, -3.089403189716001, -1.6523615922928139, -2.796593869460208, -6.186169892692089, -3.882038917630563, -2.9910628335267866, -5.2727665165310755, 1.922668592919245, 0.23352917033224352, -5.372656050247631, -3.933395729291417},
    {-0.13531710612102021, -4.214201080214429, -2.009827969879796, -3.312144388349651, -6.279899717610078, -1.9849301630321516, 0.20994212567875142, -1.5178796856843733, -6.72486670674734, -3.9997928128653983, -1.8109348640443628, -4.776323104716749, 2.006913648685428, 0.8564567757899338, -5.03911007037562, -2.945997258670705}
};

static const float b1[16] = {6.5197580456230435, 6.573678108937767, 6.179725744747123, 6.93119046051354, 7.035715210438675, 6.405484767016945, 6.527205040645339, 6.211559951572667, 7.51740220082167, 6.543156636853755, 6.3634430500613615, 6.522614165446582, 6.652990464387938, 6.498281360359353, 6.629135293891479, 6.46512965547416};

static const float w2[16][12] = {
    {-3.421938283673931, -3.546167408361657, -3.115359396680743, -3.5795446453302056, -2.5355002476485713, -2.644758740508752, -2.594119060445503, -2.8104718094112173, -2.688704665450876, -3.0277450890922437, -3.195741285345606, -3.4913615319755986},
    {-2.692453072440616, -2.7470458438583933, -2.5787624359682306, -2.9645226615769884, -2.853647085709093, -2.6387549304123272, -3.779519094161062, -3.3763416343836936, -3.1775023447934156, -2.9924929294995537, -3.714813126105957, -3.287937836811369},
    {-3.173279405506766, -2.664660862564347, -2.9721972435857, -2.0917879519834623, -3.0564010076089074, -3.1959377628712233, -3.3394123480516305, -2.976667045245633, -2.7087375048017166, -2.434765063873184, -2.967609477977042, -2.4656616721980833},
    {-3.686820821970115, -3.248969314902581, -3.3832361793750083, -3.355530190044623, -3.703694708706554, -3.483693922971167, -3.34498524966686, -3.6108203874751377, -3.3227962990326168, -3.592724588541581, -3.6004588384111127, -2.9811144032973127},
    {-3.448862902329901, -3.400845953149608, -3.7834167559525964, -3.368124148007487, -2.5955589572675706, -3.4498368561109927, -2.9910628369263508, -4.185100070818476, -3.3774166817083167, -2.869933515502306, -3.312587307725285, -2.98351374973178},
    {-2.303626597275297, -3.4176169456192835, -3.0110533429107935, -2.7160777859664624, -3.0635271688451295, -3.111442035550813, -2.9720592750217003, -3.6449787758513317, -3.336127155300325, -2.8097520472606514, -3.063119630751474, -3.537492965616937},
    {-3.021412107189406, -3.1569537070285247, -3.4961409711394866, -2.936218335340534, -3.1899799967456226, -2.395491087143162, -2.914694592310481, -2.974937800536414, -2.961428894565253, -2.827841349854197, -2.6631262806660803, -3.01838008527296},
    {-2.582173652702307, -2.380135484885333, -3.637071103501873, -3.070925680205619, -3.042554505733258, -2.541653336909739, -2.8957967432296736, -3.1958823455141836, -2.8366464528492648, -3.4988411223956137, -3.3903556773673427, -2.5583811767426146},
    {-3.638440430786438, -3.82539139034092, -3.662189890227154, -3.772809368139068, -4.2811858356283885, -3.67445526741825, -3.8723867961790104, -3.113330973378621, -3.955670024846913, -3.9944199791879353, -3.766552646577499, -4.208722026936218},
    {-3.457617126304192, -3.2379500778293675, -2.4296674713195756, -3.3193055277248327, -2.923031106855325, -3.9795091018524826, -2.9628849440472727, -3.1586621599298135, -3.0019420344794656, -3.219671256155875, -2.6645198788202538, -3.1916765628328156},
    {-2.9224895405854614, -2.3630493694241284, -2.604694390261547, -3.3185521749027913, -3.285904804058008, -2.5039799318619558, -2.4787895184768, -2.9881694825085483, -2.981017384399125, -2.826072233998298, -2.8566942681333707, -3.8491747126133635},
    {-2.555692121868443, -3.2144381971951237, -3.484306130206393, -3.2368489986604296, -3.095761729102557, -3.766792132100136, -3.2020014450182623, -2.6869256655394063, -2.867867036021612, -2.9254515387312754, -3.4313196309867515, -3.0000597853827013},
    {-3.4612732959549937, -2.9658806731918315, -3.531179942323513, -3.0138451750389503, -3.337756736160083, -3.5688990133757375, -3.538117377383801, -3.5809233172788058, -2.5213987283984833, -3.3451162716653884, -3.278313689585199, -3.0106526896274},
    {-2.7958230753216, -3.426482177712984, -2.752820729227345, -3.2719583425406933, -3.1126842221476165, -3.2032407890795884, -3.1913333437933535, -2.7244953052119865, -4.154139465103156, -3.3860723626748186, -2.8804933757535554, -3.418491026422262},
    {-3.537416802506738, -3.7874653815480737, -2.9809801437365735, -2.576948462332967, -3.5099569667067767, -3.037278056616551, -2.474550495966343, -2.587833333332205, -3.56779029555423, -3.1952034764842203, -3.2570960691902093, -2.7687389767550084},
    {-3.5835312721150374, -3.072362824410482, -2.8883405155835895, -3.458328337591926, -2.7326116778839413, -3.0693540671769113, -4.0157155885279, -2.908807564944469, -3.2507209331635822, -3.2951358812936897, -2.238032458165942, -2.5546067496704206}
};

static const float b2[12] = {-5.2410328799139245, -4.8218259913234665, -4.841773939797654, -5.533984009553539, -5.380228314600519, -5.408245267171642, -4.927219676542731, -5.4568486076157745, -3.440596197561398, -5.347425373948589, -5.159451594943945, -5.06008684825367};

    // Input Layer 
    float z1[16];
    for (int i = 0; i < 16; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Output Layer
    float z2[12];
    for (int k = 0; k < 12; k++)
    {
        z2[k] = b2[k];
        for (int j = 0; j < 16; j++)
        {
            z2[k] += z1[j] * w2[j][k];
        }
    }
    softmax(z2, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
