#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][32] = {
    {-0.4208563573408256, 3.2607717542556744, 0.7218316141488379, 3.526687644375688, 0.34167158688316884, 4.650412472528818, -1.0310795615792878, 2.6068383535941204, 0.4349878558248567, -0.944113525421145, 0.9580698269024872, -1.1571083029386964, -0.9064664821603308, 2.9809113749849763, 5.285285375066359, -0.471394944477503, 4.911863839308981, -1.299049520734074, 5.765047915737994, 2.9084845182392596, 5.513352661772193, 4.192704022590026, 3.470275977510299, 1.5835173704708305, -1.7014799186016196, 4.765151106506794, -1.1088996509500482, -1.3118494409022046, 0.7191365712767915, -0.3324403528583781, 4.162980497120689, -1.7847104659497202},
    {-3.12808662490343, -0.26538516154539754, -3.01938324642604, 2.2663156737084518, -2.7232062656322595, 2.943435185820439, -2.116686246912487, -1.5657021664774187, -1.681380933631998, -2.216945705862857, -1.8220092175422886, -3.7030563334494784, -2.9517908757784608, 0.8189175966869731, 2.048223115932478, -4.4867230487391785, 3.003253930952832, -4.941311186111885, 2.416448967659618, 2.5014261627693544, 3.627688548529322, 2.646185010443543, 1.5476935686185858, 0.6666201192022013, -3.560864387671247, 1.731282414679326, -4.669905115575392, -3.1755436355752287, 0.6842910099644222, -4.106342351823325, 1.2341456112820322, -3.4699334052803668},
    {-1.968969230604815, 3.047988947440311, -3.387454826006409, 4.4622836310121405, -2.632728008587414, 5.779805069408647, -1.8427518368890603, -0.5884124156611481, -1.8419965608717512, -2.30054802975135, -2.1669373648207055, -2.9913847893248295, -3.9349593346889176, -0.3440194430145674, 4.016130877234724, -3.22146052482384, 5.359727358751756, -3.1239282898367144, 4.537758139812738, 3.580982159526296, 4.998052980873827, 5.211655144753533, 4.834035953469481, -1.4487667843130825, -3.23517057285265, 4.096658017777854, -1.568832260493223, -2.5057041711270434, -0.6514127233244494, -1.554769394328613, 5.050944188193566, -4.083534222740419},
    {-3.0413933016833155, 2.595088033830051, -4.006522149572176, 3.3009921062267082, -4.323054368975615, 3.2190099179372225, -3.386888355651054, -1.3398980376318455, -3.108796411396519, -1.8821243723656855, -1.4253981159406286, -3.6386116742854164, -3.980569587072221, 0.27362450297993807, 4.408152848664197, -4.185184091635843, 3.1725112168373735, -4.838149229608671, 5.261526105915268, 2.618032234169798, 5.256326426288854, 3.1467149946601496, 3.867171071518386, -2.4634758049463876, -4.6664691509975285, 4.7102993063238365, -3.1669787537920517, -2.9651327702339962, -1.9861293499897137, -3.736427831677553, 3.8171109558931664, -4.972136238554472},
    {-3.2434293517329804, 0.9662049895742463, -3.275880779496205, 2.760734740529129, -3.6999326992934787, 3.675734445820464, -5.035777460276174, -1.6250292881092108, -3.4674629800535715, -2.315264940770195, -2.9985425680361715, -4.751619384436844, -4.8691667607372535, -1.9096078153259888, 4.200535030167784, -2.5426835823737566, 3.7675012162686627, -3.6255679233476843, 4.494037672917622, 1.949301961454857, 2.7469275562242754, 3.7124872473162487, 2.4448436386361574, -4.061195973820472, -3.340939310948128, 3.631274113103829, -2.29398560596314, -4.917311105273747, -1.8238812467781365, -3.6716899908718266, 2.329903016066739, -5.15522136033359},
    {-4.17446025533122, 0.7637481865511803, -4.490837846766555, 1.673637699270681, -3.7638315214596982, 1.391499688723761, -5.3032796825944155, -1.2840267100730285, -3.8076211874384267, -1.9049371729707136, -2.8227299894444258, -4.5640115263549585, -4.962643501470757, -1.5257979233467893, 1.7014147059907683, -2.9270285936210536, 3.6783107691985646, -2.1438406935108536, 2.905067188276028, 0.9992484221101844, 3.212686771755519, 3.0357216030848058, 1.3777206736395549, -3.9509444803657274, -3.793146364347451, 3.737998834009604, -2.3321368199066304, -4.8391482435884745, -2.2607003822076597, -3.5953701216806917, 1.4609505539354648, -4.658579208890629},
    {-4.2464582490720435, -0.7911263233291035, -4.755883506424843, 2.0182535874278256, -4.968266068360788, 1.8141788305538395, -5.382541965432036, -2.817297264345409, -4.334321399193996, -3.5437879548563034, -3.871265763617448, -3.4506590913158854, -4.844549391559956, -1.287777937039536, 1.5411011455411572, -2.8879430594391424, 2.592071253378884, -3.6052995772332173, 1.668718577358939, 0.9785128631336518, 1.4773440295769673, 0.9742657615103806, 0.7896678694033358, -3.6691897789214223, -3.232718973551862, 3.2444359282841564, -1.9916165631993508, -3.747552075376929, -3.1925104494625836, -3.249367562123489, 0.5287193522133662, -4.9751705961257935},
    {-4.3614063051692895, -0.5743727841356753, -4.461193407991304, 1.2969545104242872, -4.924181147164508, 2.364932196821706, -4.3025646422777895, -2.892961573816652, -3.9947995075815617, -3.667061372205443, -3.5800797796430297, -4.958252156011343, -3.9895091468882646, -2.7337164644318444, 2.606362767252938, -4.228172923899897, 2.7995975510864035, -4.02608942990409, 1.5413692004785946, 1.5131349360925415, 2.5880577680900134, 1.5562143972941755, 0.7685478261243365, -4.062446597039152, -4.751024251227074, 2.9278471085680544, -2.666079796013279, -3.6600559210701658, -3.3114680961032916, -4.523566594869513, 1.3535353850000693, -4.657900791486395},
    {-4.765845263449434, 0.6883780850044567, -4.623179048827599, 2.6867634255861055, -3.7710899738153585, 2.066896760780332, -3.3041368703458427, -1.9143338205170182, -2.5661308289059677, -2.7005084045179726, -3.5351120927071675, -4.392374640062374, -4.782703606068756, -1.4781422289090898, 1.9850704445797158, -4.563753466662574, 1.8960709025424274, -4.92736149815326, 2.2830582096562795, 1.8341280883750877, 2.6266056262734234, 1.860757910175601, 1.5289466544560144, -3.6229481187076544, -5.230170265289308, 2.1747320522957114, -2.6573264459592187, -4.979283290273639, -2.8270148006882794, -4.731843767534917, 2.351075208501182, -4.5733446865043135},
    {-4.885449471922635, -0.5229574734263512, -5.7872365257165095, 1.9532607742378085, -4.817138094676512, 2.599005871642823, -3.8233666391193304, -2.2388926243098974, -3.569931980389728, -4.289610501425551, -2.8360679364617223, -4.983494770056097, -5.421203993889538, -1.8098768450538942, 2.8214432429312155, -4.954071817470056, 3.008610116440342, -4.655527868027548, 3.2872895827395956, 2.385774624488512, 3.310888700001548, 0.9486444866127666, 3.072266682016798, -2.704641074756662, -5.287206240878893, 2.558013000454307, -4.751528415911925, -4.498641932894384, -2.423623581404288, -5.274098169459874, 2.3044525799649205, -5.147901643617372},
    {-4.344754011086557, -0.6703812084041156, -4.541866846961786, 1.3939736508563332, -3.578568110576919, 0.35995393483004645, -4.395801299328163, -1.188348971546417, -2.9260680906108516, -4.627457553559931, -3.886832578957073, -4.858508788833164, -5.4421001366219866, -0.7668500655106978, 0.5570619695979019, -5.172064412474222, 0.9144189034436673, -5.863049986200413, 1.8999543966143095, -0.08363609326869069, 1.974504428808923, 0.42871281513217424, 1.0056841612132872, -2.2068557311727472, -6.0961712418009615, 0.828681910302107, -4.71365905529742, -5.200226038262461, -1.8163138948458784, -4.76400513286132, 1.3206898428971727, -3.320486057264425},
    {-5.418067255237364, -0.8832040335206407, -4.696058158032252, 0.7284706493745842, -4.686298998835545, 0.5708668193353853, -3.904300390687469, -1.79336817909604, -3.202120560759311, -4.458608138000077, -3.2345660400319627, -4.875523553291511, -3.7057036737331037, -0.18983404772687004, 0.9111627454389186, -4.789968987776571, 1.0154947359976794, -4.397542924650031, 0.23417544065705184, 1.745842813934301, 0.314310234118163, -1.058175629774441, 0.8863854116363227, -2.003417755306114, -5.448979465168855, 1.440530620893236, -5.103322955211888, -3.342019429240753, -1.4140196079366516, -5.973594470981542, 0.5030850419131108, -3.496710162508166},
    {-4.613255774952448, -0.4526073325563355, -5.332451200058429, 0.37336524757780803, -4.067776728573416, 1.9618084738440789, -3.0171074962573803, -2.901203455591017, -2.806450512880831, -3.2478914817518776, -2.3859446192952825, -4.445684751807288, -3.473721281145603, -0.44678555423203264, 0.1468878686094665, -5.28567836894716, 0.5512589228593117, -5.490447869835279, 1.6107946658725174, 1.0787008977243695, 1.7360052361239824, -1.1487005200259186, 1.9177177474879492, -1.8308742321364682, -4.812970650716892, 1.908528537541801, -4.717542231806452, -4.580908187943003, -2.610605581945058, -5.911545784138508, 0.7731360707928433, -4.3414587977114145},
    {-4.619449931331459, 0.3628816478992209, -5.182459838624275, 0.2680962024774745, -4.579972963762361, 1.8170183780288445, -3.1473103029340836, -2.6327562053405984, -3.025031274431446, -2.829363255902547, -3.638323869388527, -5.306869710030309, -4.895562163357736, -1.9379464770989512, 1.088098892964444, -4.707704920230295, 0.3057379682660337, -5.147983081247488, 0.624879759700057, 2.2559767876506984, 2.395969995094941, -0.13454100962662116, 1.0618172647089696, -2.0426505557657064, -3.9847673322125248, 0.7868806631598239, -4.636538412035652, -4.029036245976237, -2.799508156261593, -5.052130649121112, 0.976661603706798, -3.0447164778736724},
    {-4.576856925317567, 0.6484892151900528, -5.169417228836929, 2.203384736054899, -5.304704247220786, 2.9170848832479024, -2.473253455393186, -1.3527500642872283, -2.443672973632305, -3.2581012668323326, -2.704484117638062, -4.443080636012877, -3.23530795046048, -0.7389299196117354, 1.892303456409803, -5.783859812538681, 2.249701020728524, -4.5895070785284515, 2.7243079727747768, 1.7219734879236912, 2.237952083043618, -0.09568910094579634, 2.154476575284002, -1.9442466591528602, -5.598160413660816, 1.0613378198176608, -4.798856221048734, -4.106024830656308, -2.5753897175735507, -4.704828761575282, 2.088674362129688, -4.370882118290144},
    {-4.207619567078586, -0.2795288584879956, -4.949152390745553, 3.7007900800538063, -4.135249582239772, 3.187879707746892, -4.280485395039872, -2.540154310516511, -2.806893669690945, -2.943723084579579, -3.9713504258919006, -3.902722110670899, -3.817433149299334, -1.4394231456959903, 3.01767329299111, -4.418199877211967, 2.6473245121254987, -4.323962580218617, 3.6937424086756807, 2.6184042909899605, 2.6797080350916667, 1.005267802546393, 1.8381766018282555, -1.976556006598449, -4.264370901315348, 3.4636150120647247, -4.93458616942988, -5.180836499496735, -2.9543660185936655, -4.223246546748723, 2.5736560493185836, -5.375735251338023},
    {-3.4481361018755887, 0.3939872097832002, -3.8763729367544104, 2.6350522520589164, -3.148212452612243, 4.056933334660356, -2.763848287796331, -1.8815989136485443, -3.906551649970301, -3.019306843929256, -2.4189229863644988, -4.991662425914992, -3.7870168084082274, -1.4340235811194881, 4.232081937054373, -4.823351094326193, 3.764617021535232, -5.265867482150264, 4.803129395185542, 2.9696126750031246, 3.801312901182123, 2.2378317084207544, 4.382641861762749, -1.5911908754135076, -3.9620681434511074, 4.3979033684128455, -4.029856115071285, -3.8777131985051336, -1.9431700926986428, -3.2472101258730612, 3.637603041526628, -3.410916682634611},
    {-3.8239664152519506, 2.941729459145061, -2.3578254112801216, 4.396857606413913, -2.8860640559434163, 4.8325702465502856, -2.507411064761056, -0.18233316822134188, -2.5745294505176552, -2.6003295197839438, -1.476654247698742, -4.064784431337185, -3.5993981258706014, -0.49300186333487417, 5.2016381519784725, -4.626097960879004, 4.472274935809026, -4.109630039428579, 4.318940212370546, 4.425571376247367, 5.33124131381446, 3.905844339563155, 5.2436111805317305, -2.2233852850639932, -3.9109856449739593, 4.651665245131568, -3.3765435662647616, -2.363242930010579, -1.3943386320297992, -3.4780898238355116, 5.23955313653904, -3.6065450410765796},
    {-3.689531172659793, 2.430761766710791, -2.951681908188575, 4.797033405034746, -3.349855113920951, 5.039304728227515, -2.532105025637962, 0.14738085738574694, -2.2226750764987653, -1.3922682833287565, -1.98591702648552, -2.344907968767784, -3.9234572321080226, -0.5980371174112039, 3.7992621074176642, -3.8174067154300064, 3.2105244118642853, -2.3726220936184728, 5.130053608969689, 3.5424249771775, 4.835988760430644, 3.2528672165675445, 4.738917433869, -1.933564451190828, -3.7595074782680866, 4.075664173653916, -2.858275370579075, -2.291859479213208, -2.37331227279025, -3.4740740740050158, 3.9298662397210764, -3.5155849375826977},
    {-3.1980471414287037, 1.2168680353416756, -4.643744445863031, 3.4049003382066703, -3.596515609541526, 4.674014004937367, -2.781739295357023, -1.5085943044965282, -2.7569866935486083, -3.5847292722876296, -1.6627052706760068, -4.214533280927111, -4.636813409865188, -0.7641958647391626, 4.5242242639772945, -3.5799554159746028, 3.808426212484506, -5.073904185709888, 5.094751323771749, 3.4451400026464314, 4.8858543195921404, 4.088943567441411, 3.8383747974699123, -2.831510621491261, -5.00763613565655, 3.785326378625057, -3.4063625253010663, -2.9269723333137025, -1.64367889521456, -3.043795388738208, 3.4273264710048577, -3.460353339339971},
    {-4.610276529916828, 1.3724957023314446, -3.51253239707121, 3.4771476625078543, -5.068665158791766, 3.9231408620962527, -3.426206806008126, -1.3180686864054254, -3.1779502200620633, -2.6149271521726423, -2.1592124790028615, -5.254483876818202, -3.743506835597199, -0.18657102844177145, 4.467056602004567, -5.485435409925578, 2.209676651193043, -5.488555004653266, 3.52393867493408, 2.6444286962410675, 4.659839013582782, 2.8719404352179025, 3.214334348659077, -2.258843779657212, -4.803807476003749, 4.477274403291276, -5.299750277499922, -4.312374849543626, -2.127531808552082, -4.5460670694519285, 4.2391338452826615, -4.682276905256953},
    {-4.65513563523209, 2.8074180576966974, -2.6961948402225007, 5.303274856567689, -2.8993236156529516, 5.659860791567562, -2.255055589197345, -0.4808132534635504, -1.5425142510377874, -3.2116914447477254, -2.49932607965558, -4.598884276285196, -3.8736502566556874, 1.1867081488520643, 5.797881840909027, -3.638636630679888, 4.393612885393943, -4.040064055973276, 5.755673580060345, 4.968139609986356, 6.061267975344042, 4.441593408249043, 3.756479705525845, -0.5303024226123265, -5.069058056216796, 3.921645674347831, -4.037355953791301, -3.3961948793138643, -1.1119917517988378, -3.0447300863082227, 4.701494062932834, -2.9254705427870937},
    {-4.116559397639724, 2.7991537906798833, -3.145317304067991, 3.6704594207716084, -3.050819061701261, 6.1455819447217905, -2.066073671461873, 0.5677853379095689, -2.160395993791433, -2.758742139297198, -0.5916524235735461, -3.268861777795673, -3.064671461782621, 1.7879723932568832, 4.8613630197948625, -3.9526311019056917, 5.448957197260525, -3.289499321985255, 5.244032981952969, 3.8422717720439663, 5.911391702812193, 5.323019641677539, 4.111102932464123, -0.21956607218092689, -4.031934552113684, 5.549140550343057, -3.5720496314400743, -2.1965398907766764, 0.1371414050745402, -3.0497867616301746, 4.6542014420115105, -1.4221235295361374},
    {-4.725089357781339, 1.353657876907291, -3.778767344617536, 2.8421194072090454, -3.4806980195347204, 3.920032425635642, -1.864173405143028, 0.24829469298366547, -1.3642606867051643, -2.4470327218214147, -1.4543597346461843, -4.333781484174788, -4.385854387345249, 0.8566335801603602, 4.780313137717773, -4.631246037356906, 4.088353244061727, -5.2756432937576205, 4.392931637504967, 4.408901255140213, 5.187232723999852, 2.3911334718655866, 4.3849502256102255, -0.6469151993818494, -4.250513939453885, 4.267490300208757, -4.181483723123464, -3.704858906798813, -0.08977475110507617, -4.6758512628572495, 3.921567875147798, -3.4768375673702763},
    {-4.350580336393345, 0.19279245783533577, -3.4077584897509667, 2.1012916134650976, -4.159290174567337, 3.4131729135746, -1.8683561661312944, -1.6400511564560363, -2.7048550857915474, -3.3365095783600065, -1.381506672781775, -5.082782895287851, -4.617500957174009, 0.47416953663718064, 3.4307176570236773, -5.329787148832083, 2.9541530873139097, -4.699198335541706, 3.083961192477822, 2.9140214707397503, 3.2475525321382652, 1.8109538064834263, 3.485259891682092, -1.7761878060356833, -5.340357486012332, 3.710508702891736, -4.0980100311864325, -3.3514660641216, 0.5393812025528483, -3.9468838895609437, 2.9122985360585814, -3.4664729172620596},
    {-2.8562718183693936, 0.17606774111900167, -3.5814700817282716, 2.7554042447761704, -4.238669233018545, 3.3177712889425464, -1.7839230223773324, -0.3265532167798296, -2.1471639969194185, -2.351089340340441, -1.8882887115874532, -3.9825680450697374, -3.642619569401034, 0.2491888297349344, 4.652034655136058, -4.857696602814505, 3.3348211199415094, -3.9503887247879, 3.87860048609048, 4.319913346882545, 4.626357862870187, 3.0903458542995983, 4.643583741386449, -2.222999063972044, -3.2162225863074676, 4.666832867178426, -3.8897907439976227, -3.4348450745347368, -1.5424423233586062, -4.091078371357691, 4.019703517505455, -2.4521583313872184},
    {-4.931427648839084, 2.301527002464163, -3.0214107412178715, 4.133895410040754, -2.7287945114156082, 5.09439914270081, -3.380848014372472, -1.1456017818759956, -3.103496542906886, -3.65922386035646, -3.0278823829216175, -3.182904557200881, -2.766100784797664, 1.1287092936457148, 3.2773368281852595, -5.088222456705744, 4.556110506590472, -5.135937861149057, 4.982770565580978, 3.3191576802883747, 5.636927375020464, 2.8595970912420645, 4.375611958908823, -0.9838757177674399, -4.980081795480055, 3.824202917827589, -4.777534198951917, -3.7965268442149473, -1.2474864483560935, -4.967685578866539, 3.853308407806968, -3.227679436069859},
    {-3.678772437209488, 2.316735777373237, -5.01375975860628, 3.506423432358069, -2.8325367583456122, 5.050791896981296, -2.7586577574950204, 0.36944086839368645, -1.9161492910131817, -2.1524859794768663, -1.3485371409077527, -5.072896118705628, -3.805067266704273, 0.29294858119141803, 5.199922227191603, -4.068052967707607, 4.696109947988529, -5.3278295926452515, 4.822141680974103, 4.3286105736005425, 4.861543392485288, 4.2621918710534725, 4.718187287485633, -1.4724711873061722, -5.382944193348803, 4.229849367482112, -4.7559573759467115, -3.6247046060926476, -1.5806835150500644, -4.839274212170036, 3.9402595144973294, -3.9618207552542697},
    {-3.428154164820086, 0.5828760443376696, -4.728489151389942, 3.767714715101959, -3.540775859848789, 5.118901187649182, -2.855395873741086, -1.4007249092971576, -1.9007204108794529, -3.9096430468771186, -1.8182958295911213, -4.320367664611116, -4.514246641335368, 0.7243316884828914, 2.8615792086211735, -5.64925323556669, 3.4819101367215195, -3.710688159172728, 3.8452111012704044, 3.97675765929097, 3.5392026813650213, 3.062264963840304, 4.1118467382546156, -1.068700795966197, -4.636225242101801, 4.649859864562637, -4.836179219826113, -3.552776401897652, -0.07835537436285195, -4.476563855147079, 2.8991742990873863, -2.728868342171307},
    {-4.772716982475528, 0.6000225889735489, -3.6154899156267963, 4.207749266711011, -3.263879372550684, 4.117768967823275, -2.0266967158312825, 0.10807927658192629, -2.3778371463675354, -2.880490516723672, -2.4452710053254347, -4.871200342307568, -3.8001515949520606, 0.489298223195038, 4.442771056833563, -5.51031439446576, 2.7595996386782082, -4.007860468377705, 3.2903998951556686, 3.4937183926816693, 4.833191630241226, 2.6971859230800224, 4.5355217106749155, 0.046143002169851045, -4.26976079260124, 4.093778962924836, -4.76944785992846, -2.564586041168375, -0.30788439432178166, -4.22552781140597, 2.8262753677047625, -3.0217024227227265},
    {0.1992627718367976, -1.9995711484755305, 1.3592691202800644, -0.9937795037043594, -0.7418023910983099, -1.215276005021634, 1.5190521041236316, 0.8422650793940544, -0.5556950904740555, 0.04866148231278453, 0.021437479823887377, -0.45213125528558656, -1.1052935050734523, -0.5548948783185703, -2.3859476149464482, 0.33379899441749716, 0.10299243223669335, 0.6340395987869634, -0.5428460994651858, -0.2186128218553018, -1.9265607022581352, 0.47444194897261754, -1.3712612111799491, -1.7666312528020807, 0.2816847095530934, -1.503735455613703, -0.0034288320954648723, -0.2363598001169511, -1.226661702717635, 0.972562570153106, 0.31467984267664456, -1.1681485389311},
    {-1.1977642678731457, 0.6063218339079308, -2.6848424470748213, 0.6964598751564793, -1.090618231195655, 1.7107604417472664, -2.508261614863737, 1.041928921665554, -1.149092972763165, -1.4201764479964774, -1.5969732446223222, -1.084750101979639, -1.3712579577136315, -0.17872722320924347, 1.1251587388069613, -2.360166062117635, 2.3477110137356236, -1.8228300654810035, 1.3266746213247371, -0.11242560102712598, 1.0482312783378969, 1.8621112147343146, 0.496679840995547, -0.18498140491514933, -2.1297069602570007, 0.15568850988717134, -0.8713700711934684, -2.380889814103088, 1.3025718072631007, -3.0495157664075, 1.1850575600261832, -2.7164123843707375},
    {-1.2308076330555568, -0.9807698090995652, -2.6542890893117685, -0.17459529324194706, -2.632155479376916, -0.3243938323159511, -1.4297332511168812, -0.22972532311730248, -0.30106061752333374, -1.3640821164457198, -0.5546823029419299, 0.42416750377214135, -1.0458911488462097, -1.40654056160167, -1.1462924986904086, 0.6681354039578289, 0.10273202603906131, 0.6867276656893558, -0.177913991208591, -1.0188903899576638, -0.0006572409408579444, -1.0555622035559302, -0.1898527866013486, -3.153633987974526, 0.5060257739722569, -0.29440154691679865, 0.399249677985412, -0.5645132963639764, -2.9789475234530114, -0.9330397199002269, -1.3012525791619194, -1.0403298593508894},
    {-0.9496473165146638, -1.8852877069035894, -1.682674607953731, -1.723842195310182, -0.6507305833131705, -2.179543637960035, -0.5884896524125736, -1.6362208227654507, 0.1189573228965661, -1.6617024737390185, -1.6543896869385586, -1.5988017520221665, -0.3018854073723708, -1.0897824904732327, -1.574843794159668, -1.457838537815686, -1.6543937277155654, -1.262581301244456, -0.8106979748509424, -0.27675860704328054, -0.39095605714581394, -2.210469103490183, -2.104199756145282, -0.981937517018047, -2.4233235750441717, -2.7468176913319002, -2.0182454429874097, -1.469409112921436, -2.1674830384390398, -2.5173773204649303, -1.6966296900942006, -0.13158645418932982},
    {-3.7143847544610638, -0.5458677132227026, -3.3773038632729575, -0.616462154187345, -2.8739293404560535, -0.27004071869321833, -2.56326868406889, -2.5046935328974427, -0.8485913898918027, -2.2590446303091527, -1.3178283234349293, -1.8056261459248857, -3.408849299715511, -2.0486401111438255, -0.20789571757114184, -3.1443693134814166, -0.19184943673989818, -2.5781163313259468, 0.358746714488815, -1.3414133084092792, 0.6166378578693558, -0.7888827913752293, -0.4459953002971783, -2.7602099746789053, -1.8195207131645974, -0.20390164741469768, -1.38178443256809, -3.9632986829000645, -1.6312372269258812, -3.0850739194422765, -0.05382786118969813, -2.331043185113583},
    {-3.514787230380804, -1.1846888667675786, -4.022484380534724, -0.5715462538603207, -3.839765810154102, -0.6691086995212872, -1.8566118905352085, -1.932627835796414, -0.8850424114359536, -1.6128800239831458, -2.654983390843491, -2.0322414224932377, -3.601570254372744, -2.150368203024402, 0.23903689537808118, -1.7290914725814723, -1.0909356156411707, -2.9185421542587147, 0.6530340957795453, 0.15598283306484578, 0.5063393370590255, 0.5520336115182743, -0.40495758884676697, -3.594609324104325, -1.4319259239480935, -0.5751109630896053, -0.9830680790456829, -2.6102434462524267, -3.0103123117474717, -2.5660203151015386, -1.235332330904379, -1.9367936548872688},
    {-2.999570284913593, -0.2191939553785678, -3.0505213134795177, -0.22439041544345495, -2.8627064828508186, -1.0591602958407769, -2.4454101260704544, -1.69774308052773, -0.44719157024289247, -1.6366276692640087, -2.3129728931697553, -1.6253714079486994, -3.4794785816739964, -1.0647284792561769, 0.2988422788065854, -1.4483743705643148, -1.3355742238564465, -1.2317263672138903, 0.059761777811191456, -0.07363962593902484, 0.09847768077555862, 0.666296880618884, -0.677699684333322, -3.818997595711623, -1.841791883629079, -0.5581392306987466, -2.6572636155677096, -2.532722635851085, -1.5441691686995964, -2.023240482527586, -0.5167228762967612, -2.1888065595785533},
    {-2.4730897354398254, 0.5479262871306402, -1.616672066341267, 0.0775428043121265, -2.157807529655315, -1.1938825527533943, -2.5857187111808564, -2.128335743894557, -1.0671116769719793, -1.7695514190645103, -2.382181225350211, -0.3586467006048637, -0.7113505305580948, -1.6408670958496516, -0.39614824645070973, -1.2552220102313663, -1.6970951659553168, -1.2419403731147611, 0.8252276887366888, -0.06904448941022179, 0.3998055194530865, 0.5231744098665958, -0.35476391747318436, -2.3613409448440543, -2.984305681056919, 0.3676572916006681, -2.553913406614612, -1.2130717891343523, -1.0218108680916713, -2.619530229062772, -1.3727018621209104, -0.4611739678954136},
    {-3.3801968865764516, -1.0607002064498388, -1.7827820168145565, 0.6265299239654559, -2.066190131349508, -1.0777407337244063, -1.5977411555041323, -1.8126058847569004, -1.114836862357373, -2.437488973302677, -2.2766861682174127, -2.194303776462906, -2.8583526487206465, -2.788066755185295, 0.080684698887617, -1.694143851031407, -0.5528726144057857, -1.1076105376621814, -0.1029363670421984, -0.7066784174401107, 0.16990194672251716, 1.4003681335290705, 0.5555470955513426, -1.833227222932916, -3.109202109640103, 0.5412959873542137, -2.4050710819727597, -3.1475937369994673, -1.7999199747231507, -2.690013566354613, -0.42508583609293643, -1.6823734386545468},
    {-2.908779390717182, -0.8422504470838703, -2.785197124735009, 1.1712720238874557, -1.4583534912355915, -0.3168102489817006, -3.2896850924365566, -1.9229381440508193, 0.30033616152013143, -1.0010440187291128, -1.8162834757920314, -2.1885237465887006, -2.613525871109656, -1.3968610498927734, -0.20668188731659123, -1.7580229882450753, 0.33863176087015606, -2.7922934788358034, -0.3778421653165788, -0.5069941777129804, 0.48077952895513376, 1.4403375222288548, -0.037598854231541204, -1.5774457578440044, -1.6005814487415906, 0.00238790155753195, -1.321986751502473, -2.5690091245687796, -2.536923872689375, -3.427970231454134, -1.2389198995680615, -1.3709783938443858},
    {-2.6018036364893677, -0.47043890443254754, -3.63650208952053, -0.8423858918290308, -2.892654784964191, -2.1341607339062203, -2.4600733545907287, -2.111451938680137, -0.8779589058839228, -2.4574650197514254, -2.4927096798275388, -2.749625678998524, -2.9148407859617764, -2.1871725462733744, -0.9095988665980265, -1.535592226853744, -1.646668321530961, -2.70195613932966, -0.47351652341617345, -1.42007043440091, -0.9227740483739918, -1.8128096099868636, -1.8716530209611926, -2.9939785104655607, -1.5124752007612596, -1.2514716316360563, -1.1193661835267663, -1.912659839383827, -1.5612464291412473, -3.2997428402551563, -2.7015673135549334, -1.7572548413781666},
    {-2.135440093035167, -1.0500753726377654, -3.2272684224220742, -1.158613016362889, -3.6606201285856437, -0.8315821419265274, -3.3357366406023736, -1.184375182251814, -0.7767641892682827, -3.035297842784673, -2.8179051266616066, -2.0007636812368608, -1.4612100797174796, -0.8869676141377343, -0.5246126537532627, -2.3890836969626266, -0.7600714759580577, -3.136981056503891, 0.8504306196724336, -0.41516415627963715, 0.332462363689423, -0.27465611010780516, -1.5752920521379126, -2.6605137260098153, -2.963679432315498, 1.224508516371032, -2.1796827390174136, -2.4704026031425137, -1.5728607792453155, -2.5351739900912036, -1.3613689615568898, -2.0643279786958706},
    {-3.162809479275587, -0.23330339627738322, -1.9372309681743274, -0.17362299839434014, -1.4748451388018708, -1.1718949131203507, -3.4480606670380474, -1.238964953437061, -1.3018281853630085, -2.7379167258646055, -1.0288709234096207, -1.3884785785354337, -1.6727464464156179, -1.3978822345874145, 0.3763412522574251, -2.2313158013967938, -1.075276452955212, -2.7520117924116447, 0.14995184849253584, 0.11055469987473063, -0.466938067841457, 0.44877768968820414, -1.5465211624319395, -2.028519955658134, -2.6539315841319167, 1.3166585534399475, -1.006896165365323, -2.3311768782788387, -2.3182435657384532, -3.6373766240835104, -2.0659966120894513, -3.518483692250826},
    {-2.128590927022576, -1.5359239877460127, -3.1685817655628896, -1.133113254407764, -1.8223801585434953, -2.0263443215429424, -2.3545494901238038, -2.0951475049063446, -2.4116906702580634, -1.8454056607218967, -1.3100553057186792, -1.1210055322478782, -3.384947996106968, -2.46817657601641, 0.6546355415346791, -1.7353831696049908, 0.1288225271179035, -1.6984702833357028, 0.18716720323187694, -0.9267522613472268, 0.2118878578237436, -0.23145691850351696, -0.16750276276556061, -2.0849073942487566, -1.7396214427271854, -0.3679317783255108, -1.326171773460477, -2.828491843774972, -2.9423241106135882, -3.2860898427415113, -0.3822149501360702, -2.4328368961973035},
    {-2.7729829557009165, -0.7157842856685896, -2.5714614581385367, 0.5749071521498713, -3.298066605157232, 0.32216507812733036, -2.383677403650296, -2.117715703000439, -1.9905078245725087, -2.877431897611451, -1.3567841637411175, -2.5849157493370574, -1.7169511216813682, -3.0237450387730695, 0.15354092801991137, -0.757619666219494, -0.3675195333562289, -1.8110012598377958, 1.4325600709392083, 1.0756260260092354, 0.8786976111413494, 0.764372310551548, 0.09320577037187058, -2.836189534681462, -2.364335027537408, 0.6872915463710577, -0.9511980636244536, -2.1427122110194317, -2.6722964205636637, -1.10296162428828, 0.7351468610011546, -2.217900106393242},
    {-1.5795882059535213, -0.14323474870755465, -2.4364787353747412, 0.7020974780720198, -2.0667766329740322, -0.011068769451591541, -3.991603622285202, -1.2870868560449777, -2.439528017478554, -0.9527680834909441, -2.554970438391527, -1.021736290053071, -2.780743906920833, -3.2492055890246885, 0.08867159230846051, -1.837716679318798, 0.20587451865796727, -2.843424825736721, 1.2768574158828263, -0.0784682718849706, -1.2345484332256225, 0.9249729039785999, -1.0959208668915217, -4.04673260232106, -1.534661286861415, -0.060893324561514355, -0.13467488368160452, -2.6936807349807093, -1.792312835217001, -2.7628834172957397, -0.7293029970133748, -2.708456795530469},
    {-3.118244023902869, -1.6388962173320196, -3.45359563342891, -0.492893163662589, -3.2527954744276344, -1.6479336417805257, -2.6466297065305318, -1.2255288260368387, -1.4175379399870092, -2.9466740416285004, -0.8592386640694651, -2.459739554104918, -2.2454699117991845, -1.7678277301499528, 1.5553933609592514, -1.164006149936846, -0.339345677701423, -1.8569689014633737, 1.1148043590224883, -0.5735933899441676, -1.0702082221975113, 1.5448212876021912, -0.11198002886591729, -2.065258879787325, -3.147505103688298, 0.15714372734479187, -0.7876143445330792, -2.2791074289770075, -2.055132791612372, -3.1871424296317055, -0.793390276946577, -1.2132440344576192},
    {-1.7907729633138938, -0.6930712365259273, -0.6376438067927818, 2.1626586895880315, -2.2200434282443995, 0.01428574144285763, -2.2037432926237392, -0.08366032617385541, 0.1635593072041831, -2.004664511681339, -0.7850987363057219, -0.6540507458071061, -1.758608281172248, 0.03449029433344225, 1.45199774555473, -1.2303606669835692, 0.6407025365646507, -1.6013597358071807, 1.7756373490528732, 2.059577249637211, 1.8800667325118907, 2.3092340384613936, 1.6643147980385797, -1.8529135516897284, -1.943102378352942, 2.5967118953361585, -0.533727628528805, -1.4665622098844597, -2.2147089952433268, -1.1390398541665123, -0.2600661059368604, -1.5687280043763772},
    {-2.6842902991402195, -1.3386348767121132, -2.4344722237334127, 0.26426006204871677, -1.4354081102958507, -1.748078325083967, -3.7341748031368702, -0.6680835145089988, 0.1717605665087261, -2.2125557817317, -1.2782781947114121, -1.1798690402432674, -1.099464428673465, -1.4003005507946036, 0.3204852275785681, 0.1082813356802957, 0.36392146550722404, -1.1210673644334856, -0.4359772385991052, -0.041074616004298986, -0.7098468278662069, 0.43812359676842333, -0.9292681361552947, -2.481011073395907, -0.2548617151462315, 0.9198263334924924, -1.3044366806096217, -1.8095554477092703, -3.926774829471134, -0.8104586171251102, -1.5299423398667942, -1.3318564310749084},
    {-3.353444816007082, -0.8166086793227317, -2.1380196518985497, -0.662525921127617, -3.578880851944804, -0.8318335981490503, -3.75921928647995, -2.045381307629486, -0.701752681195643, -2.38860554825345, -1.384127175535529, -1.7204428522312236, -2.1431342958207265, -3.8511669450630444, -0.41436787017107396, -0.939456300115021, -0.4306866342385896, -1.9471251292096177, 0.5247845683048159, -0.5297765819663302, -1.250107002457952, -0.5930827270979293, -1.0904830775721057, -4.225605553749663, -2.5650904604298024, 0.48698822911476264, -1.3501180338320513, -3.0106536999364595, -3.0410759549738584, -1.9181511067250272, -1.7831615404681702, -1.700139471294014},
    {-2.5154899608229946, -0.9647166161562948, -4.645975731388416, -0.08824252069121577, -4.2029072102458676, -2.641309493239015, -4.555029897179195, -1.9582824810769408, -3.1814793234125682, -3.761950257945063, -1.9439030544742775, -1.9745016533359683, -2.452998460285699, -3.8949800901920217, -1.5509433415724563, -3.773696096983195, -1.531587172586977, -2.22345738455779, -1.3215027198720801, 0.051698604579636036, -1.3321065787669348, -0.15202273349276338, -1.081711681220549, -4.961690560622844, -4.245010999630004, -0.09217736418680458, -3.692626286966677, -4.187281021278246, -2.938255947415662, -3.3177976356142316, -1.559138004426182, -3.254791816435806},
    {-1.4315384442948393, -0.6053712100610859, -1.8049779202953737, 1.153962207385795, -3.467385346862817, -0.11435132449557092, -3.790622752628242, -0.3607688649186766, -0.851894955802728, -1.5952310743075881, -1.1393840020140487, -2.729803764589422, -3.5131327606315215, -1.6202443462798677, 1.7428574783019382, 0.24277417741927326, 3.0893622492565203, -0.23765946693242038, 2.8385709532647114, 1.1616382867952342, 1.532997953531306, 3.494368318129024, 1.156303063590837, -3.791406720386836, -1.0802174125232311, 1.6601726410649753, -0.16474571676431352, -2.4779100418613433, -2.3189039816881474, -1.104386933066552, 1.6577048180462235, -2.2054844677352197},
    {1.089099603228143, -0.22294940535102248, 1.1110583099653073, 2.2380557920136592, -0.8131108882840243, -0.4398792653354712, -2.552994583749256, -0.12944878495919626, 0.6712940252544738, -0.20637296817800602, -0.09749258938689255, -0.09464800283650625, -1.1302278751656172, -1.8338099049366048, 2.4365271975810896, 2.2683023777481504, 3.8161778606047188, 1.9880870319030446, 2.558150327696821, 1.5663130291740623, 1.3670591377852337, 2.732200100836792, 1.072754517929304, -4.365277069004667, 0.35854916020132216, 1.7377760505949005, 2.009269872393646, -0.9991116919810262, -3.7116809409111977, 1.7168551123972358, 2.372434245775348, -0.6101868096980751},
    {-0.4167265973883812, -1.128310746454747, -2.1464617158162076, 1.6568972356748535, -0.8869973704578825, -1.5086462329741046, -3.5628813115395324, -0.6539198461700206, -1.290551711385281, -0.5198968808441323, -2.5561925937849184, -0.857286752394987, -2.8521109243974148, -2.275302389947981, 1.0907289563674447, 0.561995227799448, 1.9143991032919778, 0.1493410363946664, 1.5288514018771142, 0.344013584414189, -0.2529177557237412, 2.1262615399816625, -0.43631309098764554, -3.274294459724491, -0.5249081776759907, 0.024858535876168087, 1.2230218842215663, -2.8265551698480533, -2.908971084522415, 0.04391358589198988, -0.2058219724324394, -2.57907101883636},
    {-2.10871883348178, -1.4599426135123414, -2.973164674724157, -0.12853392527398827, -1.7963008875385265, -0.9220250083970528, -4.0929373589853055, 0.04503943207761118, -2.0213528721258136, -1.6581791035941569, -3.296282828846891, -2.386907938250662, -3.2715432697921023, -3.4208592003732274, 0.46997047305923095, -1.259183740071596, -0.6168084281239099, -0.8518108556990313, -0.3748018516352056, -0.03297304286430181, -0.7474270413378948, 0.5882372878676284, -1.6345284552108337, -3.1107403917720204, -2.3971069592094403, -0.8268085423986419, -1.7472028394393098, -2.2402068301411977, -3.8411645077389065, -2.8874108728787413, 0.2917386883109146, -3.5125898834033036},
    {-1.132608612224273, 0.19168049065177814, 0.8191201540415303, 0.8336822837320251, -0.8234058552725106, -1.8197001534881565, -3.534374947561726, 0.2821577781624763, 0.7098622574121656, 0.12678077767460386, -1.4288592419373414, -0.8412533243545496, 0.07289733418936266, -2.718841710454767, 1.468183404032136, 0.3425723167909411, 1.0825492537361212, 0.3586892404725236, 1.7675304878730287, 0.6176156473852442, 0.4053797168796952, 0.3719331118149054, -1.4473977057578216, -4.760657407850996, 0.6420270961427983, 0.29342470775522694, 1.2518854785131313, -1.0769485609504128, -3.3679178090822166, -0.2664215647821111, -0.8596149904707062, -1.334447822923345},
    {-1.84694324885982, -0.26180203559632, -0.3533800361168279, 0.5547512827162944, -1.9524045462279316, 0.13649730213993969, -4.529578337471682, 0.6242496156426495, -0.6767559908150832, -1.8894941954901725, -2.8789958510776996, -1.0675817419297107, -1.5360415648485948, -2.276023438051803, 0.2821004313007256, -0.6146010967691397, 2.159166967337579, 0.29543731160326864, 1.4402009581108748, 0.6396615969150725, -0.7292124180752918, 1.3608193124237757, -1.0099982007101815, -4.225127396973138, -1.4701787149321843, 0.3289759139669746, 1.3254103735422258, -1.0616269210856077, -3.6196275786906917, -0.17518470653519783, -0.23725133278730767, -3.304933272660584},
    {-1.82055719267022, -0.2980216542930979, -2.5813414858678634, 1.214552650681485, -1.443037898841145, -0.597467932765303, -2.835613324562418, 0.33124143589503263, -0.31062022432307757, -1.6376098033055753, -2.9297837789528627, -1.256012120264997, -1.9436350679013903, -3.599502194204231, 0.3096704330738505, -0.05101269431485327, 0.7576969651268101, -1.7416257975301408, -0.013812101842852205, 0.616927974989186, -0.13801992951599998, 1.264244172704558, -0.8941779846962178, -3.159190800598637, -1.2973038872858398, 0.7513280930732708, -1.1463926745373223, -1.3162498536922889, -2.868112596904756, -0.4621148543347644, -0.7228137744431713, -2.871179989748778},
    {-0.7579545036017252, -0.44258895117232944, -1.0226612472737344, 1.4162606886899283, -0.9675113545780689, -0.09538453988230695, -4.2767747943004295, -0.8611553497868648, 0.11109763470572943, -0.9175663384119521, -1.421342144928697, -0.5376746264562242, -2.9385086433763203, -2.8081100143181277, 1.0235729135089944, -0.13845274576269864, 1.9306534263524084, 0.29353839955213407, 0.8766514982924245, -0.03154881228295185, 0.2839217413294443, 2.6566091593332644, -0.25543754952512104, -4.3253862731587684, -0.0430360286522397, 2.1087478622208, 1.642696302181401, -1.6835778075824266, -2.5699817751904646, -0.28238602984495725, 0.7139231301699711, -2.730454638457934},
    {0.12677121327545174, -0.2601249977867156, -0.3485301448300261, 1.668955341359386, -2.229415941919342, 0.08819106425635317, -4.0770525813147716, 0.3491613300993883, -0.4887609740051083, 0.1930323907199206, -2.1787249723184616, -1.3809522203253026, -1.8949002877371386, -3.0757277792668276, 2.7453713940261824, 1.0808140703078695, 2.2822546741116385, -0.11882409499181348, 1.1081948192470876, 0.9104968546889894, 0.4665561682740504, 2.0677036333422323, -0.5138991660792973, -2.823953686437303, -1.3530713099472784, 2.0351562558774074, -0.014344211266557206, -2.6438540603986644, -3.336613123472991, 1.0647036629138067, 0.7531216978445802, -2.5955019842056575},
    {-0.8218191121663885, -3.57618418016272, 0.5568672070666555, -0.3569374168931939, -1.09867499801067, -0.7757631680366429, 0.7064102831191036, 1.3208669990913753, -1.4421256511361025, 1.0574655639442938, -1.8884084437409274, -2.034943670707856, 0.7178085842636612, 0.652798742877388, 0.16730351063423268, 0.8103887194048037, 1.2772836708810147, 1.0820490824344782, -1.933627814082477, -1.7115089442189027, -2.056471443947176, -0.38350262641115673, -0.8624502432592945, -1.1238341933775213, -0.45988122928251507, -0.643624479006279, 1.3909149851968567, 0.8016051077508631, -0.11056433746965709, 1.1856655899566615, 0.9205452326561525, -0.9318375254495647},
    {0.9410273409754796, -2.7853789809731433, 1.5045826171000207, -0.12149491681014414, -0.13167400943398086, 0.9635438472910889, -0.3210945566379751, 1.6048641880617023, -2.0469562024179595, 1.6931916319225566, -0.9666481888879522, 0.6157028530032131, 0.7980506184583944, 1.186789861846224, -0.4230968304519357, 0.24893480352157882, 1.6024956027690334, 0.6274235382480201, 0.2033952355681516, 0.328098875074152, 0.647694336490263, -0.22963638995385505, -0.9090066539852697, -0.33956883790187914, 0.543637021312566, 0.7297072242249426, 0.1585438950758462, -0.8863689748045163, 0.07631759878813782, 1.66388920200308, 1.5564446912124825, 1.309828315777961},
    {1.8488372932606023, -2.4650118726093324, -0.3709554158480758, 1.5793469071960469, -1.70031134289964, 0.8054095078450373, 0.6841865487910914, 2.2254972164277014, -1.9914031068607587, 1.716967912605153, -2.6021532989855336, 0.8442779414388615, 1.5706967729699715, 0.4695850637973603, 1.8685882534545508, 1.2851644395748962, 1.409978220729952, 1.7702371764546012, 0.7289081925564362, -0.8578341854183235, 0.5154319499359434, 0.3255976952893769, 0.38885099392019373, -0.18579591132590262, -0.07249090539895081, 0.6862989002974443, 1.9211338786815517, 0.6675692686205108, 1.3856839701426853, 1.086519975322906, 0.32914691143361235, 0.48831640590769926},
    {0.04440534858650675, -2.51310231929994, 0.9092476931866236, 1.4363353672724029, -1.0357565679767682, 0.070164425719994, 0.38018720353719193, 2.5826793713860856, -0.4467306716013058, 2.198530292288468, -2.294828130892296, -0.4982964671329784, 0.20925147765450217, 1.2372811380858852, 0.4427188621901607, 0.603690935988451, 0.9911356121677596, 0.1008165224058706, 1.3876685280109466, -1.6089406424833732, -1.0778254240631384, 1.751595074958868, -1.4018479051276584, 0.017073511124069612, -0.06275994227689004, -0.9056447008637195, 0.9680634322289315, 0.05597320670089296, 2.0270694729257017, 1.6629165562489692, 0.3966481855551624, 1.2728724804710678},
    {0.18906693117678944, -1.7559152098788355, 0.4875213294844099, 0.7683613771525607, 0.2266327882430932, -0.5788383898278613, 0.6387668154922405, 1.7598493070019297, -0.5397190453299741, 1.326895099632443, -0.5731684595218904, -0.9712565475432953, -0.7908326755977239, 1.5582723474642184, 0.32127611436458237, 1.3050145013518215, 0.6615267033230933, 0.3159840350528281, 0.09806733423636771, -0.05648770620064343, -0.5537355656431868, 1.961454436623673, -0.45969556406116197, -1.412869642621608, 1.2029856129555407, 0.09944048008239818, 0.7233266629679003, -0.4661952276344198, 1.7962412938038905, 0.09640260472380166, 1.631585910059078, -0.8275624870683227},
    {0.20156703750168942, -1.1782441802090173, 1.2844007057089222, 1.0236101431720919, -1.042366584921634, -0.9838803456560785, 0.18235817617516012, 2.8125319581964847, -0.3847751887943317, 0.3763362732508972, -1.5294376000304355, -1.661570490304849, 0.3907669818071247, -0.27488660814487464, 1.382709520531063, 0.5513984618456634, 1.227447866934614, 1.390872876852882, 0.8200291109707445, -0.7360022190545032, -1.7116286765726616, 1.7839486205082682, 0.2820581770289023, -1.1476265947060413, 0.6872413255982613, 0.7922026629763846, 1.308172658404191, 0.3029783369265372, -0.3411043462672781, 0.9972838450813385, 1.727108340465952, 0.2753135645125545},
    {1.0782033629479277, -1.8161505802366658, 0.6804766304060836, 2.11532029659744, -1.6857452478815398, -1.0156382829859787, 0.7307567547117051, 2.9762133759736207, -1.1412346596296357, 0.47838683652168346, -1.4667947818993132, -0.8174734624063231, 0.8641675733326404, 0.9939461026754478, 1.4211515042206797, 1.3433467133232972, 0.8025606633315423, 1.8157108877068502, -0.20616633752329228, -0.8874543358971125, -1.0935958646481994, 1.6000631981404136, -1.2605125526430665, -0.7080467556140134, 0.3154953131797136, -0.10894227228146748, 1.932104175457712, 0.1472898218357025, 0.537147250185827, -0.04707458769088213, 2.0355836278862016, 0.2906238092941286},
    {-0.014834848779794876, -1.5626833341930115, 0.5423545747675796, 1.3878792950321817, -2.558431336890455, 0.6827582551199608, -0.2149096060731642, 2.7968188300929646, -2.625696745525177, 1.3551056989272132, -1.9079750914038789, -1.4657008189875202, -0.7691304657422475, 1.549372319187644, 0.9072903627429902, -0.09035288941276497, 0.8722911473330162, 1.4465700846044982, -0.40545001154294874, -2.4635052931505625, -1.8455604869434907, 1.4179308912171658, -0.21413353284642797, -0.562916954750086, -0.7729335313723319, -1.1634429792939631, 1.1770635093478719, 1.0767103609111963, 0.13763395956002455, 0.43672301035445243, 2.192108885917783, -0.7249811741891189},
    {0.3744357798492775, -3.1321980957756836, -0.35139125010748645, 0.4436365545403053, -1.1961020396568725, 1.423625400382131, -0.9877482009673314, 3.037105401167579, -1.7942517549685582, 0.9817201240064519, -2.76039268582654, -2.077922122332604, -0.5681119824516581, 0.22731253441972998, 0.23209728776468733, -0.15982929817717811, 3.070730767637473, 1.2425612279140283, -0.7146187640927266, -1.769426184440492, -1.3081871935930711, 2.051262213125132, -0.6009962508182585, 0.3144398162324352, 0.09401181618091364, -0.6916042883478375, -0.38931569124092846, 1.6152367381249324, 1.5282216874103518, 1.670548830342264, 1.3331122299187284, -0.16653076120326601},
    {0.20912407546248826, -4.009263219811801, 0.00967474076825338, 0.6875202960347688, -2.3403008967987677, 1.3374617681541525, -0.14117964559612, 3.270369025386317, -0.53420634664003, 3.0984203547815543, -3.0607859477586565, -1.9581715631521421, 0.5101097350302868, 1.6520755778569436, 0.7460626887893721, 0.9274922918687788, 3.3565639400142686, -0.21028363552506477, 1.3379661196403247, -0.5351377686070002, -0.22284633250029937, 0.9726118491047134, -1.4191773827698606, 0.8109684865114383, 0.13132858958018304, -0.0934040203474498, -0.24657967208543702, 1.4768083081797327, 0.9972252059064924, 1.9255458688486033, 0.8320376624189945, 0.06353936849301181},
    {-0.45830551955654475, -2.776370435313744, 1.3081654433995618, 0.19474609956306765, -1.7048164609936292, 1.1593885772581376, -0.5733027458106259, 1.4482301826881225, -0.7214465971231006, 2.2646109599504953, -2.7549809169469976, -2.419667525414177, -0.04229652279272159, 2.1161294056041187, 1.4870676140624035, 0.5916278137750367, 1.3868460366579967, 0.21429113383218415, 0.610732034720829, -0.25717829453810936, -0.05890060840436899, 2.6434561316456335, -0.5722859884624565, -0.07935342354561639, -0.7008543023314038, -0.8659583391591575, 1.4342064824335496, 1.2633825765833526, 1.2058304548816479, 1.5635194899408342, 2.7347732789315975, -0.26608516103200214},
    {-0.050521851934770386, -2.9618716673848953, -0.4973534341345839, 1.0719050029989656, -0.44517849822482036, 1.580274723263795, -0.1787363717467269, 1.873994240954045, -2.327199324222946, 2.544124399017437, -3.3115145393519168, -1.1096617514080929, -0.012173325748878508, 0.6541260235435628, 0.5190628937267946, -0.11098490143821908, 1.7858917926186582, -0.2710016850157084, 1.0987814426885762, -0.9475774740351317, 1.1441937373106768, 1.8853960226920323, 0.10590933535395959, -0.7208407395070354, 0.432331665197438, 0.3087431728253207, 1.3765026811398875, 1.8853775116848044, 1.0797972374861808, 0.9105605774777497, 1.1847812611861508, -1.6408930945552098},
    {2.0399093767846983, -2.429502609875683, 1.4324291722410796, 1.4296477724817236, -1.4884311272852295, 1.5113472779206514, -0.7720361682708363, 1.5809553830908314, -1.377687220077659, 2.176495688094539, -2.017215579144108, -2.189504161991861, 0.8785056580103214, 0.669142570199594, 0.624546129037869, -0.275306650198475, 1.5263886753831273, 1.5036490718626603, -0.9598943576322154, -1.6079833003739117, 0.12202127724674929, 1.4450415256324594, -0.34603485051399213, -0.17118911993925282, 0.6220993911334743, 0.5388436554751668, 1.5268691102999805, 1.0889656696458334, 0.9773208253065785, 0.5879958182289083, 0.5571383676627555, -1.0107306787948167},
    {1.118348778971096, -3.7974925242276782, 1.2244671769483528, 1.8279411854100691, -0.11232756206562836, 1.8915743053593934, -0.03286014045793867, 1.9890205570424606, -2.0611316292956774, 1.1932347634176186, -2.590744459878859, -2.623261807282194, 0.3668445085572262, 0.8242869833976989, 0.019453997641385598, -1.3333114754248754, 2.2956762632335543, 0.0018619521084477268, -1.418437516014697, -2.6952982423362726, -0.38616340866558035, 0.8787543835632139, -1.348054614472351, 0.36846078496301493, -1.1770562577215766, -1.3760954242167103, 0.06799821793790847, 1.5226995595344315, 1.494373666107819, -0.3417554381775054, 1.5666752053499051, 0.44614133870304873},
    {1.782080519956949, -4.057571292960881, 0.4131158876413409, 1.528117062005907, -0.675407521119377, 1.210213196592258, -0.7417281998490468, 1.9087828038094636, -1.6076426532014654, 1.6131553243076024, -3.2659864791370374, -2.2578519086469195, -0.8918379285119464, 1.7622536533780138, -1.0317546974785383, -0.5734507972721272, 1.0225919327653468, 1.1166906817650406, -0.9785331570614718, -3.582469585304283, -1.4997325388073675, 1.2403555459523357, -1.0049041935692022, -1.9007214370255756, -0.05721294623490348, -1.5085502831348667, 1.347002310382878, 1.2416005245316861, 1.7223782628962796, 0.8241444743105301, 0.24976992968179546, -1.7507112155044606},
    {0.19776877542704632, -2.274154877401265, 0.5807664893381395, 2.8549214251805966, -2.3442032791727008, 1.781082120200669, -0.3733981654607762, 2.535683968665227, -2.2830845518105765, 1.9580172542640801, -3.8675712523084322, -2.5541984546427328, -0.20673452229566436, 1.4741766142628185, 0.3078152305577076, -0.6669528974978503, 2.964676558559475, 1.275631063826693, -1.5026701555901925, -3.1803400052071176, -1.3866730885486265, 1.1414372395023988, -1.018580872947934, -1.2167601155652867, -1.533215485289549, -1.0380374610533645, 0.050837618571573207, 1.1916033220627913, 1.8083659620547294, 2.072158290100462, 0.9520280285626869, -1.0774250214208323},
    {0.8751109186142374, -2.400461481785236, 0.8379973944268876, 1.666277841067076, -0.21157133213295323, 1.1900690690614995, 0.44032559045702824, 2.767050806608817, -3.3608158042978276, 1.6433687074134533, -3.5187456980552994, -1.2187902178293402, 0.00014737084258014565, 1.8216782906444136, 1.4194636443515036, -0.7159665457083333, 3.4898012559076017, -0.5217119585455013, -1.0732184934086577, -2.2876789316292436, -1.479306380373134, 0.606167985493972, 0.34889254627624894, -0.3759616792214624, -0.02121175931871337, 0.006459591166182163, 1.1447314878963264, 0.6379949697734656, 0.7901587507714863, 2.070197150777794, 0.9945388551823067, -0.8837209557068667},
    {2.21699772754032, -3.3555474518020945, -0.48461705519616766, 1.514470896344743, -0.2793729678768469, 2.159215353386017, -1.2166876953662131, 3.418575536118261, -3.160591954618473, 3.0389412366388857, -4.012218047375243, -2.376497001056351, 1.2033199440730713, 0.674156531028498, 1.8672111620997434, 0.6475176052643009, 3.395638436381963, 0.5201311786803613, -0.3264334392708088, -1.9383211184017857, -1.3180936133243375, 1.423990329203848, 0.27290181049648987, 0.2713020552647432, -0.6605450772244211, -1.5749784574270982, 0.997627793269633, 1.5741308991035838, 1.1711706593752338, 0.3896130753325943, 0.337031769852491, -0.08904719881099518},
    {2.475572870095335, -3.3307200282665663, 0.6848483632366168, 2.494400669067886, -0.5118201406745421, 0.019625413668511702, -0.8944790735675224, 2.688286974500746, -1.8398010847765338, 1.1210686531403218, -2.021397326567844, -1.4400452768546237, 0.8220089748332106, 1.4565065485853617, 0.9622650437163528, 0.7339901015428936, 2.2548110511222252, 1.6801608751349129, 0.0348423698267774, -2.352223720917323, -1.2784675100511194, 1.2987078724403547, -0.8649284020359875, -0.8172789771988349, -0.8471067299887115, -0.264966311261569, 0.8152208597079899, 0.9043366587348763, 0.5638515857583363, 0.9486946761040556, 1.4058755035966517, -1.0936752085261978},
    {2.185745115293423, -3.6364560106192676, -0.30643548815324234, 2.2550314510899825, -1.1870360483730158, 2.141311195242908, 1.090968544534312, 3.0269124090989297, -1.6195305852643342, 2.9067162034554177, -3.4060433478457917, -1.771046646449837, 0.953271511858351, 1.4987695993240409, 0.4295985712118525, 0.7185131468012234, 1.9589725450083975, 0.46446500980349303, 0.8074426324813874, -1.2911995117098098, -0.11616598754315736, 1.3727236165041599, -0.8861303545683995, -0.2035974122802761, 0.9533623029320659, -0.896354659808343, 0.8060281417370851, 0.9658357568696654, 1.622173483151084, -0.026591724555264765, 0.6694480838564206, 0.42628026702014926},
    {1.9125371741426325, -3.0134600550303725, 0.5817347490406565, 2.0410613809104814, -1.236095905138099, 0.4799042792832876, 1.2693094539533345, 3.421264323885807, -2.721393068593658, 3.149857475031006, -3.0239310518752482, -1.6504649284374742, 0.9987849993060672, 2.457109451790779, 1.6966871458100563, 0.14089600284519324, 3.367905122304621, 0.8981100341969654, -0.1996819047048108, -1.1878576325198293, -1.3593133918590126, 1.7675834868301963, -1.9284872812534894, 0.7139466710228246, -0.9959034927527557, -1.9049905027213925, 0.6327191103193243, 1.4868218917792468, 2.6561597142640765, 1.7393891039712674, 1.2709240413222054, -1.3866822226509128},
    {2.366012925255287, -2.0486372822082957, 0.23114246555457277, 1.8828502141903667, -2.3580019504949448, 2.000543865273076, 0.914378123224258, 3.418635594685342, -1.3992947116698151, 3.332459945713953, -3.639413087121939, -1.9984090166508444, 1.1950075500221002, 1.4559789439192774, 1.777222759511911, -0.8957751690772251, 3.5269955880609296, 0.1549633227240027, 0.27898777185113566, -2.5759151143251087, -0.6673048970227599, 0.660821677807259, -1.3537397993090103, 0.5780379075038217, -0.6686713062077518, -0.43743548508131386, 1.1186140704563163, 0.5632931650953743, 2.113451737763921, 1.1417091164039541, 2.086400174199217, -0.10114796781812432},
    {1.6029799385452417, -3.364087012892391, 0.023715980996741208, 1.743478377963271, -1.5168392951262841, 1.3691240164564147, -0.29037047970297625, 3.7289833688762632, -1.982430829499197, 1.570280717997384, -3.2714477773179516, -1.0998002624634784, 1.6105905769820106, 1.5483289630746688, 0.1081772101756794, 0.42416888661105806, 1.7352727316345147, 1.5715525271129402, -0.7071045621270096, -1.570576767047459, -0.2563483744350116, 0.4097151841167511, -1.5500570383195933, 0.5982895781788066, -0.24885671126573372, -0.9869396675194041, 1.4725380041474343, 2.221156350425158, 2.517893236130579, 1.6815346883196616, 2.5863108263374204, -0.4535255632282963},
    {0.5795419744456243, -4.688100540803842, 0.5200682748795126, 2.1317144829479036, -1.1367273263279758, 1.2324760550406277, -1.1774582710684225, 3.1111638740948364, -2.374383181557963, 1.5498105870792191, -3.897533651597154, -1.8256147826027758, 0.9279090123060318, 1.3201649119824106, -0.08915933789411276, -0.7676209646643618, 2.464329083397699, 1.1286449723127645, -1.6584929810356803, -2.419637386095843, -2.3237359258970045, 0.7295235222910139, -2.657409329871808, -1.2361502833605318, -1.8393703944853208, -2.524946321791571, 1.0942806042767983, 1.489220009734383, 1.7101168210760342, 1.5842977140318293, 2.2200114144684377, -0.15728503492316057},
    {2.4386837380392463, -3.933236592354857, 0.1401458682820025, 1.7574158499484376, -1.737080245442887, 0.5431369087453042, -0.2578396874440812, 2.289576551327451, -2.006605730368608, 3.251283318874486, -2.837539659002261, -2.9151375231540246, 0.2451069438291435, 2.630691454284628, 0.01911246670064668, -1.088879875430817, 3.3955733413512577, 0.2393097995855494, -1.5484936010817356, -1.1579150056289118, -1.921626607648325, 1.1150215791852056, -0.6974774524167497, -0.729157118422342, -0.6127679555376706, -1.6129431841852426, 0.9752771430782948, 2.1904566501986964, 0.8152651153949113, 0.6266616777334045, 1.9783119285795403, 0.059125677833636085},
    {1.5492658585693448, -3.8760065743930094, 0.35995079612056274, 1.8764735522687421, -1.0996706687520104, 2.2560098166471922, -1.0466999978657627, 3.5619119193600364, -2.2452555357498998, 3.4799205847678887, -3.6041821813231, -2.8858446488333303, 0.4415358472632127, 2.1909728299586138, 0.21896035779825976, -1.0437723839665518, 1.8537703083027155, 1.0692737135287922, -1.5526445175947552, -2.771838705167361, -2.0382963403654197, 1.767893510191446, -2.393388971400056, -0.6345495299360069, -0.8533004109785821, -1.2054807915283148, 1.9790433635567766, 1.4051832316386796, 2.3323423873294034, 1.8632857337087068, 2.3331307281840146, -1.6527514658875393},
    {1.5798954838515586, -4.243356297001834, 1.380284105456051, 2.1271488214197656, -2.144822622633613, 1.1853067407495457, 0.8870812335886616, 2.752326676598515, -2.5315635133387286, 3.7591334092509565, -3.0188756998577873, -1.3277013213366304, 1.70736758923861, 0.5333101659585678, 1.227201142449402, -0.16809946673138795, 2.814139118697127, 0.7427900979829286, 0.4653252069690219, -3.3054875750942503, -1.796118944731785, 2.057606610436699, -1.7461418862176379, 0.47413956923133316, -1.56732178799616, 0.3831581129047596, 1.6004697024913206, 1.5037741443128274, 2.6661360297169163, 1.7497415815933108, 2.4235004159993268, -1.610032406478668},
    {2.347203520322779, -3.7252244840965045, 0.18538379458390022, 0.7260002330562251, -2.4495112585362, 0.5205833955654933, -0.5652363011440489, 3.4939255929778334, -3.5165952010291783, 3.655393802451236, -3.256062167993899, -2.1598470716897253, -0.345967005466777, 1.4341924667338606, 0.739425816328576, -0.9039997694738361, 2.746668579615041, -0.15875595364121325, 0.14922870391997703, -2.225501867028281, -1.2419010781239719, 2.037588244651722, -1.6181432411288332, 0.2644269720097229, -1.2395658213079752, -1.4143935791047038, 1.5683570571622285, 1.1432544058054759, 2.5892366366190895, 1.5927468699866487, 2.577443154396724, -0.217686319039351},
    {1.636287797089964, -3.1963671598468957, 1.2073628405654706, 2.916204761772526, -0.5727529202631491, 2.640745094608922, -0.9306405435252175, 2.3439946374669955, -2.7330660756001546, 3.6440773216547346, -3.7186784726351045, -1.0302392135055687, -0.2792192889268802, 0.769375335440832, 0.1374058791142939, -0.6448472641641132, 2.6980318390081406, 0.2518020470377549, -1.2291670395809644, -2.680358295480141, -1.1805735849706285, 2.258198315327439, -1.9761660869612678, -0.29660413127372115, -0.6506403415103713, -0.2994889012310273, 1.584074209288775, 2.254508579076915, 2.425324722497547, 2.5836623470806366, 0.9954344971015846, -0.11145440558206784},
    {2.2588778158962652, -2.8481749873125226, -0.11923258371150962, 1.5475023799264471, -1.496450605666922, 1.2995700401526207, 0.8569152427973385, 3.0064809368191394, -3.7913594365884196, 1.790173502225114, -4.165681285309663, -1.7001345087718156, 0.540895193025749, 0.8351968211257605, 0.8497842409438352, 0.4740308855377768, 1.8324053728939418, 1.0793082819536315, -0.8680474327294301, -2.2812160938045696, -1.6333341251110043, 0.32933968109296524, -2.10262948035019, -1.2127865098655835, -1.2127406613728497, -1.0265714124755088, 0.39077710152636114, 1.6361677584239536, 1.669058994823391, 0.5831271664903622, 0.7476218553914302, -1.4814575517334607},
    {0.9799596825768034, -1.4264076962713879, 0.7436598587524074, -2.8575271888990015, -0.48482454942818043, -1.6158165296930942, 0.1420363315418922, 0.19768143233247285, 0.805909361097356, 1.4176653970030142, -0.740257590395187, 1.8103285962812243, -0.39347700543951003, -2.9477166068556206, -1.0742453491699029, 1.8301484784956001, -0.1402618583319092, 1.838596443510453, -2.2261225059010887, -0.0619465230925882, -2.6142037119408856, -0.13797280184879274, -1.9081051589758145, -1.3653982024703963, 1.8900445335162401, -1.4270531019176493, 1.9021551001259733, 0.17445741582256175, -0.996556836421061, 1.88508918274472, -1.2693419429209725, -0.5308263823116764},
    {0.8499085693165389, -0.5694934604843708, -1.4235270172856656, -0.525644628143888, 0.8532471202590587, -0.9972621845785714, -0.38976804910403234, 0.5094558038969657, -0.731095524988306, -0.6518719694580243, -0.1518162838439299, -0.5534804840009478, 0.1997888787507758, -0.22332110915572195, -0.3375420202697128, 0.6613234708342721, -0.42151759665396316, 0.7941254508874402, -1.1442589386028899, -1.373304794105845, 0.10959654712830678, -0.5899107223386535, 0.2979220149120697, -1.0562295609108983, -0.21661181716871525, -1.5221048225225187, 1.422145945383491, 0.061538619688173035, -1.1016369357471532, 0.580814264845707, -1.3942582051597918, 0.8971678724803073},
    {-0.7579419103851053, -1.322549751922087, -2.461632824633777, 0.31539637369830364, -1.201564914946793, -0.9898456285188446, -1.786291327019739, 0.21692431375753388, 0.8722269811888989, 0.5075258326845671, 0.08341006411856257, -1.024963750714002, -2.004404960812615, -1.6183721043034462, 0.04325731942726333, 1.8536386119942643, -0.7222359735674881, 1.2584673384614093, -1.2971527610502978, -1.826738479505891, -1.3595520206398126, 0.5787075373387869, -1.6122260805718467, -2.8386735281783024, -0.12708991024577448, 0.03374431013278955, 1.5261532078476294, -1.0431773824028028, -3.537910298740227, 0.875114849503552, 0.14576490205835302, -0.36001382275015276},
    {1.1135267648391134, -0.9438078636642692, 0.6344133002270091, 0.09164806343882215, -1.2397145153666789, -2.729949295248747, -1.0896623625160236, -0.8988145343773082, 0.4055805525401014, -1.524413675341618, 1.0221198619934175, 1.4289898090902724, 1.5372325667452287, -2.0738458684516092, -1.0479939977243335, 0.9249475803182384, -0.39146522633359, 1.0213232375501862, -2.298612556181369, -0.4620222546000141, -1.7099815478834115, -1.607456777818812, -1.179600125533296, -1.1044828337777857, 1.4783927820166098, -0.7404435394431627, -0.5922067668719759, -1.2413549800700443, -0.25704585042218675, -1.0096140849250117, -0.5412026121830599, -0.10254159954081037},
    {-1.071987933650623, 0.643156006987593, -2.480619302260037, 0.8442163268041702, -1.5253793850254374, -0.08935068581637019, -1.636218245436948, -0.6966040947951238, -0.556163307818652, -0.8009274113493435, -1.124319114794488, 0.31532160521709734, -0.906645588177225, -1.9550109673544103, -0.5504273453866277, -0.8904844109288065, 0.14503875383266288, -1.0241799478699651, -0.6460832089343478, -0.9715253415577688, -0.01867088435868709, -0.06737355660104309, -0.3944465197432862, -1.7642003995132012, -1.5607720998153607, -0.6080413564670216, -0.13705954923517202, -2.899982726633501, -2.274238330881217, -1.6212777839324337, 1.3017892495807069, -1.1660193608883558},
    {-2.7726658654722214, 0.6356482789011216, -1.9179308333363567, 0.5940026017147403, -3.272273359594947, -0.2743327120487353, -2.2131438393053937, -1.427401957400494, -0.18699428599965914, -1.7037884962017618, -0.7023485216670178, -1.378564144006188, -1.0249792144776693, -2.064486606925222, 0.5558973460303214, -0.19087303920763904, 0.39710407998224606, -2.000148414588131, 0.6242442784725366, -0.5027288106668404, 0.3718407949400484, -0.5001255569897883, -0.5240551195803429, -3.0621426302284402, -1.0187977269197626, -0.9344706332600655, -0.8766501171715703, -1.8401818701511086, -1.9522496455424967, -2.2021823451951565, -0.25116747621944513, -1.275446453438189},
    {-2.631061475543528, -0.23996206033783415, -2.488157569315177, -1.4420163429618842, -2.427378691227658, -1.4041810761482825, -2.3935126169285876, -1.3478939898824347, -0.08981912160860757, -2.8392753298583515, -2.129196862161376, -0.24768061807721142, -1.050882376380323, -0.24835698563413336, -1.3675282656386702, 0.16349184465132482, -0.7898802206597348, -0.5779146883302644, -1.687354810378679, 0.28290770247100466, -0.30101609720041134, -0.884305054849816, 0.1570145687891141, -3.0074973432921146, -1.0607046708492227, -0.025108993068281224, -1.3641347594802742, -1.950759641841251, -1.6475468954109387, -2.440321679648713, -1.5905257838839555, -2.120287219068376},
    {-0.5195485484463233, 1.0241772912920781, -0.4116053955279233, -0.8694705020430328, -0.20125828242681135, -0.05394017867837994, -0.20380139384474885, -1.8447958736816805, -0.9941119888810273, -0.40467981299840233, -0.92213206780997, -0.03241912534863516, -0.7250073809944784, -1.9898383232911372, -0.11225277311361573, -0.24558193600606845, -0.3927569238302212, 0.2183949361569156, 0.9628862014877424, -1.2593076709571145, -0.08557523745970555, -0.24684269352828786, -0.35920629311555874, -0.44918687727885875, -0.013613077590106453, 1.0085085632491375, -2.0125587799682467, -0.81935466278354, 0.2429205106927699, -0.7246210133067544, -1.1839237121422181, -0.35529291372407373},
    {-1.3744977952179187, 0.5334614177891667, -1.3161015126224804, -0.020189917456815844, -2.0621678890143644, -0.9841279397096193, -0.6117100587852341, -0.937645119624083, -1.293907868393417, -1.8020352283036247, -0.7038742796858115, 0.3860968926466996, -1.5383539020623678, -1.9173040657459384, -0.18230443392153003, -1.095862385246249, -0.8030406305194585, -0.5686092199248313, 0.8271772513754886, -1.1496945655048947, 0.9938208832371138, 0.6510556525589196, -0.17592187336968157, -0.7935207036692477, -1.777871975286185, 0.3821548388410603, -0.686205098153349, -1.2121203102781282, -1.2572743025611264, -1.7027598924957836, -1.51100703578882, 0.29455567715527126},
    {-0.43971498075982746, 0.86060363765594, -0.8629828734840449, 1.4197744080625134, -0.25112568714283245, 0.3837404734854243, -2.425221970331848, 0.06311376356549699, 0.6123659967455827, 0.18737488627497786, -0.4742599439007399, 0.12066901076611616, -1.806995194783899, -0.13211430328951118, 0.18701200555474426, 0.6669051161977726, 0.8252246540574766, -0.9449112471182847, 0.1412630928074747, 1.0929790209075734, -0.49677908184109365, 1.822737817780613, 0.2804016048119399, -1.740193331571329, -0.2362104452106107, 0.3945508701768808, -1.2121822162773033, -2.628275707712063, -2.3431869706674004, -1.7918837976952322, -0.3298421257812432, -0.47277379034275163},
    {-0.373827952915983, -0.6295004372733487, -1.911007462023461, 0.4659560958647711, -1.7668318128505565, -1.7132843407964102, -2.722483269678422, -0.7647516229091702, 1.039524546154843, -0.8752036680250651, -0.9917840008008972, -0.7621795926731798, -0.8491691234342226, -1.420616325435936, 0.2836820400554216, 0.5481592033691334, -1.4369793985973214, 0.27952013933714176, -1.9561816207505012, -0.2529966864576818, -0.5339634988456317, -1.9805958724046804, -2.0331723296946596, -1.2604661870080218, -1.7090886906851341, -1.4831953113844227, -1.0751405960876925, -1.4083021492427346, -0.9979178825741551, -0.24845553047643612, -2.3366617552355002, -0.0023805658820914635},
    {-1.0922803002909889, -1.8149780025579176, -1.0393829519334348, -1.1327798533092948, -1.671647447839284, -1.8852843916769126, -1.717982931087262, -0.44962154033935187, 0.23286839589180253, -0.8858254070560251, -1.8137163738113542, -0.4896900944142671, -1.9329688048621219, -1.163101607297385, 0.9938341254312506, -1.1546937468980163, 0.9385659880245536, -0.99300757772512, -0.4510850343885449, -0.856699583726939, -0.07675141062892626, 0.5899881753890671, -1.516623439052809, -3.0268735093093744, -1.4745782017967368, 1.231253642018471, 0.3500596988480775, -2.0288377782865283, -2.0798434859198562, -0.21099753440431263, -1.6600297267805013, -1.5100368042403365},
    {-0.8643526748204938, -1.4547965430294434, -0.2706553709123788, -1.2469690918806438, -0.8368826102782397, -1.2022314857495937, -0.8500881435050367, -0.37306169455096944, -1.0666930322465842, -1.8477954036983721, -1.530171000578011, -1.667417559846262, -1.2772538621880387, -1.8248080716648505, -1.1481689544304536, -0.28661677616253495, -1.0593210076298438, -0.26479142659467897, 0.016276357392572736, 0.769804666731915, -1.105485244821802, -0.46894944463828153, 0.41837278518774945, -2.4394121983273553, -1.1708137481995533, 1.2065521275414237, 0.104378572387506, -1.175678846691484, -0.989457511963434, -1.665795649690221, -1.1226035648776684, -2.4199823464590065},
    {-1.2968333944216803, 0.547677172759261, -0.02207756005043785, -0.4564747517614938, -1.8936319625576044, -1.2210648684424557, -1.0587682430106424, -1.1654686900157372, -0.2998702618170142, -1.7664656212845018, -0.7708272502861888, -1.485504009475212, -0.80246045857946, -2.1278886021623293, -0.7638449827892, 0.30013825902844626, -0.94841431871709, -0.984621100837392, 1.3613052756508432, -0.38800693857021423, -0.15918806502778, 0.5823420094955696, 0.677057406302727, -2.2046165649595957, -0.9239629805687503, -0.5954911779450413, 0.4797734284854757, -0.3271754181918999, -2.707236519923285, -0.3728780259394307, -0.24568235883902684, -2.302197604208236},
    {-1.146913527101642, 0.1094194608958925, 0.7569375339513543, 0.6400061419498657, -1.0242859108301585, 0.40011323037319296, -1.2725056409421043, -1.1618679930811333, -0.531176606939329, 0.14503094717766846, -1.2993551907693595, -0.1367751695931002, -0.2630053484214868, -1.91646360839527, 0.9830432613492263, -0.15479405135293928, 1.2403697441036807, 0.25984572367418607, 1.0954012066483698, 0.17393204296597575, 1.7431719530392136, 1.6032330183606114, 0.09435408663409849, -1.8210414891234095, 0.017906827091675057, 1.544270035249433, 0.15769830517883815, -0.07786149970530137, -2.5835843999032604, 0.02745898587677944, 0.7016345651210567, -1.500895509048931},
    {-0.48244449558291097, 0.831585108799406, -0.6812118632576518, 0.4215456303960472, -2.1798262203028176, -1.6947348423350497, -2.5519994726587463, -0.9737572269951333, -0.32394178970990556, -0.9805429353941911, -0.23169333179079918, -0.19057255214651278, -0.47726758938795155, -2.2398277282871355, 1.5259051904780865, 1.0713709821577995, 0.3759130448807915, -0.784012944754767, 0.9938108384764782, -0.7357732671574587, -0.7161929326082996, 1.0221035877006337, -1.5655069907331254, -3.7023315060893425, 0.6956638583692994, 0.4369954550369877, 0.22924254612567513, -0.6936725282782717, -2.522776113611404, -0.3325627591288621, -0.4477645331920268, -2.036979471469687},
    {-1.0320139113429705, 0.11464999257987579, -0.8372953418016255, 0.16639082122916124, -1.0957882062226247, -1.283176825303675, -1.6295003022894536, -1.8243067025029442, -0.8537405679019469, -0.7113175253599067, -1.2299927081691069, 0.5439919962932175, -0.24258660898371767, -1.0283166980988112, 1.1283044802002018, -0.0801795321520811, 0.02820359624076058, -0.9909197980076428, -0.19780757147629707, -0.06045540872523873, -0.6293323777133466, -0.05975938624243396, 0.16104021631759574, -2.3515570810462587, -0.665283870425864, -0.07943607454212595, 1.1057929873118535, -2.34927159356913, -1.6757160550612324, -1.878981117233869, -0.5338971678919285, -1.4077340968254584},
    {0.8547756202794005, -0.2559718491116024, 0.7581177876547206, 2.1368009992032784, 0.21657947732403207, 0.92257985646129, -2.7196491187283462, 0.3632197387703741, -0.7954746807226987, 0.90764087733761, 0.47713246969199813, 0.7372681891599554, -1.3872561302377868, -1.5984543000092257, 2.233138355508536, 1.1285289685745923, 0.4158208415311579, 1.1154217073481603, 2.1564000457634984, 1.2178213807108447, 0.559408856563024, 2.670835115669105, -0.0166917710263372, -3.282747296266595, 1.1850072202614816, 1.3587072975442949, 1.8230041917077324, -1.408748399498311, -3.1151318686158493, 1.4184247633040539, -0.4030587758862892, -0.456232194070446},
    {0.5808735528106868, 1.0293083628781972, 0.707245019694155, 1.6544862142515004, 0.3025301261575426, -0.3352499145164583, -2.0455323710739006, 0.6073923972067428, 0.7953860901080702, 0.6592135243952433, -0.5090938298918987, -0.577448735681394, -0.5921955406139087, -2.109167515140202, -0.09482174223607609, 0.4265269179180161, -0.10030292107709034, 1.7174754113974138, -0.2003539214318148, 1.227452569033483, -0.8724265028094775, 2.2526766815604677, 0.11127231955051875, -1.223080823604923, 1.6610119855772272, 0.24216286526314043, 1.9100324714939865, -1.241016458155063, -3.0885325295045285, 1.7508922274474563, -1.1186394391081218, -1.4562763697323418},
    {-1.1323147482528835, -1.7615848894759771, -0.6174015546238303, -0.6019492455631567, -0.7280047240475503, -0.6870647143111548, -2.7296506630669577, -1.020318687089204, -0.186461157172114, -0.6042390898874744, -2.0245817073434247, 0.452032777095791, -0.5369785333150362, -3.1940639223835454, -0.9618590895551461, 1.0755388088697777, -0.8163163368801535, 0.6741125570744315, 0.30696199735234536, -0.6797322050073661, -1.4248118805997567, 1.6258354255130256, -1.4176846509832082, -3.0230785717040756, 0.559423085325338, 0.0869924602966744, 0.14273477808430862, -2.538930750932993, -1.2546738416592003, -1.3742301788513611, -0.5626681667070637, -0.14360505341711233},
    {0.01267212069118942, -1.1026338342437103, -0.2141202143566712, 1.1675430053329565, -2.537590046009316, -2.061801890994663, -3.114740517209908, -1.6068603210693548, 0.0053212559127572895, 0.03331228736208938, -1.5541485285614025, 0.7354828892028124, -0.869945611747955, -3.2497169665318433, 1.0760425159406652, 1.252423550716665, -0.4765010638869135, 0.3826167922537982, -0.596353304161314, -0.2821739773911025, -0.15164855868420754, 0.13839790445330435, -1.8132891597995835, -3.6756328048073006, 0.8517563095520969, 1.12450184120999, -0.04915021468958989, -2.6544598464436873, -2.7326808257058373, -0.4330566536556473, -1.2298781511897476, -1.0266879070797659},
    {1.9165971250938276, 1.2699974707578583, 0.2972898986004513, 2.037407332088148, -0.6276352742152763, -0.7099312557831443, -2.2493342488419446, 0.5314716542673544, -0.3225488715384034, 1.5956307409494084, -1.2150400079541226, 1.1621995820561961, 0.6953053311863174, -3.1585155704374834, 1.2944728395991498, 3.33124606336613, 2.8145049402900213, 1.7944436291387142, 1.264400120042922, -0.2505058623841964, -0.03721206591556883, 2.545521387749334, -0.24265411795282385, -4.63505775847434, 2.87575640415895, 2.243086800543057, 3.2388790437982533, -1.0566661365462977, -4.238202922685178, 2.908647948867585, 1.736273371187707, -0.6459039879422472},
    {2.727330893436044, 1.917659280119368, 2.9979704677242167, 1.9396752924856235, 0.20779822609330614, -1.5658607917064948, -2.325143472456748, 1.6683181145794244, 1.3986844523127284, 2.209292070199396, 0.6185478685474903, 1.2595020132404287, 0.6839175502785104, -2.7911197164003836, 2.406528452157053, 4.404326800981644, 3.259290205238836, 2.524501844509689, 0.9147721390624421, 0.5200903311752781, -0.5249839887241059, 3.5252705881783704, -0.026779835137320976, -3.929798941501253, 3.405735700526545, 0.7512703585934196, 4.3929787686857935, 0.33174100408099194, -3.3946400174496776, 3.9643366438420515, 1.912768711307151, -0.34334330710683386},
    {1.5368231899705083, 1.4119539163264787, 1.4924844845139664, 2.290210281296161, 0.34842492264963115, -0.1792009096129847, -1.7803576455393837, -0.047057467989555644, 0.6799134592279545, 1.5968283534324177, -0.5754035928859326, 0.18500393587374048, 0.8541656340774996, -2.6945591974615084, 1.8144196239864163, 2.7786679511123062, 2.017617862198314, 1.7973143486661673, 0.8485803077471155, 0.0604069074971126, -0.9791209596543239, 1.143044285491062, -1.042308630507022, -3.9791523001115148, 3.1939168248497936, -0.2794027603412003, 3.7912532526804767, -0.054175988073223644, -3.9269638929729584, 3.1747715192646435, -0.1499070924453339, -0.19732959195086025},
    {0.4234203754655888, 0.14798224787419903, 0.04292072277907485, 0.8982953941106355, -0.3957423883847915, -1.3605934243814957, -2.5930843129322687, -0.63086444268283, 0.7471109779182421, 0.5053237305311682, -0.542445598780785, -0.5270829853902116, -0.07215444504581109, -3.035637833977997, -0.5373932082107621, 1.5551672605770803, -0.1356677203929109, 1.3376287613845335, 0.17532451930852122, -0.6991542274240394, -1.0112597617359784, 0.8938637496611123, -1.3409269306082547, -3.387177973072203, 0.9128400908400868, -0.09806657179049569, 2.2993143877710143, -0.810000798578804, -3.330811179417084, 0.34895916803124305, 0.03218687942586801, -2.3268443474302223},
    {1.0764949296804394, -0.2470964126841083, 1.6215049659302039, 1.5676604594192014, 0.8727867439672296, -1.878042654006819, -2.8769267791559336, 1.42950628975344, 1.2155210024324534, 0.9219474440316825, -0.03768908305178175, 0.4262686154781305, 1.5433781567039826, -2.7236482404228766, 1.1853041614390554, 3.4635040220093307, 0.5255049786720575, 2.3071168122438697, 1.0160493161446016, 1.2775067698697022, 0.4376999606786614, 2.12442375321689, -1.0351341126210514, -3.579125686411737, 1.699585333212093, 0.3550995229872762, 2.0327347858739255, 0.7341590674098836, -3.7079850644384083, 1.0245256085366439, -0.7845073627058667, -0.42023537874337746},
    {1.2211346070286389, -0.37456006110281287, 0.8541877093351175, 1.9542515224630854, -0.023978330292746652, -1.474111448248471, -2.997393946524569, 0.03528465441621478, 0.26818878513105043, 0.1220885315513064, -0.6784819365107091, 1.2743218797942457, 1.1953854038208467, -3.0637320195267908, 1.5303000059738894, 3.6314874211398345, 0.925315189270292, 2.7951037883090706, 0.37071599482933715, -0.23695549851282285, -0.4628139411511015, 1.555160878174246, -0.0780944731647548, -3.461544831868335, 2.6321583210599697, 0.7891270429017085, 2.3342132463679666, -0.15391256647160262, -4.189286280816486, 1.4467455485531777, -0.0836238832583549, -1.1877506515179441},
    {0.8657887812038573, 0.05862634487015965, 0.133696729957458, 0.34698897467085504, -0.6621944202476819, -1.8813222454183762, -3.3661303006948287, 0.4982125187903436, 0.06406957420534942, 0.4956276388232542, -1.10626342093824, 0.14936242879223263, -1.3390333235032466, -2.0427553703960726, 0.10221610276787808, 2.9920600202268104, 0.7579341663660912, 2.010883336072921, 0.36738482103879544, 1.150432052229423, -0.8767214300029753, 2.4109216564852844, -0.8906274991964883, -4.366491211562714, 2.716239539068772, 1.3176055725804368, 3.4884372989321975, 0.27304646303986135, -4.348458379413447, 2.6527608321738425, 0.7402976386607022, -0.6537725439089251},
    {2.1813996221919356, -0.3322184418756612, 0.8761250455781815, 1.2903717553277736, -0.6717870765184789, -0.749744811501174, -1.2956119102926602, 1.141416927218817, 1.507993401115412, 1.8906764353898653, -0.4031187558172557, 1.8790453518806771, -0.6130270561665415, -3.1245845484657924, 0.3769407762913612, 2.667894040991358, 1.819206047701346, 2.9608607503363666, 0.9443793310237065, 1.7108142855674804, 0.7991347569000209, 1.2064617612152262, -1.0536563836357038, -3.5516656270694122, 2.613134831615241, 0.9853994241245687, 3.317244623929989, -0.07514439200214441, -4.119275792009468, 1.9036510390224297, -0.00039735886082327535, -1.210281939425681},
    {2.6488132337943813, -0.4530696254252581, 2.3509982795592763, 0.3306981503230188, 0.4722449046587174, -2.125210532945448, -2.234908475862428, 0.3523232239368664, 0.20951685446256363, 0.4356555209263401, -0.6964614064142292, 2.194801380645195, -0.2986443959886095, -3.1187925803766436, 1.1590847792978736, 3.826210362716267, 2.007052304161242, 2.12416566071475, 0.1855154716345476, 1.3943305409476372, -1.3617985563744348, 2.953872987098686, 0.10139145537116062, -4.821044544901296, 2.767544185429608, 0.923617383034276, 2.2104228560222796, -1.1092241115750618, -4.497456614007292, 2.9401331847687717, -0.7537807978240642, 0.035967506928213086}
};

static const float b1[32] = {6.403848787182674, 6.363668097655138, 6.567889065076135, 5.979460193679654, 6.474346071618393, 6.439474573063263, 6.19482719191419, 5.118214920993667, 5.8776786966412224, 6.188956566752307, 6.198595420949648, 6.220578701377268, 6.114075498469117, 5.42316544394501, 6.515960555404984, 6.373974716178608, 6.696463894586428, 6.118157442889205, 6.416681257002717, 5.965934979255809, 6.678066778487347, 6.184058632520454, 5.372076939011487, 6.345497233976323, 6.264683749036908, 6.30383836770751, 6.116382958500717, 6.005131756769279, 6.260026586804045, 6.432019780104193, 5.9966961147907965, 5.985577213388473};

static const float w2[32][16] = {
    {4.890663724363121, 5.614285653600314, 0.007368991881995182, -0.39884346293448514, 1.8262529037382387, 5.3734660624351465, 4.489459107648972, 5.724058240600966, 5.356424675912607, 4.426947719918246, 0.031126880025343865, 2.7423968666435177, 4.809368538758608, 5.316517889580525, 5.8656436919406865, 5.662960384538605},
    {5.983529561913702, 5.902835307284965, 0.45206065766139675, 0.0338571564471833, 3.504792047161012, 6.266029261592263, 4.6685287111927165, 5.983690857234344, 6.234088646986958, 5.2124739686993165, -0.770851836222023, 2.7800613007170063, 4.612962927720654, 5.698725225684308, 5.981810013681464, 4.985870793036469},
    {5.303854728047347, 4.548077657998144, 0.12518168888808465, -0.6538724430856167, 2.199491129981607, 5.868415549079853, 5.00388387898816, 5.578668158526186, 5.739792938878622, 4.1387787660592545, -0.8524885522030642, 2.8208395912558917, 5.603366163481611, 4.8246846447919625, 5.238535541587236, 5.722410155465737},
    {5.422117865603493, 4.5134358555126495, -0.6288564532025129, 0.25147019042244106, 2.408143267173605, 5.765611539179435, 5.167389424212253, 5.392379379228461, 4.56766023573659, 5.204597644622671, -0.6842583813244874, 3.8016336089826446, 4.653943025069083, 4.752164700715616, 4.513763126878808, 4.316573271075648},
    {4.89063657949202, 5.979224965615982, -0.2682882952119931, -0.8285677775691818, 2.3040425807444813, 4.781142579212464, 5.214782492647749, 4.68983671764159, 6.079181179620457, 4.140365468276746, 0.14638903857839441, 3.701714192940897, 5.4732259382743065, 5.416162295197987, 4.248175937789876, 4.803363105064055},
    {4.865059141921145, 6.547274822498642, -0.7865390404522581, 0.7606694167848228, 3.2720164604522948, 5.424793540315194, 4.952772611360608, 4.39975702483597, 6.210003840615428, 4.326447852943394, 0.6101380495144816, 3.2056826360500454, 5.862357026949632, 4.646601113341545, 5.31969944545564, 5.854103189203067},
    {5.125955218277498, 4.9765526090255765, 0.34956358040372154, -0.955434165412568, 2.0707157198209414, 4.704560309878051, 5.086256361910165, 5.686867460191809, 5.151746615629151, 4.824428436303048, -0.9087901185000478, 3.9386589167267334, 5.918089244171592, 5.604344044047265, 6.000919704843209, 4.609806722160398},
    {4.6907954626767, 5.1040902362919285, 0.6023731454742748, 0.01940101218341733, 2.952601244468206, 4.654529805798479, 4.572678830304702, 4.494122659209322, 4.514607228281684, 3.9021814612607195, -0.988734017789557, 2.7159978065752473, 4.586969187542841, 4.366565780595808, 5.69658370354244, 4.68631291571195},
    {4.597165415488996, 4.8454299795173075, 0.3417252241751444, -0.6144791533695951, 3.5184088160348637, 5.467549803021333, 5.349070942625346, 4.3881083870820214, 5.254977873801081, 4.278107320992395, -0.7361018408110362, 4.236627856432454, 5.904895055302061, 4.667404135309942, 4.356306385731441, 5.086367504876167},
    {6.038993177484101, 5.32133835340558, -0.7879701219221737, 0.10701643772736098, 1.7485586435541898, 6.2830879139254145, 5.171304062738475, 4.3939100545436975, 5.143092419092538, 5.521706116549912, -0.0480221260801984, 4.1111295621763855, 5.963894050004372, 5.620935409248395, 4.6752924706942895, 5.5502945348536405},
    {5.921576726154496, 5.277463760245955, 0.12971571632759815, -0.02326123944957698, 2.327809315822404, 6.418719543986145, 4.957240527611948, 4.199001594896404, 5.408420055192494, 3.9088224717017814, 0.71175255453053, 3.6174174976985842, 4.657307558998418, 5.97126293972876, 6.360738417354103, 5.724051307338558},
    {3.98519061718036, 4.72354200082149, -0.6973822701431238, -0.8283572560536673, 2.936693547988481, 4.756674017518102, 5.64671562609709, 5.069568568166219, 5.5181756701516536, 4.068315396343603, 0.15667130059810258, 3.5973156475087733, 6.25294693609197, 4.595378825827901, 5.895502342472844, 5.785542087456937},
    {4.10277352417598, 5.984886052022093, -0.8004713596633102, -0.4886061017658072, 3.0888001229970774, 4.433925413949606, 3.97237082019832, 4.438530097735906, 4.815853939901319, 4.516970993523442, -0.4931312887139136, 3.9665581743833154, 6.338001782329444, 4.509663682468361, 4.653112857254025, 4.8592038138617335},
    {4.960594668738761, 5.260949858323438, -0.4525047614847436, -0.8730530152223471, 2.619567730564207, 5.296400654375119, 4.273299916470242, 4.634761360565945, 5.151778188442179, 4.385412598676668, 0.1553055880297207, 3.6173705022122706, 5.65757873141055, 5.786943106049055, 4.634966332383411, 4.600760009225602},
    {5.282569227928382, 4.793036297081117, -0.08610624941516556, -0.5993989241246208, 2.9635781143064714, 5.98493338052157, 4.816585340652674, 4.37481140797648, 5.931545684833779, 5.157196239938429, 0.37930763974510934, 2.7939748752997047, 6.195635949773432, 4.294789605798654, 5.804223012113494, 5.2236368481852535},
    {4.314222282302999, 6.009109302059405, -0.9447624319657467, -0.6475068543999882, 2.6390567116889936, 4.642072730843359, 5.095594889742946, 5.9673396199436874, 5.278808020415842, 3.4249554574400283, -0.6116799020527232, 4.079246833893484, 5.453036473425017, 5.523287286169097, 5.338485417169736, 5.7316912809729645},
    {5.478103585268176, 5.758125818015558, 0.31069433517407985, -0.035223619268279674, 3.145473940351341, 5.91345919952771, 4.329196075799179, 5.61585196565994, 6.014353890221404, 4.342554708880937, -0.29215898766351295, 2.702839295961761, 4.779671124741905, 5.22839246817898, 4.459408422747301, 5.168360927873128},
    {4.975246904587968, 5.251441717352493, -0.6292014398349403, -0.47240226425635656, 3.07762399423892, 5.236961796337644, 5.791136132387643, 5.105451211585102, 5.083879528233394, 5.237119398575827, 0.8197155252857796, 2.8170733568841997, 5.823187125940741, 5.445371996900762, 5.829338508072025, 4.75098396936124},
    {5.39522495691095, 5.2904271045615685, -0.38856430806614467, -0.7027478398010276, 2.643978335364937, 5.223309644486385, 5.583205429615256, 5.338922942176779, 5.255708080136341, 5.25013385804249, -1.0111444415326232, 3.1878732321822465, 6.003780283451482, 5.148075371234647, 4.4147720478874195, 4.875571768469273},
    {4.770622072792006, 4.737802182098589, 0.06984997877063209, -0.5029453052708759, 2.6051414356785276, 5.1780013862341265, 5.2919056584115145, 4.807159544179716, 4.753498959227196, 5.44132535592563, -0.006912504053448639, 3.890966160352641, 5.40627400189487, 4.2193523525113745, 4.345480960729753, 4.750338887634798},
    {5.294666948989027, 4.724368181373252, -0.8124132071954006, -0.6597048268616795, 2.7279503576677344, 5.738417828866373, 4.523674637460898, 5.809977763356585, 5.548986103009876, 5.197726391584755, -0.6387665880139508, 2.880225861626397, 4.9440129712221905, 4.4312043678070605, 5.4755277709637555, 5.139045734169266},
    {4.312092979031011, 5.201339970855706, -1.0722851172038332, -0.13909500985013298, 2.4954038801121796, 5.261257697208561, 4.612994262607977, 4.727286881755385, 5.279436631226598, 5.299586700902591, 0.4997799763868589, 2.327896552364117, 5.131191532055171, 5.112873612705008, 5.999055131057945, 5.002936393865075},
    {5.229011882460148, 4.942467261848452, -0.2717525366831729, 0.8751870776091578, 2.788267436608311, 5.659277965093448, 4.769423635605969, 4.430702738558591, 5.072770591353553, 5.5892563775559765, 0.24312671655075072, 4.425446943197761, 5.595805249133449, 4.502678758775541, 4.86670022983651, 5.243307230249594},
    {5.375499932062592, 6.0025857755904415, -0.5471269344810417, -0.40062413576512446, 2.6171581793585217, 5.279215922109007, 5.55162218441097, 5.913931580866884, 4.811926024867148, 5.312882944391651, -0.7493704593457603, 2.6935537513235013, 5.970577731163968, 5.579576782779763, 5.572839930275869, 5.51814898845525},
    {4.601277922903299, 5.8830290060954935, -0.7918433994819509, -0.7689012673155714, 2.6437737180734375, 4.85683430454314, 4.963165504506128, 4.810629345361622, 5.141650915572677, 5.132198823706076, 0.7267973576437358, 2.730091641298268, 6.191062169067601, 5.493632566000108, 5.358954905063599, 5.704311169201287},
    {5.278996515498052, 5.687699312498822, -0.5916341494525466, -0.6746836751006318, 3.1918616970550153, 4.535587992868486, 4.242053871204698, 5.8085191717643285, 5.254176175289031, 5.298160654145745, -0.7389151994594773, 2.8120928302430506, 4.321737181924664, 5.749544157892674, 5.344741770517097, 4.719072218097817},
    {5.296825854434393, 5.745592997465795, 0.34523723918328125, -0.7229981326943581, 2.893007559816289, 5.313100420274608, 4.610913599065575, 5.145599434802931, 4.835014249303978, 5.357201244467681, -0.8215540321772599, 4.155965686013585, 6.28504861137521, 5.6027389587591845, 4.519634378097649, 6.274929083064313},
    {4.413583244258837, 5.8236467460568795, 0.412681291765454, -0.6383516089203706, 3.3103442428679264, 5.786759793465625, 4.877683581804465, 4.970895151292879, 5.414605565717202, 5.295051223905424, -0.7187187168605176, 3.8778559117409985, 5.330464677880217, 5.244552650021023, 5.481124892316952, 4.392589734764241},
    {5.493126196488473, 4.989333227965619, 0.07589939408953966, -0.7409349289404829, 3.29401158970155, 6.369427578713929, 4.6313282611878, 5.545517759916691, 5.239575923391762, 4.759805830606156, -0.7635158695301043, 3.7568999838769606, 4.891331295608599, 5.25571274254541, 5.436039567363082, 4.797328638448024},
    {5.029372776125096, 5.707582135041332, -1.1165133612231766, -0.04208668607615817, 2.80095615418005, 5.829438531588527, 4.254098607692359, 5.508471314945989, 6.127149507309336, 4.518739650909422, 0.004962881788034102, 3.7620834856739234, 5.449447513178789, 5.183195949344802, 5.348917281970954, 5.951589261044046},
    {6.029898712274303, 5.131351181213361, 0.5909656263821301, 0.029998547058681033, 2.015838124553493, 6.018246098521826, 5.404324267628397, 4.891193068860214, 5.094960551194624, 5.436621333794127, -0.3022718451964526, 4.269715775759996, 5.065813748775792, 5.731420529021605, 5.945569309102511, 4.727867380033492},
    {4.875420688804349, 4.945536410339612, -0.4868608318721439, 0.292238295183324, 3.1343083183393894, 4.802257167472305, 4.847753431874478, 4.365636128185995, 6.06378232798082, 5.22725370313178, -0.7520820802615906, 2.4828720658568812, 4.908253039910323, 5.03868123118555, 4.562481619347365, 4.523512491041202}
};

static const float b2[16] = {5.722824426108215, 5.901265490699213, -0.23594574163116214, 0.11829857271307143, 3.5545037582784107, 5.914733078047547, 5.464493260268754, 5.330929221334438, 5.666042108293388, 5.014701106526097, -0.1932892211377559, 4.0852000381158575, 5.835728228061884, 5.543652514118205, 5.6567268666398265, 5.7509000569837845};

static const float w3[16][12] = {
    {-3.936587591521281, -2.634364399397486, -4.1946850830027405, -4.661253118779212, -3.2409600577234654, -3.715937281548276, -3.4509111956019107, -2.418995293644238, -4.004161363245837, -3.0207862353311015, -3.7201954206384342, -3.2706219953109605},
    {-4.006140842143418, -3.949152349637733, -3.577752460025386, -3.40562085767386, -2.971946602290483, -3.355614698081641, -3.986184552145836, -3.0554778696844704, -2.964579578900377, -4.3438957825267455, -3.6600673907021912, -3.1447223843014913},
    {-0.12491297716416262, -0.26048163905503996, -0.20812279292526342, 0.451754961425856, -0.8627732599993468, 0.35253023046670956, 0.8208355824643031, -0.0037131079769028193, 0.18686785991138546, 0.44823717092091414, 0.649527416395091, 0.41361751060461355},
    {-0.9093218344528575, 0.08421529514024215, -0.9608915261127202, -0.8788642254830251, 0.21482392977361217, -0.7314718211737549, -0.342457538573037, -1.0941049175664115, 0.13752631186941686, 0.03414711112471078, -0.5472296870467691, 0.47915638941858313},
    {-2.098922673949927, -2.6836799571804337, -2.109119032074678, -1.6216908648615664, -2.3507840968757594, -1.5335236741739626, -1.9021232991053776, -2.4812920369834277, -1.9196586924755028, -1.883388970121623, -2.927134362830168, -1.8816320946395992},
    {-3.537864042174542, -4.645828500868262, -3.958846486534226, -3.5746160031165686, -3.6779719620559437, -3.3657733737887554, -3.697728432811182, -3.86397567781074, -4.347695369236307, -3.1911852178655855, -2.887211459489618, -3.9293250939444775},
    {-3.168928198386371, -3.2268150955918657, -4.239401448654071, -2.765826804145924, -2.5642670940426866, -3.8350627090289136, -3.489163899794959, -3.4807073143534106, -3.5189124959938374, -4.218011822488733, -2.596499390098142, -3.179768516688629},
    {-3.9080032485503438, -2.8354062018224404, -4.4913320566209505, -2.878689516541054, -3.775480546077384, -4.275761978926892, -3.883174828728266, -4.1905685166984945, -2.714272561675746, -4.540230974900835, -3.8764763731328737, -2.7214591535088544},
    {-4.0319064432084275, -4.383288251316789, -2.956660090872451, -4.304361892770431, -3.3153400536200834, -3.7332094548336756, -3.7699313246477946, -3.7973521207790095, -4.008579515018221, -2.751030468458346, -4.658136927556453, -3.725038720140004},
    {-3.283190427184467, -2.808566636863573, -2.518110719960406, -2.5951628882498534, -4.105894726103086, -3.618385329805102, -2.6873453783270183, -2.659719427888854, -3.652337054608816, -4.144714259928702, -3.548396131729686, -3.715514134571537},
    {0.8178764213794169, 0.6988085604250543, 0.20817526757674285, 0.6406638057887923, -0.981795909526394, 0.23356889971374603, -0.8250101065236178, 0.04373173582586816, 0.4528207067640404, -0.19022645155271162, 0.48407996865237646, -0.9486550798838744},
    {-3.2360457447788376, -2.8689665123657817, -1.7658111091322641, -2.307983544340321, -3.230388067117951, -2.7559440850143977, -1.7565722021747856, -1.6103136263711624, -2.6999913953529364, -1.705945241868974, -2.0567683455944823, -2.3159245077000548},
    {-3.4921611296804445, -3.884106271565572, -3.3635924126451138, -4.130308204938208, -3.7156600085878897, -3.269461886462856, -4.382560152867319, -4.380009457755692, -3.5627108035324975, -3.436583233319285, -3.394575910211597, -4.530150755754041},
    {-4.120202176507689, -3.144731349792005, -3.6232779977927, -2.754677218350783, -3.791878589556044, -4.088155413108476, -3.75562857571681, -4.306660221402385, -3.6817234158078707, -3.1764073127638404, -4.411556607687153, -3.6778246788804165},
    {-2.8367044035090783, -4.0371137887095525, -2.876701185460182, -4.454492563361136, -3.9023036212599647, -3.2556405166864018, -3.5443967436530794, -4.331693854280639, -3.752534214735382, -2.9263143350975085, -3.980342671707439, -3.768655741531327},
    {-2.699509550803465, -2.960314929524804, -4.393499159206939, -4.207947891766236, -3.8368953518387787, -3.1962588957375435, -3.382045033549796, -3.363152580383431, -3.2760519514904884, -4.515152197863067, -2.626867229116309, -4.085886641181378}
};

static const float b3[12] = {-2.5232255051848678, -2.222908971896881, -1.5615001946465428, -2.3987576031719318, -2.7199097203335287, -2.008630075983075, -2.1914623391289094, -2.5070343426806163, -2.276329197093546, -1.7372824136362415, -2.047179390472869, -2.017791048686169};

    // Input Layer 
    float z1[32];
    for (int i = 0; i < 32; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[16];
    for (int i = 0; i < 16; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 32; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Output Layer
    float z3[12];
    for (int k = 0; k < 12; k++)
    {
        z3[k] = b3[k];
        for (int j = 0; j < 16; j++)
        {
            z3[k] += z2[j] * w3[j][k];
        }
    }
    softmax(z3, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
