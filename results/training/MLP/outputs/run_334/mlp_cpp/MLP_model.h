#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][64] = {
    {-0.4579677528857913, 0.005190177443842295, -0.049946923359443354, -1.219875868692312, 1.384564844800325, -3.566939022959623, 1.5472132366290117, -1.0533650219780575, -0.8791444412877205, -0.1797590330806887, -1.2077196339277094, -0.9892241934462992, -0.48084865789562964, -0.7037986322104576, 0.20092239210642607, -1.6069652246094224, -0.5338308867180137, -0.05404558560087861, 1.5672781064604806, -0.9508640352738853, -0.5111578950794529, 1.7710815955430521, -1.0442580466306606, -0.32673843135951747, 0.6595063154501399, -0.3719897640944524, -0.9202005127626822, 0.06432266614129692, 0.6350629854220684, -0.9955117558222115, -0.9695813536504535, -0.6223683746290788, -0.17381014679287743, -0.0875971824991417, -1.2066170086550054, 0.36416683722025067, -1.3865331269968275, -1.0861946047852333, 0.15193830569064795, 0.390287313399454, 0.14355378416730194, 0.07516785196128507, 0.40958672201577984, 0.009849880654104283, -3.7135289250326737, -0.6713726247781839, -0.32048990306704905, 0.948705877575589, -1.232410296233391, -0.2989719582488267, 0.37038705357948387, -0.6089760600315464, -0.9196181716317557, -0.8892925445689673, 0.440594577716953, 2.9102250293716274, -0.2671709543109915, 2.798040301544767, -1.0373625950584255, 0.7817892621549546, -0.7054360726418621, 1.2110701588577055, -1.2918141240783465, -0.7913877507950744},
    {-0.286331394971181, 0.07988064418703361, -0.6461112140327284, -1.7181666906311694, -2.337941468896808, 1.195708974949729, 0.17940558063262974, -0.5718048541663783, 0.25159262687897627, -0.4476342077981618, -1.5634853678125091, -1.9030048633144485, 0.2472637529188356, -2.006043872049171, -0.1789766934390169, -0.6731399399090829, 0.004039883377859582, -0.6489432291761204, -1.136069974003712, -2.3841126618689645, -1.5417832099803461, -2.3379187164028012, -2.486812459771725, 0.40477681659644216, 0.8316196496917034, 0.44574574639522146, 0.27382095100566356, -0.01575192078140686, -1.4635107033520882, -0.3768768430945023, -0.6564826293254548, -0.49856271247908784, -0.9458348216172245, -0.7070372298002975, -2.7694131754211964, 0.8678107151677419, -0.8549955346398755, 1.2809451074596359, -1.4367774764098677, -0.420489925767692, -1.3910470857016286, -0.31128413147207484, 0.5773990721445097, -0.20829014970838097, -0.8643939808012588, -1.864895898382746, 0.49133237836055477, -0.020814232849818665, -0.4898881879071403, -0.6156532621432677, -1.1470942273225126, 0.26466123318628615, 0.9324656737823119, 0.3009980167736742, 0.43907929834849285, 1.640949223476867, 0.5551136706465706, 0.47145746634509733, -0.27566493978284096, -0.4298695283375486, 0.9146302472614491, -0.787320935425762, -0.43674800897802035, -2.0962156253211153},
    {-0.9736468294983928, 0.37415954599238194, -2.9923719851709283, -1.0856359134565408, -1.2872846841521834, -2.068683960574311, 0.7268525557019698, -2.0591026187992005, -0.08609438043718103, 2.29673163749242, 0.9121816903520258, 0.7902549066787924, -2.633863773298376, 1.3555280728780281, -0.7762779497415412, -1.1268290096298723, -2.136883198411643, -1.593525670126721, 0.8917079557691594, -1.1010748886322117, 0.5424789868370293, 1.1961448203824683, 0.13676683442622914, 1.0738944952750475, 0.5349030354375519, -0.14526097348461436, -2.3533640895686307, -1.4600366445196697, -0.05335790974830581, 0.33038297441981485, 1.079022462373799, 0.6089182714328517, -1.7722779506321198, 0.04635543172715443, 0.32067235418874207, 2.4172846153486867, -0.2702141718912657, -1.4823016319647915, 0.5846381942585644, -1.5921196902442976, 0.19534616263851745, -1.0107099528078323, -1.2460770167881703, -0.15745856919660317, -0.9840124866286692, 0.5342268450741751, 0.28480922793560687, -0.9246407511800164, -1.8036718129264455, -0.6329108271456801, -1.1595747016406597, -1.9657007647033613, -1.2377614162317823, -0.48266548692789973, 1.541448444761328, 1.3778678663900052, -0.40658162423298233, -0.8028583402088886, 1.2893051665768844, -0.5108456806325467, -0.9667306805512719, 0.7605738887903262, -0.6389003526824976, -1.5821342491922892},
    {-0.9824201372290896, 0.2138723536108415, -1.0705516660454013, -1.1590932100281706, -0.1909359046522846, -0.9012621924134792, -0.6661788648118273, -1.6245146321062907, -0.8293872447717823, -0.11498753495755909, 0.2865541941398347, 1.5644724562313406, 0.2274271976661955, -1.1404382222307798, -1.0226329765308992, -1.4830035228719223, -0.029456820657744524, -0.454150702326771, 0.5489049557063588, 0.454127072465222, 1.1162342498305466, -0.9561894378976503, 1.2523136355208715, 0.9742210180101842, 0.0703035794366459, -0.6984001223276468, -0.5708482016300875, -1.145317432631277, -1.7405328985919182, 0.031026863815557297, -1.28042457399566, -0.2359200927409392, -0.013697832112985671, -0.6390670683128177, -1.5893219229611537, 1.2055524846919468, -1.0509377024852913, -2.5504064450956836, -1.691336161503026, -1.4725277103060972, -2.7355108093876113, -0.2056851733559768, 0.11551845964243655, -2.090132284115958, -0.14587497959680273, -1.8553012332221779, 0.417621074651293, 0.5296350535283869, -0.03892261732445956, 2.7197744648726694, -2.8473179566416325, -1.24290083930252, 0.04574060711356492, -0.7677565125398367, -0.9348238954660213, 1.0550076090700995, -0.3669793065845691, -0.61068078395664, -1.2230783902707947, -0.8002694859835703, -0.848700867194488, 1.9067625253903078, -0.887719357564237, -1.2774453381712225},
    {-0.44799889518236174, -0.8790034515114464, -1.035843563662497, -1.0738302577556949, 0.3914647287189086, -2.0355494342735274, 0.007694317025604589, -0.9666311783565359, -1.1396631855615114, -0.2951702351090074, -0.3680753022913563, -0.785894259695105, -2.241777751493621, -1.3095454751461224, -1.3519761994245783, -0.9505148984741049, -1.3980491313268042, 1.0671127158498854, 0.18045215464513084, 0.7067722362216232, 0.5176458533191929, 0.7733929383669359, 2.9424381237658723, 0.8430197813790822, -0.3781691095503761, -0.7975466511003899, -0.3736264521804846, 1.5861781569435336, -0.19249255191443868, -0.2939645211607574, -0.42154079102170283, -2.010069528864971, -1.9575618301948678, -0.9240156255833287, 0.19357341027088093, -0.008222065077136829, -0.08207303261125089, -2.488034534469192, -0.07646493477819725, -0.13534333087137837, -1.0927788880188782, -2.182431982282049, -2.0836141800053913, -4.026281541029922, -2.0712217461243627, -1.4037917777776001, -1.551909192272895, 1.2396820449710908, -1.4327737715089144, 2.077026547702941, -1.604951303120156, -0.4101780898766322, -2.6796558788376124, -1.5790780527693193, -1.1933517103037008, 1.6383594953168406, -0.8796298453654168, 0.09682613566365186, -0.8298980568435809, -3.5168714737464692, -0.09411367260561387, 0.14121090066969447, -2.026635121236973, -1.8339157875557257},
    {-2.0585932121760595, 0.25688196845316, -2.2162227955638256, -0.34713328081949185, -0.6198955684697649, 0.21708872460500026, 0.3859140482848319, -2.8344796138315016, -1.3278128504431794, 0.5880939450728284, -1.2163232930602692, -0.834772223502357, -2.07548491316613, -2.035142261052696, -1.2556062466617268, -0.19681279415957312, -0.25774974117420973, 0.6872425117524392, -1.5997306804775915, -0.9586599982514838, -1.1749409045677064, 0.19224539373125257, 0.8040272715710589, 0.938191049145452, -1.804310189814246, -0.38442647827776694, -0.8804669980897978, 0.40998864461930745, -0.691570449608119, 0.5632647513793267, -1.4439439573585902, -1.6362542373388047, -1.7110953211020505, -0.06789156162642701, 1.1637991972035526, -0.5661533747829951, -2.1971242234138177, -2.8979682010846903, -0.30883092138022306, 0.38835418004582556, -1.7605663029303693, -0.49387697938969727, -1.2657477408281, -3.0494491972485913, -0.40219540666416437, -1.8705664518041984, 0.6075711290564512, 1.5199298746368703, -1.3703950097451736, -1.112911866187236, 0.7135614980573305, -3.1165461384650412, -1.649539680255461, -1.5210632199716634, 0.0008358284982406709, 2.314626066215516, -1.9950202338511525, 0.15893633835224205, -1.1910622462130958, -0.4111051158921715, 0.2555125728231757, 0.1174951388171651, -1.0114112827423132, -2.194205316807963},
    {-3.268138073189174, -0.06267457695763895, -0.9354100914559125, -0.904066449148609, -0.8259835767607198, -1.0397191067384985, -2.077173065699989, -2.229222550205256, -0.41759597704545587, 0.6394275586240566, -0.22498365476784235, -2.946132942067307, 0.8368397185990188, -3.2225202820434085, -1.941333568835643, -0.8404632248685457, -1.0036167945037606, 0.15609648271583496, -2.0128745003573956, 0.7695677849640596, 1.7926829600952272, 0.8625816073925789, 0.6631224891225103, 0.6704418203596161, 0.3982554745384981, 1.2825055522284412, -0.8044428354912717, -0.13786276559092633, -0.7329319634593481, -0.5161485135861751, -2.2321828120457763, -1.6487164795492975, -2.390061915358934, -1.2329060761602244, -0.7452429599362714, 2.2760268682727958, -1.5609043472981174, -2.1791342614518707, -0.7473694157578965, -0.07314418007379635, -0.0758411448848307, -1.3067509859258182, -0.7418602077777583, -1.266129001691353, -2.670540962578603, -2.0323982003358143, -1.9478979376833652, 1.1376308738652774, -1.4578246796388343, -0.5833797361748826, -0.5918325446924535, -1.2023805987984695, -1.044791643103757, -1.0879831946230414, -0.4557788441836519, 0.15054589697322002, -1.4185071713938335, -1.3143612828004858, -1.6271960152845888, -1.5861652452080912, -0.6329367216324365, -0.315045853055227, -0.9884920194205762, -1.8357305628516178},
    {-0.9607891551357092, -0.8560468369113984, -1.0343719278290036, -1.859637468103903, -3.373979683125487, -2.668332016374086, -0.45410311232132766, -1.6880722999452527, -0.13282887748335107, -0.014756612657730775, 0.8334467749841238, -1.012737314450035, 0.08205272606819251, 0.5265584537076814, -2.3582886775408363, -1.600581629545749, -0.5599822378677325, -0.4654143910128493, -2.1390958680006142, -0.7009292479358268, 3.1159777732804943, 0.7618884203153956, 1.404302529124776, -1.8478505035694108, -0.13183907531005964, -0.2542756674800551, -1.2598412689617857, -1.2046141685588445, -0.6222645910923068, -1.8534728919301175, -0.9887640193614464, -2.2887111240139317, -2.8009589048044403, -1.1153710219891975, -1.0699274219882995, 1.2178714742720418, -1.3053725800775309, -0.9274338185402006, -2.661186853803417, -2.0467419314930804, -2.1803297015863627, -2.240281934561144, -2.014905802409305, -2.268582286385601, -2.311028682013882, -2.533655899863555, -2.489225871645331, -0.736570241773197, -2.639229086203725, -0.0397716908635751, 1.04437520297818, -0.18501341279763328, -2.5160847374688124, -2.5659500240415496, -0.9975213271616642, -1.3881156388017462, -1.2771629216006826, -1.2153083112793355, -0.18373588881935235, -0.22159994231223104, -0.5628824490833456, -0.7427797566776141, 0.4858275544272101, -2.9320111299043456},
    {-2.4034969759108122, 0.8750256616103975, -0.8571027808614226, -1.6686730909006071, -2.1434838156007197, -0.39964233520483117, -1.3720312802957235, -0.7359381420969772, -2.774580240717429, -0.6441707216488187, 0.3244679983221223, -0.1495303670041145, -1.6473834405806613, -0.5057462465779109, -0.5643839233185953, -1.351075269086416, 0.663189484706084, 0.016298096953750334, -0.32358310115927724, 0.04002123480138697, 0.9512964861962148, -0.8246440914217605, 0.9421018003257645, -0.8960982599221587, -0.7721002199736342, 0.03639657440670624, -0.6359479462897644, -0.5251011396242492, -1.8706524581989854, -1.3890058739652626, -1.7768566785074795, -2.7763266549107026, -1.3004090150231162, -1.6468589920777714, -1.7385935731334308, -0.26929883084910783, -0.3876947056504879, -1.7112414212407974, 0.15780764866771319, -1.1048387387710887, -1.7212670291683088, -1.294168759673792, -1.2763614400029628, -1.9614323803075182, -1.9847000715823864, 0.5634806445362199, -2.658721774355227, 1.3453692728332134, -1.8936583098354127, -1.4128265453472844, 1.0720145990177543, -2.896613708795721, -0.7310640460131519, -2.2142771119244085, 1.0535760219633261, 0.9117206922079946, -0.7876056985718888, -0.6470164845120485, -1.313297518695771, 0.6066298864241433, -0.23157022827875273, 0.5213116033985344, -0.38644455632622177, -2.038774570302144},
    {-0.739200666150628, -0.6192749033549048, -2.9807434284219743, 0.09232770506686026, -2.197802443889744, -2.958855299068007, 1.9835616831077445, -1.925182415076262, -0.19667312838678727, 0.016734301919849422, -1.2311238107952123, -1.5936605493311549, -0.12464763997495124, 0.09811258294083097, -0.9317431029998162, -1.9051315871278134, -3.3406968874991745, -1.4998286901916007, -0.45624747124688025, -0.08172495525936734, -0.20316046497346288, 1.3635549849361364, -1.3922498459857682, -1.2685661796272236, -0.5448313915461954, -0.6558626081906334, -0.9723631226880399, -3.517636299786544, -1.1725025792296555, -0.7960610527190827, -1.3608132612833894, -0.5838266215651237, 0.3922594776514607, -1.2969384081172666, -0.9168634858772636, 0.15993375324781567, 0.7705622289219082, -1.529579554960196, -1.600457038017542, -1.420441988581207, -2.3280317577550265, -2.3162259046267404, -0.28060333295240936, -1.239365162662853, -2.0322050904075244, -2.0059908164375484, -0.2314884291493312, -1.083351099384097, -2.1804886847066016, -0.12292311464934486, -1.3660249321809432, -0.4441243258617718, -1.070963258752994, -2.837909091043528, -1.6934388920786136, -0.8683472421549203, -1.1278598428471285, 1.0287758541222825, -0.00802397201384711, 2.382875410419861, 0.1913077967634735, -0.7317842432985713, -1.6777344054164824, -0.14800143606578284},
    {-3.061199458967427, -0.9456274659577394, -0.11652015397601584, -2.2453160545236193, -1.3268527492540425, -1.3395191519936966, -0.3664379911049163, -3.134788233765273, 0.4685931413132626, 1.0563865746612666, -2.6253694451004317, 1.2993492502178123, 0.006972419684959505, -1.5162398777779025, -2.351089809306913, -2.0521492441669587, -0.673864205333074, -1.0103093909141956, -1.5979684051439278, -1.5548993784956278, 0.04708990529821561, 0.0944504724371522, 1.2704023973556373, -1.052063668827004, -0.5717471715320324, -1.2041075383008228, 0.21221956026340172, -2.4424204695539182, -2.6664257376735883, -1.468558994758917, -1.7747238188941565, -3.3273346408993723, -3.2717549670018915, -0.05070606771626103, -0.21484939204181508, -1.4696121339931538, -1.2632069938852872, -1.38789974558398, -1.2811456646697532, -0.10089739297460598, -1.5515136586609217, -0.1965227485659532, -1.0934639711600833, -0.39377211925388944, -1.4742694296314702, -1.2242844944511972, -1.1061280438056722, 1.690682993907818, -2.5250927483735133, 0.10356378584439416, -2.0620216255250035, -0.43604188305670544, -1.0553060856047067, -2.350278100654962, -0.8547970210953422, 0.5425824560262924, 0.3284860313357173, 0.25297548715866863, -1.2217712314964528, -1.1577348581256106, -1.1819631165623057, 1.9363509741794025, -0.2476664883099461, -1.8368763773399197},
    {-2.1862694357495482, 0.7366404268353537, -1.4015432668271148, -1.734541190020934, -1.5904171027801983, -2.277561608272094, -0.7823541012422874, -1.2720543633936439, -1.7284500621986707, 1.797474414654151, 0.36987621945299165, -1.5709879984991897, -0.9332259081799016, -2.54274566471428, -2.4156577136169277, -3.281040965460409, 0.6973252515258939, -1.368175114000061, 0.6527211620579662, -1.8739520684467281, 0.34448283955135783, 0.16448873089458219, 0.1689748104472669, 1.6788341053639035, -0.47149626251677007, 0.7256811021249086, -1.1668923643262528, -0.07785459531561335, -0.7861095094827907, -0.5898122082190586, -1.8511447143855693, 0.16801600671521205, -1.9134339625649237, -0.43221911205816116, -1.0240473682846596, 1.5038848563143659, -0.8167673648418435, 0.024993979323124922, 0.18867642034738633, -0.11441973320010566, 0.11649187004733558, 1.7445941828155516, 0.19564505559039952, -1.0647503625641475, -1.3948969681929062, 0.18961994884024763, -3.2068135887499616, -0.8578897130867091, -1.9586288651763009, 1.769798472895927, -1.9066901987130895, -1.8858666652182314, 0.02432469502270539, -1.0870909778569369, 0.42440661307316513, 2.105478149428829, -1.2199788957571904, 1.1068955758618142, -0.7275477231694386, -2.669161499304964, -0.45882574180576124, -1.7453470088893885, -0.06639184181932338, -2.2796090101002457},
    {-1.2871138940902223, 0.6241273726737768, -1.501903788491606, -0.9101991242336458, -3.3907943948086823, -2.239059125297611, 0.7032974846190362, -0.709603562207842, -0.4569417683268674, 2.8290197954207486, -0.7829717737024158, 1.0707852567061085, -0.27240500566422055, 2.0148960509414366, -0.534057814163582, -1.9385502609180343, -1.7778548163356722, 0.1840491398471201, 0.5351847698708843, -0.5164290941224121, 0.2528194129614695, 0.8002464845465344, 1.9106027159810288, 0.24179632372352727, -0.38727028409192993, -1.0341988286259656, -0.8874540826855446, -2.6305081912247164, -1.4049249287413286, -0.8839694457775059, -3.0814514482177664, -2.1676906295898912, -2.817444013246059, 0.6049571369626789, -1.2900572036431268, -2.371609333805606, -1.0532392545260671, 0.3228664887598502, -1.145516213277062, -0.3754610953396093, -0.5318274887592385, -2.307051335235103, -1.1654427449437346, 0.09927454779361534, -0.618714533594489, -0.029191623748188573, -1.033002762213258, -0.010096632041149146, 0.4617270029809094, -1.2442974765053982, -1.9843812411239097, -1.7078315663969728, -1.5008870773989866, -3.6952561359182043, -1.5438513664024323, -0.32644283642011707, -2.1594888472766574, 1.4159155388002787, 1.458844071681776, -2.0761617687621654, -1.2123112252190817, -0.3286981474250303, -0.7818965195683525, -0.9909426416213518},
    {-1.0971384073808057, 0.9791429981443298, -1.5272725679061436, -0.8927803786543848, 0.14176584637946382, -0.2801010287943383, -1.479254388904619, -1.003607388764379, 0.1083987853551554, 0.6743748403986454, -0.09426666594658216, -3.3582113992157887, -0.9674660713683951, -1.1178328408335834, 0.3933465183262006, 0.1806720415968579, -0.48768315567050474, -0.8376312735299325, -1.0896196601280024, -1.4288831908489878, 0.9642481192503831, -2.3648203473721208, -0.7631277070913075, -1.3992415232746314, 0.10460612870530234, 0.6947189307050484, -1.1918250629409162, -0.3060190237164212, -0.4163570137743393, -0.6499557829603659, -4.106248040323887, -1.309055959351443, -1.0388545562241358, -0.4382371151835355, -0.9991764267315413, 1.38287662808556, -0.5804830225968959, -0.5229891377697596, -1.0892645499271487, -1.6901340189595166, -0.9227137210539309, 0.026692803405459445, -1.054469360461385, -1.387104543595222, -2.657969777356968, -2.138677674603826, -1.1979101430773746, -1.2711167173894884, -0.8511959702195279, 1.075287276538219, -0.7714202798371321, -2.459442539039967, 0.27479578059341037, -0.388396764866354, -1.1944940202167735, 1.4302709263894335, -0.4624668497406407, -0.7510868685311256, -0.894634891888617, -1.0488884294989855, -1.7286112408198278, 1.4711417723434561, -1.712051309108624, -0.595310369989883},
    {-1.2434995896595635, -2.167511200759121, -1.609108463495961, 0.18562112622058285, -1.0352442525673802, -1.826701864849697, 0.07800157502989018, -0.9726964767890197, -1.051817163287085, 1.4527045054973127, 0.09395995851814917, -1.9506973371565621, -1.8644385006176263, -1.2960721749775455, 0.032089527663017446, -0.44106870351584543, -0.33941181291011396, -0.8866608918071358, 1.2539613115921235, 0.3429557409083876, -0.19753080058556508, 0.40651033349504223, 1.644761096402535, -0.6890856564784782, -0.042945882701948344, -0.781552792565302, 0.5132232491341667, -0.3960452822405794, -0.698964259923079, 0.7526010015428549, -2.2742351430116123, -2.496095081593352, -0.9482143746750883, 1.2189381912973847, -1.3681722834731567, 0.7432615646943384, -1.2354855754865859, -0.5327364852882388, -1.6328564106493308, -1.7369969880299585, 0.6916521565429962, -0.8614104588656287, -0.6942201252693403, -1.703040767920943, 0.04228785683485405, -0.2381235309683671, -0.24090974125961243, 0.8886406159415524, -2.6868772463174544, 0.7416976167529048, 0.935713317158051, -1.2306786684209439, -0.6024399798439977, 0.5949499949865764, 0.6946363517597971, 0.02144514055889505, -0.8307795899006436, -1.5948271456173821, -1.1377621008960623, 1.1572601113052197, -1.2778487799032874, 0.06526854283570363, -0.6691522677918875, -0.407304012768251},
    {-2.8647373077033014, 2.469738917943658, 0.44425588591407433, -1.9033058388959347, -1.9902200208781973, -0.6054682518974869, -1.4720971389817528, -0.29175469048339414, -0.1489885702535698, 1.4452539726676858, -0.6836574672022316, -1.2017942197624607, -1.907327470387552, -2.0956127917361793, -0.6505997824004404, -2.3268836929481584, -0.7485077948999835, -1.2971438398702773, 1.2185681975472447, -1.0816411978468798, 0.9065875842552075, 1.2014533812395354, 0.44058570732995533, -0.025511757690467048, 2.116615532090649, -1.2243814784447846, -0.7013632328388136, 0.26932916246004834, -0.1314263047339933, -0.4573360729562639, -1.86774424888189, -0.39073152823266927, -2.756054850651619, 0.22126175377677304, -0.3698271400962379, 0.9732008611857038, -0.07392334294654519, 0.7076133964770295, -1.9888758801594013, -3.1506420819870753, 0.6959584358370534, -0.8740394960077628, -1.79704687983089, -0.06093765967967255, -0.6832756378854438, 1.2718939795942565, 0.6928360354118837, -1.4424333851077955, -0.4464636909969515, 0.6760906854368873, -0.8638527469903532, 0.08492963182108008, -0.9959508631199958, -0.9000319101240982, -2.1888636005014424, 0.48965633309412765, -1.8753363632401843, 0.03876578092291084, -0.8943052225843902, -0.5101840561378768, 0.5916795560898805, 0.5331678830155979, -1.003569760654326, 1.4983083582566135},
    {-1.9367581217734051, 0.8814056073264647, -0.39374203532430013, -1.0975345330462607, -0.9403699350943558, -0.40929071872925404, -0.09616198508947861, -2.213694660120245, -1.226800113002388, 1.117926951386936, -0.46544055765773273, -1.0943057502178306, -1.7112209218258467, -1.3315744137775598, -0.3256980688623618, 0.050159495001482174, -0.6848279757439077, 0.885062716917518, -0.0515051186473133, -0.4986237797801102, 1.5815886132966122, -1.733820849724471, 1.0415919102156581, 1.1542628328843267, 0.1626178593445092, 0.11050467402945678, -0.2012226647740198, -0.6241722095846687, -1.8054371389782098, 1.4046865037621459, -2.7640085785268536, -1.9544055017336135, -1.2289458522570638, 0.0469478587986958, -1.737159480305961, 1.4951802439185804, -0.6296865544772484, -1.3262679149215566, 0.8634670819299743, -0.4384572621111242, -0.6983741141344897, 1.220211148627845, 0.2171550203756845, -0.8218616954521597, -2.5714334116075226, 0.860319915029857, 0.2563213770275554, 0.695683301220472, -1.8116488476384058, 0.9240457136820276, 0.13671297030124818, -0.8953005276311591, -0.5587522174041851, -1.7132057358926682, 0.7837483533665426, 0.9824078246253345, -1.131479558891676, 2.065861661021753, -1.291091843315899, 0.7675411043094755, -0.756165977422385, -0.3125645854749996, -1.0577294631285274, -0.39343276860457865},
    {-0.96011919954589, 3.0282923515165714, -0.47566546284819766, 1.7497173011424358, -1.8342606298287325, -1.3667392583085134, -2.006069941730435, -3.772497443603084, -1.8044377234990794, 0.5911163585241203, 1.1318490337854663, 0.2329549000240085, -1.1970227792377444, -1.6059324083362139, 0.9580519829454567, -0.31918839390415826, -0.44519480867677935, -1.4813272461124412, 1.4050960875238727, -0.6353888453076267, -0.700097016796535, -0.6110603283719733, -0.12580401982672687, 0.9907106352804957, 1.2338442263223848, 0.7137196334302531, -1.1323829234736782, -0.6402348950990567, -1.0652732983524273, 0.7395792210137017, -1.63638849565698, -0.9520929582888561, -0.43629365112727064, -1.3438188573900083, -0.8378605429337187, 0.3256878331890731, -3.0558807925646074, -0.48737832088450267, -1.615483396263181, -0.4776966067349632, 0.266443477700358, 0.25783932284889405, -1.4168531595273557, 0.07671181840566081, -1.945940177686965, -0.060822690706175825, -1.267012893058449, 0.11646322912003106, 0.004583904844215036, 1.4422218088404861, 0.04644095735884745, -0.41411251379834507, 0.9975555068694031, -0.5102860259469822, 0.07355779087044462, 1.7713401194539364, 1.727178725672565, 0.6024668636995715, -0.4361593716184819, 0.8171464167286606, 1.5516005764117506, 1.690788826615875, -3.1127955916030725, -1.0816355602617738},
    {-1.2544761531929034, 0.987962642919973, -0.12189456700389648, 0.22797665146769086, 0.11768242389548648, -1.3614910511287281, 0.5327552655755698, -1.3449830181217493, -3.5118400196136497, 1.0129995262283182, 1.3182081824540852, 0.4431568296136845, -0.23917050256033173, 0.09102470408353579, -0.4486772629823753, -0.469566806196279, -0.6067504040594136, -0.808836636599381, 0.2646614137366788, 0.907692186333366, 1.3576387460517423, 0.05799243771564971, 0.19876618875969979, -0.8387444650741867, 0.15015454635952488, -0.5966109112059585, -0.6912488935062122, -0.36669179532313734, 0.5649487877885659, -0.6729350765901915, -1.8007344927746205, -0.17737131898512665, 0.2488443627932625, -0.8021637425289471, -0.9561567275252049, 0.5463106246920452, -2.122237555033532, -2.2236869299729083, -0.1368218579117014, 0.402017637004261, -2.1606462354942977, -1.3628178774499728, -1.4603358731756275, -1.0890404162284946, -1.514296778018237, -1.6358184214766955, -0.7795118917140529, 1.0146412204656112, -1.7500981110672948, 0.4721019504530749, -0.4958787941062066, -0.8432124942642363, 0.009483421708986169, -1.104827354510017, -2.821955215693652, 0.10539948916673819, -1.8741600606861015, 0.6368030727126209, -0.2673020912022547, -1.1684316138374906, -0.8143123130937967, 0.6096252500293228, -0.7218989336186973, -0.8336317870569565},
    {-1.7920672370735262, 1.0868241934539296, -2.7034201418557613, -0.8446761388670557, -3.0059759197554654, -0.43136296844576, -0.9408022891670287, -2.177015426356321, -2.4939765708665815, -0.1355782305946769, -0.28474610648537974, -2.2290685041972704, -1.7924386895526443, -1.0452525632367138, 1.7019371528359393, -1.9889597217934925, 0.20410736692133827, -0.9338488510013384, 1.3843353717660094, 1.6973205298614291, -0.5380213399880475, 1.0812219834031636, 0.46538125431659827, 1.2963564054392458, 0.82108882630294, -1.4794635977351505, -0.056518834780524885, 2.328314351717779, 0.24147589960031476, -1.6757813110905089, 0.26110267369462087, -0.7103114456757093, -1.8870242594920341, -1.3218019714214735, -1.446630915536087, 1.1991794668920936, -0.751440615449445, -1.8080542747639001, -0.7736705660251931, 2.483947884641905, -0.12394857099287795, -0.8734017339837697, -0.01784724992851267, 1.2381220821234875, -2.681432222080177, -1.0576093446853778, -0.05665896966493295, 0.17914533172987515, -1.5657013467589704, -0.4806956383255771, -1.536733864960166, -1.7175444646302016, -0.7744791423921158, -0.3023249995219749, 0.5118148394007668, 1.787371840807443, -0.20315430895860556, 1.131480037360334, -0.8720504426143331, 0.983428911244199, -1.256112751864753, -1.482503608115099, -0.48858691675945237, -0.9229827308305384},
    {-0.8845781275926811, 2.8369209741781, -1.5608058340896718, -1.5385912988374568, -1.7085895324865374, -1.5022775424709887, 1.0620500052334119, -0.7622717894404197, -1.7273774659471117, 1.8960226492838042, -1.9395869273048087, -1.5951225821146704, -0.3046267822484105, 0.02347977064241216, -0.8910985598884722, 0.06361244112197234, -1.0794240662482557, -0.14820486031536334, 0.430132305372903, 0.7524954417386328, 0.9058207508612166, -1.1909967128460417, 0.8436430744833142, 0.8712725257669279, -0.26432120292070094, 1.0303800088396453, -0.279247223191859, -0.5410528715191546, -1.8862075543134593, 0.6383876635893222, -1.3222765065836108, -0.3217779687058472, -1.8159197386667996, -0.9048907830072531, -2.611971279334745, 1.6346957876207857, 0.6935089773383598, -1.3481510246810824, -1.2639765452051472, -2.3204588873087237, -1.7606325882983502, -0.9577165770543461, 1.397419477845048, -1.9170760308546877, -1.1220588347917981, -2.0711447350813317, 1.6730980066404297, 0.5092535957175143, -1.9999634381959512, 0.6842726137335353, 0.18772931213735597, -0.42468513702009203, -1.2245523410627115, -0.11542730745547161, -0.3690590413171769, 1.0827687959310832, 0.5508188185349396, 0.34327198043222795, 0.30795275361411145, -2.426069284704963, 0.2841125073407758, 1.6171586092031907, 1.0815148690127212, -0.8540674388978747},
    {-0.5808746085396718, 2.251852718453968, -2.2319127765671043, -0.32819720466484875, 0.4043674314794512, 0.310347076466736, 0.3264380367146165, -0.13826287179284635, -1.5967474576766645, 0.23144342196536904, 0.19616044395486779, -0.4759805875591844, 0.34070700494186296, -2.610619082587586, -1.3583902759393578, -0.8825132412321033, -0.8989658876584227, -0.561244981692522, 1.1315293517993434, -0.13829087349177313, -0.2902581684451329, -1.0339563923029638, -0.33079728745822273, 0.12626220349342185, 1.8750683900428269, -0.39321730657495957, -1.0792708639285176, 0.6916901367807712, -1.8312064034225737, -0.17917458201173653, -1.0269762151990958, -0.4701950937524441, 0.31114619048095205, -1.337927300858136, -1.1461218192638816, 1.4689718539087886, 0.8001309484489395, -0.4841838295033979, -0.20183922501609944, -3.9357216756857114, -0.6628473677620815, -0.8332327527315674, -2.725367404865041, -1.4561726702193183, -3.128369717895782, -2.4492331389846114, 0.7637504244381366, -0.3920919174878261, -1.7005776505054047, 0.6620661846368586, -1.6882722749923182, -3.4269512498960344, -0.8837726597311378, 0.945007400155859, -0.47346305170972536, 1.1607858284810697, -1.1200070136744897, -1.5641591577173912, -0.7589584348819314, -0.7808173998382687, 0.3880714113974064, 1.8301241733276181, -0.7176020141486912, -1.5468271684153323},
    {-1.237533993242145, 1.144992640845887, 0.61185791484293, -0.6540045878357215, 0.37603027687274754, -2.4444511130581894, 0.19145879663406784, -1.8857039634631863, -0.6568421654605786, 0.6591171167785389, -2.3489802116723473, 0.14895892891008564, -1.0332502259322391, -0.48790397960277154, -0.8160201630683421, -1.651457313772704, -0.28764181513378045, -0.4818378500451866, -0.7677106371711634, -1.5603035027953673, -1.7372872687060468, -1.1023977609050948, 2.0165995452759726, -0.6142998793651077, 1.1492511049541254, 0.05831762279267302, -1.178752322009211, 0.28829308348001925, 0.25141034571655063, -0.6871608166104555, 0.43279986616993177, 1.0192518814630782, -0.9957605158817058, 0.9227499912625923, -1.3217318798155222, 2.306657463211454, -2.553608361972004, 1.049980015976886, -1.50326284839441, -3.6812324116471995, -0.2946639885047166, -1.00389609363218, -0.04345348907705943, 0.23061946799559158, -1.3774615301330553, -0.5680032807547075, -0.9904535213411287, -0.7196289278434493, -0.315215228235517, 0.8249462048764781, -2.373579666597864, -2.8445229205096685, -0.877920528626737, -1.6592395440540448, 0.04957267368618713, 2.204342976136891, 1.337193079033187, 0.5012611987669167, -1.4899823410791135, -0.4982583233200454, -0.5491224750700006, 0.06669769348230525, -0.7053273200350407, -2.3732914449028315},
    {-0.8097713464719904, 1.9912263323719501, -0.9900602478757426, 0.29641196847102047, -2.6803883613915707, -2.4703472046810537, 0.2547744431420713, 0.2993795384498921, 0.4389147256702373, 0.15536673839820672, -0.794326430762944, 0.17355827303949406, 0.2661886084268342, -1.2990092131819666, -0.8558100611753537, -0.32621650274482705, 0.019436663805540228, -2.1664438576608496, 1.4874465398886794, -2.177393735732348, 1.5573851817049609, -0.388773566376977, -1.0345872686740436, 1.0770857595623204, 0.6796967858493177, -0.8367782208232715, 0.6071849522621463, 5.746009770447614e-05, -1.5593024688877288, -0.6841977081280071, -0.8078708032870004, -1.7094118846413209, -2.0902561192865226, -0.41670970151672404, -1.744649501870362, 2.3561213015220486, 1.185952956456029, -1.1089516196052212, -1.1749251088848025, -1.6978245777318617, 0.5239412831494679, -0.29372831317813486, -0.11611223010884783, 0.33807939660776193, -1.6247686328140516, -1.6904707787551998, 0.08703678060282202, -0.1780746624302342, -2.412556641163352, -0.2664856944846646, -1.0329204412870854, 0.6201367686130143, -1.1526848363931157, -1.3041219405843334, -0.9500559171046015, 1.6068152052962543, -0.1559775001291889, 0.8273780270580896, -0.218471702122412, 0.3800023172489457, -2.9368882702638994, 1.6273705021033524, -0.8224107158913551, -0.6216973487079627},
    {-2.172187423725999, -0.009194128104300536, -0.18325679715668172, -2.812005226984247, -0.7620393396757449, -0.4482778695713833, -0.9921846243001784, -1.8069791039898147, -1.1894175470105457, 0.6063646917570727, -1.4641984406827249, -0.5315444410802088, 0.1733991063304595, 0.4102551397855664, 0.7586858590076091, -1.117693787523328, -2.2462047179864446, -0.5440537988399061, 1.0159591493887103, 0.32229853996786517, 0.2718851742730585, -0.5845125659487534, -1.200761687659125, 0.47180709334291016, 1.8030506738032714, -2.1654093080049908, -1.0928614781418704, 1.7330309271634754, -1.9781318572256192, 0.3148582247592404, 0.4524303568833263, -0.5333608585657058, -2.1019670344350057, 0.8258501033547879, -3.0194564784839257, 1.765237129837937, -1.0869076001913796, -1.5190151889066454, -1.3340305284312637, -0.8726771336793414, -1.8540877022591165, -1.2318736234185397, -0.6200433279118106, -2.2070389538551725, -0.49990526700409743, -1.2735086942688139, 0.24096215220302372, -0.7853232691415795, -0.008980427741576235, -0.6340355154363503, -2.9563600822617, -0.1547312753932729, -1.301427851292871, -0.9803742424352018, -1.281132732899807, -0.03386174967702332, 0.9100405469032931, 0.02491085204695002, -0.38085684772851885, 0.5597329350029769, -2.2313217059257187, 0.699101106634343, -2.084137829433565, -0.5236423373823016},
    {-0.5498891247964229, 1.4836433879875637, -0.5587091406859214, -0.5578268907364885, -1.5145703444315157, -2.592188540605355, 1.7805582594741385, -2.163819066722237, -2.6608179342058644, 0.6136239537921682, -1.5669385882407099, 0.025983274306897335, -1.0910576236470457, -1.211130332710494, 0.2831093709989911, -0.2287581349469697, 1.3815073225748644, 1.8370277046957073, 0.28092219411305097, -1.1198061577377858, 0.5349806695670049, 1.6574424777713812, -1.3848463329986485, 0.3295360980077962, 2.253919936719443, -0.7168108681909979, -1.719893419273352, 0.055820579675684066, -2.0303372735256455, -1.6773388867341754, 0.013718305221470621, 0.01101391468838742, -1.0470495110648292, 0.5394299799343897, -0.14502926365329474, 1.9781657624321138, -2.532986866636522, -0.8725648941131973, -1.2960864261719018, 0.2854975111511702, -0.231880502453515, -1.784085409760338, -1.9222167853653873, -1.04066253367688, -1.8509570347114717, -0.9622738334916328, -0.49847353567915514, -0.12624743552279014, -2.7809172323796822, -1.2245239215623378, -0.4143689587971656, -0.8616054884785842, 0.13045445443222464, -0.4405680385392489, 0.49103447073088974, 1.7204994583403042, -0.8587952549753611, -0.4025896198124481, -0.0065578890762598326, 0.377999160845065, -1.1445859411809778, 2.2483704426335245, -0.5797852707117144, -0.918915519162248},
    {-0.9108441548291152, 0.23284512191085474, -0.36441954482049915, -0.3462531138844591, -0.41511518690103105, -1.1622306578858743, -2.310488408569407, -1.51074597769634, -1.157559350186441, -0.4791817752612323, -1.4651196628132965, -1.2230582512205994, -3.063369345755356, -1.7811651002252353, -0.3902033085049945, -1.1506765573531454, -1.3506340748783983, -1.7204638786619726, 1.1706681264591934, -1.1954443727871233, 1.8478951340226542, -0.23397053968365744, 1.0703717169873854, 0.8384361907536992, 1.106212601465039, 1.5317300320080738, 0.63692918587797, -0.09709226800379046, -1.861045186083073, 0.7578835822646878, -1.1767089203458068, -1.4247176305353129, -1.1605027498491804, 0.9862343098166343, -0.50296259217636, 2.457476349317087, 0.18623605185487588, -1.1868458442882757, 1.082587514996289, -0.6117211413736544, 0.7323342238312731, -2.3432038708571263, 1.5189491608257546, -0.12861783284877348, -1.519736963641348, -0.2690844038324391, -1.3345009124297036, -0.4662929102871112, -0.12841630248450106, 0.3410474460432264, -1.795666037969642, -2.57035083792529, -1.250286630951872, 0.009617026352063202, 1.2827818476352206, 1.7506805602841746, -0.041463083418878624, 1.03125274577249, -1.620150980475289, -0.12047091727964138, -1.0558733368608504, 1.3315167861638597, 1.198774129567795, -0.9448645386321844},
    {-0.8683789835136738, 1.3625809669702662, -1.382041686050136, -0.5615244235762226, -2.654758528849454, -1.3307791053904907, 1.842799583104983, -1.6892630164431768, -2.53970477097875, 0.9546934708335024, 0.8054694286162987, -0.4270099631475393, -1.7195882664421984, -0.09031879826599855, -0.925324294509012, 0.36355481191525635, 0.01869035428989061, -1.0458594688298635, 1.0970247441431331, -0.5561089631780873, 0.6139079153516495, 0.6460614653251496, -0.5691463465315911, -0.3161944193912768, 2.9499784471892085, -0.8157622794285405, 0.8246026174374815, -1.5264862546381714, -1.315078748488505, -0.8223540680683568, -1.1588851051249554, -0.8344337154147063, -1.707796515337077, -0.744136362490278, -2.144500033756631, -0.7439684850313307, -1.6038509894147028, -3.1544332566217554, -1.6134245554332771, 0.8120848498180838, -1.566982815338932, -0.8509948664555107, -0.10933956173256895, -1.9269197010369452, -1.8169232380180438, -0.6634177371095649, 0.7488827629751825, 0.061906396160736496, -1.7060555384236014, 0.3728066621531884, -0.9865068324133801, -0.7796106764629608, -0.05886452874782257, -3.0633991119035313, 1.8054477387515102, 2.699463789038613, -1.6859596581990972, 0.956176354658405, 1.2314867764709376, -2.835007025843804, -1.5904278688994982, 2.2322984982709126, -1.99232395292284, 0.3688569308305977},
    {-1.9731153844574616, 1.2262671928028064, -0.23357178868869835, -0.9323468772745738, 0.8865314462343269, -1.4938666056231449, 1.1871061740643607, -2.780790364950995, -3.7157793067445417, 0.046123098335684044, -1.8655243163721944, 0.7162884358262256, -1.1834930724341497, -0.8591170807762967, -0.6394251143596976, -0.8766613956372067, -2.0314296298151127, 0.005148960317582447, 0.5094790446900049, -0.22740102256503883, -0.25891825545153974, 0.3292591475303954, 1.4426011655714992, 0.9071801594059342, -1.0645744489984315, -0.15172144925552575, -0.687527591706252, -1.5939338567449939, 0.29409598249200897, 0.38273004557768764, -0.0618080361142111, -3.039174116372096, -2.039553009182217, -2.9789538567866676, -1.055920572594492, 1.0303804766509415, -1.5370268281763357, -2.537011674580702, -1.809041049423227, 0.408015672759678, -2.0126929377730005, 0.015584422117201381, -2.595593866430011, -1.351423145180088, 0.4133473784572664, -1.2491005594060571, -1.1521634369160692, -0.8041310766394639, -0.7629581222034413, 0.9331625868128279, -2.403267378843763, -0.8878471498458144, 0.28749972262183643, -0.12411030150343544, 0.15326317725380428, 1.4484747921652412, -1.2318700270892666, 0.15587430980004544, -0.3612024484342871, -0.31541995056186933, -0.07847668734713371, 3.3051520447748852, 0.11443533901282262, 0.38625213719762486},
    {-1.9812574588472733, 0.33425732247149853, -1.3558894881243064, 0.11050103450993198, -2.1045839939492184, -1.1707989136647035, -1.9910916459574832, 0.6409143611543768, -1.175485245051302, -0.7270996532373006, -1.2690236514550033, -0.5281313442983021, 0.5095048143078363, -3.842104513510741, -0.39972354980178765, -2.063213223320725, 0.578117092965111, -1.264135165378383, -0.42884725991012573, -0.336731383652834, 1.4444061844536336, -0.15140516665691317, 1.0369027552004186, 1.1046728254736469, -0.9314474670142218, -0.6086127522912093, -2.5315711345199654, 0.48331868496523445, -1.4900381593722065, -0.7806526891069063, 0.1307173013349196, -0.29152266186341846, -2.3949766917623965, -0.032121847070856996, -1.3101744485948037, 2.085116906698346, -0.23798835712451968, -0.06764771837899798, 0.27108350576454937, -2.5117515056914725, -1.3114616695648214, -1.7876812312905082, 1.1551049324906437, 0.20677473168240454, -0.6944561274458085, -2.4249426465058868, -0.5809351300591412, 0.40193627893401673, -0.4753679555339148, -0.1265258344737358, -0.2413182711876243, -0.6639738318108888, 1.8214129997338104, -0.581996298745757, -1.1045564254117415, -0.27868289692057874, -1.3877520128550274, 0.10793101387519176, -1.4154130015256545, 0.888943029435471, -1.4761020917751344, 0.4710191006704005, -0.3970238432252023, -0.8188295048677403},
    {-2.5318888565751863, 1.421318881009894, -1.0025654006584992, -0.804568886655695, 0.46917392141486336, 1.3696412464736203, -1.3710091999408556, -0.6922801398730493, 0.30371143503361814, 0.2843957145452502, -0.3749430793153713, 0.07480325469897646, -1.0115755224211798, -0.1752551568401405, 1.4471734460307513, 1.177309553886062, 1.5042794953630978, -0.29687154733878235, -1.09948299930814, -0.3979702477927081, -1.2565638037868978, -1.6263031137950037, 2.3798227071763707, -0.10545576924044728, 0.17191054547235166, -0.150480213445052, -0.5557005888195832, -0.2207302611019783, 2.1414066823703477, -0.2968417023425243, 1.5177304821365394, -1.615197704382694, -1.8831352417734053, -1.297531585875735, 0.6678037788998876, -0.9603023361892574, 1.3149405260173894, -0.11089506925084715, -1.0519352278729648, -0.7913234611939044, -0.16236534289942173, 1.9025803845222704, -1.5501118135232523, -0.11602950440221524, -0.8790032987387493, -1.3227609953448538, 0.8227371424385181, 0.9879685696596876, 2.77016890927571, 0.2426633274314677, -0.029043732557283004, -1.026052715207255, -0.3387993871531095, 0.5221504821334111, 0.2790742294975955, -0.09637236900302115, -1.0012832268014538, 0.5912815457985681, -1.031226931521317, 0.770550254821949, 0.6367722664126361, 0.7012950413469399, 0.9476485891328597, -2.0171719265761014},
    {-3.063611885519853, 0.020206421283778173, 0.7159669774524571, -1.3799136015695233, -2.030771177929141, -1.036699191376706, 1.1703703226922177, -2.152314623245853, -0.15705150522428363, -1.0906346118933181, -0.4925459282166842, 0.4545712339945688, -1.5513692154931975, -0.4479662569364688, -1.636904326710788, 0.9177901525767506, -0.41165944887047046, 2.2101820724464476, 1.072010648715335, 0.17289031169322816, -1.442737187428485, 0.8920081114099405, -2.0441373919516583, 0.23710370168728948, 1.2255350733858252, -0.9104978533251913, 0.4839586226570901, 1.4701531507153018, -0.20416408627115282, -1.0084030885074293, 0.4979873716703238, -0.6569611554124197, 0.9977335112934479, 0.0037809995197443614, 0.6044993882351609, -0.19154473111119824, -0.18860430372715242, -2.1521775170220714, 0.01317595005355586, -1.171433415388332, -0.7069843422096961, -1.0353853761161662, 0.24495463712638121, 0.30982248469829293, -1.775192451910251, -0.6052008956816429, -0.17725194393592145, -0.23131983715529722, 1.9646840603085074, -0.38076434823663086, 0.7205479474682147, 0.041262033923853504, -0.08177957438768117, -1.1746374403758395, -0.6846948319487235, 1.4805845623500944, -1.1451916989066826, -1.2845348993231263, -1.7676212761029293, -1.0312727651980031, -2.124508924907174, 0.8358480004217752, -2.2429249963362823, -1.5014781607239056},
    {1.7185931932412672, -0.6015569513446097, -1.5436417486322316, -0.9689613815809871, -1.6230254533432031, -2.678143766608682, -3.475166480274345, -2.057363627151046, 0.9390607095047138, -0.10413990179817247, 0.34323986386853134, 0.8611414239106554, 0.6988444458102349, -1.2682445470544916, 0.027513858781632834, 1.6194976888437975, 0.021508037013211304, -1.1630324966480299, 0.4773727641549262, -0.9063679384995402, -0.1490522688292619, -1.41199468802536, -0.2639823194777946, 0.2638438349244898, 0.1788084005560898, 0.4779690981095075, 0.593153105043131, -0.2339694033120317, 2.5674942686388977, -3.3257986189890087, -2.0627907645783075, 0.8138428142599331, 0.42103894377648554, -0.7639929224108489, 1.605729050361593, -2.009951977291354, -1.9137696360550456, -0.29038474679051085, -0.4984714663548424, -0.006931644240242212, -0.6156213947256917, -1.029062973074622, 0.06385403173712968, 1.2244887259230934, -1.5610040978522624, -0.4280170401285238, -2.2815293621521, -1.3422941054747095, -1.235582012629895, -1.4601656649507253, 1.4135543164653261, 1.1895873730885853, 0.3550169232360835, -0.6013894774798113, -0.8962294194203169, -1.0310719838365459, 0.3190946690334231, 1.828235262440775, 0.9945168247445461, 0.22191857789627775, -1.7262289486119529, 0.41872828402486617, -1.8556256348267963, -0.4001534835796067},
    {0.15812600918956382, -1.7937567763361373, -1.0498308874606854, 1.0918461337018694, 0.7978790244021161, -0.9837877727130586, 1.8071594418143166, -0.5131910608398539, -0.2880275192550276, -0.9631643573967146, -0.5893611182230928, -1.5433440317862293, 0.598415926897852, -1.8920592974456143, -0.5334443955273548, -0.034263444601045155, 0.19189827012807475, -1.2583820224879423, 1.2319592530375998, 0.3236310903168152, 0.6066654415634094, -0.7581998185768875, -1.0057147945706726, -0.5912655136068719, 0.350494824264248, -1.2590243322636512, -0.8330866956798559, 0.1477537055641, -1.4706173551786188, -0.31903541348730524, -1.1227732344704981, -1.0012893682675426, -1.6515314217499013, -0.8743959690627285, 0.3707634435425069, -0.9041829341768448, -3.0642579780082086, -2.089648659457633, 0.28915103406602166, -1.467469949408432, -0.33604152560689365, -0.768278233901122, 0.6037525253801241, 0.24482548912924423, 1.3664412375082193, -0.8386339739930136, -0.04478854009436433, -0.06969378958289597, -1.32571253483966, 0.7284048881930852, 1.0706545919637356, 1.9336284883596628, -0.8226089440770488, -2.007785359863452, -1.743514235024793, -1.6547982188258665, -2.46104354194876, 0.7924786041580626, -1.1398739498410093, 0.4362192934944146, 2.037258144423099, -0.3842187424939927, -0.6640673191139354, -0.8408846355187508},
    {-0.569765160377882, 0.4668087986687886, -1.482499639711075, -0.876773682135592, -1.57176442469885, -0.424825724936505, -1.40232037568604, -1.443511298613959, -1.6932972946446039, 1.767879996446862, -0.6380499844036578, 0.24389862089848008, -0.5328556548733759, 1.1708465802613792, 0.8148601676978166, -1.7412065519111937, -1.3595391166633868, 0.06210281593707969, -1.2902502234042426, -1.4337948788813313, -0.21102553565445914, -1.4626273677528068, -0.6605784521318205, -0.6008482672933911, 0.12919958721011082, -0.8567166969010214, -1.2752729143931096, 0.5801051929467365, -0.3548303888588398, 0.5020483386984809, -2.5500871656876676, -0.35399182906653726, 0.25710320092744504, -0.9290955281764992, -1.0631190149978509, -0.6126809382452707, -1.0534429100732352, -0.05889637530819951, 0.031078833342849554, 0.8167028427947118, 0.12588976448341718, -0.47034709624713067, 0.7484702196067662, -1.6158114900637006, -0.0021369522437788466, 0.1390202646385415, -1.0613177311666917, 0.6882654751584915, -1.3263609356069797, -1.7807106494622493, 0.5610898974575317, -3.6846957264942644, -1.648807477261481, 0.46787120456300185, -0.24130234815806645, 0.4022537049010195, -0.8031051762001659, 0.6622162389491683, 0.3231918871050541, -0.06106479565537474, -0.04876268475591496, 0.5589010451792322, 0.5883480988289262, -2.17893870373616},
    {2.2430917413612526, 0.7357355299276189, -0.271648190855082, -0.7750359565993047, -0.8257482870519047, 0.9188213203228394, -0.36923814318243875, -2.328842562360747, -1.5259337174711018, 0.16369365491267576, -0.9235278629265745, 1.4016808926067286, -0.8211677483841399, -0.1579423275161959, -1.1447416841841265, -0.5595901425824471, 0.00573502800200778, -1.3013285889779418, -0.8056929927479268, -2.2195229830345964, 0.8888122567155191, 2.210338338745327, 0.7030405495063456, -0.40142025927918734, 0.5468279388579049, -1.61412313459298, -0.48287430923177876, 1.12470442440592, -2.5008747638365127, -2.0432965181507683, 0.4521844873656635, 0.07003187038356869, -2.213330263620204, -0.45680573732630225, -2.3707255878368425, -0.9761891838200801, 0.19998805259753222, -1.2350099460488382, -0.3849265356608835, -0.682649815576156, 0.5228695187451774, 0.8009158621493304, -0.06779214124801478, -0.3135958743971296, -1.0055788151304492, -1.2949596358378752, -1.2275876563281898, -1.1725569502890993, -0.8354823040701966, 1.4665426539129345, 0.3442179366781916, -2.7016004622142273, -0.3462255302235285, -1.6974139666608916, -0.08810852162018494, -1.0455777195232492, -1.2006050930634802, -1.072563020559781, -2.0808169895103865, -0.375990221956854, -1.4558798744977302, -0.8295385609817738, -0.5668545826355276, -0.5548154926484599},
    {-0.061567562148761946, 0.01290839276338972, -1.6381290704305411, 0.6009713263764347, -1.1347122539351806, -1.3332196436541892, -1.6119558429906535, -1.1300267444264356, 0.6081798267941041, 1.128209636193811, 1.010617865759866, 0.5540558057349079, -1.571525913254143, -1.2600215029630586, 0.22174790366854796, -1.9603635464134186, -1.76000624027789, -2.7571205422041185, -0.9234101470705828, -2.738540335372099, 0.5971713633872895, -0.6635737551614205, 0.9940407666796596, -1.047576879541286, -0.14970706409148415, -2.525146960649065, -0.7207037566206346, 1.504237356245893, 1.2757688387530417, 1.4914647548074862, -1.715812554610948, -1.237929161354921, -0.0009994503832647574, -1.04744398405437, -0.2861953756632252, -0.4398803517283788, -0.7462812340153987, -1.0591226592899425, -1.2902255777089933, -1.0224376864509845, -0.8457776636705283, 1.129987471864161, 1.8541375722164708, -0.3230317508935809, -0.8539126579088032, 0.6571610709745229, -1.7682318950322988, 2.4886821534527663, -0.5887749150693533, -1.3763576185697513, -0.23006828981372046, -1.351706881314906, 0.364252618732608, -1.367233919186296, -0.5380048920984525, -1.5604157575795627, -1.1510347173849296, -0.017688820806419658, 0.907019288062326, 1.0685879462310586, -1.7107926381166374, -2.522819027057543, -0.08180432431763683, 0.6968304695771215},
    {-0.14467930217778152, -1.0010868542088294, -1.7455047959070238, -2.8380686571330256, -1.5777904475213584, 1.2718552346002419, -2.0310284156742298, -1.045604515957106, 1.6296548217657, 0.06960718125772011, 1.5381922633945344, -0.8912655754695724, -1.5750983531129494, -1.4604815810643914, -2.291626511846116, -1.5910684454950603, -1.3374215781508199, -0.8300424911081136, -0.9758780751933056, -1.0458131554272014, -0.7542719180707225, -1.3597622376843543, -1.0465618881083492, -0.564054017924591, -1.3398347616350053, -0.4591292333245484, 0.2670390754478554, 1.8011318650436887, -0.19835925095623763, -0.641709978504461, -0.8437559036437065, -0.9755459780024224, -1.1469113651805491, -0.20287004966456335, -0.44279397353426575, 1.452995829110328, -1.352903168135085, 0.4468600665435512, -2.0048222577677706, -0.6739576642691055, 0.0837509174043694, -1.1145686451956356, 0.2961517308327235, -0.9716874065674226, -1.639297236792253, -0.9635870236064376, 2.5141389504093787, 1.38975639155627, -0.7555834561382501, -1.379129962063532, -1.6039617447241075, 0.2801434576745876, -0.6557953678905032, -0.09248768226232579, 1.6088238635090668, -0.03691623938868296, -0.23312413595594936, 1.3146678112144192, -0.43265921604947094, -0.18073053771141787, -0.29192515126993596, -0.07743596530505709, -2.756714153784754, -0.4383463475960574},
    {-2.008517566421718, -1.8095145090985834, -2.69074221728797, -0.9748439938353911, -0.38186956711403475, -2.0970471391928927, -1.4678753348454188, -1.2739735034040673, -1.0857909088492592, -0.8557555480397524, 0.08167378571036346, 0.33137053687084495, -1.538035975512695, -0.2710505198039771, -0.25793597847648203, 1.546663948575274, 0.27288357909498945, -1.9613881249427594, 0.06992009146145388, -0.2325383334548845, -0.43186911181751186, -0.020495351747138887, -0.45765829656640156, -1.6455487056149147, -0.3878231337836511, -0.40509152197753695, -1.166661092040475, -1.0651700019064423, -1.4047594390189138, -0.047459166568306475, 0.9072907891469391, -2.121898883242404, 1.430201300691365, 0.03040827156470173, -0.15894866893282825, 0.40657027698869985, -1.575904363905964, -0.1142164990936773, 1.175718735544527, -1.7427283011405177, -0.6556504600123306, 0.9366740225513224, -2.4212474838702507, -0.34805474158470023, 0.021978334077122748, 0.7253739872861463, -0.907492854378771, 0.17584767246526625, -0.8544507968842285, -0.8582253222846494, -1.3974937152691367, -1.4620564477460172, -1.9128468724387915, -2.033639146545494, -1.6762397879484292, -1.6332563309923778, 0.03526174437007854, 1.8116134042349703, -1.2795270143992816, -0.5344048424016185, -1.461120220955217, 0.15364177533377615, -0.821025474383008, 0.8927888330184204},
    {-2.4322049607685012, 0.0567573318216726, -0.7496952292659749, -0.17203835518227084, -1.1359932076932318, -1.053788762623939, 0.28476579091633475, -0.3577992289440646, -0.6451582032240932, -1.0840741025611296, -0.964277155762695, -1.5000878783976763, -1.3778021831018878, -0.9107378276190699, 0.39896733868408274, -0.37876652919301873, -1.3950279503555316, -0.4045224604657742, -0.32898594976544376, -0.9035541782201512, 1.3597547799689063, 0.5707716661598886, 1.28676014182975, -0.7202748260335607, 0.24440759367716344, 0.8213267560873762, -0.5828142184945672, 0.13913089435449316, 0.44164566189053356, -0.1556706215736535, 0.06386547062793506, -1.110969553975, -1.2119028629562867, -1.4471147191664975, -1.803675905864993, 0.5035751367794178, -1.094555043598444, -0.490573003107965, 0.4553592727832197, -3.734604655331596, -0.31921514118486366, 0.7342077105902054, -0.2942882304109128, -0.7224127498640672, -0.06543335827974094, -1.313365591660388, -1.232143401692036, 1.7756098621625196, -0.2585025524785578, 1.2686091478563615, -3.3212026032667024, -0.11076875400804553, 1.167018492691298, -0.2708212881385461, -0.8780839981053702, -0.7647375245827638, -1.2645568108708836, -0.6330075896980762, -1.0693136523791484, -2.4954041011230577, 0.3792935170030115, 2.4036184050990532, -1.648532538660763, -0.6803114169492392},
    {0.5268565313092444, 1.6852271117467053, 0.8848550113101067, 0.6526659963099252, -2.0609909973705256, -1.036017385199139, -1.4684766973167134, -0.32730706252909403, -0.03107338447958401, 1.5747137319645803, -1.5525369045041255, -1.0260970480791507, -0.547264443578402, 0.6239736931290021, -1.5699632981903369, -0.7055823195718647, 0.7209217831500675, -2.3778310638985998, 0.707009576190369, -2.4995966084008225, 1.1213315809809785, -2.154015210241133, -0.2631988116594084, -1.4048526348546895, -1.1575999607527645, 0.7467884346394487, 0.7601824528689687, 1.2707709572629011, -1.517214413690927, -0.17395078613370105, -0.1037379741434664, 1.199466683133617, -1.2393988047911126, 0.2027063772854714, -0.34861453300342743, 0.07142899057872838, -1.8258620876006266, -1.515825275391819, -0.9629151516754425, 0.5468474553295972, 1.0856184204505663, -0.6054150167675452, -0.36627144170161374, 0.4662185130342628, 1.3584190598927361, 0.6435461313602651, 0.5237215532565915, 0.977864259998354, 0.433083628000345, -0.9431908324273118, -0.3200897185864711, -1.222147488585818, 0.23330915709399275, -0.26713364421923314, -3.143872222542231, 0.17763571384968865, 0.7492755872593315, -2.4691547424932874, -0.2673313534081423, 0.2602618873548517, -1.1513459989460497, -0.8424723814324308, -1.3130866175067648, -0.3112589767065503},
    {-0.7095308348137328, -0.7682275336735916, -0.06830812895685172, -0.5762214053107275, 0.4259857259747724, -0.1478964518810338, 0.3864755076095066, -1.503925475160511, -0.20656659795739504, -0.40097378541595147, 0.9440228924401617, -0.17220717772101105, -0.1016534462370262, -0.530440477537921, -1.8841221378299824, -3.046321996302199, -1.3489771977970813, -0.11380705689092153, -1.8041300745625366, 0.07354359845234994, -1.1607109311258441, -0.8330913336547803, 0.834813720979812, 1.0357625100158465, 1.1085632616381984, -0.5668748527759914, -1.4813386720949877, -0.9846300959148697, 0.3149541719575223, 1.212616262076482, -0.767634790475926, -1.6156216143507292, -0.5947735895287131, -1.200571712205632, -2.5309943300769433, 1.4949168963052224, -0.9192060790448302, -0.8546937569141164, -1.7437739987071763, -0.38939692118529395, -0.8706348369545476, 0.9859708829992083, 1.3397047532197779, -0.2563757654741959, -0.79469018890456, -2.3584438264228575, 1.0945167918309602, 2.207970836479542, -2.0730453062081047, -0.9833359182099068, -1.4324339913066406, -0.36681950457507817, -1.2460730140015692, 0.8696042104115963, 1.5558300299292884, -0.7696434083976244, -0.7707873857899125, -0.029639621856275458, 0.6798291004077309, -2.1409093169276683, -0.7360072966240483, 2.1716163200443552, 0.2419831542560918, -0.5169746844675119},
    {-0.9919210106223285, 0.6558941491354352, -1.450303166715271, -1.2183894442057122, -1.0611878474041057, -1.8004861410653001, -0.7960528767982868, -0.01377840734097123, -1.3178378923684906, 0.5767163053928703, 0.5877696744668266, 0.19994882689490562, -1.870829340182501, -1.641271696789866, -0.9599046826012106, -0.8330364271316427, -0.11914525569643235, -0.19358525439906038, -1.2981726733359487, -1.5660047613103272, -0.41267435720554463, -0.3042099128587057, 0.17843143068676776, -0.2597041735653995, -1.5851547368317649, -1.1280102661978355, -0.8704306966736338, 0.32771263400819034, -0.6292511181861848, -2.0283028111598025, -0.6496301845150192, -0.9176622912729098, -1.430919311194311, -2.344506283969479, -1.2769404225117293, 0.1994546863171748, 0.04689676583181853, -0.14004683157154282, -1.8740550913327472, -0.40027059488059297, -0.49894316903352787, -1.0398815493485383, 0.5079551717615324, 0.30632759543523674, -0.6084297632045903, -1.1218680497384543, -2.043720785479777, 0.030662267047978864, 1.3944831961185233, -1.5121964409278301, -1.1512192641236028, -1.8412575985407293, -1.4898187871936892, -1.1475573279737106, -0.4918732498470406, -0.816388627413227, 1.0637207337379646, 1.3687707291741462, 0.6225419769830971, -1.7752137906382115, -0.8524923692401116, -0.9823339013863874, 0.06750128524505422, -2.1378788663786294},
    {-1.2308641101213524, -1.314669812672283, -1.9941371103005017, -0.7912001380674062, -0.9887746922762178, -3.3145389992884384, -0.48482659974890135, -0.24960759066357052, -0.3654898020720789, 2.644980216217702, 1.4353191392229867, -0.8301962394678007, -1.5252808998522613, -1.1152516771648666, 0.45629530370754157, -2.5362721663751198, -0.554138120018707, -2.9408417801518136, 0.5865730044872376, -0.7310266168753768, -1.7712624173623004, -0.20569652647016226, -0.22543886416685718, -0.5579405169061044, 1.457969316510883, -2.9242869374337914, 0.635716609489892, -1.4377294119892128, -0.6686990543539373, 0.6057880280094349, 0.7849093030355435, 0.8555085848240617, 0.29204464129214275, 0.7747776801756557, -2.9754036920632054, 0.5373009502069633, -1.4434026653456937, -0.22699146935897746, -1.7990861603977588, -1.5584737940706181, 0.6323405506550124, -0.15032971611279064, -0.16462734295186635, -1.5827017483108714, -1.1385105583618715, -0.9277503166859629, 0.927339107871068, 1.2985445553362953, 0.12273830768631612, -0.8432133044506022, -0.6885040435752577, -0.3063582662217009, -1.2149515379998534, -1.170055503670763, -1.5506707268913673, 1.074680580931032, -1.5113056737344595, -0.3452841794074578, 0.6351858309481168, 2.136091427832836, 0.07034420393871342, 0.7079343000020892, 1.8318822220198798, -2.351513767428343},
    {0.636743662106353, 1.3448249903772251, -1.237561222469684, -0.8793642303939114, -1.941282322581873, -2.334359970092701, -0.7524397146575421, -0.3611999527636888, 0.8151353405264516, -1.8109660083158317, 0.8530548742923245, -0.006596868357395686, -1.6433277368690369, -1.206428698311076, 0.6488401138718016, -0.9666769046715574, 0.08141911898759838, -0.6049474821691505, 2.4826665156555627, -0.37977185316427753, 0.4478273182517321, -0.3798715076202324, -0.5358258324667481, 0.19406439786735558, -0.09346038489221432, -0.7550378838143312, -0.8395260785891389, -0.8756034253257682, -0.21972548592530014, 1.0805595396262169, -0.20718802770632894, -1.0032272198316043, -0.20094814470187322, -2.7831301602722682, -1.2517611820015673, -1.1888504364033177, -3.0275485063331558, -1.0302161631256623, 0.2720307265923059, 0.3563780718905378, -0.4058403414765947, -0.3798658647429052, -1.7889996740821437, -2.4110283291839782, -0.3045285823645256, -1.6922875599246285, -2.0024702100174645, 0.8077529864444513, -0.34741829801153723, -0.6431806881321009, 0.539360512474179, -0.022997759810109035, 0.2932228453719306, -1.352254197622839, -0.8615707746979135, 1.0504000142019996, -1.662398322876304, -0.4065051408261538, -0.3203391573399683, -1.139189048160791, -1.1307394363181835, 0.11323428221758755, -0.7550644534026367, -0.8367055597790142},
    {-1.3920120165750516, -1.449575035068255, -0.06479846543107758, -1.0105573474282297, -1.3000312606479452, 0.6137298378810042, 0.5243427319857831, 0.44841450916918335, -0.9325914243709592, -0.004913066103115091, -1.3229808550403388, -1.1065695224291943, 0.6674594222980247, -0.19836541175230138, -1.2262878788920153, -1.8691743892188255, 0.5890806477287432, -2.5267991926504227, 1.5860611975615806, -2.3158277127632396, 0.3261319290812096, 0.4716408212147762, 0.12739525815280286, 0.5563370333438511, 0.043431062678256804, 0.15142091586910572, -1.2492478227998138, -0.40840876861585723, -1.6275020531383844, 0.22846399157415279, -0.024232867052694354, -2.3161079768525497, 1.1137568227319152, -0.5111425993165157, -2.569795856892448, -0.36416007859414756, -1.04576887891561, 0.1508469784728065, -1.6238926899687638, -0.7979817004697785, 0.5920319214227783, -1.5074819054370303, 0.13635591757591456, 0.07893576067577128, -1.70556704818544, -1.371705470042332, -0.9986136323807837, -0.6324368646647386, 0.25575642711280816, -2.118759387483744, -0.038723990192062054, -1.7143838034365118, -1.148808286473061, -0.38860078243352353, -1.6376174689684009, 0.3449477762496797, -0.5036916410130968, 0.08050874125853112, 1.1412624144091585, -1.4674372254703765, 0.6919428935121452, -0.04915362694738982, 0.3604026014414315, -1.3028267646185163},
    {0.13599455737475674, 0.5313618432464493, -0.738394932497077, -0.15343151925991574, 0.6351265561491152, 0.44754336545690665, -0.7032387176633684, 1.3557079017442422, -1.3310174691290406, -0.9733136894615093, 0.1446942629092247, 0.2047758104915985, -1.2896143587093993, -1.799762030513584, 1.034810366892727, 0.5859693653235789, -1.192800403490615, 0.47654955345804106, 0.8622942801928096, -0.8644671579482665, -1.2494934434628715, -0.35835024576137664, 0.4508988439715794, -0.41219426243723745, 0.00423423678800143, 0.2887064969401806, 0.7564233234066668, -1.1148548188951877, -0.8579908878543394, 0.20699257282734426, 1.4569631427164065, -0.11918918219983529, -1.3392966282476122, -0.916587596604649, -2.075071214328351, -1.165019704121895, -2.6452052683222194, 0.36951869667503906, -1.277215829281869, -0.9503123855409733, 1.7212561737878957, 0.9080611213485477, 0.7297136171806727, -1.1586204580902641, -0.3982683585727043, 0.6574029191079811, -2.581997053558084, -0.5624166411539064, -2.3090937227919293, -1.0412165346338729, 0.38288455212101374, -0.6325156486026431, -1.138867359204986, -0.5529046873465356, -1.2777153818637976, 0.08187398345547703, 1.427227585959244, -0.9705592357610847, -0.5616147576588196, 0.3486711231674888, -0.445339113565446, 1.2980340644533557, 0.11041332187190245, -0.5944001076908428},
    {1.9272459049383515, -1.7006582802648758, -1.924746454416986, -0.5642288332845667, -0.5722089993975381, 1.3168274951889567, -0.5124568343674308, -1.7665416919493167, -0.4507934847566062, -1.0132985064360298, 0.34252376765376913, 0.22765906562744898, 0.8116345238383721, 2.3126441933991218, 1.094332540990129, -0.8111468581796794, 0.49429805355036904, 0.438874268327916, 0.5602537690138106, -1.0007880322374685, 1.798713476370597, -1.3254490738791969, -1.1618742785496263, 1.1872398988087243, 0.17283070268796455, -1.9996951142885517, 0.04013332403348006, 0.3787699386906534, -0.11439794582359457, -1.8296681815975415, -0.1116788734051339, -1.2321776840413157, 0.5578626908059975, 0.8357067576257967, -0.5007421723043065, 1.6295075157356769, -1.470317159727452, -0.529750032585053, 0.7468648453170398, -2.069714333516325, 0.6566011171541684, -1.3224655899787745, 0.4412489255538768, 1.3468507473408537, 0.36529177797550966, 1.2758845522056632, 1.4308571136226829, -1.4006935575810722, 1.1539028763166665, 0.4864299425364513, -0.16725481396771819, -1.7312166845036132, -0.388060260329166, -0.07396704292338807, -1.394583210296974, -1.6018193041577344, 1.0011534461468323, -1.3037074826296458, 0.9626595730032189, -1.1215025058199484, 0.3221715874776456, 0.6179084048531017, -1.8561775769469433, -0.7550264703376213},
    {-1.5529325510635335, -0.7394804554499325, 0.29778334260230294, -0.5555757608833732, 1.6881623475790417, -0.15042816533699802, -0.5110683879607401, -0.631428144497174, 0.44110010557918955, -0.8986370679991679, 1.1901291082827061, -1.225444321294638, -0.7120349744994587, -1.3058275895620985, 0.4629481462010601, 1.7756406758850365, -0.16455104371679896, 0.40052538347770383, -0.47828972889051136, -0.8680763488836243, -0.412210569879409, 2.25140053021344, 1.5434483883486927, -1.293066046306795, 1.0909165765849798, 0.7279274895209142, -0.6328353027774519, -0.4871302129917868, -0.890641837296746, 0.03615425330011628, -2.651351156750861, 0.8408283044434763, -2.0031079763092894, -1.1360991272858834, -0.282045127062923, 1.8149851951538447, -0.9514109245454572, 1.1881081983223392, 0.4603061836008709, -0.7589826459988137, -1.0350210191128923, -0.1254220678604, 1.5779726034027124, -0.02899943425041361, 0.9236384349607637, -0.7706172095493681, -0.24998359384816762, -0.787498316381268, 0.4858676528482788, 1.1795960990219032, -0.10109855011620672, -0.6143352313558719, -0.6293080983951711, -0.022331279670144307, -1.9560992380639004, 1.9505326258167028, -0.564305945458737, 0.09516863880978682, -0.3597831611054216, -1.208692405444531, 1.1341202266187178, -0.6176663528723729, 1.5400916562573514, -0.46761777163871127},
    {0.6997463112544596, 1.2422234120111528, -1.3882116004367797, -1.0744300445693995, -1.6853106814139354, -0.6317910397334716, -0.24438755632172102, -0.5436331741826654, 0.8646389538155943, -0.02661991078621102, 0.045336298928922256, 0.8425699214623478, -0.6996699306773678, -0.3896372179210147, -0.16533279565740616, -1.7465519201390498, -1.8577053424079595, 0.27742373358421263, -0.28952830490126186, -1.63410804516094, 1.9168534098905996, -0.9692313076817455, -0.5552994933727885, -1.117365688246239, -0.19681819252448557, -0.8945037730737393, -0.9161060566139198, -1.7468335897790324, -0.7412481803370099, -0.4130230310797498, -1.2410336499474022, 1.2836241414284049, -0.4745390336954065, -0.18355931995756034, -0.33863207012323193, -1.61943849658653, 1.8742744466971113, -0.3649902750234118, -0.1464229900999093, -0.9499000560251482, 0.8208401556857279, -0.4560452705196514, -0.6297513299127256, -2.4137699967009008, -0.5886459305317947, -1.9705599915935321, -1.5288987549686912, 0.5568133930125703, -1.1951383102687037, -1.5915722509428198, -1.0676939313161997, 0.2616169582198675, -2.061384701089792, -0.5862679331708194, -3.2339801370820003, -0.9439196594629292, -0.5025619777595088, -0.16695619484050994, 0.24747849046720818, -0.5782987703739325, -0.7226464925761334, -0.5943377822801588, 0.4201688966490925, -0.4037233794577638},
    {-1.2341898806114262, 0.4893627735712356, -1.880474438554671, -0.712887924990286, -2.0536436534237317, -0.49218704491517923, -0.3931424127042074, -2.1257804025215896, 0.7012706713557131, -1.2988544871854606, -0.42002070401786235, 1.7994500793256696, -0.24483057925588758, -1.8711203782501298, 0.7813339818687027, -1.0257218226813882, -0.09337942915985437, 0.04571228526007422, 0.00928850334904784, 0.07053012326823686, -1.4395691774845805, -0.47835698971991875, -1.6324668203639419, 0.5825368985089464, -1.6910233272734616, -2.4521053345092563, -0.6836397488326544, 0.7000235722320849, 1.1045778624466898, -0.8979160158974703, -1.9171078133428312, -0.5810961052120543, -1.6995271046163383, -0.315876061158438, -0.6677668271135667, 0.7296778951180142, -1.5648258271635596, 0.36312439259877033, -2.4130756483116675, -3.058532790480753, 0.9053820860056495, -0.2825868590760393, -0.12760723160324466, -0.16893868337370807, -2.006868233977322, 1.2609494154524117, -3.1562551607732066, 0.893059992927789, -1.9740514712943877, -1.5997137927681315, 1.1985997323331299, -1.832248156310812, 0.21766276299214946, 0.3739857421756226, 0.7356469118622457, 1.2860813639265711, 1.0487149649839989, -0.9363646662230088, -0.3987176477015856, -0.4414718237487096, 0.5048512436636464, 0.6532758470802474, -0.08384323747480225, -1.4867272058614063},
    {-1.7494539380679497, 1.1574984492738098, 0.5160843323841807, -0.8718585591564998, -0.0466162487043551, 0.4653334347504761, 1.1424932457928927, -1.4461461542240883, -1.404487065858137, 0.6243644639824588, -0.25990157455471696, 1.7604799419706685, -1.945785906490168, -1.395705534768664, -1.0733457987767554, -2.0308532351017243, -0.046106066367774506, -0.6032749703187122, -2.5528829831003295, 0.8727267155011499, -1.0068528540562516, -0.2535634202286119, -0.38025075696066035, -1.2172736089503369, -1.2643955249978263, -0.9492016312956644, -0.5734139071489514, -0.821399477510541, -1.270089547150986, -1.1736628735674899, 0.3323757427671624, -1.9835024201790292, -1.87933020973375, -0.54064549936406, -1.6856655075680647, -0.41963221987162047, -2.6574452811323415, 0.09042491883356496, -2.1568510086806207, -0.9604582246241263, 1.3830955634238702, -0.2518994910956327, -0.6582880233279432, -0.8376147864794996, -0.15157249076335533, -0.9805039362118241, 0.7142640832448786, -0.28713732420444493, 0.2819145382709215, -0.4681278398469556, -0.3969586108414305, -0.9590271945301725, 0.10808683194137657, -1.5536942522217652, -0.6850776842401493, 0.18354678028219779, -1.1673188505121488, 1.0409849528772677, 0.09801225238110406, -1.3499346044719995, 0.9546939324743382, -0.9777095070368493, -0.22057076934656872, -2.0412386966204266},
    {-0.5474829348100763, 0.010737361898305212, -2.067499196897055, -0.2949049912475726, -0.8993691185318765, 0.6565346779177349, 1.3640571392076708, 0.42444323729221384, 0.041995521953720395, 1.4710407291855123, -1.5807548994692608, 2.596299468031599, -2.2157792500490356, -1.72273196498688, -1.1407936426614091, -0.48061088582593303, -0.5378596731844446, 0.8760945594627224, -0.4344845401602297, 0.45875879210834575, 2.016097195212429, -1.2445950904255165, 0.21656922280853566, -0.6868850375147925, -1.212620985908118, 1.4236112914245438, 1.4614516214137534, -1.533827446376238, 0.7961976352755804, -1.8729254667806965, -0.9154588803762734, 0.02786462738477172, 0.4750729402356145, -2.287442612954471, 2.2143918320744715, 0.26487450671923135, -3.0205668245735016, -1.6653611144052745, -1.0924504885502806, -1.8572191109193488, 0.7144990477475078, -0.5984979970138556, -0.5871319357578966, -0.13878768299874542, -2.8111769230240964, -0.7813048782914553, -0.16315105413863004, -0.6282791175220573, 2.3943644886217936, 0.039137463631978536, 2.1206956577029508, 0.9340691157790748, 0.238030891341043, -1.8712803151495818, 0.6867034427692659, -0.5319153350357912, -0.05641222648768616, 1.1392217272636205, 0.5031640534581389, 0.9187296185577682, 0.9533254200485789, 0.9035084623099031, 0.6201551256290929, -0.5721162692831423},
    {0.8070965661612189, 0.14469740283669053, 0.24933043436319133, 1.0208756039078863, -2.394970089917503, 0.3808071626529098, 1.1169991297595774, -0.35805866242834145, 0.9143557130116946, -1.9123801323970278, -0.33818145054202725, -1.0864226034239852, 0.23087093171138645, -0.27787335693039134, 1.1440805509219347, -2.502833936123152, -0.9651197355915662, 0.004642953270106684, 0.009364849364569989, 0.08618152342965761, -0.25603660515096105, 0.34641636023884315, 0.6491549680021739, 0.057918463702843044, 0.6181741498434525, 0.588367646299016, -0.5527852800537305, -1.2131059703081517, 0.710410749905807, 0.49827331953094345, -1.0402931260827317, -0.20110783141731367, -1.6753341831622888, -1.4958664237515311, 0.5362713162624644, 0.7674962909228783, -1.495940232265717, 0.5298742043068952, 0.3682697075104719, -0.6433811329435188, -1.0813608819829346, 0.8388732289842505, -0.0015037601378650662, -1.7048513043425524, 0.14572451129794925, -0.689173067944314, -2.2433010252083556, -1.521601145647053, -2.208179812665551, -0.6988125702613515, 0.4604733554617073, -1.4651824663860518, -2.4833957009557337, 1.109263587858716, -2.552174990859849, -2.052421058067822, -0.6951388910380745, 0.15329184210044292, -0.5537445645602045, -1.9355439781675159, -1.1412907479636465, 0.6483255074551186, -0.47346143373518906, -1.3651322502601033},
    {0.13681786032333687, -0.6951521449378271, -0.4049228490380226, 0.5504342038695746, -1.2978137991279382, -0.76828379985629, -2.133568027098654, 0.13177944351448653, -0.9027987450307395, -1.274494886960862, 0.5644567666239908, 0.007228868630192213, -0.22584328634628068, -0.7234022569953401, 0.5010234116064967, -2.42115008649643, 0.4744172464445243, 0.582224621965177, -0.5509757309909219, 2.112644940308498, 1.0816413866180459, -0.8108636900224471, 1.9699472478653193, -1.265814179955978, 0.6642948235978745, -0.540119190798843, -0.7835042565757886, 0.03410924698785462, -0.7630437415537168, -0.6358941496589715, -2.1100350337144307, 0.17682847235501892, -0.4576257215103567, -0.21042629248951567, 0.3272103946090652, -0.11785948570586018, -1.0453680013914834, -2.7686544270045497, 0.5871716603586395, -0.9798578164434314, -1.08691244514434, -0.400360127905261, 0.25428797940132875, -1.0191335486224482, -0.9836580197872868, -0.22225467792430556, -0.6298727612503652, 0.5448912488543731, 0.3690103876448133, -2.4616494591739433, 1.4702891097087758, 0.5574458616390381, 0.06995379733701285, -2.0859874910195573, -2.2890519843350217, -0.1497884900901387, 0.11005375625823145, 0.6297087594991937, 1.604700971798722, -1.8008797096790754, 0.043073815629235415, -0.4900590860635812, -1.2802337986983292, -1.3678257759082713},
    {0.843883101988923, -0.49223238673923553, -0.5601267182065194, -1.5775932286342569, 0.9691490419998663, -0.9915323265847216, 0.45751207292183704, 1.0257099888907835, -1.105180900330807, -0.6953375954618042, -0.03462981330528942, -0.431365752838933, -2.050494088928757, -2.131935609762241, -0.35964876158703124, -0.811269272155091, 0.11854022975591282, -0.29448688207302304, 0.6576014399704692, -0.4027894567001435, 0.3754552004372433, 0.03795854344670263, -0.8149512352709506, -0.43176534966846747, 0.23813217458978897, 0.4329279074526386, 0.181096218137081, -0.16121600495159946, 1.3306094701236268, 1.0549249917018892, -1.2157790880892898, -0.4300758473917184, -0.21520264090434907, 0.3376586721126384, -1.3973292350494437, 1.4008698056526068, -2.3234368190741104, -0.8784001551997547, -0.35849052689509575, -0.6579312017439876, -0.6268373771391779, 1.2408791984258634, -0.5548448979361466, -0.5813940392047815, 1.7932916077896655, -0.21267488814965357, -1.8480170364092205, 0.6894946883916947, -1.0300146639059025, -0.5824697458450647, -1.3029639961052475, -0.9061466161269999, -0.1658246088370535, -1.380276206742184, -3.3963756344224025, -0.031929516749790963, -0.011252317109449152, 0.00023512692465800432, 1.4605407465274098, -1.0462730092723311, 0.6296176621777904, 0.9920549261523633, 0.5306094417369054, 0.427783007406795},
    {-1.1893810631721038, -0.6929397008887457, -1.5657757790572573, -0.3230267575066778, -0.41440742183523144, 0.728779835439992, -1.1118537352712037, 1.9245578530127898, -0.9913132543758251, 1.031454818367456, 0.7604821223879262, -0.7686507128507047, -1.4167323558589957, -2.332629925932351, -0.47525434696010266, 0.3630491274637109, 0.4827964748213208, 0.6821346329635131, -0.7733818524872322, -0.601722434128748, 0.6636037729084954, 0.46623643911457213, 0.41308107774243397, -0.4892040511092675, 0.4311843600364395, 0.5517033198296414, 0.34303537885175067, -1.5138406355164653, 0.061290188382136186, -1.0854289124595418, 0.35644361082090226, -1.0315176189378616, -0.5283969611003068, -0.9404066288164866, -0.8752770164530292, -1.7059768440039758, -1.9891482331662926, -0.8283558115982128, -1.1360608908560332, -1.5136178614939286, 0.7963253142043097, 1.4186594084871884, 0.33264179185881776, -0.7271782334786944, 1.9612913453176868, -2.180423028251168, -1.5098861514952449, 0.11159557847185214, -0.767951813947457, -1.7987247235034305, -0.9620716530766583, 0.12648654676669366, 0.009641358582732224, -0.9404755948865258, -2.2745808501799463, -1.4153165142924928, -0.5059191779367308, 0.13878441581144835, 1.4458815734437098, -2.0441597960948386, 0.5766387501053606, -1.2780533532746883, 0.8506681828507132, -1.1924961818045543},
    {0.07115032977656068, 0.12056339305447719, -0.8721619477149647, -0.46052547076920275, -1.6343915551617962, -0.9503146128316226, -0.06500679452536216, -0.6951387822801922, -1.6755808544884123, -1.6943760945525217, -0.46490497260077834, 0.40142808559866416, -1.0569720241040266, 2.137412049059607, -0.3708115531372399, 1.541171072102199, -1.745719143490088, -0.9319206038018878, -0.6680929297202478, -1.3043313183134404, -1.1504647685745548, 0.4884497807765179, 0.9725472157029654, 0.10571654423152167, -0.38488969111629484, -2.421870990521735, -1.1289508549822564, -0.15712478372442365, -1.442188576538974, 0.014314029739678255, 0.2676460579074618, 1.2884765894624384, -0.36101730504254814, -1.0078830908188294, 1.811328801815608, 0.29406356671328127, -0.5666995408653513, -0.2394996834410388, -1.1297426967287387, -1.5637556073762464, 0.8689826915610566, -0.0767906461786234, 0.4193668720197136, -0.716443357569877, -1.2031361763778983, -2.329303999017921, -1.5514394428576366, -2.128401712386353, -0.018182639678433782, 1.0518329816123824, -1.8340406263975468, -2.4375550299477715, -0.18064199046361384, -0.034659091821456815, -1.2589227238464034, 0.04357478454840345, -0.14008552708691455, -2.4444467893930253, 0.3676028929212216, -2.5877783600734343, 0.15937162713383163, 1.2485464725175213, -0.18984621483408737, 0.05780041529703231},
    {0.6492846754067683, -0.438016850524814, 0.5972050516328294, -0.6285777680192792, -0.23113565246976087, 1.306757037946852, -1.6199252783402796, -1.2006110427137944, -0.5388422129548427, -2.547538898231838, -1.4593259806238323, -0.8087987978558646, -2.6194075191234996, -1.277967582779489, -1.890654904722721, 0.35120481613447047, 1.581552332360716, 0.1532699796793009, -0.025596673968248433, -0.7525179906542286, 0.026576751410987122, -0.8300368399220441, 0.13463041346152754, 0.2263506836740238, 0.5351669773516168, -0.5614201330959143, -0.7301873498491056, -0.2687246190618609, 0.17645357201735362, -2.469524682054389, -0.09767762861210949, 0.917226293620778, -1.3018547153543838, -1.9789777550352556, -0.2368687374831126, -0.4322630719280441, -1.7374737364874615, 1.1211665560152602, -0.7389888750702316, -1.1141563123339135, 1.24366808996621, 1.061223325642269, -0.2501895310561263, 0.010430504498934835, -0.9891550522379089, 0.861764032415337, -0.5913040178023625, -0.224840222984285, -2.527888537557059, -0.4893746819350406, -0.9671224643097457, 0.4696914837175326, 0.7082901233216569, -1.6494444760913687, -1.642885515310461, -0.9668588670894712, 0.8259533774589608, 1.4060876391959705, 1.1513363577586637, -0.9915369328017701, -0.5633522994348642, 0.014445130068347484, 0.5267836659812724, -0.05114112011512751},
    {-1.857081271250728, -0.2207158657562925, -0.9136641136405703, -1.0364699306816418, -0.5177937801443296, 0.4429964168335757, 0.951165123139686, -0.039287311995072426, 0.18465154851834875, 1.0323242773996062, 0.9207309797337491, -0.4528907648472904, -1.3457874438752007, 0.5305276987350349, -0.3655964537889941, -0.25120961073347925, -1.0252249951477503, 1.5200830152848246, -2.0502663208019216, -0.21966956145989663, 1.1323716294583617, -0.26660156463063733, 1.2672694888943472, 2.4729257342628066, 0.524779915706833, -0.4669854462898903, -1.7162671604663946, 0.25580911856091565, -0.026768023442353923, 1.6828465047758288, -0.6067801697511002, 1.0284055579755482, 0.7614863906562818, -1.0613914948848018, -1.4371065535731042, -2.2379620923753336, -0.4745260750938718, -1.4177807171319117, 0.42892051325890485, -3.2853720839439826, 0.46686965674208836, -0.9068729192796133, -1.446658386781575, 0.1299742869816768, -0.1081529459769013, -2.188711229560718, -2.5769343445979285, -1.2526198991035131, -0.7216314840218075, 2.590091467387572, -1.177296587270825, -0.04778035162685442, 0.5443013103976851, 1.2616056945911627, -3.185782083815669, 1.0578863393755717, -0.5403441319985562, 1.4730161751334172, 0.6306112136646873, -1.4855044962649986, 0.6356410878364728, 0.8560484092292732, 0.9140253184494984, 1.1858124141275408},
    {-0.5744992464243599, 2.9795897926299073, -1.6185254706492405, 0.4421246919242696, -0.606303067150623, -2.3027048407505917, -1.9405661707765736, -1.6560080563956008, -1.280370004145682, 1.92263056161883, 0.9860303302291143, 0.198728056709484, 0.6930597075550287, -0.42737785014739293, 1.1149838088504997, 1.6782316568526858, -0.8298448744005733, -1.7239147644360917, -0.0715155177347127, -1.074655735114609, -0.5456640896091436, -0.1699699714108273, 0.341559842929769, -1.0216054028806747, 1.6179135542570862, 2.41249823128909, -0.31219213659571265, -0.6989276068938636, 0.6504636193795789, -0.973274575888097, 0.7497727316621533, 1.0149406786787825, 0.6229509554140813, -2.242525477475976, -0.19587219630158026, -1.2630476952281546, -0.9611540847728538, 0.23682340373021868, -0.30819913058568005, -0.2344389626581937, -1.6730803995817338, -0.24196263525330378, 0.6440041875212588, 0.13349495263812647, 0.29396798162841165, -1.3830307213123385, -0.40409003585623726, 0.49778271041494176, -0.7733337151327228, 0.6799025080752554, 0.7839651421567482, 1.161445736106656, -0.9442787645492025, 0.856978798161004, 0.3530118593631989, 0.07697565620061252, -1.8657894220350688, 1.1747804429024344, 1.3841811979687464, -0.5477481165657632, 1.8798278827060089, 1.347797741802733, 0.3681054399957631, 1.9636509763593166},
    {-0.41774008783898153, 2.076763987250285, -1.2636854745602402, 1.200610917426789, -0.04043180825217118, -1.5833900265158671, -1.0501650253428556, 0.8616632336555345, 0.7321809778285805, -0.2896571191847582, -1.0686281740081174, 1.1350196865316924, 0.25980384114390953, 1.7562915780312, -1.2712503645218642, 0.8014993104633062, 1.0978776916261632, -0.10267539433696977, -0.23250052665043305, -1.4223418857574657, 0.05231110894690608, -0.6454742094601315, -0.7100881544318826, -0.5025728596186084, 0.8578639147158615, 1.3460766777714734, 0.9710902870839339, -0.4716584164453493, 2.163281351020846, -0.6734789820565292, -0.9526283517219744, 1.2872867752995854, 0.6917697641985135, -0.5117873701055822, -1.037393275183081, -1.437425492273296, -0.8170736699656534, -0.8282537801713236, -1.4787935263587961, 0.6803227770086215, -0.031175755944947852, -0.4037079199084773, -0.5274443433122555, 0.6870495828866348, 1.1091951517712557, 0.7459226996347772, 0.08645745835680324, -1.02765578227894, -0.5964334363622644, 0.6786524581636202, 0.5139919069044367, 0.6480592967065757, 1.0961275903593937, 0.5887933162671452, -0.018959702371383266, -0.9756112643213951, 0.06149370112074878, -1.6556134386957035, -1.263872850894911, -0.8964866791382072, -0.5829760642362378, 0.41528149497169337, -1.9484947878512864, 1.152998492435382},
    {0.38332409663787675, 0.5941182362732917, -1.6017138857959063, 2.3106469617186187, -2.3874146800060263, -0.5047411616669084, -0.13599767702518423, 0.006540639590934629, -1.718937574093709, -1.5370561713326951, -1.0971395940970845, 1.8744187671356238, 0.5185326805213835, -1.399282424475508, -0.6158505344456269, -0.6597427453927697, 0.16532759326585822, 0.0885519800050709, -0.2744981388648109, -0.9226778579575675, -0.6385481439937907, -0.7580831578224395, 0.4469753666788566, -0.35992084837153676, 0.2853735593287217, 1.6638557402962915, 2.057930714715615, 0.6643275089253814, 0.563057578517658, -0.17384303261668965, 0.9601908807808279, 0.49830250447362456, 1.8139215886224318, -1.9239212778561503, 1.115593408002214, 1.2209284686697128, -0.5637719068494685, -0.5301967495472062, 0.02332705766708419, -0.6805648723397374, 1.3055580854152278, 0.5956422409526028, 0.6089220541534157, 0.4817509487311079, -0.64946065899867, -1.2997456417274271, -0.451825828257045, -1.1269574896158856, -0.83044150680587, 2.6098952388346857, 0.03890328596959334, 2.7606321316107536, 0.08524991302964115, 0.8365570698698181, -0.2684893830609573, -0.2737019749279088, -1.8352185850776856, -2.174116783572615, -0.5351806093534959, 0.8395076603890208, -0.12193158965047017, -0.2553346705322584, 0.41562669004153424, 0.635425535101868},
    {-0.4071786484792741, 0.09534989793172276, 0.6026741512833107, 1.2277418001325375, 0.14462243696148852, -1.3798932937781907, 0.8242863606151645, -0.1211646533459485, -1.3819870143789785, -0.5242314924778061, 0.4909287444461593, 1.0141661139542335, -0.4442222195444272, -0.5032640882466449, -0.7596386420008474, 0.9354300502782906, -0.10637525419684445, -0.02829179365097855, -1.6648902465168467, 0.4801435777349265, -0.3592911158664468, 0.7832049464564095, 0.1897583490383426, 2.2921894556489475, -1.7847737413002762, -1.0283750229991724, -0.8978231088505343, -0.5166117299760828, 1.2277835076276178, -1.1260264953542556, -0.8561808136573665, 0.4003526908869296, 2.7563816170429893, -0.2955621137263204, -1.5430889950214892, -0.45576049716569544, 0.4223444461319742, 0.028926690653465554, -0.159652075389061, 0.37152029587475877, 1.279498773710416, -2.339476534454193, 2.850158702181606, -1.4854610596223543, 0.12110537993220723, -1.1254545404686165, 0.10154736908870905, -1.0260480389419524, 0.6998689325153883, 2.3737535250396404, 0.5755277912103767, -0.5520947212791646, 0.5361939982659882, -0.13689584661832746, 0.10163715416448246, -0.8619498603243485, -0.04177923503761979, 0.34942814615703344, -0.7082971513370249, -1.7725590685633625, 2.1121512130649807, 1.1653408039054325, -0.30077111205199875, 0.3732284317946196},
    {-0.9865061782013832, -0.19402630563773277, 1.949402479430816, -0.3458138997214475, 0.057407011710319325, -0.8490216458477714, 2.1407285907962867, 2.0670144899520113, 0.32693443947953627, 0.08660929788797224, 0.6852721116053426, 0.02554712043802405, -0.1380712025179286, 1.6563354033393678, -0.26405179559300007, 0.8832464513580189, 1.1468382815547549, -0.1645381986582008, 1.6996730357808059, 1.3666111845632174, -1.2060347864324117, 1.6566140759541943, -0.971292493571063, 1.505031440139174, 0.4796135024736147, 0.8417903403070698, -0.8249534659195757, -1.4260247040594651, 0.965926667351769, -0.9892416424707954, -0.010667022922134183, 1.6641225806179463, 1.3267407935272606, -0.4851822590730501, 0.07284110066958721, 1.5177554268029618, -0.39152771492770355, -1.261538688960573, 0.8830603507294223, -1.211776259899598, 1.801690251016507, 2.3444613601153397, 0.14145799532763284, -0.16980981845815296, -0.9295986146156034, 0.429427917033723, -0.241914946024147, 0.36399881695704855, -0.504618426083488, 0.8717673045588267, -0.09507002133226734, 1.639015421595189, 0.8551132938087476, 2.556889652850129, 0.6881219561698273, 1.200006114728567, -1.1545858282708725, 3.0883477964949098, -1.278903319227434, 0.40773702799773454, 0.33614001270247074, 0.5117330595958506, -0.7574308490957511, -0.09244314867765295},
    {-1.148437437615266, -1.4243141836148583, 0.41553043707281245, -1.211106619099343, -2.7116763145448806, 0.034271641000480406, 1.8081329017328158, 0.6801957209270625, -0.34020186494116533, -0.5446037054405325, 1.4120805097350086, 2.996977835858864, -0.1947330331762166, -0.8393217811724235, -0.8288115730328962, 1.111473349969625, -1.8812970637983504, -1.549399273875553, 1.5262248652652914, 0.349807892421583, 0.5490004972711486, -2.1826542642463673, -1.2236942600975573, 0.1352875344790818, 0.9408773943716625, 0.6459881587773603, -0.9803389005182268, -1.462891273171278, -1.270849848191329, -1.1516295392900109, -0.09434132892219871, 0.6989318944266748, 0.003313965972043693, -0.3402933351472938, -0.4941992643350677, -0.27617849093532126, -0.05674733423007499, -1.8413895846475719, 1.2471354433421293, -2.003732173305111, 1.6339033254709867, 1.8191660528744455, -2.492361640098147, 0.0868512118756803, -1.2210083211279594, 1.2140982600877688, 1.191102517551009, 1.041422356430347, 1.7321598360956851, 1.5831495014869554, -0.409199844437591, 2.260751395404057, -1.1698639934356454, 0.19531214114942255, -0.9902777030050094, -1.6993744447924206, 0.06897030216112576, 0.43939980992865124, 0.6513564874712731, 1.5341833408239651, -1.329111283187246, 0.12117532435561663, 0.9036726735710391, 1.5206970385128837},
    {-0.5265766630088388, -0.6117933217508373, -1.6926526011758223, -1.480494196973492, -1.86614933489801, 1.2252542959271098, -0.3951734838158727, 1.2050817484924976, 1.6288303863631233, 0.1043825801020702, 1.390500027544045, 1.6002874626452293, 0.8154152899516701, -3.1198252225726257, 0.25953963957464077, -0.4560838671571815, -0.6867849805492128, -0.21221211338063786, -0.8318303782539914, 0.10711128528364083, 0.13880790198728626, 0.07711246183125595, -1.4073571283854212, 0.5203743822191853, 0.9147307026907951, -0.5839178004850262, 0.8497700474014485, -1.7392097031484097, 1.2807021079794003, -0.5041544610997523, -0.5545601615582998, 1.3253443906259674, -1.7660679560483266, 0.6266789821941973, -0.9835353121390019, 1.7601741654271092, 1.707901223114339, 1.5012084768368192, -0.18203296778579567, -1.1113495060614533, 1.1092665458218818, 2.694801812604363, 0.3213673663707861, -1.176716936765373, 1.649669471716939, 0.31616263665608396, -0.5309675974751911, -1.2944030586741095, 0.7578012765943206, 0.34992865614553287, 0.3025783864771442, 0.5196891984574536, -0.5709661151614501, 0.5238517589643998, 0.7681759787154289, -0.1773691563708292, 1.1060903243216684, 0.07322621375143096, 0.06302077744786792, -0.5550304806633912, -2.854737492452028, 0.49303342719960996, -2.0011617731768063, -0.39796651261057625},
    {1.0756147302564534, 0.325799837409575, -0.4467996940349892, 0.5411829947490382, -0.11650398034495088, -0.32782884315110844, 1.5938764112605615, -0.19136389962469386, 0.7984823847643016, 0.022227500994278986, 0.8770649269293888, -0.5292574092385055, -0.9551937158070501, 0.30186572345807977, -1.9314573197799472, 1.1059046444687952, 0.25558699819460684, -0.6588851135726784, 0.8063253828850072, -1.0733476557454513, -0.6983062469422017, -0.09910675684847346, -2.3870199563891417, -0.5941934343916746, 0.3561405222723457, 1.7176188893873445, 2.4594465819491007, -1.2585352522941928, 0.8680251084505837, 2.1294590591676945, 1.227955360952455, -0.8715808314555767, 0.6290877391919102, -1.5101007647979479, 0.3087321538798899, -2.295470961872502, 1.8740403436775563, -0.7685495674028983, -0.2678319967835287, -1.3171698681563127, 0.5207695088433114, -0.4816071545525026, -0.6528166454673745, -0.28285263107798647, 1.4679871991027504, 2.1006374047350134, 1.6735004353869076, -0.33173021032407624, -0.99533050203174, 0.7185225381548094, -0.24146269524314976, -0.426437010868224, -1.2200883742219588, -0.6170868608993161, 0.7142510098260548, 0.6211885409765655, -2.192040080877646, 1.2017972148565668, -2.323167168436913, -0.5854481705416767, -0.8998002602629364, 1.1524154910500466, -1.137929164107472, 0.41429341921140633},
    {-0.11935881856001464, -0.8943897277959383, 0.5562293071193505, -1.248138419437972, -0.6645314685155631, -0.14371578068226168, 0.6242508902376392, -0.6380261298177492, -0.10822555701591102, 0.2266238254596646, 0.3091334476693425, 0.9813038478963917, 0.8005631729370474, 0.0028369329098496027, -1.5294807186810424, 1.8703586874428961, 0.4500156282446926, -0.9244135103055897, -0.563980241540554, -0.5134131758590316, -0.6025427266037733, -0.35148529232772313, -1.2901242163676994, -2.2333960556405157, -0.8247909776962976, 1.223175013663563, -0.330424503136154, -1.935881074484184, -0.9250095571091831, -2.628430159461423, -1.5538052304151193, 0.5020429144196094, 1.2766077292790432, -0.4349699180634204, 0.14000609406632303, 1.2718074852139112, 0.18548568388991463, -0.22956520881880152, -2.244263468449932, -2.9922518851032542, 0.7548742232354989, 0.20114063776842794, 1.437173422686058, -0.46100567428120987, -0.6365114167710494, 2.5249977327352844, 1.1421375762931878, 0.2066829823897823, 2.1997777753735552, 1.0928147702914115, -0.48012175379949995, 0.7954934576105103, 0.671491289066757, 1.1962902532480466, -0.6279105010780208, -0.0740345825368646, -0.6873747587323459, 0.7596606472249472, -1.7907548197954142, -0.14668726860439327, -0.9214615215320365, 2.4739601023775335, 0.34088912390530196, 1.0543435088721813},
    {0.39059763252949997, 1.0513390605016433, -0.44420658890644954, -0.5054014455376242, -0.8670480613256057, 0.4248127216958405, 0.15000110141333922, -0.7023288155788924, -0.7473403180284881, -0.3761183701169587, 0.04135425414612068, -0.7613163282377245, 0.38615020841290176, -0.5125730873581362, -0.8894954343865419, 0.691473600476037, 1.2591442405412552, 1.5954011362042901, 0.7515971639886847, 1.239564275050262, -2.3596582212778725, 0.34119177127884726, 0.2218215656704668, -0.8736609051309125, 1.020532489121675, -0.08026551399774236, 1.7150672269922198, 0.3077623371728286, -1.0087601744867218, -1.9835790730925873, 1.1030361040811383, -1.7792322653547707, 2.4479245625164983, -1.5592663876480974, -0.03304649903202025, 0.12291067483286648, -1.6406601154116305, -1.823399436700556, -0.25744992918949927, -0.39157402489705073, -0.9838772985446066, 0.7716795997249583, 0.857072802602366, 1.5191562969614723, 0.019577733166001286, 1.1407585410981154, -0.17978603425294803, 0.8814494320908124, -0.4902780397037195, 2.2782404183403977, 1.028058935111559, -1.838253136903407, 0.17458788638223072, 3.7333906368390357, 1.3791442177778812, 0.03212081929279804, -1.9039067870096453, 0.3893376817736244, 0.7802361339326372, 0.2769311996067781, 0.18985195518689, -1.1249840429800875, 0.20220463588702145, -0.1774228725827989},
    {-0.41047575321107127, 0.6223340107600244, 1.0820667721280384, 0.1182425795659241, -1.0811381553327708, -0.041436105018231854, 0.8157330803055678, 1.2012251845752902, 1.172553188264666, 0.04779408299038412, -2.008669205533031, 0.06632505252259341, 0.6058642693405784, -1.430389783131658, -0.708109680867031, -0.9910432895397331, 2.5555985399531114, -1.0484880731682578, -1.7690567764679725, -0.932498848681439, 0.8158644928897998, -0.12975375265520106, 2.1643564821136265, -0.6511365949472718, 0.15610333090932382, -0.9502407509320968, -1.17642226659878, 0.23312335388710906, -0.48387059524003534, -2.117188349458545, 0.032208376342425134, 1.4065488582545527, 0.690253407249804, -1.0431812513607757, -0.22507176507122598, 1.172070172405829, -0.4865730195975518, 0.2018138706338336, -0.31915471097137627, 0.45463043434070466, -0.677949795814521, -0.35904410606343806, 1.786939753421015, 1.1831173573072222, 0.9966523551246693, 1.0276241588239923, 0.5095101013798029, -2.44116104774642, 0.37206814746288175, 1.7456666551656779, -1.0933209973915539, 0.8872981576289254, -2.5162346524121806, 1.3414892732149342, 1.823310216528366, 1.9581427556862436, -1.2044716274744118, 0.5653159786121027, -1.1965474147871302, -0.34073602579235934, -0.5183183350446227, -0.5951864110754983, 1.8677335481127204, 0.15255533447756336},
    {1.129030387751529, 1.5695842578669166, 1.2022379172228197, -1.3448721891855195, 0.33979363259548095, 0.0009172554648791819, 0.017111828143245265, -0.3124786048113235, 1.1834092123299798, 0.08325922352517488, 0.01570071533461361, 1.5628295128253107, 0.410753343612241, -0.1629727860571353, 0.9604560282502146, 0.3808161885921499, 1.6497974847032533, 0.22829719774328583, -0.28405938196797514, 0.5705398550795097, -2.9414571827287443, -0.26098970991025716, -1.0496650372339877, -1.0717511966190865, -0.5195344551687425, -0.6334478929779269, -1.0431991786934443, -0.9313005907507566, 1.0526305101343818, -0.7699371265431784, 1.4575936806829692, -0.3475457542278991, -0.09724549830415243, -1.9250282829170533, -0.4145399275628788, 0.027066939173653694, 0.24225472070008222, -0.37440447535375093, -1.5305661465145328, -0.3347708205755889, 0.007913775826885712, -0.09367558909323456, 1.120392654050182, 0.20911245659260005, -0.1743305673013403, 2.270776663220754, 1.1495223537411814, -2.368725088417563, -0.4952440533042593, 2.40986397042183, -0.6847729110022764, -2.684218940374233, 0.6487146415313542, 2.3610973051257105, -0.2971821572672404, -0.3514936746108788, -0.16889594071442707, -0.3467628695408679, -0.7495783942942538, -0.484678167157661, 0.00988976900456251, -2.1337296755638464, -0.9828112932314241, 0.11286395986755259},
    {-0.7226337149253522, 1.79474392571294, 0.42002436696413364, 0.22064455769845692, 0.6483840962408509, -0.6229721192836297, -1.4990747810234704, 1.570189581897417, 0.07085844102589217, 1.3467223517684355, 0.4739048568555811, 1.2479387509028794, 0.18981123923389673, 0.46626326484581476, -2.6950426598135517, 0.09262263694733655, 0.17646824534485384, -0.6219834875799095, -1.2490550166479117, -0.10775305211265093, -0.5768251261567042, -0.04869644377423156, -0.3110892658399577, 1.5710428327492578, 0.8445565125905191, 0.5758009299316086, -0.13258409725853298, -2.047490249597824, 1.3317228351192543, -0.7165539934676731, 1.8731144340630652, 1.1073269532332688, -1.5913176853150124, 0.584530183137582, -1.3467021656195914, 1.5896314051600318, -0.5068661873536703, 0.9920611007436871, 0.20609291270925614, -1.536740142383033, 0.5534525809274067, 2.71796703664849, 0.5601699876899826, 0.5559091750902008, 1.5186895762546075, 0.5278519551819467, 0.297586350436999, 0.03981820175199293, 0.47949246883317115, -0.2699628434344314, -1.2756984470623856, -0.8459100531048181, -0.2977319878476414, 1.3893717306091784, 1.7217217306582133, 0.11960514029742143, -1.1988291612791635, 1.2789737772297254, 1.6779648172672552, 0.7028925241684034, 1.1870226847226695, -2.6977037468168987, 3.7232727042049367, 0.34192481915693484},
    {1.112334510574239, -1.55928857125255, 0.1946366821119497, 2.0016668960655424, 0.24509911963523362, -0.4083946498667707, -1.3096826729473845, -2.0410457885690296, 0.45367669916509296, -0.7324644927792867, -0.4543458268170763, 0.7063352273186366, -0.6615056396926379, -2.052877428852088, -1.2864718034437372, -1.7886166830846084, 0.9179127229236891, 0.23630640170955722, -0.1534950611526671, -0.4576106784048395, -1.748099359081151, 1.2671728890111282, 0.09966190267925955, -2.1428192577834553, 0.9364619432312695, 0.1426340107270819, 0.7492359613389821, -0.5651300865909511, 2.4437654650650638, 0.1865929084853099, 0.46897535481669617, 1.0132473417396266, 0.04445154133129726, -2.54545543935612, -1.004831065728276, -1.0494517062483586, -2.2626547019567362, 1.1176579977450904, 0.573337221050106, 0.9390038921739969, -0.5314550212897811, 0.7591412670772401, 0.5186259876613034, 0.8750419668487174, 0.11496562543412146, -1.4354322842883247, -0.3146196868111873, -0.5869902406661203, 0.06325516452307386, 0.5415100871764701, 0.12454682285562338, 2.2276726150267976, 0.927205986072686, -1.0243406811536304, -1.1126298846843803, 0.47068413414348176, -2.063145628817952, 0.17434366125968526, -0.2320099929047351, 0.6693807307308062, -2.166449840161528, -1.20142577479895, -2.4313751477318624, -1.0153592521409478},
    {0.8017023250114095, -1.6930908386220138, -0.48773855435269453, 1.3176686918121883, 1.7972777932925204, -1.3167083759934448, 0.5407286817747459, 0.8381412215615891, -0.01750074689100894, 0.8858034189189309, -1.7043311709595133, -0.7511992654962703, 0.1781951048802619, 0.7913432869126888, -1.0320566925631034, 1.2060597388946417, -1.5372583099861097, 0.1250122285819875, -0.49222893912789273, 0.1710262672283329, -1.557558357759526, 0.9651760005517618, -1.80618477254771, 0.13427315735068615, 0.13081426240251912, 2.309067699445295, 1.4233050019487286, 0.6192943172009772, 0.9298566977198495, -1.9050281946116274, -1.1845958894760868, 0.8993281796259701, 1.7690196434632792, -2.8978553658016484, -1.4974339757166948, -1.3236526912912543, 0.4364182919177181, 1.301903920762012, -2.4336550233679053, -3.2815723455376005, 0.30514277709749243, 1.3625182546516568, -1.6493405157230006, 2.6428076994154144, -0.9037143448477286, 0.05100684959375007, 1.3862080514978186, -1.3223222814179874, -0.25419539101487404, 0.2582245929213292, -1.2229089043246626, -0.11491053712761871, 0.8594320946125006, -0.9026495169374532, 1.275842846301603, -0.151509996509854, 1.1725232688721425, 0.20715990726510752, -0.893685125392908, 0.131194389118487, -0.6193326039895422, 0.009468046359314104, -0.6619421215428876, -0.2626796621481801},
    {1.4208139268199549, -0.4787572719739901, 0.26714143391984374, 0.0688104840095773, -0.6830782354822994, 1.2224488316473887, 0.4827643510177811, -0.571189575262423, 1.0877395828351002, 2.4356251324952747, 1.0893559838638045, 0.6117685017725237, 1.0891941799015772, 0.3054392608433107, 1.6216432302848989, -0.6785249125279152, 0.3410358083802853, -1.3684377184899288, -1.6414380667100719, 0.4104816423576069, -0.4732265637214306, 1.1064200660666563, -0.22764831966689408, 0.8629258582298858, 0.8003499363676455, 2.501514766842959, 0.2637656338925838, 0.3528939400575068, -0.37803682792819493, -0.7736978364692021, -0.3744191084030962, 1.291170829517846, 1.446047361448814, 0.636453582033594, -0.9247101678049618, -0.7421269983001332, 0.10306489780864782, 2.2536145209280676, 0.1069239382425791, -0.8869755885053952, 1.89617847912171, 1.0192717537285927, -1.1228627714437929, 0.6204332331608019, 3.420578698627957, -0.07901728324156176, 2.768519461598431, -0.6264932363361575, 0.5794325439002992, -0.4884172590714386, -0.6152440036985763, 0.10078400646001676, -0.09647308175456012, 2.3041403326604155, 1.2478540541987573, 0.7259836015115085, 1.446395680009303, 0.33578083264094516, -0.13520503425404476, -0.3705580273810628, -1.5185289315947177, -0.42795430313810867, -0.5448720519889422, 0.9025904870945768},
    {0.718793720432909, 0.6696891904165502, -0.8312894438569239, 1.0409461533917639, 0.8757300644800815, -0.16596542490184435, -0.7402734045446022, 0.4123885395881872, 0.7939045810672264, 0.1679871286836701, 0.018299372399624574, 3.1979046290024304, -0.32542447920669276, -0.418889460680624, 0.9192772624028666, 0.9686748091683853, -1.2728755508196197, -1.2971406668467782, 0.047245554146465835, -1.2450170012094481, 0.12145061479839132, -0.20719813109315488, -1.299147674773664, 1.0841879825497345, 1.0951693411408039, -0.01936604825952394, 1.8058139174247898, -1.082667832549643, 2.5598602967070243, 0.518683349975662, -0.6409089097623336, 1.541121873932282, -1.1947653136238274, 0.6241706098024693, 0.8109422460191044, 1.216398953412111, 0.5518888827210038, 0.8987275490808128, 0.05929642160823911, -1.252047649847021, 0.7710050409045807, 0.22993325056230793, -0.2193478138811337, -1.609560446730209, -1.2209425474195217, -0.6086199132972577, -2.168884313599553, 0.053540882676400565, 1.7645964374882228, 0.09889405923667949, 2.5380010714648176, 0.6182323779200762, -0.6136965619553718, 1.6336671600398942, 2.390815615280827, -0.5572425963568729, -0.2734530194202779, 1.8228413407659692, 0.16315159645102006, 0.037867207446242925, 0.09667698118631701, 1.6856721114725661, 0.7440222390434819, 0.8622892368470232},
    {-1.1134442993931704, -0.28149858927625215, 0.41075849314294977, 2.9992667740874337, 0.003155634591185118, -1.4103477460390537, 1.8361015074971112, 0.9780036336780881, -0.1484053422206888, -0.21169999915566554, 1.2959905252627166, -0.7128268029929257, 1.9188729055248959, -0.523985274121972, -0.6607922479507556, -0.2139349602706609, 0.33596230394309445, 0.5300193948189871, -0.6547944601086947, -0.7456206036704977, -0.7825121062808669, 0.6413859647897634, 1.0258247482952891, 0.5879596362012706, 0.8889897452154502, -0.09989909592523426, -1.4305909113065858, -1.989550600535533, -1.6848075575942507, 2.1066721942197635, -1.192866454710834, 1.0979234899633457, 1.92522148613531, -0.13657924843207875, -1.4151011540300205, 1.0277125674445524, -1.8628022782749412, 0.15880103580453778, -0.8746730178276888, -0.9206797320955104, 0.5041754239823361, 0.6562195264509155, 1.925638183058017, -1.2338747077411933, -1.356283526697585, -1.2820445701188063, 1.5691486373890133, -0.09656180652143555, 0.3930510647852882, -0.8450561841770834, 0.1106205440871952, -0.30673646268937715, -0.7677009110711268, -1.9821409822276972, -0.297323217133833, -0.6602805143652101, -1.4943592780410233, -0.502667004436959, -1.0750172431657012, 1.3182452190271714, -0.8091521387095776, 2.208949895464192, 0.3117196651118345, 0.572815653656612},
    {0.364157346079706, 1.2128628664180823, -0.4557473314182707, -0.7092661816908836, 0.48450458147417186, 0.5425928232328505, 1.9366181290670408, 0.1137950919257461, 0.306601924500047, -2.4450843871566557, -0.9008482026351081, 1.1547139338993155, 0.8512893702004111, -0.5687513946791186, -0.45131972911837637, -0.10948316011115396, -1.5748662493215506, -1.034627199638282, -0.07093876666901817, 0.20018985659885566, -0.6446518570689839, 0.9889773796309648, 0.43087620208524047, 1.3059632623654855, 0.339558112032978, 0.5398458794175891, 0.6087061472627181, -2.359668685798527, 1.1686397786371445, -2.398244396044441, 1.951828196058658, -0.3230285703672305, -0.26940862359576495, 0.08714963042520339, 1.3929928987771332, -0.6397032991519528, -0.088364561706876, -1.0481900291827657, 2.600168419591164, 0.07110944108287857, 1.0284838661060216, 0.3850204816711244, -0.5203442180378532, -1.1455331370182882, -1.4826796775899012, 2.3175976011439396, 2.059086126874236, -0.4726582757013214, -0.46126816487288386, 1.4166374923604115, 1.160595047194679, 0.9486344618195532, 0.10798611158055918, 0.3307979144863546, 0.17911024974429196, 0.749846404734568, -0.39542819504723176, 1.087315116310258, -0.4953345397767871, 0.19631650293842803, -0.4217547996745064, -1.4182047724148332, 0.013897589737896753, 2.091517197919642},
    {-1.0378831588951605, 0.3836680132079522, -0.4677514194023196, 0.7132375324373406, -0.7042813836081318, -0.09419599642912073, 0.8988285341918234, -0.5294803455256002, -1.0020615945762037, -0.06182922125154103, 0.30046469549618354, 0.7617554887840069, 1.4386613125445522, 0.37210987906514376, 1.1616519945214823, 0.09794746723034206, 0.7190581501219738, -0.2790869786184353, -0.21320136413676877, 3.2553645978587977, -0.34367367978549834, -1.2658867611577158, -2.5510573559965093, 0.18587578306340732, -0.43921804461042563, 0.14483273662100965, 1.423266202382256, -1.0600254929996786, 1.5079593546830494, 0.010237776941158553, 2.9756374260668843, 0.9225953462875726, 2.2745465378171965, 1.0160420261364775, 1.1326742618908365, 0.4466762457437016, -0.38763243726121593, -1.429355369287764, 1.7553495325981374, -0.05478993109040226, -2.021619083848051, -0.4302038073363291, 1.1195686436478964, -0.9138744622356763, 1.2000246848863931, 0.6979620908284356, 0.4964708660130117, 0.11359148040805495, 1.648176097588326, 1.557439753081215, 1.078356891781246, -2.516823162733541, 2.224940227505655, -1.1162220941282002, 0.14697787313497163, 2.9264541665174115, -0.6951333772975749, 1.2337673614410873, -0.25398732507201066, -0.8146780025828678, -0.7709393856463755, -0.3335850403653215, 0.980565259674093, 1.0175164195951902},
    {-1.3504526273849895, 1.043183462010347, 0.08005422918695967, 0.4036439738321355, -0.7975088911765623, -1.247325582498245, 0.1217060167991402, -0.5609713165400156, -0.010647814731731656, 0.1326141243603733, 0.7752357063668035, 1.91541168013135, -0.0030590436530500142, -2.2190594753781974, -0.7693912945659975, 0.45313508815053494, -0.36381444124005397, -1.4502542415096211, 0.9959852874898608, 1.1506038932982596, -0.6334199587408343, -0.4788627993115676, -2.181431455530567, 1.1843047910103734, -1.1767027350465749, -0.20026341617480584, 1.673973722689746, -2.4030508585505093, -1.7141928316872945, -0.39450235048078014, -1.1696420074229832, 1.9193256869560313, 1.8036670656690066, 0.2949225197780572, 0.5981697172181472, 3.0999814892681328, 0.7183511995516164, 0.07721356932934614, 0.31605247155435734, 0.6259917797323401, 0.74364030510528, 1.2516839113520073, 1.4638111231644222, -1.4465593354038766, -0.2147414239019298, -0.18285167398992483, 1.0519832881700424, -1.5747148592982572, 1.6670572961569794, 0.8992763111124714, 0.97374049878366, -0.8762567610998143, 1.8058837194448403, -0.10893934623131629, 0.6625876460983865, 2.424637432790858, 0.145258722148445, -1.023470719262711, -1.568219251149378, 1.1268022802600233, -2.1096194506223864, 0.03998698013180596, 1.55053040959499, -1.0357101956764485},
    {-0.3554376752697572, 0.609044143087151, -1.5837074953453287, 0.9751821275689448, -0.9917601226118495, 1.7467115291379682, 0.21775766150584938, 0.5770938853162395, 0.2879718295280937, -1.270212467618413, -1.2408660827352342, 2.268615839887323, 1.2627639387031975, -0.5055953808017232, -0.6333809455806462, 1.092793807278559, 0.503231539807635, 0.05920030009806734, 0.7418132675168965, 0.518399665589321, -1.036770127067972, -0.49721695067393334, -1.0548117991273358, -0.39294515950277265, 1.298710433581761, 0.8497434664263788, -0.8477326440048875, 1.9666985609296033, 2.025623810518034, -1.4202415513044437, 1.002760688074103, 0.11363837399862495, 0.4772290074280695, -1.5032708701446587, -0.3544641180731621, 0.7707836249492427, -1.395530361476973, -1.4567311056539014, 0.5041835257807576, 0.034179869127437194, 1.5312328613281623, -0.4610373433578263, -0.005344446224928444, 0.8872823375847058, -1.10223798971525, 0.2407482247728352, 2.3883073390859124, -1.3662260858881101, 0.15751339908293058, 1.056177511098479, 0.5938523100543687, 0.7851181413528645, 0.3383622067943676, 2.1790986525610907, 0.7582580445192209, -1.4442491255603973, 0.4822462649099367, 1.1631761610190128, -0.7455885994924296, 2.507828953370635, 0.4807955751552301, -0.21178378126393618, 0.7187633815604603, -0.2305938993928911},
    {-2.814628977469014, 2.4433060211655837, 1.3807889405496412, -0.4748731928478968, -0.14123050860189548, -0.18684475510995127, -0.9852472731835817, 0.6623802722738545, 0.7144432951519496, -1.5704112152661325, 2.0120175026534275, 2.334425792784442, 0.6836867117622651, -1.3342508170795366, 1.4147693761549982, -0.36417041798091354, -0.32763044232341565, 1.6810461001482424, -0.06140207795131569, -0.44724440009957167, -0.13232084169553715, 0.04883824775692038, -2.1810061204220075, 0.8992905557773141, -1.1148007349452607, 1.2194914203853788, -1.5597669581874587, 0.765779265629348, 1.46721997811899, -0.1581349471473834, -0.5525018540057205, 2.7043719590399444, 0.4815930872782096, -1.2333142072664143, 0.2004323077628109, -0.6910118090090688, -1.952668400234404, 1.116230424906947, 0.34669162831402894, -1.8400640381323166, 1.4352174947687815, 1.9022281047425078, 0.7816849333354303, -0.43601869766907336, -0.7594901357373725, 0.4707983226357746, 0.6754985839289124, -2.514586482389912, 0.2873260341556763, 1.1762319833503443, 0.15014746531726703, 0.7245307401772572, -2.1467652178618666, -0.4154323005744305, 2.6447844732879076, 1.6207629863542106, 0.15212180111125875, 0.7487664594029266, 0.24391984070538844, -0.8268559415516091, -0.9962868749618881, 0.6188556977231173, -0.487750213906101, 3.488936749632438},
    {0.2344428506754522, 0.5768413500358662, 0.80206419246294, 0.8216882943046494, -1.4885519687028748, 0.472437350822868, -0.5204634069204753, 0.10440071012466708, 0.4594673075663617, 1.4696937268795915, 0.46951750659237346, 1.1029549959094531, 1.7445290210162292, -1.3391352691285197, -0.3661616980203637, -0.09579833029782452, 0.4503822763474767, -1.0884426976632249, 0.5238337549853254, -2.378596369277491, -0.9860919021768177, 1.157133027985891, -2.2578026926382964, -1.0778844414930735, 1.546176143452789, 2.240885776487182, 1.6955764928530033, 0.2669961676666191, 0.8387891449347443, -2.862762263690956, 0.06793998200984487, 0.489598236666507, 1.403924864729363, -0.6742072482525407, 0.3659895514205948, -1.2238524250466858, -1.7302696665354609, -0.06525948270274007, 0.18405567516780638, -1.2390024153279848, 1.5967766678074753, 1.1476217483452387, -0.03345469224590782, -0.45692998781407396, -1.2926897307990486, -0.7542659793139982, 0.05845629100753753, -0.3860916690554688, 0.62681224664946, -0.3399067208025675, 1.2373263122359306, 1.1010296369219796, -0.6050912939618877, -0.580012216671191, -0.6672717275327198, -0.3844078457135786, 0.21922866781737643, 3.8774525488167404, 0.7087574861431014, 1.2673534710817451, -1.0101196931670289, -0.07276476147809198, -0.22208944611193518, 0.5782917049673779},
    {-1.665488092446765, 0.6879225183944514, -1.8928081626703093, 1.1387203455572736, 0.06579548534789471, -0.7998542210467358, 2.2835829842650313, 0.5225054172750098, 1.8465489817075236, -0.4679583006086656, -0.051216399762055324, -1.098550264388447, 2.229973308836692, 0.552594162603229, 2.3278547104621428, -0.358750842653244, 3.5571062334817416, -0.5522591479305697, -0.340130985898375, -1.0941319902681212, -0.0891257822358815, -0.6110658196133922, -2.253343993601772, -0.49585105331910856, -0.885954701379127, 1.4095091796866923, 0.6597628445010542, -0.12276249905943465, 0.9335519999470894, -0.554799179322709, 0.45635405941830953, 0.9700863023159084, -0.33735970837345264, -1.5089030023950627, 0.6932995330635995, 1.0138787844955197, -2.1658684083111104, -2.031065503665758, 0.5083900146757603, -0.9531065835687887, 0.8101895632617983, 0.7368608762830201, 1.1641187244004334, -0.005272506434108982, 1.0039076843279757, 0.7472986773332737, 0.15794209064877365, -0.12963650889519324, 1.726693094641492, -0.1077546628020153, 1.3620963641837927, -0.1345091347373461, -0.005396066025788717, 0.9750882833339707, 0.08361504221911134, -0.07041575654238368, 2.0837609243356403, 1.3995411000662863, -0.8997988587810835, 0.14852945527935288, -1.9060566256602818, 2.036878321340828, -0.0387934611414103, -0.8403512720511724},
    {-0.6976221853480573, -1.0952703989068697, -1.4975113858906672, 1.4755487552079696, -2.1920745732358626, -1.1362909886637775, -0.05381883462566895, -0.7121341853512494, 0.05720585113102241, -0.12206602998368701, -0.4404956463525332, -0.3522743107826857, 1.6719625597211674, -1.1862827679315437, 1.7559358118984105, -0.35721698800207896, 0.7298112097858851, -2.758369871321808, -1.0025926994085708, 0.8536488453095603, -0.6642042171183641, -0.9533386939149284, 0.18147628519539064, 0.8414784498422774, 0.15380361943052018, 1.0051937659753596, -0.6557010539852117, -1.4426517612631575, 0.17574567433203483, 1.14865390471063, -0.0017054283066668314, 1.1254408884371623, 0.8841758222355698, -0.07132518237103318, -0.3121288908091986, 1.2666688543673088, 0.3375031985039984, -1.6521784211442412, 1.7815424022511006, 0.7068379871962778, 1.1125489164600637, 2.580797438240569, 1.758258480675171, 0.7329436422766591, 0.5136778586807191, -1.426071176423226, -0.2969031673108589, -0.8433784565655333, 1.0877892443399897, 0.49980103701422524, -0.869813850241944, 1.354881846019289, 1.715254524821872, -0.020202423027886773, -0.20927824737433767, -0.10714545077581762, 2.1027760347961686, 2.666429306986559, -2.89203244815728, -0.6200072193053695, 1.299207748004761, 1.277611163052414, -1.3599764543746995, 1.9530744651724303},
    {-0.9064735810850835, -0.8766885582589643, -2.1670667604593943, 0.4041503850764535, -1.4713960720633201, -0.980238023136417, -0.03667175396119399, -0.11483917425200448, 1.7850271575269472, 2.3846543001606397, 0.7063354200913565, 0.5663005459731316, -0.4765410373391375, -1.8317493097300226, 0.14158231537234606, -0.4868409616735502, 1.4346815351776196, 1.2730819038975862, -1.0324288101460368, 0.030246873198618553, -1.7867768463933942, -1.1306002065496967, -2.078589586548356, -1.3457977089497088, 0.52169134669118, -0.17908929964945364, 0.7452037370930578, -2.310006034062524, 2.3551080095202273, -1.9391205858536449, -0.44482290767478877, 2.6324939462254764, 1.624870723715339, -2.1178007930997174, 0.8789448239636435, 0.6368290986971125, -0.2127460143601544, -0.9657251758884492, -0.4046014233303402, 0.6251896367955306, 0.1965602120944668, 1.003827268564676, -0.0028549200816295316, -1.1687936104606451, 0.9069744459048403, 0.31163302104363194, 1.893839440017917, -0.4500775326402059, -0.45376784554649563, -0.3607652987781721, -2.3639232506006436, 0.17295171922311672, 1.9082946447045832, -0.5869578458667137, 0.20701721264913867, 0.8935911783907705, -0.043760154695971866, -0.16573370067043, -1.2195695877877164, 0.7301712364059986, -1.582391636235079, 0.7287988996026579, 0.7844154695501492, -0.04820024808178219},
    {-0.3012257347946198, 0.7121827294362619, 1.2180836269839266, -0.08772617344954449, 1.9042203048338826, -1.5745055393581007, -0.13787614174288218, -0.42807956239224193, 0.2983317530587445, -0.7826952313756378, -0.21808954944684078, -1.058977677794762, 0.620025591316649, -2.3192495503001753, -0.6469323381253583, 1.3753227518530222, -0.16820117043786523, -0.8904875221138027, -1.0589785283779016, 0.0015599208285908559, 0.854175401630889, 2.1191091605820835, -0.8927483673164952, -1.9523925791488677, -2.554062766780055, 0.6833388594598232, 1.248012302188714, 1.9847609204049685, 0.8882834639167424, 1.080060232306091, 0.2477820611590912, 1.373384668032024, 0.15811163918300944, -1.6699921240489262, 0.9567865478311065, -0.14288468204426538, 0.137355762584645, 0.6724028602469555, 0.3498275226560379, -2.8849291669799624, 2.422948471228625, 3.085742133540947, 0.16859835383009583, -1.2645866850262544, -0.042464472817848584, 0.7949986213218541, -0.08793888542014804, -1.3018520067197674, 0.9272574016131372, 0.7781057760715608, -1.136241668254441, -0.4673802967979819, 0.2594305996313158, 1.5328541790938368, 0.7828825234335057, 0.4862678040677428, -0.49535225920430154, 1.9579254857234498, 0.4543180651434023, -1.644227010476509, -1.5514274937591486, 0.9643260877847203, 1.9288857284103627, 1.6411509347566071},
    {-0.2640160137212754, 1.5119592902152639, -0.23425685371944252, -0.6751882148375427, -1.7145657688639055, -2.335965962419151, -0.8726332823432286, 2.1040251920400443, -0.20781994182063027, 1.3907221179403344, -1.5093017382452825, -1.4458061489269411, -0.9494073500864203, -0.11639522734091903, -1.665045172711218, -0.309554900660206, 0.5449545251955062, -0.5670502237538445, 1.0471279333536367, -0.27715606792041564, 0.05798880417471536, -0.4810846052029847, -0.8447422222564069, 0.02968979005541123, -0.639269674453432, -1.54523730819075, -0.12901732335822166, -0.32718713934942856, -0.1784875348950548, -0.5865406301514704, -1.705812594768737, -0.2571697547793868, 0.7752537698682788, 0.3921529675248944, -0.9075203916801873, -1.130883615622053, -0.8533030337430493, -1.9624081904102624, -0.1710254309848991, -0.7015966548426184, 0.3530894470256517, 0.004366919013180658, 3.390627408144144, -0.5661434582499668, 1.498072052890157, 0.43490016902652284, -1.5145234026330792, -1.6201668504670448, -0.2742271293606065, -0.09920351074147335, 0.8490532773961392, 1.4511087804040212, 0.4340120155036891, -0.38857403546824704, -0.8217790934329382, -0.18822208145490715, -0.1719392712185864, 1.6203326614582478, -1.1168545152709026, 0.70459825663727, 0.6180887596189449, 0.013859160075096542, -0.4208743675003752, 0.4855670410474042},
    {1.3686720136317396, 0.08262930383958181, 1.8234655381979104, -0.5107939387035948, 0.40464114733006673, -3.7003628878874073, -0.9199305636675774, -0.7948213649196025, 0.9804103439245511, 0.16678646040366918, 1.3940349476253462, 2.4865795503922214, 1.2497214211562275, -0.6888800834470298, -0.4949570205661814, 1.0161192380057615, 1.7974325063704353, -0.2717469584958478, -2.0256894526889653, -2.148235908574065, -1.1535083854474362, 0.18003893983114078, -1.6198898762000145, 0.350299975015166, 0.6362570252070634, 0.45717216742087, 0.826746852390344, 1.129592414611863, -0.20330298569362412, 0.12737205166092705, -1.1346986870821085, 0.12234784049733696, -0.013129396579416239, -1.3986705441638205, 0.8792342649545531, 0.07280847167744532, -2.1290000094129193, 0.9123802223494695, -0.5676943805961656, -2.6562027372095653, -0.8052531217473269, -0.04878421571721576, 1.4921983966568833, -0.3920940753519893, 1.0176042411368917, -1.0380815708837785, -0.9742656490685397, 0.3259797796523644, 1.2618077165031618, 1.004442999528748, 0.8108424570067271, -2.362121726285868, -0.2681131855345092, 1.08769837374354, -0.12637237284213607, 1.2298801649550941, -0.8120066621905959, -2.90254600721215, -1.2280914184528118, -1.72522597817796, -0.9602618688764766, 0.7201171561201956, 0.7616389849213231, -0.28140069803270307},
    {-0.877301084721908, 0.9187067187091958, 0.09019213391952456, 1.0671814116896208, -0.24287370799217925, 1.1985702446638884, -1.0396552006388164, -1.0854637822345556, 0.29484012054607495, 0.7817773492481033, 0.768579375691352, -1.0000974267245044, -3.041519098718459, -0.8539016624304538, -0.5670965705462798, 0.41427989267288085, -0.08699620793621575, 0.6464468111478426, 0.4886122662291662, 0.03204159013602797, -0.0007060972196478769, -0.23614664009817082, 0.3377147967871578, 0.1527442895664139, -1.551336307802531, 0.08200972909042946, -1.2090054690302965, -0.2304144407814024, 2.490028191366738, -1.691052815125738, 0.4562777550082567, -0.5602738886466392, -1.0210853659075247, 0.2853715470473072, -0.3406610989187581, 0.9619738660496842, 1.6796940674977328, 0.3268946932779637, -0.297321668399302, -0.5391824096808004, -0.04107853086452525, 0.18949991089912682, -0.705163507858377, 1.1191660625256996, 2.7260673354328566, 0.09966538172176646, 0.2734656745778559, 0.38898479322229773, 0.27956212940378034, 0.9342796572257707, -1.4508055883076094, -0.6028074588058471, -0.719871323917837, -0.5680074264812891, 0.5637980335550488, -1.0081510132281215, 0.6699870498248439, 1.3496810917986155, 1.9830629634377057, -0.6170532686295115, 1.9972152462451285, 1.5812543167748434, -2.080266430263175, -1.4834760738185413},
    {0.4900891111877037, -0.45224637719682104, -0.42521636455545353, -0.9280721093616654, -0.28278081309603054, -3.5047354081252884, -1.7605337986235488, 0.2681725370569496, 0.48134206594660606, -2.373526671591292, -1.244091170687231, -0.044638859328350086, -0.8897069206901939, 0.003470374115360317, 0.5276756109289729, 1.9774763971569358, -0.18665037409998728, -1.7654801958718846, -1.2394784657262425, -1.0682867950462114, 0.5053675525444362, -1.4081676836997135, 0.2236415554162438, -0.5022062867879952, -0.49778086273014116, 2.0129498598406856, 0.661661937032908, 0.21748117451960663, -2.0895479473140965, -1.8155750028595297, -0.805827844100802, 0.1079919459635199, 0.49347037193059073, -0.4483003226301936, -1.3165575851980007, 1.7371749907604594, 1.2615926734744514, 1.3268252070817117, -0.8456082845624784, -0.8952752046360211, 0.5187827792225789, -1.1751559629401154, 1.7904671853298852, -1.9494180297358747, 0.4748513242055052, 0.057430369040113574, -0.7260108294132922, 2.3517018266691614, -1.923659373334987, 0.011647397398839241, 0.8563903862739161, -1.691236458300656, -0.9724023175590923, -0.1343107523111522, 1.6227514805798489, 1.1127756323088234, -0.8231330077818624, -0.4547448219385542, 1.054713510224393, -0.3298835892074214, -0.9660351639845874, -1.9451162854451878, -1.1494671315774827, 1.2638525245802557},
    {1.7009073977028257, -0.2396194734631599, -0.1641559641457989, -0.513361789807934, -3.088148038932656, -0.20057420541580015, -1.0636575443434406, -0.40281221022715397, 1.7461172960887665, 1.2794427532113328, 0.15703113413400016, 1.1423612996962038, 2.638329105335813, 0.7170133268071077, 0.04250403641454628, 0.7606182392948925, -1.4773570187651002, 1.1777674950618495, -0.9615482989095868, -0.3078180377648605, -1.4596013900114597, 0.4969272652281106, -0.5492537728263575, 1.0098250029439013, 0.16802759080860052, -1.0955659322967135, -0.017189205340843332, 0.5706266394841425, 0.3622792723449208, -1.2861264335036635, -1.1112624549429178, 0.6425197864561365, 0.1461239935761205, -1.6248514047812004, 1.4085551044113351, 0.08928141074210061, -0.6728371369129189, 0.364057811076481, 0.1037327927378622, -0.47367467113785944, -0.7705267378257467, -1.9461664766589373, 1.2400909556134079, 1.3965242943597613, -1.1774638380410432, -0.8693872354325977, -2.1947854463764607, 1.1510925469316664, -2.238212037810575, -2.486083481300209, -0.8481911723867788, -1.163119171522377, -0.1641521689385863, -0.7349913155522252, -0.6408183151443222, -1.1612892689041243, 0.42023669980675216, 0.2105711956386979, 0.5562713739622192, -1.2727671198380404, 3.536560583089712, -0.15157954883691932, 0.3080763865367805, -0.9775209072045579},
    {-1.1576281562818964, -0.40517936116366265, -0.19314961502492292, 1.2664713376447185, -1.7391914902048453, -1.3684774838906204, -1.4811000381354829, -0.9678561009429805, 0.2659090818386323, -0.5383027492272696, -0.14073403621205388, -0.24343726486237496, 0.003790854687602594, 0.6021774121900807, 0.03601332452718938, 0.28837084854605755, 1.6492958362266454, -0.7127140619142213, -1.7112009644086628, 0.41480987350497234, 1.0570794775847934, -0.3352237828083146, -0.31120410004415144, -0.4110436050401552, -0.07425471618761416, -1.266975620400997, -0.6234227087465594, -1.8532739693248992, 0.004076923634993583, -0.16899648391657532, -1.6445685719553056, 0.7743572534346391, 1.8192056673447943, -0.19278438678944623, -1.5192639079415329, 0.17396871232160616, -0.4397382054459661, -2.7343959114177805, 0.5305336248986771, 0.9279393893323573, -0.5445304239039682, -0.14371063936638406, 1.5257412205583292, -1.8138718789179862, -0.5583727484405051, 0.9072193251936912, -0.5217814603982424, -2.137709463262017, 0.623687192515286, 1.4660242263142855, -0.4326947092348727, 0.5709834711488271, -0.009374396031554986, 0.3590073806544332, 0.7276611362830001, -0.45043172970712003, 0.06108795987691074, 0.5584938114413949, -0.3825146613593089, -0.05979212527924303, 0.39907281050801346, 2.3248018814781464, -0.6485069138328682, 0.21795722962399103},
    {-1.424140066758246, 0.10674273993767773, 0.12864245507014854, -0.6751165126190176, 1.2706743690815976, -2.0257462346189383, -0.871194463274723, -1.8364339631699684, 0.06974662670514208, 1.360181921845253, -0.6683010327764959, -0.20746197467017044, 0.5296342536780179, -0.5870774183654517, 0.407093730030292, -0.9972214162453186, -0.3866013364811429, -1.9611323905693634, -2.6606220624351615, -1.0156443627153462, -0.40529566475377443, -1.8379896627026213, -0.7883944867381488, -1.299926158985074, 0.28200852155931483, 0.5144978083888606, -1.0341951138155934, -0.7401413539747523, 1.4027817427870055, 2.025070559709459, -1.2318924638005935, -1.79512383435225, -0.3416102621875835, 0.04396569537738724, -0.5428952612866217, 0.0903480754536127, 0.40705514516878344, -0.21879557807031438, -2.2919220812540773, -0.6355406950932343, 1.7750139127615874, 0.02719748856006636, 0.2618604344953743, -2.751951801734956, 0.4652918647057827, -1.5281833557948372, -1.2769779879593095, -1.741392298076062, -0.17070172557268762, -0.45463028643965925, 0.1899018731655675, -1.04805321833708, -0.8981908261479229, -0.1560817765442269, -1.3981963530553152, -0.053070362902713886, -0.5178103012770867, -0.9260500961280818, 0.6467362849831846, 0.2626517356510219, 0.34921710337731504, 0.2290826201756212, 0.547289474413587, -2.012703950419827},
    {-0.9354219473347378, -0.8066891557042398, -0.40183771954140024, 0.7487290790386478, 0.6402668297737494, -0.43361139686305084, -0.4736389017262761, 0.17047092097800792, -1.0680700272259736, -0.6900843049519809, 0.552409982364095, 1.5351949742664015, -0.6028391850984957, -0.10360124416259833, -0.48105851284080586, -0.5086552788379785, 0.8964603691655575, -1.3303844412066415, -0.3699898020902651, -0.6254954234666585, -0.04001877812514458, -0.20845824311249303, -1.4182090323431813, -0.9296871400822384, -1.628634166910376, 0.10003846542972263, 0.9987603954076787, -0.17869659089066675, 0.5349049220240594, 0.24734327410171544, -0.5423266072772548, -0.9184202167164545, -1.076681321460135, 1.223580408339991, -1.0291520843802593, 0.2320500280202347, -2.1769096636630394, -0.41528263422817097, 0.19001767185290172, -0.6832679732896166, 0.4177479262984789, -1.6487728777923896, -0.683678814928366, -0.6056462547885717, -0.8070232069407149, -0.026490137874659245, -1.258860904777786, -0.21813816520515814, -1.2647055455288576, -0.35444396579099313, -0.8775544579592566, -0.8550196329727204, -0.07669187572692897, 0.9592047977717293, 0.6697699511597894, -1.333357716211876, -2.304634194898342, -0.06773111791531036, -0.8438335008152398, 0.75740588817964, 1.3959742854678618, -0.5598553274408342, 0.9072848108413588, 1.349964458681031},
    {0.4539827493026615, 0.3319369197916536, 1.7607505429915724, 1.5110605805835304, -0.34982263973524375, 0.641061401320204, -0.7203967341736037, -1.8685787140367305, 0.7281183915526762, -0.7150198711181699, 0.5847800589073133, 0.10468628025140914, -0.39698728673759515, 0.9566869952788989, -1.106101507397165, -1.7157377427548293, -1.1983944903203638, 2.111376503103613, -0.03984064476767404, 0.9829405455125323, -2.3619995823154736, 1.211330438478201, 0.04143047702222486, -0.11106481780006633, -2.0822211302622007, -1.9193924163496061, -0.3273688816794724, -1.022368548958509, -0.3875540442173115, -0.12454217747401232, -2.061559577752646, 0.032965946280921976, -0.6824988098815296, -2.0167717194906936, -0.18156914504215413, -0.48605973175470585, -0.47533553481243757, 0.11598269926583352, -0.8060004944742466, 0.9098311485901457, 0.43422153952681863, 0.8614198761044402, 0.11759775904766169, -1.9126224773661193, -0.5250916511267906, -0.9478659400962031, 0.546421896734945, -0.5382075497134726, -0.31004169221044886, 0.35876619695522943, -1.2524980016642955, -0.8481785238369602, 0.04432575896927099, -1.399340912236166, -2.3171284064736763, -0.689693678847223, -0.1220261455543566, -0.7835696549928645, -0.657281637208473, -2.3742664832163403, 1.0570614890349794, 0.6728954833172248, -0.27444518685760694, -0.27339924721665215},
    {-0.31437889741130587, -1.8839030872745441, 0.634044055321203, 0.6026671601751049, -0.4094344458611723, 0.26974555995571886, -2.4003478164784493, 1.2741359970084605, 1.003148268328316, -0.3667355327685856, 2.1434527676677804, 1.3895767864655315, -1.1567630190747231, -1.5742418794971103, -0.343159353173905, -1.775278347960797, -2.151232231321613, 0.7305169778476556, -0.5129329141695438, -0.027563191823884448, -0.3524482595912406, -0.08065606394808046, -1.0322969105770752, 0.2961538180726341, -0.35764244310555765, 0.22662993675236473, -0.9343521865132177, -0.7272555310563928, -0.06653564111272482, -2.0678859110154577, -1.1139471154533167, -0.4422773356506566, 0.09870922870831061, -1.9794819739655711, 0.8033628932733368, 0.3668813240515059, 0.14913520357853818, -0.9091209283520691, -0.23442555970877588, -0.8762864322822819, -0.011134747049672666, -1.5042029551890874, 0.11810431604386325, 0.9374200651738955, -1.6358827698374494, 0.04744126446696266, 0.706520678036099, 1.6797584340943839, 1.2649283654411216, -1.8653855404893507, 0.41381333409732984, -0.46396494740784183, -1.9716532410745853, 1.7036698651540378, -0.027041202836513536, -0.8507763886769534, 0.9616487933198404, -0.19503517786519686, 0.15335842204688, -0.34386739971671226, 1.598921491046594, -0.5614226883085551, -0.7858232538344753, -1.4450683507946624},
    {-0.06810580237016317, -0.5759223093070228, -1.1433370270608332, -0.3231384186599445, -1.1246317509197326, 0.2605614975413049, -1.3640193207801332, -0.8138622939987646, -1.6378943471984335, -0.618337627524575, -0.49610887386788594, 0.8133136627685692, 1.8102391053962428, 0.3365846050354071, -0.8203152557170962, 0.21985977415933722, 0.5972725020772989, 0.5643173094360087, -1.2695415367115934, -0.25031798204838707, -1.2053708705462416, 0.8781613549284283, 1.0132928675565582, -0.5602897766775108, -0.9334797301722321, 1.1149690527049398, -0.5568604388931522, -0.35600999811934503, 0.28574578961741487, 0.14552461539538045, -1.5198006612463775, 0.2696061473800985, 0.4600166177257765, -1.9064738074797742, -0.5206896218901913, 0.38905937998700496, -1.905713352619593, -0.6464369700695418, -1.8549781190587715, 1.052937069171375, -1.0792988344960333, -3.354463701038697, -2.474648162067595, 0.4376620320794284, -0.09372586277396164, -1.0232140811218373, -1.3806662824767624, 0.9442402770348082, -1.2836705538038793, -0.5036060084408484, -0.5248894546014264, 0.26215392246545527, -1.4286026868986537, 0.5078451774293445, -1.0212083974558832, -1.4317104025332548, -0.2915518977959298, 0.6666866652247946, 1.319310652398433, -0.9033875983445323, 1.2262627973427722, 0.7460742656470984, -2.995976351663199, -1.010544719124036},
    {-0.9816851424111077, -1.3958800553288904, -0.9942630470579606, 1.065631597676325, -0.8213903061995659, -0.8336739094423578, 1.335889312192594, -0.5743886130236635, 0.5574106495013613, -0.08700089054377877, -0.7230136517161484, -1.2197581283417174, -2.1677470226984554, -0.3592695528268857, 0.48941639169992857, 0.8214815997378035, -0.023585283381391358, 0.12942133929547053, -1.3118425582944453, 2.171770801037527, 1.0335986625285962, -0.7823932816590976, 0.5443552785296626, -0.22176446983264006, -0.3848226180168409, -0.014734615629996265, 0.3551594539638207, 1.1535732233065312, -0.09927659142075403, -0.5220750122915446, -1.5781572785461115, 0.35812843187303556, -0.30703905922751756, 0.5285523027546912, -0.0066174304371841115, 1.30940611601012, -1.427390512875023, 0.7830854801221386, 1.1283628335914198, -0.23367750654461783, 1.8362014725279014, -0.45965014368283813, -1.2896353444788837, 0.4188295675862643, -0.30428665912889497, -0.40139031758019555, -1.7279270322150413, 0.37031481967428537, -1.3348522583890874, 1.7117101479812495, 0.6744997396337604, -0.5428033143624983, 0.6173033087734439, 0.8426396463421351, -0.4468146469626904, -0.427080549231668, 0.9676972611203368, 1.0268218376103968, -0.6365980473091739, -1.8184046881221256, 0.03558784392219656, -0.25386773671421065, 1.8084126161697782, -1.339652636654183},
    {-0.18213303119928356, -0.7147235831294962, -1.0204427922171795, 0.6668285906220324, -0.6801615567822248, 0.296380903101655, 0.7742914906855011, -0.15022546568499262, 0.07050928106948424, 0.5367774225395333, -1.5863311794471073, -0.06494483675837286, -0.9805026884215855, 0.46299548543175206, 0.8191218075266483, -1.1678499518707668, -0.0073848094453005065, -0.3994304559569766, -1.0567518630763733, -0.14065711724356877, -2.116450695560919, 1.7961233906422205, -1.1510657781929305, 0.06462636125753876, 0.5232444451885304, 0.599428703875129, 0.4718715896629332, 0.8510222263884698, 0.6406713399682775, 0.109563976174907, 0.10635037704537424, -0.5727882804433071, -0.018804860960630047, -2.6666987771079023, -0.5917032491105946, 0.17226584141993725, -1.0627315751164188, 1.661837836133846, -0.5377923388486064, -0.1355541458760196, -0.6232721187832218, 0.9129669889869124, -0.15173789385333963, -0.09528035181891027, -0.5825043764109082, -1.01812393693897, 0.9605302760644897, 0.5418018161461021, 0.29304745033711715, 0.9734678136591416, -1.2921833821945201, -0.7102764388476318, -0.16515760337767857, 1.3268872468425037, 0.28662452209162015, -1.5298371623601745, -1.7733401740954158, -2.3903054944482047, 0.8071155639467645, 0.15837874071695704, -0.19353917323799222, 0.4890935097419332, -0.32753573931952096, 0.34093758711278394},
    {-0.3030208139494572, -0.3755136895643299, -1.4376968237997791, 0.00023789331084595787, -1.835940823121585, 2.8314830506309803, -0.2094939638558896, -0.012672139103119276, 1.7770683894988066, 0.6416542958369178, 0.7260242904477047, 0.15980135952360028, -1.1886411280567557, -1.5789275546134072, -0.3408018264149372, -0.6412319167437668, -1.0597097379347102, -0.32925708720769215, -2.06312435867187, -2.438100041387813, 0.3919381255081475, -0.231359312967994, 0.4358251871651894, -1.1375257379342878, 0.3685727908379024, 1.1236707340232661, -0.8386518565422867, -1.7715111371767616, -0.2203412790681567, -0.5278493214436113, -0.7956954962732243, -0.4395491787087153, -0.1166108294633996, -2.733197078344238, 1.0226933229564992, -2.47663232776367, -1.3482077327159576, -1.8453120149190863, -0.03634239394213649, 0.8288265944419785, -0.8980104377437509, 0.4957482339918379, -0.9077007132342031, -0.30225521135443745, -0.9287545059613682, -1.0426208725346784, -0.6148674975085062, -1.3653005568198802, -0.24911142777644474, 1.4086373706431654, -0.12098487242542177, -4.652286764438089, -0.7699177219160344, 0.028037878352007838, -0.39068350033498817, -0.3666244185958932, 0.4250482052935719, -1.4522214461951353, 0.012651220125293336, -0.3258420202554737, 0.619084024432058, 0.20975406686243359, 0.19018694759385338, -0.9872395495616972},
    {0.5887990371753369, -0.41369260239830263, -1.0527353879487, -0.9402923989304941, -2.807992573301684, 2.0624804206261707, -0.5220536182677712, -1.566298395432718, 1.5582732585202805, 0.6147782847975034, -0.39988816880653555, 0.9210034493865612, 0.47544608500963076, -0.6349380826697985, -2.5679728943666578, -0.968469215336612, 0.28243928810729374, -0.9105284399177234, -1.9201395625553552, -0.18915062127824384, 1.5015725634555952, 0.6643719634161734, -0.6092675423096544, -0.7551781918099438, 0.5786184249074664, -1.4256608006295615, 1.7257511437472226, -2.867983698111315, -0.3769544346405957, -1.5265244630878956, -0.7216782680415481, 1.093885520815166, -0.07606611627054027, -1.3375420054841116, 0.9852035330852104, 1.8312034988410257, -0.481431234764196, -1.1146383495542662, -0.036324634622582785, -1.2794973172057247, 0.04241443801975045, -1.6372734097344073, -0.748080231157887, 1.10356279363638, -1.069186910167753, -1.123872910980366, 1.059297250968937, 0.15283219529436978, -0.5679208772348564, 1.0065078566777887, 0.4495219393148869, -0.21358243726834106, -0.8665780277812684, 0.5187081333691278, 0.3708791797340636, 0.6837304650952158, -1.1855850004613662, -0.32420365935135, -1.0369154595953463, 0.5113855578218598, 0.28595185295073466, -1.0073444427134135, -0.7553949253513784, 0.2492132428564902},
    {-2.2939577451684143, 0.9657963023933054, -0.41384741609260023, -1.002913059051172, 0.16336152015197916, -1.1644962641678485, -0.6449794989393225, -0.44083607081655035, 0.7444461645733896, 0.8312121843529219, -0.04760240550441207, 0.41380057879298715, -2.416130667335852, -2.2961154141506896, -1.2490558758816999, -0.3293881398965962, -0.12431589779055414, -1.0336069743639087, 1.482534280684494, 0.6088059687289213, 0.8842034655553068, 1.8931227706272273, 0.43111476196286275, -0.05550230561999499, -1.1104904858142692, -0.3171359193278769, 0.04802716958913586, 0.5912063852021903, -0.9935509912073643, 0.7559265023559946, -0.693064138375062, -1.4646717124283286, -0.2381827712806866, -0.38638018038654226, 0.4666891581992866, -0.7314396863379407, 0.34984015455193734, -2.2505178914268127, -1.3500650287441653, -1.3969002697227875, 0.8780602981984889, -1.386697197614704, 1.5149596636778717, 0.028798745969897583, 0.9118862854850903, -2.526859540440504, -1.0312859265379184, -1.0398436709326595, -0.34434330070725466, 0.46906038013360574, 0.8613501938580987, 0.014078816420141261, -0.8118842814103137, -0.17539956279599367, -1.3267956533898064, 0.42837064895332366, 0.5820418202478792, -2.184343610772075, -1.2002076048772392, 1.1543881111881753, -0.15407744355649836, 0.6822105539898815, 0.8837449503313627, 2.5190909483950725},
    {-0.2935627212445928, -1.162284202305509, 0.5666023764678012, -0.5759094708206574, 0.197588146265817, -1.2577851041156511, -2.49695771949593, 0.22085335103810222, -0.4207728368045626, 1.2299828602702378, -1.4708947696196149, 0.7865635799507134, -1.5169480897575236, -2.320291234914119, 1.0910949175063225, -2.2758539574398617, -0.5425890954179723, -1.0106652545427015, 2.7166133015032616, -1.2712505092692024, 1.1198259736858602, 0.37113406112804254, -0.38345712695015677, -0.681422388683635, 0.6954548812579179, 1.1992106171732877, -0.5782327159909306, 2.0183805821595615, -1.1683829055872665, 1.0293590909127335, -1.9168476210746357, -1.5017362746718126, -0.34965686556199194, -1.7324690910312528, -0.8355113091903164, 0.4012729174195696, -2.1010224328630094, 1.6731844721251574, 0.042963753339024004, -0.07215677490348552, -0.31337167587019366, -2.027320776236568, -0.44977972453307546, -1.3357930094626527, -1.9762817716740686, -0.6917033303452641, -0.3223099488353932, -0.3120042030193821, -0.748740025517314, -0.6756432920718926, 0.17461270500838594, -0.3769112368126285, 0.7499087855926423, -0.4467188659238993, -1.9756864609396827, -0.3958219836944615, -1.0885610966852068, 0.9407199438319537, 0.6748865907560208, -0.747355844761092, -0.539155477301412, 2.05527156978298, 0.39015722056481167, -1.401473012118985},
    {-1.48598018836996, -1.475076157483151, 0.19599117388127524, 0.4849969885087725, -1.0448010272955521, 0.22526803545202526, 1.535165570263693, 1.2063596703500303, -1.12166956937996, 1.0606094143266536, -0.4093727823497421, 0.1794014897855301, 1.2383566870487224, -0.40358278550214655, 1.2458095974046202, -1.7015300887735736, 1.895556340740708, 0.13008156872474916, 0.2015856044785895, 0.25137184912342514, -0.16094485828546656, 0.0529572490738026, 2.2431548254763705, -0.9812495257999985, 0.5479447324379132, 0.6177725873982455, 1.3519221692409369, -0.5404906574132982, -1.423057919006627, 1.3471175278520178, -0.018217949246381142, -0.30242525719495145, -0.2211387656426426, -0.4173166811794208, 0.38980021724293773, 0.011494071964976402, 0.37887994327373803, 0.3867911869449474, -3.6742778142176142, -0.24750952293988274, 0.3798074832593269, 0.22961332073025678, 0.6748870447975075, -0.060564024218577865, -0.552214192259944, -1.147709427907482, -1.9179625415389128, -0.10630343169715475, 0.12103444572520834, -0.22362783158181895, 1.4155171040517438, -1.2711962019887126, -2.1240320081111492, -0.5089854656114589, -2.1521463761467237, 1.0677132495563921, 0.9549664735466273, -0.5058312556901132, -0.6029026426329692, -0.8967394618089255, -0.28745197541024076, -0.3604255144732291, -0.7827125881772788, -0.45724594374622834},
    {-0.37906026433748463, 0.2879100467752397, -0.8172161259094609, -0.3995043101552499, -0.799403633427266, 0.05032567866022081, -1.1566173865200307, 0.17773213699799045, 0.7773770194160786, 0.19622544576114498, 1.5613851371696676, 0.1659852703609998, -1.4514759556106402, 1.3471517513107276, 0.421630169465882, -2.4037279946867303, 0.6121118361378701, -1.0435023398970924, 0.7048334538200348, -2.5705603063248263, -0.5556459281295234, 0.40103345799744494, -0.5632524059857713, -0.305382336466147, 0.7190178254986983, -1.2683204698670862, -0.5231160552442954, 0.29346314848623545, -1.9102222059430551, -0.1518539439207062, 0.3442555044607095, 0.7481975897299218, -0.5676444421988468, -0.8771645173284098, -0.7621481658195876, -0.5578497358326293, 0.619781897883409, 0.027610659991460607, 0.8879460530453857, -0.9431370131349374, -1.0364341604306953, -1.3366688396804745, 1.4296373942887173, 0.3444455907901529, 0.354531288083738, -1.1560752930556246, -0.2572948272958523, 1.615978285115403, -0.5088772862770906, -1.697589236059319, 0.31049769469790206, -0.1841658152566097, -0.24926902222423095, -2.85466201908748, -0.8056749942250968, 0.6240870290311833, 1.1503487410507824, 0.3089859857581213, 1.295590701130871, 0.6665529891623995, -1.173891670263722, 0.5832712864407344, 0.08894970096154202, 0.5004273655861007},
    {3.2668742331608707, -1.0059205750961733, -1.030246789222968, 1.0168863153297318, -2.0459954481306353, 0.5644703663429973, -0.47859700103523356, 0.19415958253611088, 0.9427673352971538, -1.7231554251153933, -0.7907016516596046, 1.340110295707635, -1.387479070455982, 0.1312770902984999, -0.45074821121883296, -0.6043678560933232, -0.3418121487532763, 0.011005792564803208, 0.7846862804969571, -2.1922957420286044, 1.256959358040637, 1.57649344449143, -0.5164136728250053, 0.7677346349409443, -1.539899767003858, -0.7498814960439382, -0.3419734936673259, 0.6002856968629598, -0.45024528006427494, 0.23961207785610594, 0.011205265645398182, -0.16909454052178927, 1.2815591109102222, -2.1906370117546445, -1.2639820063997946, -1.0021571674557133, -0.6546571752368486, 0.6413761981792647, 0.6222330090021335, -0.5523359021634856, 1.4737641527569796, 1.4274700685621617, 3.268375345088982, 0.012645372581139383, 0.3851988018656933, -0.09971438018064567, -2.121419642276954, -1.3355768528965886, 0.061407754344421396, -1.7052905903207018, -0.11651066593621197, -0.34038993280469637, -1.4187916216617993, -0.8093126699898687, -2.044843862671226, -1.0676893857851493, 0.480712401317585, 0.8874796686581942, -0.6832202964408286, 0.8542353357854674, 1.2657725085528775, 0.18342762449138994, 0.9167651863107776, 0.27968464195969905},
    {1.9753831273462188, -0.5938837095301869, 2.5930741386217337, 1.3077875357179922, -1.7791423844592373, -0.8205977509169257, -0.74579297329951, 0.05071294125480477, 0.12813900635330444, 1.5673682048556434, 0.28793458739434563, -0.8032190886051929, 0.2186218754417257, 0.22907305219530968, 1.4975126749820813, -0.6927736690322495, 0.26588670901118727, -0.11828476956620404, -0.0019507112429449256, -1.480147644865286, -0.4250239319239864, -0.7368435139048292, 0.6454347522125352, -0.583181785599457, -0.06611261937912769, 0.29094022266881936, -0.14800980592524862, 1.0492108321051807, 1.4191313231234794, -0.20249178482409275, -0.5584143249492499, -1.0607728170096493, 1.4257799760323886, -0.11446956428893634, 0.5438834194833427, -0.28124462349942486, -0.12673097437885575, 1.491496091095213, -1.2053248040192182, -0.6174733056119287, 1.180908631906183, -0.8656167639861994, 0.8076676439700998, -0.1766031030223917, 0.22774543410752807, -0.8932428782146277, 0.09653416914008658, 0.17026498928682046, -0.9322869863503023, -0.01716689525269603, 1.0306743225153852, -0.78242664885847, -1.0890118042027475, -1.3326931956242563, -1.8992291064458884, 1.313989058003906, 0.38964817249179945, 0.3702197030291156, 1.733563078500745, -0.45116203959161366, -1.1990764754324323, -0.1511846346894858, 1.1934877937510346, 0.074168807396778},
    {2.6439158706034167, 0.1762787100962376, 0.5038412283100697, -0.39439214680921575, -1.6679038946058045, -0.8051571958081964, -1.9037127973671955, -1.4854463911932607, 0.0013215004550593868, -0.7092221176198062, 0.16137387268982178, -1.561069688529404, -2.196154687855688, -0.5837057923720551, 0.2318424319087949, -0.014938743919396228, 1.782018137678873, -0.012608528396482386, -2.792845659184264, -0.13544569009537447, 2.7150289470887983, 1.1206189952797028, -0.0394952287719679, -0.367730794274621, 1.11689054919861, 0.8056804574088895, 1.147191933200826, 0.717468268496705, 2.032776890482304, 0.5159903820098881, -1.2699887899193862, -0.3827163353596557, -0.12316004990378991, 0.05979892432012542, 0.19556722271657814, -0.531408757215581, 1.9281475729437014, 0.28393034975379, 0.515657572583426, -2.459903447775874, 0.31177901046870726, -1.6489308255325699, -0.9585493239325912, -1.6841689857909976, 0.43399961080432337, -0.6333594233656384, -0.8449757487236795, -1.8287809388366518, -3.2632428355662464, -0.901939933340818, 1.0682623170686922, -0.3216953640769094, -0.2571946741553083, 1.5354188803602287, -0.8276133869282344, -0.8790134780703341, 0.7905165515812018, -0.004996692327657217, -0.6445683134327697, -1.510315738576374, -0.7601794914167855, 0.4773719503993693, 1.2624975916802308, -1.606516652375291},
    {1.1400113178673041, -1.0780331787260156, -0.10062155665106905, 0.6173656203054413, -1.3540176818207, -1.3069550008141655, 0.7284599193959378, 2.0022744787987445, -0.3198340887902125, -1.9374181544261677, -0.2268481874655996, 1.6534849337443156, -1.5063722668743724, -0.8667135840553399, -0.3004888213307787, -1.6358525021889545, 0.8927595264993838, 0.26117425754388474, -0.6039018375596859, 1.995107371655591, -0.04561959249811239, 1.670987099113771, 0.8283781850307945, 1.4035641932424499, 0.5587926884951839, 0.1830041347947204, -0.7690322196283397, -0.8114504621607287, -0.6551812507019522, -2.0979031618267086, -0.993437451861093, -0.10226980359922716, -0.1102177668113685, 0.8003043740287158, 1.5609185363843245, -0.9279722991837246, 0.9018654335285026, -0.03594626414953163, 0.6351182991402743, -1.0270598468402172, 1.4129389554615366, -0.5561034219025619, 0.07501777966004938, -0.5200104099969443, -0.4595046566952162, -0.9060031016491648, -0.5932158436417282, -1.407627274912732, -0.061923338229566555, -2.5174280856497986, 0.4509193981105287, -0.40824893683729174, 1.522551510677974, -1.018241586909068, -1.0171291720599398, -1.3609482604239234, 1.5370687368753695, -0.6536021474127152, -0.35947464706363585, -0.3105682102627696, -0.33698653342396045, 0.6781432118915468, -0.6114320439212142, -0.6692946698194779},
    {0.08322887615143043, -0.04296976130236431, 0.03561636759712701, 1.975426779074585, 0.7333372758718077, 0.9063652152443992, 0.7212462452196149, 1.875809135029614, 0.02993059549644666, 1.1476459093224913, 0.6379077339541459, 0.19621007876183252, -0.6579683933945601, -0.47925962443261944, -0.7582743491375378, -1.388055786807246, 0.10543323635254258, 0.4421412106203546, -1.1292373711703312, 0.522534213989032, -0.9886054962987061, -0.6689898979924241, -0.3737304711036849, 2.740297072541665, -1.2715541101512369, -0.0610669312322192, 0.05439964593115173, -1.7619983283855676, -0.39529214206026064, 1.4285973513979244, 1.11727945640299, 0.06575203117094022, 1.5088136230393252, -1.6383856408293394, 0.8427917817770447, -1.435944345961081, -1.5169643775678714, -1.0657239775192737, -0.4019362728586398, -1.9711399255362652, 1.7734835290614814, -0.5056872657180649, 0.7294905754960077, -0.5633447562640567, -2.211494189466462, -0.7219918054663113, -0.3000439808823903, -0.7379048630107358, -0.9319562735230233, -0.5531835905732683, -1.1275621432460476, -1.1081140814503028, 0.18465510421520664, -1.2114134418025526, -2.2143639188674236, -0.4652585154185566, -1.033630116477636, -0.27018672223450113, 1.3404171735533412, -3.3448434931552073, 0.6529772823154879, -1.1810085302121869, 1.9695597191100598, 0.15746437988160272},
    {1.1015883287672807, 0.7541273732610538, 0.3130335374705825, -1.3842504321087172, 0.7594498161754498, 0.4615244132997306, 0.36214897472868396, 2.0372175054273667, 2.087328884912017, 0.8726982898266206, -1.5376911941456983, -1.8969186415268091, -3.01492682145206, -1.5130326912519287, 1.4294679219840964, 1.86778535251556, 1.5269876843049983, 0.5573084022005323, -0.2567153813786985, 0.10071729988370337, 0.2027087408769508, -0.5570051958436767, 0.21848372662615304, 0.47530152772102513, -1.874321375869235, 1.9993390013704713, -1.7386023228074605, -1.9018066022449827, -0.2029105596503542, -0.8270102904653766, -0.625607163390341, -0.8871083665950643, 2.1286556076918335, -1.1347669456632348, 1.0406781017450555, -0.2279336686704796, -0.6019534275843383, 0.11040298211002432, -0.9312109111738912, -0.7156397367686194, 0.4665105514205375, 1.2872596301939516, 1.1162265761148151, -1.608723119025561, -0.9388588866469159, -1.8736534438691679, -0.29079717298757696, -0.7333224809070766, -0.3018641987140393, -2.1649472462147856, 1.6927905048743095, 0.12813614334575685, 0.937445247230101, -1.4857942738815348, -2.3025556727372387, -0.9272167765100788, -0.20743016049177718, 0.1696284002357697, 0.18183569661242877, -0.13120952959957755, -0.47792583663476323, -0.6695662403384989, -0.26527857284915723, 0.009637688458446057},
    {-0.3917397033159549, -0.2702202290231955, -0.2506879393255603, 1.1764575150995924, -1.7374784603868, 0.9454329744455363, -1.4083541888094675, -0.33007251319419423, -0.585102314190564, 0.490601330263762, -0.3626462645243505, -1.406494019454866, -3.202545910727842, 0.6728762957321536, 0.29255964014085745, 0.10292962627708507, -0.3169585904001906, 0.4675416743023036, 0.8518907204834186, 0.43359710310233324, 1.8856922284514437, -0.24388377943478448, 2.1161948698018263, -1.5146270275359746, -0.43722711372210293, 0.9265697707205438, 0.9331177405198108, -0.488448983258185, -0.777611783169246, -0.30942589741858934, -0.24606693036326155, -0.27730104942344436, 1.8939869560248006, -1.8021570841605432, -0.786824564393069, 1.1032068242136, -1.920216531875342, 0.16753260166675807, -1.3459824859181078, -0.4842596106934666, 0.7459232241985823, 0.5503372524586616, -1.4895590938538237, -2.7937502144568596, -0.33643078754225775, -0.8654247320811702, -0.4210028490571083, 2.581540265674399, -2.0366130177988455, -2.0247506161050315, 2.253937527938932, -0.3971339159085058, -1.0594711280500755, -0.12319587667472441, -1.902870655909669, 0.9236403639870813, 0.23710676543417109, 1.2293032368725547, 0.18051322352020543, -1.117279900009129, -0.15957368079586146, -0.3894251592163875, 1.2966017255894366, -0.7476186842292534},
    {-0.049632186332784184, 0.17056472813044204, -0.23437398974510237, 1.87969044515244, -0.20396633533068173, 0.9901276712966158, -0.8309338637050807, 0.6581627849022272, 1.0126028631916149, -0.940965752983872, -1.2109470410566217, 2.3817794072469542, -0.18767221147712534, 0.42077784015878206, 0.2888347577599639, -1.3767698639494905, 0.23679351715381433, -0.18030012593758038, 0.4603894587274828, 2.233126203222186, 0.6900555223950848, 0.22124995073152298, 0.46986282828681036, 0.563777404065916, -0.45619223283255467, -0.3381120060417489, 0.20398636154203745, -1.9364526684137988, 0.8996528670943861, -1.0972261703997386, -0.6901191979557622, -0.8694252185309053, -0.08331903902057082, 0.825937123149271, -0.7652097697624947, -0.544755575088635, -1.1384488200128529, 0.7112165776567752, 1.0772740300341974, 1.3120216956417157, -0.23116075989680956, 0.26680919232797323, 0.6750435849239734, -0.2764726300643796, 1.700671625710854, -0.03776872085939454, -0.15893776836377982, 1.5004597353618363, -0.157962149602107, 0.09325619123436336, 0.9530903393564217, -1.4955549782256214, -0.2209568557412636, -1.3959926806851237, -1.6885464187919106, -0.6292325135451117, -0.1568916702604124, -0.340369682184342, -0.2547047882290446, -0.965345202468532, -1.159354894098417, 1.6083833323214496, -0.8946581410542488, -2.057466458377853},
    {1.5110999277620136, -0.6788965050596559, -1.0763554227384642, 1.0989184407013777, -0.450878142909311, -0.0812098242731086, 0.14154510165162734, 0.9238070417996253, 0.9757180967810815, -1.2342896197683466, 0.13754653732986596, -0.10111256013129792, -1.6350565218926976, 0.9392801560816377, 2.2872643185077104, -0.23042195221081593, 0.5146034181032719, 0.9146674663050185, -2.160396697339576, -0.7025471901085545, -0.9338318669675028, -0.062287885538595884, 0.9239756518044207, 0.1497587598738946, -1.1938210062113586, 1.6702026872320195, 0.24538989868505792, -1.30277577339866, -0.03901405358295863, -1.098964520176208, -1.1340564064454053, 1.6398287224675918, 1.024669876184947, -0.7145083140188611, 1.1523688176020817, -1.1091222306420412, -0.20830368101522412, 0.20272241990874032, -1.6722114730045678, -2.1658153769210466, 0.22832998537874896, 1.2803900070705057, 0.18122461485971855, -0.167163812766135, 0.8437115727150456, 0.012663518491081667, -0.5736661259420445, 0.20447828218422304, 0.6858464763084053, 0.49144396001605317, -0.404652974115223, -1.4170792067971691, -0.5334004976932203, -0.5697871522247309, -1.3595912070570437, 0.025873406929828934, -0.11953594326457598, 1.17181751726018, 0.06788278368968964, -0.05249045565141942, 1.4453927984685628, 0.1200075229337591, 0.7710932402196269, 0.3813079188562443},
    {-1.7094152708184034, 0.989023802567946, 0.042672766605350396, 0.386596237029823, 0.24311471877775181, -0.21381120258835334, 0.184722841188202, 1.78015585278029, -0.8433223206989674, 1.9937722394252415, -0.9798560024009433, -0.43698283426860984, -1.2990916862745063, 0.2718694020954736, 0.9348542511982267, -0.6268419422567757, 0.9457345153694573, -0.1641448955747887, -1.403739602697751, -0.07505699752021865, -0.10405740414088399, -0.6048021294604246, 0.2900017265452405, 1.7433595642116269, -0.7243464596547609, 0.63301003470677, 1.3485405076460482, -0.8623753175139759, 0.17578730025758021, -0.9348019969361537, -0.03909457034176679, 0.795629917168632, -0.342955164624515, -0.9619220070078948, 1.6605110244402734, -0.34427042858056656, 0.5770801130020098, -0.16687605038533534, -0.35142323594824326, -1.0111214663860246, 1.1601361245568922, 0.6873392558564315, 0.6404796125484415, -1.662659800295214, -0.7789341131318357, -0.2168414600804259, -1.1497378753448655, 0.4227949338846401, -0.6470223911857361, -0.7795892451367973, -0.6610463888393355, -2.853986694492758, 1.8830525413842756, 0.5257879797955639, -0.9633794542551183, -0.18465898652430265, 0.3184388243335987, 1.1471618987034176, 0.36768297889330204, -1.4219778321805019, 0.08090591853999167, 1.3600564551789138, 0.32714961970043827, -0.2918480317887683},
    {0.24313121980319366, -0.8728847007348239, -1.734964527066743, 0.3187178171956118, -2.064227027542771, 0.5870078305118034, -1.0048077875773087, -0.24499278826864568, 0.15117810797461742, 0.27915044606538286, -0.4324767224320161, 1.5321217399540272, -0.6458266241645317, -0.4814945624790906, -0.42077740784090156, 1.351357339406656, -1.064757456658692, 2.1621490585844403, -0.8316875761366567, 0.6758084290462208, -1.3081664889841538, 2.6524269750938383, -1.4593650542731316, 2.917617521502201, -2.1611178373484154, 0.8413157434481866, 1.0300070357166045, -0.8957687811885527, 1.2420310364146376, -0.5739142100797249, 1.9283120578610797, 0.26895526342347287, 1.9795037625918877, 0.49114297610549035, -0.726338587234973, -1.3106188771789555, -0.3681704180564258, -1.0077581727964882, -1.3283554719829336, -0.8596520446641346, 0.5626506824688906, 0.9515088435089983, -0.05275371064585816, -1.1171455470764198, 1.3843775689441462, -1.099179237971335, -1.1169380842297867, 0.09756346816137412, -0.8739173620233445, -0.2284643794114746, -0.2601983954108092, -1.6035732909951586, 0.7390314601951478, -2.4776897145466372, -1.157988927149567, -0.24847376309152774, -0.483984906471039, 1.7761078002096524, 1.3234560272792262, -0.74579260146774, 1.5440491400949852, 0.2757908693466323, 1.8538898688126662, 0.8042200626625725},
    {-0.6260573036210357, 0.6080778659780556, -3.9193748340381007, 0.04394940661484732, -0.3281956723152437, 0.6613419363331179, -1.330622139123227, 0.023198576751686163, 1.43782763515304, 0.6230799498114784, 0.508183662805404, -1.2381936121258632, -0.024012583923971393, -1.1734369303911012, 1.1188598371481746, 0.06001827329534807, 0.1951975740401485, 1.0166217213853221, -1.8207432316362109, 1.4885570748205523, 0.0077606043841924165, -1.362315050745328, 0.4842027676113953, 0.9941291234417028, 1.7868469813480203, 2.785463635443481, -0.5071766714014294, 0.04065320332415422, -0.5700256991044343, 2.1911247683577093, 0.17614299243285442, 0.6575712182658784, 1.7301110877053938, -0.731812254022243, -1.18803487296871, -0.7391505918033796, -0.6345100548306892, -0.29151273753664536, 1.123373737963279, -1.7369064666583516, 0.8928162242418415, -0.334099687908136, -0.1729043809668858, 0.8022548723925297, -1.1672169277860904, 0.6434433155102919, -2.4590853793146876, -0.37556394406370996, -1.2048841900129492, 0.44571826739325476, 0.6158908666567326, -1.855154384410596, 2.5924319510657043, -0.3478455794106188, -1.5324246123752006, -0.33538792486638785, 2.6917025540020854, 0.8992282271213634, 2.2036156741770436, 0.8428627468722959, 0.5387926202802172, 0.9430804567955406, 1.1018012204669547, -2.762736019847038},
    {1.0534382453656084, -0.5714075962121175, -1.0268111867890846, 1.2359725224734335, -0.6542563042825692, 1.4741473647015757, 0.5960731425895927, -0.5640871522678809, 0.3237164634716813, 1.0406245275852262, 0.03473799999448365, -0.31066859838951943, -1.072157671976575, -0.23332861387448314, 0.6062291771999891, -0.667240498770215, 1.0653781961972077, 0.7602027109340727, 1.2693182562510759, 2.2797340723066726, 1.2610368512890646, -0.07351434166478678, -0.34865154776474566, -0.013574779366677173, -2.482883973039012, 1.1443604120183177, 2.3915626044058285, -1.6940201728258557, 0.46231599671709167, 0.20432280507740516, 1.9855880287737158, -1.15879138550758, 1.01857793619828, -2.3362224658411876, 2.611062413617929, -0.09863117430888603, -1.137794136854951, 0.8127985771984879, 0.005586662257935389, 0.2342465008158835, -0.6585491794687829, 1.3073671029197431, 0.491594389181754, 0.464622354612175, 1.287068002864772, -1.1919291236796947, -3.9960358570091796, 1.106554241832795, -1.154940554156262, 0.6815442491963896, 0.9861992173506862, 1.2498447720252301, 1.3965190724071155, -0.6816747184865906, 0.019922277101913393, 0.28783234907027083, 0.7786341142272682, -0.3627127593392316, -0.2882239963562348, -1.9676361462392247, 0.3094204053190148, 0.42949595101992927, 0.336747662564334, -0.21232155776226244}
};

static const float b1[64] = {2.308156237164747, 1.899023809037704, 1.6764264809319784, 1.180197466701773, 2.287272930905651, 2.061569821527798, 2.013368705717588, 2.043338501077693, 2.211368478378767, 1.6075561380408898, 1.587919911917316, 2.206590636044443, 2.352918257066506, 1.8695992237925143, 1.6270724176629328, 2.0586460684481103, 1.2916453734918836, 2.093303305137375, 1.7869528795319458, 1.404181307753456, 1.4390149616856887, 0.4582046654450545, 1.9252508095385699, 1.4008131912603257, 1.184422780723026, 1.874362027835584, 0.9710568040730843, 1.8270617226694335, 1.112040465970121, 1.8961562839964687, 1.9735740424389276, 1.4321791201670333, 1.5175022363910038, 2.175161358131798, 1.90917972347395, 1.9647610200062784, 2.4044095886878636, 1.333856370754663, 1.8022205992827893, 2.1663154163292844, 1.8556480759250364, 2.0861993065291786, 2.280271252507992, 2.244087122195692, 1.9309675211035633, 1.9621338233570287, 2.570066171590825, 1.5712693989179192, 2.459924734941095, 1.954590335780353, 1.388553978163738, 1.9025521069417484, 1.1869087186328655, 2.169099209405297, 2.6342728541450526, 1.7822431984702407, 1.579012042747959, 1.664591325521814, 1.0948417315459305, 1.6049730251871426, 1.5315103600565507, 1.9586243299519663, 1.6050099402800961, 1.5664946666696884};

static const float w2[64][32] = {
    {2.0164502495852523, 1.5270231826179008, 1.7749176903207524, 1.0175241073233001, 1.4368302589320845, 1.7144865856294116, -1.085121847663092, -0.9363953516943533, -0.6364202868888666, -0.0649344359243092, 3.0205132109715898, -0.8961203500385709, 0.9585416972060046, -1.1767816496271353, 3.140428104972957, 2.247359506520542, 0.5168736869323619, 1.109201605656289, 1.7138962953145707, 2.0282985853422435, -1.0248863689476362, 0.0940920893289199, 1.3081493566461109, 1.2142447606641014, 0.325366306248639, 1.8145266261128374, 2.2357558594991622, 2.9305646885822543, 1.2712399279464506, 1.7959083077709994, 0.32350994267770466, 0.014140540370159332},
    {2.620879764551433, 1.40159610284661, 2.388818746961828, 2.155532107623893, 1.5731635017551322, 0.5723969732395527, 0.3946135606856648, 0.24845861833382546, -1.4799713363949603, 0.06993451750408387, 1.6898593031216815, -0.6814613059220463, -0.0071303845373770535, -0.4962375685351813, 0.8078449547831317, 2.371750130042772, 0.10717970334474158, -0.16099194606034462, -0.021485835932015376, 1.6004419196089974, 1.3845442081521495, 2.787561911204789, 1.2821772394596371, 2.2154340201447598, -0.567098754952723, 1.2994634137991896, 1.637405279248506, 0.8949901729810966, 1.101578220728537, 0.6478130274298549, 0.9791069501885167, 0.07862868239159612},
    {2.193915806947693, 1.1263741366189193, 1.5955997155953114, 1.3990230935741756, 3.3327956344879817, -0.12141374463232493, 0.8960533447602185, -0.6444306803122363, -0.7707693968793162, 0.15274317332962073, 0.9406236114039924, -0.758177238757024, -0.9376226954358362, -0.329541184327026, 1.7506276829566036, 2.8615360506446725, 1.4578134034151644, 1.6486322625259633, 1.3163910587860659, 1.4485815949904386, 0.041758826969449166, 0.42838222290503875, 2.2928682908953433, 0.8727449635408666, -0.21913558966702587, 1.2651173048825317, 2.3498851134098495, 0.20698851383932154, 0.5581785477862627, 2.00058957969078, 0.7654014151688284, -0.3566127695564946},
    {1.9067213807523629, 1.7247514654900498, 0.11250871016561582, 0.9634163350198396, 1.9422524077508665, -0.051865044653547146, 0.03015996461145905, 0.9200193729134415, -0.1088127569085063, -0.29161081951369444, -0.6369598047927897, -1.2550914239118902, 1.8052068466210778, -0.5808509361034861, 0.8278197704746717, 1.8965476877690117, 1.6637914091935193, -0.13650585533808057, -1.317202501141811, 1.4077296267895396, 0.7709529965633679, 0.6215276047333934, 2.4514880448407776, 1.842558767640776, -0.43620032997340036, 1.0096626620100675, 1.1312863203228918, 1.3613973396988674, -0.8960274100773552, 2.1481344057984, 1.4074429508229702, -0.01121024151721261},
    {2.4051325195730637, 2.1533981737251957, 1.3999840405406094, 2.4389509010736057, 2.0431505640212806, 1.0796405342297997, 0.1629236146082685, -1.251861859295269, -1.6660915013254711, -0.7488144670544643, 4.145900878276175, -0.07055369127688317, 2.965369978083409, -0.2059448341921879, 1.2526035334677896, 2.5590438705536163, 1.1596020287294386, -0.619433260099882, -0.49407055487227225, 0.9206366650179019, 0.2440245271366892, 1.5953579958118222, -0.16837908114527797, 2.317568816604299, -0.22899178753460075, 1.6637220140820543, 1.8143057374441651, 1.6766400712527554, 0.7540431422225679, 2.8412455377655133, 1.7731835899237807, 0.3002795417614927},
    {2.1866292127368463, 1.794915383468888, -0.4676606413132098, 0.4742656269785735, 1.8343571183630565, -0.16319856312292116, -1.5574432810074479, 1.1907750317192791, -0.2834909091959321, -0.779309039667361, 2.502420534237932, 0.7702090440618606, 1.4371623870484984, -0.5759289358837762, 1.4331240911039451, 2.703406991302658, 0.07964581824472328, -0.41264029772150596, 2.810836102506315, 1.0903055855289487, 1.1912773153461833, 2.3101748058422813, 3.1507388773432976, 2.455917931708832, 0.1660151589893715, 1.8442764007988544, 2.498173406056605, 1.1545718868897845, 1.6631028428010037, 1.2671702144626131, 2.920683656359367, -0.7539086620066958},
    {3.788873969181573, 0.5281603800025645, 0.41480243378660325, 0.9696609846781374, 0.1619849436610912, 1.5753196943456338, -1.3781558038696295, 1.4578012240068436, 1.2361868936307585, -0.004284363396414659, 2.47884016835434, -1.4258822876704014, 2.9212047361322293, -0.17839438328373974, 2.935790283913189, 0.18494482285953173, 1.809995997742667, 0.32247231917584585, 0.679482657934353, 1.8820479505886276, 0.23963609390848564, 0.9839469549137927, 1.2277388263149625, 0.49386018019094347, -0.6852373220444065, 1.402124752512459, -0.11688148153340859, 2.835025959038979, 1.8686300489747338, 0.9538036095240591, 1.9635242239456392, 0.6220016291047882},
    {0.2658781317178847, 0.8530121649387589, 1.4010908549895404, 2.2413812630406964, 2.096553318451284, 2.7528766328923546, 1.1437636650049652, -0.2938081135617354, 0.15327073378030995, 0.7684485233852286, 2.5290662896646556, 0.7233806053834536, 1.3645422112248276, -0.15760787913241595, 2.0430454246659693, 2.882272177493792, 2.1879854185633714, -0.3768629815466282, 0.07296967848322254, 0.6662141520778526, -0.49822338095063495, 1.7842079669328768, 0.07422048250602697, 1.4435362511307994, -0.8443180287038328, 1.7505313570726975, 1.5430010327622048, 2.962342403874225, 1.007824752110046, 1.5708373391949813, 1.1927862595129015, -1.7881105159616817},
    {0.9108459256756766, 2.143830428251201, 0.7783549179193477, 4.059392071343721, 2.483097490820903, 1.9751514252410918, -0.5100787769254174, -0.6581242578526385, 0.026173473074842194, -0.4734412533682919, 2.646322002234436, -1.2218636432142815, 2.224887597744832, -0.9127361871867627, 0.9133038291761323, 1.9758880940476224, 3.1456212196546853, -1.1745278039081237, 1.9154981061364702, 2.0465637096211613, 1.269219672695808, 2.552230459568772, 2.877430501356828, 1.7502609552587458, -0.09968948399210671, 1.8023094666509745, 1.718995755787809, 2.1487807640176144, 1.8412540734320413, 2.3103903769811223, 1.2435008883799072, 0.8476860972327307},
    {1.5750044863176076, 2.141595165170554, 1.671853305148136, 2.012459110110877, 1.3469612666490824, -1.3750687206954944, 0.604290605361113, -0.9502790181107678, 0.6449727361063737, -0.2919759987129719, 2.5999170178307875, -0.4633559887606129, 1.4488215192627798, 1.6074866093102687, 0.12403655932145778, 2.505042984634953, -1.1801455255395612, 0.3762287182380144, 1.3619212914899945, -0.26106864269601204, 2.53505222437762, 1.1035894488664568, 0.8346656419987831, 1.347252436998367, -0.3515482783145386, 1.0352877647384642, 0.8061346989343361, 1.9661686004908268, 0.5334428025188448, 2.0739426159195418, 0.9057660201346162, -0.3648205040834518},
    {-0.3930829878058476, 1.8719052744538902, 2.435623792647421, 2.8263306688973904, 0.7807837530095522, 0.3791164255821478, 0.21693349131647302, 0.7126429231685785, -0.18979065972689332, 0.059855825131955274, 2.1880122633956978, 0.033095295559843065, 2.6474721195047803, -0.8062054567446176, 0.3690007920380113, 1.316862099278361, 1.9155558663850876, 1.5224009617125347, 2.17588907639175, 0.5505036813117351, 0.8687364414266638, 1.8463078194100675, 2.285414878724785, 2.4331600047520356, 1.0090249587345428, -0.5543461371492406, 1.4762219579746454, -0.3506095742525707, 0.9570496038356968, 1.323485787006043, 0.8186082093095038, 0.5897505322546557},
    {2.4271691600594707, 1.8781321883422508, 1.4279676804669952, 2.4538559365797727, 1.4672315962963796, 0.5210063019827567, -0.5729525435235423, -0.5374735053878119, -0.00042071036018913186, 0.6204345006755354, 2.2668452370884884, -0.34501683036404024, 0.8659559385834612, 0.022945887109030727, 2.281788791663864, -0.4661532582377828, 1.6572497546286487, 0.16470625327685326, 1.3223971411681357, 1.9720772047664963, 1.159928593096733, 2.2800810723923224, 0.8216006261419615, 2.179132260173373, 1.536908842451345, 0.40863256155876154, 0.8748403065848671, 1.659091582143971, 1.0418570680362804, 0.8480180981529521, 2.511347337063397, -0.4103214844847007},
    {1.922466846415859, 3.8588122876426825, 1.389266587414525, -0.08316296235526541, 1.2117161052822947, 0.49600400876380246, -0.2792397402684863, -2.2788247538985975, -0.17906429553324232, -0.34716173898772373, 3.123593472109095, -0.1596163668922181, 1.783907771377949, -0.1639449365209361, 1.1817466278730377, 1.1033007398614265, -0.2784407900601204, -1.5294426558242848, 2.32743900881847, 1.9908901381514157, 0.40462959745339067, 1.199612160593918, 1.015295837765232, 2.4123405563909013, 0.6718962625475029, 2.016261101167303, 0.8684848630718074, 2.668372478770498, 2.045121342487699, 0.5349528226195776, 2.2336903736193054, -1.244794537092404},
    {1.2247212677189678, 2.741896130381825, -0.14295023122278017, 4.8896278877407955, 1.693537584333199, 0.8196501858975505, 0.9058070084305996, -0.12226871414392114, -1.3894371366487823, -0.9912148884372676, 2.39709152232035, 0.8732414227694099, 1.3529900645162807, -0.7440042696448649, 3.2978432905686104, 0.9085095224457829, -0.38378494639497424, 0.28556555577788456, 0.008432887063605456, 2.0705672439139104, 0.9192417748980012, 0.8728492802872786, 0.549303796240392, 0.9094688354552729, -2.5472456953129976, 0.8031620022549177, 2.549711331082957, 1.6591127614469487, 0.8731676048920983, 0.7751723482940022, 1.8994192278346296, 0.25083191448676245},
    {2.7523156758056837, 0.8471220691333536, 0.09061088144757827, 1.8460801376765, -0.07759839991207987, 0.6596543644268354, -0.2747877082843185, 0.4938260539195735, -0.2947621940315285, 0.4954596775276111, 1.7580969679483127, -1.5543254263142101, 0.6431609881016909, 0.5728386080927911, 1.9269663915663313, -0.3833849440668633, 2.002518025695934, -0.7057244127245799, 0.6688389506348164, 1.5042587332144288, 1.542880848524279, -0.3007435044753977, 2.2134557050133323, 1.4598065677459355, -0.19543025689627835, 1.7462584618166568, 2.7286618289796603, 3.0735472069106216, 2.8816063434237202, 1.2832975540457958, -0.5194927705133865, -0.8881931520472376},
    {1.4345347034972933, 2.7723208414309997, 0.5277928043609272, 1.9136508275225157, 2.607056388095194, 0.33871661544771703, -0.4584963287464128, -1.06640355665611, 0.4968562773832041, -0.5124478432827796, 0.3259582135723269, 0.32378677348781687, 2.8814167366342485, -1.3007308779806726, 3.1714335295791978, 2.504840457136607, 3.242598933364407, 0.32581218557596936, 0.46059131840791206, 1.912688936691196, 0.4964410309691031, 2.0974763262273024, 1.4284904678031138, 1.960389472821114, -1.275882663136496, 2.323586791111732, 1.8091167962355386, 1.6864478597424941, 1.0640800300023687, 2.3599560141323574, 2.4844490444224605, -0.437663198206875},
    {1.6262343802939703, 0.5776990172606838, 1.0702290701462975, 2.9028894121447455, -0.329937211088724, 1.3044610572115118, -1.2234907256794583, -0.34816778659858033, 0.4424937960630045, -0.02174435843426946, 1.413757498469514, -1.6092784765943844, 2.605157671996291, -0.36612569926410915, 0.5592165122470428, -0.2519254293467305, 1.1648490032114531, -0.385364693665631, 1.7511345162830914, 1.546403337031591, -1.3558781023015347, 2.011788959591724, -1.431392394126373, 1.5360262081812728, 0.23723725598517337, 1.9160809174683815, 2.580714355328134, 0.9100728550198969, -0.7167970590261916, 2.349985692612582, 1.7795816689465156, -1.3644490701021286},
    {3.0474749598498, 2.5695045554912963, 0.3301872380759034, 0.9037571074340236, 2.270937148915634, 1.0322781806183412, 0.5321343032618862, 2.208678030537437, 0.8338883197873274, -1.490547403896574, 2.063379479395267, -1.934091153765955, 0.26639137658234596, -0.013022032683845516, 1.15662801190219, 2.294291990945213, 2.405929506202498, 0.6365780206383068, 0.2358250955933368, 0.06115608266209385, 0.9250090649168802, 3.4246670375980135, 3.641676053241894, 2.0190631005116564, -0.8992801248102641, 1.441824805313046, 1.7411895888054505, 1.9803141929825812, -0.33045137632689897, 2.447609901473516, 0.7323873538184194, -1.479860090463881},
    {1.5749655831122067, 3.165177177093718, 3.223705060528937, 0.8665829711918092, -0.013298589566270183, 1.020609558876648, 0.5377222358430305, 0.18834826761019088, -1.455874732873392, -0.7139230535559398, 1.4076574758350364, -1.2147173831820512, 1.140105244077719, -0.36448798760481543, 1.1186777661325498, -1.15292086660938, 0.6840416631946443, -1.250340430171292, 0.4751268311951439, 2.2666365056019138, 1.5085670902914772, 2.9718266469390398, 0.12419308941455993, 3.2900379669220152, -0.9121316981078302, 1.1241137472230194, 1.3520730021988683, 3.2597702299767515, 2.582149591053177, 0.6020873150073461, 0.3519606104216508, 1.3396640126885289},
    {0.9960689688298419, 0.9370733990025399, 1.5643008962851443, 1.6282156405547548, -1.3567158132320905, 0.6928127106023596, -1.595080293030378, -0.5885081153478392, -1.2278513701876743, -0.038127455178838005, 1.57386304113868, 2.1113679547708166, 0.8265504379223851, 1.5642540152802908, 0.6136750146468917, 1.9004161444619714, 2.252041187483265, 1.8158672570655718, 1.8997543192382604, 1.4749674591779374, -0.07889610892074611, 2.531838285418318, 3.2973962580019074, 0.043512275404921426, 1.0015030321975222, 2.4673504278979537, 0.028861588467056064, 0.8589860360690947, 1.185172789634675, 2.0626899576944506, 1.3318341926278945, -2.5835188662965454},
    {1.1711126672716776, 2.005847804042331, 1.3039130222655888, 2.340109007629239, 2.335702618632071, -1.1786805903553816, -0.09586669277172545, -0.05782327844603243, -0.13227859618588655, 0.9304160639315388, 2.0982048417900585, -0.42264318372717885, -1.3412038763216105, 0.43824630249433516, 2.094313152270349, 1.9097038968529225, 0.48957946428247257, 0.04216638160345379, 0.6668392549353904, -0.06062343939668903, 2.102061023885888, 0.42949337137990146, -0.8398923326171318, 2.1235631693671047, 0.32675467199498326, 0.5780135219941539, 1.0354621664703028, 0.8814871254104237, -0.19525356743894845, 1.40159364239582, 2.2282750898976924, 0.17952609428468083},
    {-0.44640813610697605, 0.7216040938469604, 1.1291748959783359, 0.8363034888014952, 1.2243685293157858, 0.1307930334300202, 1.6932556134139118, -0.7715401367018051, 1.5198638405834248, 0.02945406944320304, 0.14980435036646317, 1.708458493990487, -0.3011604056361521, -0.7729449270307844, 0.12706309130209878, 1.3911615412358371, 0.10166695811802273, -0.37051638859305935, 1.5004782895089603, 0.8765818021659683, 0.022694108462253743, 0.15849895076924098, -1.3684707424346167, 2.00672261690445, -1.4665346726548563, 1.9884281878351742, 0.6987262285423144, 0.6076555915200682, 0.5957631575000749, 0.7394991580723926, 1.3343087596482752, -2.543443502992686},
    {1.47104114168824, -0.36253221421784443, -0.6105507086584736, 0.9531707976484791, 1.717609822931425, -0.1098076621817697, -0.17271971055319785, -0.5636552504899882, 0.4405979250654027, -0.6569341443996007, 2.9004453055373216, 0.6693608348382581, 1.0088164372040702, -1.2368219216990521, 1.0112401717004107, 2.3208780948682177, 1.1453961900495087, -0.803651264637454, -1.5865256133245231, 1.7246147558966545, 1.0421439815800624, 1.551205846644731, 0.034007274504711034, 0.2937708033558196, -0.08555427400878157, -0.6222392465927724, 0.2155843179677516, 3.4313748946512095, -1.7130815430239021, 1.7499137868777774, 0.13014327261591074, -1.3876861096259465},
    {1.3545887377507644, 1.4033873218882071, 1.1559509975532214, 0.3594657911305661, 2.6917028488034633, -0.29758985885536654, -0.46532314316180223, 0.10373474044323655, -0.697336353409045, -0.43336714738066845, 0.6800194635695439, 0.29348908513677074, 0.13826971146662914, 0.4950314409916977, 2.106092208874795, 1.7023163202821447, 0.44518804807234486, 1.4231250657542416, 0.2875095319235394, 1.5726583386599287, 2.4835796964817316, -0.4875033387409385, 0.2645122595649341, 1.4467062256547185, 0.24192692935842453, 0.5529170589565184, 1.555981230947287, 0.7251295438199709, 2.4771446110924855, 2.1228536393271016, 2.2520146559264695, -1.663616826515948},
    {0.7924700325144103, 1.471659330102711, -0.6408569932135983, 0.3650885655843612, 2.4087975085528135, 1.9722215038335893, -0.34807239899738773, -0.7388069139236245, 2.5388204391568316, -0.8755337168580697, 1.3033700205242982, -0.21973666427844976, 3.0884660337063554, 0.04476987447766513, 3.0936898291141426, 0.3347068437333143, 0.5861290399991248, 0.5181311746550431, 0.8016465131634383, 0.4825023014808064, -0.0452967349970318, 1.2506952138749556, 0.89859706352041, 0.09250950232926453, -0.4057806189251246, 0.35295260111430676, 0.42008880569230866, -0.07866933027336297, 0.17493043113228415, 0.32854133313832845, 0.9917131298709423, 0.583308208140063},
    {1.611398450358748, 2.0218230847112904, 2.001353334176481, 1.6297223098147195, 1.4755795773017801, 0.49648984218863046, -0.8360535920241425, -0.5671745266516083, 0.5809164373753799, 0.35375564739418, 0.5935166782025414, -1.67037373479787, 2.3150287333830706, -1.2347822709908591, 1.9782202817924421, 1.8568342584551143, 2.6500290440594787, -2.2602753407588754, 0.8247174447837169, 0.9830694546779278, 3.1230852704029055, 1.9187332574807678, 1.3179899630464993, 0.8363844446512849, -0.8988453901501703, 2.5244244275334426, 0.5798193683196166, 2.3192880374023663, -1.3516381859833848, -0.316412430149797, 2.553065528170777, -1.3344471636518416},
    {2.1846166274003633, 0.47734356002826545, -0.88985618345852, 2.187173192051864, 1.3751391696690407, 0.9981094451634123, -0.22908204168258472, -1.1976874720373747, -1.8847380833522445, -0.1530371030554215, 0.7437529824487606, 0.3406890271306798, 0.9645027367537575, 1.23199796883935, 1.6424615727709118, 1.5073411306446305, 0.7448558733100945, -0.6523799129384525, 2.567136200878335, 0.8682776085221474, 1.592653894764165, -0.48448099746003587, 1.2003357470580394, 1.41206540644933, 0.3851708140189361, 0.4555095665496037, 1.3865738397414087, 1.2935188989967465, 2.472763581555725, 0.8992920732443648, 0.34854324727976566, 0.6223056645860584},
    {1.7515514766077491, 0.8329851790865614, -0.2464272146780092, -0.7497819408247409, 2.292772870847265, -1.362884381268737, -1.7818344565051214, 0.6810809969940734, 1.2870243986385315, -1.1747368840385741, 2.7083140414333458, 0.24248940335862015, -0.6838182673102148, -0.04065958959430457, 0.4039220572446492, 2.0553894493560487, -1.061543411256493, -0.2080146035180789, 1.1442323158273684, 0.818890828150251, 0.7751648177107492, 3.291992170452531, 1.0754218668141684, 0.7823666156874843, -0.17956915333432288, 1.2108225574283462, 0.6438703124920568, 0.5839178369022473, 2.4929976513744747, 0.5893034861274787, 0.11799512374786554, 0.13826033825893938},
    {0.865174564292525, 1.7632361972958484, 1.0538481915861522, 2.4034714971595443, 0.23605242305827612, 1.6144865484800774, 0.5947737198060676, 1.191905433508948, 0.07200592022326006, 0.6930523630331911, 0.8561296087307169, -0.8397618485104753, 0.9562627058952008, 0.3584386403457658, 1.2154683268524666, 1.2290962951601414, 0.610415689207036, -0.9489431162354955, 0.9841320882501903, 2.3056500451413973, 2.432622436813561, 0.3936822562952569, 0.6925821988533057, 2.0774790201449207, 1.1560201840793585, 1.3589966083559235, -0.10004501782526393, 1.7108076308599527, 0.6733055912993965, 3.981382369026813, 2.232302462562355, -0.2965290510376235},
    {1.2442661857364843, 1.8318723847626655, 0.9427093254130933, 0.6414476381425523, 2.0715149322155137, -0.7883024432819036, -0.7694876230708579, 0.15255739786153666, 0.9671547183360067, 1.0263464375982922, 1.3952920417691315, -0.3782728653808233, -0.05764582818388204, 0.5699842421746238, 0.4970984934740824, 1.8352720776383382, 0.5831411721061887, 0.02275530891958587, -0.9192466103517971, 0.7979732681056145, 0.43935611528569785, 4.396444026182572, 3.877163764812756, 1.5935339417741854, -0.9269383667403563, -0.018495410808400364, 2.355140354911364, 0.8463216504194622, 2.1517329488255434, 0.8040769334559412, 2.1009667457244317, -0.7626967751969594},
    {2.708778257589816, 0.9146895062932533, 2.169055027568156, 1.1572987524752012, 1.3380401103050508, 1.508203557121074, 0.1528234020198336, -1.214180236803184, 0.028552339865558475, 0.4384619365533083, 1.603888695055312, -1.2163646567691222, 1.7264051414822383, -0.6231885545568183, 1.8126953561444232, -0.05815241078232483, 0.14416503757374516, -1.393470901422338, 1.2150715842585338, 1.3045958097381554, 1.2320889944492268, 2.264944112393293, 1.8275080297014419, 3.5958558100134512, -0.5782635369036351, 1.8043022140530143, 1.740574310406873, 1.3459873270872358, 2.2548087005647734, 1.5190084430719992, 0.6543600110640532, -1.0236743756271636},
    {1.571222716055857, -0.10485274034220249, 1.9201089237192934, 0.04878524748626008, 1.239717523367132, 1.887071871432812, 0.9033985247315296, -0.7702829040894424, -1.1446067397314532, 0.09496331215687297, 1.302860507240881, 0.43145833325632466, 1.8176574361398405, -1.3503251586944185, 0.5777783934419999, 1.8206013991960357, 1.0667981211249424, 0.05947770284800447, -0.08315544868357286, 0.10961534386764431, 2.3133675463749546, 1.422071078060145, 0.5579621149500664, 1.2264824791364688, 0.28563723704524197, 1.3911634967008342, 2.1276256248866527, 3.5702140934702564, 1.136431647419885, 1.5974083410104234, 0.6281187939300089, -0.3796639203637361},
    {2.3949777549997187, 0.5332646195907785, 2.0578126907884307, 0.9264483852317135, 2.5047311277868904, 1.98601684673259, -0.7888613965669398, -0.12001347174510256, 0.49292362148139895, -0.0672747187862812, -0.9508761352045084, 0.5942663557796432, 0.6742495990502373, -0.37229315299694943, 0.9029587803760253, 1.658077902690935, 2.427882799093727, -0.17605107724280158, 0.9638781360248901, 1.84510572370528, 1.7644735877847357, 1.1955005274309234, 0.37741350767774956, 1.8938970988307822, -0.8196005313174319, 1.0433254726124837, 2.8986445241440046, 2.946526900526594, 0.507645947318748, 3.565164520799297, 3.088174890525515, 0.4785092777777735},
    {2.473954856304752, 1.9552261980420287, 1.4925001778985134, 3.067751144250118, 1.9267943530799525, 0.4621430572887466, 0.9512677772992285, 0.027210965005664334, -0.6774180777819279, -0.6849820045491984, 2.130435453777152, 0.5754513336449181, 1.7873781673006304, -0.4073088071802479, 1.7740059935733654, 1.7898592266430902, 1.2040987438565143, -1.241128928841159, 0.21829309817935114, 0.7631231550535708, -0.3292305492719765, 2.0765486970387217, 2.532034206103872, 2.5674010015204782, 0.970637881660312, 1.5796278679854743, -0.04979495207329919, 2.0331769243835716, 1.5045455882993617, 1.6594937457997834, 0.6039718914730052, -0.6765888046023427},
    {3.2435029787603997, 1.4151130326108796, -0.6346632789739286, 1.3741592868404175, 0.9512662493657553, 1.0639083892071013, 0.6808524831599171, -0.596321359937345, 0.09460451415584878, -1.7266488301082394, 1.8193341373177634, -1.6000321592341766, 2.2447273183236938, -0.32525485572433965, -0.5895354622965051, 2.6090680669748085, 2.248165639497922, -0.5203147022900437, -0.2671749782732171, 1.7874425637937874, 2.2067799347398647, 1.4429784159070493, 1.0125449461314613, 0.9845295558758699, 1.2958966733643458, 0.9505942731367142, -0.5659039909432201, 1.4953691302335275, 0.21736986419126522, 2.0963180507232, 1.767766439747992, 1.9903629101923082},
    {1.0459298816859455, 1.4866660126145377, 0.21382873127825996, 0.6380851039732339, 1.4008954779552671, -0.9658216232380343, 1.8233259759200606, 0.8972359366338739, 1.264306955158929, 0.428258134875819, 2.3508177414904887, -0.20153372534124137, 1.931820870069967, 0.3502449946158813, 1.2691318555807005, 1.1861817521929494, 0.46376838672095133, -0.4498494543651096, 0.4134182192630005, -0.9766721566458738, 1.9497788183203961, 1.345813170500959, 1.7315295245934983, 0.9721685937639629, 1.1223254124412236, 1.1122739547031104, 0.8178224451724931, 3.805590733690026, 0.999489730046862, -0.9442728085434081, 1.1719045405149968, -2.4729671801524478},
    {1.8072519973767647, 3.1592895553086775, 1.2427832959935756, 1.4253122682191035, 2.389260234944541, -0.5014753122506039, -1.522760078831012, 0.06664495254208777, -0.21747218434530224, 1.1185499784588275, 2.5677144438332418, -1.6772717992337338, 0.08822832616738784, -0.9779797716691946, 1.6310670616710232, 1.3017867073463836, 3.8043969510617, -0.2021346052518608, 1.271802680472544, 1.00169496115978, 0.8092595251314278, 0.7988225854228951, 3.0721945096505547, 0.9931461880845024, -0.2589949563944736, 2.235507885998264, 2.3816276457266694, 2.309048413921934, 1.1257258630068259, 0.9238661937677657, 3.3301561026353466, -0.2429110243722773},
    {1.614513335732209, 2.066776552740515, 2.1156092458847224, 1.8074449793467229, -0.4369474338748785, 1.7417679224780749, 0.1472203562205067, -1.0689574010430556, 1.0676017979867185, -0.18556195824506552, 1.0232266978148743, -0.24058136777786418, 0.5471147662701241, 0.2536425720434175, 0.4692318923994885, 2.456123475825719, 1.5644588001932378, -0.5767274874136503, 2.353670698940864, 1.6543991476840834, 0.08687474199596139, 2.032420454460731, 1.3353371038930215, 1.415145654556414, -0.4142184436729212, 1.5231427994431412, 2.9394070081533674, 0.9260977642157644, 0.6091501150624731, 1.0395480642156105, 1.2644965295240524, -0.11006342074022439},
    {1.3125341478506662, 2.0825277206237796, 0.4246005913008597, 2.6506293299897594, 0.3378372886230654, 1.8979457234357846, 0.4892523587490367, -0.07325051922842514, -0.27196011210138876, -0.8465567633479743, 2.4103690865911034, -2.324060684542587, 1.4784541329397298, -1.2435126213767258, 0.796580704234088, 2.918659768781515, 1.1285176489489739, -0.047585400284216504, 0.46489560997168033, 1.5996376705462587, 2.929894004660143, 0.6857694716778877, 3.7519692863712724, 0.8309521581089552, -1.4839668066163254, 1.6064206943698114, -0.5880531756573738, 1.7816034257830158, 2.070549080529004, -0.2149698571659118, 0.9384625091965074, -0.690496851293671},
    {1.4783142267853897, 1.3813195435830552, 1.8220287769855448, 1.8397806189934431, 3.8759911856883456, 1.0264252876970021, -0.23799233052307806, 0.71855320807085, -0.33810889586951437, -0.4286633238716762, 2.574942642752209, -1.1383647197413806, 2.0051459059021726, 1.3825283751287687, 0.5290437587264503, 0.9800416477113836, 0.45249425839804025, 1.8651830978013932, -0.39872422449582456, 1.452855255262369, -0.46687649506744555, 3.754443686730193, 2.04103397492995, 0.990682286654496, -0.5315475604917759, -1.2239465428486322, 0.41612541218928817, 2.71686014337966, 0.07323663645628307, 2.2107936536946955, 1.3857172036812082, 0.159694042936129},
    {1.83373616252571, 1.424480209535058, 0.6242225934156441, 1.0982575066196933, 2.834289185041938, 1.4702233272989553, -0.31285406788917636, 0.8515948017543172, -1.2851345034550343, 0.5913170019802535, 1.4254534586965002, 0.5925673964986142, 1.3253648988289783, -0.11350371823180369, 0.44010432702266367, 2.474583785448954, 0.2924894717981348, 1.4494733439978407, 2.8437239418927938, 3.239221480603853, 1.799481187554456, 1.595500571405102, -0.043933549083950287, 1.0142008487092842, -0.221835114031374, 2.2322518336732764, 1.1213792892662413, 2.283599332922022, 0.8400095443441314, 0.37178608983012795, 0.8696425900877249, 0.7764225048147875},
    {1.2221406252344866, 1.1326846570634563, 1.6514377348143057, -0.2692242777633942, 1.3173024146246493, 0.44819523434408237, -0.7857777373154944, 1.7275368327765799, -1.742525085994967, -0.9124075965647838, 2.0050673604249196, -0.06562975709264525, 1.7698534059302642, -1.1444315994584766, -0.6813746812326058, 1.8172919293957057, 1.7016300581511918, -1.1861494193800617, 1.0336758940948336, 0.31869691045596693, 2.6238173195199486, 2.6527736185425064, 0.4427445322483112, 0.6519862309142334, -0.376405174274315, 1.4452336815853768, 0.7057519585766127, 2.8506312625759427, 1.6309077730071873, 2.5098725191374487, 1.8342417567921967, 1.4459588793897509},
    {1.8429632454031335, 1.1469570101635735, 1.9806813866875044, 1.2443539787866447, 1.1669710756297567, 2.6086765096663527, -0.4386451396333708, 0.7680933943651275, 2.21040459415088, 0.23589250255467506, 1.7908685854928732, -0.21358004841098818, 0.6339126667997663, -0.43154394237379456, 0.06721449688918162, 1.28219472535511, 2.687307814444424, 0.35404046175256965, 1.411153312546874, 1.7530449982238425, 1.3579228317525929, 2.582646369718864, 0.8849204118255419, -0.3391566071851341, 0.36163110427348644, 0.0739181900539208, 2.52896825761519, 3.324622293066198, 0.26866059743403375, 0.9377231988922143, 2.89370754418757, 0.30641779344664943},
    {1.5564982216215741, -0.18730767350296698, -0.9791356760980197, 1.4473374496704545, 1.0448844367153023, 0.37165757852888354, 0.433333987117095, -0.8014178891900877, -0.8586650790350456, -0.9187164416425557, 2.8282973792951625, -0.1662811478605997, 1.3852607126899201, -0.20271572011930933, 0.33243333666883396, 2.2626639947879146, 2.963739726614109, -1.7638307495914596, 1.137742048744654, 2.888591365075811, 1.9953050600026092, 1.2752310555576594, 0.6695386839361875, 2.8532441624819125, -0.1225217800215989, 0.6397969466702167, 1.9425670228853664, 1.5146825128307324, 1.393872065065523, 1.4688575507286783, 1.6284202786460258, -0.4542781457039179},
    {1.5257752541127712, 1.6966905897396687, 0.014335783455152854, 1.2322428209749048, 1.350049924181006, 0.29348703242144697, 0.8503635339476749, -1.0941282665558139, 0.2741433295154446, -0.5180208045988496, 2.8521931436732078, -0.6206060022264104, 1.2194311025534257, -1.2855168346095642, 1.1474745076830637, -0.25685608643394525, 1.235786795556615, 0.7076382301063244, 1.5132809350969871, 1.627950091051311, 1.0575982203684615, 1.8467443626120865, -0.6218109273650473, 1.5936809898625524, -1.2323600639336094, 3.380214187600463, 0.4636118770973008, 2.49659875307829, 1.1287515996738002, 1.234212337104782, 2.563000888596003, -0.6182510517049737},
    {2.8047459328117355, 1.6406173562711137, 0.6565052033544292, 2.451965026663471, 2.1023695562568903, 1.3718872157228772, -0.9903311606689521, -0.12222242979955436, 2.6876053373867026, -0.5696809553520722, 1.0742476274927748, -2.2005010717299958, 1.9312973154691366, 0.3179916595724612, 0.8201577667557131, 0.33411398368916917, 2.231699903326283, -0.8110661692695283, 1.3271180136902938, 2.4910224977884408, 0.0023782629862203336, 0.8073399718155777, -0.352985194303244, 2.286610728387405, -0.7739900915651862, 0.8188123884439245, 1.7414756385976609, 2.4580200491351882, 1.4717965627971108, 1.5860151525534254, 2.811814543258043, -0.19937472852802263},
    {1.9065948490483515, 1.1362489953163872, 2.0260894744623905, 1.3550355224712336, 2.637920658487006, -0.6701951410631418, -1.4214540634163157, 0.09720169383744286, 0.13334530526494423, -1.53856652411034, 2.5531479543348388, 0.8010528784671633, 1.713505937497711, 0.8578468635909811, 1.0987845187990921, 0.989636108175158, 1.3165833527243174, 0.28755620665912207, -0.3655755322784502, 3.8180687327579017, 1.4542777775441813, 2.1769516851495907, 1.5601771204990915, 0.3159687388028943, -1.5336425049905988, 0.10731913667028946, 2.3668712469126123, 0.8348981416310152, -0.39125894777173126, 2.606596988823121, 2.2519656209228844, -0.734762318535918},
    {1.4476089661615057, 0.5933420409130887, 0.5975502754374427, -0.3338253238108725, 1.9764932744603714, -1.0200305120892785, 0.38249535422236836, -0.9334031469148514, 0.07485642024518249, -1.0912541576152497, 1.7414825080115097, -1.4773634098679957, 1.5953256922505734, -0.7663396287325701, 0.29386658144359484, 0.8463234304184929, -2.702992104770121, -1.5181399268691116, -0.4104277229409944, 0.8676173897692946, 1.6440689956356012, 0.9666139932663756, 2.4118213820683008, 1.7966762965938077, -0.8131066475426857, 2.0944967319108345, 1.4891468567707715, 1.8378728416834382, 0.060596258063983034, -1.8317455774945943, 1.273097663843265, -0.5936689124577565},
    {0.8335061901591218, 1.7797479873617617, 1.8717272505670302, 3.4245036930071007, 1.8545862527664305, -0.06832986328906175, -1.816351862444407, 0.8782046721292448, 1.1210934348550239, -0.047370675566443955, 4.485439684533087, -1.8577816577339215, -0.4971674589210556, -0.6375801177563166, 1.6769788004155102, 0.6202095507856535, 1.1599567969206677, -1.8077227890526686, 1.4934270684396052, 2.5997044333710972, 0.593166116618149, 1.3187328591158338, 1.0039202590974925, 2.152396006799704, 0.26135812132974195, 0.2973870387001164, 2.4865396760194782, 0.8822051076934785, 0.9871137285197813, 1.2355040607727161, 1.6411587655326005, -0.5703432727245148},
    {1.6592520616847428, 0.64691465607538, 0.4518312594794106, 2.508545351590239, 0.6456249806279568, 0.07635723212186107, 0.10660281645822103, 0.6735862075831371, 0.6047971922371224, -0.5406377603499407, 3.1014814208155728, 0.26692159009823396, 1.0260310607429752, -0.9949100090940696, 0.7986903153198223, -1.5592831953523472, 0.6221361985561502, -0.9801304113075457, 1.3833064953931473, 2.733518832105897, -0.010585224535331948, 1.8588058737899638, 0.8745817915351843, 0.7825008062800436, 0.9907119954661447, 2.0073192928361956, 2.34636072451161, 1.0180648222864077, 2.070536137859508, 1.4440113796530505, 0.029822776106803405, -0.21562693520929302},
    {2.0960462238742026, 0.7190406793883998, 1.8852770466665318, 1.4269124813947922, 0.3482284853077792, 1.7187386559226645, 0.26047068001530227, -0.7588064997611265, -0.4504814567064364, -0.14356389430872551, 1.3600973150571694, -0.5793644721422214, 1.20154779461745, 1.0872978745480346, 1.5154156940988022, 1.8988304879306117, -0.2291666551953794, 0.5709418458533682, 0.712696139920564, 1.2590009737028705, 0.4741384778701956, 0.854689669818592, 0.7655995676064838, 0.7874225533415158, -1.3066296195523106, 2.504811354426482, 1.9008014739912495, 1.6132125779397148, 2.6056338680782005, 1.0633322980744777, 1.1616468762787304, -0.13289194199971657},
    {0.28922801053729535, 3.7570921036271607, 0.7182536749328239, 3.399121770222825, 0.5853137234376887, 2.0884728004330677, -0.20591732840053914, -1.1296036854059672, 0.5228683576343806, -0.6731171778581707, 1.9486060401880305, -0.8785470562306921, 1.8455211751584182, 1.7111971349464172, 1.329045406428276, 3.200591859812414, 1.7060782477205836, -1.7561240115478238, 0.8922348474512892, 2.139342935669847, 1.0782606893293096, 1.8171346087276403, 0.48333923095663617, 3.1156044423786002, -0.6442305949391206, 2.2904623820100576, 4.065320318601689, 3.395579487207203, -1.0427394907429863, 1.4374732627181406, 1.0941983796498915, -0.5125157214752251},
    {0.5678470481903232, 2.1249000586446747, 0.682270373196888, 3.387160108112792, 0.6041545066064966, 0.5257870898282463, -0.8420084843822087, 1.055864859486902, 0.7363792968830635, -0.9367013742651842, 1.1726035948137428, 0.4607421240059148, 2.5447440693469257, -0.11947925399744211, 0.031236257099238055, 1.4857886180279174, 0.44294637853915536, -0.1589107611127723, 1.3966038000373462, 0.9891826643649755, 0.45182454029965163, 0.884378682109061, 1.7631786948156585, 1.4105346895347735, 0.061906592424455176, 0.8417423548880838, 2.150220930421208, 1.5987401358941993, 1.6299003503852156, 1.3495750455010247, 1.9125904460221728, -0.7297864285907372},
    {2.0469991456271632, 3.7179768442676515, 1.1314007080985842, 2.596397197086565, 1.4028843869144088, 2.165540103028943, -0.3077756208950423, -0.1076062483266237, -0.010790837320867233, -0.3459743844365596, 0.828600633514923, 0.1766237328107213, -0.4458386250240264, 0.6722426828343815, -0.7672420456205163, 0.9138425943655977, 2.477838297910182, 0.4402387922905597, 1.2573315069476436, 2.649215556122734, 0.7779769054923352, 2.0109954189229895, 1.47357199901512, 2.6851482166232303, 0.20020662347074367, 0.7938221114212999, 3.091972376624013, 2.437342386118408, 2.4264755674165, 1.787257196697561, 1.2689888573297712, -0.4763162435824231},
    {1.8772492491847328, 1.5332520935007787, 0.9813404391016771, 2.1292347670682963, 2.481952911306201, 1.6714525579347155, -1.4227716011355305, -1.0523658282589952, 0.37758887983681505, 0.6880463338447779, 3.2849470536910945, 0.25471771217849937, 1.4413890929509403, -1.0836262482559038, -1.931369106572446, 2.771802487093076, 1.6053943482903326, -0.9842151060172287, 0.5140918541443434, 1.5445160965219122, 0.9288555029387849, 2.3892242871219125, 2.8700430818068567, 2.687531742727783, 0.7538247526843962, 2.6674294046003015, 0.43912811189660844, 2.0810492322523357, 1.0059217230763118, 2.453146641610123, 1.5592473707859038, 0.5725831802445017},
    {-0.6315911140796121, 4.352423349052624, 2.055539497968317, -2.2540186003281324, 1.2468013141192757, 0.9009651538496091, -0.9650199345847833, 0.10926653086439463, 1.6152220674769366, -0.05701147487845822, 2.664958539125841, -0.652741654886555, 0.8636876695428248, -1.3019067595131497, 1.8718875007074534, 1.1211950101880803, 0.41580189606661283, -1.2037226453580723, -1.078735910271005, 2.25566124363356, -0.6325322858425154, 3.883764312389673, 0.8659294233468979, 0.6396242671713694, -2.5393698417592243, -0.9464721724568906, 0.10860941478526334, 0.16156938629054785, 0.7794332642107289, 0.19213480498055394, 0.4476062617469842, 1.302236336540973},
    {1.6256288693349257, 5.13015895365592, 0.8467302006837124, 1.8288652216460857, 0.8465087257609892, 0.891190999698507, -2.199087186260046, 1.55859677404015, -0.07215397990419369, -1.376188737146476, 0.5259131823155108, 1.2619629391147544, 1.8254802240821804, 1.4810736405628584, 0.49437194719075456, 0.09074772547899211, 1.3964761772062853, -0.7797244424559745, -1.000559910782172, 0.6109145922185032, 0.38707237981290266, 0.15308368848272505, 1.4947537510665365, 0.7637733041260701, 1.0229614334103785, 1.9335878424212969, 0.9937300632597541, 2.857245374543361, 2.0924481924823617, 2.0561250599204355, -0.06655489715376792, -0.2868786303768751},
    {-0.16102928510841183, 0.7560531641273922, 0.5125576439797903, -1.1669938123833226, 2.234072502214427, 0.11200317267388639, -1.074636345732743, 0.11249167645815966, -1.74770934986055, 0.7055404442672922, 0.8167675158916776, 0.6364020226379398, 1.4987730077705854, 1.3787213350117067, 0.5599018395883318, 1.028509086741393, 1.3752036003230823, -1.4500766611379514, 0.07288184983861601, 0.6828815906226151, 0.7966676287031473, 1.6137402160512935, 0.17941345035433137, 2.2088190197219255, 0.43660601628002355, 0.8507596313633983, 1.2691205094555453, 2.433672657815411, 1.500944723429439, 1.395489007973623, 0.2396614558326021, 0.24168459080878077},
    {-0.8420337501301925, 2.2455413718895665, -0.6281763969569265, 1.3810928244963037, 0.49500821550512264, 1.5120033789018072, 0.08129023472824191, 0.2782629876783944, 1.257820180493178, -0.9538763972006622, 1.9630743303756457, 1.2938997222154314, 1.205666652605313, 0.40594427460065347, 0.9788802238446972, 1.0524647415342032, 0.6112504393556624, -0.6852941789026722, 0.792952305902938, 0.23624285403059703, -0.5443672831178311, 0.6511635497764295, -0.5252727384927763, 0.025224766330980475, 0.7410650727591863, 1.5999636886371322, 1.760325193489977, 0.5553292351372121, 1.5521143117618814, 0.8847964493933417, 2.1213609019355766, -0.11620554461002842},
    {0.6029392466428986, 1.8157973803090517, 1.0644248707866533, 1.680641755975197, 0.9157095870705798, 0.29349980237088075, -1.229577747756195, -0.932097619251573, -0.9369073801022528, 0.6524615921909004, 3.1449683499460575, -0.298056830230753, 2.0471447266771894, -0.027139489940214673, 0.5052951177412864, 0.5546380486159679, 1.4219063960459448, -0.5992337193319754, 0.12730467040286023, 0.9210131469542084, 1.2706729791674722, 0.5754467164371262, 2.7210161775883996, 1.025334792816086, -1.0867083455076616, 1.7357286397175231, 1.1000604121194857, 0.972215330060217, 0.09649091862028751, 2.351522202843168, 0.033055586193471556, 0.7999543951404877},
    {0.8367750414669339, 2.219578440473728, -0.8443259829559389, 0.6717609354975873, 1.9330311981343813, 0.08008643904813023, -0.4286847896409634, 1.3018218786834521, 1.362901541816564, 0.0862344913972705, 1.2975245097418435, -0.42077630650451087, 0.0288693939746385, -0.3538948060355786, -0.11993127247663347, 0.26755689516530495, -0.5560201157444568, -0.30352862928556584, -0.8864127492909324, 0.9368884191655731, 1.1319081823573256, 1.4327942830770044, 1.4239819589356382, 1.0497648540450955, -0.13597762563172736, 2.4146102122866084, -1.5207293384514136, 0.8208518812293459, 1.6939057037249259, 2.5469033346091767, 0.21495001550643175, 0.077979994034151},
    {1.441552222514568, -0.04504703348300719, -0.29205347786206826, 0.26059034558258104, 0.9816472396327605, -0.018268058040047632, -0.34309438156872313, -1.006816733843356, 0.9617874800984744, -0.5556617402986196, 1.1981966777916382, -0.7718102668417988, 1.295814281604961, -0.24587458266989323, 0.5432623018065518, 0.06170387871932094, 2.0527414231497123, -0.16188183886690435, 0.977699810743143, -0.78812831253578, 0.5760984609449006, 1.3437859444369769, 1.7350928575666922, 1.1593694295438253, -0.5636006735054571, -0.24254877670009986, -1.234266368236683, 1.1672669240914346, 0.8600949505706934, 1.2828189423548373, 0.7166556150291975, -0.10141146105905026},
    {0.7664908299145791, 2.221262041842558, 0.8000567129337133, -0.24234385667945518, -0.930596124281097, 2.070244575502142, 0.005253030344110425, 0.6009672935357164, -0.5681980773978481, -0.5705234249391548, 2.052922898639045, 0.20638625120051896, -0.4151463973274632, -1.0481498534238762, 0.028391441940023045, 3.248506979576034, 2.4474595163777875, 0.47016942417480245, 1.5698032198039742, 2.8832004669260476, 0.4362502840138221, 0.18367224952338523, 2.212814504620821, 0.167525629635448, -0.35975551841799835, 0.6985131066104696, -0.7131009199200231, 1.7753618067606225, 1.1489327697712926, 2.084904289608397, 2.2183743562956657, -0.35712845850939046},
    {1.2115777184703564, 1.953776272419887, 1.2903673953879806, 1.2782277598756515, 0.6509393064413246, 2.1418505154522633, -0.062075104995448195, -0.9068733678627878, -0.05156735218740735, 0.7058339660501916, 1.5926434937374034, -1.6275981065327558, 1.326456114409458, 0.33309114045361293, 1.691818557994331, 1.669269989639022, 1.1413433223522333, 0.8253205202578136, 1.785236492843957, 2.353196439153512, 0.7327609365610636, 1.573271594513412, 0.8320434315343127, 1.9585448534876755, -0.3494771931202619, 0.6225395164270288, 2.2334205155581826, 1.707362261784538, 1.2232880691385914, 2.368696998647063, 2.376531036875948, 0.002873924198487786}
};

static const float b2[32] = {2.348507997930578, 2.160361411241157, 1.465476706514188, 1.8167371260140228, 1.8872624078368618, 1.1648263085916848, -0.5964708886572112, 0.04745415950067642, 0.0682322525350559, -0.38705924230350125, 2.7649070623321963, -0.40535344037684445, 1.7378804105537609, -0.3402164903543335, 1.4889998468575596, 2.0216414134446694, 1.6729699800092435, -0.3646802520670333, 0.7469971548125537, 2.214685648032761, 1.2637976232402246, 2.211554870408272, 1.6082513580429787, 1.864041199521698, -0.17334422946063513, 1.832347992497028, 1.7339329697185544, 2.2874737396113654, 1.6003565085258644, 1.926963649485352, 1.9991979138095433, -0.80363359521955};

static const float w3[32][16] = {
    {0.47528793895592886, 0.5960601455116188, -1.1479127851827027, -1.0106797398393776, -1.0512546261437623, -0.056926691044206446, -0.15900693368118105, 0.9970953935779416, -1.2244656926254047, 0.690251365866805, 4.342713420220673, -0.8043179447302529, 2.9944345899537943, 3.0429962102338948, -0.9162928310551154, 1.0911430117187602},
    {-1.2298167652091456, 0.9366140812008488, 0.5146558437979825, 1.2006118346894665, -0.24125874454099286, -0.028260718050541846, 0.48925413280785274, -0.4610694359998177, 0.3893169904136122, 0.6138627900698569, 3.60043440721955, -0.9416495270212583, 1.3636441712018017, 2.3066896307704146, -0.5704749843651119, -0.47060790360880184},
    {-0.28895646857623, 1.0018859317487459, 0.2675674944270191, 0.4349280130908017, 0.5611604450963079, -0.12214135938026464, -1.5267161633511686, 1.8093626061484989, 0.3012208154909083, -0.22531623202149043, 2.2643051950521436, -0.8197195254100025, 2.078249820340947, 0.6045256034086743, -1.4763999044356981, 1.0738760892116823},
    {2.1945844776401655, -0.3758950639722671, 0.03629391993921397, -0.7432830365435279, -0.36228077628567723, -1.1504996680139845, -1.0503330063669614, -0.9335572922164772, -0.4031024914285632, -0.8948691891079076, 2.4916162596283593, -0.4952989543517788, 1.527766632112183, 1.1004209587506117, 0.7398269936371503, 1.1133928770085484},
    {0.45473645441689126, 2.839966737348111, -0.12463697465486533, 0.8447593740885155, -0.5831676692155101, -0.9655420593271753, 1.1980716725956941, -0.7855396336654651, -0.41417925564447905, -1.4759363072934897, 2.6033268926776154, -1.298499319693779, 4.738066588001867, 2.3974990413632744, 1.405586060741893, -0.462844232777914},
    {1.2674928082226016, -0.862004646758166, -1.1116539596000905, 0.1956220690564017, -0.571868451659334, 1.4882525392851293, 1.043185555980011, -1.454055095101426, 0.8572504815913989, -0.4322517476388429, 1.543596917886504, -0.7784197582249254, 1.0072552003345643, 1.6802564698566749, -2.0360547040233583, 0.6094582296971524},
    {0.9398813968003571, -0.056818857937602295, 0.7135160852204534, 0.25361333130484226, 0.1536699663156684, 0.5216693928238935, -2.025513541705889, 1.5606640310426705, -1.0145542320670908, 0.28929734611436636, -0.4719496395711174, 2.2748887532072097, -1.2454039540726576, -0.11203031232966494, 0.25092215042437954, 1.2336451530277996},
    {-1.545925071302828, 1.8875073062116183, 0.21805081045984293, 0.1977848840199041, 0.712305318707891, -1.0281836555564472, 1.1839647620828064, 0.03901254999856921, -1.1564747880702084, 0.6341905074969001, -0.2027173552025258, 1.8848089349919372, 0.6611958279470148, -0.1089394616893012, -0.43852497596308493, 0.49871156647918474},
    {0.6585308637358438, 1.0632393696672713, -0.1560510261869134, -1.8088860865855552, 0.4640840907666702, -0.8376664263040867, -0.5517190672937105, -0.8406309377957343, -0.10970546741823575, -0.31983679936977116, -0.7258127757118745, -0.5562210751327465, 1.2027796110678188, 0.35787769888920024, -1.7163052209583907, 1.649411134191933},
    {-0.6205910136384244, 0.7205226875812718, 0.3543897158254266, -1.6608571544107116, 2.0747605054886176, -2.279217194547058, -2.0856989334193567, -0.04703411931213358, 0.25041745659878223, -1.1148662356862042, -0.7617107234420705, -0.5512957043982682, -0.5766834149088206, 0.09654738843273995, -0.7588737956754736, -1.4265492905185608},
    {-0.02112902027692299, 1.176286278377972, 0.34613240323267214, -1.3183728066688585, 0.013362566543140478, 1.9860050837787027, -0.7125056443595632, 0.6987121035835857, -1.7467106449045393, -1.4988746630727157, 4.69458794302254, -0.2526636501650124, 2.9516297779536567, 1.7224759069638151, -1.4799702883292978, -0.6198649817375689},
    {2.597772254617626, 0.3273503998104146, -0.9389473048093853, 0.42255160946821974, 1.0635662343468266, -0.5877635596989144, -1.0113859911093732, 0.8497215357762185, -1.3568250957870749, 0.8588080176858712, -0.9100937214877332, 1.620478458738957, -0.7870009696503105, -0.17088908664345953, 0.6604942411817408, 0.7163830191201634},
    {0.6732759533573874, 1.2990004552830658, 0.5155128740990708, 0.020202074495810796, 0.8818063409675471, 0.11523884991607829, -0.08609454100066388, -0.1308520551362926, -0.2887778092274732, 0.3783812642238853, 4.479429530097066, -0.6876065370626034, 1.1688301892684791, 0.7158666485495019, 0.9530445687169614, -0.2689666729831272},
    {1.4192948979475006, -0.135976126316995, -1.3027093098454798, 0.025352241487054523, -0.16239632603368262, -0.6806322116825406, 0.3179492458812054, 0.18160056571915875, 0.9560769646753314, 0.4368254026499268, 0.46422702652486986, 0.059826341924661484, -0.9316439758783794, 0.24966268709139192, -1.4614566186815612, -1.638407596846722},
    {1.5431644424307893, 0.24780307126199494, 0.057272216020277406, 0.4664703367509489, -0.5546933074623182, 0.21615843566209383, 1.123757879927954, 0.8310169608381957, 0.20424330033642685, 0.5274474530387925, 2.354682590907589, 0.12737583007680348, 1.4140744187508574, 2.140915649471382, -0.3046462671765727, -0.5378329128843004},
    {1.2651232155177914, 0.2856324873494699, 1.132580207053641, 0.09315663923562009, 0.7240544025890701, -1.5117375280516459, 0.1939725359612993, -0.514766706920943, -0.33179592346772346, 0.7458993307692616, 3.1746854999782395, -0.47380170370758584, 3.2939803709120703, 2.535109184855691, 0.57095047308206, -0.8225094171508982},
    {0.14807832412051766, 0.5391552206330491, 1.3440755807595424, -0.5434414959085131, -0.5324633120318717, -0.3603272823212943, -0.0612656816524319, -0.27178000987781187, -2.9692196699821225, 0.5635495928262559, 4.023556937814626, 0.21232616355013262, 0.21596074053010342, 0.16146440319180597, -0.3944600813997276, 0.18402415979057224},
    {-1.0190047915986924, -0.5350092870225353, 0.5808151185104029, 0.3245815797706147, -0.5372781138922367, -0.1950371042557131, 1.5307901593553315, 0.6098826560061811, -0.09984307080627576, -0.5762918693267137, -0.9406771127583913, -1.3499797578287325, 1.2617760177008777, 0.17162834596376061, 0.2359725581384006, -2.2526917158657156},
    {0.17349899936587085, 0.6502408727386428, -3.170607350671991, -1.2535435828855566, -0.005470978483361807, 0.15092915329100032, -0.2726668524078272, -0.019938673776760573, 0.4542923159986628, 0.5963156142404722, 0.8855370930315976, 1.2054581490946614, 0.9173623375352254, 1.457302312714517, 0.2161752004969104, -1.0343949044441403},
    {-2.0744275034902726, 0.3297828215418433, 0.14911715853031823, 0.1455193050555732, 0.08286680998875948, -0.8579218498499471, 0.03039066881789128, 0.09122168739730327, -0.6958634112009645, -1.2682968738537488, 2.7229824009999164, -0.48609118887809494, 1.0796330476249296, 1.7722554749913142, -1.5364073002460257, -0.5809511328549565},
    {-0.3383253872104119, 2.320855242202269, 1.0575599269756961, 0.47840177268737394, 0.21064253048814024, -0.014143582923476592, 2.2003548326844076, -0.49714341212419144, -0.37303193919841726, -2.119643024344159, 2.8169973685747594, 0.6886017184892128, 0.14481150636816886, 3.8850126603687554, -0.6977106304563051, 1.3062448509639666},
    {-0.7041771697373691, 1.2727135900616589, -1.887029946566271, 0.09078294728598872, 0.8349116240122768, 0.11384896583704104, -0.162086431897324, -2.3943349593286816, 1.835911164395663, 1.340268382479469, 4.1795543887157605, -0.6877009691164458, 3.379656442453506, 1.748342097668482, 0.9597756673435061, -0.34925469438031703},
    {-1.1157028935601643, -0.1872191263251143, 0.33615895837908366, -1.0770672479502057, -1.6236026243997361, -1.0697150330411147, -2.5884035277550104, -0.07843453968700853, 1.3218816272780318, 0.15240430965865018, 3.293379045316068, 0.475371496081698, 0.2401609910683796, 2.662902603677163, 0.3662656959705976, -1.2306406887768195},
    {-0.8765123749358734, 1.1705036294249882, 0.24044817779982097, 1.3126187618884069, 0.20269973101210376, -1.5194098256220812, 0.5684379919437668, 0.22949695695429462, -0.17358863761542034, -0.2073260366192632, 3.076250258986507, -0.10456717189153153, 3.719570630448598, 1.1996129501639317, -0.1980232372939649, 0.05059683196381015},
    {1.9386739491356988, -1.4256660323386434, -0.19289376713647463, -1.322993785870424, -0.0674887729303251, 0.16816129530262555, 0.681086733387187, 0.2989994864805976, -0.7567592318894033, 1.0441525947209562, -0.41596245552911704, -0.18615088137784191, 0.7715954376446066, 0.6429163626735866, 0.6843919792400595, 1.7933943587286973},
    {-1.3107953238638854, 1.7955959940835204, 0.263963189573139, 0.28675514265147717, -0.32826509155823197, -2.0533857790346204, -1.4981486315232924, -0.6571084680893113, -0.865581488775015, 0.7944519942482063, 3.843114554497283, -0.15087988782433434, 2.3086504007141913, -0.3739817012313108, 0.4051375833624597, -0.6841371669709211},
    {-1.0985013810691793, -0.5115091080059014, -2.1687708413135, -0.058231770884123464, -0.2831586508815341, -0.282736659077303, 0.8900280300904339, 0.6002964339288009, 0.21460064314771166, 0.1760045112220782, 2.6436915831496153, -0.8094056823857757, 1.4327424216221178, 1.3656175287877053, 0.12884087076101947, -0.15062059786890122},
    {-1.5572957240362186, -0.7162025887015374, -1.2081274960459192, 0.23608067023613383, -0.8136931721250081, -0.9202102263674613, -1.3070102531934926, -0.29574781804895073, -1.5965731575534425, -1.127172755873302, 2.661148989313285, -0.2868164360503913, 1.4448145432836268, 1.263593528451146, 0.22400548995153508, -2.627391226175859},
    {-0.5395828328111529, -2.013614210503862, -1.7974638626932522, -1.8066052635308159, -0.37611361839443264, -1.831080896053315, 0.4184047450152806, 1.205505905850296, 1.213257743072667, -0.6639456433684057, 2.674652721385673, -0.40678202714712763, 2.1694580147275855, 2.0029932435537776, -0.5550225541029962, 0.5479679806137786},
    {-0.6612648556858329, -0.25917532632495893, -0.045940424662132565, -0.41712680400606933, -0.6763754679943076, -0.4455453951353743, -1.7824548293586053, 0.28865615033419156, 1.2477622123608838, -0.35126576890239597, 2.1436127208397004, 0.630551933325615, 2.672080605151373, 1.0262346346573192, -0.009432505293288882, -0.4474013164861876},
    {0.12403636522450895, 0.4273878804122427, 1.118155065261863, -1.122551708200908, -0.17605082866684965, 0.24594788692420008, 0.5388581258091136, 0.3702852543772946, -0.62054658028978, 0.7756486893922527, 2.172535346914594, -1.002343979096942, 3.004870529619147, 1.0109545124880495, -1.6186543324682243, 0.25227596639474636},
    {-0.9547420025791915, -0.2374286698366732, -1.4015912864200655, 0.2470674965561155, -1.560617165940935, -0.5073504440689048, 0.06680700824564657, -1.017032098720214, -1.5012841095899254, 1.0548002838940997, -2.2959737705333634, 0.8866024494170535, 0.6088479116274802, -1.4758030513734535, 0.9970700275968968, 1.1817793576770121}
};

static const float b3[16] = {-0.3486245188773985, 0.7373012794285684, -0.3047480256734137, -0.5423177173162078, -0.4441264938527883, -0.5126580127347005, -0.22594343461251828, -0.4821708369436462, -0.2700083135451927, -0.3186400692668457, 2.5194518912409536, 0.048581208880777396, 1.5437346265723872, 0.9914289611569341, -0.5197896173718604, -0.2864610485566351};

static const float w4[16][12] = {
    {-0.019373945211310053, 0.7741061130067018, 1.3812515490874584, -0.22832041172819056, -0.18716108231092388, -0.07080793569357707, -0.26959946239096105, 1.194017614618282, 0.19975752094272525, -2.281508192038044, -0.7241463955849347, 0.0015145869795479096},
    {-2.3162595944798396, -1.6552977600485739, -1.376661567595657, -1.4684377232928947, -0.5770864594282553, -1.456387736804322, -0.7359782899401007, -1.4348258402961065, -0.554295425483839, -2.4195710084164697, -0.70698668361862, 1.3858496206788675},
    {0.7431213980205673, -0.25829619185342995, 0.011287210295577695, 2.6473196590967447, -0.5139511781092988, 0.7204616407353829, 0.6164241661783071, -1.0610374153252629, -1.8568202358053463, 0.5557984079420506, 0.7657642924787155, 0.11454051444413575},
    {0.7622387719385888, 1.0028836432806694, 1.9588548326907669, -0.5750811625760538, -0.4502100340134398, 1.5796064466204582, 0.30397040644602447, -1.8105991658498302, -0.9878477547085648, -0.3897856669238668, -0.8566040136602906, 0.09795992240364487},
    {1.3701608896065003, 0.6173324758238614, -0.7634661513011369, -1.8123178751549838, 0.4788413281737453, 0.4807980298413504, 1.109104222939578, 0.35940814550447076, -1.1350749953339687, -1.0723375180597003, -0.8989646442570335, -0.9454870383168406},
    {-0.13328256808497568, -1.029244757739656, -0.2929972962094933, 1.1139188482546591, 0.916863779443699, 0.8728543764619264, 1.1617946355197972, 0.1810902567506238, -1.127605824396057, 1.3216629742142754, -1.004782288077915, -0.6435285420956123},
    {-0.338793293170298, -1.4703231861857164, 0.7727178105047892, -0.08017000347307582, 0.8669514563213138, 0.5320261775901127, -1.5632460956138012, 0.5644880775271461, 1.6973837543173338, 1.0515288937335203, -1.2578801496603549, 0.4903722964835753},
    {1.998511731505069, 1.606338672260489, -2.1927443752517193, -0.35307555412902547, 0.2966448500829237, 0.0030993235565446933, -0.005633945133802577, 0.33530817490766046, 0.5272515517762036, -1.0172815193387155, -0.32469304921195147, -0.39526250449946476},
    {-0.33360372267083466, -0.583586948267857, -0.780196434078683, 0.44959951842103557, 0.15021952729840596, -0.32122438881840354, -0.25333351713293817, -0.2884129384701463, 0.09635743198319388, 1.0669738745171806, 0.6937745927924486, 1.416402506700827},
    {0.637396933207115, 1.6744289602722202, -0.34537653213343344, -0.17995408167050642, 0.9621101405094075, 1.5076706981575576, 0.20822986024913465, 0.04134861123731694, 0.7946153152058556, -0.015443187197518232, 1.392298195463303, -0.8024571660297476},
    {-2.4257069095567823, -1.7888242906643963, -1.972087763172429, -2.67653263740721, -0.7088159866438045, -1.8911127053241081, -2.1048909810960317, -2.153028699044358, -1.1988404236961188, -1.586122038084143, -1.1866140585476541, -2.0081779524003114},
    {-0.7973681058428941, -1.189184178577884, -0.8403430624821431, -1.0914137737703493, 0.40487989428616405, -1.049044630054857, 0.6762822449801413, -1.1830879122611495, 0.37959597921254057, -2.1680542986347975, 1.383704276102219, -1.2101856272996658},
    {-0.4397993549612544, -0.17176135054396605, -1.429141949228332, -2.6774650382586973, -2.2894103542178037, -1.2863437977856755, -1.684254718652148, -1.73397730881734, -2.836669601051747, -2.087410475485088, -2.1809195230052425, -1.0595394060386605},
    {-1.0682390661011432, -2.8064274830247453, -0.9559472223913426, 2.0013443308873593, -2.5281929601469075, -1.2684674522500874, -0.5720284017304312, -0.22205895115644636, -0.8834286820511548, -0.5758829646968262, -1.6686959253857365, -2.2423851458882904},
    {0.7100300152914217, 0.5618446795697211, -0.018751666992517124, -1.1007335176393673, 1.4010220167707446, 0.6432256588063668, 0.4573894965948406, -0.4597209067312579, 0.26290805161201447, 0.09150294522167705, -0.7597429097490941, -1.663817848752939},
    {-0.559717998085084, 0.03477188235006251, -1.292988401510601, 0.510702216862785, 1.3704220814780965, 1.3003676178159134, 1.2089004158956667, 1.3925448258645754, 1.5970325870982998, 0.6980519963115592, -0.7823131300377557, -0.36096662333404994}
};

static const float b4[12] = {-2.7019568083462615, -1.7722083892501388, -2.5630291618588315, -2.486114728409616, -2.718751770621367, -2.3573760825328187, -2.3818497274570474, -2.4155714862850197, -2.5087257027874577, -2.7710335255338485, -2.576386153470444, -2.8692630574115867};

    // Input Layer 
    float z1[64];
    for (int i = 0; i < 64; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[32];
    for (int i = 0; i < 32; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 64; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Hidden Layers 
    float z3[16];
    for (int i = 0; i < 16; i++)
    {
        z3[i] = b3[i];
        for (int j = 0; j < 32; j++)
        {
            z3[i] += z2[j] * w3[j][i];
        }
        z3[i] = relu(z3[i]);
    }

    // Output Layer
    float z4[12];
    for (int k = 0; k < 12; k++)
    {
        z4[k] = b4[k];
        for (int j = 0; j < 16; j++)
        {
            z4[k] += z3[j] * w4[j][k];
        }
    }
    softmax(z4, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
