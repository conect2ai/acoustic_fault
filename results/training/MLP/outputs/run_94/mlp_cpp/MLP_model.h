#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][64] = {
    {-0.8553114560341754, -1.7200943116201926, 0.7055006356975758, 1.5940521331492192, -0.2832695204601397, -1.7063332491248677, 0.04688245883698736, 1.6067143609211119, -0.33666131483265904, -1.3049570842980056, 0.10090426967719228, -0.4875215478254191, 0.6406160979091013, 1.1551059066267761, 0.5764582007944347, 0.026162121091372226, -1.8141108535746373, 0.2753444125065908, -1.4814107575857134, -0.9635216543870527, 0.2914067978554012, 0.24054643295442862, 1.0055274411423716, 0.81296802624615, 0.4576017303967963, 0.5794293733078332, 2.6956421964060127, -0.7546953678674878, -0.442890114138131, 0.10346728493579001, 0.413298204588262, 0.7971465441711629, 1.3094911277528158, 0.882475242095123, 1.963352291472104, -1.9085972291425357, -0.5659409779124541, -0.0171592483494886, 1.4489406312563347, -1.1311152548622625, -0.38159972420278565, 1.9854246676634708, 0.8068407079244547, -2.1607468753501253, -0.6906216592613197, 1.1919673828090522, 0.7003371656085261, 0.20660074724362515, -0.6925903906274287, -2.256968173670235, -1.1530632516599693, 0.21961294545687698, -0.8905700315361077, 0.424611503780249, -2.1060300803300755, -1.4442941256838506, -0.9719487802521889, -3.2372077342418493, 1.737393028151085, -0.35904793405862484, -0.06084981275711868, -0.42171220096863926, -0.5226275328173831, -0.5929708344692128},
    {1.602605493568149, -2.1795788867124157, 1.8252643255665901, -0.5581697278240997, 0.909582873583206, 0.018094598730476346, -0.20003494356804785, -0.8237497136673687, 1.5075513622413907, -0.6470931479442832, -0.25564377158261375, -0.19460603633845303, 1.119510408524649, -1.3998403818795544, 0.8568938211125433, 0.4822495816712401, -1.3215401991953386, -0.03731916848515402, -0.08498777950300984, 1.674371099399707, 1.6215183722765778, -0.5155492434028721, -0.0471602436141877, 0.03196905355018698, -0.44949328212474754, 1.2882034652121799, -0.4141486083572893, 0.09001611541202124, -1.0792661006461213, -0.16004443501556578, -0.4609019421702664, 1.1153146753798937, -1.058453565681882, -0.2327354598309847, 1.485903857554736, -1.2669354097911825, 1.229655367003278, -1.4632934288292208, 1.0463134734425714, 0.36696848812688004, -1.3186416129688354, -1.0299687331593597, -1.1973590356228148, 1.5310738164036615, -0.177849939071462, -0.7671000305957821, 1.2594647616111831, -0.10380864182009213, -0.6369715624297714, -0.11211935053226899, -0.729678265192011, -0.2524647797972724, 1.6920823408404324, 1.012143651552766, -0.22029404069114036, 0.12190639053739698, -2.1486759428031954, 0.005740309416794334, -0.31340358704829707, -1.1754802847000334, -1.4099895109925678, 0.7973714132302221, -1.4318989095805814, 0.7542561967367776},
    {1.2234335240407406, -0.16909157504305092, -1.1484680916595127, -1.1330353533816127, -0.7594596755910138, 0.4990702823932377, 0.5083409057134938, 0.4625411649488624, 0.7223007765061934, -1.0597254638762281, -2.0952037470066114, -1.2221155185441535, 0.40556573031765225, -0.7972029662530479, -0.018905319642365054, -0.7390466136248018, -0.5757049449765574, 1.9841703955772945, -0.9689061506874526, -1.0342410122225103, 0.4921670719889519, 2.7826489329463397, -2.3871082209366468, 0.2828637324621467, -1.982998035646092, -1.4854005777321935, -0.028476469703728823, -0.7433653602865931, 0.9986646608964105, -1.196693309590206, -0.4954000556549557, -0.32234201198943907, -0.9041347073974815, -1.505408210515847, -0.4483920414486258, -1.1861958557119425, -0.10440383724850541, -0.282007115628941, -0.7330881607566363, 0.04303618120569163, -0.31934078965682716, -1.3076847890288388, -0.06578813774953811, -0.17695329441829039, 1.5471693813346985, -2.9196126130202704, -0.43872447512433155, -0.24193892018985305, 0.4243997546963214, -0.9565783272137945, -1.3666459357005476, -1.3578033024701817, -0.21952932541416656, 0.22527724768186172, 1.0833999448915546, -0.4248600148132033, -0.9782941418102862, -0.32809363177276524, 0.09785723112433764, -2.990842004641893, -1.5160658697161096, 0.37286641606703974, 0.8049917990360983, 1.5040977901556838},
    {0.9857742168858918, 1.587886090724013, -0.24839817378491874, -2.1086500232960814, -0.5047868618750515, 0.22612563095404453, 0.24162026294161937, 0.6188403493631225, -0.9297668841591801, 0.963926151394043, 0.20409611757985827, -0.5035169355611885, 1.6087107988288984, -0.2942003531638083, -0.9320326779392458, -2.1439422057841595, -1.704053375689939, 0.6399778486640423, 1.4572006257476262, 0.9627108384155328, -1.0393902475798598, 1.1111145200029995, -1.0130995139470365, -0.09445458488861327, 0.9244744291029799, 0.19499386031865334, 1.2181578050680206, 0.32264181023835664, 2.6565935864484054, -1.1840326829911212, 0.04406168605182602, 0.2847729836621213, 0.11759061860547504, 0.3608402575878193, 0.2896560103361795, -2.0221321918043014, 1.6008402363555498, 0.663028259405738, -0.15984182545800302, 1.3881565798320297, -0.19235511630473306, -0.9219092742644175, 0.5317117053425574, -1.712220266791566, 1.2937776152289044, 0.36663738107897426, -0.573850708800752, -0.4088301531005176, -0.17737321110510865, 1.4902456628969067, 2.036771586792686, -1.4991897419323779, -1.7144610628371064, -0.3082024681578612, 0.8537010319759494, 1.4497698969116937, -0.8577238336022801, 0.07214670843508623, 1.2383215308895528, -0.3776979774714972, 0.7227360133428198, 0.2794979073599633, 1.0982129007585935, 1.4739907315754},
    {1.3288086184191397, -1.2481877325138033, 0.8181348566734729, -1.3904599770640937, -1.4351454922459335, -0.11395806901172148, 1.1042713321158637, -1.2353921862597177, 0.3883208465552494, 1.0635444174509558, -0.36733876505188173, 0.14090727367357495, -0.6944293999236449, 2.6386701097518985, -0.8835676516187015, 1.045079324006136, 0.3841752424081422, -0.658944951721488, -0.9710250241874973, -0.5308025392923659, -1.5427174329266344, 1.3761546813539078, -0.13465129177686777, 2.2949045414334255, -1.1158473243765985, -0.7544423280558304, 0.6169367467296558, 1.0097482550297696, 0.8824002509526245, -0.8470444092142858, 0.8545192222179406, 0.9674919652972919, 0.3651154020553278, 0.2511447420077443, -1.010873238464886, 1.597097245565135, -0.1746933694914461, 0.9115660193025087, 1.99697802887605, -0.4284777761058307, 0.08614631068542626, 1.0727930116880007, 0.8665364477606035, -0.1023804814861839, -0.48910784613808594, 1.591913773063655, -1.4920239616910431, 0.4625268081454741, -0.1467795230297365, 0.09195101852347698, 0.051355832813555186, 1.0114000244219448, -0.4273896926488301, 1.722965143696726, 1.6282028178198051, -0.2365437163793157, -1.0946462830933035, -1.5346940691578033, -0.3006734625897547, -1.0993652632569295, -0.44556352798647636, 0.6647819131101839, 0.5251131783450751, 0.818342009942169},
    {-0.7793885053510295, 1.2059260905196518, 0.48667907591978826, 0.3026661948287119, -0.21700485958505605, 1.3447138538343295, -0.16312931983709952, -0.2082603938048749, -0.8563031402192965, 1.1957031305501913, -2.605706652077187, 0.36509459202995387, -1.3922455886231009, 1.0258357913714184, 1.0669598908443534, 0.4676650905646322, 0.38438483360840203, 0.8067631012130251, 0.6109496121219699, 0.20967993223691506, 0.13528507417584856, -0.6159642320553255, 1.1477479154329637, 2.01832268506712, -0.18727173816088685, -0.13149433414023612, 1.2665575915566614, 0.29188564111385884, 1.4146522949556588, -0.5752060647045815, -0.5727191187740664, 1.6611800966669235, -0.8249716853394911, -1.0683405381183317, 1.661264386228746, -0.02622990836583477, 1.5676707585184613, 0.7435444136295575, -1.0096137357743946, -1.982473125074358, -0.1329550505731088, -0.7667927219589424, 0.5412454663959102, 0.39794565447001473, -0.5528467981622754, -2.09361707329516, 0.829345510248829, -1.8618180223716287, -0.801724776048496, 0.31612668296056134, -1.064159288307702, 0.40432460161010225, 0.4608956645164529, 0.5670628805963723, -1.2648013928002555, 1.450083888892521, -0.0362868009038078, -0.3356034024193722, -0.8151830592439249, -1.207604948093498, 1.0280975996440538, 0.2967348187917018, 0.128148323658334, 0.8759936457748335},
    {-0.3199744768409518, -1.9390339858670969, 0.11764456368207325, -0.19599988847633681, 0.901652428799544, 1.5381165932148317, -0.41499160081750264, -0.04012436189672127, 0.6126250275527609, -0.7450208966568492, 1.360820999021159, -0.5537550452400664, 1.1538125407561826, 2.111635058325068, 1.8737618693445655, 1.6826285726349048, -1.6898023458051437, 0.1143380092275593, -0.6434958472750206, -0.6616927713028651, 0.12244984786295353, -0.07515388270246505, 0.12517343503365674, 1.854957909479566, 0.8242765225278235, 0.1703999815447283, 0.4335316604009484, 0.5568233554484608, 0.1020752357590625, 0.5167044907767971, 0.7966523602986807, -0.17868282000712454, -1.0932114163403972, 0.09987613552099775, -1.011522035427808, 0.43176529263035207, 0.3782268978240132, 0.5862273658657455, -0.06584702096186902, -0.5129843039476192, 1.0798686756155242, -2.422510632607745, 1.1384406502513085, 2.2220733878446577, -1.2942268666564112, -0.2786158606321108, 0.15632627923874384, 0.18564831755222644, -0.8723736972750753, 0.6711181265756164, 2.6063525514675137, 0.8315512695418406, 0.3909993721476208, -0.09094943044176611, -0.3518829780998779, -0.5272612409479555, -1.1601936220517832, -0.6530340808891376, 1.283344661768345, 1.6873717594109632, 1.5360706964020105, 1.0781257211902617, 0.3523655358153011, 1.326407824579458},
    {1.4303160869214933, 0.981294175319373, -1.1373303390083596, -0.7624414492841556, -0.1022093350587579, 2.1669528898101516, 0.8587025549164076, -1.1611550710834317, 0.06764453029103788, 0.6385965146001945, 0.936184193982183, 0.25372999000789365, -1.281351669991049, 2.080203994999897, -0.5398657014135656, -1.5907771770373236, 1.8127163991494009, -0.3463770991350552, 0.5463287689106252, 1.1574634235686818, -0.4604554818165109, 2.564878142399185, 2.0672125164555797, 1.5918598788902218, -1.6163432168336278, -0.9292923757776507, -0.44839207712812845, -0.34742175451403956, 0.029935759294792225, 1.0140973986379196, 0.7642514523315664, 1.193690760613157, 0.0852096948983657, 0.0975802096258371, -0.6915850877879688, 1.0376818450099987, -0.022824535915538853, 1.047641426809264, -0.32967772234014675, 0.8902479102879081, -0.29670889724872085, 0.23855307632425565, 1.1265830036268614, 0.7883542230112992, -1.749297008391822, 0.4860503183244726, 0.05880627236686349, -1.5556882374818364, 0.8548687170193808, 1.2497345419375194, 0.026522126013491625, 0.22466901111374904, 2.1600347535590054, 0.8053415980697732, 0.07075420780516573, -0.15311020629311314, -1.9263919376663845, -0.5174176945414427, -0.6643800069334072, 0.6227439822056036, 0.22047767779015673, 0.01834318806177621, 1.1928266977982211, 0.43403691723879884},
    {-0.6183019163036425, 0.5727643905128638, -0.03132277322014441, -1.027296496500646, -2.1526712073738685, -0.14171412736944244, -1.692628139435817, -0.6188585773216441, -0.11236719680116149, 1.4379083319670576, -0.25637631223689744, -0.6197561921031342, 1.8162704396483984, 1.1202272464966903, 2.2274027001750802, -1.445762826406649, 0.6688911783613922, 0.39718896858701275, 0.5913300490543298, 0.7779831874990278, -0.8886443582454625, -0.7221526535297448, -0.11696938570072074, 0.8982982090873813, -1.2526288629471376, 0.2498533596590693, -0.6132906871170796, 0.7107560800169489, 3.241170089429632, -0.46770406142116494, -0.1344647543612517, -1.314626851377049, -0.42187113966805884, 0.6817255029490824, 0.7512405178939953, -0.17337969758368862, -1.2781791300190382, -0.5613736824734018, 0.32368588219968303, -0.41737603999369927, 2.0643888698870443, 0.5159273317443215, 1.705785439137565, 0.6784286626633481, 1.065960035627779, -1.0998855349045442, -0.7970850704199173, 1.231463393268168, 0.7696369519036733, 0.9602778883462076, 1.4371276493819043, 2.0776238737295754, 1.4811111513004447, 2.6886842847927945, 0.21364389664317118, -0.8657730915091166, -1.9612393741383756, 1.2248094017989324, 1.5162049841484537, 1.0796582574933888, 0.6087186226106184, -0.8544984509717501, 0.2602075024804924, 0.6935583034443688},
    {-1.9405056425547085, -0.4088546845472891, 0.19333647008316598, -1.75280621789427, 0.7988900942646685, 0.21161228521339573, 2.0985030883634828, -0.2966623262539437, 0.24350368202023637, -0.5643004416752573, 0.7105523421688883, 4.265525452221934, -1.3970406081900881, 0.14966727707395036, -2.3582004108606127, -0.81971816281745, -0.830070307626306, 0.16644982347068926, -1.3326155730197569, 0.2422084292089652, -0.08054921249354277, -0.3798507267466275, 0.5921010397654135, 0.12232966699146738, 2.4278130092505634, -1.0152831163098874, -0.1323143602333368, -1.5390433147322364, -0.22562740978465518, -0.1647141364423414, 1.0788135049334968, -2.009047610006282, 0.9665612045259964, -0.9669458699351559, -0.3086908393302803, -1.3338138837451181, -1.4271521924123092, -2.7932885641112817, 0.12312417601686851, 0.9029567716808174, 0.13869621384060993, -0.5264830664211266, 0.4277602622532275, 0.12720725249068335, 0.8962836896224708, -0.5026272610213917, 0.8982569982198783, -0.8630340459367576, 1.0794429052390047, 0.9510067416603318, -1.5843670752781809, -0.20752995388882214, -0.004048228970270114, -0.03989848545658849, -1.0521073812869592, 0.043808029864579906, 0.7764108598441494, -0.21702771743617974, -0.7585947052128501, 1.8430097870248467, 1.3499779966337948, -0.4345149823356369, -2.0533461372648665, -2.2597231368850657},
    {0.3895437039807822, 0.45807302512881104, -0.05078086444089187, -1.2130560805005774, -2.232959572934542, 0.25463575602398697, -0.28399802912009825, -0.655628541093018, 0.1536071389381626, -0.6597449863298038, 1.716177813280231, -1.2482956026810739, -1.4948972570249404, -1.020704152610327, -1.758896299557021, -1.9132840824111892, -2.0044812073677365, 0.6555565259251234, 2.236920967941284, 0.7315616266178402, 0.2699537373975816, 0.4431564340185672, 2.714270482649098, 0.08373353422336896, 1.4802870050386672, -0.5563482361057203, 0.7814377380864793, -0.6489321719420788, -1.2520663866686048, -1.065548389601877, 1.055553922028615, -1.2618327343024776, -2.3714004614264677, 2.046393838076557, 1.1514038747002082, 1.5801316985570093, -1.353720548705791, -2.455019580703445, -0.1907624699855916, 0.8185409328902676, 0.20477631872878613, -0.19843546638755896, -1.2425299069599605, 2.854703927329942, 2.490377831190213, 0.8454034243329489, 0.5203994413416504, 1.477789182354483, -0.9833996302964777, 2.074088665086331, 2.6079136397110916, -0.8026374877740623, 0.6583162754393016, -0.32359318013460275, 1.8911707309880352, 2.9804317971223897, 0.49433812813911515, 1.6130773622760106, -0.6139180800598015, 0.07865415312089911, -1.1503335098386571, 0.04798078738948344, 0.5755213692225212, -1.3057976574270962},
    {-0.2167480648739446, 0.1464823076488714, 0.3594339384958439, 0.4255612937776962, -0.3869645906141029, 0.8991531944913731, 0.20609342656519572, 1.6631693393328344, 0.08177776965897363, -1.7731692700248516, -1.3192716262911506, 0.0515153279569747, -1.1103043961648897, -0.8060672512047731, -2.3427866229830756, -0.2400464316118278, 0.40138022515972915, -0.2637046815579735, 0.6338134178182607, 2.5357663509780872, -1.2978481469061713, -0.2891250823236875, -1.0970201490849263, 0.3965579754275121, 1.5329716085213365, -1.5852658534284594, -0.355818599023973, -0.30388235089769405, 2.089459684796916, 1.3454161895020502, -2.3709850337695904, -0.5927336148730403, -0.5581846658913526, -0.46960217752852723, -1.954597302191156, 0.049558832292386584, 0.48986809322527036, -1.2666628822075348, 0.10494515882819902, 0.13685581097599023, -0.7355314069111837, 0.6493278523513241, -1.4830472634441612, 1.6686987130549238, -0.643044969096436, 0.7761706236765548, 0.2642156367788997, 1.896663536369736, -0.7381217480911109, 0.49364795134456996, -0.7914610806446075, 2.0594073898020957, 0.23912708780257483, -0.33541317064544607, -0.24447427877797753, -1.4541653338654468, -0.5949786782670815, 0.5559396417315391, -1.1785753341870375, 1.9181747501745636, 0.31372463548844287, -0.002204817928795002, -0.7839247638585022, -1.208013584665905},
    {-2.820419800185692, 0.3679863009992536, -1.1544571510748154, -2.8416499297202673, -2.7950351619012883, -0.519344391698302, -0.13740767920322755, -1.7086311599910913, -0.8106585388243005, -0.4645420947768921, 0.6646549096051324, 0.7780662801941649, 0.6890905946961654, -0.9620909636557345, -0.7738099443365999, -0.055847735857321876, 1.2630507861796871, -1.235670038473404, -1.2911442230307681, -0.11936703921079071, 2.9898048860015796, 0.5868484782717388, 0.6654305051799206, -1.7158548433169398, -1.6899841848396788, 1.805398315001956, -0.22043489350614706, 0.04455749115657143, -1.2564500049236638, -0.3282601840375642, 0.5320991052837442, 0.39118547645835583, -0.015392840777887487, 1.141464211724898, 0.9543004838160928, -0.748121695804535, 0.11802734836115472, -0.9657320252134393, -0.4470649289250301, 0.6692863720010102, 0.37844148758259244, -0.48437872780127295, -0.1829648481656039, 1.2619931652352014, -0.440892274526579, 0.8168541489890679, -0.34497575949094333, -0.9606587695755826, -1.8453933697259806, 0.5650108435447914, 0.29364791029730264, -0.6934062828906532, 1.7339736197508158, -3.516216549533919, -0.4717427108980314, -1.1604973587752472, 2.1749075290479083, 0.515953382476951, 0.714830789238333, -1.2143253191199925, -0.32169705487702477, -0.5409827935926421, 1.8470689524200337, -0.8716515847478128},
    {-0.31681325948991285, -1.755875591296893, 2.846282002783938, -1.7559122248556591, -0.05558421185509879, 1.6916795684296122, 0.9501265059613786, 0.5198115150772122, -0.39524597482143464, 1.1100590345963657, 1.002096909282681, 0.6323004686350913, -0.4548833125342766, 1.0376951196054953, 0.37202607067973037, -0.6166733618814045, -0.02121187807914529, -1.1646907959963835, -0.3601978513014084, -0.836294195040732, 0.3353267713870081, 1.014344235836601, -1.64792111207796, -0.17859613852244346, 1.8376626203158046, -1.0055215335409504, 0.5571064036695265, -1.121623887296314, 1.7953208597218593, -0.26386391231876355, 0.7534132304750591, -0.11854905079480382, -0.7199440844724856, 0.30563763933366805, -0.7287954145179084, -0.47997202186647697, -0.318172790400518, -0.563209094208324, -1.1188038352654595, 1.9155875689464852, 1.396995896269008, 0.29565704830400497, -0.25566326427851194, 0.007509706477735031, 0.3338569355966392, -0.37388386193641016, 1.1051263148596515, 2.879951007494172, 0.5061545041867042, 0.5570370095236017, 2.1974408989534866, 0.6807579437477033, 1.191461457529583, 0.29922032407557103, 0.9908723469691483, -0.9324547926398558, -0.006599422435412608, -0.27767174233702224, -0.8481835905942826, -0.8703293558383489, -1.3443591442975154, -1.9130149621941153, -0.1888992841385751, 1.4282787726422204},
    {0.6080291775154146, -0.992543662430154, -0.2698909355440377, -0.2503361097888422, -0.21847772274543412, 0.7717032237092296, -1.9731088674665584, -1.3507805831791202, -0.31514554714161624, -0.7726143934492918, 0.5343387203682103, 0.13314470213233487, 0.3500568008499324, 1.2438450906046834, -0.6004598606792644, 1.0944107120173474, -1.8210642483841328, -0.8299564727726758, 0.34746238167415777, 2.4573708683948903, 0.20109878190086425, 1.3344100432204888, 1.018710927161012, -1.1763820547840953, -0.5356846205903242, -1.6677537858442066, 0.960281324273038, -0.7874727445892844, 1.3317268082406104, 1.2613901322136836, 1.7187523266473532, 3.823341639063467, 2.1829835207612973, -0.4132912622196203, -0.5444616612573374, 0.357650861768952, -0.36100635201125314, -0.45541485250618285, 0.2451327350491888, 0.09629650421568166, 0.42829298049640313, -0.0989579153985035, -0.15791662766833328, 0.24475755940300722, -0.527835311939116, 0.35698973516023175, 1.109036944530896, 0.673634884288351, -0.7982714243671322, 0.2299259849889078, -0.49497242872809577, 2.3991564430336014, 0.8463090389975828, 1.3343130310587432, -0.11297400162655782, -1.0980660976309722, 0.19392598722044402, 0.7397726534268618, 2.748303626307949, -1.1530359935438776, 0.018187753436776876, 1.114578592934719, -0.09174815504601076, -1.812424958311351},
    {2.038803069957098, 0.1501605086077603, -0.4363617606907017, 1.1619670171668854, 2.2488719685713487, 1.3574482730721094, -0.8412270517760068, 0.8693645689555621, -0.42577038692089364, -0.5037187635507436, -0.9687887690406445, 0.40415721879247046, -0.6618978371530249, -0.12352037525540202, -0.49331012421216947, 0.9960403017987922, 0.30649948947764094, 0.19200100223062005, 0.7635532841605089, -0.9409671091543279, 0.9418394862100343, -1.139889768053665, -0.4033398665619799, 0.340175375425209, 2.076981485238205, 2.1396798740864313, -2.6902385630808774, -0.5787965453021379, 2.3207207674354007, -0.8232649342351046, -1.6163658849552447, 2.200437335284567, -0.0941310059199142, 0.0005056175121929503, -0.14000995291251173, -0.9840811415699149, 0.08893949513725383, -0.6228647285316972, 0.3883003475639906, -0.31473777318736024, 0.4669817249597096, -0.7203229331400989, -1.0839862538547325, 2.375086636513603, -0.43539980961764396, -0.37741465191248, 0.6144702803793112, 0.2162555352447819, 0.3998729177054158, -1.334430521541911, 0.6478884084247813, -0.22113381017683023, 1.0801276544210867, 1.1711355896664866, 0.732892073937472, 1.073575034054924, -0.7178214779147354, -0.5047859626832363, 1.0104423503055728, -0.456325671417489, 0.043929877876431385, -1.3688463664309027, 1.85933777984061, 0.2744274096459605},
    {0.5896885026732713, 0.1700192647468237, -0.06704661729725162, 0.8489179809298975, -0.14399942741936175, -0.4149177147615218, 2.1850065191633354, -0.17084166233869788, -0.29638698323327034, 0.1545925635240133, 0.7941502571392514, -2.448898864381892, -1.0870311906857486, 2.2735957963665596, -0.10399638493449456, 0.8625963631904693, 0.2957925497103378, -0.7052515808165297, -1.9486217425454626, 0.030544133816033676, 0.819467477575221, 1.4845956063015153, 1.143725088640414, 0.23511064450275976, 1.787056397361974, 1.8169181301270805, -0.623506078749355, 0.49239045657926467, 0.17787103663061457, 0.06637185387920147, 1.6884877178944815, 0.12871858278280918, 0.6137840031663292, 0.3201201000869236, -0.6018155060558676, -0.35399595641070586, 0.43814086133192176, -0.7440931910135608, 0.08503536160295384, 0.8436706070520132, 1.365473239675274, -0.23895879902515108, 3.1634599201765385, 1.8497951937545238, -0.8159109641406522, 0.0651138002442661, -0.490403287007728, -0.33111522618455813, -0.5947679339040288, 0.28815082996544755, 0.32534663995621266, 1.805975270461255, 2.505713896502705, 0.3689640548090889, -0.22796135778929366, 0.5930071153109859, 0.9715601728999351, 0.5112432405895504, -1.3082197657488008, 1.6478740516698054, 0.25505726101979487, -0.3945632929735149, -2.2359879549884396, -0.9541006703124759},
    {-0.6915579222216945, 0.30547089972822705, -0.7434222763169696, 1.2941141554572873, -1.73105390438721, 0.8146367610675481, 2.3124400714898496, -0.5232595167033642, -0.5145114834566207, 0.8416750398853693, -0.21139211746126615, 1.1098134136022788, 1.5794929754531797, 0.14626259675808495, 0.49846037480250127, 0.468952421463206, 0.989002765522709, 1.071012691182129, 0.4804496300503064, -0.1146411144724124, -0.4243008796074064, 1.5019169687982834, -1.4998839436732576, 3.0165523412729325, 1.1360374955191113, -0.9399907012337572, -0.5980822322749726, -2.299007567525264, -0.28682350504308, -0.3780892145148837, -0.611123751455524, -1.4353814219391896, -0.2088155054161457, -0.21461429666249196, 1.0280624323293455, 0.3997688301210817, 0.2692490084491266, -0.3764661631248114, 0.17958178828847754, 0.2341006383546425, 2.04356937891402, -0.9784887652429901, 2.738178260055213, 1.0187793400755623, 1.5126844287749488, 0.8828003593143461, 0.03833627921585982, 0.4233473526740747, -0.08221439444895148, 0.933664962391729, 0.6577549397447393, 2.216919510905054, 0.49588767493116703, 0.838227158480263, 0.9630800867618736, 0.900721624796241, -1.337447006540071, -0.2609087665041076, -0.28153745381863776, 0.4401219507512761, 1.0453229774830815, -0.886882156236503, -0.5142821021054593, -2.143045710415368},
    {2.0274395943774115, -0.5772981249267073, 0.2007866762577961, -0.8419233546021542, -1.356205299336215, 0.1653214899775465, 0.31876611706499086, -0.18645311077880947, -1.0254848250166053, 0.9419203202949912, 1.6676249991597873, 1.1049717298638801, 1.7710148211171053, -0.23553390180934372, 0.043915721309032436, -0.26912310740940765, 0.41086217295810973, 1.4610445783618662, -0.3756509924579413, -1.2347164361951652, 1.1156780582392418, 0.8877846063506428, 1.031078192935027, -0.20669325891971757, -1.6539682212288396, 1.3158179564210661, -0.45221479573893836, 0.9315877390816919, -0.14701207040904457, 0.7206641542743758, -0.21014528214308853, -0.21535651566788608, 0.24944912573226133, -0.5468712725854681, -0.84881436297143, -0.044997245689498096, -0.3193296737523619, 0.7440313707819847, -0.8122086018269973, -0.3529365410667484, 0.05683987382236978, -1.4007289391318005, 2.8132835154160647, 1.5070576645135367, -0.4431707342337428, 1.2093330450767075, -1.7815009197212113, 0.41426255125992606, -0.5211049297131618, 0.0030846047980754134, 1.6060347975648734, 4.413834356677491, 0.06933692648148537, 1.6207397756041646, -0.48921348246042684, 0.783336763151903, -0.21541660892961556, -0.6059370330143969, -1.3337582947360285, 1.3594006514186467, 1.739459176858587, -0.5140463402808887, 1.2029770103926813, 1.9089174758524152},
    {-0.054538209836417974, 0.6799823966929702, -0.73860679608126, 1.8444755956014034, -0.21017898613781727, -0.9365547107948642, 0.7689252212963785, -1.7031384204834217, -2.1018479969912156, 1.5765518447491262, -1.0438862478917863, 1.517522304738787, -2.07341486231212, 0.4105467202860017, 2.116094174209137, 0.7240499892265464, -1.5113607409940262, 0.7802566380670313, -0.6703945827584388, 0.017426900530442352, -0.40434740839479694, 0.03131249333578983, -1.013003687737601, -0.6567081077958479, -0.3875791226247605, 1.700607841404027, -0.21735695117673007, -1.3744342792815698, 0.7630528081234886, 1.2058666348430307, 0.325838857987883, 1.4232503728096253, -1.5269544435658085, 1.057791145454638, -0.13732956673066912, -3.065381910905397, -1.6643265163469667, -1.6238604732546118, 0.6416535648732079, 0.4886522002849965, 1.6213208930024612, -1.1192854206446388, 0.4868427315764244, -1.3844540975796602, -0.15872799326551984, -0.9421539192921092, 1.3368510426223685, -2.343793635654923, 0.020294216738470965, -1.4185754638905999, 1.6543038100928475, -2.1636982856454967, 0.5680508325846554, 0.6593518699193837, 0.35542260994468544, 2.692609400467228, -1.2985158294487165, -0.8854785996004534, 3.2633232415310625, 0.4933708154106175, -0.7281998173524205, -0.8356482801061251, -0.12057317966027606, -0.04005192726135182},
    {-0.6993026567968287, 0.7487813884872971, -0.79344320323875, 0.2637440947022693, -0.04486214249840082, 1.9350070319138355, 0.01161261704624982, 1.5434942810698304, 0.276723540971279, 0.3482974566781023, 1.7006431080256212, 0.32734354796067217, 0.5908522430829297, 2.7901906169546953, -0.5809308687025098, -0.344825167766916, 0.7566086791090675, 1.8873726928755605, -0.4565454616056513, -1.882728616782845, 0.9983358758957777, 0.19252224547826596, 0.848441131422389, -1.1211656726757058, 1.2232280584052586, -1.079337211827304, 0.16712990673613007, 1.202888848077399, -1.478859362763609, 0.6822204003254525, 0.35680515296614634, 1.8580639641666699, -0.25672577933650714, 0.3923276104292175, -1.2914267592903883, 0.5156279640161979, 1.6926697553979364, 1.1295587887304215, -0.6186240499799358, 2.7101599230973217, 0.8707826437516466, -1.620773065335621, -0.9079358024815433, -1.9210706217238729, -1.0686426984102158, 0.001988196138861784, 1.384817333673464, -0.02790338742424388, -0.15432394388948567, -0.46825650676178954, -0.8763611206159828, 1.3512592830206456, -1.9116487191404332, 1.841548678303905, 0.7541813952218552, -0.08233106927536321, 0.19922822792004619, -0.9413491269585305, 1.665042449859745, -1.0641345675275946, 2.2490143459687024, -0.7784255792880507, -1.4271895028887227, 2.3896906580525363},
    {1.0024343786616228, 0.24219562627426627, 2.4475012236682687, -0.063029303309672, 0.9234237018030168, 2.140293970209072, 0.704077155693174, -0.04963134777966876, 0.6550269210165032, 0.11608945482761888, 1.8851452933345731, 0.426861710345066, -0.1057752297631975, 1.4219141551852346, -0.3169864073581306, -0.46967200943218773, -0.9630067470946052, 1.1604765661910394, -1.3013397213809326, -1.7375668735621632, 0.2419407122792835, -0.472195122834782, 1.0016972851738923, -0.1319820113250155, -0.050653401361141506, -0.6431097894851877, -0.418508909631804, -0.637458361178599, 0.43081720128945955, -1.7722274001474914, 1.4582387271606903, 0.5701808907297401, 0.04748664896928747, -0.7227990199382981, -0.17081669745071223, -0.6566147598350106, 1.0912398114137125, 2.872949212764415, -0.17476507923427267, 1.9920561146298608, 1.3759686772982866, 0.4359762093611552, -0.3200025221715112, -0.3167407141616614, 0.10662894245853202, -0.4114576276160004, 0.43828357763963305, 1.0791397340319588, -1.544851743835082, -0.16835907837234565, 1.433127143473448, -0.0018601492679062809, -3.039151989903676, 0.6131622688177253, 1.642340522164919, 1.6841371093615924, -0.7990709236877821, -0.45085477182724853, -1.730706820836644, 1.6127989556936515, -0.648566978372242, -0.2297361187658739, 0.06091962398728172, -1.1619678907132567},
    {-0.07197689404998424, -0.4159867087636591, -1.2349006057498233, 2.1687122446721645, 0.2329331494339374, 0.9942574068036032, -0.11593865936484991, -0.35208510867138026, -1.85793666571397, -0.013878546346166247, -0.11595867104443115, 0.3830700544088599, -0.335750626636086, 1.1311044918286208, 0.5518981445979764, 0.44626602614803473, -0.0948427280308898, -0.32653691465746065, -2.1394740576920137, -2.6745659867926883, 0.2936752901825494, 0.9373223828185746, 0.06544344149512758, -2.6716388587751663, 1.9219347447788369, -0.6290962857972718, -0.7042331283450274, -0.6562382764121774, 0.019788128233705893, 0.6143061701774553, 0.5343551291985752, 1.2225118471160978, 0.21717261614828548, -1.229583678036568, -0.45471650280037573, 1.184627309492852, 2.7156019135737073, 0.0762195418941125, 0.4265684198603834, 0.7941939528263712, -1.0773694008618044, -0.16997990460887089, 1.1735471992307593, 0.7729738001696781, 1.4684781599502488, -0.33469092075558327, -0.23669206707835969, -0.6245250251298903, -0.1636425756791935, 0.8822173951424782, 1.0181712646685108, -0.3706691357259901, -1.0096938913699705, 0.7939410305346061, 1.3656530513718703, -0.12707764916941305, -1.1079291354486327, 0.10190885327439388, 1.5631226442455388, 0.6133087706183118, -0.7932248590659101, -0.03415786588459001, -1.7725184434879475, 0.782818320252849},
    {0.27031260862724404, -1.1226095930139528, -1.2786630317863692, 0.9033562066894265, 1.1457069139957134, 0.06357144533808307, 0.9756531157322904, -1.3806330149883046, -1.2841677092210928, -0.4581958039102343, -0.046147975397572684, -0.5654963081130704, 1.183951711532517, 0.09999373319623887, 0.16683284852410027, 0.18293808285801427, -0.5926117176270933, -0.01027370699396333, -1.3150722277701703, -3.1744692770963714, 3.159954535056026, -1.2758645710197705, -1.2204469037616916, -1.4436757594768237, -0.8110768721250088, -0.3706957933347001, -2.843123164718474, -2.4806435166041463, -0.4483687088169066, 1.1539518776209419, 0.3331878301007178, -0.3114792565556943, -0.37380235977808424, -1.0040159350170628, 0.2912554532404923, -1.3170608825885781, -1.1472301172409949, 1.394981609550917, 0.9632849461355497, 1.7092749825091076, -0.7926638008409722, -0.6841011051708058, -1.0538927245093233, -0.3272856877246663, -0.4737977217358777, -1.152238393377285, 1.9387106986486597, 1.4933739265958264, -1.0038404236947067, -0.291938090466549, -0.08827977163202838, -0.9593729561367975, -0.1850567211329655, -0.6402209643863698, 1.489578627965525, -2.1976044633100384, 2.1906716040365306, -0.09195342943154242, -0.6428130191386707, 0.3599567538534897, -0.5041402623594324, 1.1453878022518442, -0.9324299407920851, 0.8994531619249635},
    {1.283933288649049, -0.522063930229591, -1.8566385760583695, 0.13164990459414083, 0.7598459050177763, 0.6270010240376126, 2.870755243401805, -0.7960330460055834, 0.9344635299354133, 1.9437062803362977, -0.6053089198252252, -0.4526545734660718, 0.775203524973617, 1.5328190370007224, -0.4273647470661919, -0.15774625225307, -1.0245651172042174, 0.18543250872078904, 0.13294654337738013, 0.20962856138613348, 0.7264393146611485, 1.68924913362766, -1.627675240066444, 0.6707056538997171, -1.6243672874048134, -1.306271368744833, 0.21366578449707632, 0.19359860588843295, 3.189214644494883, 0.4396914173876282, -1.3798583680796366, 0.46734847046141337, -0.38105718812221767, -0.8267708352388458, -0.26587864293829155, -0.9250623819801327, 0.3639975694630029, -0.827527110666557, -2.0417541099978367, -1.6714988161429853, -0.7550249118240258, 0.3723865188553788, -0.04145914912503418, -1.8461166504474376, -0.954663971127819, -1.5940866654817278, -0.07394116547097741, -0.41161604242631633, -0.26618696837260936, 0.6944883015924818, 1.5574348229948893, 0.36317201938698956, -2.1724658234820504, -0.9803921100376347, 0.30440655264754235, 1.6002620724909173, -1.104900801752733, 0.22066413036570784, 2.5719301741079934, 2.842795493068303, 1.880428600954088, -0.29936174595619364, 0.8623798447201091, 0.3824630798019253},
    {2.08715233129029, -0.7247504611121456, 0.19908153845986526, 1.0237038619927408, 1.967566492983718, -0.22606992321902805, 0.2600151421972215, -1.4334123542453259, -1.434419789636589, -0.38535691032972, 1.4866263999159983, -0.9520491905885019, 2.268782222642102, 0.3070746800080975, -1.1540373876264565, -0.09321481359463184, -1.4235991163556077, 0.6206242177823558, -0.8814271340733326, 0.3664511055441796, 0.09000200533840205, -0.7729151031416244, 0.7524386093525816, 0.2872573449753499, 1.2907694585855178, 0.19276639697951845, 0.9091670852659757, 0.13813238399344485, -1.4803158403732968, 0.4657884167562231, 0.33995431990483427, -1.593561851072567, 0.4203728419096495, 0.699601665557708, -0.5469797927567638, -0.5326894211528288, 0.37774750098032084, -0.994151198085979, -0.0075939962253977365, 1.9111398005521611, 0.7788968666656247, -0.13199357190574768, 2.987821107569585, -0.6616581412977445, 0.5403453107096632, -0.5759022673940782, 1.4239596893421778, -2.2209155227402073, 0.47042220954547315, -0.3784065018318454, 1.484533695251289, 0.7611336063152729, -1.4266687071934057, -1.4198170907927379, 1.8998516718403766, 1.5441727700371388, -0.021059648151265955, 0.14544340135187775, -1.0858916748014533, 1.2784388069377892, 0.9180413978308665, 0.2085894155838259, -0.4881226744387239, -0.8696074272419441},
    {0.015429764271352207, 0.45895784601053824, -1.8066305533051235, 0.05966598568641898, -0.009325157155244922, 0.16018047137410354, -0.03822153039891616, -0.19084214677664688, -2.650371077791003, -0.2822054167837829, -0.5087914220910917, 2.2911062394797184, 0.19287749063884768, -0.2779786410052853, 0.5256392223157906, -0.3883563716454546, 0.2635848133165599, -0.06557940120018105, 1.190859952382873, 1.4384185053671217, 1.080774717590964, 2.2080449266197797, 0.06347685573224784, -2.6205625788316356, 0.47290562208332965, -0.88447580495004, 1.4271272225754066, 0.18064239510428273, -0.18096770973811996, 0.38337875083368395, 0.20577326667847715, 0.4828860523221302, 0.9075563601697558, 2.0953913397052695, -0.9881841289387376, -0.45584563201822986, 1.3325768623362613, 2.0406020440167096, 1.1294715062599192, -1.0915942585027392, 0.601871318608024, 0.28461430430233464, -0.2767047978996275, -1.2943297249324281, 0.42171252334273224, -0.8311625311532538, 1.2428368494662962, 2.007697896770813, -0.3943598418787242, 0.704834347493188, 0.11198917609138888, -0.43344666346811667, -0.9841514079130755, -1.6098006976176642, -2.3738442694375173, 1.2388831285728976, 1.133105696983541, -0.22619996000661566, 2.4308938412738903, 0.8670657942992045, -0.2240364876947784, 0.03119476319989444, -0.5110329238534621, -0.04407939360225338},
    {-0.25849637517871665, 1.8395628985998629, -0.4417585725780454, -0.8958889355520139, -0.12994351327363943, -0.6661806099618568, 0.9774612896660835, 0.04747181059978759, -0.2780660754430339, -0.17925678447717083, 0.03585033573912993, -0.9628521853267515, 0.5462909519317022, -1.8039764594343857, -1.6032354946054108, -1.0315038928639428, -0.6287413693601182, 0.34837410011233216, -1.0683007969706746, -1.190718668618143, -1.9443054607930357, -0.20838413825769594, -0.6119601096089083, -1.994391079904964, -1.3706488278847604, -0.13552800772029358, 0.6795072285387498, -2.419227783340888, 0.3727581401839375, -1.1534402239260393, 0.8587851315997438, 0.7407276176687698, -0.3885250988717669, 1.395183801384811, 0.4713308543639981, -1.4142802616289776, -0.6474316309086542, 0.5751008034686526, -0.7181220278998074, 0.8439892229783427, -1.4037364402441599, -1.2382629524828077, -0.6688775409818825, 0.8289230298862429, -2.1633029444165293, -1.800801237600842, 1.222960438441999, 1.2116184598959885, -0.9384070342195087, -1.9855922577177492, 0.6357274854141024, 0.8363307369001715, -1.84401186475329, 1.705036837472718, -0.11813012204637403, -0.20776515487605846, -0.5536221299376042, 1.7299816547278175, -1.1248880177756178, -0.6240354636198163, -0.3495661918437047, 0.5556922121979575, 1.742994897465777, 1.4392571487497192},
    {1.3121655063314022, -2.1013823896662935, -2.1125323576608346, -0.09352957139834428, -0.8026952792690091, 0.9839433995855849, -0.5842525568090724, -1.6235641285517355, -1.686714678678381, -0.18982743307103, -0.3373020460006041, -0.9542645469962531, 2.177291586539208, 1.3511713904936256, 1.0526872286704159, -1.0742208866916256, -0.4636827290939461, 0.6108532516139692, -1.646431385200567, 0.06661120259372616, -0.0946370485082477, 2.0019045087996936, -0.06943124342213239, -1.6145772628319304, 1.2105050260400096, -0.780382168281266, 1.081646625461179, 0.737297552179312, 1.9218508520618993, -0.5192389742936552, 0.5216342151357167, 0.2880155179979729, 0.6818673829057501, 1.1271813051247712, -0.2495202235554745, 1.1001623966266927, 1.3993445027116358, -1.2141376210059491, -0.2850195621065608, -0.6864869643881698, 1.1500467656811146, -0.3483009617821473, 0.6232709875298024, -2.317334320355931, 0.5292308300997678, 0.8672545134030194, 0.944098467090256, -0.9052591152921354, -0.6641527883883923, -1.339444781350755, 0.7469820698767582, 0.6136836438886987, 0.2629383175802172, 0.8833171463660042, -1.054779957718589, 3.136526151545914, 0.9221861314161879, 0.2521827785421735, -0.5707220913707596, -0.14499673667690882, -0.5238008427441595, -0.20398199713859763, -1.6406426191215597, -0.43596885551523795},
    {0.5090201824332491, -0.5403156557256418, -1.2642226202750984, 0.05580017218111548, -2.515830144135568, 1.6200916473874671, -0.33914934225026605, 0.32575816665427515, 1.0273966974644533, 0.38133565081112814, -0.21532542776981126, -0.7666679862610388, 1.712014546172717, 0.7195534844753213, -0.8663870644918802, -0.7039684531340625, -1.682951650124146, 0.31039149850740066, -1.3779707827368104, -0.9332808478147804, -0.2841609068923907, 1.5485322196970284, 0.47660427175080466, -0.4636482795619332, 1.0529808505222382, 0.21455832661221308, -0.18445871626726146, -0.22402566826784748, -0.14878674721822518, -1.263203332808543, 1.5154432329046796, -0.9570380561164817, 0.8607223130052619, 0.5999989116115617, 0.36006999862765193, 0.03963010847477956, 0.08698039729065062, -0.1315184815012746, -0.33176700463806436, -0.4495331009959453, 2.383186375195662, 0.9443083881220037, 0.8222135473810654, -1.2931866946341533, -2.512142877392331, -0.7723231072339568, 1.7254918855463504, -0.5245031366992078, 0.3028662287006632, -0.5693727411505195, -0.9436619911906496, 0.14386563541086128, 0.24624399877767522, 0.7462268041577961, 0.682157830967933, 2.9222487017225456, 0.9899515991403322, 0.8808097293860375, 1.8406133954957475, 2.02882645858633, 0.27373360398135105, 0.13883720736126745, 0.23422142626697617, -1.5075967222658369},
    {-0.9931126631322668, -1.518768006217706, -1.1299168574754401, -0.018747178816138892, -0.6336932059401132, 0.03923196528646082, -1.0824947816105819, 0.27075261474447576, -1.2415712890249395, -0.6745710230660535, -1.0539344343727568, -0.5722627264446657, -1.8228946235072208, 0.3425538999587556, -2.0147324625379346, -0.7739751845647633, 0.7500869631315015, -1.5737803341005667, -2.5884545451929566, 0.19430462639183724, 0.32385467859541583, 0.5595189284210325, 0.19338815636208262, 0.17235870104638942, -1.5273931593490528, 0.0052431052234469784, -0.25535441999062614, -1.3320079653497028, -0.9884748499950519, -2.526983619073173, 0.3114207880655902, -1.2074641435698468, 0.2843437471952472, -0.13318991819538023, -1.0436732672171547, -0.6540717041854489, 0.8820384635049444, 1.0029384165492756, 1.0746002788153222, 0.5422136426808982, 0.7148140754781304, -1.9381560426802231, 0.24299627946952085, -3.6692180748274197, -2.3854571873420958, 0.9299422868805104, -0.8434726558364243, -2.8128196244472368, -0.8943983359391503, 0.9142117221498227, -1.5955152173555036, -0.9972861745839514, -0.5205020815748889, -2.0098483018314064, -0.4688250397582043, 1.7037113062867348, -2.331290307155406, 1.8415778456546983, -0.3768628598089015, 1.0432343269960507, -0.5180239862289646, -0.24237348292926778, -1.0711546948945347, -1.6708975057030575},
    {0.12404713793712305, -1.2592408453662123, 0.23799350828568894, 1.1394768216155569, -0.1776997395200205, 0.46592028712821, -0.1111895113416557, -0.03170969064740482, -0.4677473850718354, -0.9312418724233281, 3.625927521387249, 0.3760210819928406, 0.11321042258752119, 1.3854392823615946, -0.7907427100412034, 0.5791937455678693, 0.265832098329186, -0.5167946969748656, -0.8255671526339741, 0.5580016402560283, -0.19389328432497094, -0.24560759731577594, 0.2184884305212375, -2.438099441514852, -1.8382339160114327, -1.2657772943412702, -0.5544249535682177, 0.01006559388029159, -0.7521722316449143, -1.185835124071154, -0.5884339167474336, -2.0532855012905555, 0.01002326521128526, -0.4730758587080365, 0.24641096761413422, -1.362770794699517, 0.06407971053773813, 0.070971477403303, 1.3389420580725686, 0.7879247816605436, -2.11535859262123, 1.0595114357204336, -0.8475218569441328, -0.9294058637141525, 0.6169846503667484, -0.8209119489486939, -0.10809825484655403, 0.1578357748912068, 0.07902644317264629, 1.5671962531024675, -1.3188448351973814, -0.9759264533193177, -2.582052587269389, -0.551140811753214, 0.2989565500658738, -0.8324386566368446, -0.29954475146521103, -0.14600872256531733, -0.06524148814882341, 0.038504325387140985, 1.4567586422695047, -0.09540493166064795, 0.05253917435962835, -1.586902878190636},
    {0.08830956086830243, -0.5981672527195732, -0.7846765938768858, 2.000969968897416, -1.070584734698802, -0.5992451722061155, -0.4716766157976626, -0.2183747297344753, -0.6522324188877529, 1.3291431188952887, -1.711717017542968, 0.740520717126688, -0.4513376993394138, -0.16536769669321638, -0.39106804695678243, -0.23240375845713276, -0.31068370704067605, 0.42114378158047455, 0.10810541391358304, 0.19537836521775534, -0.866077717130914, -1.2017416714423765, -0.2377547630810499, -1.317395687335686, -1.2696645452717144, 0.22290673796943974, -1.1725034679369757, -0.7788495191548008, -1.2472093092931873, 0.49406106169420905, -0.8817821258960804, -1.14708057444787, 0.25687777214482127, 2.1091065072417785, 0.9455417725376849, 0.5141173435134252, -0.06621417173687673, -1.1018456402363659, 1.0987270523111834, -0.24803531127016562, 0.020616624549312613, -1.5010983262622724, -0.2757745314049532, 0.12127502672326042, 0.1865121428562327, 0.9688309708374955, 0.13672434681595452, -0.9980463130769206, 0.6168910945779997, 1.0537648923259193, -0.08966363248198012, -0.9218734046777006, -0.567292682191442, -0.7883228568136796, 1.7873158660546902, -2.4389665980153636, -0.46580509379194784, 1.3321170486887783, 0.8642717268488816, 2.2346396508618627, 0.042750086972804684, -0.7954163920239177, -1.9505854546597612, -0.6340591321552128},
    {-0.21366879723539617, 1.3789675482248418, -2.236680919722267, -0.04003442569863556, -0.508102604511232, 2.724838832535182, 0.9571604575495352, 0.19895101380693486, 1.1998273975277596, 0.34871703048782915, 0.5864896226978418, -0.07111963765747988, -0.8417608071171693, 2.0416978747905192, 0.932514575838853, -2.54471012632295, -0.7188503362443909, -1.4926403670214998, -0.23343291661619137, -2.41605861762457, -2.1560986527410035, 0.5533308028566571, -1.2230799368978984, 1.5597472500888585, -0.010563682109235471, -0.26556718068359186, -0.24590485697132847, 0.3715949235394044, 1.36960459152778, -2.4053270045015553, -0.34157909785620844, -1.290194278843816, 2.1856920622209, 1.3082185086167437, 1.455819975651038, 3.065676101297739, 0.5329994776539085, -1.7915938924920538, 0.8373949426977743, 0.5932325459814914, 0.051378479946188126, 0.8799075085216893, -0.015199076166609643, -1.7302760410503149, 1.6174729140544695, 0.2904156292563438, -0.8108001989091721, -1.7320600787708709, -0.4466393239662288, 1.4226405653628484, 2.107287311160642, 0.7154470796254044, -3.565141853028282, -0.9759670692735952, -0.8572124229045892, -1.0993870968450878, 0.31363925591748926, 0.5473189067583892, 0.05275888388755737, 1.101580974503257, -1.1385260860106379, 0.4743314420570463, 0.5575015293537303, -1.5213852421580485},
    {-0.3182655793729404, 0.4361695382916649, -1.1725627392621831, 3.0146861951820325, -0.10835821253738427, 0.09422497592670487, 1.4334476157173186, 1.5850034093866519, -0.5896971045465279, 1.2862278002085326, -0.28430609474293983, -0.7210568942445047, -2.6883802704349353, -2.7276452208912167, 1.5996521839937021, -0.46537527150447544, -0.38981019001748624, -1.0576263644726993, -1.0588810438374336, 0.4900971122067171, -1.113156752007346, -1.276338760305117, 0.6643965799240269, -0.9512830391023956, -1.8357055528438184, 0.21402380969244092, 1.2268088039626557, -0.5196602357444507, 0.811306779195608, 0.7120982876896953, -0.5690466140440996, 1.7514683372874968, -0.7685585636389631, 1.5743607328608205, 0.8176103830818593, -0.7158765691737395, -1.7293972178045283, 0.5414229207961823, 0.32156579584756306, 2.341337939953411, 1.3691350378384375, -0.20229998137635993, -3.9347247457662995, 0.6052046878264291, -0.7815952212984725, 1.6647776616669676, 0.06851863224025961, 0.7796138384920613, -0.08292893177285277, 2.0385827661851788, -1.3007501630697493, -0.7415402708570225, -0.6683765768604588, -1.0464696244307918, -0.18815210139389332, 0.23371200216340535, -2.288298732551562, 1.0484594337636002, 0.19705812337598774, -0.12169991957784398, 1.4317693580649236, 0.5702496266832622, 0.2502302508298657, -0.2964264019470396},
    {-0.55295159716462, 0.6309609298474396, -0.28381135876345837, 0.07076985543598381, -1.8547970245665621, -1.082410209043767, 2.2235171579667075, -2.107502880146391, 0.3793591382855422, -0.5338630074814541, 0.11233351851794074, -1.1018805538141658, 1.9604107453497552, -0.28512841581421494, -0.014132857494114812, -1.186689203826005, -0.48198405530053606, -1.0806789335442497, 1.3175054717295738, -1.812765160181523, -2.674966921122788, -2.3488647735593107, 1.7901868772307465, 1.3406960521222508, -0.2757199369757608, -0.2959345940728132, 0.9716614361777804, -1.025706984178036, 0.47151052006885663, 1.0787375253779565, 0.785037601197234, -1.8517012828723998, 0.04720585944153106, -1.3267521390288972, 0.5066700164518642, 0.17682079530191927, -1.1750805725060292, 0.6492655193093916, 0.6539495674432688, 0.057602704242805995, -0.3547081445849258, -0.3959863227300424, 0.7008091163528972, 0.8315388662040009, -0.23500428011940114, 0.04439731828042776, 0.5960067686066423, -0.5203713221858917, -0.387354279544046, 0.8274986564483654, -0.364956755480535, -1.296005987625287, -1.3214560960937989, -2.079945971270286, -0.1482028650962624, 1.4139336857072247, -0.668543920851069, 2.240503502194305, -2.958362561385303, 0.3900963959638636, 0.4636993555250094, 0.40984502298699377, 1.582640869329211, 0.4472698800862249},
    {-1.156070559479345, -0.48959570624518883, 0.5749596342209837, 1.050659865122533, -0.9421465651984112, 0.3907812177969656, 0.6297279294365615, -0.3238195457571753, -0.4930499243379955, -1.8475846757891088, 0.9399292152316469, -1.12224883042494, -2.9204778603169523, -2.463742511927574, 1.0550737678517377, -0.7240489657506539, -0.2962789220450986, -0.11214719498509135, 0.08689653894370937, 1.5128366763328744, 0.681928399833697, -0.3297302919950556, 0.32009950733782067, -1.3635621189685214, 0.7370350598310271, 0.8020718302251381, -0.8451401271389503, -1.0112185757757117, -0.5555142086605817, -0.9739355031158714, -0.05227300725565922, 0.9769572244928794, -1.2632779723915974, -2.2068180989119672, 1.3179062963133197, 0.7060060058233248, -0.8484870401263686, 1.1100906759413731, -1.6919652736648911, -0.5397760020275411, -0.0830607220296317, 1.0764296584805404, -1.7623029690362686, -0.6367720876457732, -0.19171003326089806, -0.08293778658378775, -2.0614189358742556, -0.8858883431188544, 0.3961736293755835, 0.9211607261481158, -0.6259786548684388, 0.14046889153462042, 2.6544444701178302, -1.3693544723268793, -0.209486989567074, -0.06424963987706461, 0.2943328619795831, 0.7411285560377627, -0.9359595238031497, -0.14470625370392867, -0.7679273530347145, 3.1852016588059615, -0.6884624624324922, -0.03765023813003968},
    {0.6494333856224686, 0.12468777568029614, 0.009347966204524326, 1.4408776198600217, 1.7762461564563128, -0.21904640289518632, -0.5655539414807353, 1.9755953530803836, 1.9963199769753663, 0.02720650746247587, 1.0434117502974056, -0.34778626959781633, 0.3956186770674634, -0.4081535323654095, -1.4451127737689398, -0.91027870583611, -1.4847634457595311, -0.08684333996372391, 0.35585603623059114, 1.3677724488617942, -0.13043740082558053, 0.6475512608801366, -0.6379565509232253, -1.3530362627760821, -0.32147509872406443, 0.6045412282059937, -0.5569037002357767, 1.007911848183762, -0.07315897423417184, -1.6944139826958027, -0.486832755470396, -1.1538101895263237, 1.2786135939660253, 1.693933777214529, -1.769543996844872, 1.065904048156846, 0.9778936744897306, -1.0029887278854965, 1.1856538842955626, 1.330104228984028, -0.7682089155742745, -1.0028985197855984, 1.2882731981528859, 0.533578385791553, -3.318312844682669, 0.4590431548977281, -1.1335827939014, 0.2113794740984081, -1.3292555934965402, 1.3616822506529458, -0.14171584561373635, 0.9412664822099399, -0.9742300429437438, -0.23946198456971934, -1.206083943839473, -1.775914827187819, -0.23722654966239112, 1.1562945515009766, 0.05359558926334579, -0.03651642254989082, -0.253809060764242, 0.8526175281817983, 1.0112791332118445, -2.975685720270762},
    {0.9489429880246723, 0.24077979337768296, 0.6331162951083854, 1.1878404083997545, 0.8700327926242083, -0.379657238405398, -1.7338237811245956, -0.31808337198066483, -2.1432409965110844, 1.7848730372196684, 0.15472895331954917, 0.98264467045285, 0.20314755102366744, 0.34852382678177596, -0.9110756901680158, -0.14685990038820143, -0.6013499980471774, 1.2406327858858957, -0.981700179178307, -0.3520426387035485, 0.9318572120771059, 0.40262897269433473, -1.0333126931323242, -2.542221358178456, 1.493045736150837, -1.0602444746844244, -0.7054275853943004, 2.251635933114711, -1.3335119994136233, -0.21362373971100249, 0.966448883545756, -1.8619522519188412, -0.9248388257147344, -0.47867727255383996, -1.082858266791141, -0.09950072436993507, 0.33741169120486936, -0.21249175201533052, 0.7706407746002618, 0.7168226496539142, -2.2333240241472274, -1.1119537556254226, -0.011879522715271356, 0.058160976009487796, -0.7354509800124787, -0.6620439016018054, 0.2768298523156115, -0.7729028328516613, 0.9316664062409261, -0.9719850986006787, 1.0997626975828492, -0.31030138254361667, -2.0888038976003496, -0.31728008615218867, 0.8093630166576758, 1.2511168932888383, -0.40652086646734775, 0.2215236919405739, -1.9449912250020625, 1.1116124649293577, -1.471700310052743, -1.795490447433911, 0.7109832615110028, 0.5716837163158305},
    {1.0975887571156004, -1.0327932346519808, -0.23842172132112346, 0.38370117496191875, 1.4673436158274091, 0.9447494852821764, 1.093976498356817, -1.6623351663285293, -2.13967766968482, -0.04383495547212726, -0.24177723960060626, -1.7358188150597618, -1.3961562921563755, -1.1745987470905233, 0.4790937755410325, 1.9784403139420506, -0.09418537952270593, 1.8314016116752765, -0.7784862025800107, -2.7875149833714756, -1.5291503216231574, 0.13191845672936725, 1.1370856262634936, 0.11768529694476272, -1.7002983641893819, 1.0262496831276902, 0.769012908779591, -0.6675307548344195, 0.5942599003604405, 0.8839531746984765, 1.0269796448761304, -1.0966989783435854, -0.9072256141430947, -0.4396174681497134, -0.5178079373774629, 0.4574051406841393, -1.1012747590513592, 0.8131600028217522, 1.6752128731217855, -0.7078720908393288, -0.9305884089677952, -2.3110314229868933, -1.4531898130098682, 0.8347857503267291, 0.1620470418097568, 1.85801936907284, 1.0953720153522983, -1.6501286974184608, -0.23819824279801036, 0.571489522302175, -1.1457424592914294, 2.7514593481180385, 1.1872565595459044, 1.7473684928391795, 1.1336233348360496, 0.32717182242854037, 0.023853373775768027, -0.9967900308803846, -0.6404447807084922, -0.6193736862546604, -1.0793559824417465, -2.706145042169008, 0.5423046034230329, 0.13934469451773093},
    {1.0441611978771783, 0.8598096057389635, -0.6278688242503553, 0.188260575856378, -0.4486725660675263, 0.17315721497731837, -2.8876483869325145, 1.2302082714859375, -1.2581229717712539, -0.5078761523652455, -2.5454735191585955, -0.545647746913075, -1.1285429666872004, 0.694746369176831, -0.18119209856676957, 1.494238396706817, -0.092090291825252, -1.8386834636563907, 2.4512961705577805, 1.9809941611101343, -0.2934490203432714, -0.4577726472352631, 0.3616174190751761, -0.34523409880984846, 0.6194628001990777, -0.6091310852219972, -2.344932744638625, 0.43451028403338443, -0.3566385141313228, -0.40955275423977083, 0.6274923109613822, 0.14336583822846788, -0.05412101086950452, 0.4196004345170841, -0.5809491092359428, 0.1358538689475971, 1.1150727230957698, -0.1565248811637562, 0.7887293904008444, -0.45402027133528, 0.882104595695257, 0.5638311250904621, -0.40244777785350805, 0.15868857133141334, 0.03937589725345586, -0.1929460377261036, 0.6220572044199174, 2.0090529939928605, 0.5859708331959921, -0.6157921514759761, -2.5783211114653057, -1.9538289228115475, -1.1423745848104596, -0.5287709477548109, -0.5621969960612307, -0.8080418621783365, 1.0344012570776868, 0.530132106819117, -0.6539641134649605, 0.7117842841775026, -0.3223597704556872, 1.2226502134771497, -2.3794202963705646, 0.02004068418543182},
    {-0.43803654419088967, -0.20920339080202413, 0.23388143807165374, 2.093951678046834, 0.4205441861817103, -2.1706092618269532, 1.1157486987997078, 2.1126693425194403, -0.4336588932059561, -1.4358648393518112, -1.6796506353914211, 0.26352649564230135, 1.3512854893286375, 0.36980839149646333, 0.6642474906592756, -0.3679285407405758, -0.8197922759698357, 0.4062650333394908, 0.4561385366605652, -0.8991723935612074, -0.03347786164620886, -0.33356261699999684, -2.3365288048777098, -0.1239441461537653, 1.684779259271418, 0.04443414563057629, 1.0101008506325404, -0.34761412179796364, 0.03944357220291127, 0.01576870682303034, -0.9214830298448728, -2.1999205742416685, -1.0459848590905305, 1.4858213715349629, 1.4380687568554602, 0.9179061413244776, -0.12387154900299364, -1.297973506152856, 0.10806971019771984, -1.9711692452765217, 1.425107643192418, -2.4820469767455795, -0.32733448396743225, -1.7252335990391494, 1.2828333564779555, 1.2376512175057337, 0.032317152816958745, -0.3012817025610246, 1.5688738650477743, -1.4882447761665845, 0.99443510964199, 1.496663510384877, 0.25873882327071407, 0.5647116352470933, -0.24649848027634644, 0.6492280148497144, 0.37929755792693537, -0.7935958113824092, 0.4157178728144833, -0.0724323060877734, -0.31281966999899113, 0.6190382504021306, 0.33673225308692295, 0.9197275609516125},
    {-2.1541683905455855, -1.5469952345580116, 1.4098511317612115, 1.7802069339763045, 0.3047717047685121, 0.8557164432185393, 1.0784097645091706, 0.12047712694615406, 1.6092155490107147, 0.5236690852268479, -1.3035018251629442, 0.01984211680849427, -2.6556655226152612, 0.34308897665661553, -0.2260615213746841, -0.24509225624105793, -1.3502824403524096, -0.1223183860393741, -0.5542097365019403, -1.4888609953313312, -1.2358139183071895, -0.790545820894696, -0.9997371224877194, -1.1547485065882421, 0.32703889240083045, 0.4760493942888294, 0.12113291063532275, -0.8749290448264905, 0.243629862004416, -1.865671348660702, -1.1083715751377838, -1.4989082907548277, -0.04870958927557787, -0.26239747413070347, 0.8747446406504855, -0.8389595067669591, 0.48943819136070355, 0.339291607203989, 0.6702281375503036, 0.21054053097628794, -0.3401681355280015, 0.03597406057980763, 1.3730465118685538, -1.850687457083721, -0.48464362057935295, -0.6141277018392028, -2.681133755541701, 0.35752233584860105, -0.5595484490982174, 2.241069446647067, -0.45152716976315405, 0.41206266757944904, -0.24939891912316894, 0.4652380954015721, -0.15616416714119458, 1.9216979136888988, -2.696428117801993, 1.867109071118872, 1.127613674015054, -0.024780590194916602, 0.026848936330043056, 1.272906682224136, -1.257408409271137, -1.3926784241613264},
    {0.9195837960016978, -0.5549527524883685, 2.685051570110435, 0.813899965667293, -0.27593624719969445, -1.1333939398368857, -0.7708119575032853, -0.05187255521781456, -0.5859886109552642, 0.30792072443252666, -0.11358094318512128, 1.3956106942541093, -0.31060228581391186, -0.7073767999666617, -2.2795033303878545, -1.2192644565208435, 0.36860162065328134, -0.28231474937516376, -0.20460574018197275, 0.4216621483034461, -0.05747756132972726, -0.0388952003529616, -1.1730383203141352, 0.048147769301999196, -1.6332471216174391, 0.40588260645721336, 1.056032530651178, 1.1947899695915059, 0.20025953817420067, -0.869553551259275, -0.36637591292573035, -0.5497653180819899, -1.0688394180289351, -0.10577655437972823, -0.3546303391591179, 0.6817203101389188, 1.421368855523856, 2.111462540418644, -0.15886524249772652, 0.5584123158849007, -0.0870416654016756, 1.4409410809958254, 2.526875889398813, -0.7229724314409441, -0.13116809141305302, -0.49829424464469496, 0.602095330113757, 0.8217323770147977, 1.0630870159399572, -0.8778570846121788, -0.05324311311844466, 1.1700102900473284, 0.8113470828823118, -0.7718415312652914, -0.47361446962306214, 0.22192671125649638, -1.0629793791951108, -0.7759732759529282, 0.36403760706090965, 0.7074809897746125, -2.607792905975392, -1.6078483995145074, 1.1986594875816996, -1.8708476355998314},
    {-1.9810784866526978, -2.2530032511588476, 0.6497794034577262, 1.2960297374542207, -1.6679280478537395, 2.6474921064004646, 0.911831486472041, -0.06360838298997057, 0.9490468254652258, -1.3980279177063055, 0.19949913986037585, 0.4612907196870343, -0.05669488895719051, 0.25070468596249246, -1.179586532037248, 1.0462492764585867, 0.5987618732066439, -0.056817511115546636, 0.4016228242760205, 0.6339394317392512, -0.14480455457351607, 0.7607239713162205, 0.3921234797522515, -1.3602237914934074, 0.47199442792795054, -0.7383568250630343, 0.6047937503946714, -0.5301005298901289, 1.2672661986787144, 0.7855147001493902, 2.268862542221268, -0.16160305648633308, 1.8117819234759502, -2.8486586041979756, -1.4728988721508804, 2.0298000601423665, 0.42756456290363487, -1.8106833029232345, -0.7891976320557967, 0.4111894240465871, -1.086227477074431, -1.158651608016257, 0.4634064202645435, 0.10559445399353667, 1.7195259031332748, 0.07748475387371098, 1.1371912663255292, 0.8450263342848374, 1.649069502907866, 0.26265098173607143, 1.3520948447932368, -0.06662977338389005, -0.4110131489883901, 2.3221782188095257, 1.3255109127226161, -0.19320051996227616, 0.5930490632022506, 0.45694433973603427, 0.04887222684093763, 0.834857245680581, -0.6014373639258419, 1.6475029489435664, 1.2920923365890533, 1.5848872567805385},
    {-0.3160956633348465, 0.6171126014046281, 2.40384679131639, 0.596313090985508, 0.07321353562039823, -0.4455283856099716, -1.0124978272922496, -0.9564523576804104, -1.1696024333709332, 0.430197794557181, 0.0025879233978120565, -0.7398767994627368, -0.21283976370027674, 0.6046621482185882, -1.766459262851194, -0.0574957428105359, 2.472304199181995, 2.2587475996439483, -1.0607746420383188, -1.1603278655349558, 1.6102392038386204, 0.6557435210007544, -1.0343149662347442, -0.25268425105021797, 1.8658107884926782, -0.8060783816651073, 0.9557281588176577, -3.0499786876534114, 1.282477592105704, 0.009086494727135663, 0.009328169935769555, 0.1483679222782823, -0.13462982261554576, -0.17694797155555705, -1.308826230469687, 0.2267097127567114, -0.4839867704967242, 0.6070329120185259, 1.1303372271128618, -0.20151808439892302, -0.5056092482611911, -0.3775279161757679, 0.9029847652287004, 1.6368466772275208, -1.3007245782190013, -0.388221658811793, 0.23510529288531398, 0.5966197318462666, 0.05611398088296988, 1.0115203540243793, -0.11246246154846046, 1.8377179394286518, 1.019896728421227, -0.4913683291502924, 2.044930437358507, -1.5427420685978097, -0.11736271315074145, 0.42234094228143115, -1.1415313366973139, -0.5551116385200994, 0.3073082700926741, 3.0841431454058155, 0.749332668321459, 0.3179300574494204},
    {0.3031499566196276, -0.19866510647331262, 0.1642334923426616, 1.5566530115831194, 0.2106087229580252, 0.6366519157998647, -0.9398685177783528, -0.3285177411198037, -1.0336050885806056, 1.2145309667345592, -0.5967135337647448, 2.3444632495904694, 2.547715889114028, -1.216736277111211, -0.4430972315440098, 1.159373376452794, -0.5876007222514525, 0.2989324134609308, 2.1879824265876957, 0.1772681725812774, 0.7253434471590183, -0.38590098602287404, 0.26476400306158004, -0.06306851688948559, -2.3758698714833613, 0.17332934860781402, -1.2453451720081363, 0.6829563131980448, -0.12534700718736252, -0.6169930513958084, -0.8274710238986631, 1.1900120952251194, 0.31775519794459167, -0.6726425362683943, -1.1913293328363486, 1.4172562585961066, 0.34338981483801384, -0.1294260757185878, -2.0966495481743173, 0.44966357141143043, 0.09737430717497209, -1.504526591636095, 0.9085583097600322, 0.5989712395555753, -0.11939459117839019, -1.4482708368283546, 0.2584141002955416, 0.8718218659133693, 0.11189809100555768, 0.3580757938522359, 3.0385005083633674, 0.47153608327139057, 0.19867319638417752, -2.5985969036107845, 0.18336004854911014, -0.32665952406115223, 0.49050014910145534, -0.5165987770183968, -0.16995953953492718, 1.0386891687645217, -1.1085341350126243, 3.1479723832484936, -1.7383507530093447, 1.42400946391029},
    {-1.7328425660398605, 0.21714563603817377, 2.038389085672182, -0.5860908660196565, 1.8170800825510511, 0.8557176144671328, 1.760425558215346, -0.5145898698625255, -1.8705168583800924, 1.12023242074063, -0.7157087119877245, 0.8399365967413961, 0.005816373834984579, -2.4598670014213946, 0.9500450306527802, -0.8897210808893055, -0.8455570427938801, -1.0570337050586616, -0.5464184185767105, 0.4027296690882379, -0.31277308105608365, 0.849874088304137, -1.571616118231389, -0.5495905341071264, -0.13772014446613318, -1.1282953438312624, -0.7214894679682929, 0.9346047069821024, -1.3982439827880897, -0.37792829084456486, -0.35401522977833344, 0.47435546127509187, 1.5595881156154283, 0.3084056395337064, -0.22447339739650646, -0.9798335727435797, -0.5634337263610634, -0.38071678108925966, -0.7562917358199656, -0.15774716982422868, 0.9014804806852783, -1.346501027075297, -1.1445472397158365, 2.222658291416321, 1.2203364154009224, 0.15467411524845293, 0.33192479998141644, -1.203203092944434, 2.03636304135956, -0.33677247885587236, -0.9784129168558536, 1.337439380082001, -1.0864865528698273, -0.8776622397500893, -0.4751616699535908, -1.7827194986862092, 0.34815689491348684, -0.5916192568844486, 1.1142622597486793, 2.9459056939430917, 0.29161702051988503, 0.4235049001639004, -1.5746577868769953, -1.167647521960371},
    {-1.1013889344629324, -0.8957798197964925, 0.4886727012185645, -1.0956567828796109, -0.8152539762996114, 0.5821736673231729, -1.4363949841765564, -0.9541996169136904, -0.5662658243167749, 0.7431097767746743, 1.677577142100691, -1.1401609320528492, -1.6464326940504805, -0.7938019307882047, 0.6819195929477387, 1.5456331495083773, 0.9550937400535784, -1.0074995185566062, -0.6106099739870152, 0.3541547540369079, -0.9587540875933398, 0.9655519169724799, 0.3506805630118126, -1.5561513548638644, -0.22666401289605836, -1.1535433246120625, -0.2252161196817324, -0.8130318999483398, -0.33991965562528587, -2.209308326440983, 0.09850317742365126, 0.3207969360264911, 0.7288998277066193, -0.9162369181433743, 0.4510651473050515, 0.20972434304970092, -1.630496520793478, -0.1320784806566979, -1.8498962340526939, 1.642613615498547, -2.9342029609490328, -0.5581658621298574, 0.767549293657957, -0.4663342289101636, 0.4941842774267078, -0.5523930745468676, 0.8780888998482155, 0.7298505625275973, 0.2075272492551808, 1.5428761762943088, -2.634999331255476, 0.451870977388509, 1.0510455769758398, 0.9138661057085244, 1.4083163200602966, -0.6077727749500371, 1.542619456644707, -0.3576403814736156, -2.327918775155759, 0.09416185700937141, 0.023609192949166698, -0.2893633249726375, -0.6663991852599244, -0.5913327752130004},
    {0.825918778430288, 0.3460568311745874, -1.28771951820662, -0.8246241218433292, -0.1793126648709202, 0.5108917626407865, -0.39304880314839097, 0.6151666825486402, -1.9801226720387806, -1.0853901897707807, -0.10697426457737584, -1.868742146909038, -0.748026250188118, 0.1340432206699697, -0.5103508230602097, 0.9363654785196147, -0.14074599241952368, -2.081888327653347, -1.3962622340265014, 1.4317039230846775, -0.9359680859030559, -1.6939678391538266, -0.7512139324279639, -0.36990582467553057, 0.3222529055171366, -0.5881627083150126, -0.4299648627393667, 1.7490656509258753, 1.637729827655401, -0.24149030926475976, -1.6189151689252534, -0.8326643579643034, -0.5542783750633635, -2.8058789709272327, 0.8629606255414664, -0.48769764396399945, -2.272766414655376, 0.07966136476096848, 0.43881878642321137, -1.3319385416904388, 0.8619480874644901, 1.5867645408047146, -1.0306123200631392, -0.06645609369579611, 1.1130608360124448, 0.8016477901341099, -0.36802434334625717, -1.3280004544802329, 0.13473089215858386, 1.1401920137369264, -0.2730586679668855, -2.3095446210292994, -0.0031049979644809465, 0.5139890587894691, -0.3468907139415753, -2.629244556584663, -2.1585486257887734, 0.15461695044893428, 2.941950261651982, -0.8931371752470385, -0.4202532070284369, 1.869985605990204, -0.7616510501364409, 1.0201126394059763},
    {-0.029234582258637776, 1.14191207589103, 1.3965705269684123, 1.3725138310549332, 0.275075986119399, -1.1389121444492172, -0.37515521146864733, -0.3599514557190389, 1.3048601256666936, -0.5415049098177234, -2.8240703454262577, 0.20710883952417086, 1.9099363863241856, 1.7186367939664766, -1.309865868706315, -0.6535876958482163, 0.025014530441497044, -0.47422301256150473, 2.5326336915881673, 0.2950575189353073, 1.2524779041288756, -1.769084749417232, -1.265807021135314, 0.5230806079391497, -0.08512784941156164, -0.698596179164121, -1.5324966288880513, 0.39744209019574167, -0.3931500030802004, 0.08984753814080076, 0.2727493982713429, -0.04774555091976822, -1.4659665876004926, 0.3808182720266254, 0.6441892392103776, -0.4499529514417542, -0.27635593616785203, -0.05051720996861051, -1.6258338834810602, 0.5667150053125519, -0.4536651297893155, -0.1569246266513507, 0.0013455339050405582, -1.8701184208588486, -0.4777379772209854, -1.2386857320420674, -1.086027703389578, 1.2828468403907696, -0.04757620679041907, 1.0006970167426592, 0.8556305555150872, 0.4745526330295, -2.4611907886810194, -0.6688473174040461, -0.8143636034694702, -0.4428659288695631, 0.7863668084229681, -0.5908735406620798, 0.1930761828888969, -1.6583877059523908, -0.35457360665128157, -1.3124628724873193, -0.3124009802860896, 1.5062174963666508},
    {-1.4771337558500597, -0.01286701007238317, 1.9054947465397971, -1.2856902861643105, -0.4514896324802652, -0.4667356719107987, 1.7363921956695667, -0.18191867444103882, -1.4997706690076273, 1.0866687157927355, 1.3090557189959577, 0.3280745940090403, 0.5803257312143824, -0.012222150488139672, -1.3098119707141342, 0.8142709065070657, -1.9766133629066374, -1.388632489721734, 0.06758342088364598, -0.47114902973499756, -0.004660444451147386, 0.5436705001720056, 1.887873129556932, 1.188876463887794, -1.413812324022354, -0.5017520639006863, 0.3435525392352697, 0.9925299280052243, 3.2875224245357795, 1.1037134801199528, 0.7604571570384819, 0.8493369796372915, -0.25190312975941753, 0.3986584594680484, -1.4591575398685859, -0.38427403561081863, 0.2389494114964708, -0.14641962714930734, -0.31336162626346875, -0.2092692484961938, 0.8181040721422184, 0.714900216553222, 1.2126443440065842, -2.951584777768346, 1.4690130203773013, 0.49887440545084105, 0.15973167736460442, -0.5528607764308436, -0.5361168713390083, -0.93185637294205, 1.0288019597713958, -0.4542608216967517, 0.30645124900149806, -1.065794579411476, 0.9564762178403288, -0.3254777596921229, -1.3757015742390146, 0.49410661591152993, 0.03179495522092541, 0.8747371807761382, 0.6614343529428708, 0.9890540058468738, -2.944178815895564, -0.7524270422726875},
    {-1.8603634834766958, 2.5155010869715535, 1.827175342419197, 0.95495496875608, 0.08588293755310131, -0.979718102233924, 2.4698462066581004, 0.11184083667048872, 1.2236119197206217, 0.2864370597417468, -0.8824002726684471, -0.39093192476335803, 2.1063865050917427, -0.9992613953556901, 0.9972300477517695, -0.3647085177679085, -0.3890669348716806, -0.2428602301889949, -0.7605443350686518, -0.5178386752347456, 0.17370391867034787, 0.9854921171416521, -1.4648278296393151, -0.387456071729252, 0.9614381463312497, -0.06190452403922018, -0.6739340805295454, 1.2772892478853228, 1.1960133227168783, -1.5207112719752702, -0.7709079309921775, 1.0739095312225437, -0.1486074809887147, 1.8646988972960499, -1.2413444232966924, 2.125284040348418, -2.095405357362548, 0.4939477049384151, -1.1480599510222167, -2.0037075623082248, -0.7442548075257781, 1.0291901035534308, 0.6417094064561811, 1.1800976144456836, -0.015379639491846796, -0.8714639702802291, -0.8222915404014755, 0.4357733973847384, -1.7280412455701721, 0.09910008196881294, 1.2651764105817325, -1.7192913818742288, -1.844997058126243, 1.2845090833520423, 1.4873704990574026, 0.6993035376434451, -0.5766772321637194, 1.7335100618134176, 1.8041555632392174, 1.6118170418673492, 1.7998631016652256, -1.9454177729271631, -0.3795820101367416, 1.0935890925013798},
    {1.803724687057842, -1.0145976843645008, 1.811745573596055, 1.1213126487681429, -0.6888888405389026, -0.2975552987325445, 0.5910660188115086, -2.143516919661729, 0.6766520780644584, -0.7664065649737968, -0.5712273734994197, -0.2628226725102036, 0.4818351235127801, 0.8992108003102491, -0.5220946686426794, -0.10873438208505339, 0.6960841857135557, 0.739410247864446, -0.23720559658274953, 1.1164096129347933, -0.5763646989496826, -1.109980453451196, -1.9336769490923542, -0.569641067073211, -1.6084419329121573, -0.40723160713617135, -1.0039614408975956, -0.7359013551156678, -1.1327695894147878, 2.241393492731435, -0.25063069177443204, 0.7643962561227376, -0.3142726297424554, 0.5807099945911853, -1.2645952094702064, 0.15055590286517673, 1.441047599490285, 0.4150783224430661, 0.4416394687008959, 0.1367050287014414, -0.383046252604993, -0.6539973787501199, -0.1273093927819083, -0.5345529285959604, -2.0746752156430714, 2.2111283197833993, -0.19418152676558406, 1.5405097189641517, -0.1848735090742584, 1.9809880874458483, -1.1323620197033863, -1.9273629717232381, 1.2309480772669668, 1.2820211523287275, -0.3550451553576028, 0.3944383110620595, 0.05284094829244719, -0.47712108535449105, 0.14025730652398796, -0.3448533586482405, -1.2173445617671257, 0.43270891712325754, 0.041870847661765236, -0.39460453210757185},
    {-0.47593694429839156, -1.811845339410138, 0.856504381460205, -0.43517473136937046, -1.6895909475781117, 0.6266283279841129, -1.7370609646178072, -0.458245105336575, -0.6846934790922206, -0.7713520493854306, -0.5664634241918743, -0.5483017686100196, 0.21280244886790153, 0.3669649962269083, -0.8884314056469422, -0.6752908476640821, 1.4399444567924824, -1.2681388876540671, -0.401640401333629, 0.43876537912498836, 0.07056192315707943, 0.03204319427537466, -1.2727052240908747, 1.8753703547324154, -0.08348879209491826, 0.05666806938757883, 0.06461370039242227, 0.33576441792297956, 2.612996494084221, 2.101398788414254, 0.8605437795640262, -0.6217832258077143, 1.5401516167386977, 0.16862850014820369, -1.2485748097265457, 0.3967575446890125, -1.4472050696392558, 0.24265620431899831, 1.3249300764673446, -0.2194415551297572, 1.7753198482489192, 0.9366301770903633, 0.1024057708850136, -1.3323428222874183, 1.103628284212165, -0.4645883006913431, 1.1440212312684426, 2.112880872602771, -0.23716037081426444, 0.20414608814278645, -0.17904100373970552, 0.2489237809184676, 1.775611788897269, 0.04346414968013983, 0.519383629745656, 1.3793574317281003, 0.435580258364103, 0.3573227702902292, -1.644969386487056, -0.2431667012907297, -0.4751136125675028, -0.33035048623287633, 1.2179535199730116, 0.22315547323392942},
    {0.7297406460888887, -0.19468868074178292, 0.48139096401498555, 0.8992073032962821, 1.0622929584839236, 0.6198606690807807, -0.0824400592990165, -0.43099174070850715, 0.184788376223054, 1.5246740360293873, 0.4105847054679012, 1.0383807280996724, -2.098085883612019, 0.40941853315807797, 0.4876346644410729, 0.4048523888651797, 1.0350464822104664, 0.6715733781761113, 0.7561988410985229, -0.6208821311275516, -0.589894918223433, 1.875042596215468, -0.1931187900173085, 1.15414867517564, 1.7104296061607192, 0.5834995490291596, -0.3603982407367801, 0.4481352470799506, 1.2449400390668612, -3.731229254903999, 0.8771238872982866, 1.5498580132230242, -1.2340659368410871, 0.12926878848520193, 0.7464583621232801, 0.24298896370676043, 0.4356314983151547, 1.1387877445438985, -0.0728018775700007, -0.6352022425264701, -0.7737998403233222, -0.0871542679197488, 1.0523008787465353, -1.7095255191081684, -0.5984645385706155, -0.2205174523014002, 1.6403823916585059, 1.512596011834559, 1.854204012763583, -0.4993707767066109, 1.0353655568437206, 0.6694977863215785, -1.2638286774705514, 0.3680942833854971, -0.48992843845316364, -0.017447588315957274, -1.5141963174623112, 0.6282085444681736, 0.4810862828381253, -0.3812563844187138, -2.510914599989884, 0.943443557925976, 0.39652097697691574, 0.10819808802945687},
    {0.7147446062173982, -1.152663209458647, 0.30946209919848977, 0.7255255135607365, 1.1098009542990153, 0.18240716759560296, -0.27360366991508744, 2.204694764354302, 0.9986151636600117, -0.5978446770612059, 0.39217619840912793, -0.88726673455244, 0.33230134180976695, 2.068330887789584, 0.8513766532297383, -0.012669713492799205, 1.692547297511447, 2.3986869952774974, 0.314258367046944, 2.677892880085423, -0.14749781491890832, 0.27268620039092234, 0.05657784195242516, -0.6904216144757359, -0.1556931217549369, -0.12532539488469213, 0.5002162040593625, 0.1365659235371574, 2.25937364911422, 0.8043552520992907, -1.3594856309578496, 1.3290706555657572, 1.3320513514149108, 0.1567142012478421, 0.3525688094160043, 0.21407296120337677, -1.1295928130243909, 0.12871090892186135, 2.0776246368866826, -1.6809685884566297, 1.2237781895204918, 0.03320536205533569, -0.7853783372306087, -1.3262389183022223, -1.2449675481180156, -1.0918350587374397, 1.0733029353778738, -0.46873114768947954, -0.7425397847483441, -0.7619044998470801, -0.6351153250285387, 1.090694536482143, -0.9265928753945931, 2.2369674453629504, -2.7680330771633233, -0.11393582741252417, -0.6682260043027577, 0.08947892828154158, -0.47832301573101094, -1.7950052837221602, -0.6450092011877934, 0.256338761068557, -1.9529151119660262, -1.9879666815674883},
    {1.0475263888604596, 0.17259419556919214, -0.9035130063873117, 1.3875388183864275, 0.8889497290541156, -3.2359875855656712, -0.23502345046135456, 0.9778239530851962, 2.8719971468593415, 0.04016203199365342, -0.73563475865725, 0.811332884830625, -0.5629011716133456, -0.050280578555030334, -0.18129157242646043, -0.7992038389046634, -0.5678004367080302, -0.06222615482392748, 0.07371464602553712, 1.79579284515278, 0.9206328572715241, -1.5604041481678002, -0.1337557023736999, 0.15688461869782186, 1.0589918022060683, -1.0850818152922275, 0.28061929446749495, -0.10193822876872403, 1.0622804959711967, 1.1536362843971013, -1.776110561448509, -1.187970300417931, 0.16953302706238257, -0.8251592521863813, 0.41564661418218046, -0.32420147078995737, -1.582629905267066, 0.22348522656071768, 0.3863697194969498, -2.1252724307408166, -0.8755988753871424, 0.027390582505665135, -1.3664197160742018, -1.1701405303288601, -0.6170320070843494, -1.1011435792922364, 0.2283160326463199, 0.1290508318143895, 0.24633331047206972, -0.5583008762330572, 1.6616012515386087, -0.5653439427081803, 0.5688560072974251, -1.6131448831903061, 0.005074795058168605, 2.105209306619743, -1.446458305909016, 0.3767373869960581, -1.1264516671402929, 0.417808072283215, 0.6328765818589668, -0.536746761421188, -0.7420311883309486, 0.37463251464120295},
    {1.5604497474805201, 0.5476104088035614, 2.1011360207450247, 0.2970200488451253, 0.5802093880083465, 1.3447378390049285, -0.28656586071926193, -0.7935661547806023, 0.16147717809065532, 0.7479666151223854, -0.2968902776593162, -1.4138845899358847, -0.10273248504149948, -2.200322137585249, 0.7844334883191411, -0.7870914933329336, 0.34427558710395667, -0.7703634118378929, 0.5238112637518376, -0.9546045074679658, -0.5042964717635886, -0.4380790745932542, -1.1491786805326278, 0.18683457053804156, 1.6880726105474073, 0.06396570078227512, -1.0470961265459673, 1.553167222684324, -0.023970854283006608, -0.03589929563401975, -0.7596944529812258, 0.24835207077306437, -1.1024089269873254, -0.19204337628000112, 0.7024713296293067, 1.0203094463062856, -1.6588784574974158, -1.3921087357412967, 0.42366887374345386, -0.02333935336564447, 0.6146604183017522, -0.4095554155104441, -1.3674765073514992, -0.7826817682536534, 0.8194600438546066, 2.0603113656536025, -0.3953553757597027, 0.7378112631570073, 1.038513303543471, 0.25878574399491455, 0.033006629808413825, 0.7016473729850409, 0.30183126658454873, -0.43748876013255833, 1.4818167758032403, -0.595014670779897, -0.16912703731420706, -3.1743650983567155, 0.8296181933235847, -1.3869177533797161, 2.705086548035105, -1.6359141987528991, -0.12970663699489704, -1.723202411146434},
    {-0.3867351664423112, 0.44711685348125846, 0.598284878900204, -1.8327286253218111, 0.3000680149192396, 0.41443105449499124, 2.5525111024165312, -0.25434335456424434, 1.8800897304315158, -1.9163519751779095, 1.427981191829123, 0.37821556585994465, -0.47609424564129776, -0.07325921654727643, 0.07680881312329596, 2.4650292475480184, 0.41966648881782614, 2.3632076353941875, 1.7751332916602172, -2.122260612679409, 1.3315373529309427, 0.15616806371305897, -0.7964688121577902, -0.2657291989797905, -1.1081904667911175, -0.18922282324945452, -0.06428389207510349, 1.5429977282141976, -0.3669167946595914, 1.6055651711671466, 0.21221905235289035, -1.5146345590645263, -0.7783866400423601, 0.4272152506320525, 0.5233043285284273, 0.718361241263822, -0.8206318889245486, -2.014704989343336, 1.6725348807174785, 0.07348713419483342, -0.3843198083168514, -1.9542470780313634, 2.0544013868144058, 1.4640808123225046, 0.6513485465854608, 0.44036074504442924, 0.9704267683216805, 1.1733372243414422, 0.26430099512078103, 2.0401972055495965, 0.7710377801758849, 2.2360731116036883, 0.8619055296455558, -0.4442253476857986, 0.5917797371672598, 0.04304492344059206, -0.0020596693331803194, 1.626409038162652, -0.17436633493455853, -0.04187957335871044, -1.061089350747375, 0.1920602910129692, -0.10100503786277054, -1.6506057495955229},
    {-1.508886451727514, -0.07319105212372938, 0.9583301587003702, -0.902358557382573, -0.22527213538761628, -2.094623267426045, -0.20301636478286697, 0.2070540855181939, 1.2044366493966405, -0.18581389667282466, -0.7824852005546851, 0.4371807667716151, 0.2883379694707494, -0.6400279450834965, 0.707326899366794, -1.8617637308160897, -0.14474579344997615, -0.6868951852464685, -2.5197450070045293, -0.7102002746170444, -0.8721270296173667, 0.23580175114691415, -0.5635347500315513, 1.201949622290231, -1.7275790873405439, 0.20298768739166487, 0.8211205311402541, 1.8281358356568538, -0.5601447752763488, 1.5828021219627157, 0.27656930885284287, 0.5466471209516073, -0.07081960166840642, -0.4592621404454294, 0.06588394934371375, 1.0769946184995833, -0.20980229543692425, 1.047452741291091, -0.18206986163444897, -1.302253049729827, 0.472355426674402, 0.32253886736354603, -1.2255827195727094, 1.469509439006521, 1.085411386331101, -0.6272371036474401, 0.11976267258399702, 0.6307827551579185, -0.302227592417806, 0.3622962885560734, 0.5639408208810666, 1.1014276869846988, -1.276402928072084, 0.5251846418987905, 0.597461348171809, 1.1540241403374678, -0.9028491570530955, -1.7228831374231148, -1.6069398670668507, 0.28534543925022415, 1.2346384299798796, 0.28607274696524754, -0.8574779878343706, 0.09758333910484619},
    {0.21445672799302723, 2.4533891255598252, -0.9525934974630278, -0.28388156257694663, -1.1192662369556032, -0.2594212666961434, 0.43011758308831716, -0.5008589549335635, -0.4674601395240938, -2.85074224307892, -0.7906048631169168, -0.7212174629095706, 1.4683598027610858, -1.6476773304581345, -0.5377450390518523, -0.35873313599099704, -0.6856466271889924, -0.9616172212848548, -0.43643841503036124, -0.9586113396345555, 0.6849010963284643, -0.4427899912551325, 1.29080778049392, 0.1517682683524984, 0.7334918299170757, -0.9084829537427163, 2.144198924360946, -1.1074537866080647, 1.0039579606175464, -2.064425705834579, 1.9651167087492518, -0.3924452972934649, 0.6960186372362991, -1.0248766554810793, -1.8878607545841772, 1.4532435143427473, 0.4161772113184302, 2.3246783170634, -1.29772636802799, -0.4929713418604464, -1.1904152555004204, -0.31612932360150947, -0.04750421216797634, -0.11654716257692536, 2.0811210539077343, -1.4832793112530822, -0.3629874264210227, 0.6476026393293012, -0.22567962718175916, 0.7221334032683554, -0.6515459709513143, 2.1111077867350394, 3.4108324392295732, -0.7283130540776332, -0.663731516775271, -2.408246154373254, 0.2054458856396079, -0.38562610006843445, -0.5763125420252619, -3.43096821713567, 2.0005054239038977, 0.09387718082000743, 0.974328766174962, -1.4154452351153508},
    {1.0088385590558728, -0.7473857228301979, -1.0331773621673517, -0.22290647945586636, -0.08193127545030467, -1.100205509170632, -0.37034780465836986, -0.4040219929015328, -1.8540645063700782, 0.4027878731417567, 1.6506462408220794, 1.361965626510239, 1.4500086688177565, -0.8076941009632356, 1.66974862618562, -1.0863777029236388, -1.217847750611771, 0.3695470375230282, 1.3802713761465406, -1.7741952545691109, 1.9061108972425236, 1.8708068321108295, 0.13858798491635907, -0.6201374486816135, 1.16606887401404, -0.20327762711796377, 1.3802344539249587, -1.380869284121533, 1.534151444405994, 1.0755848230079796, 1.0348597053957969, 0.025586927713347675, 0.10868469608184388, 0.335067269641778, -0.1488223483814593, -0.00916213503747637, -2.072490096453296, -0.5172931786979734, 1.6700284143990873, 0.6704294196329673, 1.007447348168849, 1.0209892457363396, 0.2533411546258369, 1.7743972177339942, 0.8305860707449098, -1.4292677132901934, -1.168047209626948, -1.7391631197463446, -0.15584974260773501, -0.866262573482469, -0.7597618167425727, 1.0285288511718005, 0.09493558622527658, 0.15824008199093856, 0.814250807799229, -1.7789046395106447, 0.4630201940672198, 0.23674982554040755, 0.11189903371791449, 1.2466382933701887, 0.6873180509372132, 0.4031257715513985, 1.694470798055934, -0.22065151862918098},
    {-2.0303923618577384, -0.24860313378702503, -2.5499966406997614, 1.5120762821620881, 0.6624890264018961, 1.700896917250316, -0.10076535246972829, -0.6252095619871169, 0.9478592962305615, -0.6219262793080566, 0.04318246640158089, -1.0752711975316356, 1.4327086159494193, 0.32561003713648445, 1.0088759113411163, -0.030755201804349905, -0.9181915101385967, 0.18860753981633638, -2.2998924062742487, 0.11238766801072651, 0.6419285575660171, 0.8352861719049596, 1.3459671158596147, 0.6636885869272171, 0.08693103320291883, 0.9701717481759545, 0.3258212755353819, -1.4156283087364796, -1.2196374001111774, -0.47665413024609216, 0.7678466962514526, -0.10395902201332644, -0.9551582855559554, 1.6965070122210162, 0.7058377160512586, 0.2187421384325625, -1.0379550900556263, 0.8595069227223427, 0.08041932531938872, 1.8706690726314217, -0.9702063702529842, 1.532776522719432, 0.18467308717142653, 0.8364383814097335, 1.3431790466668354, 1.4089705510034098, -0.6246100429727568, 1.884774098339712, -0.00872168764073692, -2.204370641579286, -0.26578031447048234, -0.002727510496603175, -1.1921836483615484, -0.833814163874285, 1.0308035115105636, 0.6413696211103961, -0.17816067700566537, -0.04272917818334639, -0.7906391457152445, 1.0215764576931698, 0.7479832574105487, -0.3853033082244473, 1.6382361650260335, -0.13216627410989976},
    {-1.1655465319345886, -0.44641134694724255, -2.484540378908567, -0.004057647860095389, -2.465166069043823, 1.1818391679454472, 0.6247134456027057, 0.051421959592426715, -1.61116807187362, -0.17211480257719625, -0.3050677634241227, 0.6029273884970046, 1.47024733118515, -1.5330793375526697, 0.307100843544756, -0.3740538436995684, 1.811034751674723, 0.1299109457427831, 0.7117734951876924, -0.04015519196176285, -0.29538412119962726, 0.2732254753710655, 1.007932268082969, -1.1188992571275487, 2.4009860976973836, 0.502682494066052, 2.5706839033830415, 0.8340851015915924, 1.7250847809144991, -0.804866649872336, 2.292746848620471, -0.22335468524426005, 1.0183232884212954, -2.3683353762743216, 2.0556435310881613, 1.5881681824181095, 0.2896156898779496, -0.30329969801607615, -1.5570991076577696, -0.40239618053878495, -0.8661207472187861, -0.8417264554460903, 1.1288957907505284, -0.8155538580966583, -1.1638573023382548, 1.6345231589747944, -0.7341188269804473, 0.4389852564101158, 2.4022816234936766, 1.2526393933898536, 1.3703332707613758, -0.8977240397350492, -0.15350242816021872, 1.3677436411332715, -1.2964299814018445, 0.3169202706391919, -1.1751768410679422, -0.8531584933710491, 0.23218664853505813, 0.09471929084610047, -1.8344367267277522, -0.878203937037989, 0.9956036881501992, -1.0160588282908172},
    {1.055244299070432, -0.16721171927357378, 0.6464895172669357, -2.2482716937872382, -0.28868380123630183, 1.277624012739837, 1.0487228324135998, -0.4345919327887533, -0.7882425361153642, -0.900149929609811, -0.2868994031908598, -0.18880499160007555, 0.9176318058438308, 0.9973077682587255, 3.014935978762193, -0.3859642319117404, 1.2862813242158202, -0.3676164145891103, 1.3086454523348285, 0.9835120808903539, -1.1949193507273017, 0.37282027198453516, -0.198024121171099, -1.478524137303917, -0.615122083683083, 0.9240989276940069, -3.118360695270396, 1.819944708919541, -1.9929089533811744, -0.21335879270208735, -1.9141122967023643, 2.739309412998199, 0.043300382485221466, -0.42286787429166334, 0.656066999808953, -0.6637649683063294, -0.620640875863055, -0.10335805539736286, -0.7547291886046458, 0.49223768602736384, -1.0188059250191128, -0.16384759235376323, 1.574392675919427, -1.4688404539899496, 1.2227939703064499, 0.4859471200362916, -1.2618098849950696, 0.4950258135383052, 1.8669869867771534, -1.7555373980368962, 1.4085187437683735, -0.31865111592966067, 1.6029032213498602, -1.6052024971539378, -0.7346740610292958, 0.33170210940955924, 1.009920534612472, -1.9193408507176006, 0.303012933090017, -0.961019100911955, 1.1475489672027417, 0.715651846669915, 0.20898253750116352, -1.9606502129824896},
    {-0.8389006762503532, -0.9612858728283858, -1.3987853226592615, -0.5715590545236646, -0.5593140705072756, 0.8256622967624003, -0.8467073830201868, -0.6506180927345593, 0.12747147592648844, 1.1573139918968394, -1.100806915288268, -0.11526369775253012, 0.5231901659689515, 1.0686455293167467, 1.9926781385918921, -0.8102241832417892, 1.294162263572281, 1.4053906308575963, -1.2217868393715459, -0.4486905972442965, -1.3312502823894317, -0.716064697549948, 1.4767060950309534, 0.39288026749266786, 1.5638589329908206, 0.5928637430170437, -0.9329148537040753, -1.1197462329590586, -1.562075511148527, -1.3857860842559468, -0.24311560472760074, -0.08650937102380127, 0.3168761272906513, 0.07006240378772512, -0.677130454184312, -0.46330558417983414, 0.06003925795831243, -1.0565829846595554, -0.2778837162149851, 0.6147352685580965, 0.15812442579031594, 1.4876871977929282, -0.6573432592423293, 0.07295573893383202, -0.11137591747018491, -1.7112750624259945, 0.4294254068031554, 0.7528866951029408, 0.5571878490861102, 0.37130853858947716, 0.21622195012505815, -0.8371707158572669, 0.47145003569416, 2.8906071635517807, 2.3248110423597543, 1.212958656159111, -1.1885240859123272, -1.1488956654168976, 1.0340514741673228, 0.5991498121448917, -0.6328893548692716, 3.1790174984200026, 0.7644435350296677, 1.0680667617339796},
    {-0.1804420656371309, -1.9163749224478734, 0.5778912487124986, 0.49536669719854015, 0.5908985287917452, -0.20451126569109027, -1.0921806857766438, -2.5313354417018, -0.2084462759843377, -1.1493803457755212, -0.2413799418501597, -0.21631611492345182, 2.2089941768980794, -1.1382520290867564, -0.12862068982983343, 0.5061038262991128, 0.4252141226036917, -0.2504982467665601, 1.4835028790249236, -0.2765424139706417, -1.1886189580354494, -0.15339397804433472, -0.9531515495444386, -0.9277522195737762, 2.2927054192718592, 0.15290828384414618, 0.5739402952807048, -0.8377647501744675, 0.705503703989098, 0.8973286031415839, 0.4325462657582612, 1.0100847430172726, 4.197843543371433, -0.0343066366747274, 1.2527424838422805, -0.8678738728856297, 1.0987737257564103, -0.2478956978473987, 1.3891240551101773, 0.8352365561447676, -0.09536563555368012, -0.08494541302240823, -1.0350460364966694, 1.3826342553011397, -1.046355109926564, -0.5775688254105487, -1.5316588355309295, 0.5076040726707183, -0.3619313415653847, -1.7650267443632501, -0.4161412316816004, 0.2319339063355267, -0.6680632034741948, -0.20311321434218987, -0.29040063472086486, 0.15799243412736189, 0.023377480768328792, 1.0276481816090626, 0.0736338560950264, 1.32168420832371, 0.9272829722031144, 0.8163288391442747, 0.05825833053676741, 0.23371426903255674},
    {0.7594464480130825, -0.49144908293608797, 0.7869336801234066, 0.2632800640346266, -1.6743624590225294, 0.24989775924488755, 0.766364486033387, -1.2026348301438274, -1.2871773611807016, 1.1247992525966553, -0.322457461766702, -1.3085197815826064, 0.24571696615891125, 0.4716740004647535, -0.4683919942534341, -1.048277605943726, -0.801425700360097, -0.55277634814011, 1.5567745954545362, -0.6048478529230887, -0.40683130327484185, -1.2008289766859561, -1.5549187038602215, -1.6499178585244163, 1.2686119925510344, 3.242039484251439, -1.7852591358211058, 0.8325714200150129, -0.10852522028535709, 2.460394549053465, 1.2750745022717487, -0.7642340611423952, 0.22580258303004766, -0.34606939619537624, 0.9456911982151883, -0.849917126221837, 0.04467280346487414, -1.5270618788766652, -0.23003527633601492, 1.3262335767957698, 0.5510359240384287, 0.5065241621149186, 0.5081842976462198, 0.6416837291991794, -1.0710271255191457, 1.2211901927145523, -2.9081240532802455, -1.67401273480268, 0.10366141849325612, -0.9221871051209299, 0.12164408618642275, -0.42951566991982193, -1.262274917026586, 1.1244699933593147, -0.36290359918417625, 0.7041359658753437, -2.5601894128190574, 0.9078311270232158, -1.613226887629221, -2.1297929727191987, -1.375884597243982, -0.05218586394078245, 0.3052513937711933, 0.5977205673824545},
    {1.1566192308336711, 0.22223639350852575, -1.0466613361431016, 0.7423300112425204, -1.1624269996235141, 1.2021059829138718, 0.6388776564297152, -1.692735331878745, -1.3059378183174426, 0.5693044714639108, -0.5218314599387075, -0.7029893211376744, -1.1565534865877418, 0.32387465191149084, 0.1099965595209115, -0.4076989886561151, 1.054155013724175, -1.325525010236877, 1.9564600641073209, -0.4224227200296439, 1.2719287042115117, 0.7031623140866627, -1.0198274052475746, 0.9771725349519191, -0.7831037286766048, 0.6404410262626579, -0.34809228488634536, -1.0063104907632658, -0.9388360569637497, 2.1271566869971434, 0.30405629801298345, -0.34256715178810365, -0.06193007444583637, 0.12765125459156518, -0.4543928257700484, -2.086624042724862, 0.0705219670617338, -0.8386125211335965, -0.013442921917835044, 1.575761159136058, 0.11288649390851961, -0.38558008878789113, -1.685008402341892, 0.42114917123468104, 1.4536506848224138, -1.8468387346663748, -1.018061176579966, -0.02235837206992053, 0.36824085753633556, -1.7281385444975532, -1.0814744563723502, 0.9368769084256853, -1.1967303952478403, -0.4393264506004879, -1.5618622249656147, 1.253398372985929, -2.096094045079573, 0.10683015995614724, 0.573578166298471, 0.6492803185388102, -0.5567178128931495, -0.5502968195700761, 0.2139374531882134, -0.7580232309058405},
    {0.32921806310702406, -0.3936200800772868, 2.0571213764989498, -1.396677909495135, -1.0158058281950348, -2.4727947474422645, -1.2148572007545935, 0.005269299226857155, 0.5501550196758688, -0.4488302802171809, -0.36681571301800214, -0.6749505294618473, -2.140064368066922, -0.3980346524301275, 0.1273244719955047, -0.6650472708392411, 0.24355423603725085, -0.8937988628258996, 1.0547282380598764, 0.2928012243124522, -0.2671519269214135, 0.23821869075878366, 1.7529120855580593, 0.7064300209210798, -0.5341736631000332, -0.47401048372337884, 0.6186360779535651, 0.6892998911796335, 2.0817553592455433, -1.6887072730434864, 1.3635426680903906, -0.9575072633438114, -2.73915865717631, -0.1531826584410154, 2.690624248425362, -0.4877493757481727, 1.5355553170118077, -0.2870646026710961, -1.3806001220871345, -0.4329786499759575, -1.3503764926730264, -1.09513695138193, -0.7772473892284204, -0.7416920523125108, 0.5157396726266358, 1.7126243001174715, 2.420122940551897, 0.803553209798565, -0.6592638765066943, -0.3136449045668944, -0.7644913868343327, -1.0019734894442085, 1.385361203761142, 0.5091447366918456, 1.2716885013701624, 0.2782601926130643, -1.894916022958535, -0.3493059064431347, -0.8949257764433348, 1.6766383533114493, -1.8444745263635096, -0.5537345910490108, 1.1506844204769526, 0.908914289255308},
    {1.329067241427204, 0.05751436983426476, 1.0837643847757992, 1.861517010076078, -0.0012913115898915285, -0.14569565007408924, -0.19448916109619813, -0.42389881027068743, -1.3651039866512575, 2.0906310435531226, 1.3355087606019753, 1.1484026375505418, -0.49915306354653266, -2.0127498952583633, 0.23595054021336886, 1.576638123704404, 0.7647367129410464, -0.9196964031990724, -0.5493859303366437, 0.3333562284220838, 1.776131118804596, 1.4947954779370076, 0.3698443866504713, 0.02569082246317462, -0.5656890329010972, -1.3181973786534031, 0.023408677833551418, -1.628288116366964, 0.3894660842404836, -0.6030930669907862, -1.1404863830241898, -1.1934656688968612, -1.253207399901417, -1.0605965630870533, 0.11145320986465468, 0.0841458145270222, -1.8864223079580802, -0.229227447474616, -1.4564924214056738, -0.5799907907871674, -0.8821718050578975, -3.029656465410656, 0.11554588908795214, 0.012720847090087015, 0.7746362750997012, 0.008594768715704672, 0.8819739598212902, 0.8989968852459266, -1.0502827678234914, 2.2773836417697155, 0.91725564244211, -1.9206162594301353, -1.1152517608178993, 0.3468874982973891, -0.7656980592618682, -0.18397984343197515, 0.9220483128907884, -1.3034188639828472, -0.17555854924419687, 0.7965705255203758, -0.9638290263551083, 0.23954512775444867, -0.874760753108418, -1.3833252853170839},
    {0.45079394412216006, 0.07317209852511028, -3.004478760754971, -0.30769405900592706, 0.49416160287794436, -0.6668535055999818, -0.22217517431129044, -1.2034482786426501, -0.22979742286236413, 2.1321767585027356, 0.00018453398958549175, -1.693679541236715, 0.6024362792373589, 1.8372927091749585, -0.31675130922137024, -0.7131958630451513, 0.1851717810640359, -0.7492638206112574, -0.11044926740004844, 0.10206944035357664, 2.3763741020652502, -0.48063482434775473, -2.1328848136376943, -1.2304508612517655, 1.1112482019226226, 0.1722380265143001, 0.06551103502707344, 0.3189815915205118, 0.9587497834671392, 1.400668921823842, -2.10364910676728, -0.21274775354535186, 0.37171763965299537, -1.3619329697953824, -1.0218814918294266, 0.7425912547419845, 2.519419094278385, -0.622207926490531, -1.4312874803622275, -1.0177730625519907, -1.052906566826786, -1.1522188689712387, -0.20384591624631967, -0.020917087959970847, -1.7603218024847487, 0.2075573211953093, 2.1173638102870553, 1.9212211020540817, -1.6472550871372493, -1.1823212010660067, 0.6398079609236633, 0.4140782207489116, 0.5574027114745603, -1.3837024454452964, 1.183945287445925, 0.14394411627324608, 0.09518567726849891, 3.3176001111347677, -0.5594405403417125, -1.6650684237924225, -3.063778381965245, 0.04417129463873316, -0.5005735966637352, -0.5071274372561129},
    {1.4808700420723757, 0.38117612004476403, 0.6720184163138888, 1.8926702463135487, 0.22711415493942116, -1.4700860880623305, -0.060298759019946246, -0.8259693121001779, -0.9165636428246695, 0.5393472494475072, -0.9446770160858062, 0.5298237807427714, -0.4587875662235517, 0.16026032831761478, -0.3207755776876983, -3.110963456486537, 0.10468845046446525, 1.30445489701852, 0.018970866753063496, 0.5400153541596413, -1.337891893974962, -1.2375789720732653, -0.0018018813720438388, -0.9792179327673999, 1.7507784339166066, -1.5198192585220884, -0.3649002675942818, 0.8959885477947332, -1.584397023696575, 1.0053028431462776, 0.45711421032370186, 0.6629803277672318, -0.7607501650653824, 0.2930280985074649, 1.7554485245809546, 1.9547394612581679, 2.3445261496988716, -0.32460889816715943, 0.9438798203679415, 1.1141778515723697, 1.0884664590672142, -0.39725606157265436, 0.5617616303801282, 1.2305640751968654, 0.08382151309635122, -1.0414665662660556, -1.0607998959733511, 0.9910714921170412, 3.1115179562473982, -0.5338915974504488, -0.2543389957357984, 1.167567496789401, 1.0033308897871946, 1.6914740217525865, -1.8285575808098653, 1.270124025107109, 1.1131376080040136, 1.1940975626425487, 0.49663956150234984, 0.3087427324139844, -0.1421527181807754, -0.6037062444122296, 0.14564540389797268, 0.10586794481573092},
    {0.31653044541733866, 0.2415163287016122, 0.8682814513452471, 0.503862817411954, 0.37971361119087954, -1.9799304318322863, -0.21869102938777465, -0.9955740331877168, -2.2668663557111195, -1.2643258668958248, -0.6865011152769206, 0.20718060189063028, 2.617583985991035, -1.4705265145180997, -0.35353559789283484, -0.06006802441646512, 0.8967669158990033, -1.605008392710563, 1.4380759328584145, -0.23387009590888955, 0.11730227028255091, 1.1988471308981665, -1.0419061265694396, -1.087478837425465, 0.20640615394425488, 0.9136588175418203, 0.1275654883038361, 0.955775284115486, 0.478351104552646, 0.9554018662328608, 0.02485570197923158, 1.3179815554726644, -0.20544976704588233, -1.0129216528815186, 1.0294683190514264, -0.876278035075451, 0.15336387721275882, -0.578359652438586, 0.0430644904939009, 1.8203977007391046, -0.3112157915085309, 0.06635271204011378, 0.5229359644507182, 2.0775966521529443, 1.5707857454486587, -0.673272333475963, -1.8623199535649557, 0.440355091376581, 0.9419735300025027, 0.023671517811744907, -0.9028882507874422, 0.12759946604523253, 1.3166707599742395, 2.240269636087625, 0.1515055469069082, 0.786232160854088, 1.3637566626774693, 1.1134946472804075, 0.7765713497191897, 0.7326183896517667, 1.0609361914066557, -0.25460116774945774, -1.1681588843117074, 1.5615773724968462},
    {0.5798258228186991, 0.22215605645886669, -1.536121691268256, 1.30920367381338, -0.030835119920515193, -0.7304941298705728, -1.0273817332175386, -0.7951161010574381, 1.8627612962370566, 0.11241092424440383, 0.43332742278316033, -1.2656599535006696, 0.47797962386085563, 1.232417450317729, -1.9573232850800082, -0.6930133769944368, -0.7454275402373648, -0.3930336931870552, 0.30662083485825975, -0.023858308926218173, -1.4764967526830075, -0.026567552958077324, -0.1125550140456391, 0.685057249814541, 0.07889002434444405, 2.1349556420870788, -0.9206192137096801, 1.792096431808524, -0.1755053396934992, -1.305777214965906, -1.2203365395563823, -0.7287299101858781, 0.294677351588977, -1.7862616047944087, -0.38662378638735073, -0.07719898175137918, -0.36789540370872814, -0.18130040054099367, 0.19641970647672016, -1.2302801104727015, 0.9298776596014741, 1.415041219760696, -0.07878939226069608, 1.9497143515789832, 0.6099291095649579, 0.08047348056829617, -1.7982671114475595, 3.058808275951653, 0.7916224183753691, 0.16421114664216427, -0.2111106397807805, -0.62830713791958, -0.14831447823766783, -0.0678545601152143, -0.9863754076652835, -0.9547566820762068, -1.2347469024476863, -1.9241005524408585, 1.0931710816234317, 0.2252655315326039, -1.1414285949880318, -0.4440324294298753, 2.3148260425220877, 0.72392488394951},
    {0.7635176461106435, -0.1501598736552264, 1.4271554989240849, -0.20216581866037678, -0.5447341910876131, 1.9206363543636018, 1.7938357099916573, 1.396308201159504, 1.4542058332816212, 0.34703383091065787, 1.9783920708973648, -1.3113802790210192, 0.8527850517690202, -2.029822592847372, -0.5573381490078214, 0.1673899173197486, 2.5634901454721875, 2.095145646489583, -0.5746221410281647, 0.40816667887881547, 0.17991698022542216, 2.403406524141236, 0.6092230540523321, 0.06533949004441128, 0.7417718086522405, -0.49734121252008984, 0.6469516171708409, 1.4263650661558198, 0.8133727929372429, -0.39454227687998766, 0.9504529103357263, 0.1983857320630635, 0.18304243427754252, -1.335862400449429, -0.14239250721979405, 0.03201748011718507, -2.0371037082313803, -0.20356120142678996, 0.03435301787760856, -1.3878545500946777, 1.0398659445187632, 0.023029223535523072, -0.88359650339052, 1.2032355977760512, -0.5522017090159016, -0.6456307110752048, 1.7755776408541701, 0.08680886310819269, 0.36590356474383673, -0.25654422673273364, 0.7637768607196717, -0.5651771885743279, -0.6989156453246478, -2.1476502053917073, 3.983287077379419, 0.17798228685266368, -0.020393741595394352, 0.34294036687385493, 0.23892835937027898, -0.660232262501085, 0.5979457776750331, -0.6973799056920165, 0.39068060989262, 0.5479061021334299},
    {-1.994784971531615, -1.9137870664973349, 0.7900129950336144, -0.20312171420091799, -1.1176759017875875, 0.2959212973113283, 1.439152316368274, 1.4023972547494334, 0.1923193515207003, 0.008172167711439434, -0.5832027326801184, -1.1246344320944122, -0.7704799246597808, -0.9134305116491055, 0.9108257948376476, -0.4119996231820325, -0.5027145332788127, -2.3533223438963566, -0.15063721351886628, 1.3396902815886773, 1.121217557831363, -1.3022980660580543, -1.5947015570476377, -1.2144917390218415, -0.5899886836341209, 0.6965848608271947, -1.8618106385215254, -0.4792034965317899, 0.780520823130574, -3.242260835148439, -0.15499014979713094, 1.3460847671829288, 0.6692575837585154, 0.31533463540389023, 0.08324440865195396, 0.04783832184643006, 0.856906868634183, 1.8651073607594548, 1.572121057203189, 0.9299203095376128, 0.020299857453400412, 1.7180116210897, 0.6230815866757021, 0.03127619975683764, 1.7993186707829314, 2.6946459944412315, -0.12502998177967156, -1.4474919997907576, 0.8295730202533242, -0.17999070752961727, 0.3829253254324234, -0.4196640877381583, 0.3871709823933638, 1.2813917326406514, 1.8075524458912549, -0.6378790478101971, -0.4154566683533493, 1.2186241359041166, 0.2262922360671706, 0.7091967459119134, 0.19776838644473704, 0.10563626035529003, 0.621379908154283, 0.35947534509305523},
    {-0.020594760142299582, 1.1252243512984934, -0.2860561089851558, 0.660092873493636, 0.14627924392179437, -0.13588043340326458, 3.097353034696929, -0.9258697571683913, 0.2613260850798582, -1.3236588842620365, -0.608442081316121, 0.8640757649464107, -0.21349230813725875, -1.9280310551429563, -1.242800363177434, 0.6264642848112472, -0.27006675554672355, 0.5423239680389362, 0.13176440126559144, -0.9527578423574109, -0.0534286806507869, -1.719977992292369, -0.06735359952542036, 2.2128781586590125, -0.1730341758247591, 0.9146307180837978, -1.3302530414551466, 0.7874765215717928, -1.0838252415018672, 0.20601822654472504, 0.6749540270045303, 0.303141230431366, -1.22325063866347, 1.7151396132342522, 0.8187062112690463, -1.3135405818651262, -3.173685267241802, 0.10746370098571043, 0.7943355405551413, -0.19369122359249114, 0.3797546848466415, -0.09354922830585932, 0.39993771157858715, -0.6664776897181048, 0.5221406166197227, 0.2327446907156209, 1.4089701791024236, -0.6732402849509926, 1.165889798563736, -1.4437349182135895, -1.8958943349506137, 1.2976887739095115, 1.2954619872243665, 1.5766151270678772, -0.017182835445549677, -1.2093507569618338, 1.2100444434565478, -0.11043376955055466, 0.617821599910731, -1.651090706324947, 2.817701511090925, 1.42060980783123, 0.3660605002571317, 1.1743406179512732},
    {-0.8602256544742944, -1.9401914368820818, 1.4730915124205555, 1.056416966057294, 0.5746015653566324, -0.4335742519733632, -0.45537377275949614, 0.5271277186703638, -1.9006632647112454, -0.9103642465287141, -0.6632897512771078, -0.24130724829733924, 0.5650733143179326, -0.7589326329588748, 0.49117586015883147, -0.44654733174803446, 0.12722961846855993, -0.1351903923854869, -1.2410818795598806, -0.4903769058224532, -0.5739162824947883, 0.7620934789823649, 2.0231264104197586, 0.8703254933503853, 0.2682792963866686, -2.351188265814037, -0.18617321577483442, 2.3040876363631497, 0.7096783526200917, -0.8635496777131898, -1.1170967265407283, -1.1170734245928298, 1.1099486072281153, 1.3997169519701411, -1.4391735860772241, 1.0778662031129072, -1.958983736829776, 0.3399463494957364, 0.09986646038360171, 0.07786407300427654, -0.6784071603548673, 3.2741995907932093, 1.7038457123370927, 0.6431561749986573, 0.09630192919522795, -0.5191748807715943, -1.0979989809719584, 0.4849470875593177, 0.0030108557619664047, 0.16045261004500522, -0.26790052095051037, 1.9159653327358663, -2.76187679431598, -0.9147789727992576, 0.1721164764574985, 0.7800364332467223, 1.3197954578936972, -3.2167180149655112, -0.8072455268410142, -0.4352630050006597, -0.47033702321478865, 0.2740228331680585, -0.16817043704378654, 0.3183403642402068},
    {1.0176247344311342, 0.5130196434774545, 0.7235824659303672, -0.2141266261301071, -1.0528544960259305, -1.43704590684088, -0.8626519534119028, -0.6607890874782675, -0.13475680912033902, 1.2215390404946331, -0.8573031532676568, 0.8242241081429529, -0.6044414812845225, 0.7723095127924637, 0.04526519752919718, -0.9449109800593227, 0.3237924645307899, 0.040282353426493056, 3.03643713653617, -1.2459575618419603, -0.5087148698766744, 0.7822797595963937, -0.2733553955547677, 0.3574613796725088, -0.3523393167382409, -1.0489321279161723, -0.4211522536939548, -2.0329908888376096, 2.0549798689479544, 1.537657238499737, 2.229904776969817, -0.0770652314612618, 0.45010714545944486, -0.9977785024507967, 0.1341532382629469, 0.29744635987042056, -0.9237272315487979, -1.5400114424699676, -1.1010254279676004, 0.21704817871510415, 1.509982224006555, -0.36905545645035726, -1.5182302868932196, -0.3538430873550086, 0.03688128237155335, -1.5407831361880888, 1.2829484855852253, -0.46172280797035, 0.250265951827644, 0.6550310263211917, -0.34009135591353856, 1.1797419206923936, -0.8402868638467316, -0.3433203837347884, 0.009853189555087002, -0.03754046349422082, -1.755963942123649, -0.055584871536475663, -0.18471496784020902, 0.3460320092797994, -1.358420101501841, -0.44398230533686917, 0.5502715342080782, -0.5027577830533703},
    {-0.824564196397845, 0.38199331644909584, -1.0637430681960331, 0.40700691374812664, 0.6039893040725431, -1.15970572686318, -1.0690721825831802, 0.018277100804420722, -0.09982326628132572, 0.4523326730833815, 0.20827301130635148, 1.3649818776842, 0.572100597025824, -1.662182529404449, -2.3798701207431083, -1.783660751682989, -0.6650222840088563, 1.1776660520835085, 0.09002601131767085, -1.3545568628021698, -2.2892425697498755, 0.5968679098776538, -1.8919457857043809, 0.2775860442754878, 1.3483643973713089, -1.5980754872548528, 0.7098059918263222, -0.9983761206169198, 1.057535303431048, -0.527808198669786, 0.32806389344857884, -0.8089287835356104, 0.2216698177521068, -0.7828141665350803, 1.250702092972276, -1.0823955534194913, 0.14262674450931093, -0.035843674494984434, 2.5536467114385486, 0.21253521614814783, -0.0190922400831512, -1.1895470536173005, -1.2665618480375473, -1.0232032017844037, 0.9942914114352174, 0.10365839664436258, -1.541009600477922, 0.09622333205538751, -1.4061450698266713, 0.3528493911830534, 0.4017311865648419, -0.9087204152781896, -0.19081818210280446, -0.5998823626517359, -0.537076319654958, 1.0679992655569865, -0.26256951622413793, 0.6058890676756232, 1.295741276992358, -0.5294790277986601, 1.9473516682971406, -0.47459362296718216, 0.8099093547024402, -0.09440923779465359},
    {0.8752137934331152, 0.6517915186753226, 0.13089256211615835, -1.8241134269773291, -0.02333943206524098, -0.19066878537798407, -0.31129701525286557, -1.217449449730726, -1.4184819577250536, -0.853324485557406, 1.2711194159351853, -0.401871658952477, 0.19536989272959548, 1.9504343721448891, -0.39577469536196896, 0.5680626188448948, -0.4323757702008195, -0.9811308464342683, -1.0878277001016763, -1.3517841218155273, 2.156681512207171, 0.2360981506552006, -2.681453867781344, 1.6148481903894616, 1.314069140743964, -0.44961921044640696, -1.7268766211517639, -0.6030009190105335, 1.88158342689256, 0.5309502402227408, -0.0817004808493822, 0.7844576751483328, -0.02415063829473481, -0.6063848341359294, -0.4877790742020516, 0.37882000356713025, 0.918467314049835, -0.15417722724627073, 0.8560373466892448, 2.168490914905523, 0.3912464587814211, -1.5140182804756375, 0.3655362060165274, -0.7321781960328885, 2.489741883359204, -0.8261455227503866, -0.049770212039036435, -0.38689892116014846, 0.05573951697066939, 0.5801902978470729, -1.1344459999583518, -2.773659859572641, 0.09710830900905564, -0.38523886019725884, -0.2561425062187766, 0.09785403664462881, 0.703641870214696, 0.5694165311356691, -0.8393438990227718, 1.357152443400868, -0.6935797749707714, 1.297206913262651, -0.21363658510689842, -1.6962851456846872},
    {0.027739146476351947, -0.6099676878932966, 0.2281047500280916, 1.5013235484578025, 0.8208456281886559, -0.030927911437615602, -0.9656487534505366, 0.5475137639999451, 0.6900486470031529, -1.8877584846939763, 0.42228326235465885, 1.2594157715692655, -2.983670343067804, -1.5149169316817033, 0.28320898032820035, 0.0763715334070403, -1.9954895006114488, -0.48784883636523463, -2.4776693720751486, -0.39415391704118086, -1.190453711093703, 2.332717434057122, -0.4256021877655585, 1.2114679667101234, -0.2936198299397373, -1.4101807841909118, -0.7389440038018656, 0.8930138934283082, -0.16111833443673063, -2.8215421742539704, -1.070870864039096, -0.31673911347020983, -1.7257140038627112, 0.5613494907667742, -0.3267428031825856, 0.12796820499077075, 0.0889275041215868, -0.5325234048317562, -0.05738108032270704, -0.26081700945751346, 0.2317038303250831, -0.5362367122661001, -0.16435162079741134, -0.11927631973440594, -0.8161029872546515, 0.6335998195854733, -2.0565372439934784, -1.8497138507569841, 0.04381760498075419, -2.5219710447016106, 0.5065401499934774, -0.44406106313637195, -0.5634423502131252, -0.20941791289755624, -0.9843331517074975, 0.46213848489456816, -0.053708490776140864, 0.6407025239479064, 1.3502113731910883, 0.750090238404816, 0.7074059284999147, -0.15846815605301076, 0.28008886642517794, -1.408070764451931},
    {-0.5466353873959122, -0.06345909072780002, 0.02124205963925082, -0.0072772615367407735, 0.2814689753953488, 0.22475097415678186, -0.3837710168880885, 0.1795639385327951, -1.3476331731819053, 1.183034191597795, 0.6735831568585583, 0.020093412877650384, -1.9958141905212496, 0.6826100212631301, -0.6761584644903326, -0.6448513585987651, 1.2076095469384323, 1.4630030480761387, -1.9318149720131543, -0.8170766420029575, -0.061103265613687285, -0.9156695563026018, -0.3098835126172, 0.20424331935629117, -1.3781798960686351, 0.10503621746336186, -1.8997644558368758, -0.015223577394642154, -2.333878276092756, 1.4157182940532809, 0.1279152458610902, 0.7491413435389668, -0.5792492282060585, 0.9234048708467433, -0.9163404090860965, -1.4457814747003321, 0.2472836795325078, 1.3208639089908036, 1.4001946872740751, -0.22387088831192306, -0.27583716923741725, 1.0278393421941547, -0.5750660762242643, 0.4187687612415646, 0.6410028085336538, -0.2400530349500453, -0.24986089924267005, -0.3380817588864133, 0.5040169508504719, 1.0596504606388013, -1.4000222993932132, -1.367482316299265, 0.4340522538335625, 0.6919028598937826, -0.898278676286256, 2.3195197279365587, -1.1313624674933138, 1.765707896698479, -0.3694741757144531, -0.5376047071436745, -1.3443890058352528, -0.9386846713967367, 0.4004392850380981, -0.9157669133372879},
    {-0.036438991384760144, 0.4696872529560911, 0.6748423757173697, -0.5648413528607119, -1.357712596314797, 0.7849767501260376, -0.42736523804519844, -2.173513322574328, -0.671821318088613, -1.7165986488274545, -0.9617777980125916, 0.2106270757221141, -1.2298690153493703, 0.5090229749924631, 2.199349448055788, -0.4514382001804573, 0.1536947652396821, 1.0371378609349924, 0.16781354789015732, 0.6480213785763962, -0.013453476210784156, 1.0344743953320434, 0.09607001713676123, 0.46502328058750897, 0.7267074341465363, -0.18479386118172567, -1.141500454771743, 2.7625997028540157, -0.40765955902987283, -0.8350887391922397, -0.8432127298248704, 1.6678328637081972, -2.978445222047976, -0.691116377075325, -0.569463153533401, 1.6227210206052185, -0.14520781846288147, -0.8895541423768095, 0.6650006385480544, 0.22690839018224557, 1.013191192002309, -0.042498808255356416, -0.7993052189487324, -0.8064144545566141, 2.203591435681855, -1.1989687167413117, -2.0175417721348916, -1.2023584620229884, -1.0289677404411806, 0.41357503756603836, 1.2719924403746292, 0.8569099375386244, -1.5735980012282778, -0.6958251959141041, 1.1200606287453214, 0.5854361467501343, 0.014764454608129645, 0.8517383334001716, -0.20874283724475828, 0.41660961017132025, -2.2220264340034683, -1.1192228320457773, 0.5864042030137772, -0.432409053551777},
    {0.7925532946734357, 0.10719182732512376, -0.12390026675702352, 0.39492001064235105, 0.4605146027381856, -0.29991545875121217, -0.32503395947512054, 1.9052637470198135, 0.6501269711119312, -0.013766009257751087, 1.303167236961588, 1.3782195657844598, 0.31252322003706207, -2.5722497801133652, 2.433640747877274, 0.5333630971581483, 0.6613383677919521, -2.1033251024840207, -1.5877749737857358, -0.22953591365035345, -0.07329151202146784, -1.5634022538810681, 0.28502507205044875, 0.6813966041373727, -0.7397023527530304, -1.6477403518710174, -1.1041745544633306, 0.2904867363501334, -1.0328101868833346, -1.426688139083995, -2.087143175868161, -1.40945142538161, -2.183838062866826, 1.3133305396471404, 1.4571177005868716, 1.6456779958580408, 0.9868415123027426, -0.20547878250614196, -0.3543046505554101, -0.6674100138012222, -0.9912958081742057, -1.4037355697033207, -0.5925915298527026, 0.8417180470749213, 0.10718216926706246, 0.2805657851861198, 0.613197356853838, -2.21205344889497, -2.929897917249374, 0.10054600352173228, 1.3997537229381933, 0.8007565930128028, 0.058393710776847, -1.2886935946625255, -0.10380453997184302, 0.8073153870996511, -0.3156901954101646, 0.09050622362987329, 1.1503081227190632, 0.7748754369890307, -1.4253891402545933, 1.9758904236985724, -1.38043033967794, 0.3809198863371779},
    {-0.016052034031954283, -0.6086144782504034, -1.0624599478593513, -0.2794780043047609, -2.263169674572445, 0.48092258702875135, 2.0372680937937293, 0.3956884817623883, -0.3343814781720113, -0.570356900287153, 0.9301484171961374, 0.237982449841516, -0.4778612711631621, -0.01411824730962447, 1.4756184982081546, -0.2802039584165794, 0.8363850789983178, 0.593236009549473, -0.5637955818402977, 0.12392818486621479, -0.4050212754963379, -2.036623327737244, 0.787114707005078, 1.2987054013861266, -1.9400173847994298, 0.3063996261740616, -0.29888331082680364, -0.9922484089402175, -0.8192268340493352, 0.7930076847652748, -0.9930914541220349, 0.9635549857264404, 0.4924436037127932, 0.8007958877237119, -2.1455306245504837, 0.44623608041131024, 2.8949308873461748, -0.8529067067716588, 0.3446920567923859, 0.016798246113066937, 0.374224847784864, 0.8750461083110087, -0.575073498625143, -0.5905176167570072, -1.3840476310815064, 1.1392252496395017, -1.3989271406971209, -0.7055725216186378, 0.49891221907606503, 0.23658621121961781, 0.11086749221421227, 1.5630803792155392, -0.5791387469339901, 0.13594064009639215, 0.8359158663712248, 0.992779919868279, 0.33606972020127823, 0.1216828482880511, -0.24137085837606037, -1.2964201408181923, -0.24636907743288147, -0.5869289770376207, 0.17884875664561245, -1.9811964461589728},
    {-2.4083554338277193, -1.9954241389988596, -0.3304329712179311, 1.529089638850436, 0.49384991476086343, -0.47390666731189257, 0.6403333881761111, 1.4413404911340204, 0.00857566554785158, -1.5699456551168838, -1.058032460095739, 2.5030110780244827, 2.5250090482429344, 1.6804005703888747, -0.5274196207810361, -0.17347230648489315, 1.2963325257000102, 0.08190562644525602, -1.9279184494001993, -0.3190205586275474, -1.0189090076509588, -1.9830567716677212, 0.7854884661787873, -2.9141161288075645, -1.254389017111129, -2.024106649831324, 0.40626076879768536, 0.04219667662433434, -0.5793897222516698, -1.402532068130646, -0.6026329096789956, 0.21387068118718222, -0.07905399809816192, 1.6475835986882112, -1.056300606011594, 0.3934885763826565, -0.3106677654484597, 0.6615233938590142, -0.9898745856400701, 0.5018062664046891, 0.58158201854226, -1.416532416627089, 1.8588627934015367, 0.5401709267169171, -1.1802368827915124, 1.4582353505194035, -2.1301894280844658, 0.407834359838432, 1.9064854443550698, 0.2044619731265426, -0.30226853434198725, 0.19617942696824872, 2.889041086606653, 2.1641476574221916, 2.9170160092359616, 0.37446465848883304, -0.39255566553262916, 0.02390624891804469, 1.5427717108953583, 1.8419479129035663, -1.3681417809839413, -2.727327888705848, 0.5904005918536367, 0.667893498394892},
    {1.681570801624176, -0.14028662727573318, 0.617224389207742, -1.5095506266977827, 1.9590742293921335, -0.2557730667840406, -0.3144663691694689, 1.6251211406767287, -0.6087056390717707, 2.0062469879352705, 1.937462208398319, 0.6139683727193339, -0.8724398342757473, 0.1330720018399754, -1.046548083713244, 1.1954766047845016, -1.7988300065913805, 0.2083588273796286, -1.076823653974764, 1.4418969081168918, 0.8460098869388146, 1.3051924245585558, -1.7360696905618405, 2.154111203291012, -1.0678062862709417, -0.9290087840114154, -0.3399084940567632, -0.8571924023680968, -0.32395915624799376, -1.3174816882618423, -0.7435148398868707, 0.381850275156669, 0.4628530752999858, -0.4532245672739346, -0.43564167483945804, 2.637029638690755, -0.5025788524568036, -1.104535759153887, 1.106803878293695, -1.3138774604989887, -0.11050601458413775, -0.22552473826072827, 0.4004156952920177, 0.8478490094098614, 2.2697617618866524, -1.591862388229662, -1.8557519549439527, 1.0711582481861728, 0.1584598770895349, 0.13770803846607602, 0.3092307896020844, -1.3322293562426153, -2.5248082175746913, -1.2945001133831084, 2.214889910958313, -0.9091358609099075, 0.8701280921279547, 2.5524918342826366, -0.3489472357938254, 0.4008630383186917, -0.065275506733443, -1.9385625504987938, 0.4245818410775293, 0.5535547726242123},
    {0.3792739491623149, 0.24501478392678147, -1.0673846837226688, -0.4092310586763519, 1.6482082721026776, -0.7599975987672988, 0.14744025895607843, -1.8007521241847502, 0.9600365508844703, -0.24467837648052365, 0.7161942357698878, -0.6902949851575159, -1.2981934751419038, -0.005975332528344436, -2.050463579377684, -0.06982264741995328, 0.4480131967191137, -2.3347478975963534, -0.5356836557022602, -0.4057380044660953, 1.86623337787642, 0.07783894135413785, 1.5311213065992848, 0.17264101110964714, -1.7237434479006313, 1.2142354223867686, -1.0677984227573198, -1.2571997245552182, -0.20743633974636194, -2.648134973167316, 0.16293673227564215, -2.596181295012577, 0.6963145826581632, -0.6760493023016599, 0.2989835805616312, -0.7513547882104953, 0.21899037386717607, -0.8825935579901883, -0.5486861501413619, -0.003129113047733462, -0.4230354762609976, -1.0273481541812701, -0.9558952997752301, 0.6412803847833053, -2.2557459481195954, 0.07358212167945019, -0.6401549494347593, 0.5849294771786253, 0.852093334289378, -1.2594737775439702, -1.0200321447203509, 0.4492181969747789, -0.471445280099549, 0.94119667370149, -0.4536264860420653, -1.5810563822560342, -0.21044616423238743, 0.46809196136467146, -1.141868800698954, 0.7730534121041563, -1.4143832304344497, -1.3906918991567228, -0.7642055709430989, -0.5601553878002418},
    {-2.7280105564210966, 0.5983247297008947, -0.42457280166688083, -1.557192416980587, 2.1348001633275135, -0.3661740470555686, 1.9121292594595511, -0.8988250733505947, 0.8941105988501069, -0.7958693087655544, -0.6646218995985955, -0.9162424690413038, 1.0590819121471564, 1.1431058976094373, 0.47452665733702265, 0.06213565274538668, -1.4884871172900658, 0.44739780929268463, 0.03330177583158716, -0.3038265934574682, 2.175094287334122, 1.0368468945443132, -0.9880607771212268, -0.25412945192593117, -2.2510624293228383, -0.12658912933496075, -0.12125836314996681, -0.5491496781237751, -0.12387789664992703, -1.7650898260501242, 1.6919418299109596, -0.24339926481823937, -1.5558235286648612, 2.051435721431272, -0.1390920878724232, -1.930289458967254, -0.7696142901938992, -1.6039643446935792, 0.43425448703339475, -1.0472671651072176, -0.4887259571970124, -1.481031910251931, 2.013690821745416, 1.398794470578047, 1.084412087045729, -2.3316294725554476, -0.8935994419804897, -0.970539253719446, -0.9796117563315443, -0.5668440335192726, -0.8179171772428051, -0.45250388826936716, -0.3936850221736225, -1.95757896967156, -1.175680413905789, 1.6024533416188618, 0.851162706417639, -0.8189091900113676, 0.6368616376427786, 0.9487456451338354, 0.6781652941728623, 0.7641376296898742, 0.9110296894205098, 2.46984977920748},
    {-1.1362019841868025, -0.9513663263976028, 0.7667230723560228, 0.044580937858001705, -0.4100601375863868, -0.8211175399958948, 0.9365789206842869, 0.47924198117056616, -0.8029674500201216, -0.7174671250831198, -0.36762373108718005, -1.0571614378636212, -0.3218162684310296, 0.3832277217076622, 1.0414451630542407, -0.9983146731314713, 2.854662358212947, -0.275781502561859, -0.8958688299441078, -0.6555352777758924, 0.35045293615159967, -0.24004498755941345, 1.8753438508523745, -0.14025641225247557, 1.0012494930854772, -1.4127954151006772, 0.02399364117816154, -1.1105504794609828, -1.3463778846552212, -1.6977080346659403, -0.2800752021342592, -1.267840871781021, -0.6535814679727502, 0.9037619362132235, 0.814285038504682, 1.4905806792932443, -2.4225129652198785, -0.19931848833192345, 0.7476333795673833, 1.0101659297222318, -1.53911176564421, -0.2701322270356857, 0.1407655487072005, 0.4282408518190296, -0.9644899213792354, -0.2778629727004043, 0.1353810771970812, 0.35325391369861636, -0.41344249613958733, -1.7113089958289553, -1.7979947711690683, -1.3483404876614762, -0.4136622141766733, 1.1837680960997727, 0.318922154715468, 0.4416370190638721, -0.7563265359249753, -0.08397314225443794, 1.0422664878663421, 1.048413724731983, 0.5406192546307419, -0.7843098203756216, 0.1955924117759372, 2.030771261528928},
    {0.40008351856910535, 1.7991147872136666, 0.9673766753056358, -1.4447196797198643, -0.47872045039356903, -0.8385366935892808, -0.5207349506169564, 1.7463673358476535, 0.14236854418438838, -0.5343536901950866, -1.8205284707836542, -1.1274536261739108, -0.016087271721384046, 0.47317037787663996, 0.6274638637753586, -0.8683367608792578, 0.7307523667598871, -0.8050766689800111, -1.4848685224879412, -0.5709739309617751, -1.9909856262684258, -0.9475220835053281, 0.13543931811056473, -1.3150900807269772, 1.9528805964750813, 0.559998871100273, -0.3039339053592276, 0.6165761062211086, -0.8425258548289631, 1.7762419860827108, -0.5454558527417492, 0.35131806385562653, 1.0513993131863293, 1.047318049743215, -0.4172197704807625, -0.5327582317482634, 0.34036563120842506, -2.4514088989946594, 0.6595813122768989, -0.23049786563667152, -1.0561186890089278, 0.7350973420327893, 0.5796978098862178, 0.5486831305414214, -1.1247922235636854, 0.7942656946493334, -0.5303457802829662, -1.0511575686736525, 0.2881401532588769, -0.36701192561129276, -1.419332634468162, -2.2625474620476638, 0.5795962613685143, -0.711274689470528, -1.6256892593146117, -1.7266934167023618, -0.9042800827052252, -0.8010365343423265, -0.8005702693638942, 0.9317912152584619, -0.5565632835448401, -0.07465978744513224, -0.4911607890807475, -1.85936474160631},
    {1.6957367240861831, -0.15451415712814878, -0.3853030446669271, 1.845659285688961, -0.492019381860821, 1.8711728272569872, 0.7649796692199772, 0.14080872936672947, -0.6748161053288504, -1.600731711380503, -0.7463115689820037, -2.327851926813928, -0.1096438183101613, -0.026618139059587816, 2.144006345909739, 2.6285116989055903, -0.3116525729532293, -2.1225845974989124, -0.21462902460648992, 1.9561260428986909, 0.3140047824449436, -1.4878790009906318, -0.49657114169771926, -2.061793317529945, 1.192140640328095, 0.38251932911592657, 2.443295525058141, 1.7081536893649534, 0.564526347672029, 0.03859340296133322, -0.06901357059673312, 2.5340471996480383, -1.7962097903002885, 0.5267332861355032, -0.027580587285942225, 0.31789207460484387, 0.12317521981635711, 0.2340529330212044, -1.764943309252357, 0.012767705540865048, -2.2863816790203075, 0.4534630741155704, 0.15354302802437078, 0.8426143146511471, -0.49456235856695624, -0.18252424922845722, -1.4150774631079808, 1.368282246814233, -1.7029576840353913, 0.3619364402447573, 0.1299859333032898, 0.3002891855948799, 1.695046242646357, 0.3605449734767775, -1.96595983269842, -1.2828713317414224, 0.19046081346523744, -0.4694180837633309, 3.3373975435701797, 1.0033588661465174, -1.061987919095432, 0.9810800230915901, -0.9646395458028678, -0.6281703587104475},
    {0.7275469601025477, 0.543732511570798, -0.6684169523709504, -1.563925013974393, 0.5108848942894311, -1.5714319070520606, -1.1279836712814502, -1.1076988104050114, 0.8904578719415062, -1.9477790230120018, 1.394773662712037, 1.727925967159744, -1.146438072172716, -0.26376099503095646, -0.10078929246053286, -0.6207526749430601, 0.046290617261560904, 0.9643748609905354, 0.461495008368591, -0.649610002945393, 0.3695115086053888, 1.907719318948895, -0.8009086523990453, 1.466995454645479, 0.07826157890529441, -1.1875968715147065, 2.3254231904943756, 0.7567612409636951, -0.42158462507786565, 1.3428928856049815, -1.3226089123300748, -0.44038817247333323, 0.011824903750750196, 0.3683020369840571, 0.3068739175067601, -0.30366982370250556, 0.7238868605999094, -0.6057554718560619, -0.5546801760068931, -0.6327541073686144, 2.285589790970128, 1.74358299574522, 0.39681110145952647, 0.9899946097207369, 0.5677837937501223, 0.10530130771133923, 1.495971764518837, -1.0925832020503214, 1.6301977648231238, -0.057160863570578375, 0.2547143522285327, 0.4836140173627053, -0.3774514004596745, -0.54642776677844, -1.5304156253636054, -0.4248510257485402, 1.114464608586061, 1.5642069080996632, -0.7490232760301971, -0.18369260781170538, -1.3798489988699598, -0.6077754515740845, 0.29208890890636796, 0.2847559804813079},
    {0.1712879455947823, 0.7723547330531136, 0.82022495272424, -0.5323968171895023, -0.20075200084772624, 2.8067477571729773, 2.199427047567681, -1.0946765470955846, -0.3416078696339215, -1.2908790765621125, -1.515342209409498, -1.078912493981647, 0.4855147970726015, 1.091607319217272, -2.533142064089529, -0.09717192693034794, -0.716726777936703, -2.2411703951201067, 0.41375511890639205, 0.42729014958350886, 0.2535500585933972, -1.594860142589093, -0.7279711103879201, -1.3754026381025586, -0.3534730332575588, -0.04496758831925704, 0.4636458705133148, -2.111172945729926, -0.11878471423101356, -1.835371912080279, -0.03166989987062793, -0.31990061170332734, -0.5763016958201953, 1.6218957845086854, 1.3082421650554552, 0.5980764562433817, -0.45783872206134524, 0.9342984748304429, -1.025761640055677, -0.1126935902142329, 0.2939355642741018, 1.4728299750623082, -0.9369044257098056, 0.2792974967628154, -0.20204053075018039, 0.3728011980433702, 0.4528402772446406, 1.2654274497781437, -0.6064212291954255, -0.8394214351716691, 2.2208966853383, 0.7106574084938844, -0.31614343708795783, 0.1955729872299661, 0.339783182426917, 0.3167321843393206, 1.7327815791246208, -0.39493195406987675, -0.09692799152789135, -0.7573708205911126, 0.8253891975445737, 1.916386902214806, 0.9726394302252086, -1.145208189104015},
    {-0.7097580450279921, 0.6279582219595977, -1.2355751027423827, 1.9042279775727566, 0.5581003304001741, -0.09585627546114402, 2.4734057472954207, 0.20986548880463327, -1.8750949534487882, 0.7402980472981076, -1.1149939680625973, 1.3072300425331695, -0.26531802718344166, -0.17061754174851798, 0.27367586198039495, 1.4589935329568184, -1.4176679730071433, -0.41826849702096336, 0.663997678154874, 2.296221126285563, 0.41766512815235407, 2.4888696100609993, -2.055058861888299, 1.5045696699548463, -1.658668092845048, -0.361925400842854, 0.5539220143655592, 0.967148998635304, 0.24160231552489642, -0.803385010579808, 0.3697002624678538, -0.5887256662342373, 0.23656914171217694, 2.086894972263112, 1.4011222394389258, 0.2885038750046751, 0.8182031312327642, 0.39766376605541237, 0.18137396636222936, -0.20162203483818875, -0.37297445778096877, -2.330040081399679, 0.7446954792499391, 0.25420189925229997, -1.006357667422103, -0.32200792298091574, 1.2051943961085674, 0.7580810648629611, -0.1830236499829275, 1.563613017317496, -0.8864607230093476, -0.038523116384109664, -0.3237939141394561, 0.5689543963056619, 1.1232519713447184, 0.10327421803204315, 0.4021444707807564, -1.80063917691074, -0.6054302653478919, 1.5495473862940423, -0.6734938539469231, 3.35261254211492, 1.031981645747159, 0.2407729774886469},
    {-1.333073493591748, -0.01225985737908992, 0.09522456449539062, -0.21978523317325355, 1.2734091683162485, -0.20853049795214237, -0.3229669443579095, -1.855387321523695, -1.6155904692833916, 0.05953231806514536, -1.061903974418327, 0.3681135123987031, 0.030281471444407015, -1.077358909875891, -0.9914486851805169, -0.9404280736087005, 0.9116220049808365, -0.8276555466404846, 0.32382363882183085, 0.49430947989646945, -1.7469268409952063, 0.2528459384057707, -1.4938198876325532, 0.37824284065018143, -0.10983024801970848, -0.4447073201295716, -0.6916932603458136, 0.4716804050612019, 0.40367154867411237, -0.43600545234675375, 1.7338962104166875, -2.2193210487954196, -0.8018574846393915, 0.12306175660723889, 1.2732219418857, -0.2917988104863294, -0.44793512308456346, -0.5778216922940562, 0.7076028510990636, -2.072695330669195, -1.4613711543224182, -0.7081489360880463, 1.0199698080785007, -2.421952807907401, 0.2709602208891543, -2.5215312748361565, 0.6027394717170941, -1.952898669311298, -0.36728895047201543, 2.0531547876605454, 0.5305283432379827, -1.2082980033036792, 0.032716439601039614, -0.7762273902784211, 1.1009984184324801, 2.002265457087313, -0.5253479283821441, 1.4368107091117324, 0.22198970040722282, -0.2851989930687762, 0.24836864511681003, -1.838671852321028, 0.21057128668886615, 0.9354759150436431},
    {-1.545138433233462, 2.6339315281498794, 0.7726914781989023, -0.5728226216261157, -0.2448320067982627, 1.0598882529975018, 1.0858012226608202, 0.4309357933039982, -0.7443183469299447, 1.4071638408736495, 1.8069464021533947, 1.2763893931778965, 2.315697638955396, -0.12912790937147828, 0.05858380442210325, 2.352001324425273, -1.3085741575129084, 0.8370205050421332, 1.9964583228400152, -0.9213657144534222, -0.18827452065494382, -1.148770770501711, 0.38969939861652647, -1.7528687892638066, 0.7981549822624003, 1.249999571909328, 0.6654100466605295, 0.6003390173456625, -1.2449100414576038, -0.3535897658707554, -0.033970880092348554, 0.05896766307170211, 0.07482440291407237, -1.2620026476207737, -0.5277287456308788, 1.0402455746212504, 0.16597815193401416, 1.7017926502895295, -0.9483109358118124, 0.8902349490850734, 1.6818579299131098, -1.8773936435656828, 0.7670243929995758, -0.051483838663438156, 0.43447702218388295, -1.9335933740858813, 0.5347321316740951, 0.39322615995184573, -1.910370648409682, -0.12442791729571284, -0.37525524967239693, -0.31462177046235423, 0.9991795332610429, 1.0297989694435845, 1.5682051311997733, 1.1398806130784147, -0.2992071199005331, -0.015646753749955805, 1.361628956264431, -0.4937189601961172, -0.3441194625131318, 0.6976478356372479, 0.8685939264738193, -0.8663025578583943},
    {0.3642731382714216, -0.8813362243340964, -0.4461233509500976, 0.025074440311072924, -0.050411207470977035, -0.15019325329259822, 0.5231975639283948, -1.6125906780050603, -0.22770109255824272, 0.3757433349984078, -0.31359081155512275, 0.6339044396039325, -1.775675309661547, 0.9131392976731729, 0.23564460987790836, -1.222886964515865, -0.643654910150453, 2.250118632496247, -0.6827449923034394, 0.7781625985989105, 0.5058227584252907, -1.928426113327796, -1.816490205555141, 1.5933725600618933, -1.0334115696691732, 0.49935811620147436, -1.2117398111248265, -0.6937937554388117, -1.7615852783985444, -1.5692464298811046, 0.8154132346389708, -3.6142721463841014, 2.683004152960057, 0.5287571783246433, -1.1682354535092103, 1.5633289386849663, 0.21549283712637093, -2.3437051483090574, -1.432518892399018, 1.355749163206369, 1.284794495694333, -0.3586041147412655, -0.9508490449302416, 2.0518081230274015, 0.14965414366978735, 1.2864856142925707, 2.129451967524677, -0.49826072209769584, -3.087128875790018, 0.4140253626341448, -0.40545835671904334, 1.5698285045104103, -0.4570730643319576, -1.1982953301552501, -0.3557581604555673, -0.03794081797010095, -0.17602991562159062, -0.15076045312698655, -1.7275927031501126, 0.8764033178710541, -1.248824133694197, 1.1804775578178257, 0.5737632020254285, 0.23315798505395993},
    {0.9222749588841898, -1.3283241516209112, -0.8024488963144724, -0.04421879626991352, 2.0995052277598427, -0.40558717303243325, 1.0332737878413718, -0.12377517550780633, 0.2685119813872813, -1.8448172507610823, 1.0937289588525878, 2.673685312628981, -1.1176070204286794, -0.9673042950383806, -1.225119698369085, -0.6859046161323619, 1.4717472998480956, -0.34414865231297104, 0.5916586276595909, -0.12943082762774, 0.1263607968729108, -0.7107390879033074, -1.3100535573421068, -1.707578592996722, 0.3208207131780637, -1.02747905566314, 0.5057328587143133, 0.128701433871354, 0.4895686471260951, 1.3406419215731555, -0.704487131909455, 0.6451521598104693, 0.680519825086631, 0.5973837961872693, 2.2766848546343934, -0.6646975913669604, -0.4859887490166964, -1.4597345951883574, 0.8632858000081466, 2.8214611015240956, 1.1629666880333045, -1.807368828596602, -0.4052639452521691, -1.4929131714104626, 1.441778598755206, -0.6225253697304172, -0.6050516656161441, -0.3331473735186813, -1.020524469769181, -0.11637358644503569, 0.2345508110579379, -0.6158649650092985, -0.028152654369374617, 0.8265231829120724, 1.4350011419932187, -2.451588209309489, -0.1575964452041357, 1.7278957799286037, -1.8979776980144187, 1.4790640653724763, -0.0878131328261053, -1.0393701766484515, -0.26510827904502965, 0.31150757009257973},
    {1.0661799439319721, 0.046272480041925725, 1.0117233940034684, 1.6575553371936291, 0.8978197435305206, 1.9065132513590592, 1.8861106777107421, 0.7539794230301166, 0.022817193871776022, 0.9270756858783626, -0.6759468224767676, 0.351455409809913, 0.8886587201225822, 0.5969182565775324, 0.14472205717338496, 0.8686538260561193, -1.1426117502491087, -1.741570314629313, 0.25796476793310985, -0.3873546747751332, -2.279212399070133, -1.193752026997901, -0.22178178664659465, -0.9070632008166022, -0.3381091537403018, -0.2145570358823103, -3.267682498508583, -2.046633064389963, 0.6190998172683428, 0.0913875223931798, 1.044522890816883, 0.047352319379803436, -0.18069029163275516, -1.0495340313217791, 1.827564427585108, -1.6413674400361549, 0.9421930430295804, -2.240017409485713, 0.9822347259224318, 0.02749497654540336, -1.1057648523704429, -1.1866132557191422, -0.3613092923212993, 0.29703610753652027, 0.9426709961716982, 1.1838320555357211, 1.165303940684862, 0.665760367570082, 0.9072633061806366, 1.2087272125872044, -0.5339219859461481, -0.6213474243852136, -3.2664577204886154, 0.3066745705724589, 1.5105581958749834, 0.3484059228870104, -0.7188761763667483, 1.1500365688160838, -0.8208305504329277, 0.7099641176303244, 1.0070069162475157, 0.15111161443901439, -0.014614065780074304, 1.8723728910485107},
    {0.3528516751237172, -3.099474673987706, 0.3824603637161908, 0.8580927441710148, -0.5921785954995457, -0.47445981479732857, 0.8373380888118381, 1.1145781454672352, -2.400378227902998, 0.0674317094561503, 0.28868905703155734, 2.5641805443506995, -1.1717926706078443, 0.6391523028023037, -0.5218829262328202, -1.7394008695732337, -0.3792123847090154, -0.5723560944286853, 1.2724657813415134, 0.42656459296322075, 1.0261824654684506, 0.718288886634586, -0.6833235161050859, 0.2271418851670508, 1.057521920345684, -1.401415028307749, -1.090396654637982, -1.0121299087648281, 0.0911512724998585, 1.6692763630355647, 0.24406740253437112, -0.08794631962370421, -0.04418373681975121, -1.7267530051967597, -0.19634402307415957, 0.31104278434372745, -1.0066393785398844, 1.837553203064924, -2.150774938194874, 0.8849473290884313, 0.2757357177982348, -3.4295437243961944, -0.16234487105085413, -0.1637352250806696, -0.44082398197601513, 0.09124051701143258, 0.02694808372675012, 1.0153301498364855, 0.15945027619829572, 0.17508054765134232, 2.3811648879485863, 0.9623724716023097, -0.30087865434705446, 1.8742521101168328, 0.7875125395526987, 0.38289482547225234, 0.674615608067046, 1.4373402088817795, -0.9110647188172717, 0.5234485897539669, -0.23424426349538846, 0.08829795166353938, 1.021564506470592, -1.63384115009298},
    {1.40416125041202, -0.031023287353235635, -1.6786205486364674, -0.19617799829748492, 0.014649508451673275, 0.8887038861417241, 1.0319283579543626, -1.43793455888719, 1.0097684879096727, -0.7846159087136935, 0.42419990730306667, -2.155274998929224, 0.9319540560406707, -0.5274633069887564, -2.494717932806618, 0.33806689647755916, -0.523702315762891, 0.8851804298506676, -0.09283949095784359, -0.49136278269710315, 1.3283564958055598, -1.3400370610105725, 0.11010370086907441, -0.8232800521100601, 2.064093700681361, -0.03524263867280623, 0.2695746498924577, 0.5548056258556637, 1.8222486484139095, 0.07985236143380568, 0.3763690748864697, -0.0930956023618517, 2.41748812122714, -1.840071982542846, -1.0619231446198203, 0.7570901467488658, -1.0003510423163486, 0.6345535320736106, -2.150145510972506, -1.440871825929364, -2.13134946866143, 0.7191561700563568, 0.2657083482037718, 2.402346022087048, -0.729141241420453, -1.4854367256173513, -0.6424141000560802, -1.570392798050042, 1.9293746432458565, -1.1256136522489129, -0.6460476526851099, -1.4892373471757963, 0.8916757826314562, -0.0884699166450819, -0.283852367820533, -1.095989280870012, 0.19802624808956895, -0.0775685724829001, 1.454910822499745, 0.04192758106716111, -1.266221178040459, 2.0281088786558614, -1.6272451498559986, 1.8296767450912608},
    {-1.1970079270212248, 1.5996071462334518, 0.1438083898049863, 0.40319965441497785, 1.223789951853849, -1.746056573542308, 0.21103956395803541, 1.6042726329075359, 0.7128087960814361, 0.052416959193057645, -0.7291732327247624, -2.884119592730891, -1.0582146756629962, 1.1084291008192249, 0.16108416006500717, -0.1897551743959987, -1.0937655149709722, 0.3860905403808493, -1.9203996824994705, -1.5467583705910954, -0.5188922541330613, 1.9684119789757575, -0.7803532653271739, 1.3786341929239847, -0.02733005780260892, -2.308408290611004, 1.5791497675714945, -0.9859545433990379, 0.3556592331531536, -0.1500374640549849, -0.7841466286956638, 0.06571545832886791, -0.34796058538722624, -0.07776634295062555, -1.5982336901421546, 0.16662964052119392, -0.6657223271013368, -1.5068191154192472, -1.1824005357630059, -1.0237857872759404, 0.20262582817052455, -1.139189484444097, -0.03321907079538497, -0.19349927414476925, -1.6816934798187264, 0.34910214384678173, 2.0581069389496762, 1.4716110133874778, -1.9228241334831802, 0.5875753757119979, -0.21229421753166877, -0.2075320786994383, 1.2572095143864854, -0.08969513688681065, 0.2813389212804075, 0.8322258093397099, -0.7669137110063734, -0.8390054244136388, 1.3958402782611503, 1.3120372047198046, -0.7286925435978406, 0.892036514228235, -1.0629858662264495, 0.7356186643022214},
    {-0.4008093436739451, 0.0683686347236184, -0.557708183508316, -0.30617590426809055, 1.8899366451249218, -1.1834733973709293, 0.5360264533042955, -1.1282521206235863, -2.001338588438119, 0.6290970618916549, -0.5454432742978701, 0.44253258219682584, -1.4885038283632808, 2.0802501357822947, 0.0017180178423395925, 1.2175933346417693, 0.4413947994733356, -1.5808566267035868, -0.47709634049401173, 0.5141230974574635, 1.0039999599952167, -0.8003898725255316, 0.3432752777399823, -0.501582670398122, -0.5078361206064687, 0.5613826546651017, 0.27606002304882776, -0.6425579657772954, -0.649311722774758, -0.4593213886438377, 0.44869228498191055, -0.9836968739852616, -1.204148466894181, 2.052384825917099, -0.9683600833485884, -0.1299592152142893, -0.9128799488252135, -1.6015425881738674, -0.5273445820735296, 0.9458825644767529, 0.014614831009775347, 2.1661698528949134, -0.07109177149932065, -0.38519805130977497, -2.0880862137702145, -1.00758134146931, 1.226285181571781, -1.6858985699525897, -0.47221757252953517, 0.9282264511503148, 1.0781171679863863, -0.31791539530963764, -0.8214755455837961, -1.2467958690188665, -0.59801025449254, 0.9394159530829281, 1.2918902921972302, -0.7764368563776196, -1.937391833052263, 1.0617528978066522, -1.5179875875221647, 0.7109778162661026, -1.8738584709613537, 1.2028832378408227},
    {0.7519778807126676, 1.4306316605012175, -1.2854142667176864, 2.2718917943675105, 0.3735500099853112, -0.036693601413610215, 2.175559818351122, 0.23852910145500347, -0.24842359599637678, 0.4971201790003845, -0.6587722728084834, -0.9088227217191348, -0.6557173992557255, -0.5893092918762277, 1.049442826202245, 1.4967953427604492, -0.0054322874544171125, 2.1437443513985963, 1.8497539633988045, 0.6832062707565769, 0.6239973768684033, -1.8958035875182295, -0.31763579664739394, 0.6938285900960399, 1.1221053079494407, -0.34182738234214877, -0.34073296342658804, 1.379806868383338, 0.565533926622033, 1.2584971814350743, 1.0013201855538678, -1.7340438376458016, 0.8668856816210287, 1.2932733886827934, 0.8161209452944507, 2.0735548943432893, -0.7614700229914491, 0.8467653500034019, -2.2332656480017983, 0.7874851263219143, 0.8139659650485184, -0.925100321659422, -1.8111958381843094, -1.099752984488441, 1.3974198502924124, 1.9512217733307322, -1.0968932083743759, -0.7180015567499586, 0.25313473984517815, -0.9340450100861541, -0.46890128735743014, 0.7398830330075301, -0.7999392315943329, 1.2082112030121122, -1.5695281008605757, 1.8967723334595559, -0.4296953964658873, -0.9049947730990935, -1.3992560520281203, -1.1290499444600137, -1.1299011494111804, 1.5903892408828277, -1.4454223394734116, 1.2677298795942342},
    {0.3953857317446067, -0.215731151873051, -1.2377992020395723, -0.7487423234274092, 0.3348528979721122, 0.7550076143473985, -1.4632903385480427, -0.4283035188278589, 0.8831165622351143, 1.0540743833812718, -1.773116637348714, 0.02522438689477595, 0.20592615478045334, -0.07845557665557606, -0.6175760957458927, 1.2303252644174991, -0.22954009880311, 2.1019072805783643, 0.8159549568403489, 0.09644411232740237, -1.1481316957382905, 0.8134583203541959, 0.07447028907496431, -0.10100446892735754, -1.8699272088793082, 0.2685856075017149, -0.5797235605013471, -0.13503466612334267, -1.1635240342859745, -0.8109331932412187, 1.1984413257280797, -0.6338473571136604, 0.11820426304326, 0.9696981476724043, -0.5756107281106901, 0.10126437471952625, 0.4919017798240801, 0.489104911128755, 1.968037212514549, -0.5297114336617914, 0.380976032150299, 0.3110582444002893, 1.358657958055182, -1.7554582770674587, -1.6148352907937291, 0.6166830554810898, 0.9902313109515759, -0.132610217166386, 1.3304192048859147, 0.6920935514275408, -2.262181327846421, -0.9583775090819966, 0.4239308556702615, -0.09617663431322801, -1.4190974466155784, 0.7491512206638462, 0.9432602015145048, -1.7270147987114681, -0.4797522549626895, 0.08915764551804926, -0.8567577241303291, 0.01896542130146675, 0.1518335551568722, -1.7923296776133175},
    {-1.391284491046942, -3.522003988783942, -0.9906310800681221, -0.7374921038108815, 0.9363593404002475, 0.8053844658694531, -1.40494824119867, -0.33080942198147584, -0.6131417462419464, -0.39636788815793056, -3.046725583517597, 0.3501488455863048, -0.38389514284316645, 0.9281853531467961, 0.010090437180344882, 1.4467782765185937, -0.8168595956345582, -0.9911765457063494, 0.2558055082218583, 0.3085301159058618, -1.0973834792945394, 0.3269318151757518, -2.0649374939623177, 1.6725848870424354, -0.36963518223505454, 1.8683606807300022, -2.1598538839222945, 0.3541232856916692, 0.46974146548239687, -0.8814189083640748, -1.3685390506669188, 0.3793716241675398, 0.5502787062591192, -0.3230960377541539, -0.6541074778487733, -1.2624793928093088, 0.2696754364498053, 0.5585211560668893, -2.407991968403765, 1.0195819945743243, -0.2597451065924962, 0.7521591550185671, 0.20608615942880937, -1.2714934093303023, 1.9789009504472377, 0.7689069509873191, -1.3533520660427094, -0.7528124709706792, 1.6367236446505167, -0.6509672412894693, 1.664026245775344, 0.5533804270426986, -0.8897640277389547, -1.3440722878924705, 1.1421199362107772, 0.09856236016690408, -0.49332210460358356, -1.2660620110022878, -1.266210241132853, -2.517469192335822, 0.26187031159282037, 1.1177157038273062, -0.2683479106449067, -0.9276381781385048},
    {1.8725785773676353, -1.516860240568661, 0.3621696644742356, -1.986253925968989, 1.1645989590765184, 0.7649614325161836, 1.5545319014472068, -0.7706031989665943, 0.9052597268401108, -0.4594582428498101, -1.4710095362455948, 0.1776482484022181, 1.6749786523004073, 0.519645125176829, 0.09042062936553538, 0.5170512499929826, 0.4991652122257963, 0.42990114078072655, 0.41596746233626103, -0.9829838554773138, -0.01427986604406703, 0.3150333705347992, 0.055022726983362365, -1.0715503818867302, 0.6184957854705666, -0.6076196853488621, 1.162282218798427, -0.12045649490031939, 0.11679229979496812, -0.9117519063868695, -1.274418122582576, -0.20798891054469673, -1.2757755560807749, -1.6024804924558653, -1.9621488528064204, 0.6622351912485681, 1.6791790697971305, 0.6979661406715956, 2.043257244180994, 3.143317900667005, 1.4933721967285611, -0.9133831781742269, 1.3867829848075934, -1.4446134341755934, -1.210236528611385, -1.7616198819103088, -1.063011398748013, 0.41979260609717545, -0.7963585735547936, 1.5778005764294367, -0.0914944301563823, -2.276130239820339, 0.3919351770878517, -0.1275974163034975, 0.10901157936510297, -0.535191190476687, -0.41778299062874086, 0.26692984882769744, 0.009576396418887337, 1.7930117980530376, 1.254280326602187, 1.0040148893647507, -1.395670118185717, 0.6997699475013461},
    {-0.13748660409949603, 1.8834059397199903, 0.574676936956517, 0.33400849607571237, -0.20476516045524507, 0.20285059394688526, -0.09802557605325779, -1.9390603886626545, -1.6680622215830876, -1.2725758553875355, 0.9812932708075732, -0.5267713954023574, 0.40515277338482436, -2.167934617346734, -0.10393340881664637, 1.487122232207618, -2.402446051222218, -1.1895113958442587, -0.33619263579372244, 1.0092636139931448, -0.340286956813792, 0.04909921582586333, -0.3116500555152807, -0.34036739536734634, 0.17824309544673608, -2.453428371749154, 0.6577015166219777, 0.38041481103666236, -0.49963818482858485, 0.590157501374406, -2.2169395764039197, -2.20309504059508, 0.19530039055355472, -1.2787487567945883, -1.1926341534088851, -0.8369658848614473, -2.079864690531021, -0.9070207651425688, 1.585161097276777, 0.5503165985823606, 1.4624429601445477, 3.0303913920667185, 0.2903467466147473, -0.2525463223877225, 0.4189259736401079, -0.606567846725546, -0.2776154287725925, 1.7414840024258937, 0.21872937469945838, 0.34132190511412247, 0.1597569572635711, 1.1177075735905686, -0.8450126463967017, 0.16532360470615284, -0.38331246192824303, 0.4955832701302754, -1.9730623945547976, 0.20370108312405785, -1.0774445897605371, -1.1094802767628582, 0.2845352117143458, -2.1330310976187508, -0.30697199884504384, -0.13280917820623742},
    {0.41338129927040135, 0.3809349111922496, 0.6876319839142562, 2.985760538197592, 1.025219726494649, -0.8578055160749966, 0.7581060507561691, 1.5424692331783505, 0.7109371618581771, -0.1431441183126447, 3.76436510292689, -0.5226761691461412, -0.46192136763357894, 0.46526754647730634, 0.41255491629093327, -0.34388298702806386, -1.2505199690521716, -1.1047996466209096, 0.37455697584650516, 0.6808997748079594, 1.2080840507500064, 0.8999347787260615, 0.6503956704610573, -0.9645106057166449, -2.3207457213207654, 0.2260110618446383, -1.7047653734631674, 0.7943790916119092, 0.29513793080424705, -0.8503335563941694, 0.16303827199691234, 1.108152775077356, 2.329814932132547, -0.5204473777441808, -1.1106856593359435, 0.09997782038209525, -1.7336483045512479, -1.4331724488199766, 0.4360523148083875, -0.557260215178846, -0.24172255350823743, -1.2717068966239016, 1.6533030689746644, 0.8793460013819172, -0.6890040619686019, -1.1833582412912862, -0.9517012176266104, -0.6230791700844138, -1.6619036712816146, -0.6745790027838332, 2.453082335996587, -1.9449657728847676, -1.6677981920962748, -0.616784806785916, -0.7223237245048019, -1.121634466836091, -0.17027618896706323, 2.0032950240432377, -1.2264648301260286, -1.2562056047285783, -1.5007914298794351, 0.04475002096808661, 0.0003398237252517518, -1.307361956304057},
    {1.3298898023666146, 0.5293799674680848, 0.12385497940061126, -0.45862221341389015, 1.7313571168096131, 1.0110951054801067, -0.07535372594362545, -3.316403103526079, -0.7550173525052283, 0.17464382278780605, -0.5742369631832532, -0.5337603157126898, 0.607243135419845, 0.12222138780319827, 0.4280439191084849, -0.4778758325182966, -0.3389470951591405, -0.4767663581884928, -1.0529884823985431, 0.1734543785449822, 2.618420125803666, -2.4341185692079823, 0.8093566969972111, -1.1440267301193427, -2.121836949122581, -0.738092648541021, -0.32052898640630983, 0.43972060844834987, 1.3611388050966613, 0.0396736465035145, 1.6269662129107545, -0.8504341422646136, 0.2865965689641486, -0.6097260014200047, 0.9266827710932937, -0.4982017441221817, 0.7061718317422747, 0.07293845898455478, 1.0065119174156374, -1.3292982818574146, -0.9501638638712759, 0.047979427512431325, -1.1228438124294027, 1.0507315638481987, 0.3923576245134866, -0.8239664961958667, -1.0722783071504847, -1.191316716875353, -1.6843075906232738, -0.21376277309930172, 0.900578073718385, -0.3801800290098456, 0.11927077071280834, 3.8564424725549284, 0.11593536673128844, 2.3881786568507164, -0.998766968787052, -0.2663486645628686, -1.086237171130904, 1.8417852055970196, 3.5277156391904727, -0.29726065011871244, -0.37113051410669984, 1.156032189409129},
    {2.267822596981468, 0.8955082611016032, 0.17335841324458362, -0.672818602478308, 0.07874437964664976, -0.5712411518091628, 0.8452726423298215, 0.4403493020950532, 0.7435966596204628, -0.02474694522662801, -0.7789328573946108, 0.7511351093807668, 0.27089434710675553, 0.7743099729144023, -0.26840226862218797, 2.561888295584472, -0.039261483131782626, -0.7331544742197045, -1.219847511643759, -0.4584310620947445, 0.012287663303298106, -2.234357971436403, 0.2481357500890372, -0.7510032135989726, -1.2125556068373027, 1.2478597101702804, -0.7092578975974639, -1.5092615782548893, -1.8107916476996233, 0.6346261682625863, 1.6013072540248312, 0.25534981307570115, 0.5335217057140651, 1.3474029794106865, -0.1304643606155608, -1.035751184227031, 0.06976699322121169, 1.7405283260120872, 0.5178268730983576, 1.660707508798486, -0.23806357180586782, 0.25516835407651317, 0.8384588763006583, -1.5622781562324053, -1.2736639582364477, -1.2424047678218666, -0.06873249736386178, -0.5773802800131534, -2.4570916449068956, -1.8120887849593899, -0.14108137988829497, -0.7717514565945057, -1.0896348570317294, -0.659928335645296, 0.3279588850339938, 0.3496601465411419, -0.9609558895239253, 0.28993784231182035, 0.23348259809600372, -1.0720361532856975, -2.0780252681181035, -0.19377688395548862, -0.16336109796647588, 0.22051418384804572},
    {0.8491485637412508, -2.5143571821082213, 1.3969468504298272, -0.33324043126227476, 0.5091652166048897, -1.2182415912501479, 0.9024195394973391, -0.6462209830159722, 1.7094722750065288, 0.13337807186937548, -0.8859272511535916, -0.17238901798008527, 0.6053418905980259, 1.2403781612796494, 1.0579588417465196, -1.2820302115829332, 0.8005661276566947, 0.18707528682451294, -1.2471048777501832, 0.20827072733869262, 0.9746391313070685, 0.3279594447575213, -0.5301450765360027, 0.6391593170184391, -2.200633854064322, -0.6065262441442292, -0.030037874630572423, -0.666453401067412, -1.1162570376563317, -0.06769252271929731, 0.5646034728569009, -1.5005549767618784, -1.4881892424296068, 0.3461493657206553, -1.131223270078926, -1.3109944585071487, 0.21567218303135183, 0.4108153700289859, 0.17160336530412232, -2.0649750565978424, -0.5138750899148152, 1.7318905847167805, 0.6773173472424513, 2.3784855537586154, -0.3707217143667781, 0.3582194769926994, -0.5933759611232201, -1.381284007874936, 0.5982637783050421, 0.3435839532891691, 0.22225976427864247, -0.8025212711756102, -0.24946998038378948, 0.473351392460979, -1.2527175365294096, -0.8036683704044709, 0.7337426076507282, -0.6871757024819839, 0.4736287948142015, 0.31920946920039567, 0.16303613148375912, -1.18775192995229, 1.0240671114119795, -0.11730764972192774},
    {1.2339441672526215, 0.9565220322858174, 0.8578929427020263, -1.4275406045624022, -0.7427442742381932, -1.2143244885280173, -0.08099105927940058, -2.483921033160118, 0.9216493436269542, 0.46990614366191535, -1.072720733647844, -1.1464418360590933, -0.16660503443103558, -0.9687163814811209, -0.0043658200145923216, 2.1890423241760493, -1.2457889014876693, 0.09949135571285937, 0.3505054341573811, -0.03079506957595003, 1.1330451684010276, 0.4902688396921938, -0.6440063550532368, -0.3362333986224272, 0.25491137043946316, 1.8672636632585757, -0.4035781266579221, 0.10976812324156027, -1.747377050187216, -0.5237313070177934, 0.7821427442413975, -0.4846999226943004, -0.4677322406974299, 0.26192456947465476, 0.6049102376643217, 0.04986595258382631, -2.0972103726328566, 0.32999397242521655, -1.6872547744447273, -0.8955495769165216, 1.9025323362063147, 0.24060615115177333, -1.1806098229523354, -0.8225854920577212, 0.4705607148653873, -2.9957312613610276, -0.7825503154041095, -0.6656421025564466, -0.8906806154177555, -1.2250142446641952, -0.6105550970695279, 0.22176065015707583, -0.41836973831611796, -0.36144988785687804, 0.1984902827117484, 0.014619213565161765, -0.9260462293124753, -0.135903777172469, -0.8483759909677576, 1.150344681645678, 0.17085777156298684, -2.0357778939649998, -1.306097445179911, -0.18433212938931162},
    {0.6431101462215987, 0.24091209047727355, 1.0933113803324954, -0.5627742513706738, 0.8155679298310806, 0.26136386212110124, -0.6172158844963542, 1.348800165426156, 2.0538714009926258, 1.2047589390575317, 0.5532059810877028, -0.5744072601456958, 0.271912731655216, 0.13674959929067954, -0.4086537360998608, 0.6067221927429798, 0.11610354239649633, -0.8988719107036757, -1.3251591051340406, -0.0777699438653287, -0.06740533477639296, 0.7995044824132527, -0.3481636412100316, 0.159341204393424, -0.5208738535510248, -0.44620065017803545, -1.5714497606397526, 0.03512121217456573, 1.5912857791959918, -1.1352760040464587, -0.6828517905396253, 0.13850578707319175, -0.7091947624804968, -0.2614189052703548, -0.7563857496969264, 1.1680947326775803, 0.419321379278461, 0.48588733320472655, 1.9578229194481105, -2.1949103819706313, 0.8665228526100843, -2.0085045051084918, 2.4872147173335755, -0.6727194597940908, -0.3813647870184597, -1.8114188059514806, 0.3738618327796797, -0.9163253041023796, 0.4863377606225148, 0.2820113244218942, 0.9860713259728944, -0.8120025934114252, 1.2722114573405605, 0.5008823253765128, 0.8503105346654062, 2.000623174313995, -1.1462974849674368, -1.4910176146441916, -0.2503406640224095, -0.04446736545371714, 1.167006336784533, 0.7617551783955938, 1.0302667867488389, 0.13242114961952536},
    {-1.4994552639805976, 0.5626995518526619, 1.1683766942425289, -0.36416750147988275, 0.768812873826714, -0.5968710624942414, 0.31276761851459506, -0.6931089424632829, 1.0148286911347149, -0.03863415327153845, 0.34452077294211003, 0.2303324183107155, 1.4345504491885444, 0.7339498308014063, 0.113531869493007, -0.2702766089889426, -0.8826527191586085, 0.7346118027858836, -0.49073918061692917, -0.7602271975047411, -0.5359728506753435, 1.008137088671021, -0.9373597758951615, 1.848638535715047, 1.5612548834853228, -0.21416592836531076, 1.6502340371971136, 0.3384373445565501, 0.004175969013517096, -0.4135394168736585, -3.112170331552536, 0.9461617086644627, 1.785015193878492, -0.18469466619504776, -3.6000193822986777, 0.9337860634657147, 0.8157835081574515, -1.177289150269195, 1.0344795105434164, 0.14238041930006562, -0.9398098059472698, 1.3558299774011477, -2.330349585842636, 0.7085083732728413, 2.631671922990491, 0.9625949417959927, 2.395500181904165, -1.396354727815175, -0.6423219132645713, -0.5325353625310371, 1.4367115820365737, 0.7462549533689179, 0.3181734847095835, -0.42033934930882294, -0.2578314838026648, 0.5616259247362302, -0.9911692172200732, 1.5606416224406832, 2.191820891630536, 0.8085612953072794, -1.5558852789081326, 0.4919509240668037, -1.9830110934118497, -0.1126153715318456},
    {1.7369464817761984, -1.1645414713682287, 0.5550202298251886, -0.5880195706398088, 1.3396054129738018, -0.14289836015460783, 1.411234049875993, -1.351926113471736, 1.7791403815365296, 0.9715872096785734, -1.044126730587277, -0.27690018060040195, -2.007200378343636, 2.3800121377875922, 2.04789726625707, 1.4237068205953218, 1.7980070456819506, 0.8237100233704063, -0.1101760534158768, 0.5540628591131049, 0.5221186071538381, -0.6356439453151572, -1.17280073668433, -0.24974837366695743, 1.68011821588741, 0.18280071573243256, 0.6157513878307335, -0.7913783909587165, 0.14312975151220916, -0.3982511722792223, 0.15730485079422046, -0.8320184735670679, 1.016531221878739, 0.055945486295168864, -0.6935015623941099, 2.259276615718841, -0.1814487684173368, -1.0976652426685687, 0.9647354337125486, -0.5753021521392417, 0.6629075731592429, -1.1319451009083055, 1.8235842875029227, -0.14341655931499997, 1.815541090452323, 0.28453821641799415, 0.5643210077768713, -0.06252185332507865, -0.019132857805115557, 0.26653018606281315, 0.6083273848071689, 1.3009120652981832, 0.45756854314319784, -1.3403426693567504, -0.2684430185720082, 1.0549022322547383, 1.1864093630721255, -0.6525824923758267, -1.6630053341418536, 0.5322720415613933, 1.9683753630178278, 0.9576706564524121, -2.5509499854523283, 0.2542067202818812}
};

static const float b1[64] = {1.3600312116335396, 1.0796955841927243, 2.0618856995334993, 1.7485796405958158, 0.6749109481764726, 2.014281073375107, 1.7743033335866438, 2.023384791209726, 2.4073180478487384, 0.6383998702924799, 1.8257655965630857, 2.1228124947851663, 2.1866015292986805, 2.03565892299055, 1.6150885428527242, 1.1981241491024834, 1.6587736070599401, 2.1421679426142224, 2.0575797543875196, 2.182656360157448, 2.1926737666960814, 2.102079027446194, 1.8934719101458117, 1.7066332540209739, 2.404010116462704, 2.0328696816813445, 0.6375368667895326, 1.8347541499682771, 2.068373376420363, 1.9643731037248338, 1.7235932957357596, 2.164933981690319, 2.148673423578884, 2.1071281149511365, 1.664037410381661, 1.2772838302831937, 1.0353375400591156, 2.014219422197605, 2.0309785135480807, 1.8835532462242355, 2.059517762484793, 2.3458499852401364, 2.49604067466751, 2.342188350609777, 1.9450342705134063, 1.958631833101835, 1.8173030248636453, 2.0238276204439853, 2.0920395576637336, 1.7511212318075295, 1.7657586915022938, 1.9326302243660745, 2.3706697557358942, 2.0808537879753968, 2.0426753317631587, 1.9902260134960472, 2.082929280813069, 2.1710095127391393, 1.7619758438028847, 2.073743842274025, 2.3891050193502004, 1.796078160427822, 2.4725486648541533, 2.239182312868775};

static const float w2[64][32] = {
    {1.9027515939943094, 0.26091817789761146, 0.23499862775564115, 0.6373530617497345, -0.4362942384847048, 0.3473384471051619, 0.589198510485932, 1.1985480606501662, 2.2404197329132383, -0.2837070485867056, 0.10761025357400107, 2.276119208900452, 0.4274259327632641, -1.385021317147965, -0.088391378461591, 1.0407827502449336, 0.36248705712740387, 0.7862344008279439, -0.5809081928956025, 0.027039459275699326, 1.8694964870586293, 0.562143866896331, 1.040482104587229, -1.4217666831844025, 2.1617115303472287, 1.973205627345591, 0.9066804592279036, 0.8014089599345069, 0.8295478713896182, 0.984189196367132, 1.290361722601565, 0.9231248830790835},
    {-0.4925779566564837, 0.3618576997221684, 1.7679277960270274, 0.5075721489420808, 0.6446163554624131, -0.33483981617789693, -1.2340551810392242, 0.2953226569339206, 1.3651041568692435, -0.9048101804830806, -0.526807070210895, 1.3237070843588903, -0.27520141234130135, -0.20950432278198453, -1.8064351231888758, -0.11102072373202702, -1.3869685337742226, 0.5221907442922105, -0.5492534219216059, 2.309292040992747, 0.7847309135209004, -0.09590917853398236, 0.029042926588931647, -0.5641241957953353, 0.8349111583174207, 0.6329842859128647, 1.7848324244231675, 1.672489566310088, 0.37997825399764695, 0.12660438038414895, 1.223642850487166, 1.9420685760218988},
    {2.2707467634930505, -0.37067278988190855, 2.463434625952606, 0.7563873632750634, 3.1061786907414035, 1.077916655608251, 1.710992436958843, 0.7101857441874917, 2.4798091077046194, 0.40691826575953016, 1.672012526255073, 1.4836292896042134, -0.0017942369591011388, -0.0035038426851746536, 1.3584867045209557, -0.3159583922910111, 0.4644951171684848, 1.4128868111862376, 1.1236111865336136, 1.0750468884917501, 2.2871333114532604, 1.3360176283213665, 3.1981370532554116, -0.2374052059927483, -0.7113063476627026, 1.435081690341128, 1.1242702399878803, 1.920337576483716, -0.05036564396882534, 1.4647041599428603, 2.5916166885796263, 1.5207850530113358},
    {0.6131053022305722, -0.8358341011653041, 0.494358504365659, 1.4843612825804327, 0.949259550620124, 0.5484083387821381, 0.03799778527484749, 2.8952165223797524, 0.6437625839743824, -1.0366049278465128, 0.45478506130976787, 2.1723213707762317, -0.2772356042514804, -0.5119942000887188, -0.46414145382165584, 1.4618462463450839, 1.0903511774820704, 1.0454286937867514, 0.004383150193073363, 2.912304376119063, 0.6551523720613608, 2.233076810306147, -0.3251150072921516, -0.5127783675320187, 2.7963453489345493, 2.3365118785738943, 1.4282406855223806, 1.0951042228773509, -0.3384464925837044, 1.2550379381546704, 1.2458872000879229, -0.6392981607755843},
    {1.8080117125680923, 0.9235584573510113, 0.05771106670234639, 1.3859995569758028, 0.9518225681813008, -0.005655954422661057, 0.33588768895402027, 0.44899644926518906, 3.0576492713732124, -1.3363033368336266, -0.4237694015473601, -0.28485957801016804, -0.31217789201750623, -0.7173248981875685, -0.1495902253739525, 0.501101390263197, -0.6132730371579412, 1.3351659654923258, -0.6858950644260368, 1.8032444396780816, 0.7150104968286742, 2.224863744436707, 0.9904791847622268, -0.3513508150221787, 0.7747659729135642, 1.2982246656146286, 0.8557139037579485, 1.544687551634825, -0.49225582735136086, -1.7763628570685657, -0.40134100883536905, -0.006242920783898766},
    {0.33183189007514574, -1.1374577832901152, -0.9067918965926349, 1.6796954692049901, 0.987515974952674, 0.6785200022340528, 0.21994233045724562, 0.7132099203150601, 2.271314577134056, -1.5888768667554536, 0.06934998767393044, 3.6927810965503376, -0.3923564266504174, 1.3154688482319277, 2.0135723177560116, -0.08242316550570378, -0.7509561644367045, 1.9402462813645538, 1.173132429270229, -0.16941718532232458, 2.6041908234443003, 1.0094170656870733, 1.6887325786502796, -0.3765396736167289, 1.930382600719556, 1.8886115704340614, -0.01131131010224084, 0.8078788831761013, 1.0758574977961033, 0.3429779971275786, 1.8363491667660035, 2.157697706334208},
    {0.03271270370965326, -1.21324680008599, -0.41909671531533416, 2.6300713840724703, 2.472195436045365, -0.09886430899017737, 0.5325178070264442, -1.2650826563353799, -0.29383903724387556, 0.707390666248993, 1.2073150920803264, 1.516353886236644, -1.4701971639987652, 0.03378779755126023, 0.2973165049687503, -1.2261156061530298, -1.3548627115879934, 2.2547913133600277, -0.3608488266766089, 1.697509937703645, 1.0394072129229048, 0.11284021187660041, 0.8868164058490154, 0.3981976989794118, 1.807646510425231, 1.8992422017111679, -0.028171749297590667, 0.6160003762126631, 0.7455235271506042, 0.3488899186694051, 0.40865056973438185, 1.77613083319218},
    {-1.1685837373988772, -0.37165111912693455, 2.2151461507834296, 1.8637755186524005, 1.6623374630325447, 0.532247268932579, 0.41638067859380923, 0.07610086663567098, 3.580785400212838, 0.4182530799354278, -1.1785245896039365, 0.6981134156921479, -1.8229425453742636, -0.22139584180205168, 0.5122363826581119, -0.5693352443735774, -0.5151439242187982, 0.08847647000059208, 2.505871277820806, 0.31598511271614227, 4.114397633617336, 2.4957462138988338, -0.24439014788904007, -0.25355550447721836, 1.4061594606639756, 1.5111536798403702, 0.3633878955099485, 1.6048061283566455, -0.8570742503652937, -0.6856127674948235, 0.15157811177391162, 1.767887957110191},
    {-0.4601128370848363, 0.6441797725245513, 2.9913489295055333, -0.5458700744651229, 2.8323518233103435, -0.37997093863976394, -1.7365781997511403, 0.11895576365160582, 1.3269245590551464, 0.9635893246780021, 0.3308931664089178, 2.8417707520369366, 0.8890457745687693, -1.1850814755242312, 0.38003764019315633, -0.6705398417728912, 0.12722440964219628, 1.800967284750049, -0.430999189730701, 1.1207833494015935, 1.4200385236869957, 1.1325639173477247, 0.9147532515239739, 0.34097576183623973, 1.878522652707225, 1.7516569740448795, -0.898731162798034, 1.5650510669077562, -0.6864074753482233, 1.5243230778360806, 1.036000379914087, 3.409486580154987},
    {1.0999216317058602, -1.0210970864813806, 2.303788726315619, 0.7107808551642265, 0.014253877037339383, 0.4386508316745977, -1.2894377666696075, 1.7128732128950137, 1.5400948178587748, 0.3099265297738147, 0.8743502225539139, -0.8665183745855843, -0.054238660125158475, 0.3838340725963405, -0.16407908385091466, 1.2364150729281882, -0.43554118613030246, 0.9145204204806157, 0.38618309857045896, 2.1574797894944284, 0.2541805873257709, 0.7223730978217764, 1.1083392087521953, 1.029811058105797, 3.464266695081469, 0.32479948499307354, 1.3489670112517478, 2.249984812686809, 0.5921613379259851, 2.673982280083166, 1.3201977231390076, -0.31084235147043776},
    {0.6428127155327087, 0.06578618040878388, 3.161787471480128, 1.048847205539531, 1.0542276700805757, 0.5653490891827255, -0.44907378734810743, 1.6037068410013566, 1.2578782331069829, -0.9950631856206341, 0.6387674960730023, 0.8578093575588784, 1.2067614405335567, 0.42649378113080944, -0.16893055947083174, -0.02687308370543418, -0.38725602907347534, 2.422752216719806, -0.7688011873932973, -0.22399847498012979, 1.9112830806234147, 0.88089063685552, 1.5159948787420763, -1.811908481473563, 1.8878922461282734, 1.957372995754652, -0.12822707321727977, 0.5799138238116853, -2.329024948606469, 1.255900813442916, 2.0290047375224303, 1.2671713321952822},
    {-1.7722757274136516, -1.1384302303032774, 1.900832684054606, 0.9913215996196364, 3.1540324956136416, 1.2356942450356794, -1.2108184105914495, 1.78448219791584, 1.8482065176619198, 0.13209335110342177, 1.8796250504663934, 0.9921502047968641, -0.780593017605034, -0.06376199552959257, -1.9927747253296306, 1.3740878137009978, -0.3659222324131537, -0.14853027324101334, 0.6902946603765561, 2.1547329849098764, -0.9755225492982522, 0.24649122127144854, 1.10954099510357, -0.4418450037825583, 2.882577279115205, 1.63044069133738, 1.0483669771811162, 1.4822108993952778, 0.5399749039613472, 1.8176298272097038, 1.4180967396662374, 0.7217492464761722},
    {0.7526228546503926, 0.025037356526893487, 1.0681889446968145, 1.6302213273265707, 2.2571916556954363, 0.7351477038421097, 0.8739970075948581, -0.13694245023741758, 2.117472869589438, -0.6215774225574219, 1.6052068443728713, 1.410193997592437, 0.27628602197914864, -3.1984858041756734, -1.1379672186494088, 0.24835537148124925, 1.299114229659482, 0.17384747674968565, 0.2976674011099358, 1.8203046888858394, 1.4925016779941576, 1.2614193028037706, 2.2306483833054487, -0.7389506494896868, 1.1233914616658822, 1.2782324390817692, -1.2236528847667973, 0.9421906099601512, -0.10747437624144424, 1.522529399627608, 1.2281336512425551, 1.3943409755413745},
    {-0.2927986094494322, 0.6374863959548263, 1.6951105588853554, 0.042012500120973746, 2.916857355486614, 0.4354338909080445, 0.005425910452535516, 1.6314479561877722, 0.5083656333435141, -0.6026181583005644, 1.1754463272974287, 0.6407932067113294, -1.3134069836691957, -1.2674432274889804, -0.8417382823132132, -0.3837909517674536, -1.3443467733877916, -0.3600445129802381, -1.5619138743497791, 3.033466858523296, 1.4077378342819253, 2.0642964156032306, 2.2682566797602277, -0.8243656023725455, 0.8256528762842399, 2.536315224167778, -0.10325660226938554, 0.6750219673074703, 0.18585893690390254, 1.0396800478700488, 1.0183309875843058, 2.300171416262199},
    {0.2886113702149551, 0.039134588176800184, 1.2943333278942621, 1.0716461743574595, 0.009112359767287035, 2.2595764394974722, -0.5487900821715453, 1.1178472755191762, 1.75130373935057, -0.36954169232003986, 1.9094612053033178, 2.9635724244566313, -1.09971021578193, -0.7175291848997537, 0.012220054630140595, -0.20285266128833326, -0.5192413868948718, 1.5531415417285603, 1.664967336320784, 2.347687040127681, 0.9308308380769584, 1.35029164388917, 1.1485830492497342, 0.47289660906599984, 0.661737820823666, 2.4706081268652134, 0.3406053182445652, 1.3324625057646229, -1.2603854459318584, 0.33999439157817785, 2.194063315063732, 2.073351491294034},
    {0.9964364550648847, -0.38085561173735555, 2.1998566824158123, -0.26799900099104346, 1.8829392677990724, 1.7283894842484617, -0.1503341906790011, 1.2250359245955627, 0.06387249014787955, -1.0748454240123533, 0.901634265048362, 1.2565416195435117, 1.489939289418586, -0.21272557620265103, -2.2284701077005122, -0.6759625343828971, -0.7897480013464369, 2.358605469987315, 0.9817193892641772, -0.12199391528459713, 0.6486114979555019, 0.3041683115763098, 1.443310441707579, -0.19179421252168782, 3.1252728075665006, 1.4325818638519658, -2.1721483540905195, -0.25345822707698534, 0.715185450065764, -0.482786235802361, -1.425724162153716, 0.3865601841091073},
    {2.5325650269271702, 0.30945325857877287, 2.398357511233158, 2.0311863895347946, 2.748581456481642, 3.789524138457913, -0.13242996137393587, 2.554245784254071, 1.540460275159013, -1.568898951815935, 0.6200188054770523, 0.574542974933987, 1.3890480383942798, 0.19041175308570013, 1.457292322092576, -0.6729801643501552, -1.3664422826525648, 0.6916930455011638, -1.4392893159474602, 0.4682793235094609, 0.788225734775231, 0.6407467635864516, 2.340174773435114, -0.7708063767418635, 1.540566417494041, 0.032953704433722045, 0.7871954358588102, 1.1187666144987736, -0.488090183105801, 1.602809054409916, 1.5405662053416158, 1.3926237497659317},
    {1.3580084779167185, -1.0499768414091935, 0.30180902037342805, 1.8811808624482729, 2.904033736839969, 0.30278874044358367, 0.9934271695918113, 0.8540744029199822, 2.413116648651181, -1.095989055183428, 0.44978403587883603, -1.4935045220243062, -0.3855157489992456, 0.32485374944202955, -0.614333088958961, -1.2181090441233582, 1.9095239208165533, 1.374289920115985, -0.9995175864370373, -0.8679637787615124, 2.1134038593588405, 1.0158334237658346, 2.240012584866045, -1.1095232571880809, 2.986122395506245, 0.8816680742619999, 0.2302559326263134, 0.08798223102309376, -2.8856804040708552, 0.7170735043814519, 2.7025052111446826, 3.091776131817112},
    {-0.08297357947975234, 0.25281786910295956, 0.6873195380629084, 2.5965334545097765, 4.2534438691722976, -0.4636701054498636, -0.274243290085509, 1.9508342475513096, 0.015550744804909089, -0.6071530362505044, -1.481907578927171, 0.595192395892273, -1.5672065495014353, -1.3814975957437647, -0.2665994272747693, -0.10933260228867504, -1.0674650276171083, 0.694741300164122, -1.4204288127557798, 1.8505285301438221, 1.8842746110050042, 2.477955342050301, 1.4769701095091199, -0.060002730815707075, 1.8071900318419907, 2.308045729310686, 0.09737488199843142, 0.5426492511206583, 0.9327172877410531, 2.3950428359806004, 1.9775943236209679, 2.3840877174838573},
    {0.4038911042712065, -0.23590851405167335, 1.0155672206685342, 1.1890223655910572, 1.5430029407679482, 0.5591450509246558, 0.03019190152581437, -0.01688429574256133, 0.7167471877188921, 0.7708007115109684, -0.056108552061442274, 1.5252991126577473, -1.702852955373951, -0.6080711804430657, 0.3116211392903042, -0.484515045708912, -0.3333514212963124, 1.3552030344990138, -0.8619235256937704, 2.658845292399564, 0.9830747437698114, 1.009131461654956, -0.10359376219585349, -1.6301013995913733, 1.1562249139688763, 0.7574642229255414, 0.363764665200973, 1.108784556120035, -1.093330702470146, 2.950770134187611, 2.6819115832024454, 2.676241129494952},
    {1.6828319876611764, 0.9650383310739726, 0.5345303588401458, -0.5590671841236898, 3.9106221552014038, 2.3410427398125107, 0.8983178145438836, 0.22880407496362637, 3.229611072732251, 1.2369041083462164, -0.772485789914169, 0.7740484234367041, -1.0088057550661604, -1.556576279750561, -1.550327409214277, -0.5266195442081066, 0.01912661835251717, 1.274523932063132, 0.10139875768260995, 0.11833707798376394, 2.178485812923421, 1.5254267812944646, 3.0461461194149337, 1.355477650546477, 0.6167950316486109, 0.6630244141317682, 1.7271794429880651, 0.5915079171737742, 0.11910327184075019, 3.298100962671574, 1.1733352667866699, 1.7948376078131223},
    {-0.9205936044669273, -2.471819862531639, 2.4078538396814264, 2.2054618500849883, 3.7454872278409077, 0.7251265799320893, -0.6353836754209885, -0.9745783336534855, 0.6824228734684638, 0.3763375206668133, 0.5217411577772595, 3.982246495891501, -0.9859564816354592, -1.4161695183401535, -0.3567683182835813, -0.7944133804888174, -1.4083793405252145, 2.161574917422851, -0.4254677880715021, 0.14331960575158115, 0.8517787628741529, 0.9564103231950645, 1.3038888990931652, 1.8759082514124492, -0.09672655557616618, -0.02979603707423547, 2.273398042361055, 2.9015524077459416, 0.14152706856257252, 2.4373080661703477, 2.386588474288871, 0.7740398305204942},
    {0.19596439632783813, 0.49323022071106726, 1.7766100887042682, 0.4763708824202716, 2.7108591878305823, 1.5674399872606792, 0.8986446801874053, 2.3105298926568265, 0.8713890568882086, -2.879301851958227, 0.840110419929563, 1.230974700004444, -1.3702428636286892, 0.7829810429535168, -0.4522200866341167, -0.7196258722881883, -0.9771885636869306, -0.10910100178147324, -0.07071804617914934, 0.2909220554612932, 2.236482425821445, -0.6881364920588482, -0.043808015990108896, -0.8870696338881069, 0.9109844832813869, 1.552397754360019, 0.5442945795708749, -0.04248490144465227, 0.03717023619141705, 1.236611203480297, 0.5927677993039334, 1.1749115318047338},
    {1.5476413622384648, -0.3360157089356231, 1.1776366190112004, 2.516550133700985, 1.8266185303404936, -0.042713167720649516, -1.208392576922142, 1.168595525305249, 0.8725126499413282, 0.35937208082933025, 0.9009586401162795, 0.22258281859609383, -1.1179963693708588, -1.0485174213587343, -1.200952618318298, -0.45174712180399007, -0.25570952220832194, 1.960092980625705, -0.8342519542564082, 2.2307551652209225, 1.0142229592255632, -1.6750361566115357, 2.7906692242200997, -0.9741765292551378, 2.03173338997493, 0.6754893464602606, -1.401851329304134, 0.4974462277230271, -0.979113508354968, 2.0637742126289016, 1.2305815932315423, 2.1501980867154487},
    {-2.0335298215296738, -0.8547368918558458, 0.7309508212434345, 1.3141911454601407, 2.7309691282598743, -1.089766446875219, 0.6550690205509013, -0.710949984261125, 3.1551520221211256, -0.7520996345935742, 0.6649318010530498, 2.1392126269441762, 0.5639207765954912, -1.060704636425626, -0.8614265179977056, -1.6034785767734068, -0.22721387256554296, 1.9194608799731396, -1.9646569328950452, 1.474913826137959, -0.2744573236570061, 0.7304909190783662, 1.3745442638010656, 0.3802638882430761, 1.7495429203312027, 1.5146903364500577, 0.2536662745958133, 0.5904953980875953, 0.5133029349483621, 1.3243645768559436, 1.786097016293485, 0.7349169619851708},
    {-0.9293651719294418, -1.1900754366084283, 3.449974403268888, 1.1060192368792843, 4.04449845619836, 0.6505536369220893, -0.2224162916381932, 1.8397400506210468, 2.166017356417857, -1.093552217293886, 1.9030010501723515, -0.4878668382748233, 0.029312244883846903, 0.03252410381537561, -0.51209387624366, -0.4074612322924413, 0.7382093555040607, 1.6332995497708864, 0.8596772181912199, 1.5577236437068163, 1.1842289234027001, 1.4818371530600445, 1.3810247760887577, -0.6139770513252536, 0.9859197344104798, 0.4103861745528694, 0.4379209149396401, -0.5795605921898738, -2.0449814750073037, 1.2668821315995753, 2.2013504878286096, 1.5639642607544686},
    {1.4394705846401281, 2.5343560499436015, 3.1165418361957826, 1.8609600515415314, -0.11250311152241145, 2.2462865646191648, 0.39132453015191626, 0.8548465469648576, 1.181841752303791, -0.5375864104899122, 0.6898892246678857, 1.898987163066375, 0.25146177100662104, -1.3153857129995024, -2.5121063455421577, -0.37601482573506695, -0.9830822221436539, 2.03125931470645, -0.25939710523373444, 0.7501811125545367, 0.6944559749426547, 0.5496389856341893, 0.48375790404055163, 0.34358305985561455, 0.6577137528534649, 0.583543094752214, -0.7231297663528033, -0.28416045207094737, 0.8612136705845319, 0.4905222166481728, 1.0568407142952503, 0.09547774802690343},
    {2.2873151376520005, -0.9041363999882874, 0.09062238154197015, 0.7940763893211554, 2.8687383731243092, 2.2709585414139934, -2.302219014538061, 1.4814414246293928, 1.4203093651496412, 1.3800181964562304, 2.257274641528997, 0.555222835777548, -0.17872745479206484, 0.24089056537849382, -0.005151574001797452, 0.5061235739859509, 0.9724097007438014, 3.3129496422723688, 0.7118403254344788, 0.5782429609206883, 2.53954799113619, 2.1714646073987702, 1.0645498303048757, -0.23453641742690676, 0.5977627339191277, 1.4487535369630389, 2.178886407254948, 1.1936656325846504, -0.7797973622824871, 0.39465087397058907, 1.8558973325674637, 2.5270858517118753},
    {-1.292049929405989, -1.2771464991576356, 2.2939976983400365, 3.395559051541513, 3.4641807450847057, -0.4427793927795648, -0.009916382609169277, 2.4626530576330965, 1.0777109820216115, -2.2339089350865375, 1.8953540706959173, 2.1996156897490824, 0.14975632692283022, -1.210093920420949, 0.12198497492318087, -1.8297234658267667, -0.6959161235440077, 1.1886726174222804, -1.4243891762323515, 2.416702848932611, -0.15984824984791515, 0.6395259845311136, 0.8022442265427321, 0.47823858171665107, 2.2601213235088418, -1.165711881653274, 2.0206337452242935, 3.501963776011616, -0.18976223656400992, -0.6076911122854042, 1.9996131366722436, 0.17044348417588065},
    {0.23720026073751155, -1.4368234632135484, 2.648263577215037, 0.7587643638999448, -0.0627053697683885, 2.039686315319837, -1.4592341843491285, 1.3159934902576444, 0.9021723443623354, -1.3076911342107354, 0.4681069413523016, 2.4056210951902988, -0.3732070724104953, 0.42790693932040463, 0.010911767719591601, 0.036062930426637343, -1.4756117252964724, 2.0535834394733063, -1.1809546523763117, 0.6038040432897078, 2.7353548458962895, 1.8668307773647734, 1.034306945818177, -1.2499859945847518, 2.566080973168262, 2.898106845952886, 1.5341129756246095, 1.221985553507674, 0.6730778367079855, 2.5279032930450582, 2.249059049872897, 1.8276381072627388},
    {0.9091500978276912, -0.5094551592447463, 0.4465682536066165, 0.9801820550314377, 0.5852731793068163, 2.329839409562959, 1.4559920667393933, 0.8081673327758756, 3.6802912019895375, 0.3955597162495042, 1.2273708334117088, 1.7828483459299411, -0.966111363321367, 1.4099906665258284, -0.608414708809101, -2.1275867116400513, -0.08539396178853596, 1.3491736291443535, -0.3933251581207448, 1.5896309278336482, 0.8427620237668119, 2.2952061562357087, 1.8581601482215897, 0.08100380983235188, 0.8266276966151223, 1.1602325823487025, 1.8116880938916744, 1.3034642597010435, -0.16013940645196048, 2.92669357073254, -0.3300852848046507, 1.0302572467840583},
    {0.21244938113756412, 0.6893604004882116, 1.619101888887496, 0.10311652644291977, 2.808471349863637, 1.1696082842546238, 0.24573507390026406, 1.548703228172676, 1.7634203588956354, 0.16591011828080374, 1.2962903460090078, 0.8268669769357339, -0.8666016930783339, -0.17290326859676758, -3.249981831273435, -0.9904165804973262, 0.6195908942580893, 1.4844959657381978, -1.078189215219133, -0.4449531889918104, 1.4985334633506846, 2.154079631153577, 0.35502130799169557, 0.5304161711979193, 2.276529602249618, 1.2558978647434298, -0.7576991759304337, 1.808235932919665, 0.8518339177416491, 0.8582666062940865, 3.0285233450625846, 0.9185523451919761},
    {-0.4065386896943948, 0.168519710066345, 1.2753262111649795, 1.6867820065243107, 1.741704049169661, 2.1226633829305204, -0.40784927619195993, -0.5337138072645687, 2.7057190885047997, -1.0110522933145365, 0.583697573668673, 2.688998012976432, -0.6183098950760354, 2.819530228556139, -0.6432968970516578, -0.1596926122040714, -0.8251839644922263, 3.6008806804381353, 0.7552442837086685, 3.3172830623989125, 0.9439651513750511, 1.5374202068091551, 1.2458264566329822, -1.502025566751769, 1.116690531107239, 0.6896019594510938, 0.4751851602392597, 1.9127112646232176, -0.9773203081163807, 0.6799401091416521, 1.9696660639352013, 0.3399069882653679},
    {-0.37641317300227967, 0.4798542473908796, 1.637226512158397, 1.6645938429839964, 3.112883236984187, 1.3873210490290564, 0.08344628926129305, 0.430091756074472, 3.5869623881655333, 0.2832029228910985, -0.6072844713290065, 1.4268119716751408, 0.7234992172445305, -0.1007689748629162, -2.1883629979240133, 1.161094851966005, -1.08405726901749, -0.29377686061111896, -0.32395202750252716, 1.241988148781858, 1.3629766931780534, 1.8597198527973966, 2.1072593874295857, 0.8892948884254349, 2.067331533206893, 1.543429392899479, -1.7839336462229156, 0.09133873126586824, -0.612350788849232, 0.2559334564437529, 2.148439682798782, 2.054401162484587},
    {-0.682173110070717, -1.2361899403434966, 1.6416512321519519, 1.2834463717939888, 0.9905863831916031, 2.602159409811176, 0.7836331343374576, 2.244020212744153, 1.6796688193038902, 0.24069398290449823, -0.38390695073238423, 1.3558091650157897, -0.7548261794595497, -1.2979026669457743, -0.6940041828940025, -1.075785844275457, 0.03148073139418003, 3.244086149420095, 0.026661587109659848, 0.6973092482967498, 2.2471675566385496, 1.0648674396920739, 3.48550760290901, -1.4449045540102816, 1.4531879426347354, -0.957439950864644, 2.765212194024228, 0.4498353674275375, 0.43222404595459746, 2.5344197555118004, 1.1456558870925877, 3.1606704020078014},
    {0.07225760353109029, -0.8883138807783437, 3.017362854633526, 2.0642578724865297, 1.6121077151292407, 1.5074018448618218, 0.6613549193399886, 0.6985793896587877, 0.7560131935317449, -0.6162530992235318, 0.13675479769018056, 0.08084821334307624, 0.4835726535699057, -1.3731468105258622, 1.003596610841255, 1.8114198549359046, 0.766436202963059, 1.88783613942446, -2.3494551648293767, 0.001492581347595456, 2.3053083588727477, 0.1945823210970533, -0.9652010380828133, -0.14586095412716713, 0.9536831714077164, 1.8465778624842621, 1.5248442857862616, 0.358836026329993, 2.5896916005288353, 2.8249901292197572, 1.9094865257632216, 2.213595543658896},
    {2.0022903087397435, -1.3200318795951453, 1.4753832574972223, 1.2813152635573588, -1.708552560842085, 2.284771645293529, 0.5426372231633527, 1.4108536045913334, 0.6543850548441154, 0.035627544709647116, 0.7220587370872572, 1.9059798870239906, -1.387592581829064, 0.2648690137552374, -0.6676390304155485, 0.32571346265902157, -0.08945425031006858, 0.8580115059598993, -0.5322044650475586, 2.1056985591908286, 1.1904383524571953, 2.226223833199515, 1.9541007051614006, 0.779068492723003, 3.39678107375725, 0.9438612072485912, -0.7095721866905171, 0.8663000198860187, -0.5785734989771673, 1.2566535294751284, 1.7427236464376021, 0.8137678415707047},
    {0.5436752705935203, 0.8189321337230043, 1.2108780742267764, 1.4039289251419365, 1.8595950536656383, 2.2184204742354328, -0.9989003109148261, 1.7446180204984765, 1.256832016058285, -0.25860939588136267, 0.5971845265971324, 1.6944241224273267, 1.1917029822959457, 1.6720415890939229, -0.7844445641207836, -0.5148482982741626, 0.7126814529004991, 1.1907845341934942, -0.7776007118027386, 3.0301108530408274, 1.5425806714858927, 2.626024395799115, 1.2557377297958878, -0.13740836753165914, 3.5422410754391636, 2.00049878080702, -1.2521198194836156, 0.3253230599381637, 0.33148381371349817, 3.1987323994277777, 2.4035215534422116, 0.673606247679981},
    {-0.34628055148169723, 0.10282753116701754, 1.159776682879403, 0.5240738415830013, 1.3321487195618034, 1.6359127936458406, -0.7200681941617773, 0.7294096526078353, 0.9300005148686956, -0.20981031848158208, -0.8238911824355508, 0.5320301143781878, -0.24656943552828375, 0.1504772229350994, -0.9158274746147728, -1.030919360950242, 1.1493558123744705, 1.152853275602575, -0.8758414359626392, 2.9111824914963935, 2.239651817107922, 0.13987404764011538, 0.7835823766694117, 1.116542148179263, 3.068173250818581, 1.335982480386897, 0.8860778301066385, 1.035960673295434, -2.0258610052709702, 1.2509827797337023, 2.16701849639815, 1.83693109183363},
    {0.8818477764311675, 0.059248047987739125, 0.9562941774306385, 0.46357572971058314, 1.4561323778070618, -0.06917605739940606, -1.0839019139675834, 0.7642882183393498, 1.5627952656148163, -0.5844830237164226, 0.851469877620548, 2.358519159770528, 0.9913058400650974, -0.004128484947490539, -0.37497785319270266, 0.005893802695527048, 0.055519039983936064, 0.27895601840415934, 0.31714733955974, 3.831603977160484, -1.6273253268420154, 1.6444160024366177, 0.8876786301161461, -0.9841450833968548, 1.011364851782195, 0.7548713120165973, 2.0257300813576986, -0.11108912243922936, 0.47656371577685414, 0.9824986425060945, 2.5452155488296633, 1.2947974514036351},
    {0.5488355057219381, -0.7755318659227546, 2.6054440588056584, 0.17559740524899897, 2.6882490468839664, 1.9180184013338395, 0.6458526262546902, 0.7404557581549468, 0.5026379324445188, -1.8859636031101241, 2.001748097943144, 2.399383599262848, 1.0703803259525384, -0.9593131591439612, -1.1760263446078187, -0.43603591752761583, 0.9630997602348813, -0.015852027363019133, 0.48686829280029403, 2.898882183046288, -0.5422732398106358, 0.7373255014487016, 0.6538222203075048, -1.832747175971466, 0.9446382297906359, 1.2017497075193133, 1.0147314368449238, 2.289408539635153, -0.8943079228242308, -0.2916016175905028, 1.3045529584661615, 1.9467422104210883},
    {0.8911703329051224, 1.1858487019721786, 2.4975833579712843, 0.5167970936239259, 2.185466331693243, 0.19894066476591668, -0.16211071009603734, 0.5842883248762705, 2.820217125282772, 0.2545399763493932, -0.15796416917019548, 2.821298260119757, 0.8418514307014389, 0.223551815318263, -0.3887502200571313, -1.4982473159553276, -1.9836809647170566, 1.1472027076406641, -2.2300155285463523, 1.7361050449906432, 1.6528480127308327, 1.7386660676488548, 1.7276336465748598, -1.5355185113550693, 1.570861026092519, 1.7383777998418188, -0.21876618693426184, -0.9477660674414458, 0.4199588178541322, -0.6956067148930922, 1.2979081109037307, 2.3994926861646486},
    {0.2853324106506293, -1.9962334087467561, 1.1476697638776898, 0.273119663992696, 3.342814499474129, 0.6399587546244854, -0.08727044199105767, 0.5723262821245679, 2.4331623193285776, -0.1579381941525784, 0.7820143878121001, 2.977547873650088, -1.593649190071466, 0.604203331975534, 0.03597202195663314, 1.2168528382049382, 0.19660684150201513, 1.750812344880657, -0.9565821139691324, 0.8894507087691705, 1.145235393229422, -0.0014703439097537038, 1.9451646082177658, -0.7833171060193709, 2.4012051919007917, 0.5457236497222954, 0.5020028389160056, -0.005450302525875238, -1.476432862363084, 1.96834212446655, 2.5364671019979745, -0.3786238560615288},
    {1.0117864981404463, -1.6560954515979578, 2.55942489593224, 1.321352346954189, 2.2835837956240432, -1.0520199304744586, -0.5481781342889421, -0.7465537194247978, 2.4968805826421314, 0.11454339502940025, 0.35396109201176396, 2.2891629334483334, -1.6155354250512546, -0.6937198524606886, 1.193347514343175, -2.3670849059262156, 0.18378648028423564, 1.605981294386381, -0.4675895964221792, 1.2299152539281708, 1.7707604832931878, 0.4493945917772295, 0.6982806075843984, 0.349570010480541, 0.7817273229644086, 1.4376178618760929, -0.27402655436474027, 0.5387316870312362, 1.6378101002200822, 2.154790190661678, 0.39315198801478124, 2.8520649706480476},
    {1.313043129162366, -0.8033536811526012, 1.8047734891301879, 0.1574543741003335, 1.9433902177804225, 1.4804887316166369, -1.7875675805226554, 1.9773778247300127, 2.036235939974274, -1.278431939419468, 2.0109179375541117, 0.5306034148767264, -0.5943235445032367, -0.9816703725927389, 1.0178575088393969, 1.0321732927469134, -0.09518222306963273, 0.6187887975271216, 1.044898629781402, 2.063350935046965, 2.4559028388324693, 0.521203870765738, -0.21520633520119387, 0.7504429692455324, 2.9711216370049987, 0.15391928830127066, -0.3661059968241256, 3.186147909935359, -0.14055462243161984, 1.4151040387113512, 0.07219199971232738, 1.3268594941322178},
    {1.2911397730033358, -0.6894689151774552, 1.0051078247972345, -1.217083481872848, 2.013671254611338, 1.267781328250674, -0.5739133798692915, 1.8409355545268815, 2.4941825901561474, 0.5296488164635575, 0.028051178879564227, 0.48928517542816435, 0.9778607378484796, -0.21346134776267975, -0.19025105852200505, -0.6536777432811399, -1.4781409220048287, 0.7355778770254567, 0.632643243393288, 1.7953008328929554, 1.9491557636633037, 0.21986131722794963, 2.018821182137891, 0.22991854576974377, 2.331852775910204, 2.9980167529234354, 2.151551612808852, 3.221890031886098, 1.0605574957233312, 0.35989823212581523, 2.245825073043086, 1.1591251558295181},
    {-0.700509635172421, -1.1166045372709728, 1.7150672788496373, 1.3810707373178026, 0.4421310718820568, 0.8188503284246589, -0.32149972281604594, 1.1848131939789586, 2.1134231986211534, -1.8402121953963593, -1.526705208051109, 2.692176342295789, -0.22036274078808837, 0.38965901803925385, -0.6237013719494519, -1.1953132523679726, -0.5321963068698383, -0.030546722081126798, 0.9734804215016614, 2.0102615848196024, 0.7175144140207018, -0.24242776559977494, 1.0560592804725595, -0.6950087917377898, 0.5306163030606303, 0.638171268112502, 2.2680686397985954, -0.4669975056785156, -0.8356107884391211, 2.756876407255397, 2.110489293470842, 2.9555910810363475},
    {0.887977317556747, 1.9247971625567801, 3.4033130436399293, 1.9582011870795244, -0.3015846726138905, 1.2855013859284536, 0.4716281682630578, 2.7533544014664546, 3.0176196941759423, -0.651763967885176, 0.3168843044094523, 2.5347833358998875, -1.0907861297852275, 0.5711448951653308, 0.9229190188384893, 0.8537802685009409, -0.7989955999573315, 1.2831319402883612, -0.7148818587002794, 3.7665656746733496, 3.1080164644897565, 2.127255001663021, -0.05486366398365594, -0.05951095641056154, 2.8874556449950375, 0.45399293052298145, 1.891821100846199, 0.6879968689423289, -0.8402148845418754, 2.016647819241962, 3.65558664639355, 2.1361141987244667},
    {0.5887073126590717, 0.19570854473137714, 2.593297159684362, 1.8401517437374326, 1.3808957911226587, -0.9633007623932223, -1.901896807421155, 0.1963685847901508, 0.5018157134238647, -0.2833451771204309, 1.975156360854275, 3.01011154542197, 0.43305929348016786, -0.506031903225325, -1.1224941652648044, -0.5580615286523363, -1.7438154852773184, 0.9181436611664551, -0.8333225844979648, 1.2750003402082764, 2.912218429432164, 0.6456813019480441, 0.7257976272446574, 0.7520594456643639, 1.068952893751514, 1.151628813716417, 0.2994436334608234, -0.04583723698978328, -0.2822414600877181, 2.1398542393695643, 2.0995977035005935, -0.8397222956170503},
    {0.37863805828151187, 0.14561429105662924, 1.7714414189279204, 1.7632536246985664, 1.3097102472593205, -0.023387918582086494, 0.8057251056104893, 0.4951587429379527, 2.843616975811828, 0.9783566377298059, 0.8439025890813866, 1.023112215350857, 0.25979364331493027, 1.2004585493464297, -0.28076536243531336, 1.4094337336708203, -0.8474526150689727, -0.7096319306298404, -2.0039538293785757, 1.1635305450231075, 0.31083603076809957, 1.8528623195117575, -0.33821457637401975, -0.07894502851223652, 1.9413579921220645, 1.1356187373218187, 2.295055141803523, 0.24972288314811106, -0.16155383836218165, 0.7753334328463574, 0.5337594320213611, 2.4071513242043534},
    {2.463290297317484, 1.3409970127327542, -0.6243232094871803, 1.6508194256933557, 0.12129592170641217, 2.0049966371205246, -1.2298612658182506, 0.9102934328433665, 3.0605401489933053, 0.2663116218450836, 0.7907029877651163, 2.552702505614635, 0.23230110813970972, 0.9254497319691779, -0.08925270474223908, -1.4898168929870812, -0.45310536943053825, 2.6518878724577557, -1.2278006018184509, -0.10092340546879619, 0.4452648469149599, -0.13242557124034166, 3.585980993461294, -1.0468605542109275, 2.2283128057722057, 1.1153138676043215, 0.16619127228765093, 0.465270726340468, -1.0178697180289118, 2.126230033681173, 1.1600015755001345, 3.2111018060067966},
    {0.7225428828140068, 0.08555580110089916, 0.7605487052540805, 1.2659055097385257, 1.7084186086790476, 1.9018262485378425, -0.35972192104398715, 1.0831958992521233, 0.6661191710278508, -0.8486952894677429, 2.061065991672561, 3.9592581947573047, -2.393929766161518, 1.071834463362367, -0.11597315688527768, -1.0503760170796794, -1.2293446147415836, -1.0681257933336255, 2.1395230660411064, 0.656980917281391, 1.5919801270536054, 0.05221097478323436, 2.5912828275912876, 0.973283662088629, 1.5137378338937497, 2.819647588789515, -0.23111440597799912, 1.2544122451368982, -0.9114386729979257, 1.1827755199586631, 2.228144297520206, -0.6716233593895444},
    {0.335832675747301, -3.182834179094291, 2.567129578586752, 2.2799737434822376, 2.058422709026238, 1.0639418408605907, -1.754111336423757, 0.21730740089247222, 1.559665395677006, 0.9574914469050575, 1.121258246480301, 1.6471850928293028, -1.1800533898586236, -0.5107307595319317, -0.0804677552595861, 0.29788691514026805, 0.10447678850365931, 3.361481638724775, -0.9071691484567483, 2.216921438072921, 2.794208650150977, -0.35050718925030416, 2.1767399892746586, -0.498576422802902, 4.098552647978881, 1.994181579279946, 0.30689443531691324, 0.02955882481690309, -2.0780352490895537, 0.6928794653745672, 3.0367134807280114, 2.2837695499279604},
    {0.42383186599724915, -0.42195263153590146, 2.84653605330604, -0.34884773660335555, 2.5599589880398654, 1.1382902700939632, -2.1003862718791737, 1.4333981555102886, -0.1144022937468955, -0.7158067491945613, 0.24568767026412616, 0.8983422086342976, -0.6682959156184021, -0.22351024666277752, -0.3157231312242888, -0.917055810777568, -1.4876978056106243, 1.7558983788457163, -0.12789439895543228, 1.6166497171629295, 3.3156047075551283, 2.90684837199367, 1.5346246785484705, 0.41777548467908154, 1.744114400423847, 0.08113491063200183, 0.8961546034100698, 0.2816505721619764, -0.2898984496582396, 2.3266977233797896, 1.8927199545367202, -0.7394276493150753},
    {1.13514908455155, -0.8290382868267675, 1.1907996865646413, 2.468859863531507, 1.6292100300633074, 0.6847980063937892, -0.19226157177230085, 0.04345446122014467, 2.605632688050015, -2.3389956082068357, 2.2421854121998983, 2.231858566396526, -0.4571962734517632, -2.747683590174913, 0.13001991380683045, -0.2688419793148522, -0.8656621936982177, 3.021292748127023, -0.861572037054887, 1.4453892491783982, 0.1870814062861978, -0.11566955325889572, 2.393927411924221, -0.04392769466621931, 1.3351615206339524, 2.710108105060343, 1.702848180976584, 2.7243105234902605, 0.23544705276010797, 1.4338983501182816, 0.7506101078610816, 0.4941230448879249},
    {1.5856501190610786, -0.08611785673658828, 1.0263381395788231, 3.039364869407881, 0.9225047640635022, 1.305255682066006, -0.585222255014929, -0.4407468105744337, 1.6348861149063505, 0.9558532447919893, 1.2357377570965098, 3.7344682086227663, 0.13611639545798648, -0.2542031902705423, 0.37112869811849747, -0.8033626015892941, -0.6135035324703219, 2.5905402819812426, -0.3306967060058426, 1.7997518353319604, 1.8421524928678497, 1.1730434519917956, 0.3781560338553973, -0.024120173336230906, 1.9831291565598677, 0.08633628110612881, 2.541333419556127, -0.47617053520098973, 0.7228380051398418, 2.0604538494162306, 1.0340909091161725, 3.469622331946174},
    {-1.1786209884220664, -0.47512196911730475, 0.5922279970354557, 2.3600094209520392, 2.8668076641524447, 2.20028353937013, -1.0230659718714128, 1.172406406973513, 1.0333131893797696, 0.525195979977929, 1.6891318751131426, 2.6417642800137937, -0.3921932695238962, 0.3857600683506942, -0.04259124134731622, 0.5718185769350229, -0.23921979519278924, 1.7451985821616494, -1.6848537022519987, 0.7683503493844097, -0.23937330603241241, -0.6563318318350831, 2.123380793276904, -0.4277445678910361, 2.407921682357299, 0.6346944518128107, 1.53846191475794, 0.7109595405022531, -0.577311274826411, 1.0214868666098917, 1.4372319165386473, 0.952965252617006},
    {-1.0662842695907369, 0.19322331315644878, 2.030191573057762, -0.48145585510556893, 2.6220824528544933, -0.653360447708966, -0.9066344122408992, 0.42601882046639106, 2.211324685805921, -0.4817951570698676, -0.04594936443434556, 1.4305651847397187, 0.3118453779626694, -1.7689617529100443, 0.422678899793173, 0.4133944452965025, 0.182901760528833, 2.2711975998256535, 0.11842733836017733, 1.8629592516458133, 0.13899573410468882, 1.394132166311584, 0.5562202739845157, -1.2612131471687693, 0.9186142402959169, 1.6915723391733057, 2.122323614771899, 0.5508385409876468, -1.9017324104549846, 1.8939624107786486, 2.104959009469368, 1.8624635946254022},
    {0.2618980535194107, 0.5497101546087944, 0.9633842759139891, 2.627975253464147, 1.8428044416710785, 0.6416943769042783, 1.15125678622364, 1.3605580603366854, 2.1017702634719884, -2.1833177201734, 1.163757976593698, -0.27492154274415204, 0.29172637436636745, -0.5920098340919712, 0.6141007267251065, 0.32574217566143254, 0.08354798464914512, 1.9382364455803809, -2.0427758009863526, 1.0297507384711462, 1.2852442179219665, 1.5028372698052774, 0.04618004448956489, -1.6556347398668987, 1.63864618237473, 0.9497646007232048, 2.1572413019893495, 0.07480097674328093, -0.9881533062366868, 0.6389080150526784, 3.272891449708467, 1.941504157898832},
    {1.298680819747969, -0.35949426932437134, 1.0672678869709291, 1.4602780671147964, 1.0673915461380656, 0.41995053095548984, -1.0868027983125845, 0.750715039713632, 0.3998792771958816, -1.1600392291589823, 0.11898311003391789, 2.015672240118552, -0.21102629534847694, -0.0715127663385469, -0.8466582386686766, -1.114152180866393, 0.41777570187794616, 1.4816758336424007, 2.07591279920211, 3.986330734140205, 2.2728439742542164, 1.8897977744155354, 0.9978357755495967, -0.3841334545956397, 2.8819757820266636, 2.1710208459499967, 0.5584948698204436, 0.817423974891196, -0.12193246449112957, 1.340503062919908, 2.632612886784533, 0.14278249820010777},
    {1.2332842949729559, -1.328368412266054, 1.7080076763245464, -0.7195701203802835, 2.670766696126183, -0.2574100068899107, 0.7242238698870269, 0.8134495964648926, 2.0472460746394274, 0.9208351828028061, 0.11529407659416031, 2.006133788705151, 0.784797333995603, -1.0258281567867433, -0.5360707020595619, -0.7078940020915527, -0.8816249737654452, 1.9182271400820472, 0.46112196448256587, 2.7283361622453954, 1.7713778101624322, 0.49723934024900945, 1.3696113812076989, -1.173208148262091, 2.7449074149645982, 3.0730196503622493, 0.1202606342857958, 1.022967241923885, -0.5518120228889064, -0.48671335367374635, -0.18164665180110548, 2.5416924689694183},
    {0.22546279413520345, 1.303658883177551, 1.674114356292438, 0.6880619176396285, 1.7948674018770863, 0.6241881305635638, -0.2742540477340513, 0.87760824016802, 2.796147022410303, 1.324344396885767, 0.29194015818615127, 0.8444141768945003, -0.05325676269858004, 1.1431346020673314, 0.6836212443593059, -1.9236181020449856, 0.32583978723620677, 1.0295128519607089, -1.7745964211554357, 3.254895448387797, 0.36653464500657745, 2.829566755171429, 1.3614136210579406, 0.3081962004658065, 0.4169278487701711, 1.2060504698530694, -0.3954694937422901, 0.7504039538661487, -0.7507846972642369, -0.2824323645710636, 1.662164436358499, 2.271258710219572},
    {1.7138503307296713, 0.8713396771383266, 2.7141421281235245, 2.6152402667177874, 3.569063446603555, 1.2062052125069556, -0.34508469583108325, -0.776075698819744, 2.470619184711618, -1.7559374240936412, 2.0136788796153855, 1.3557961308908384, 1.332900803048361, 0.08043514361381367, 0.7019458068449129, -2.4987889792350724, -0.2950846314422725, 1.6540014088255806, -0.7087363348491657, 1.7875880247306082, 4.796081152597428, 2.713210588026996, 1.4803798384649993, -0.6456432667239614, 3.391264955101979, 1.3598012133215407, -0.029832772789705295, 0.8483086137535603, -0.4599551362470999, 1.5526773685248565, 2.6539606921903944, 2.046008880349761},
    {-0.18878557037308552, -1.038291039571616, 1.1435192266632228, 1.3632015174671706, 2.9468852181183873, 0.5786217879932599, -1.6272318416105234, 1.6520598991518867, 0.9758416099728323, -0.7334532312172413, 0.7912734529863875, 1.26239341270896, -1.6116583810211345, -0.8040716494370512, -0.37874538588378526, -0.4020918633756656, -1.6564020043738474, 1.006028771999044, 0.2443175842018519, 0.7955689656613171, 3.696601028858716, 0.838303702802585, 0.32685647207479057, 0.250744000459592, 1.894804947128469, 1.7738195099296916, -0.5018722138731542, 2.2881409108702955, -0.1674746954068857, 1.194658025203737, 0.15252361182629504, 0.9183380863993771}
};

static const float b2[32] = {0.8540474450346083, -0.37680940727451134, 2.3442257502741906, 1.6526870770075273, 2.5613740391369886, 1.2248937626119212, -0.4736343928063189, 1.1022295435529563, 2.6411454923454274, -0.2999913704643807, 1.3001690913736796, 2.4951778518458103, -0.5399442364087831, -0.12544505140348877, -0.3778796988889511, -0.5142554854317608, -0.16627119561655704, 1.9247434090590403, -0.24667749102988762, 2.2868947887772655, 2.34218697463615, 2.251733208087121, 1.9713900706449805, -0.47478042945446314, 2.720055367999158, 2.144662277357777, 0.7614431259452771, 1.7818286953683016, -0.2253340514167017, 2.2263978028595868, 2.5311824967724097, 2.3031306273647307};

static const float w3[32][16] = {
    {0.5013946988490598, 0.15203653710274187, -1.5009667132184008, 2.09074113649916, 0.2035735690717546, 0.5405654308932125, 1.1100171621683972, 0.26779775539669587, -0.050521092546225166, 1.7477735065394193, -0.9741725580032025, 1.0498463340962945, 0.029517249341675857, -0.49847366648365915, 1.1148109448712917, 1.4290963177931755},
    {-0.7768112237200581, -0.5747228919179955, -0.6271228842432947, -2.2266713640943103, -1.117814780776724, -0.1996634929786612, -0.4208635168594306, 0.64540434462556, -1.4929277224390778, -0.7541682222777725, -0.9872559364305247, 2.0842792065791986, 0.20460838826574176, 0.6272301054841447, -0.2902265083336136, 2.141597562707523},
    {-0.9236258203901214, 1.9570240194110622, -0.6919764955769607, 1.4475898356938228, -0.41550215208658575, 2.103936970630785, 2.033225223358157, -0.6999178339141042, 1.2967513447218393, 1.4314871860287042, 1.6761761842878709, 2.3123912330496488, 0.6405452786648518, -0.11676047769626088, 0.9749217613688617, 2.6969989584578835},
    {-1.2526224529373442, 4.018256490838022, -0.04387484440398732, 0.21507643290025585, -1.1381240921707731, 0.9960330114206674, 1.5661436868864753, -0.1097104974739475, 1.7928941871827027, 2.929879306984218, 1.494680110071367, 2.641168456608744, -0.2053983120723581, -1.6762235637904408, 1.7999334365199076, 1.4215399173185232},
    {-1.78740500256891, 2.1846082746181548, -1.056650361139297, 2.1031976254387534, 0.7033496674715268, 2.5162206510825817, 4.751162578587938, -0.05927394944588675, 1.9937505255400139, 2.4628953393824555, 3.1666583874182046, 3.736244781152739, -0.732417064593822, 1.2538733047971085, 1.3139741922977262, 4.677037642427787},
    {-0.28956207454129296, 0.3957975221056996, -0.7729107473250986, 1.2253486815252854, -0.899876571457452, 0.4560446085707518, 1.1941086998956008, -1.9622622962571026, 0.6168236775140362, 2.281848693794159, 2.9123395764386264, 2.257793482788685, 2.81501077695856, 0.04649067330424988, 1.707904178776645, -0.1891587481824709},
    {1.053942431436691, 0.3285634365412755, -1.5105928249402034, -2.1109875816208765, -0.611160649201449, -1.3786772845543689, -0.49083005762160276, 1.2436374563413122, -1.7933756336865594, 0.06016826967475431, 0.3457604804017179, -1.5170540966379613, 0.8893623443232829, 0.10499402083835112, -0.12575400059194786, 0.7605745510957518},
    {-2.051105761914888, 2.9193926273769386, -1.3038783509935905, 2.295728876247692, 0.06577176986999062, 3.0733346507639694, 0.01297124191707652, 0.29722138272028115, 0.8489404695592803, 0.9802195559844488, 0.02158604620019446, 2.4348660542577107, -1.4235970838443621, -0.0046010340643991236, 1.3236715778237436, 1.2017639542587308},
    {-0.43883775215656184, 2.732907858143998, -1.0165222156404372, 2.8051166270766497, -0.9167351903281027, 0.010747387869040639, 3.32313340895254, -0.6201706755785579, 0.5522259440417966, 4.348848423747053, 1.078798977125999, 0.92072879594739, -0.7632673169165258, -0.6597108303181136, 0.17858745387385985, 3.6919176384202044},
    {-0.04989296287101308, 0.3876435818905596, -0.03496361209952931, -0.27073300458801586, 0.9024579754409807, -0.5922699346932242, 1.1329781278655213, -1.237984499039322, -0.023754526734684627, -0.5030658243988623, -1.6277304759482583, -0.672651508214623, -1.380426161684436, 1.934055930624443, 0.146439804562851, 0.10239437113294403},
    {-0.05332728532392561, 1.8425287723235144, 1.1531828880502097, 0.3377554446112895, 1.3661710024381837, 1.1093467703818916, -1.515687838893695, -1.3614577279471152, 1.8667207741535656, 2.0661168269795507, 2.2808515958847613, 2.379993329494283, -1.0958016065044214, -0.6515905990141989, 0.7585621887433871, 2.6939137741463117},
    {-1.0741102557757756, 3.810196670608257, -0.3220231137224332, 1.452560176512543, -0.5429357701768279, 3.3769319869868646, 3.103165928010509, 1.4262219273509982, 1.289461745416457, 2.7200485307560753, 4.46633566591983, 1.6997393826129261, -0.7488649785475936, -2.1681584468868995, 1.0307987291676364, 4.302614652351102},
    {-0.38797547154328954, -2.7317501180085677, -0.6496973631589951, -0.17162710537288267, -1.6110249634146794, -1.4301320152270331, -2.632791929671168, -1.0191330490887718, 0.8326026968129467, -0.815011088102545, -1.5198736077502504, 1.53597133193204, 0.6767836334028681, -0.7070459843312282, 0.23052451818982356, -0.28062157105964286},
    {-0.8151680575521101, 0.9207929634048845, -1.043190137583754, 3.0727642535897552, 0.7872987852028783, -0.3031950609935017, -0.13858789380397105, -0.9057594631309958, 0.4875661842171462, 0.027051255277492855, -0.5720501532607257, -0.05126177645510264, -0.817190289032283, 0.5078073496778689, -0.40788744977563285, 0.06233128756050817},
    {0.6525660544919883, -1.2657913872707767, 0.01349851034418373, -0.9556537357908818, -0.8086910129571847, 0.11765950671099662, -0.8650211009109916, -0.36076996882883405, -1.6822603240698755, 0.3679431616298956, -1.103046196442098, 0.6540258042976368, -0.8108609713107966, -0.24672963485083702, -0.7305481874445717, 1.0518739044015508},
    {0.41978603806590264, 0.23061414202744274, 0.2246188841929527, -1.2601044610754486, 0.5502599104348478, -0.5116060065257697, -0.4697032347251642, 0.42953343701946256, 0.43154248665098977, -0.1247594164633231, -0.8423046544318776, -1.1589741913516836, 0.35036290146092824, -0.21732432999208914, 0.2655543396860074, 0.9146579859993195},
    {-1.490516616354833, 0.7189925888303915, -0.23582178635865764, -0.4914302580835469, 1.4476991749004373, 0.19234942600111832, 0.7277524987495618, -0.5774309052006983, -0.3067703244802059, 0.3441421502590654, -1.4413209829353069, 0.3779590994916907, -0.1229540740132236, 0.8188151256907642, -0.4884504148829487, -0.8443705224051566},
    {0.3917553123210337, 3.566058424666989, 1.2436159472586856, 2.1741758012077983, -1.4614807346663456, 2.2628558945195016, 1.452072868284266, -1.0355407670710532, 1.5441339059893966, 1.2526066582823168, 1.8428119679894261, 2.364691350831735, -1.7168560268327184, 0.09083448487729359, 2.6841080938682027, 1.903069532689904},
    {-1.289659168070596, 1.0534559796860754, 0.941996850596958, 0.04782863198091906, -1.3780285306354205, -0.17141209717894437, -1.8612062090023973, 1.354343289145027, 1.119982649182136, 0.8113541838975228, 0.024005758537468738, 0.46598193937192317, 0.0845705892910359, -0.03349343251951532, -0.9765100016373466, -0.2430158256086365},
    {0.5404867850790079, 3.034783459496543, 0.2714640652056816, 1.810716421646755, -1.4322617637960933, 2.2594733392312993, 2.6016974037051996, -0.7651087226840534, 1.7394844831672176, 2.6940035233675848, 1.441214861391371, 2.282611356686019, 0.22499266194803452, 0.08950546897805388, -0.1316780922080603, 1.691866523453233},
    {0.9839827725189201, 2.91454679751273, -0.612288292404645, 1.5861929641475563, -1.357690303240699, 2.222615732896033, 2.8485666035204567, 1.1223074575736882, 1.6476698439686153, 2.8221419398370764, 3.4640316992000413, 0.7669170122138378, -0.34288326117785134, -0.5885202854803663, 1.7050557739773122, 3.603127773508128},
    {0.4307353631055043, 2.460630425489696, -1.4892427529303607, 2.6040829208650442, -1.7204708120044863, 2.7923405818801674, 2.828635098640994, -0.7185639343433896, 1.6336711570627385, 3.6779345566422332, 3.0181661491908574, 1.693096105340292, -0.0933625989376429, 0.9202418928464023, -0.1649412649029617, 2.0567467611422123},
    {-2.1096950903273415, 4.2777772869516495, 0.12821623865819315, 1.638748114684209, -0.8744159407654735, 0.28035499231461797, 3.144782272707364, -0.44856382399117545, 1.7573656808643743, 2.4286202502804204, 2.3186339818538677, 0.9946129481564456, -0.859333290858012, -1.114788120755312, 1.4406940837526074, 2.17712709407176},
    {-1.488173466281627, -2.065571373710368, -1.1745750286715968, 2.1148112615340597, -1.21008915779822, -1.047161224905991, 0.530886058305411, -0.09090493105489034, 0.5518565909987346, -0.629901792858461, -1.102542805030799, -0.20473938879734782, 2.227069102819798, -1.8794292973258235, -0.9429613271019307, -1.4543417653961679},
    {-0.856503693615718, 2.9437981204641126, -1.0476677962253724, 1.1721524125650291, 1.1500094701755685, 3.170575844974259, 2.3879143613619327, -1.0889068546503031, 0.03408216670507331, 2.7144931650061825, 3.5576861761197756, 1.908808512574193, -0.9391120791577443, -1.1115270271334017, 2.3444069592109145, 2.094091341463746},
    {-0.10412653766555272, 1.8331298125371125, -1.771188918240501, 2.5227951811956557, 0.10534202143209886, 2.229039067446914, 1.906521860882466, -0.4631855382911816, 1.8145258369743946, 2.727124442338657, 1.9660640945173438, 4.117711236153765, 0.040573975259758435, -0.5057626074582747, 1.4971310589557694, 1.4083458433210418},
    {2.0773947513136193, 0.1467378549534237, 1.3874769733165588, -1.2300595872321585, -0.4193172750166003, 2.016871844663777, 2.3465618929270606, -0.3251255881866032, 0.22120602398899553, 1.1817326068608116, 0.6928454451232614, 1.7350859370856384, -0.5029145374530465, -0.4573564448829022, 0.532654890232275, 0.9781704860204495},
    {-0.3461720183203319, 1.0919534501575974, 0.7566940685065972, 0.8559525149335001, 1.7660360615965514, 1.0252895470044172, 3.2604431107504026, -2.820245603826733, 0.8397606003685744, 1.7669122318770585, 3.723587025908025, 1.320425342784974, 0.33704845953986884, 2.0647274211379076, 3.1411291869380085, 2.646379424229295},
    {1.1770735448557792, -1.7159336509914447, -0.6981395974357799, 0.8749754631285279, -1.500289259346884, 1.4249695764965473, -0.41680938184807603, -1.0831281815126885, -0.44153208633861296, -0.36727760178495517, -0.13752434531866625, 0.5977417325946965, -0.1606169725184674, -0.4295461927326933, 0.3559329966317635, 0.9426855361464924},
    {-0.599341072683198, 2.6176776004155715, 1.288523572690389, 1.145934303225477, -0.7367491563700338, 3.2191604441777635, 2.8278106951545126, -1.861447923916548, -0.2525559361036854, 1.8964170465733698, 2.149245374816378, 2.190913318036682, 0.7833080686638093, -0.8548450335150206, 2.9704388667692143, 0.56959293916851},
    {0.7386040795394305, 2.9200813575525575, 0.01824482860491124, 2.7434816232425208, -0.7507308923620812, 1.3835155962661165, 3.461474318280834, 0.3997608785127461, 0.9126800547697076, 3.4434560396702096, 2.0863767728370926, 1.4796787175329749, 1.3446168103736376, -0.2819748045535766, 2.407984377525364, 2.585729549115221},
    {0.017687687784555813, 2.622271613322592, 0.492316771934127, 2.41819356729304, -0.7150045094381475, 2.5354729908643834, 2.5498915708006473, 0.5005386929857171, 0.7541175190355283, 1.3607357414511387, 2.5297913071541736, 1.85542396538654, -0.39417594907921594, -0.2384232212814979, 1.4725327923678806, 2.384891087051974}
};

static const float b3[16] = {-0.16500443894280462, 1.3915103198250547, -0.14360626242246047, 1.2312547285790219, -0.3405946745306424, 1.5308927768585507, 1.9875958695822493, -0.4025901562693812, 0.5949152500442257, 2.137811831381149, 1.7112980568869403, 1.3692892588039953, -0.16716100167194126, -0.38052793161576826, 1.1695402907571133, 2.3492560277733365};

static const float w4[16][12] = {
    {0.7038598528710384, 1.0790469575785386, 0.728205269443073, -0.05233533857158375, 0.33673983664476287, 1.552544176799817, -1.438106811963803, 0.615329268240289, -0.6580383068379778, 0.4737014702521614, -1.459843375312016, -1.4686055269849394},
    {-2.0659234363193053, -3.0406151689981455, -1.8872590815118475, -0.18130752327447672, 0.23553769195604915, -0.8787846804902193, -2.4592229022535808, -0.20884721103160836, -2.4994246811903587, -2.1995696059007215, -2.0275182954791657, -1.856282616769932},
    {-0.6891698909469349, 0.3576776994662551, 0.2961055033847172, -0.3564839018038362, 0.8565516042616893, 0.15951071422438573, 1.1874180319719918, -2.4778379427923944, 2.1745961442329635, -0.06972030098390145, -2.5424718170153193, -0.9322661478289199},
    {-3.2399624461646925, -0.7782360964936256, -1.727668757214581, -1.0522558414405652, 0.1685030140173342, -2.5996762280848067, -0.5820389940700111, -2.8995879391550115, -0.42975598297742434, -1.8243546364872907, 0.1654541867756102, -2.1587124718775716},
    {-1.3727108082303447, -0.4177179945647673, 1.1509693531102478, 0.09682368575814394, 2.16120001637766, -0.06579267161810959, 1.2919437199305797, 1.585323289387495, 0.22473909659186497, 0.6805827168282975, -0.7834943471822193, -0.9174453209391034},
    {0.23688231191275058, 0.8367940841215973, -2.1101448319682383, -1.870397952053143, -2.0218478873654195, -0.8977298149971041, -1.0009126671993356, -2.5464201591378295, -1.0114124116134495, -1.4094159916003046, -1.5961433701105467, -1.6455247673000806},
    {-1.1847162850553155, -3.220438036138036, -0.7012026673209952, -1.8795880467459793, -3.0367232141134455, -2.185992820512339, 0.11965020495794795, -1.8999177620527865, -1.7903916731505576, -1.7503116856927, -0.9465615324510905, -1.635538585062594},
    {1.134241083736933, -0.8641902436507959, -0.7115625213424872, 1.8456857943985083, 0.8358870559563774, -0.885860782130617, -1.0559208748742384, 0.8927187403243423, 2.090025735621903, 0.5298502687110698, -0.3804620812271665, -0.5953496718814945},
    {-0.9820362020247808, -2.8489250252429814, -0.7822570041754765, -1.2404197389607814, 0.829066515912346, -1.1843752009889064, -0.9040081219428094, -1.137096673742344, -3.1254992192501945, -0.19597938207457885, -1.3881315038770974, -0.5447802704551705},
    {-1.6079592476442437, -1.833706436010943, -2.3020286443481126, -2.5880456209717817, -2.1479042133720108, -3.622332460596851, -3.1312128824530805, -2.3985848458892933, -1.2247876147536643, -1.039047370096967, -2.9866516130498066, -0.9611792239269388},
    {-1.5684810675998067, -1.196619804761981, -0.13446024226755393, -1.9537567483689817, -2.6172783383343527, -1.005166081753151, -3.681226911238458, -0.694015134451932, -0.5919471032659863, -1.791454701640948, -1.333167324499187, -2.4880806431173714},
    {-3.470490483933568, -0.6721715279328656, -2.7001844104510893, -1.7630847120519035, -1.219385911579271, -1.3732749044321828, -0.33019648437551624, -0.9341794770850513, -2.8500648151714447, -1.9299519167156352, 0.25013058537919663, -1.0183781442823447},
    {-0.004511220157864646, -0.7011544034593662, -1.5869118072325825, 1.2600736728881594, 0.5207249578781082, -1.4600276199240483, -1.1326576799359682, 1.092232978729762, 0.15357820653668122, -2.494247356103459, -0.3509207879958872, -0.5132708245661481},
    {0.14826779178832225, -1.141084039848421, 0.8158080836256181, -0.5418499229030139, 0.2096843498549767, -1.047294916100732, -0.6965476953906419, -0.20445087088411215, -0.4325157186866556, 0.6236713399752067, -0.1902021603126172, 1.7033556481216117},
    {-1.48447865195131, -1.8058696307794433, -1.0479047314212413, -1.6121086733769074, -3.491325964793542, 0.07132019372707951, -0.8913192842305826, -1.1292511984955484, -1.531042904366472, -0.14804083438513757, -2.2871035196376863, -0.6781582271668458},
    {-0.39049188248388433, -0.8773039333940896, -1.949511745739131, -1.4480887612282836, -1.6669709615193267, -1.3274595433711052, -1.7016384439448113, -1.9931566753607708, -0.9488534755690772, -2.1754785097769176, -2.907780800250835, -1.9299795139526528}
};

static const float b4[12] = {-0.9574677323300002, -0.9885165898304576, -1.078064115619201, -0.9908226202648442, -1.0120035545097883, -0.8549367095838631, -0.9798139895080085, -1.0476047018700982, -1.2508877849695683, -1.308532965788971, -0.8529538772192514, -1.3719392683961449};

    // Input Layer 
    float z1[64];
    for (int i = 0; i < 64; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[32];
    for (int i = 0; i < 32; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 64; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Hidden Layers 
    float z3[16];
    for (int i = 0; i < 16; i++)
    {
        z3[i] = b3[i];
        for (int j = 0; j < 32; j++)
        {
            z3[i] += z2[j] * w3[j][i];
        }
        z3[i] = relu(z3[i]);
    }

    // Output Layer
    float z4[12];
    for (int k = 0; k < 12; k++)
    {
        z4[k] = b4[k];
        for (int j = 0; j < 16; j++)
        {
            z4[k] += z3[j] * w4[j][k];
        }
    }
    softmax(z4, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
