#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][32] = {
    {-2.0927144608207096, 0.18006763345733137, -0.04263291466554256, 0.7833688199958824, -1.0432747063321726, -2.222643055641479, -0.8806805406409821, -1.5058620202952617, -1.6841256845156365, 0.5672937577273544, -0.7783151055481023, -1.7793765318610717, -0.9866190574567039, 1.3900572855013538, -1.2965264743797449, -0.26387100362272004, 2.7640672616664843, 1.3336832199572526, -1.2560099015935322, -1.2468206986837844, -0.8998652853728272, -1.7690709010377188, 1.0660298234117445, 2.7623861403147534, -0.708470997938206, 0.019060312730144628, -0.9050473418823443, 0.10390175904035594, -0.6677558145342087, -0.09927690576373072, 0.23836853992798288, 2.6048371589699313},
    {-2.998562778346825, 2.3231676711539913, -0.09385476994190182, 1.9083769193236877, -0.5803280845933966, -2.878523448422625, -1.5915731448064998, -3.117252916097619, -2.6970315118271, 1.8821791282710214, -1.618985339779833, -2.3581942122914543, -1.0085202622222027, 3.180559575322522, -2.8358040066817867, -2.139616489202212, 3.255342763419853, -0.7872743277607722, -1.9728430878564522, -2.0554688808168846, -2.013304020695981, -2.777893696271012, 2.7576617659425318, 3.1541018871846784, -0.9255589138261932, -2.3594779778636568, -1.7101535669895758, 0.41212937931960847, 0.26250378006111375, -0.5087643892188831, 0.02620538676058211, 3.0332090017268967},
    {-2.876001970182407, 2.0032957737445507, -0.7354761655236393, 1.154758148321067, -0.6073660223597899, -2.825127296147793, -1.4653991315362112, -2.1930567176795415, -2.188273048457915, 1.2915317476447523, -1.6519010366336693, -2.5030650203314386, -1.766089271998507, 3.418505134778121, -1.8836611516026782, -2.017752525209578, 4.264599825348084, -0.0031735964008312786, -1.571000885351312, -1.876238146200572, -1.7294980092709527, -2.752950389583034, 2.895041682713512, 4.125135557646605, -1.1794351731137065, -1.3922414699284364, -1.8833480105751537, -0.21018643070112814, 0.14748524476629232, -0.5541000242391605, 0.5187597979559854, 3.9684095651109823},
    {-3.9368473816190614, 1.2879645376043178, -2.2395548391114812, -0.9144694796091042, -1.949688965681838, -3.9101339703505196, -2.8272570267629358, -3.2520416500160088, -3.636001889891998, 0.12965298233734504, -2.882192277491075, -3.667633277917603, -2.8580431247605733, 2.893424848134879, -3.1495903905085534, -2.7948086220424164, 3.756706116217974, -2.2323992782401936, -2.937675983218614, -3.258254351503079, -3.005688709030541, -3.5871558200286664, 2.1815047098576246, 3.556217725023419, -2.725555367919563, -2.4440400831415143, -2.9806812786119323, -1.5699601808313046, -0.8117256665086899, -2.5946878525452473, -1.0693758005333, 3.744559425134625},
    {-4.058858107357146, 0.27132196473034315, -2.9051273314364634, -1.661823071598831, -2.1998051163596433, -4.073956213385276, -3.384553117246702, -2.6853289401758507, -3.623294753480747, -0.5766810252453973, -3.248049941175238, -3.688447429313458, -3.490652633307855, 1.9927595581101112, -2.8309142320941905, -2.962684643606877, 3.23435194060631, -1.9510293384632544, -3.1025805430438447, -3.4921166891889963, -3.516850822670712, -3.553252147012054, 1.2610276906918538, 2.919052123290804, -3.10913937446417, -2.100878525599084, -3.0617059249744947, -2.3380926839167784, -1.0690140899935867, -2.881775493916293, -1.4369626833016438, 3.1583484210804604},
    {-4.054409273796252, -0.32763048128813094, -3.1223583779621387, -2.1690873811722255, -2.2042004903552646, -3.877094366885625, -3.344069140998491, -2.4391981152147246, -3.250825740114637, -0.6883484316563434, -3.2214038441738935, -3.85036126429526, -3.60696849275826, 1.3018441235224862, -2.814248793435222, -2.6228965136284, 3.0524163119220966, -2.110509546841361, -2.9301132884394354, -3.5290132367959677, -3.3997358975250607, -3.719712046669641, 0.4099048136614872, 2.427524269515292, -3.2179619705208915, -2.0345673385215166, -3.152511342083864, -2.4463488982216037, -1.447474232789872, -2.945183565744758, -1.6477865568206822, 2.576750940766305},
    {-3.8810972107235386, -0.3901904579350475, -3.034291763200565, -1.8599875714924174, -1.9933019550667088, -3.854530569203384, -3.196636813750993, -2.3122902277679502, -3.262071889585161, -0.5312767479829394, -3.494216088863179, -3.548448254616402, -3.247911652984975, 0.8267838297228408, -2.726938531785027, -2.6633303707460025, 2.6808988888165324, -2.3629491896684844, -3.0390383501882945, -3.6310280609971777, -3.5474396430327717, -3.75362402360661, 0.5386648728274241, 2.0876040281131045, -3.0825714303567437, -1.9480014602810816, -3.2860034809361345, -2.2593107347584707, -1.0894234950720691, -2.9240552264986577, -1.6516671763159494, 2.602568235560376},
    {-3.8281726803526785, -0.3274362110680821, -3.3182830941559756, -1.9739126989774132, -2.129843078593787, -3.8502611341014497, -3.432207267256668, -2.572108162603275, -3.5230826874843277, -0.8666066968025417, -3.5842315336498833, -3.700841612092058, -3.759118007951181, 1.0361205384712886, -3.0338877891276055, -3.2876895083105415, 2.879636705980263, -2.2984115855975977, -3.344832342312142, -3.5392347419591617, -3.6442772026581145, -3.7991139566484406, 0.5238235797270205, 2.772207427318263, -3.4758480795912434, -2.2025845780550086, -3.4411122272967343, -2.832326936750941, -1.098956805581617, -3.280673034978049, -1.53064579354305, 2.73225182302845},
    {-3.9546644219688813, 0.12843818788377226, -3.2185666281487437, -1.9605795644674866, -1.9000114453940204, -3.9295155729711677, -3.40124053581082, -3.008859235739169, -3.7946057262875286, -0.9097949563933695, -3.4481929537871645, -3.7757956143343216, -3.5092354691285137, 1.5620502641507594, -3.3558693571592864, -3.232723788148796, 2.669139165354017, -2.7296201372555604, -3.4163739398552426, -3.7112634151960937, -3.459677125340229, -3.8090693608426975, 1.045780068607573, 2.793505065094321, -3.4502963446655652, -2.3933780637531576, -3.5263636823719806, -2.569884366666791, -1.0477408483498305, -3.391662762636717, -1.148894776415287, 2.6378159811972584},
    {-3.789968068567964, 0.8918807620200512, -2.5260182522993633, -1.3094205493690068, -1.5217747348334247, -3.9208409139977727, -3.3821205950740216, -3.187487768156413, -3.831089314056359, -0.3484140936023849, -3.4879494616389466, -3.9802228120017573, -3.311534507788063, 2.668717238951983, -3.7120367373683054, -3.271647481976457, 3.347539268870978, -2.653155235324199, -3.58095222229096, -3.7496798496967827, -3.5383966367460067, -3.8304706300437785, 1.6742888858189893, 3.025852948242204, -3.5181272763469944, -2.7994624053163264, -3.5660132429662785, -2.050057183765495, -0.7117336473579825, -2.926589047539338, -0.9655103574410906, 3.1603858183360605},
    {-3.8508693843668262, 1.0031458516226148, -2.4949199590158133, -1.2308990451943682, -2.0055821312759976, -3.8176967506511192, -3.239003928369634, -3.1159059369319513, -3.692957240984886, -0.26056013540771666, -3.0277356077737254, -3.6518786458995662, -2.9744976722285505, 2.2613117794115216, -3.6083386899030456, -3.149545962641443, 2.6955909308270645, -2.7779460356120658, -3.581885195592993, -3.5618426503131024, -3.510512070292775, -3.5809984249544455, 1.6086707174964336, 2.3352469929574813, -3.1551361087554355, -2.630060325460984, -3.3225831371074053, -1.8818514090071081, -0.8847841001639688, -2.665549858266085, -1.4213659026288088, 2.1621187123024357},
    {-3.4373186022850457, 0.7308599825802913, -2.7370722111542727, -1.5865912030875364, -1.834561763238809, -3.4429702338632433, -3.1647018958084967, -3.0416342328977053, -3.7466658548460128, -0.7229353871791094, -3.3249266025409927, -3.731296298818522, -3.0075231116809773, 1.9318530064666721, -3.665172539994168, -2.7740936706209873, 2.2508761756591524, -3.1685377665355805, -3.5025535920184234, -3.6806278949206597, -3.4163500632462425, -3.83869540570557, 0.8868664074890681, 2.5413099222613424, -3.4882985494057643, -2.6864203682532724, -3.493668285496684, -2.086460165568756, -0.7882527259846597, -2.789865550181121, -1.3644777752840251, 2.5392492883336146},
    {-3.70784305288034, 1.0630822398380222, -2.6234199059135506, -0.9715821795311904, -1.8963576099554456, -3.469761750985595, -3.216697060663867, -2.888197612996992, -3.6908967532736643, 0.04937250287637684, -3.516245355973671, -3.4829942759133505, -3.1293859895736427, 2.614863315541826, -3.3919897917724984, -2.733855065785218, 2.9067650547732833, -3.002543886070856, -3.625920589041429, -3.4508450190764397, -3.701162510461603, -3.6584318632465314, 1.4991927044127342, 2.87073413001711, -3.2926061515992946, -2.2994922765020784, -3.2558600148313404, -1.7995123050001718, -0.2610860368309733, -2.6965628744285968, -1.3087408748441287, 2.481759009463437},
    {-3.4637640431393204, 0.8388413891401881, -2.6522539677922805, -1.0993125815727882, -1.9762173812505153, -3.8539364068448934, -3.273576140730961, -2.989868318054111, -3.562572804736352, -0.13988761381854184, -3.5888125483458255, -3.800742564847339, -3.3750379156126993, 2.4591021986508586, -3.515998625122512, -3.0038363947000497, 2.51340956965475, -3.2529317751340825, -3.3754484096216557, -3.498320448755226, -3.6844007672725163, -3.6924810281558953, 1.2108121908952876, 2.7262538636702818, -3.5983238988448916, -2.4714019604600033, -3.651996374877568, -1.6378520691210732, -0.5603985394178994, -2.8952308358507284, -1.4917524136088798, 2.655093605294075},
    {-3.655064825467179, 1.0248836508586394, -2.4925266483559465, -0.6795527784585973, -1.5508320508175881, -3.6690075885925664, -3.081518436229199, -3.091150029202833, -3.7799857833577883, 0.4750364869803769, -3.252732052606892, -3.814486763153274, -3.1762716033407474, 3.0325771197045484, -3.368197827424874, -2.995223103969798, 3.1795202908248035, -2.8105756486602496, -3.6154013912352805, -3.3041664762346743, -3.470104730439451, -3.9101466358509884, 1.8479893890796282, 3.148349601121151, -3.0908739045730926, -2.391850997305128, -3.5265652852583553, -1.4136213433435503, -0.18827294035819725, -2.653656435007481, -0.7954369400868396, 3.2773882264404945},
    {-4.08978224293584, 1.453101990822932, -2.5926589572358663, -0.8759882462366884, -1.2355899133386397, -3.9406323236471126, -3.418366771864061, -3.144178660887114, -3.71690478959466, 0.5819702128753885, -3.5653141810269493, -3.985273639420844, -3.2503809187776604, 3.1851950666780637, -3.6268695050375097, -3.2764485071102682, 3.7750143471302433, -2.802845244257536, -3.3377487466671076, -3.646709025019196, -3.7767283492417003, -3.968725339111713, 2.444690257524926, 3.5461839770584667, -3.430889357956879, -2.5056551932028786, -3.2255510046991462, -1.5926952134399162, 0.1730695165411814, -2.56122735682859, -0.6935487794379657, 3.365876706719218},
    {-3.774862040596839, 1.7143341640073315, -2.405392415171551, -0.6096460100035134, -0.8789047132054033, -3.770413678429725, -2.9436047865727404, -3.031790696425353, -3.762698312629309, 0.5616105634261007, -3.226774357459633, -3.849769172117021, -3.0946116680374414, 3.244003479702121, -3.4378036933853684, -2.9998792810993002, 4.096503854455319, -2.2530876318261672, -3.1232914288930496, -3.114768735382725, -3.223449455437423, -3.6213007647800346, 2.4662725143700164, 3.6644511321416524, -3.0828365456801174, -2.4743313481480698, -3.056689715196391, -1.2551077025474549, 0.48577004660062545, -2.609740396451408, -0.118386553303932, 3.9534919368384207},
    {-3.0920956070470713, 1.981590572083354, -1.289858258927478, 0.29544773169669775, -0.46205498582032467, -3.1473607567615662, -2.2060589221626286, -2.7351487188816814, -2.8905916002779097, 0.8638565196771532, -2.5671407925599627, -3.0735423245027893, -2.4169163755351155, 3.4948215479288303, -2.7220268866484396, -2.2115555257188055, 4.254985489170129, -0.8532980493763744, -2.6518340522959747, -2.323540759590096, -2.5657533975166062, -2.884217518501537, 2.545968842092867, 4.010596960601337, -2.1635781850058513, -1.820901879763576, -2.344953481709243, -0.7013854716410519, 0.6215607584920267, -1.5071971572906373, 0.38393315229035047, 4.1525988249062005},
    {-3.1815190535627558, 1.4351016567102388, -1.8440826238740402, -0.5053593845106783, -0.804312195670383, -3.259751994550156, -2.3658942673364067, -2.18233208334747, -2.903151749333285, 0.5528930543992167, -2.4439949780144095, -3.001000036396884, -2.4505924081136157, 3.1775190788446865, -2.403263789708814, -2.1327388287362643, 3.9183254568378505, -0.8777155946858799, -2.438102780692469, -2.492650433992405, -2.332944043077367, -3.1090086079978843, 2.044042788769479, 3.908976673459804, -2.521783522564286, -1.336729581352078, -2.378860799622478, -1.2207849373572466, -0.07344735648226888, -1.5394011181493643, -0.18329659757661176, 3.753388494866813},
    {-3.488253186309611, 1.1486773599942364, -2.0814367006499004, -0.6643396809274754, -1.5193730894759456, -3.5948115300972328, -3.171047264342023, -2.6481134950531744, -3.5377296368175015, -0.031643737530854275, -2.9651369440004287, -3.397448252955709, -2.919105821110998, 2.9996942601719705, -3.157532008081368, -2.409399198569357, 3.9500399762292546, -1.8608757900268371, -3.1053215414919464, -3.294713502508444, -2.9989672494617783, -3.4610952389228786, 1.8007785259935774, 3.4029361018188093, -3.09107470419052, -1.986559074068961, -3.257113098912764, -1.1756568070971964, -0.22170424949852754, -2.0718131203036223, -0.8747591733519642, 3.571610300121894},
    {-3.5658964120246064, 1.8360430362205777, -2.0697635278570936, -0.2898520910210141, -1.2268301643643937, -3.4329926866552203, -3.0416137818814293, -3.4312809970395888, -3.7537548725968373, 0.44569889789692807, -3.181198747867731, -3.5636874016830484, -3.132606941965282, 3.428156628843015, -3.589332211724537, -3.116847977267917, 3.9805332611957334, -2.599793128820271, -3.2064465889371117, -3.3354630320587786, -3.242933162743336, -3.6683419730486206, 2.5473235915341617, 3.416993221769262, -3.157260314541862, -2.7902584984035297, -3.264700114863778, -0.9702146922845211, -0.10372655193912658, -2.1246933512566737, -0.7177808933066298, 3.7331481343195394},
    {-3.145347656667634, 2.0448943624724203, -1.12332653062298, 0.44218119368319275, -0.6326272588150853, -3.3683897195036225, -2.502588555713378, -3.119275979147843, -3.2219453391165804, 1.2832471126722365, -2.430839274198262, -3.217633099813683, -2.0410240553850456, 3.740898512109278, -3.0204051884109853, -2.4032470895867633, 4.5129811351727, -1.100175012497436, -2.8030205318873134, -2.813180780649597, -2.6072841126546384, -3.336768446688273, 2.825526246646141, 4.015243269915295, -2.2314685026118357, -2.3724207961468493, -2.6547722529008126, -0.37398901406328966, 0.6349712645439578, -1.2943826927963429, -0.12746452369645964, 4.344723529861894},
    {-2.809391945490996, 2.2039566006677003, -0.5110759147397329, 0.8218550291940653, -0.17816026310900882, -2.8700485807365497, -1.7023322545055537, -2.6461607797916886, -2.781783366812907, 1.5747817323548217, -1.812019745308616, -2.746750822809758, -1.357019908371086, 3.802525067875077, -2.341881225936141, -1.832682118312554, 4.640162600304017, -0.25806248438155216, -1.8852942613416541, -1.7788650707605174, -1.7400831082383996, -2.606219405967999, 3.139339415262201, 4.151188932767126, -1.5677115582364567, -1.9631967285906988, -1.8895874392571113, -0.30074508390383514, 0.8923335253690237, -0.6374932757273772, 0.5967957837187926, 4.202093391202095},
    {-3.2875311251303616, 2.3688096390657454, -1.2494035150568548, 0.45031968856803767, -0.7802575200926, -3.180439249210995, -2.287065815294831, -2.981972739972417, -3.1606242127156206, 1.0717901995301544, -2.491535317183736, -3.0427560359346857, -2.266514056402426, 3.795479030255019, -3.0208878480105485, -2.7543468075634703, 4.326274899457409, -1.30802134509415, -2.742510286907906, -2.616176336470106, -2.3852602276236707, -3.2296340000948858, 3.048568659906138, 4.01439775396503, -2.0061518684915436, -2.3380135441839016, -2.6561954646410477, -0.3895900285266607, 0.5307231230239678, -1.4642890454366086, 0.03865809516096925, 3.9122832954707665},
    {-3.544874834935862, 2.3282160387641433, -1.6719563869711151, -0.0312426725154999, -1.1484452759747161, -3.2770296334636386, -2.8841549067130403, -3.2867729929020846, -3.663733277220674, 1.0518065241905425, -2.8199266856383285, -3.2249825462015003, -2.727163730759538, 3.8471127210841316, -3.409322639163663, -2.823900350817791, 4.042058325479694, -2.1968433524166233, -3.0921429993720886, -2.8143589797861024, -2.92383271862349, -3.6956947537155243, 3.093667648159986, 3.83165983823983, -2.798850521348965, -2.8456684266921175, -2.9455969939433366, -0.8395002795536198, 0.5849972697963884, -1.9761937847633606, -0.28525394916889335, 3.546022118158533},
    {-3.012269891754997, 1.8347838100523, -1.2857728289840011, -0.11068052620214854, -1.0640787762640276, -2.88724838167975, -2.313949798005413, -2.760133070446835, -3.084832330378933, 0.778336606690392, -2.387732459157206, -2.8475853316719784, -2.20029001718245, 3.417241919187292, -2.759598323256658, -2.389421596371356, 3.780729002857602, -1.4015147230514455, -2.8188838535657594, -2.486941436407149, -2.584856960042502, -3.2850982120978345, 2.1985292741961056, 3.6249998114240745, -2.401391338269482, -2.0131437574522355, -2.561561276766916, -0.6012169281345596, 0.4106265631613659, -1.7030738670938599, -0.05465309744232172, 4.019504253513249},
    {-3.1947795138065325, 2.3459388391710485, -1.382642481846404, 0.4383321339357223, -0.931647639744617, -3.166243549001404, -2.3480633458511946, -3.083372664698598, -3.318395251336596, 1.3332495186175284, -2.637663363429738, -3.0566092774931564, -2.080572453634494, 3.963911549257025, -3.0315303438267565, -2.2114535601208933, 4.383372933616841, -1.1765276875891761, -2.543230072490419, -2.6013027154201174, -2.692696866524811, -3.241858541624522, 2.7617835104728354, 4.0094688589980105, -2.2831660763049735, -1.9011478008307268, -2.4394882412244447, -0.6421892436064028, 0.5452307234649082, -1.584902447556908, 0.23100505157043472, 4.2211462599956775},
    {-3.5248299154134477, 2.2429836081031356, -1.4943342778246806, 0.355064172702321, -0.9678650346780957, -3.487069626685424, -2.5112878939959598, -3.221316154423834, -3.551325572475781, 0.9280787853492707, -2.61608934093264, -3.2672322086292884, -2.564927461402718, 3.9134959807471223, -3.087978201440735, -2.8336087212513417, 4.27671202909863, -1.4552310678176497, -2.9560244983109207, -2.9985182386500275, -2.5937608006586865, -3.454059890429549, 2.8433230903857325, 4.043042548942365, -2.540765400505303, -2.552255475555629, -2.82244281447288, -0.5232316734612684, 0.326532330815532, -1.8186333826382641, -0.3942682346077227, 3.9679426151377086},
    {-3.1369671703339934, 2.549984966268972, -1.0709591334593573, 0.3310714867275778, -1.021824722672796, -3.3445406990079163, -2.4008680642673648, -3.1066951114325745, -3.3266323145714103, 1.3390995219810091, -2.6608633117480984, -3.3461951924929596, -2.494733377949059, 4.077534056556973, -3.2049435684450938, -2.6228763891198046, 4.193773539475013, -1.6571403099374007, -2.724762829910483, -2.9668404295318416, -2.883544257244836, -3.23601079747867, 2.856074613602435, 3.6878531729913107, -2.399732489897781, -2.6204185938335023, -2.920284444578624, -0.5717689267681239, 0.29628811953799333, -1.568441667727905, -0.12181395457057931, 4.02096597067257},
    {-3.4326500521447922, 2.6427954070084847, -0.7477452117097124, 0.4755892394229736, -0.8414469780329723, -3.0966465213773255, -2.4724868772935165, -3.502046208841166, -3.6968734961670395, 1.4508524755919316, -2.553969600770681, -3.3793955663097837, -2.3830244428252723, 3.6902944443604913, -3.428741984145845, -2.5227059336287083, 4.023609116615896, -1.9627476408637832, -3.130131629698063, -3.0760985478802425, -2.910691542793729, -3.4294989805463083, 2.960809877225982, 3.83673544576092, -2.543040455442948, -2.6572434331217636, -2.5769781648955523, -0.2347390485379971, 0.6333125149946087, -1.2128359680756213, 0.04282336946921279, 3.880654479260194},
    {1.549728074515775, -1.5447680879451724, 0.9611916432264278, -0.13260574900284378, 0.5847736867936018, 1.4330549710413636, 0.8665143653273509, 2.0920216810945162, 1.2702452770829415, -0.510427362660895, 1.1301403213974277, 1.769568713534682, 0.8110108734594327, -1.737164685485459, 1.4423252628600038, 1.8824379206634991, -0.7623325750944694, 0.6422666992298479, 1.0757105918963443, 1.2717670916716861, 0.9906156036419912, 1.4231853848514808, -1.6553654076265927, -0.7230105221189701, 0.69057708836089, 1.8963061445864384, 1.205351157942622, 1.0378753943466488, -0.3942058997572155, 0.8317890460705415, 0.5058255597073857, -0.348689572821116},
    {-2.7058766185841, -0.9904269998914297, -1.2971669994143247, -0.6404583873396016, -1.7417634297957374, -2.6460200069122615, -1.6533890009634056, -1.6819140894520928, -2.4803450403024296, -0.9009041279103074, -1.4405048497497113, -2.364281678686715, -1.1642430869187823, 0.15013373313434128, -2.5606251641754127, -1.3687880947222302, 1.481273991925795, -0.9020534423036292, -2.086190494430972, -1.8001923823527524, -1.3977563932387111, -2.578381302393072, -0.46603120568759293, 0.8053643626287162, -1.0523353032793825, -0.9503834755827205, -1.6270404535410445, -0.9883623512164514, -1.672793347989063, -1.1755131867644601, -1.156376795906125, 0.9254522323936819},
    {-0.7828649903040863, -3.1178328530756323, -2.227505881509329, -2.165355972835835, -2.2481335719546713, -1.1857164310519628, -1.3708119214041343, 1.3424183114094506, -0.6273942019662858, -2.7968047213900484, -1.4293979505904697, -1.0378454893616194, -1.9957693743731275, -2.843252075750592, 0.038439487820867785, 0.7875611434626699, -1.6679700059098705, -0.35920547088893895, -1.0569784456647628, -1.081290961293036, -1.1895037675951914, -0.7813006917002462, -3.165150232399876, -0.9758447098281456, -1.723885657581241, 1.392667948580808, -1.0867054557797975, -2.181582762281025, -2.2066220505219487, -1.5154604832137293, -1.5875224479822194, -0.5237614845003662},
    {-1.0394997512927515, -2.587572748049388, -2.246307882702301, -1.9571812014049734, -2.3625754086344575, -1.0842318445170256, -1.7334628284625508, -0.5104210642380116, -1.6538193652270123, -2.6308419568971324, -1.5435013366787005, -1.4042827502921185, -1.6911026160231817, -2.2194374808921116, -1.0337138963793937, -0.4023571703975395, -1.5556374694814281, -0.6281570056356914, -1.62448743907936, -1.7730323013895335, -1.8180956466473872, -1.3124849234090459, -2.7957649902600563, -0.8795788847723305, -2.027377383716892, 0.22708454168118658, -1.656524653953112, -2.52477686924522, -1.8037521013785258, -1.0710319290461054, -1.8417253974474816, -0.6480028809285976},
    {-2.3478680986384175, -1.916217613512186, -2.5756333036789614, -1.8995922081678143, -2.7245664162854903, -2.4564496748206337, -2.218557477841988, -1.274841897473825, -2.5268295186731966, -1.6855934119776348, -2.5014107132010768, -2.259081457271197, -2.3089580328728525, -1.3121940116538675, -1.7177083584712487, -1.4646545863832816, -0.4463888397356286, -1.5325864150120685, -2.4851853812070135, -2.5728195608390987, -2.4281114351758952, -2.3145558617839797, -1.665951542809266, 0.001386299113321299, -2.2393485309825714, -0.8453398696792562, -2.0987696669071134, -2.5245349015075154, -2.5137121924988626, -1.7282822303444079, -2.3748972897296903, -0.1728493056106659},
    {-2.6265278030006134, -2.470435028393499, -2.5738381441236067, -2.0844699136300586, -2.6999506791028316, -2.3638160210194576, -2.1737667938274767, -0.2617592173855766, -2.0532654366170884, -2.1637985435713616, -2.425741284706921, -2.227100243491176, -2.3399338548225526, -1.7905324167315035, -1.7154732525469936, -0.7912364910812614, -0.6651468254779023, -1.08717536523863, -1.9244563089769966, -2.3718088621729034, -2.222895727085406, -2.517085825556639, -2.3816827039039823, -0.1977365516257034, -2.2175882508601816, 0.01695885152918841, -1.8327934475829748, -2.9133948910842156, -2.848869447001746, -1.2686829223398834, -2.4949691354261767, -0.05656551158575151},
    {-2.122503725064828, -2.396010243218542, -2.560237865688327, -1.9527667464901497, -2.757151587488529, -2.185252608148823, -2.390951351609284, -0.326695908084737, -2.0678319245033334, -2.3447697899676228, -2.2019144897009264, -2.177647828807077, -2.1405610903894208, -1.814047249343514, -1.7377992294569422, -0.41020194032254764, -1.0453442561593622, -1.0018344218319788, -2.245009192744551, -2.306025088987996, -2.2488381982074115, -2.2867578960906836, -2.4771614911376036, -0.2709614467145011, -1.920725103793937, 0.4388827444348043, -2.139759190354818, -2.7240946232492758, -2.5100595432779604, -1.6193806817378027, -2.381750228140677, 0.05385421085173723},
    {-2.0121776933129363, -2.427967027035671, -1.907916588725411, -1.8039783168274144, -2.8409662494250005, -1.8909959838917882, -2.0425388485524243, -0.1901518530082244, -1.8265083673532772, -2.2871831822326567, -2.065910845289473, -2.4612947106425014, -2.0508746884294253, -1.995018907675108, -1.4451556429955115, -0.8667044016039444, -1.3836198817615375, -0.7041679844475828, -1.8907845629552413, -1.9759054720830738, -2.0136254922994707, -2.198458352858163, -2.525664740482155, -0.5712897129615995, -1.9706916997010215, -0.2926207284581701, -1.9478711901620478, -2.533072118777114, -2.660418131237291, -1.0296411180125897, -2.5440169099450287, -0.46883778893991884},
    {-2.2878215884666484, -2.9452171558254108, -2.5590037067473133, -2.1175425743107867, -2.3998906956460497, -2.254822478639973, -1.9981479301416745, -0.310831117116658, -2.461395617613396, -2.4788915691965983, -2.131846871682153, -2.6668943114288726, -2.545005547210698, -2.0518494158699943, -1.8620517316919731, -0.45149298235868385, -1.122618081307271, -0.5196673269586064, -2.184669907504599, -2.4509318654684176, -2.348443119908133, -2.203276213136501, -2.3314684924957216, -0.3454924260946025, -2.2980003745923483, -0.04920567996783711, -2.3428122170272196, -2.704719791490843, -2.53169396440427, -1.1343802635517748, -2.2769104803654483, -0.22205473677603457},
    {-2.23732336336419, -2.637984519499166, -2.4400292683944156, -1.7204048938642846, -2.420218901149497, -2.2909466704892902, -2.28101465586933, 0.0860053552877634, -2.490700557071754, -1.8285185798639254, -2.578878137939162, -2.0781830028933097, -2.5702373072947773, -1.7968352897118836, -1.151261388515464, -0.2575257882004281, -0.5993389684098891, -0.8685319582265886, -2.0076786277309258, -2.681191413400669, -2.5309271246384717, -2.23452004734245, -2.1494861179494973, 0.3777118894456835, -2.5779063718981803, 0.4751579542927467, -2.6037988321254963, -2.145528816196134, -2.5934434863144276, -1.211862231918831, -1.8198856681110538, 0.6193805519207319},
    {-1.9521090854028824, -2.51503597021115, -2.1156964803796465, -1.9644745917278161, -2.545837869113537, -2.018746810515354, -2.200539662649707, -0.01335771101363191, -2.18167757640685, -2.5507364939981727, -2.1260170498643456, -1.8158220703713044, -2.2669217778153454, -2.283028271970347, -0.9690289367754996, -0.7819859718081097, -1.4989726760668556, -1.268897607573591, -1.9665628331881058, -2.461666502199069, -2.593436849147147, -2.2231592879906144, -2.64026559831717, -0.7994288068113227, -2.1929617215893176, 0.19781521903012203, -2.140655388171154, -2.5297853052748986, -2.5361564100955656, -1.3977151707888373, -2.5903651976567956, -0.548998883348058},
    {-2.4327305492821814, -2.9195332487931567, -2.7413221291571257, -2.1499947118984686, -2.762795801579965, -2.1470852363733366, -2.372393512490252, -0.10629925718874401, -2.540361344128628, -2.625434058507053, -2.395413747997743, -2.319074299737904, -2.728819007846168, -1.9249289776786518, -1.800536539378141, -0.6834219466227709, -1.1037874634841678, -0.9498187361182058, -2.148824153440796, -2.6039025898286643, -2.49492665591812, -2.6191309214991523, -2.568846330800873, -0.6091614190725875, -2.7854910075245995, 0.46626142243596125, -2.4909331212548134, -2.545447751647314, -2.7937451189085447, -1.6899980266154595, -2.4141312969570685, -0.5875103375358889},
    {-2.516905598616823, -2.981461190606568, -2.3195938701408534, -2.1760786178076685, -2.6897536970843565, -2.336411331442445, -2.7635885230740977, 0.06487724334749377, -2.7071920026847454, -2.154161240103771, -2.638047544231593, -2.3123472804281344, -2.7526246868742477, -1.8698324511518565, -1.6866216130755578, -0.626477766430936, -1.1593133692951276, -1.2874218138154068, -2.700079967048722, -2.615378411841091, -2.8654206083070686, -2.7169855677936505, -2.8803583724229385, -0.8715504043078522, -2.5832190434837394, 0.24346965340697801, -2.3553394990122976, -2.7395956160550377, -2.7103811361218186, -1.6265719176408615, -2.440740340112277, -0.1566044067155105},
    {-3.0249497477515757, -2.94714656776098, -2.7313380782470484, -2.506620443482627, -3.17034054336925, -2.6039197330383477, -2.2693534031445597, -0.01805914464365283, -2.6380622989124674, -2.638343055063385, -2.657632645894037, -2.901654097335982, -2.9304417595655345, -2.350111462610263, -1.8045115094824493, -0.744010975885323, -1.246767732327588, -1.0527579399493405, -2.253846474432065, -2.896617720644932, -2.450555739721529, -2.482671931161022, -2.9242196296657927, -1.0010195119285816, -2.467688305498294, 0.2318844782206149, -2.620052457726495, -2.7142691883304155, -3.3434504404986307, -1.6392682397180767, -2.4247886103202902, -0.4252223253899972},
    {-2.478745629128621, -3.244271683045722, -2.520784646217593, -2.221658321699676, -3.0519369299246275, -2.4913702454609994, -2.6135100289735176, 0.256222399275103, -2.0081641201165676, -2.5054179208393497, -2.440308083208754, -2.6631394674606588, -2.895983358660075, -2.405297707987869, -0.8186345232289831, -0.2231933738344382, -0.7650353557262368, -0.7674132666579571, -1.9766786047612905, -2.6110697057732732, -2.6735109161708643, -2.192467715693338, -2.8372406642738994, -0.4809220697687675, -2.603328965844385, 0.6442476625090451, -2.456519186954353, -2.4825384033164437, -3.274549777125753, -1.3723734391787439, -2.6860588540575465, -0.07437378739408938},
    {-2.4578811846895867, -3.3393595622389416, -2.642664502003604, -2.4758620680749264, -3.0322650909630595, -2.7108392025878096, -2.2396719755059586, -0.12142722352973433, -1.939438533368124, -3.2484953276297848, -2.1737771911917716, -2.3680187780271202, -2.4610963690776146, -3.15963877227849, -0.9277085948748071, -0.250091217504728, -1.6433065310561223, -0.6656870932038335, -2.2133851071916886, -2.3198028745337145, -2.189566044679355, -2.2778859267525773, -3.1837271552784787, -0.7627221911136173, -2.568661719706719, 0.32547055631677424, -2.183768520912974, -2.9990539398993272, -2.9276177844659412, -1.9370276239794595, -2.4945184770537963, -0.6181420841939798},
    {-2.464301427560016, -2.8155281380483106, -2.401095772835669, -2.3859737226087923, -2.6039909057324393, -2.48132483608189, -2.2116660100111516, 0.040288351637658995, -1.9660178801052073, -2.947757088324949, -2.258992534827407, -2.363753016346498, -2.5037606383004793, -2.4099788374085414, -1.0845172438434174, -0.23892986884701037, -0.8998647662030422, -0.8633166524638061, -2.124185157901541, -2.1549282596018453, -2.0768392981812367, -1.9144042653663245, -2.7483203376545053, -0.16236690200313364, -2.3785152987636176, 0.1917327835792435, -2.1994708983126183, -2.812998233456785, -2.6025977389425914, -1.2420693061679366, -2.189264530241766, -0.5417207506584587},
    {-2.0020540904301583, -2.4779527299485697, -2.1160832770403037, -1.5184260097835964, -1.971487527294842, -2.3587767660171592, -1.8775505011583986, 0.12361921190075677, -1.5744646739893045, -2.448086898309752, -1.8220951105450447, -2.1134304903928847, -1.998951641361794, -1.9649054245410829, -0.9996551664630547, 0.04019703192639173, 0.18032444748528278, -0.1519558991239747, -1.3922477006527447, -1.6843058479877397, -1.437531890900859, -1.728971650561701, -2.4190544683563764, 0.31566077349282917, -1.9374310523526723, 0.6209560142325528, -1.8065268570713633, -2.4907058306920318, -2.2887461901585953, -1.0364399628050764, -1.392077379568765, -0.03779451563262911},
    {-2.0486084166268657, -3.1993889383757925, -2.3563941383078113, -2.429506868226302, -2.412624680734806, -1.9154109889697153, -1.9561651868704368, 0.6413622681029446, -1.388097106072039, -2.9942384655644774, -1.6187428486550755, -1.7312268129230008, -2.2259916639027444, -3.0237825716097, -0.7375471350296074, 0.29470857387318283, -1.3474983388610053, -0.35722161411095815, -1.2086060684588171, -2.0085212111277935, -1.5013481948808571, -1.5190061312799295, -3.133097207334492, -1.5272402639928162, -2.1527610883715433, 0.7284873922633446, -1.883341298145473, -2.893289403257046, -3.0563673886366205, -1.404665742416537, -2.152387825895976, -1.2924963205052464},
    {-2.6155852488261604, -3.41862746260849, -2.80786919403143, -2.642177989974069, -3.442628972395266, -2.462286688225052, -2.667964685817037, 0.14198104650508914, -2.4129443806298028, -3.142357673136993, -2.4696587308721942, -2.5293668032770205, -3.0640174536679905, -3.103067477427186, -1.2355161251595859, -0.12317150908669675, -1.659200081142397, -0.8599366085608745, -2.166434855877967, -2.9624910699381375, -2.4033791980027512, -2.2394647459928434, -3.3601881558351288, -1.3226357594847356, -2.729341058875736, 0.4096305802217481, -2.675613054379539, -2.9616235428036966, -3.55739977699991, -1.8936193762771303, -2.6808764751685863, -0.9436460700292318},
    {-2.74488480292282, -2.9727188874960255, -3.2770006824453146, -2.995976792496581, -2.9841006509665537, -2.7267376691294665, -3.0437742975995197, -0.461152339595477, -2.6717967176041624, -3.0095233946764903, -2.9556664254399903, -2.7358818668593066, -3.1620681353575795, -2.189584104695076, -1.9866651308546863, -0.711236591104719, -0.9745079819454321, -1.4134424083059167, -2.5312272039860373, -3.1673363067945757, -2.9105429354212777, -2.5191354349664383, -2.5521765033142616, -1.0089916607031308, -3.214179027400341, -0.28478056172775557, -2.9678957345734944, -3.305314693565083, -3.0310131806743463, -2.425211490357759, -2.728687733777447, -0.3932457267358062},
    {-2.735704132986335, -2.6406316603040394, -2.461435619185328, -2.4774086832466096, -2.1101942501864985, -2.265570174998502, -1.8264887511536485, 0.25719278769633824, -1.4419048171985027, -2.2755158024855344, -1.7088795242100179, -2.374450632576786, -2.176564602328066, -1.852682805523808, -0.3326507837056004, -0.0682661932647088, 1.222334597324347, 0.7454614384446386, -1.2461931830716924, -1.9920967737557036, -1.547541013540639, -1.894015738771293, -2.314333616174518, 0.7094421507002318, -1.620969511942419, 1.1906105863220453, -1.8043990845377198, -2.4815964286535, -2.626261676684613, -1.4851191871283334, -1.6137180774953626, 1.2637587945348734},
    {-0.629226157924821, -3.524347848597276, -1.403666641138789, -2.2802589009857517, -1.769358817090105, -0.7027192280866084, 0.01400904213240388, 2.2339687319232784, 0.7737225901546823, -2.537938461018428, -0.16984668015013993, -0.2374860421734673, -1.368243373350567, -3.3038041985661404, 1.9412763010241136, 1.9166022392231066, 0.4816023044695578, 2.3605389915068873, 0.5894391096874083, 0.09554860670166425, 0.031227564019157363, 0.10535908189584843, -3.264975383027441, 0.32954777007886815, -0.545833341720925, 2.7973817783597217, 0.1463130971898632, -2.0996527893291437, -2.731514942350961, -0.5265847497137895, -0.8545529595849648, 0.9525593980039941},
    {-1.5687935848396952, -3.95614506396285, -2.7980363098780585, -2.7416419361936555, -2.591931035130661, -1.3735472615024835, -1.5878891262029344, 2.0529169152678057, -0.3770917166965238, -3.2586563460387015, -1.8747610252294526, -1.0847465198457544, -2.617648418122789, -3.5942178635203534, 0.7017894990850634, 1.1876455506476737, -1.118829397169167, 0.8181331230205989, -0.6785452018133166, -1.6882752258352884, -1.6118648172406091, -0.9805548752146395, -3.9128361915513428, -1.0409768198550293, -1.900591705395851, 2.1211407721565236, -1.5229508322315346, -2.955993167091685, -3.358295650266637, -1.5613918344128686, -2.081353994015946, -0.09631719720912327},
    {-2.5946443216404993, -3.761840163088143, -2.7699142539587114, -2.755084934143968, -2.852492179800514, -2.5812613758678005, -2.518266139721251, 0.3006801069916053, -1.947340111639484, -3.3126214708831276, -2.6268290014044244, -2.754019389768765, -3.242893349166202, -3.16011386379087, -0.7778566717538224, -0.2137031840956083, -1.0876819164560882, -0.5526383017100581, -1.9413738940746408, -2.51873509731034, -2.5486271993145944, -2.2879320421985625, -3.6680308690066776, -1.261834071395791, -2.750552329179961, 0.7867278486820918, -2.4062937174270917, -3.3363296029733585, -3.4170795921562735, -1.8174757632313314, -2.4818743530609577, -0.2778063829251327},
    {-0.9096766764387731, -4.112809130684119, -2.298075431362133, -3.02773102914316, -2.4233448537524733, -0.9241607641304619, -1.2295881885550675, 1.8419631166012929, 0.06097521029676969, -3.4053008742578825, -1.0948663945552246, -0.85109200708946, -2.116613277516551, -3.5538788791562785, 0.9818828974244433, 1.61814240913176, -1.2299205187576507, 0.9269108774948904, -0.3893945430524842, -1.2096855883012703, -1.2012316130947078, -0.1864688102656521, -4.198221291648105, -1.1464443780365332, -1.6164351315267225, 2.1246665501016437, -1.1286311131678004, -2.898936632459705, -2.9392431789234257, -1.1195552075517154, -2.0443423424524623, -0.6148687769634992},
    {-0.9783834695644151, -3.7397692230102386, -1.6469238029928417, -2.322230168680896, -2.3017662337216223, -1.3239180145279823, -1.0057654329430665, 1.5701129645930887, -0.2263279957872632, -2.8518409788274686, -1.4170714095810073, -0.6636930521939587, -2.0207474359336666, -3.1219138634948287, 0.742774434886104, 1.43450663243182, -0.4256051972847504, 1.0955152573329119, -0.34119528952331135, -1.3355287151970872, -1.3649781243617656, -0.30160217473851875, -3.6004371930795562, -0.5728623449556902, -1.7661594134456633, 1.8817421250678699, -0.8551871419256165, -2.229460808534079, -3.1371711727747478, -0.9443011932764057, -1.8708170578730032, 0.42628195779772027},
    {-1.7575281079145024, -3.8501497211348132, -2.4219186198009632, -2.751406054221945, -2.8324077804479453, -1.9718543782892684, -1.5232075602924795, 0.9904234536802767, -1.2649111394495267, -3.2132717778380075, -2.057748932938235, -1.6126064425771596, -2.628506798981602, -3.0756302443978347, -0.19317902338823487, 0.5016473892873563, -0.8455530258923656, 0.5626090276558903, -1.1518316512695772, -1.7272151878983484, -1.5031744134888176, -1.3215791801674341, -3.7843845287139404, -1.0097644079480101, -2.101847662689833, 1.2424926828186271, -1.4449978176863731, -2.6567012802662644, -3.164651897418078, -1.4636621201620441, -2.1673132984467225, 0.08231736332884457},
    {-1.3553526700307679, -3.8389270329608665, -2.373023548281357, -2.4770301773846244, -2.566606627314411, -1.3272077334714376, -1.134297548153351, 1.7264384231424692, -0.5120031848399323, -3.0725360092115666, -1.6197971345926552, -1.2558295792731458, -2.1671197589458573, -3.379571615184412, 0.5305774133321174, 0.8961304737543715, -0.9752158668735393, 0.9844057448643118, -0.6557220300702713, -1.2788816098954878, -1.1277177156628513, -0.8015705963600616, -3.791177450103894, -0.8793940207494108, -1.7397154460845408, 1.9036311977174991, -1.0008294109574185, -2.863678532607489, -3.1863537024915614, -1.0822303920403304, -1.995631802274564, -0.32522995547493766},
    {-1.11690895845651, -3.7822454362186675, -1.4364196682369403, -2.1658173980637794, -2.034385456786561, -1.1167342254984942, -1.0837492015312913, 1.8230148286662748, -0.28300340769109766, -2.753076824680558, -1.1770855433252962, -0.9819942577871024, -2.122858523917273, -2.967547958959325, 1.053615001291987, 1.5971995238982941, -0.3098647718456385, 1.4436322770449976, -0.49701973458861926, -0.9270227687974367, -1.0653704848881855, -0.7781168812830832, -3.5432291693800133, -0.24889169513463655, -1.4834819517473683, 1.9998958886722629, -1.0487477307340525, -2.3711826582126365, -2.654385063300272, -0.6864284627013025, -1.330646409112628, 0.9002836770497737},
    {-1.1272788420816984, 0.3953817068334173, -1.7669996730403235, -2.2106958134260966, 1.5311707660423939, -1.286100152504111, 1.4974138012355014, -0.882519984502102, 0.6589703445028756, -1.8164637633596221, 1.2416437630174757, -1.1079924168364141, 1.067085132583553, -0.945021146076805, 0.5143217190770452, -1.3051570378960278, 1.0772349304657878, 1.541686092871903, 1.046149341394269, 0.6646180105183522, 1.065369725641129, 0.2112862723129703, 0.5467979506909021, 1.0642965075140314, 1.371284824550954, -0.8756529114761877, 1.3254884202340282, -2.0829742398873696, 1.2746815093184172, -1.9917874458066276, 1.8986173277612814, -1.868083224989401},
    {-0.3748810343858239, 0.6370413533679666, -1.8424029888766726, -2.295545108049137, 2.162939205058532, -0.6540978499180439, 1.9662970335309955, -0.915317739259194, 0.7401728671645964, -1.8931269053612945, 1.463840385760522, -0.21814086206675862, 1.4115124918282373, -0.5906266139709153, 1.136101107617556, -1.942602812968931, 1.0840795186372016, 1.8731664906350431, 1.505266265235007, 1.2906407672214737, 1.5970030688247037, 0.31905678118443737, 0.9803962410002894, 1.418198817874796, 1.6963686817835304, -1.2352250759522003, 1.570576285911132, -1.956095435738562, 1.7517486983797863, -1.84324994310962, 2.207681033234707, -2.119962096740278},
    {-0.3375903662536751, 0.3652084160909183, -2.245090316792228, -2.752917159312839, 2.495169240411021, -0.9406385363817621, 2.081054525214264, -0.6733293938665921, 1.0050171833486394, -2.449054354490978, 2.0281166625352665, -0.8224159271975079, 1.6774471060898608, -1.6826032272197118, 1.6181213751053145, -2.1624455988872966, 0.7174139513612581, 3.0097947045201567, 1.9248510514439623, 1.579369162251069, 2.2060172225377968, 0.429734780825731, 0.747221089427195, 1.7316708666696379, 2.4449258607784783, -1.4139719832035478, 2.02466704215395, -2.4633310898535705, 2.4829973802956977, -2.4798654365004613, 3.1210086725682067, -2.2682557470543228},
    {-0.19811103389867604, 0.6500122963927002, -2.316722642751762, -2.2148269007641135, 2.5827145404150698, -0.8508301243716148, 2.149589589977249, -0.17856239165209684, 0.825256099313225, -1.8069335702767586, 1.8412028120134707, -0.7673330694078506, 1.6162236156207404, -0.841585210997242, 1.3868257656690894, -2.1693363182721743, 1.3971329872428828, 2.776306414243701, 2.3279223265911018, 1.7111415031179762, 1.865450268073122, 0.5002702736999249, 0.9466151963708264, 1.9829086430145253, 2.274356479350478, -1.4001577281934952, 2.348186562846611, -2.51237623559667, 2.7408118110380912, -2.2232592896541155, 3.0620937137159965, -2.1390465525470232},
    {0.12456759685975721, 0.6683430888242734, -2.382696870250156, -2.345300023443643, 2.3110832047313243, -0.7263073857822439, 2.214799430895264, -0.490678122801232, 0.8646223624378364, -1.6574688666187793, 1.6875958423423183, -0.22702200863520153, 1.233351122017276, -0.9599845493405578, 1.1179607610187794, -2.2402220221317455, 1.062755173545881, 2.4568489466741608, 2.048269486225657, 1.284274374021436, 1.524816984864622, 0.3151336675518932, 1.2739005932209835, 2.2778013654220257, 1.9572487749576735, -1.7014627091408094, 1.98369043781106, -2.2726555126039893, 2.7703104151866036, -2.282133056265447, 2.884606159126984, -2.007888570666505},
    {-0.0842865024166229, 0.4588886350119496, -2.3880698977499386, -2.6268915992302677, 2.4420503465654786, -0.6956382549235142, 2.0431886884725654, -0.5664849396820542, 1.403453508066249, -2.3451039529020488, 2.226454412208939, -0.10248303593426725, 1.4369379508082967, -1.011165026419454, 1.8565802623771037, -2.3282272034400338, 0.9778484331372795, 2.872851055670846, 2.3730158336001876, 1.6384668186056572, 1.979405465076455, 0.6601293599085136, 1.1681555623203594, 2.180145783546677, 1.9231414576123096, -2.1839744636975102, 1.9925097283234665, -2.349734233870847, 2.4797816117184204, -2.5490066000008986, 2.674023975362068, -2.3490648020287166},
    {-0.4019717792836667, -0.03476198042302552, -2.3562838250491325, -2.704903931896257, 2.588941931423719, -1.28613256412547, 2.220228321602664, -0.7373827923233426, 1.1209187153822526, -2.6611284830641924, 2.3057230918688476, -0.3842085824688027, 1.6273608705520044, -1.6383796674876094, 1.8504764208386824, -2.280520997107854, 1.1771030091977812, 2.5351446067973753, 2.0896317706520993, 1.662669316880515, 2.2317234030774267, 0.7551613606539962, 0.523019177665992, 1.8301476068896128, 2.3429188811903887, -2.018899076801136, 2.4528947358605797, -2.6023273843817365, 2.527299188921243, -3.0765307368802013, 2.588621739731084, -2.8560071419713573},
    {-0.3701556175956558, 0.5723186282773214, -2.4245630520145642, -2.5210400151522894, 2.6599727198367136, -0.9830390728863326, 2.58086206882007, -1.0053343269038215, 1.2248502031368425, -2.2219903543566497, 2.3568924187949145, -0.829075726836193, 2.0588521523534586, -1.0969574506163147, 1.8137111031991795, -2.4078815663473674, 1.5560073890950468, 2.687474498496516, 2.018258197377555, 1.8667609272618106, 1.997256671046211, 0.8376086483238226, 0.7281099893231611, 1.6037150808203342, 2.5482912242755065, -2.0391632358146814, 2.408411342117159, -2.5771666723085134, 2.792552659107699, -2.87209611060234, 2.7216659522825637, -2.667054966906172},
    {-0.3226073986149768, 0.6694861912883994, -2.3691774424679948, -2.5754876913401943, 2.6059481973403917, -1.0700205375193008, 2.5332683749612586, -0.49614915105502333, 1.6365172327030628, -2.2135607715702705, 2.5307159984075422, -0.5986381390037446, 1.9912518949711289, -0.9552958033947397, 1.9876211221911126, -2.2417747915384774, 1.8182776261887401, 2.9921610294094476, 2.4498455743875573, 1.9538423230008886, 2.5187588033722306, 1.1166278386579718, 0.9238265560913256, 1.8479269666503753, 2.352019123340995, -1.6336650917779356, 2.507242777679234, -2.696076828238714, 2.850846142220342, -2.7453144756008903, 2.9211489195075986, -2.541021989460527},
    {-0.3070424527174562, 0.23620296036724767, -2.5118730166463665, -2.361951404791112, 2.573182567203208, -1.1599033035256388, 2.7566729208073504, -0.02851216922275523, 1.3867313711858953, -2.365083025355099, 2.5280732343123464, -1.0329793958737323, 2.1619657149436664, -1.3636813105075556, 1.9287555889287087, -2.3210096334767223, 1.7804903993301795, 2.729532288156462, 2.620865282913846, 2.458754822144859, 2.366278600401556, 1.279392782355503, 0.7590014006792647, 2.207818133576303, 2.6452460884913993, -1.532170263733643, 2.611639259475775, -2.793625241204636, 2.712079616829092, -2.5672097361955424, 2.9118046402432913, -2.534847005531355},
    {-0.3211962110664569, 0.06366120902596759, -2.397507549839321, -2.2862352640494836, 2.6954179211645, -0.884827544852717, 2.4189629761424363, 0.0596275469740767, 1.1822550436789974, -1.9473665425585585, 2.131561650428447, -0.8143004507801033, 1.6580806893064717, -0.8699214746498383, 1.929292629638169, -2.088921601931655, 1.999710471971397, 3.0795924808555513, 2.1043985369334677, 2.153203136982615, 2.2375564263769117, 1.2920921851670557, 0.9503586570994288, 2.176113533567632, 2.6218829280440854, -1.0718850807234006, 1.9151490079966675, -2.5050370094407888, 2.2421761235227513, -2.704087404686189, 2.8339977071144413, -2.4073754995404664},
    {0.07390373386149694, 0.35325780194511464, -2.438005939632586, -2.589778441445271, 3.0247779990993915, -0.9073929399815861, 2.789967915285989, -0.2778800984835766, 1.4405963842020166, -2.0552177206757207, 2.51310347193833, -0.06025345062702725, 2.201984564396971, -0.9071622538580177, 2.0225252215339746, -2.335584004994207, 1.777298162746822, 2.959968393892703, 2.50724882023583, 2.06334070750119, 2.4751288697400176, 1.42086622292053, 1.1838009401407914, 2.224978672844003, 2.5160424824370677, -1.2872703070060891, 2.24008250171297, -2.882654712047632, 2.6087306113823954, -3.1153968205189453, 3.2127003898605464, -2.65677459632762},
    {-0.42243834618331255, 0.39937915710647814, -2.833979698302269, -2.810948172925288, 2.8763367665711628, -1.2216900346430675, 2.7772802120428595, -0.8220668442040402, 1.442383378832216, -2.213485068418663, 2.538883662966359, -0.37350532821792215, 2.0636808415320074, -1.2093328472625413, 1.891010075995757, -2.2249030102417553, 2.0108999054844694, 2.960566255318587, 2.67213643226203, 2.1775433989703643, 2.59580204448481, 1.44230743315935, 0.9190920323678359, 2.0110659824373207, 2.612743487655059, -1.4136373729292593, 2.6699554449173943, -2.687178379352269, 2.7699846188512223, -3.174096905497004, 3.2285043635200625, -2.797392708605987},
    {-0.3215517874459074, 0.49008448900701346, -2.4589210533156662, -2.461291022771489, 2.760691015140107, -1.0132156921046358, 2.6522929838436906, -0.4619337417183564, 1.6905794048372598, -2.0398468715078963, 2.5972584573827353, -0.3914247012778353, 1.9812927676177412, -0.835662014233151, 1.8955522977356207, -1.7824320552422426, 1.7561599276965725, 2.65370050026365, 2.2634180297063313, 2.230745888055597, 2.566187584780166, 1.487839990859292, 0.86176068514829, 2.394357608272469, 2.3493705391899184, -1.1207079228639703, 2.6292784934883437, -2.4353285172390136, 2.650228247599175, -2.9262775055695713, 2.866648444941154, -2.297771202355952},
    {-0.6093742382522408, 0.2815611091389547, -2.4193917663321782, -2.645966299216426, 2.144771544286591, -1.0604861976331201, 2.5493037146801614, -0.47349923473826333, 1.4755779911849027, -2.1826559277853703, 2.301177782232817, -0.4153428576275026, 1.2087521335467153, -1.7165814756055477, 1.8973599437019428, -1.7280511665358136, 0.8389909852703394, 2.507158069913994, 2.6625978555289755, 2.0880609774232215, 2.2991275836933305, 1.3365332818906672, -0.021104099332903793, 1.897986922467431, 2.3720821706326864, -1.6718760753653559, 2.46642258040137, -2.629896682142093, 2.070083799932408, -2.9414234389765714, 2.3590881069170955, -2.851737131258787},
    {-0.9542926141323603, 0.4599615097894921, -2.4397312127059525, -2.607788241694225, 2.646018977100328, -1.3282753563907452, 2.480103726355986, -0.873049633419803, 0.8717963375808918, -2.6191191370506033, 2.0106568688143143, -0.8654339714265982, 1.5540528129136657, -1.6828684332094688, 1.4624674560901512, -2.1304543643126785, 1.3242091899178985, 2.5599829283206814, 2.4734946397403066, 1.9130254090741061, 2.257900536447586, 0.5891259205211076, 0.6978631033044796, 2.243938385750424, 2.585224312351302, -1.970112291390602, 2.2021487084262716, -2.7055854606713226, 2.1779661484191393, -2.8745610472581036, 2.737825684862309, -2.8002363039238145},
    {-0.7340565439548619, 1.0130538387146129, -2.2679481315538292, -2.844984227195192, 2.8591806112792866, -1.1664934228519475, 2.442998858738694, -0.6016686564879922, 1.1132939970219502, -2.1921202854050286, 2.088814068579502, -1.0905355829783174, 2.058787044010027, -1.1087020775502439, 2.0443076642912112, -1.6971211613913044, 2.1357530664961484, 3.123325394331686, 2.2652882009282687, 2.2324990968159493, 2.0833581437090025, 0.8766152761052176, 1.1489784196160198, 2.7842740906958587, 2.8226421086558937, -1.596848262563563, 2.249773476405296, -2.7594361385915716, 2.7223053260426413, -3.225613328766949, 2.87665214466266, -2.1846285843547983},
    {-0.3153379080303298, 0.33516837250627385, -2.694212331091648, -2.5845455099077213, 2.78193334674452, -0.895166229295032, 2.5406175227499626, -0.4726260736022674, 1.389750039463566, -2.291727183078454, 2.075153410195867, -0.5591609834150425, 2.302870006172335, -1.4011401887105543, 1.9036507667637903, -1.6049143221615267, 2.088233313679138, 3.2004667614647926, 2.1641757667697177, 2.139789294880741, 2.029297778475367, 1.3253060302895863, 0.5713650369445407, 2.440183858864381, 2.7315002339031182, -1.1934737128235515, 2.5363410003789357, -2.5727977778841375, 2.907134972462906, -2.9088143696693844, 3.038771313211738, -2.298081999160272},
    {-0.1167570476145637, 0.2969209175275849, -2.846050492394215, -2.7005982128259047, 3.1309526744919163, -0.9987950544910872, 2.540119224605981, -0.7186094835523686, 1.4288240593375765, -2.4825511351467195, 2.3987300509741423, -0.25943821251951943, 1.7990826115898721, -1.565041978560603, 1.7605961060980249, -2.2345399038129967, 1.837735025742789, 3.142497644665424, 2.6137140357641884, 2.4767118158823296, 2.4058648707505377, 1.1231895513714976, 0.5676096715032778, 2.3545348382166984, 2.7094802533423787, -1.4728141632825882, 2.3606477709568123, -3.0188248123574453, 2.801836868932354, -2.940688961837373, 2.903748822101808, -2.7832673963219468},
    {-0.050354086069334024, 0.8320490475558259, -2.6643587968232034, -2.7998801909755113, 3.107764510402737, -0.7716520930127545, 2.71666611889896, -0.4898307134522554, 1.3198053765296136, -2.6438427862362737, 2.7532162658303965, -0.6798669739279286, 2.061080109615779, -1.4502390839968433, 2.054810125732242, -2.055768111785784, 1.7910549987040996, 3.1901805141590236, 2.5213923054879217, 2.594848844819062, 2.5146928478006827, 1.5993986723285163, 1.2960095612365843, 2.854243155611448, 3.0173310847411003, -1.4832222132401065, 2.7536420353113975, -2.5797559455353727, 2.811723015588654, -2.7031476939777117, 3.37605721505982, -2.6149047816762474},
    {-0.5654532733580745, 0.8514930998360482, -2.6007831652724263, -2.6940470839015083, 3.023378021079176, -0.8890715549650317, 2.5978425928175075, -0.8671096248324752, 1.1443062529234784, -2.0979406137083236, 2.4189167911702203, -0.9510546486609278, 2.294810901210901, -1.0984436334781802, 1.400227423715224, -2.045072958409751, 2.0707695597597353, 2.8090411167756777, 2.671554265763721, 2.285766428555183, 2.1695006783643316, 1.1736576459525663, 1.0986145160601275, 2.684996094341293, 2.7011833414504474, -1.8234423756831162, 2.512962869441958, -2.592102572994637, 2.5940545755363003, -2.901090562954703, 3.0164696995662155, -2.2962018613532864},
    {-0.7816210107964543, 1.207469628395414, -2.297740752891382, -2.5532787517400584, 3.4296181169770814, -1.2068024238141375, 3.069310137639062, -0.3713118316629609, 1.3357276726926886, -2.2524218667043114, 2.87235604713291, -0.9369237904569245, 2.4152304933285604, -0.7031499603673946, 2.149471313756396, -1.5335188326278988, 2.2779250963563613, 3.0605247198525856, 2.874514472160885, 2.2522243905319614, 2.6273045337693803, 1.466348689394402, 1.2691889085016665, 2.9904152984636383, 3.0884423874790983, -0.8725986843362681, 2.6081133687505336, -2.7705113604364775, 2.72902850911212, -2.9952809398623863, 3.2214321489976045, -2.0395056691777755},
    {-0.8611943342414309, 0.21872125752055682, -2.5785934311639793, -2.9481443652482864, 3.1979404876824713, -0.9586352556928267, 2.7965089485288366, -0.3542396969267755, 1.4817398079101145, -2.7239273561097908, 2.828408339192356, -0.8301257723854945, 2.2598372407681575, -2.0627860391047315, 2.0262090934387182, -1.6332470024087349, 2.1639307370800225, 3.2631853208968806, 2.4381907313703137, 2.4292000720678066, 2.531924242883911, 1.3498398095804625, 0.671311025936669, 2.3334614857489604, 2.8804427965320527, -0.920526233088173, 2.8306881398583723, -3.043554277122474, 2.8848320680829387, -3.2722442300555974, 3.1785286410546703, -2.591552462729569},
    {-0.6318521815079136, 0.5647767466673772, -2.9550082235766553, -3.1154510667288395, 3.1921048943130033, -1.1694230549435396, 3.064479078113955, -0.8900809796775613, 1.3410914982832216, -2.7255951526643964, 2.602408218765037, -1.1383468801437688, 2.557354521191311, -2.0234362929665823, 1.677936869224464, -1.8190343084511258, 1.8738437260620513, 2.9999221605329103, 2.500807218275579, 2.3716332719786526, 2.775949233254969, 1.0669548917172025, 0.947729288505039, 2.347620072876441, 2.970370906131096, -1.3650195770167441, 2.9006164184898195, -3.1028736070152214, 3.04844695436743, -3.2516871357355783, 3.285751226962386, -2.6936868985827847},
    {-0.840678296549766, 0.5625314549325037, -2.8199669276538, -2.8308279424995213, 3.2841949538378383, -1.3270586786223284, 2.9049752971123457, -1.0693317644315015, 1.2742495885792873, -2.44765380613711, 2.462523613303055, -0.9155665490791535, 2.3692384462020475, -1.4422167689046923, 1.513031258580492, -1.9675993133242011, 2.2194224195142724, 3.1219771262110063, 2.4569579840738087, 2.3352847093704447, 2.388853769174286, 1.1027834189560286, 1.3677582951066694, 2.8556993871688046, 2.7420536551614183, -1.8626136203379366, 2.555575058381688, -3.0966712783423325, 2.8131424927509587, -3.3724246955070565, 3.487811162729146, -2.536460550280324},
    {-0.9918214249555883, 0.4706842850752976, -3.03981878370544, -3.2572114405919264, 3.2064684879020255, -1.3176686284886012, 3.0954857442364316, -0.38760909674827815, 1.2049665405503225, -2.9620368992548394, 2.661799863067483, -1.0365051015975792, 2.4660003599805567, -1.5749318550947498, 1.7122030103706194, -1.9187551272294765, 2.0185762005017325, 3.3864744163646145, 2.9141695150252684, 2.6114459236572283, 2.8339735472287173, 0.8762275286811668, 0.8523816749927017, 2.7345805607753575, 3.1574908946196762, -1.3322429125987787, 2.7183773197608976, -3.179703627164215, 3.0215467805596137, -3.178248174502783, 3.4150034892122108, -2.9304977909927854},
    {-1.0376832616625828, 0.12274298861644299, -2.9700752258634306, -3.252063113615633, 3.0331941437590126, -1.1659483592917748, 2.955014499517639, -0.27984772090215926, 1.2807009057103491, -2.686339670995959, 2.8427589831694533, -0.8864891823033518, 2.2651643906463694, -1.6942973153781307, 1.7937039367860792, -1.7210526604058296, 2.1816709792346627, 3.162661059032802, 2.643915998495652, 2.711047164933425, 2.7561387879411883, 0.8367837366252002, 0.778033653072477, 2.5590400961522617, 3.111864134999769, -1.425049377024173, 2.561803614641825, -2.9667938271351852, 3.130522708611519, -3.3631462319794343, 3.315962459165073, -2.951376396211008},
    {-1.1384741246401788, 0.05912465298025287, -2.904831823892712, -3.0495163094109006, 3.208919398320443, -1.496494174478429, 3.0752369650060327, -0.5558594063072249, 1.1594339495951793, -2.7847335586756725, 2.67115931834453, -1.0003586751051003, 1.8032437808373198, -2.0576350402116357, 1.7434216809526928, -1.8000534608374634, 1.7627336114518353, 2.8249622352728356, 2.8349705267609098, 2.6501374082918123, 2.537083266411859, 1.0166007295519464, 0.4764316637545026, 2.8004488323550554, 2.824419856366, -1.441818423910217, 2.580498130701669, -3.1991944370388747, 2.635900931905073, -3.219265649271209, 3.354220739725161, -2.5442666058540495},
    {-0.8038828667511615, 0.10627051810863027, -3.156744220396012, -3.0456248268914767, 3.0630951961652726, -1.275521569217496, 2.7985516258734284, -0.317392014157864, 1.0972774639168466, -2.787488683379176, 2.366573819024052, -1.0701350275928232, 2.229865107030962, -1.795512948431162, 2.061866674176239, -1.6207679911184514, 1.6152107555393098, 2.9138138145566157, 2.748918165694868, 2.582580347452512, 2.532511784825121, 1.2102190727070488, 0.9265325788184854, 2.2964701242231778, 3.109587678399592, -1.304259864125308, 2.786908819865644, -3.3136507757424774, 2.691430101867996, -3.457964256783418, 3.0344539070254974, -2.639908840150441},
    {-1.1497608481695885, 0.34131421531077805, -3.0245814013941987, -3.181991758992713, 3.226754710542276, -1.6092618684341244, 2.777444072022799, -0.16187072007491038, 1.3552745637573915, -2.954536221771506, 2.466447636862229, -1.337012909411158, 2.04087213300457, -2.2208083380218886, 1.9400572590907563, -1.7462519629578026, 1.7833258483356278, 3.1385945483500612, 2.7512479454782968, 2.477878302225618, 2.481271679121625, 1.0892914028625402, 0.7740961183578017, 2.588333814112236, 2.876493237824325, -1.0880036782590132, 2.6193254222337856, -3.0358954840277605, 2.607937159413308, -3.0296308954801363, 3.100448771956569, -2.9176641751293197},
    {2.233623721794546, -2.760686742754635, 0.5236746448673822, -0.8229611074595761, 0.2655679608735176, 2.0373760594189454, 0.9884171377658345, 2.6903481865660517, 1.893235473796143, -1.3952832200519714, 1.009328666393988, 2.2368518837694427, 0.7359333958918404, -2.2198444845641103, 2.2662796651554147, 2.1051453007414436, -1.5686028559456726, 0.8249189376706999, 1.7481299046614165, 1.442386148194209, 1.2806330340734393, 2.1740768171971965, -2.6487621167176045, -1.3678007015828455, 0.35874424630292634, 2.3815085136362084, 1.4366819283930732, 0.5358332760864524, -0.6954658031932384, 0.6115299171789446, 0.13234113637644296, -0.27598702247543844},
    {0.14875816806861353, -1.595534019059316, -0.9173387311806791, -1.0449404395717528, -1.0190341561695038, -0.48444082055136917, 0.20404244289337134, 0.6740699996147964, 0.5855759990381417, -1.3366553286269693, 0.23794219487301008, 0.03238998053395609, 0.24673559618819615, -1.3851003984837624, 0.03866311997126655, 0.30667681804085245, -0.5227885068925583, 0.585043228966095, 0.33701387169074853, 0.46242125629847225, 0.32192439751767943, 0.2871393746912453, -1.3426843792799648, -0.23355339761727992, 0.06893872224314287, 0.8651251835852375, -0.16782652471618703, -0.9488691187450824, -1.3320902514687392, -0.9941834594127287, -0.5713359146999561, -0.39873804082477965},
    {-0.6623817481465679, -2.8871596135072517, -1.3568949957833272, -1.4073510593321668, -2.3085864660757793, -0.20116441594392626, -1.0453215188077507, 1.6599427739047523, -0.7809306260967491, -2.138205250822909, -1.3576692447655023, -0.6919564373362377, -2.197976456805888, -2.4899491351364906, 0.256978024246613, 1.2319794703374263, -1.388972415616928, -0.36963743890515377, -0.9259122238684043, -1.3627702635978902, -1.365715307418989, -0.8719945569893328, -2.6000595220758607, -1.009962816250917, -1.8104970750760636, 1.764780966214884, -0.9749461219524025, -1.4410656516876954, -2.0496545265756367, -0.5038421427536472, -1.601149352466151, 0.5097518345639821},
    {-0.6365822023052363, -2.4147179846028695, -1.3219782950872159, -1.6920877326602133, -1.9203683447187143, -0.3639449638536854, -1.3421969554668394, 0.9867278944770177, -0.6544291059912352, -1.780207882752706, -1.3364779268037352, -0.6349892637000862, -1.8599215883916624, -2.1252703404918494, 0.20162057457478166, 0.21119000741557012, -0.9174452659041865, 0.03220697516693705, -1.1519491070021994, -1.5504816053317654, -1.4305490063959518, -1.0139726571122334, -2.11826401606137, -0.6576780465063177, -1.5900941715563555, 0.9256988749627668, -1.0382194752658291, -1.8051176627061591, -1.4983335431005693, -0.5727444557914035, -1.3121285803164469, 0.0864612229542432},
    {-1.7807243888395485, -1.7271971495237415, -2.2666670118841323, -1.7614434632905487, -2.3031417774786638, -1.978969255773261, -1.5628418455529094, -0.10862759427960939, -1.3697450645718918, -1.9593209296160128, -1.6004251318638438, -1.8402793815604217, -1.895913459224739, -1.462277753325416, -0.8578294372900684, -0.9250701013192925, 0.15047023970087525, -0.4897228811414627, -1.3951100589208199, -1.9349248415671514, -1.8732223616821704, -1.7390774892638556, -1.9173928046572986, 0.22278574520651356, -1.7778038828685248, -0.012603338928868738, -1.3959587066908146, -2.281302918750737, -1.8799402257004083, -0.9894958774638838, -1.717859288965951, 0.4706768253121583},
    {-1.6522057609537935, -1.7060840854071442, -1.6372686546082516, -1.6067715594735859, -1.919302008791938, -1.2990542818635638, -1.6107432576235858, 0.19140545069133488, -1.551266613314624, -1.3550875970343066, -1.550839804003101, -1.4763255392275323, -1.634806040557535, -0.7569343059340427, -1.037277768385387, -0.5180948919957649, -0.3383269818256317, -0.6376644463907984, -1.2300475138733549, -1.7445220251632203, -1.2718274151826727, -1.572857556561474, -1.5672429626800242, 0.2698570310591991, -1.411830832852905, 0.26796571420910187, -1.124373710110233, -1.7843606462401107, -1.61989615614514, -1.011442678617908, -1.4386661558243106, 0.2805844011209826},
    {-1.100884355165413, -1.9456757313986914, -2.055729745713711, -1.7014553881812071, -2.099421086066793, -1.0130027875106968, -1.2673985670072085, 0.32028970391541306, -0.9220139467649564, -1.7759931834795337, -1.2535756926974482, -0.9311555275669641, -1.4550337617536204, -1.3229948257169528, -0.4594849409541193, -0.3160591796307609, -0.8823071130994999, -0.46743852500054245, -1.3727736584460204, -1.7099349832629158, -1.7277631483073599, -1.3087856298481662, -2.2354526077375017, 0.031091772411614475, -1.4780032878638527, 0.6332514999046672, -1.2072957200813104, -1.9585298232481934, -1.7750541516504632, -1.1919343563612874, -1.7119703160729116, 0.17450520698438854},
    {-1.12061188162467, -1.8394324305205805, -1.011261785102912, -1.1669345354873262, -1.6201338088458899, -0.9627379568637138, -1.1569725072827273, 0.6203143457899948, -0.7185887149968339, -1.6246560708187545, -0.642082827729113, -1.5031665776613046, -1.087463921930883, -1.720961443010028, -0.6331286415617833, -0.22273723637053447, -0.7959894686056098, 0.20225433221895917, -0.8049484969191871, -0.828123615454778, -0.9647365877535042, -0.5787640869323447, -1.8407418144472654, -0.23832006626642818, -1.052195793410411, 0.534546905507253, -0.957966145589587, -1.8787501613348583, -1.7704497946083644, -0.0991005452990353, -1.4302337437992412, -0.30233700223268584},
    {-1.6540417672549617, -2.012439989469378, -1.5319833078234937, -1.3424787669625042, -1.473173714898725, -1.2725212949657196, -1.1002663880419847, 0.6189840207251466, -1.195457369349083, -1.6777071937117747, -1.131532985414911, -1.8651306901331817, -1.980068301262988, -1.8975486309008815, -0.9968766093570927, 0.10931596237658557, -1.2436524867006842, 0.1387856675346205, -1.270857512427793, -1.7405463024487209, -1.4831570457053251, -1.7020115568451777, -1.9313015199458672, -0.1977441736565497, -1.208505342832939, 0.3260644239919912, -1.1900112352893204, -2.1319348173461625, -2.013918556635989, -0.6867890227421611, -1.682015446268465, -0.4765076095564178},
    {-1.1277427900141628, -2.1137874839171995, -1.5397619908629057, -0.7810175363997869, -1.5609720863998668, -1.3701277219665804, -1.7561251011311028, 1.3085080178298871, -1.4867170443571283, -1.2740345509123163, -1.753876116860405, -0.8583952321124513, -2.0962660413162477, -1.2138197773231447, 0.17467985117596316, 0.9547897932764614, -0.4197416038687683, 0.19141140352761613, -1.074904655949077, -1.8689694024555898, -1.8402202033144157, -1.6574642822921621, -1.9880002325616437, 0.6981043894204604, -1.6718683129709964, 1.102330802194152, -1.594932207748962, -1.4127567344471887, -1.830163870833053, -0.6973824130158546, -1.071243978306701, 0.9649362582417591},
    {-0.44088103441323395, -2.239982293535066, -1.2180806886523634, -1.3412462647040269, -1.4254784679861665, -0.665342800018956, -1.2349279735629544, 1.1436748243638302, -0.7528705293261756, -1.7182435228952015, -1.111798291188878, -0.5115243884789932, -0.9532251523589368, -2.1683147640207063, 0.204975595176342, 0.18738850757480346, -1.2491678503676007, -0.41656569682087724, -0.5246134216041293, -0.9957789733421469, -1.451632039982208, -0.4936401789844811, -2.6923559682012805, -0.9003766422416075, -1.1156778960647837, 1.3082574488147427, -0.8516824030139513, -1.6297518152630708, -2.2900467481100537, -0.9556087971338485, -1.6945797052492424, -0.500052504074684},
    {-0.8749391066164596, -2.3301141932384275, -1.9096011131983768, -1.7081637335838258, -1.7433014180607733, -0.9728713330425506, -1.3701831096253518, 0.9574505035770681, -1.21280565679351, -2.1246474592478624, -1.3768625810978958, -0.9315824036000916, -1.7653446978082257, -2.0190808288616857, -0.22550927842869664, 0.5220428134565808, -0.8692656766027, -0.1845960577779303, -0.9947025741804274, -1.5705023137458602, -1.5553725659448234, -1.0709806308528111, -2.6760734047192978, -0.42669755593437236, -1.5967102111494875, 1.4256484606820798, -1.1855963514332497, -1.56930131995781, -2.218731644140423, -0.9555878393900096, -1.641004115050155, 0.23930903339981793},
    {-1.060525298184202, -2.184350062332379, -1.5848302734808148, -1.470265558506181, -1.5269707570280786, -0.8036089346686222, -1.3981152077358296, 1.2853083895806205, -1.158140163618968, -1.716649582172089, -1.4865820855978003, -0.8505746791325808, -1.3901726447982123, -1.8818786513584633, 0.06970198668990486, 0.6220657962046273, -0.5887350924924446, -0.1314597245222448, -0.7823550532336393, -1.3717008888894648, -1.275331188334261, -0.9156156327236479, -2.52625602838294, -0.2713527525873019, -1.3205588238895296, 1.1882869770343305, -0.9854935895080575, -1.4915411173951416, -2.1182183212768013, -0.48334298601598813, -1.464528811637469, 0.10986281872342582},
    {-1.2256572979311349, -2.7764462508485512, -1.802775739955311, -1.7845201455569197, -1.9291353793774753, -0.9493004467463098, -1.1299480979042287, 1.1292838371564642, -0.8254726798129218, -1.7542496526353986, -1.4768985237943595, -1.2189297039122051, -1.7283166249613453, -2.126845133463399, 0.12583907840732578, 0.6077062420322321, -1.316597549844544, 0.10068861328140412, -0.8048344110856908, -1.5321959639135028, -1.3780227328130514, -0.8376850710556414, -2.823567429742058, -1.0003112713802316, -1.322733463822466, 1.1701303741797966, -0.9530343274511389, -1.9464790912704852, -2.6454860090784673, -0.8015651769520569, -1.6887536845119455, -0.010527662879494519},
    {-0.7818036714837642, -2.859544115495642, -1.5072303352945826, -1.4888901947440512, -2.0417298919010767, -0.7355640614189914, -1.1213743669218827, 1.7343902690651192, -0.4737041876084715, -2.0286558091937943, -1.3183862662839758, -0.5784611115141646, -1.851631935318414, -2.1188639017877153, 0.9749806153136719, 1.2528598423272848, -0.7088349713097517, 0.7678980954056234, -0.5097358359337677, -1.2943398472143053, -0.901052650551142, -0.455603493885987, -2.648484671216649, -0.5011551327706378, -1.2434022497567692, 1.8671445134176252, -1.0363662688329383, -1.4292497416452459, -2.574250720723075, -0.19226493467989697, -1.3882144526212605, 0.5993092432772724},
    {-1.18568006076949, -2.946300465782154, -2.052740055367646, -1.6873797311865784, -2.105717560243916, -1.0605401565530381, -1.167756536178129, 1.2795250539159995, -0.6862612566006182, -2.6370087709657013, -1.1567300161967202, -0.8324248241481208, -1.499967394786691, -2.5632726426795522, 0.7036831022273508, 0.43660509147604376, -1.156504729890731, 0.40034390813829585, -0.5743772250201357, -1.090956510038231, -0.8560830672634296, -0.8297918667442566, -2.6581303938355014, -0.22218221167847538, -1.133911458455836, 1.4644624511159852, -1.0913294857469442, -1.9549751336391539, -1.8633408637374216, -1.2132603679614287, -1.283092411804927, -0.21764781464405664},
    {-1.0306805044013543, -3.104298617913887, -1.7986899487476042, -1.546479483759991, -2.084443089132292, -0.6445193181748265, -1.0932870753209545, 1.4128309738433908, -0.03874579944062942, -2.535719191596134, -1.0174128937038904, -0.7558363884748582, -1.5007980386441022, -2.465614207127055, 0.38498403294614514, 1.2182214886006135, -1.3601422885967906, 0.10120753170853114, -0.6409967910879827, -1.0366313824987625, -1.110164273288067, -0.6636933660972093, -3.0624944184754477, -0.3911603679043938, -1.3780716310015424, 1.4424279709442642, -0.9272033411346849, -2.156670319382026, -2.22260042903044, -0.4839323645547066, -1.9692070312466226, 0.030393268512471282},
    {-0.8407165510232555, -3.074666553095066, -1.4215045273432443, -1.7565856816284706, -1.5475304459236046, -0.9725484560076428, -0.7916950243515934, 1.7160642327793874, 0.20453255744992113, -2.401812228703891, -0.7374883256118868, -0.4797823633831699, -1.548636802034259, -2.9264424215837885, 0.7651839678539101, 1.3418356317496378, -0.8969222333227468, 0.6672744650831366, 0.2094361206845822, -0.8372904951945713, -0.8647824139808068, -0.2892264744412705, -3.1379817691280527, -0.3038323619868971, -1.2522549916933072, 2.0892301583262594, -0.4619262522964627, -2.2265135923156953, -1.9336780631572545, -0.7394597848080521, -1.0825423055121706, -0.15888384560025126},
    {-0.49111653457115184, -3.127417017511865, -1.625540711706712, -1.8455894916846276, -1.4543146515713075, -0.6459158744160739, -0.34974334863331863, 1.8780677820892937, 0.35507438383074075, -2.474821997396725, -0.2943544021511108, -0.5889217463174599, -1.1759200069876339, -2.8087613843617696, 1.192613817628308, 1.5800544567871297, -1.018736435908655, 1.1598319918249962, -0.018499480914225395, -0.44888808084827025, -0.46707884946695805, 0.3456052662947443, -3.219845066178486, -1.114143393325775, -1.0150559454759054, 1.9588973965114527, -0.4996619317713067, -1.8384295541665345, -2.013596731858875, -0.6956043428379268, -1.0436912071560205, -0.6209930704977342},
    {-1.2749224076808963, -3.226598761564859, -2.2245257986794966, -2.3695415006009473, -2.551087672144188, -0.981167573058306, -1.379567145149706, 1.287308540790144, -0.720258692537022, -2.826586755281645, -1.4671546385705856, -1.1632159689438888, -2.1305073862623134, -3.114701969611709, 0.4020601797863074, 0.8947411645032673, -1.7049574099909153, 0.32002133853671383, -0.5279860101764734, -1.5933370029833676, -1.1227573201076193, -0.7987297925764694, -3.391716935719979, -1.5992114852186115, -1.5134059000945455, 1.740684586933809, -1.2949941356362369, -2.7259226597495867, -2.940386435284232, -0.9785023761924406, -2.182760695537239, -1.0469534181547413},
    {-0.5249742288225926, -3.3777802326434285, -2.3585572799905417, -2.6203570973729087, -2.1425178112979686, -0.5668361484861258, -1.1787620884811514, 1.8248120748302912, 0.11723518856789766, -3.0351709833607474, -0.9600787247650426, -0.5908712237844781, -1.895993644868077, -3.001750410094957, 0.8654603712345043, 1.0813743564303935, -1.4213825999382168, 0.9157896854539639, -0.2760064775943995, -1.0444129164547395, -0.9371171240112377, -0.21906103197748011, -3.249276876819029, -1.1078734750869434, -1.4699594501468276, 2.0605633294712105, -0.7218905141075914, -2.5063079549733067, -2.3484100065224216, -1.2736526067110572, -1.8478303808593215, -0.09997483989001854},
    {-0.0005174260635325097, -3.9693095007735457, -1.4539224600643523, -2.64309614819444, -1.2914216083716523, 0.10459782696901751, 0.1776246226527042, 3.077823782499805, 1.5764621086979609, -2.893979676864991, 0.09897224109422469, 0.5375154063890207, -1.5738481794706143, -3.81010400384833, 2.135646608520676, 2.0800166659174537, -0.5338609832806007, 2.1292153953974786, 1.2589800861520322, 0.4151356616902642, 0.5247102786808392, 0.9449127423480927, -4.077773541957702, -0.3557717467554153, -0.08802165194909031, 2.8683693175516876, 0.16598357444237746, -2.454614230821873, -2.3085111831340783, -0.8372534734354703, -0.9311308950718722, 0.46251247473761975},
    {1.65331973752015, -4.26525172325008, -0.27685420225349316, -2.2112948605536915, -0.902763164644, 1.9096073709564878, 1.6237176249296492, 3.652326006403044, 2.7917796011206963, -2.7849068284595595, 1.3678263288518266, 1.8587292151300874, -0.3768204930839068, -4.120041083357267, 3.272986653685227, 2.9802004903637087, -1.1648103794544171, 2.9496102568418032, 2.356106968078073, 1.5775760771909895, 1.2934809959513924, 2.13017968902128, -4.279809296268352, -0.667609748469155, 0.7596741839823953, 3.629486134362648, 1.5258312239499459, -1.2422657018776733, -1.8832173557684526, 0.606867146359182, -0.16677883380719563, 0.09836008949529068},
    {1.1652909744983155, -4.319201037644285, -1.3750861176954787, -2.4661087496580274, -1.3945299228226018, 0.8910034433940112, 0.5636904190971388, 3.2941880261539427, 2.0469933815214434, -2.861451690404542, 0.045871367443457337, 1.2481993577756314, -1.362240181917633, -3.9381204964666012, 2.405496172218418, 2.5979144574507274, -1.5042283104457208, 1.9208364367877615, 1.4211203688021599, 0.755819622779, 0.34371532661430076, 1.5793755407680097, -4.058001333097545, -0.9822592371251756, -0.5471404148790239, 3.294720433110065, 0.4902614606575069, -2.0146316225684333, -2.4658606383623067, -0.13388042268199182, -1.0196005669242583, 0.09880243794313634},
    {-0.606073253080569, -3.9927979617270393, -2.0176646828374647, -2.7870177130659983, -2.255718047959462, -0.7731642298405136, -0.8594374901435262, 2.1556442706949723, 0.2770503459834193, -3.280675162097346, -0.9906199087307387, -0.45834828039818226, -2.0630307925641818, -3.671948572211375, 1.5553083759268442, 1.3935456550861895, -1.235670131508495, 0.899393337629926, 0.22393418180644434, -0.6531874104002245, -0.875555911571982, -0.051987771512152184, -3.857401002868386, -1.2273558349547098, -1.404009546993532, 2.201848340203138, -0.4577495044828532, -2.787569402145079, -2.7023520451878085, -1.0939172515025604, -1.3479389806261382, -0.6426098504105859},
    {1.2376714826826265, -4.225974986246506, -1.2908954369466261, -2.5777947142181747, -1.3842030174590514, 1.0365933156298677, 0.35619054561447294, 2.9158351336254, 1.8965503322555215, -3.2542312502941964, 0.4348118150125014, 1.1776371529883458, -0.792363546949841, -3.972020812897536, 2.3839520001728003, 2.669661817586628, -1.6128484556553542, 1.961183729015487, 1.277583418993936, 0.6246460112940991, 0.5659392801453765, 1.8216094056035899, -4.298927527363905, -1.4203204312619742, -0.042830588070294315, 3.0300550853873514, 0.6030739000539423, -2.291767846858608, -2.3141227403205415, -0.23577792871447018, -0.8274437989195383, -0.24211147715762668},
    {1.520261443452075, -4.329031911780045, -0.5258994592979553, -2.117717781938671, -1.5989601938033666, 1.404256592669497, 0.7160102124845289, 3.420416157306892, 1.8886528176736443, -2.6573934292888364, 0.5319666155212961, 1.3249452357431948, -1.0189208359991222, -3.942896566752034, 2.7785302111565136, 2.919348400318357, -1.4577831121528533, 1.9954449369304774, 1.5973785419375803, 0.677767787188947, 0.49799371668879244, 1.6810747638285517, -4.486364921523962, -1.2832718831865222, -0.17566601876508478, 3.1812762398996024, 0.8771862334751489, -1.3557598365734762, -2.5906896576334923, 0.41648282862605274, -0.8764089900971812, -0.12156526661611844},
    {0.9183386513289985, -4.412138286519314, -1.2944524252102367, -2.6270252023754046, -1.829474301598086, 0.980341583720811, 0.19413113070490298, 3.225810658741146, 1.5504708691629376, -2.988090621420494, -0.15799844873847646, 0.9197271720980784, -1.2484927906202423, -4.054045109637298, 2.4860457152354125, 2.4958747372104124, -1.5693223935961376, 1.5285875385919143, 1.0803721874955148, 0.24327632293636833, 0.26233065958785656, 1.3722870880766656, -4.24093343600217, -1.5577534469638061, -0.4295019120586039, 3.068507289221604, 0.6918356804391044, -1.956745074028737, -2.7260601729533733, -0.32310146686989394, -1.3818768217117032, -0.0007643983490889733},
    {1.3031841404171378, -4.241275776565179, -1.2379356372976082, -2.4560660886579138, -1.383990045845789, 1.2420648540832644, 0.6353570292001558, 3.383919690565921, 1.9470936864961035, -3.318234501720545, 0.1626645571888458, 1.4180164677121747, -0.7714552752150632, -4.453930180748956, 2.4843453619643485, 2.833100075254055, -1.971960372439802, 2.1244204285407666, 1.6641212275744348, 0.8222535445656195, 0.6234501486085665, 1.452600878364288, -4.270171488190723, -1.2399649314663264, -0.2983028748914173, 3.1520649507662553, 1.0125581672858885, -2.1324285008791444, -2.8125619510989788, -0.2582133601180134, -0.9515482737693638, -0.6666545836629678},
    {1.8232275425082032, -4.567514938758395, -0.4773047911339494, -2.410689392592414, -0.8943618117738465, 1.7913025233230273, 1.1236321342044784, 3.471272426032631, 2.409794656463526, -3.1301004446432037, 0.8290812010397998, 1.6825763515617174, -0.5446072134347588, -4.175674917357329, 2.966428038590224, 2.844439335650616, -1.6833533665960827, 2.4488558237282296, 1.7973832254087525, 1.0730959002507092, 0.8582171149542441, 2.1687532767561972, -4.345610235548317, -1.3556449898893548, 0.025489651573344794, 3.477161703658677, 1.3009523120032318, -1.3667802105542544, -2.1703297907075925, 0.49729562608754546, -0.7760019382163895, -0.02361800526517619}
};

static const float b1[32] = {4.73273070660556, 4.949729879960901, 4.718508522196785, 4.825501644466844, 4.928953792116107, 4.716595368282473, 4.684183064832907, 4.7242550772815415, 4.652185253347035, 4.9089795832991, 4.6635202268284175, 4.7376658901690885, 4.758525192627347, 5.001845008311083, 4.649113419399116, 4.876315246011702, 5.104689539183049, 4.885394436535607, 4.668161801898687, 4.6914122111050816, 4.714199374665715, 4.630929520271946, 4.984019308275681, 5.170155680590573, 4.814469031573478, 4.81427877009665, 4.636490562398884, 4.875871551706835, 4.8973838730936565, 4.8081769723072885, 4.776699806977376, 5.164928068086608};

static const float w2[32][16] = {
    {4.0126098208307655, 3.922237826164242, 4.21355963142956, 4.364291511113129, 3.7747623265593564, 3.7760456516581913, 3.9314529255474002, 3.7123805106781362, 3.9772586318760004, 4.176205386188732, 4.112890402126824, 3.670661387747463, 3.5871041759181326, 3.804070541257206, 3.77633076213987, 4.233965819217944},
    {4.577718667587781, 4.817503226449224, 4.931331381929187, 4.44097165054895, 4.867935408163763, 4.9369707099574995, 4.41591425290188, 4.3123233093967395, 4.64057683240926, 4.719995104739482, 4.865298865675881, 4.8175872528303945, 4.299335663112649, 4.903347528092113, 4.612980568815034, 4.790236419785656},
    {4.422180149213002, 4.228581996113498, 4.479821790115682, 4.077696927098473, 4.276721149428433, 4.42936464535086, 4.042392063383528, 4.174625459886608, 4.475827337753087, 4.355276562897166, 4.070162437255538, 4.291618176177323, 4.0055953963618585, 4.321908457990631, 3.9157606968591083, 4.366263734982309},
    {4.203909855381604, 4.304632903987871, 4.34929963357441, 4.432772235633665, 4.311527669828147, 4.1345171439613, 4.3835791822095, 4.266149072923539, 4.627203112132903, 4.885826891065478, 4.254544607074406, 4.0241155324033295, 4.352264683492416, 4.377543192233943, 4.1774819567873855, 4.657909947281303},
    {4.222835557422476, 4.133288480862124, 4.447107875117064, 4.035165807736785, 3.7336075381330067, 4.207685219320186, 4.23716217490713, 3.9938717935884513, 3.999110355680932, 4.445884907395072, 4.326399240616642, 4.195421290868947, 4.181589250985437, 4.1785194208026715, 3.854042403252515, 4.480961177154033},
    {3.7987581462587467, 4.071491405115109, 3.6822220384558753, 4.342501255609279, 4.165557013518985, 3.8699664661050512, 3.693928799984363, 3.5492794007766486, 3.829636748673042, 3.8627068671402007, 4.258353599148108, 3.8486666134124476, 4.013015987889676, 3.622912458182824, 3.8116433375179612, 4.197521489476283},
    {4.214640302497065, 3.785647977053154, 4.415104219211303, 4.198105514086246, 4.0850412490896675, 3.776671761740748, 4.214591501740915, 4.0030701720200295, 3.983897684409531, 3.882494430542363, 4.447625398593097, 4.277721473816353, 3.9784460491764984, 4.2750720842285785, 4.166531931538498, 4.208068735741052},
    {4.591719710296207, 4.015688295035493, 4.2181714316508305, 3.9143947660342584, 4.2209638399576574, 4.3231493881693, 4.178803327945571, 3.990159653619192, 4.162376518997652, 3.9638728443853326, 4.243916814960325, 4.103050731578117, 4.1839034925583425, 4.136887730360335, 4.331899852694628, 3.9369478002011746},
    {4.332081277890762, 3.9918655986126748, 3.931063552096266, 4.548160530312819, 4.02662828492919, 3.805223050813047, 4.36494050302861, 4.231896284478772, 4.053011386865824, 4.222006425106444, 4.397432407858077, 4.205154801804654, 3.8861199727756275, 4.357587746853427, 3.696543115081592, 3.8957961759102906},
    {4.540059623757088, 4.788629283692212, 4.4337010586632175, 4.321741901603834, 4.24499433061015, 4.401267293322135, 4.646796712799354, 3.869517105076455, 4.560445756414165, 4.684624300760454, 4.29872486368593, 4.550345007289816, 4.286510925589685, 4.990846517358608, 4.144590675862734, 4.700036767485965},
    {3.9432768106869642, 4.299029605955674, 4.201695593421571, 4.141063042536619, 4.20686888510701, 4.020508915902479, 3.8153078420644313, 3.7092564490834308, 4.466731655147632, 4.19298342578632, 4.10694003812493, 4.18618000580391, 4.125038276575099, 3.7549716983488803, 4.09258570358059, 4.388059027101398},
    {4.349707149094678, 3.946898342509108, 3.773804165738684, 4.449653903737992, 4.137958275313267, 4.055175830718057, 4.028949048486344, 4.124703759392462, 3.7947845124709514, 3.7971158254004624, 4.274714525437052, 4.036853059382338, 3.817502852614349, 3.7806727175623576, 3.558139489662024, 4.386824008487332},
    {4.234916312607927, 3.8772695291670747, 4.358452967272952, 4.432018580413943, 4.060960114941884, 3.9563357362152995, 3.8215589711744506, 3.535260928332527, 4.286746232468757, 4.128561927104063, 4.083850246072311, 3.6994007156009996, 3.75175924076737, 3.8774692347381565, 3.8972357300656317, 4.463709569802631},
    {4.656996017862152, 4.912433142760394, 4.567823897736096, 4.384447210658213, 4.835842795663584, 4.889431442900636, 4.406776263213432, 4.427988278895231, 5.021202386278138, 4.966527438729619, 4.663401636376382, 4.599158414700677, 4.758601595947818, 5.037825221734694, 4.627461905610683, 4.477096747762426},
    {4.334911369836835, 4.20347881004491, 4.440043189907509, 4.059784181591114, 4.173703860220675, 4.070744900813294, 3.9310633502240586, 3.8560249609615043, 4.1948582745874985, 4.177252150071003, 4.184556893420175, 4.3889432745399795, 4.467514952172249, 4.615235452099109, 4.034540813963917, 4.1631006183249735},
    {3.9860488280030126, 3.9866892330197183, 4.205586197443075, 3.9942681294624687, 3.7622395789637118, 4.186479270757839, 4.0712709657549615, 3.740784797276372, 3.823054646755384, 3.9765126067628294, 4.321971747071051, 4.110010900874242, 3.9887801193110928, 3.802610073379942, 4.084827796678916, 4.291688493726711},
    {4.992514111731237, 4.831779626686802, 4.678928367826593, 4.370662660472108, 4.86727188109651, 4.764488620254412, 4.919621069152826, 4.916746286347192, 4.716594358710928, 4.9398079163074415, 4.7693860968948405, 4.330270959189937, 4.683426489290829, 4.734126114476397, 5.04248212508499, 5.022856908869683},
    {4.6511829741200925, 4.348512090967849, 4.251489218903833, 3.9642453136283087, 4.263148975550501, 4.370187351874624, 4.575304556424166, 4.126221114580052, 4.54708211338385, 4.1006579172207385, 4.1199102699106485, 3.8798692652226214, 4.040904573524701, 4.28306519708373, 4.20697894129795, 4.365557039211892},
    {3.9212231655975995, 3.9593380857741973, 4.4131623566383364, 4.010286819861449, 4.176948605195663, 3.9995201243436194, 4.08647842591249, 4.095495375269604, 4.074864240561822, 4.279649000768906, 4.3294473185412565, 4.147855692944426, 4.178491448811579, 4.3328580927106115, 3.958286315981482, 4.1967505586357},
    {4.237542320474502, 3.5758506320571692, 4.375676434707634, 3.9894652195779554, 4.119828541531084, 3.958046534228854, 4.140653316021348, 4.054411892547371, 3.9555800950325417, 4.132601969629246, 4.2919122104481655, 3.8812772568438185, 4.286575771354842, 4.019903180218155, 3.8559987817040984, 4.260238632989119},
    {3.8255533165756397, 3.648618636213787, 4.238779921536584, 3.9123037935903744, 3.7279492483884153, 3.956965163878523, 4.147958856610418, 3.7496489138593834, 4.095805229458728, 4.222661577492195, 4.088938413832567, 4.196268273186716, 3.8778511681348915, 3.913248085563445, 3.850743065597239, 4.341952985929142},
    {3.7319589973703913, 3.774631671901098, 4.349065622054198, 4.241895143182621, 4.114411395791625, 3.9696998615023515, 4.295676001147169, 3.7430165088887186, 4.3242167712556885, 4.0554577525546955, 4.137837704184567, 4.062779664075078, 3.9946632943206803, 3.8373034544185245, 3.6941659890852807, 4.109740824949851},
    {4.702738045688659, 5.0371678479084565, 4.332554856769709, 4.720104919689744, 4.435314836456366, 4.829512292504723, 4.843312449817093, 4.541508221430321, 5.085532914647649, 4.8738726623395365, 4.663198001253924, 4.920624018418738, 4.814166390530179, 4.890840339078799, 4.944259992797084, 4.9644720110653955},
    {5.0658024604444405, 4.5392342827489385, 4.519788209151358, 4.868688674102667, 4.937126293996199, 4.679074588109413, 5.0031667275739755, 4.383795950809636, 4.979542725199126, 4.4679221595747345, 4.598080409382629, 4.4651567110112005, 4.489045187544275, 4.433172619382267, 4.61343279765019, 4.749079687100563},
    {4.226922375529778, 3.754461785332952, 3.9289921631258617, 3.8728254519851433, 3.995987388441312, 3.8328138593128793, 4.1941197069703495, 4.20757163506986, 4.201268940890816, 4.081401353955166, 4.37426060982047, 3.670400030317968, 3.7694848985915055, 3.9815721635029884, 3.8288618059051225, 4.155330565459851},
    {4.307387306042077, 4.129407808068454, 3.890730626850188, 3.890480286329248, 4.052230170723929, 4.25499957504024, 3.786808102988263, 3.5200177044248524, 3.8619345226303636, 3.760233952261588, 3.917409945607636, 4.232260302248131, 3.7140142043577495, 4.163185715279766, 4.0655206247535896, 4.025614967033328},
    {4.322387453498741, 4.293808972723135, 4.046891859390648, 4.298788156986242, 4.017301295992484, 4.033740585746591, 4.165225925471096, 4.038985224283844, 4.241708076372996, 3.891764381207107, 4.260751890793472, 4.340916687086118, 4.20550011811267, 3.9499912268485144, 4.193602539515151, 4.276296778927267},
    {4.4463280506464615, 4.190334696036385, 4.264277180126711, 3.9640590147755317, 4.2677885666751285, 4.559961146167684, 4.415970322226611, 3.7778770302473914, 3.9501272490751167, 4.254937649093363, 4.054902828699424, 4.146805650072846, 4.094033541710056, 4.46968737227855, 4.253814009845943, 4.5914992405104},
    {4.19741013807776, 4.364937405261583, 4.769373927471828, 4.582618352255143, 4.321460065904773, 4.584821248552505, 4.423003002747557, 4.1367108713585665, 4.829703858324777, 4.657560902685306, 4.379924436782283, 4.609818739699887, 4.248113278255015, 4.62946473897448, 4.330710242927486, 4.270773609438372},
    {4.465545782884052, 3.8638270736983644, 4.035589698534115, 4.578021783369494, 3.948919817920041, 4.107688534688884, 4.42626521064483, 3.6771445538896477, 4.057721667672098, 4.246624584067055, 4.165101655270954, 4.314553449706607, 4.232720295040187, 4.309771985127097, 4.13891347591875, 4.145671777063286},
    {4.4513297275763675, 4.542459141818776, 4.464710145823229, 4.183988749997274, 4.156095269112399, 4.698147984790749, 4.6575476256071555, 4.527575281793188, 4.734268634362719, 4.210003016320218, 4.169960615375641, 4.538992208071812, 4.696714220135266, 4.318841038947395, 4.439054447536585, 4.199473743720033},
    {4.649395246620512, 4.172496547719745, 4.469528737833281, 4.237349224956391, 3.999758517393315, 4.346667434076686, 4.080876828640083, 4.4439018401319075, 4.51056934325256, 4.243497308131274, 4.588642936290888, 4.750947504639032, 4.307362925888199, 4.583559952896646, 4.399016199919043, 4.796641201767241}
};

static const float b2[16] = {3.8812176679929187, 3.9568821829445175, 3.842275538006161, 3.9908657332887345, 3.8781961619535386, 3.8244276311367056, 3.949317214401064, 4.144367936383115, 3.968930231664644, 4.01184822551483, 3.874859432201248, 3.9461878976803066, 3.983658360346308, 4.048363133901269, 4.015664050513854, 3.8813584990426806};

static const float w3[16][12] = {
    {-3.494735927100773, -3.150271861114621, -3.3421023039991176, -2.9405750364270773, -3.208761452552662, -3.4565497837040478, -3.4712773877859306, -3.3380499032040603, -2.6278211545553036, -3.19317679521012, -2.8568957689480747, -2.8331771163288133},
    {-2.688467682512057, -3.141466691400689, -3.678405297916134, -3.378633261067355, -3.339263708481702, -3.0734794764939375, -3.1189833553377584, -3.0494708141623033, -3.3262865645914017, -2.928972809067788, -2.823552183245156, -2.8489365484498093},
    {-2.713895039868741, -3.373252403046598, -2.841102771939153, -3.0299404916592327, -3.033829492223321, -3.3489862246633293, -3.2637507804593664, -3.413849732937726, -2.7727433127628314, -2.966334804792923, -2.7342153896765145, -3.4977978417597932},
    {-3.2724627472995995, -3.675048257657726, -2.8892936129621716, -3.123581275093217, -3.543054524403486, -3.0915254039059383, -3.2119984558163495, -2.9544128155350635, -3.353967545959441, -3.6321268603892003, -3.572269877746999, -3.678067997056224},
    {-2.770291562938937, -2.809761398231434, -3.2036735821492117, -3.4256505575141563, -2.7250864583676866, -3.48418884008533, -2.975421121956631, -3.3431730711042946, -3.494183905421013, -3.0859046306107487, -2.627522081275527, -2.8414519568431595},
    {-3.5591070029260674, -2.8091117994221357, -3.0550786678369186, -3.49165696617266, -3.4531984639951476, -3.5656123568227756, -3.4718728595894586, -3.4046779945477126, -3.488875603986474, -2.907182311918707, -3.3459230223003322, -3.550640249767917},
    {-3.4365052874820146, -2.949462832727757, -2.8202012194536574, -3.502819562433932, -3.2900817392045956, -2.7741110421611537, -2.9992141693067333, -3.467845435032851, -3.2278485730754167, -3.2850093842952566, -3.4334535230153933, -2.847083114441847},
    {-3.3340208130721507, -3.0866482091020693, -2.957129335400789, -2.9130136852876243, -2.6677264222187422, -3.0603113962878328, -3.0722608933419697, -2.762412263368795, -2.6604953592269176, -3.360147459256367, -2.9918966436636354, -3.1137998311928805},
    {-3.5591380899667246, -3.1847235060371, -3.2115384658792707, -2.9787216459502464, -3.234776709946136, -3.1895488415796622, -2.940302907724379, -3.1121546503196877, -3.6002735719385255, -2.9683626450422587, -3.0200042495013752, -3.2980036426593604},
    {-3.2427621373716273, -3.6543746246114814, -2.9446786563336964, -3.245218156484729, -3.1888714770064466, -3.5178502920792676, -3.029866091993133, -3.121207509863931, -3.39269887250405, -3.5137055160115915, -3.340408125047397, -2.8546534662006593},
    {-2.8603862310844, -2.7287975514413367, -3.626048292596643, -3.186713722062053, -2.9356799690835196, -3.0030137927638223, -3.4185632717557795, -2.9086243441330217, -3.423964481057777, -3.1207697520400273, -3.5730437271072604, -3.30380483191031},
    {-3.1395164425355695, -3.055484416452015, -3.4891184777887574, -2.822502172160827, -3.145125634635487, -3.0270047997532434, -3.1747214915303004, -2.9422611948859587, -2.804088035377746, -2.74999352764822, -3.322281097801353, -3.526836432799602},
    {-3.2035369068928743, -3.321637733703929, -2.9919827394465397, -3.2082527568693817, -2.7225053317496557, -3.015005439147521, -2.823893432569763, -3.099772319193533, -3.1651117882262034, -3.286864200996309, -3.0005234959012212, -3.6707931051416174},
    {-3.622338233828955, -3.5563639017051125, -2.956211710444255, -3.324662768678529, -3.469239537757783, -2.92551432333827, -3.5626198329300736, -3.0608876590686322, -3.108908974977105, -3.5394122760486924, -3.2782516440250085, -3.109183913401099},
    {-2.7534401576892824, -2.8547809976521394, -3.5661298350689163, -2.9788388367950263, -3.1175283757136856, -2.8053754466359715, -2.9095728898289686, -3.368274977699154, -3.071305008277801, -3.084388244067379, -3.264513446253776, -3.0262047417102105},
    {-2.9847865756590846, -3.329603414315342, -3.095642222851197, -3.036408430452691, -3.5348454429142135, -3.302724375964012, -3.237700724297003, -3.2440783093325116, -3.1130254908060606, -3.1803322470680335, -3.5112798941462953, -2.800428957950477}
};

static const float b3[12] = {-1.7841862080616255, -1.7240280373657324, -1.0168016057028868, -1.8856855671417436, -1.6035044193623196, -1.7981610491468007, -1.7152994732175542, -1.155584462899009, -1.2639047061923494, -1.5856877827724745, -1.578582396959088, -1.0833416878009405};

    // Input Layer 
    float z1[32];
    for (int i = 0; i < 32; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[16];
    for (int i = 0; i < 16; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 32; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Output Layer
    float z3[12];
    for (int k = 0; k < 12; k++)
    {
        z3[k] = b3[k];
        for (int j = 0; j < 16; j++)
        {
            z3[k] += z2[j] * w3[j][k];
        }
    }
    softmax(z3, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
