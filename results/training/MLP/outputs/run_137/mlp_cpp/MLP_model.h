#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][32] = {
    {-0.4258954882856741, 0.11107712171050754, 0.4142340576207209, -4.251524556655875, -1.5879291282692243, -4.549220034486613, -4.681988197636023, -4.724983378593135, -2.0656881023382763, 1.3169449529521036, 0.3775052680313498, -2.441054197423497, -0.8286399931026438, -4.62115871688467, -4.181340890044713, -3.514903494923563, -3.3787499569902693, 0.9833324695164407, 0.8562732374143096, 1.9225104204263004, -2.0493829775103256, 1.4936885830122821, -4.155780951305787, -0.5837804779131959, 1.9142469719265816, -2.1299118109530175, -0.045417896700306194, -2.611080804312302, -3.8486647461965546, -2.4242474236858316, 1.6271581313066883, 0.40781559518640775},
    {-0.627691198592794, -2.0671403921228024, -2.831782615386201, 0.11207952622168624, 0.6277212992534559, 2.8993256706309656, 0.17372763267143987, -0.5008085715819552, 0.056209705031022975, -0.15845631931026452, -1.6023097442736423, -0.5578349521461212, 1.3000209678297712, -1.1745590069692387, 2.2059902068709834, 1.7029066844729153, 3.188516656828421, 1.3588229434599561, -3.8316475979584244, -2.4721816019397207, 0.5897284489561913, -1.7769648705429315, 0.327489892828051, -1.4177893333038964, -3.770712585816104, -2.260307750888558, -1.2524698849445648, -2.840046963891132, -1.126439287133213, -0.665350236551044, -2.773541957181034, 0.5321119869798848},
    {-1.1662597680582514, -2.9813531319116446, -3.6464935293885907, -1.24026193412752, -4.2760227043967225, 1.5922107729681423, 2.7110488300135707, 2.8238115852064234, 0.5347178872388421, -2.892075544756477, -3.7270484584115797, -0.04828013122859007, -1.883077485742989, 0.8878807213050212, 0.3874285589395149, 1.4098483986714987, -1.56264608441557, -2.588559070408055, -2.5831526033279797, -1.6334034966302207, -0.8399888105459086, -2.5480614441934257, 3.604505588932187, -1.0985826677033677, -3.042946107462954, 0.0891837313200508, -3.172993454375159, 1.6008183470742308, 1.02915795720733, 1.528135467938358, -3.3846722239669274, -0.9080613510813136},
    {1.6593027714704167, 1.5709473559130076, 0.5690145023582761, 2.4720760703729106, -1.4476502314831565, -1.8840083432398929, 2.788720550406913, 4.206901111597624, -2.441309705281627, -0.839886892667534, -0.7420671152595648, -0.8858280378533434, -4.642134218500714, 4.157409038232288, -2.8843431398037946, -1.025192851846652, -4.243111534193493, -4.3182941995474255, 0.5731775223063159, 1.1332116308297318, 1.3058860454864174, -2.036258636376937, 1.7047654309902034, 1.7223058927771882, 0.6841962449496575, 3.5485304977188292, 0.8616264856958368, 4.557591833692016, 4.022814370935452, 3.0001053670693683, -0.7234379301759778, -3.509076137505602},
    {0.1272024192126529, -1.3046304489620197, -2.8350529417567474, -0.02682900411848077, -2.483175453017731, 3.3197333268615474, 3.9677012532333973, 1.5519618109607283, 2.0087266545198834, -2.7399915720287176, -2.894496049501741, 2.286485421247831, -1.3912512945974593, 2.2133719576006925, 2.443436602679437, 2.72877128720371, 0.11753150839283862, -1.7532776718163152, -1.8009073528449708, -1.9343822933640245, -0.04801024860503048, -2.7274277523054593, 4.563038779030969, 0.20463742850564345, -2.1601947081630533, 0.2256127088084171, -2.0847417432770725, 2.1048850004912554, 2.9668117742253526, -1.0062406536344168, -2.6350223580646994, 0.22140044321410474},
    {-1.942566663826456, -2.0290988050546113, -2.472222297353114, 1.1253827884302778, -3.110747735931211, 4.949843181999201, 5.924946506992254, 4.079039887800746, 1.7341781403400636, -4.134688985458643, -2.9492848942464467, 3.1801899034343006, -0.6065726567133228, 3.997933072919087, 4.091409873149356, 4.497156055430535, 1.366462603462247, -2.5393753944465036, -2.3313736748146514, -3.2734142895422, -0.009114989201342691, -3.767435331296798, 5.954955998093255, 0.10030873881759406, -2.876270976791623, 3.4584477269143052, -2.4356744920185993, 3.6439953123419215, 2.1041453850208054, 2.1206341191178915, -3.295453371634663, -0.6418648585293738},
    {-0.830902769092325, -1.488427070101901, -1.6955854518857367, 1.7683177335224591, -2.514523405594909, 3.949577513851176, 5.927474108346946, 4.976079064801758, 1.0326823807853494, -3.8526635998497762, -3.193535674804156, 2.528271623657698, -1.4001635024573502, 5.108213668327008, 2.950076787650908, 3.4580919058623665, 0.08943633292326858, -3.165948590544868, -2.3108509878321284, -3.090171689555037, 0.8186320876780925, -3.862335559810512, 5.817393645773079, 1.0235127233955084, -2.5323577291653288, 4.365411820836458, -2.540628004976538, 4.292090092289307, 3.138932177324466, 3.195817091140516, -3.463957785289466, -2.0019854561545323},
    {0.4210933890205227, -2.5595622698289193, -3.150785000757319, -0.3784566193562767, -2.3124141588341396, 3.539171321967962, 2.5804049823458652, 0.7527845416425354, 0.7476318853225287, -1.9345554409373702, -2.9083147991483234, 0.8284630739686506, -0.1295260822962285, 1.5578022405029648, 2.286875632453872, 2.371372501014021, 0.3361680839592175, -0.7059966210819046, -3.107310400298632, -2.2542167521004317, 2.3059798477850126, -1.6235974591205626, 3.595453930856736, 0.9867865236080821, -2.60459213874451, -0.9700942266263614, -1.936706781065898, 0.544951371880307, 1.6683096545116058, -0.363830188792008, -2.776880064326411, 1.8123220640799884},
    {-0.579095980197338, -1.7489544864819806, -2.3366445387150456, -0.7989025837983138, -2.2855300577483604, 2.1215861379696093, 2.7537616541907024, 0.5288475507913379, 2.1189084209813434, -2.3645856658290323, -3.044339431982477, 2.812070717497024, 0.6058361985674531, -0.3949759097027943, 3.5308183689866937, 4.10239795516392, 2.2520840597582086, -1.189326378531532, -2.9905611034100184, -2.76733922939072, -0.38613103399880067, -3.4284326721404352, 3.8205442531018465, -1.3858555167316198, -3.170468214630988, -1.6546836930381272, -2.3172570295065893, -1.2419361541680471, -0.7958280805549146, -0.17012830932452472, -3.9989604174155295, 1.1724944638090853},
    {1.9282076019740453, -0.5471278242531781, -0.08411249826898687, 1.7563928535663793, 3.408304839147155, 1.7060741677724336, -1.647641649697646, -0.4902805914789549, -1.4156325593908337, 2.6022658578867377, 2.0317257534826973, -1.7827134907733924, 0.4903763692157511, -0.02413785501384005, 0.9594749531240698, -0.19859690581279785, 1.65173379697822, 1.1250973003351787, -1.0277711068008346, -0.8586073002857844, 3.4445898953259197, -0.25428449053849983, -0.7482606364736939, 2.6726619404975445, -1.392203905170551, -0.4001838453085178, 1.9130466188144186, -2.404907236511964, 0.26496734384338017, 0.7289001470003875, -0.6860386194595958, 0.8031260386945627},
    {0.13164840957854582, -1.098376123059041, -0.4493196178864162, 2.179986873156259, 0.5413260249370891, 2.2115032642085217, 0.6540282269997886, 1.9505510227730047, -1.7378663553044411, -1.0599994266722312, 1.2072091262096478, -1.317778037523763, -1.1437372043232392, 2.951861885187249, 0.3840425341350186, 0.1880454914193513, -0.390390576832323, -1.506748073328813, -0.7130823814035077, -1.2777959609393579, 2.304633947080075, -1.8283929843443083, 0.8365643270426004, 1.693057247969817, -1.4429395456286127, 3.189471069075918, 1.398712649627178, 1.226693513848212, 2.9472975388112572, 1.9699513140498586, -1.12252952973123, -1.0517306678650995},
    {2.0012801907092137, 3.242238922959976, 1.9628574858897803, 1.7581108810285724, 2.8195329099980757, -2.7484098002883086, -1.1293658359863061, 2.023069309144191, -1.3666403442494084, 2.820838945186599, 1.7300144563161708, -1.21673846692071, -0.8491576292724291, 1.3766113232213821, -2.667940163668563, -0.943336430503326, -1.2230835850845434, -0.8665230011906976, 1.1356632539294707, 2.539099865115922, 0.4795742413335706, 0.6535425206990183, -1.9010689798169866, 0.3060003944486838, 1.675917963616139, -0.15375508306722332, 2.5605311301274893, -0.16876839516747918, -1.2764390841827529, 2.69130123621681, 2.0104025077115577, -1.8874521019336505},
    {-3.0425596010290232, -3.0530844967663273, -2.1284737266222153, -1.2564571002836018, -1.7565882230527554, 3.828837870172593, 1.46911761178448, -0.6642310085491309, 3.3890391224946597, -1.77464568355026, -2.933343429099753, 2.7067321229993047, 4.776709135532979, -1.1466683577503576, 4.121019448895864, 3.782861240668607, 4.734560860793893, 3.239672125321008, -1.5414972215036475, -3.7650075012164956, -0.25625940025387195, 0.6750419996836028, 1.9985925437414733, -2.2033237154885104, -3.0409682621531564, -0.7214076793299581, -2.504923588746099, -2.0519847030913425, -2.945853372376297, -0.19790675144938855, -2.704350726360997, 3.1077788905169226},
    {-1.1773832128540076, 2.470246519638705, 3.4416061312589776, 2.74737317553852, 1.2136202179928757, -3.1610099381021617, 1.7793057211360197, 3.5730693760872865, -3.0176008690697453, -2.2372063946420124, 0.6149922750073186, -0.6427281130636961, -4.071619832867489, 2.9043668749347584, -1.3409766450379514, -1.4370047012903555, -2.633251463536233, -5.654711669661277, 1.8845336091300917, -0.5267917250433793, -0.7321930057318009, -3.4091624337224906, 0.19860057195056635, 0.7103749549224946, 0.2581508264201495, 4.166875556850664, 1.6248088545810002, 2.5285698014802174, 1.552589072297878, 3.8590403959214323, -1.2356209925445993, -4.736592704331838},
    {-2.1017399026926213, 2.8744230984489714, 3.977372695860916, 1.6163669220858907, -0.9465266981828097, -3.232848620427996, 3.2480228468734778, 3.142755473291353, 0.09119287961169273, -3.1897828296168975, -0.0996410864751894, 2.9936391598454266, -1.4759777199963169, 2.236881195272068, -0.0024640298006668557, 0.8834903480981541, -1.3107837575973544, -4.1657654190294116, 3.4777203296658743, -0.26822132618811567, -2.0449971301011067, -1.8686416783969646, 1.9649550160011564, -0.3580095108255497, 1.9193521986331046, 3.750339103971706, 1.2450116750745033, 3.0469379234557405, -0.2893194220045503, 3.2347045312568405, -0.10423803234335885, -3.964251373945912},
    {-4.117264511131141, 0.27637098821406375, 2.6190950814940646, -0.5222065244371306, -1.4694105987348212, -0.14737197338182492, 1.8162174180699684, -0.5432336267340655, 3.059334655911302, -3.4756018518710095, -2.0512885193579575, 4.395655052685909, 3.6150291522671805, -1.648194592954479, 3.470249251468529, 2.748822032290596, 2.829418399193307, -1.1916781261846772, 2.4731270643828918, -2.4106994599195044, -3.462650416926236, -0.7465636970816213, 1.4224414031160522, -2.966787925000056, -0.4981521705642882, 0.6469455234430639, -1.1427668591688505, -2.175260812103517, -3.72759978263396, 1.018526794447495, -1.1369559153336526, -0.7656751112076304},
    {0.27989465132291674, 3.636278116912457, 3.8026073357125383, 4.435516638894323, 2.8085891611461644, -2.0745379788372684, 3.5861161559064385, 4.900040139581654, -3.0894725417108697, -1.90471944552607, 1.5297897977217867, 0.5274328849987895, -3.886868680541436, 4.949613381800138, -0.7468009811861689, -0.23980705087506082, -2.2143481287076425, -5.392001310130202, 2.5398305165373505, 0.1478258615591957, 0.8208666684054768, -3.758337908618233, 1.1237476514052418, 2.728300225198912, 0.8309647365872399, 5.043310544991239, 2.6104514239707295, 4.273382075623802, 2.420964514145496, 5.1033759940718895, 0.5390686662690791, -4.426518722468686},
    {-0.7895694057162752, 2.87149650014314, 3.574177791989448, 2.9623648975812618, 1.570462577084222, -0.42731318580245875, 3.192613085474293, 4.455739539760678, -0.4252316816809871, -1.5126556296102676, 0.8117872511016115, 2.097448472459179, -1.5617524881060594, 3.7457137204646016, 1.1509970304353097, 1.3408458585957777, 0.49974837134801386, -4.266428051709923, 2.3111950580762564, -0.39728939453363415, -1.1166714566603897, -3.328385109484824, 1.6987971437269043, 0.2562306441794743, 0.6396631188034478, 4.24544785384497, 2.2418078289796584, 2.7222568855192626, 1.1205372672979008, 3.5680717695013406, -0.5429988395927161, -3.432013104108939},
    {0.3864019553208393, 2.7076689145636026, 2.345471772338222, 1.9019079077050045, 1.0745586588222333, -2.0245275547809594, 2.3060103801930323, 3.2620193157379678, -0.7290511914315335, 0.2272683176590159, -1.293076011815698, 1.0840939677758559, -1.1812025618905375, 3.03918910784434, -1.3827959204280973, -0.359581214283189, -1.2532756563639593, -2.6450782393385652, 0.9410615135966904, 0.6525659407303848, -0.9308116201229034, -0.08118418978478303, -0.328168025228559, -0.63559432423679, 1.1504355537625377, 2.7570952706893825, 0.04742717163898965, 2.4977545767128353, -1.086306961165203, 3.1171482482791304, 1.046359216521804, -1.9470171109061745},
    {2.5554056969421524, 2.076891692009528, 1.9367038532208034, 2.756681446860186, 2.699513887631747, -2.0051934110966507, -0.24128869645994927, 3.052586718366232, -3.301455637195346, 1.5502841795439508, 2.3461385163182054, -3.3039092360584137, -3.743228836139932, 3.782650933830188, -2.490479950902849, -2.6571179293098703, -3.1035912731880315, -2.3752131733298723, 0.7995081792324961, 1.688176279098786, 3.4260797370854914, 0.9138742935468941, -2.016778938751427, 2.695204248807845, 1.5470729236332006, 3.8024724414911515, 2.7768424554870603, 3.5297709695276884, 3.223886060213769, 3.3337692422927816, 2.104129325851349, -2.4859715947470225},
    {1.7770921518821785, 4.369544888397696, 4.7532215636182915, 3.5305383080847865, 2.7636470993350697, -3.7408829403119315, 0.23681583054316177, 3.4205721985603774, -1.9835142705852877, 1.9348152672442018, 3.1545296394740854, -0.5394484620377921, -2.9355099492698082, 3.7798646847002844, -2.7925425983627132, -3.046467748117201, -3.028076206207067, -2.736879887053927, 3.901228951194912, 3.1457330795361864, 0.8445510551055104, 2.336005997987986, -1.3844467466507855, 2.275342255611621, 4.15640361147144, 4.099593053103061, 3.318596638137579, 4.3863746807660515, 3.1078712749234834, 3.4266096925321037, 3.2471985467196016, -2.446164972137037},
    {2.185156121261841, 3.369610535464131, 3.9892296521366952, 2.8824493184796105, 3.2803424066427254, -4.299202442978359, -0.5499317651226862, 2.256064998726718, -4.474667460432198, 1.35596226146018, 3.154744820552274, -2.8204708586973237, -4.61094266124602, 2.7296709434869415, -3.7708414271775172, -3.8161637449955594, -3.925646765334699, -4.771453099574108, 3.3502168080878008, 1.8747369594778756, 2.216544046354323, 0.3027903618325222, -2.3601917060317716, 3.0151824727615617, 3.4001451529771174, 3.5598264482102095, 3.009723144612653, 3.1328097194986033, 3.2626966835598608, 2.89450408402163, 2.2225895043428396, -5.166134467817326},
    {1.9980641510297923, 3.320473820397865, 4.33940765086079, 3.121263308578356, 3.2382316591813676, -4.4726569728674015, -1.2582291310267153, 3.514674150090013, -3.703267296915966, 2.115621779320902, 2.2272537961402095, -2.658298425778027, -3.489629497972924, 3.0636930982372563, -4.206771831482238, -4.374085787498341, -3.6268252607228275, -3.5541363218204243, 3.9074144604577334, 2.8873819985001568, 0.07628856495399057, 2.031219141256275, -3.662113801990488, 2.0538116995463453, 3.394415334392734, 3.830360648422007, 2.330309702556906, 3.56161780449179, 2.706766175321716, 3.394890231051709, 3.222306772506868, -4.596393569120218},
    {4.24068450841963, 2.5329200098509608, 2.8601872225750307, 3.4803824711619917, 4.727132417335961, -3.6556428118427196, -2.478873864213727, 1.549369439967577, -4.213545335857185, 4.733815338732817, 3.790754115960315, -4.490556674721445, -3.7097808223218918, 2.5685768940087432, -4.051184370080469, -4.992860596153013, -3.7741748108002313, -1.3780811270642284, 2.182203263762364, 3.2814566754326546, 3.5198813055231186, 2.7404467158199495, -4.2067024992005235, 3.926916616527735, 3.198686985824013, 2.478351883632923, 3.72580042577193, 2.6355624988620634, 3.593567534533761, 1.5625464536179756, 3.841288799124165, -3.322028493547089},
    {4.4669796857102115, 4.108081150654966, 3.8762654555282103, 4.347838136709277, 4.582312805894936, -3.8987963007785424, -1.431969383525361, 3.685839772920906, -4.54361643610563, 4.599756468333792, 4.731923231538162, -4.56042744644223, -4.87130201138882, 4.073558641117884, -4.530369444130415, -4.130127124826053, -4.742512867271089, -3.6522460954491303, 3.6203355100926022, 4.3630113485784205, 3.8761307632208415, 1.6517464056498745, -2.765273827022841, 5.0815163063627535, 4.393209707735437, 4.5254684821718385, 4.447777955766662, 4.71473911518262, 5.57713238322975, 4.005520660688316, 3.9965590708224745, -4.329873605903103},
    {4.623155438789603, 3.678363974790108, 2.9408592845624386, 3.343495924815162, 4.3028510472242845, -3.737110071023278, -3.904544883317733, 1.6172906238895457, -4.662911093896324, 5.585360935465253, 4.5717786907139395, -5.152365422437763, -3.833431705436677, 2.5296166120962207, -5.061548213350589, -4.96485667428904, -4.712341184327229, 0.5581581441396478, 2.450441837907168, 4.707993945949461, 3.939557701919538, 3.940087856319344, -4.595653448579554, 4.634010443555733, 4.387747117130311, 2.2414786756878753, 4.200630103063975, 3.3504369444880036, 4.524238212845117, 2.164153359125761, 4.743348963952894, -1.58562576068727},
    {3.8920162680338546, 4.198071689881436, 4.4786779693064, 3.7600644505462113, 4.674901767637178, -5.04191933773407, -4.153883574074132, 1.1155632120372356, -4.557793443686686, 4.327054799174488, 4.7793014927328965, -4.719061360320311, -2.9681249857932364, 2.150444649539733, -5.122778654593351, -5.604126187451281, -4.573887956994296, 0.00954612063947499, 3.8474659924581416, 4.489691463002369, 3.0946756795545296, 4.00727710481919, -5.420092408588976, 3.6898822504542172, 4.6294311837717705, 2.592897992333632, 4.614547261496316, 2.632998929827354, 3.5798628454410033, 1.576195062400752, 4.756805427851521, -3.245580541979302},
    {2.7557398109733273, 0.18412505214757463, 0.8849933527027196, 2.230881940027078, 1.9711070148821639, -1.964306725714582, -1.383336210458382, 0.9056387588639088, -2.5036852232344255, 3.1468175538279857, 1.7510364954541113, -3.3715520858344123, -1.9375615867339375, 1.9747945947402465, -2.904180413871121, -3.175987032893999, -2.8984530873222276, 0.368217285098506, 1.196309252948976, 2.2057066772967495, 3.002659548753766, 2.9927011422721703, -2.750192497981423, 3.131309499210933, 2.5021058498483035, 1.7047221625909608, 0.9589711870479134, 2.6658951493816736, 3.6465273140972836, 0.7623484481313001, 3.6961463144705626, -1.6419409117045025},
    {4.066229025022537, 3.684736382024972, 3.5294806408591772, 4.365909034104169, 4.015353085702581, -4.207674124878266, -1.129224476375938, 4.245924843027955, -5.389364978162267, 3.496531183579652, 3.6704878670902636, -4.774124385166951, -5.071238342571621, 4.525184492885489, -5.327786132240553, -4.5967615552633445, -5.235453300084253, -3.413291418174984, 3.08070322948646, 3.4272321691738528, 3.4208908757213115, -0.3519511105945344, -3.0595217419771363, 4.075569805043325, 3.4013512396703494, 4.704394041613451, 3.873882029331656, 4.713058827472544, 4.983608477031859, 4.127489025727412, 3.3143708653396513, -5.007013527507296},
    {2.199272780464832, 3.3957384016463155, 2.7996552240947445, 2.9130960917043582, 3.131599464679453, -3.2959522991591803, 0.054155382402982066, 2.5805043023205996, -2.7119813256780403, 1.653685681219342, 1.851998196645778, -2.3147181882450054, -3.4228893624076657, 2.5909439448842284, -3.3082053354553356, -2.301368010202775, -3.5386398556466965, -3.785222961510786, 2.093944130274415, 2.103902918822846, 0.9703076742101695, -0.8998264550917793, -0.9434735476783026, 2.8278667768625634, 1.9081064192451174, 2.7171404103639296, 2.4676563412566734, 2.181722537329718, 2.72438684920134, 3.263402613398145, 2.9025476750002315, -4.7149021447714885},
    {0.745280822086637, 1.057817904862238, 0.6650696710657986, -2.554182326539086, 1.3066584998523227, -5.999436893756072, -5.368144940503439, -4.004731500225106, -6.161297375529605, 1.3852752656323897, 1.5945109749704387, -6.06210436760914, -2.259766981768047, -2.071742877243621, -6.31348955429508, -6.447154152754987, -6.34984054903742, -0.19459974885698125, 0.6515752451910749, 1.6696188618737602, 1.1791310421429448, 0.6092204107820823, -5.592386513170206, 1.891564172719122, 1.5842341393320172, 1.3695557860139667, 1.3307239678881624, 0.5973305235885144, -0.17986586088421588, 0.5248190951500729, 1.6219442279735565, -1.5403376817727708},
    {2.4155090852576864, 1.9389770416456595, 1.7360270057050067, 0.46166568876669817, 1.8808369813374104, -5.008998429025812, -5.34536765047632, -0.41057105914034153, -5.439309928420735, 2.4503556874483126, 2.736987150239156, -5.468020351519522, -3.7786290202080908, 0.22841775538579995, -5.749211199343591, -5.443409901189341, -5.461362559892481, -1.569804596016176, 1.7564044127652862, 2.9754804875916396, 2.490284822758885, 1.8294767634730664, -4.607735472165272, 2.630912333940989, 2.580251729453887, 1.884368510838321, 2.4352601452750227, 1.7109462889908278, 1.720333163166079, 2.824743554122569, 2.6706675393186012, -1.2574594423739198},
    {0.9767575056987358, -0.4029993513320108, -1.8971045081665716, -3.8446388833188307, 0.6133326666304387, -3.6041943239544763, -4.37288977337976, -3.11033361339255, -2.471588361925098, 1.430546535112458, 1.2364085868001784, -4.157613297439431, -0.4625578903964529, -3.1430751144402964, -4.03796370692774, -3.6872255853637164, -3.614713240507212, 0.8576570754188642, 0.5091255096056903, 1.65210054003704, 1.3254822354556048, 2.392115743863507, -3.300951955075531, 1.623730364704387, 1.3945574018545674, -0.05297879758608661, 0.508163666885364, -1.206735492830383, -1.4216767421596994, 0.5995488671730821, 1.8548783388416281, 1.1096838024829148},
    {0.32919616882878, -1.1832718144232244, -1.350824854976889, -3.78016518538024, -0.08772366336004671, -2.9124531152726307, -3.638101478518531, -3.486472326295251, -0.6787904792652252, 1.5672587614197357, 1.1214489764049635, -3.383744830219276, 0.2996326479172488, -3.1594423458919656, -3.512938130573125, -2.1940200343584637, -3.703735036368114, 1.3666708814129795, 0.713439639917351, 1.8552210175442445, 0.6460945822135842, 2.701431594461462, -2.9360638752684, 0.44788741961213124, 1.6682599544146213, -1.2268445954539304, 1.4939140302996583, -1.660404212667111, -2.3247338335378678, -0.6467135833925449, 1.7431762347094055, 0.6555374828473004},
    {1.261685379917167, 0.415876536367442, 0.6968085106720096, 0.9999976450800603, 1.4103285920299162, -1.9496994521240925, -2.781377196464639, -1.6922220278469908, -1.6824180666288484, 2.2174443502127152, 2.212395126935335, -3.1457813294950356, -0.8615780211955265, -0.7996812044122626, -3.761060923151441, -2.891797776409959, -3.0075370843133045, 0.7654086058759406, 2.5348433182159162, 2.1720001949279917, 2.1204110933002918, 2.9057787737449408, -2.3227010244863076, 3.306218581748226, 2.3169157421596194, 0.8741147665438839, 1.8299999260860416, 0.6962027837487939, 0.9286856712841743, 0.21640795962255469, 3.267058995646506, 1.4438943742537493},
    {0.8771475738653886, -0.6008190543269398, -0.8428601534620312, -1.0128948394011241, 0.1557733577095593, -0.3393207938983005, -3.394930519530145, -1.5409578501441838, -2.354817728489014, 2.410191717562781, 3.235056903617449, -3.384511187213183, -2.0451550050445935, 0.06968839546402777, -3.1492011651086558, -1.9937478402083397, -2.719552740953998, 2.472977717970667, -1.130982031806104, 2.637120138098855, 2.906758463565312, 1.3406091549091035, -3.2185857570733045, 2.256776447225603, 1.6750324914013488, -0.5436760782824273, 2.797810543423205, 1.2893914123837529, 1.9017564579392816, -0.08691615001584088, 2.1454530891119608, 1.5322815252988893},
    {0.9333044975648879, 0.0343299620478875, -0.4324600416780426, -2.2532049947203654, 0.6083095492930455, -1.0137900878463433, -2.427417911211249, -0.5204754393387133, -1.131873762019541, 0.8732336552708645, 2.135400538682304, -2.3087247103536455, -1.0089224639909204, -0.9762109818074017, -2.6619152971064, -2.8414453341111923, -1.7461066200422903, 2.182127679949249, -0.7622650971998007, 0.5399813085717544, 0.44873334724150993, 1.2291554529081572, -0.44147806807527235, 1.0543442912039231, 0.8202778489730144, -0.7258144651024656, 0.7972378765826736, -0.09034307099965874, -0.8633506415420851, -0.41952549110345533, 2.4917144992747824, 0.015554252715788334},
    {0.14840194381658994, -0.9701226779656527, 0.06823511370944135, 0.07755043475622828, 0.0334555729728265, -2.6694196129850716, -1.2018668654996623, 0.6578451419723473, -0.5480420531002524, 0.7221007986811561, 0.39471820271546754, -1.5962019814116384, -0.45359018601175066, -0.2986776493239769, -1.773312416606331, -1.5244535381423772, -1.606013584941315, -0.8129910110142928, 1.2095020821762021, 1.079050052173278, -0.7303124682090065, 0.44385285809875114, -0.36363387888256954, 1.8978584527330749, 1.4622847128437033, 0.2510151811837721, 0.9609528056994678, -0.806623223163235, -0.7654636015417714, -0.2650789360226312, 0.9936834406942675, -1.1803501262148384},
    {-0.5389502056298485, -0.8402640748712347, 0.49369177293401517, 0.18220075355727103, -1.019629429590696, -3.3492436214960355, -1.3239594589668857, -0.00872841316965067, -2.9277756749430517, 0.38628441711227524, 1.8518200663099733, -2.9918880757196806, -1.560340082978224, 0.749777563773172, -2.790605057591118, -2.018647583835557, -3.2101002693975573, -2.2946045090768243, 1.0599179132560954, 1.0048594122378298, 2.202768993111848, 0.936731084644588, -1.9315624936488647, 1.2127509554113312, 0.9265218639595105, 1.2681224361223185, 0.8157611778990576, 1.3304567481991636, 0.6012593434988651, 1.6813696269889071, 1.543585383520007, -1.6109488948331718},
    {1.191234897782232, -1.7478102383872458, -1.3613019412474825, 0.13838599559761133, -0.8249889801006816, -1.2876215466987722, -1.5288827670022946, -1.0558504088527312, -0.7343468943418152, 0.233151636920645, 0.561819095092683, -1.4465824638307903, 0.2918612053552755, -0.31902582171959, -1.5289659311066364, -1.4921427015970394, -0.9610652321511125, -0.2720454067944736, -0.5283983482849455, 0.9477868950520976, 1.4761928027113063, 1.1637686084059562, 0.19319419329480048, 0.6480714767924265, -0.7012834638117268, -0.8295320587476, 0.07457569502828833, 0.40093060800332, -0.13997606277286065, 0.7580350070201838, 0.4937940196593728, -0.31984699136351663},
    {1.0162356434487914, -0.9344161890349114, 1.1208289720663551, -0.4828330110664061, 1.266053979304015, -0.6993621762624656, -2.2753599711934798, -2.035170623676898, -0.7950861421842209, 1.2891871575103249, 0.5839480851211587, -0.8726711868114416, -0.15876131934009763, -2.144175805933236, -1.7357756916134293, -1.4820978952313284, 0.12390456392031178, 0.10991428291231006, 1.4302112571980794, 2.6952603277480507, -0.01714605861028748, 2.198042651864235, -1.3494551493995928, 0.5697051648610062, 2.0242991066626583, -1.1005912282492984, 1.262760578880012, -1.4695603653100449, -1.3024160874576085, 1.482244200717685, 2.4899858687837884, -0.3553762182375182},
    {-0.7250214874012397, -1.185926563975477, -0.36147298568152597, -2.4113524157450077, 0.479744303035307, -1.517783601091975, -0.4384530746462647, 0.12889186889988943, 0.09613381199323252, 0.4684856603017852, 0.44183839491115007, -1.7106878550875069, 0.3425895633471625, -0.7695283348508879, -1.3994979316343807, -1.5087890939834874, -0.32749390176791765, 1.1456005626230006, 1.5178672371833852, 1.2739668403978848, 2.0231620982481417, 1.5759620997794792, -0.5002733589790012, -0.2586249292044069, 0.46079130343763225, -0.6630214524553519, 1.7997286101711016, -0.6328522941783449, 0.7115464511897387, 0.7360797564076783, -0.2891780089244738, 0.4141416443828238},
    {0.05400117600238616, 0.4594938102779109, -0.7166651909891487, -0.9774330417328656, -0.24370470394502647, -1.6530865341999985, 0.18370890885938085, -0.22186319780559663, -1.7703471448002186, -0.8835956216002935, 0.633537119469551, -0.9112517478427061, -1.00122465514887, 0.20051984110905924, -1.122394441187142, -1.0435172631556762, -2.002325962234887, -2.075238334615877, 0.9959628945316459, 0.5878143615061333, -0.1394935375117215, -0.28077421522107454, 0.6022355199355968, 1.2484277976839673, 0.0031846116787022194, 0.5175980134986855, 0.7346666657126689, -0.6732194192130908, 0.8671020310873775, 0.4521277073360308, -0.34935736123895933, -2.2712141538917274},
    {0.5281115437275893, -0.22263036130190259, 1.6252255996884566, -0.9053611035628103, -0.41248038072148924, -1.9069551264666829, -2.1555527115269792, -0.9574276430848087, -0.04305842012374559, 1.1407317770617929, 0.19026352530931598, 0.5191168282866812, 0.9966262269467023, -0.8287823948821943, -0.6502269494832796, -1.2525009759989318, -0.5547125618945992, -1.6515885806299104, 0.9596045338952628, -0.010287323196685322, -1.0609256465948256, 2.181840461125287, -0.667170126378202, -1.6756682831668532, 2.2980266916667986, -1.3236647007720164, -0.2797900787568468, -1.0928545751712615, 0.2115832103927863, -0.3023222464933115, 0.14109745086004732, 0.10428483288456014},
    {2.2403247022785155, 0.07227542939443206, -1.6945014419256927, -0.4306639004148186, -1.2387749001314514, -0.2602709210515715, -0.01904688409868947, 0.34520231434430554, 0.020334962297874685, 1.030573253771711, -0.6235939456849633, -0.18323670904457454, -0.3353511983635992, -0.5038745388199796, -0.6061572723357233, -0.9508739804512011, -0.2724466188514354, -0.6908559572506601, -0.631803895322732, 0.8044214297895959, 1.8851658209603013, 1.5992705208110103, 0.9080213177557864, 1.3849183455267444, 1.2229928815409419, -1.6113979311697273, -0.7892265670540858, 0.006170795235682339, 0.6740649910255395, 0.44946784483522895, 0.3048669051022804, 0.5986003391717369},
    {1.2501797823813472, -0.172579003682403, 1.1650504932190748, -0.07920869549778799, 1.5920192935036714, -2.346967335347876, -2.0570964564611147, 0.7505309344203938, -2.7146135352737226, 0.31096289138991456, 1.0968084690156634, -2.7893512606563617, -3.057342079087441, -0.12097662660229913, -2.738937692724223, -2.9149356437697467, -2.8437036727723775, -1.9563479089377245, 1.0420491355507822, 1.5410130790859828, 2.863204681274866, -0.23252287768467972, -1.5449560541223404, 1.244827212106222, 0.3837885677843749, 0.02643082514191168, 0.6865213307479628, 0.7369969087657047, 1.53938610799809, 0.8087755723253784, 0.3962190108071237, -1.829650906614887},
    {2.2114894894273434, 1.4918692620096892, 0.4110370101818023, 0.06230280066489648, -0.41641768971001586, -0.8598440961614507, -1.0671314502080917, -0.22766006770309352, -0.31954149732054743, 0.9959545980112064, 0.1885949900027752, -0.7180696698112408, -2.420124962237401, -1.15677013073074, -0.6682398554351281, -0.28112560431599254, -1.3874741190391262, -0.5260593468365814, -1.8965618963101425, 0.3546187636622801, 0.9871448195842136, 0.24078547395544853, 0.27014171578227303, 0.37614815480045755, 0.9878328378086668, -0.03057787312940814, -0.07616558233013719, 0.7069231397852842, 1.493620990479991, -0.48320643254828693, 0.13106241157719453, 0.3592404261134428},
    {-0.9471413294329112, -2.3468649606115606, -1.4404434497160756, -1.7943287691498377, -2.2837358070667295, 0.08778517051800627, -1.230355796794919, -1.53032353341143, 0.6925023624411176, 0.34007558942189897, -0.7200873963544018, -0.5579689723926764, -2.034985116615112, -1.1566024859369, -1.1602819392714578, -0.5077850794986987, -1.0444027164043113, -0.6979820202036092, -2.1664367676817773, 1.1320569887581924, -0.18973995881519867, 2.746638242572737, -0.2635923414494687, 0.05105523779206494, 0.0930283960388884, -0.6774173952528334, 0.6513148450330816, -0.027698534717412463, -0.4159849731028586, -0.7786767760724733, 0.24984376639013803, 0.354119439144599},
    {-1.2877409679276384, -1.4374859259235213, -2.2906593731823626, -2.051325389438102, -2.6565614671253823, -0.22902886207373913, -0.9142660809800964, -1.120264055320249, -0.7381214418165987, -1.840353882025809, -1.141071253309159, -0.3096289586202601, 0.33420711325193403, -2.3970268854585473, -0.15735040477848233, -0.14275513313617386, 0.11996630152069647, -2.2690037786419044, -2.2795925252935136, 0.02317382461192768, 1.555993492643759, 1.9092748676883113, -0.45890180486118487, -0.11517318419036388, -2.8357534666587063, -2.4631611459214557, -0.26572237467893284, -2.200427113237947, -0.4492688264489166, 0.3528495107247991, -1.2484874347478554, 1.3632907122309377},
    {-0.0040631123416894925, -2.2863251403668863, -2.5929235470160408, -1.3096645170729728, -2.0346230736892577, 0.17047255389978658, -0.34854241106537354, -0.6401209822713126, 0.4960420975825085, -1.0407714984292087, 0.7439244943949115, -1.126222696326795, 0.6467522731884745, -0.8522008951539022, -0.28644180911084627, -0.6388763968286556, -0.3831798896001149, 0.19048960895680983, -0.02391490369586292, 1.090884764129099, -0.9781730209767254, 0.898729085434048, -0.5861035990227509, -0.5001886741727715, -1.0418956761803324, -1.7948640856648832, -1.5094099617741459, 1.241518057403965, 0.28824407669323726, 0.14147694643364436, -0.0996317908165527, 1.1696712339111937},
    {-1.5163992427825468, -1.4403241760528505, -1.8398026472283244, -0.9018200123178635, -0.01218802340878982, -1.3342933167865916, -0.06779390019060731, 1.198993000237283, -0.5351001952356745, -0.5365940539532108, -0.8232044781472369, -0.6106764854271087, -0.7120461190708824, 0.13415381919760938, -0.7383419514356528, 0.7315996565473772, 0.02867824571595682, -0.7828571690771664, 0.8823676881393274, 0.1550243664818987, 0.25818677329709777, 0.06729932563092964, 0.33784223446672856, 1.3058519514442675, -0.5693490327503468, -0.6052399617747822, -1.0742629315631709, 0.9129224559762387, -1.4024804382080485, 1.8878660425148863, -1.0649077240882234, -0.6588581663805736},
    {-0.5838826842789059, 0.10818828946681856, -1.9193041677601477, 0.35458350629436675, 1.5420049145969383, 0.08134375135732609, -0.32908165750799456, 1.5352677626159659, -0.6350532082298481, -0.41621185424475515, 1.1168068943344545, -0.024271236419599034, 1.9010344904433192, 1.938612897097994, 0.3649261870768751, 0.5653382927987023, 0.5499146061971578, 0.20311087736595063, -0.3361356224948934, 0.9020491153453715, 1.1535182135386433, -0.4592104854804679, -0.7630595805518874, 0.44165826740643876, -1.2610030661341982, 0.4084396023235018, 1.4316343622747432, 0.05417768220450809, 0.32931246077030935, 1.180929416941607, -1.8700608236438208, 1.3286396837683148},
    {0.8573572679618732, 1.0460610493522724, -0.5194293824134654, -0.7309669145181797, -0.3414671713519883, 0.2420964631623069, -1.3693830564842626, -0.47996099263077546, -0.27707233549793375, -1.3264742197755612, 0.8436078514594585, -0.11649731923230669, -0.2087137486422537, -0.22841995721523214, -0.6121190182994326, -1.3132885217747863, -0.2525355911669142, -0.9204994835604843, -0.18074250092100266, 1.250696393962333, 0.557852701096901, 0.7920989703866551, 0.03547460871115619, 0.02815246204924622, 0.25202971118197715, 0.16474063518662005, 1.4127295934430328, -0.7081793007180176, 0.8918222871207945, 2.004994440167269, 0.04867431764205739, 1.1910141122023306},
    {-0.7908034915171192, 0.5817240448480369, 1.4214019379560014, 0.7574826372331968, 0.4609612845959199, -1.1534191989254619, -0.40532799377184253, 0.1283310533800563, -1.5875680122285736, -0.2843930982596693, 2.4116006681785525, -0.9233372964407962, -1.615408177571284, -0.3745520833278337, -0.6292175613549894, -1.202245112843072, 0.47060547131279346, 0.006913581463147332, 1.757991553931387, 1.3192775024877883, 0.7437170465155001, -0.7613246924411516, -1.4136563415669818, 0.4111301062191595, -0.4411941767866121, 0.14110724341813202, 0.7546804819891734, 0.10343557713226108, -1.1415067616047934, 1.0889291782450914, 1.1815736517513735, 0.07842525111946567},
    {-2.090796913943815, 1.7268938923735848, 0.7666442435760298, 1.176420783057463, 0.6341044632731427, -2.482964509304795, 0.6068892232793792, -0.9697876744374615, -2.3149195212227265, 0.24900406588317717, -0.01640627186451475, -0.02307301043590933, -2.138734763393367, -0.09293557779994699, -0.8516054573464248, -0.5704944624930925, -0.5982693488266059, -2.380799202846176, -0.25000289027198697, 0.7152510369201301, -0.022590952449648947, -0.644240582461418, -0.6993667432698135, 1.424598455089239, 1.0631817066709122, 0.05719673504063441, -0.5455520984498438, 0.3662800001741512, -1.5856492830883586, 2.133321806805162, 1.0273269844083739, -2.6116074386944823},
    {0.3846120046417036, 0.48467294976770553, -1.853367473976766, 1.3112478288090363, 0.13050071704573812, 0.03640942729005146, -0.9533498280762782, 0.6860064437075176, -1.7600010625700921, 1.0116280232567911, 1.813794887235897, -1.466223862452851, -2.0870320826194497, 0.32563725694033946, -0.7267622109792338, -1.323494432206664, -1.1649728884402968, 0.3575467642348432, -1.0500214503863594, -0.13869439064558384, 2.1397184538265166, 0.3357817275324145, -0.14914683853675048, 1.5763891850964842, 0.773219780599432, -0.7098108234110453, 1.623806127727006, 0.7693423133347538, 0.8481373699342202, 0.7613855537696184, 1.3617169221425496, 1.824682333822435},
    {1.3029239516908229, 1.8584656379822504, 0.8071951041336598, 1.6460277603038314, 0.7774527102180607, -1.8030518840961336, -1.0591703545494024, -0.3528195398062956, -2.9200081267275335, 1.455396249174905, 2.2169604654121127, -1.7509186733085091, -1.5708944038367076, 0.1789089476676321, -1.7547840685867817, -0.08961532150392829, -1.991581938198001, -0.857515138087863, -0.7584726925452518, 0.9145504287873573, 1.4238823179183904, 0.23234008797102038, -1.4821048533399939, 1.8532878080778032, 1.3113603819166293, 0.33222805580465825, 0.7886213344048001, 0.39941058964393006, -0.3066190449311491, 1.4227876068078478, 1.7072665406057375, -2.9880910411251342},
    {1.4029041034563792, 1.2180582589848648, 1.5131135671317177, 1.6088653677523985, 2.0172206845882403, -1.1018315442556814, -0.8089560839659203, 1.5468348497710467, -0.7462798255237437, 0.7323590393437016, 1.725483194825799, -0.5027533730988643, -0.4771422440497966, 0.9106249210462769, -1.0129893178243434, -1.200368883618323, -1.016982917752945, -0.9372123680040327, 1.6275093680477768, 1.9688099552281415, 1.9490864671781567, 1.40125694505831, -1.4980572060821702, 0.39552163387387584, 1.025175522175712, 1.188607513865464, 1.7316643195922385, 2.0315050694786496, 1.275191565355762, 2.302991311566995, 2.0012093125652903, -1.518470211985691},
    {2.4933150085051348, 2.364043871738542, 1.025858512531168, 1.6245410561024793, 1.6708885318280677, -1.6961487680084872, 0.12018320588259129, 1.7124655505645292, -2.4721834514792254, 1.777781251548586, 2.3746325954045564, -0.7783815196049685, -1.6929761079010144, 1.3977135252663995, -2.4233586259839366, -0.016568451160711515, -1.765403573559694, -0.988632902038879, -0.14975819206949023, 2.0958711320451155, 2.8282934138167, 1.645052203364541, 0.13805287396928692, 2.6101379651180903, 1.2913721888526386, 2.167978036098331, 3.110911759159149, 1.1170963973733343, 1.45195289119267, 1.9429431115914575, 0.8154759918066591, -1.9622031697314892},
    {0.1581524005134018, 1.7853076526273124, 0.9378252503658254, 1.774331176923097, 0.9784032734953524, -0.7885366049011922, 0.2499024192388404, 1.385161810293147, -1.672889878191389, -0.03829724241400678, 0.7054142773849481, 0.07606014284254889, -1.9288169178694465, 2.3389353851740666, -0.4680157945386598, 0.039096566217498324, -0.47544484909840123, 0.18769493560408312, -0.5979503300809712, 1.5100596327553664, 0.7228861447996496, 0.3858570811253616, 0.5051424785530468, 1.0577503110584128, 0.7375624826662421, 1.296180654896702, 2.119124665389212, 2.620995802228117, 2.597894093082258, 2.510899130696459, 1.3091657834847334, -0.23208301988058427},
    {0.646511165604993, -0.9929445229293046, -0.740125494183512, 0.3931689776611459, 0.3988792900448101, 1.6591108882768828, 1.338360864996931, 0.6977804522763118, 0.40833454672801495, -0.8212836345599842, -1.0487883565663763, 0.6488260599618701, 0.03532000137566799, 1.058280736970383, 0.6543867612151211, 1.2520527726015604, 0.14398390801080754, -0.14902657155934965, -0.7415425139150619, -0.5172052018054343, -0.411727732021671, -0.43061749908114366, 1.6735530690972982, 0.04807279985094656, -0.4165358574600821, -0.6666704086171754, -0.5243171487593516, -0.44221830306841436, -0.43203754903314023, 0.08590653190407913, -0.24522510255609295, -0.5117123262737998},
    {-0.2562550239686679, 1.0813984882801597, 0.5864588865027746, 0.32182972424448647, 0.8544974525472807, -0.10299305997465737, 0.9426455182067585, -0.36716988779308835, 1.6764841232153858, 0.5639785436291739, -0.6566975985532503, 0.4653452230137506, 1.151591533089809, -0.717102556896765, -0.035739758866198436, 0.3582794765950947, 0.1723440516114799, -0.5597992985494555, 0.7179491173471638, -0.35020312307960816, -1.478419229810131, 1.0249252338475214, 0.3071401470466062, -1.152343243810097, 0.2989355390941072, 0.1817187616868451, 0.3602925041069897, 0.5009512609079939, -0.9047319577730724, -0.7578116554925751, -1.2105536556380312, 0.40375835230512563},
    {-0.7577840574947432, 1.63913720536841, -0.10366371762954947, 1.2550419979020924, 0.93774590285399, -1.4741481807211707, -0.7588544793764547, -0.4259475509127938, -0.5112192367859886, 1.1157027380863251, 0.30275843619169207, 0.46743410679340414, -0.5793825071475056, -1.3502645175726449, -0.26885864348648736, 0.04263891177063983, 0.5661619256150301, -0.14688601630373033, 0.661740327079639, 0.44551122367795026, 0.8964719445465227, 1.2774728787068454, -0.4073081180782984, -0.1800325053278146, 0.7796753080988081, 0.83476922813071, 0.2464245273945776, -0.03988917661466455, -0.87193006770061, -0.03154326661559437, -0.3651234982916062, 0.7383467962120203},
    {-0.35500323406913487, 0.7639095030215602, -0.7437863986421438, 0.03887625945500852, -0.8770308055881194, -0.2587917736751599, -0.5075269045909464, -0.5921804756465339, -0.7150775579767155, -0.41154803432197584, 1.2675726798811933, 0.42880530398944483, -0.38378919453806115, 0.45431035451635976, 0.28418511079722636, -0.13457632482776802, 0.3797728321979362, 0.6639393653029624, 0.7510791481623946, 0.2432618375474426, 1.2427664781598318, 0.3858301738971745, 0.04063823508041402, 1.071862972391361, -0.03392335026393058, 0.4668066804024216, -0.07357506389295783, 0.36685077337005445, 0.8017103171579101, 0.10982566209671464, 0.9162143834880956, 0.8321084379241206},
    {-0.662870895674141, -0.283024187178069, 0.09554338391606415, -0.9383537284879754, -1.2490752773425315, 0.33692890188805974, -0.8113026941193773, -1.5035559589828043, -1.452200325307758, -0.8404022123191915, 0.7531948451408447, -0.6542541280439771, -0.10270488880160121, -0.186163990878685, 0.2577068449431745, -0.589914599469838, -0.25425126876171916, -0.7469631251807439, -0.02364522106822699, 0.7724347598542204, -0.25578162004512456, -1.0530409680463106, -0.7537050896958541, -0.5121463091834755, 0.4599352346523021, -0.34909311196560777, 0.2604481525797325, -0.192859932187389, 0.11215060925968565, -0.037687915401884625, 0.7398012188657856, -0.18557518032328252},
    {-0.9774546697033533, 0.11469161026779655, 0.18169818267041282, -0.7032218943637584, -0.8482052390924686, 0.48747323094664696, -0.3255035440354244, 0.47054535355729976, -0.7071921547872392, 0.0215411451269242, -0.17504728056483926, -0.3326438300690864, 0.153123153347164, 0.8950108024904617, 0.29459560372132804, -0.9441245711246006, 0.05363785374012417, -0.4618245147581344, -0.17500104193363325, 0.09362324679849238, 0.4762199929333174, -2.285414089918447, -1.4456626894469577, 0.06867217629288479, 0.3494099867760211, -0.4545350462495476, 0.03829129907053489, -0.6666862939936756, 1.0349955070866899, -0.20047062150163367, -0.3136044905938772, -0.29117176643735804},
    {0.7443145129646821, -0.1891237802425678, -0.2417393307997473, 0.09317475328797371, 0.2198944224410705, 0.7024862483101316, -0.5503454778237887, 0.6781332031722435, 0.28216775196244814, 0.4946278141156917, 0.07568819689413447, -0.49340896012353264, 1.3921639852901535, -0.4278206639873679, -0.4439169101505552, -0.9051564927584956, 0.49330017185604585, 1.6684131637001556, 0.29193709776314797, -0.4365124425648938, -0.059805857782354636, -0.7342721252359886, -0.8503616311207047, 1.1205419407183648, -1.3248870157568964, -0.8713154329795433, -0.590461772637513, -0.9953439030294932, 0.6633693685667152, -0.32083656708919017, 0.07887196010308094, 0.6712730961947778},
    {-1.053392408582962, -0.07045789929196851, 0.12346890368946468, 0.18173133416642473, -0.5353552848803971, 0.20006986763286652, -0.9012363654373915, -0.06227159489621793, -0.02044521001699266, 1.035842190622817, -0.4745431433739442, -0.8315851808696696, 0.37544057964213495, -1.163043785187028, -0.46200075953282943, -0.5957520557330882, 0.14185788789710221, 0.7709166662145841, -0.5909225565430121, 0.730174255462905, 0.10108041630802968, 0.3840390006100033, -0.18022684680722031, -0.041784494728862455, -0.5201765515265472, -1.4523407740760128, -0.8749882797954449, -0.6905512359776509, -1.1997845583618878, -0.4457921701800278, 0.4322238278519869, 0.25314587323306675},
    {-1.3576146786829066, -0.3072802726181853, -0.162657377702318, 0.4029848402665105, -0.7415193430836545, -0.47507957042178917, -0.4429976369207012, 0.1389090394587153, -1.1682981567579918, 0.2289383868454509, -0.5315178840566528, -0.8831080463222839, -1.6698654474878647, 0.12196470749714539, -0.67587784255051, -1.4756175348027125, -1.0320043642594965, -1.013544356536559, -0.8040774360416509, -0.11024510335875941, 0.4529299009564703, -0.5863578009387126, -1.3815663711226165, -0.18060933644947083, -0.3048201958455053, 0.18948100554836914, -0.537560749787228, -0.20844146656416976, -0.22185836122097718, -0.49941447003523187, 0.658679801365727, -0.7447720592658552},
    {-0.9793099748537177, -0.7439435031378255, 0.6372187767010123, -0.16263803596848006, 0.20949791798912373, -0.10597528395006421, -0.3731387052488138, -0.1122800876886761, -0.763965024350782, 0.06360180277354324, 0.18341209322896423, 0.3265238203363436, 0.11065815068356594, -0.03890069838406019, 0.28996215984471185, 0.23279808101298427, -0.599605177870138, -1.119860064021903, -0.1943626842289024, 0.28403582986255976, -0.23160212983607628, 0.14795162132759393, -1.1513951301167973, -1.1753907319854853, 0.2176546627265763, 0.37143100264646917, -0.08741114272607259, 0.11424708739757473, 0.13133377637286986, -1.460578109025705, 0.0002653004982425233, -1.049759819550199},
    {0.3734809636035747, -1.04247459259448, 0.42742627961964824, -0.724413382087703, -0.42963278243088326, 0.3280099120911262, 0.0016888064030929951, -1.6675675760996416, 0.6156409785695159, -0.13200016538996767, 0.5225657939665931, -0.45987177283964137, 0.956534301049518, -1.0568843648655575, -0.541652586477342, -0.5641326803294097, 0.22546381822261946, -0.17547346177534826, -0.5487710795055295, -0.2989045720367034, -0.6361160044500328, -1.132588543743729, -0.7139443964888983, -0.4362463397747098, 0.08145355033313112, -0.8918104534692275, 0.28114572099725316, -0.3833345528386302, -0.8128444117163308, -1.0917615758891894, 0.18791430643051454, -0.12485870784695971},
    {2.667664371549091, -0.820150365576772, -0.23158392961838023, -0.5570558893768881, -0.24636094603832767, 0.6872391624815998, 0.2851178567819552, -0.960676361612523, 0.9118699801287591, 0.9585796480434782, 0.8772043655920907, 0.07340344080396521, 1.1602892202469461, -0.013577818967141516, 0.01400243517627162, -0.27166901647466146, 1.3646406344513669, 1.039064361176468, -0.557486252038408, -0.17451340066396626, -0.4463414304305881, -1.0262469065033593, 0.054356902655992606, 1.4960776290651014, 0.8898947781196244, 0.42255524362138314, -0.47091103042051813, -0.040097255586707355, 1.076703931100179, 1.29265393613364, 0.5595506046951486, 1.3514721313072753},
    {0.3928865407210795, 0.8884972752173453, -0.395413958684477, -0.7602427286042214, -0.3740257009437448, -0.45074291086115614, 0.1032477629926296, 0.5190674938983991, 1.4299227366531995, -0.01522447192833911, -0.46678125152703087, -0.2889766592178851, 0.8304412111671028, 1.2804239955908019, 0.34333771056259377, -0.3102624742977834, 0.22861904206504324, 1.2316083733111147, -0.7065139757301733, -0.6993370443476301, -0.8754660290983671, 0.5758011021179346, 0.21442589181808025, 0.16843028141830232, 0.5893225780897976, 0.8626750354317543, -0.20500682283218954, -0.24734401012760202, 1.7485861458562983, -0.15035852232432195, -0.03406493796846328, 0.4958590436653332},
    {-1.6048917864339751, 1.9102440518546375, 0.7582744147922214, 0.6323401434885753, 0.3593518037856188, -0.5919757107863104, 0.07880501999166185, 0.7969949458296663, -0.3331644296310586, -0.12606709175896633, -0.3446322680301325, -0.11854820240519807, 0.20073840692516898, 0.8648770512434846, 0.36845226264466097, -0.34310983490017427, -0.43697155655001285, 1.0348005918122087, -0.02877050252419234, 0.23558738075109298, 1.1880734095890095, 2.268388701518348, 0.17074802897885272, 0.8178951611435384, 0.21597777299480783, -0.7091350261213459, 1.3474318831463046, -0.8600027411087909, 0.2964582009537157, 0.24492960339286463, 0.8947810591367541, 1.2182395344009198},
    {-1.823874732188328, 1.1780764572390598, -0.6372307848680698, 1.3967402256145103, 0.47137294671632624, 0.12605075501877616, 0.6874022712388389, 0.7075101116249294, 1.2009419120294105, 0.07523446452789408, -1.2145816632547912, 1.584547306262942, -0.47079809145511753, 0.05783380282443202, 0.436977685960552, 1.2391263020561685, 0.6898605871383037, -0.7013629622748029, 1.681907501783447, 1.4122226421522908, 0.6296837514274376, 1.5183953118342428, 0.9537979866150849, -0.3419359526944092, -1.5330994720557027, -0.7396229297204583, 0.6205819860032203, -0.39623713474957417, -0.48301542048887747, 0.22624492143827815, -0.331855662490312, 0.6071991700591325},
    {-0.30750630712395, -0.11723483687272815, -0.1913814789665515, 0.35758028334841846, -0.7030707848337955, 0.954246402197349, -0.3862915076958059, -1.2999976680997674, 1.1483638244829262, -0.7236552603881964, -0.39966517198184115, 0.744718262652616, -0.4521849318943314, -1.8567782929224992, 0.5683264596071055, 0.6945234982002757, 0.27258256231946065, -1.4178847725507724, 1.3966971836727449, 0.7458499410143689, -0.26768696395456065, 1.2613012063130546, 1.1015210263331787, -1.1011893468215712, -0.8943928823995372, -0.7906028980860276, -0.9164533307503872, 0.5071037652911272, -0.8254807093349686, -0.28806220782510616, -0.8857819599570717, -1.6653118788932393},
    {1.611469375608476, -0.19292190201468817, -0.11909814932965403, -0.19487734382714522, 0.7619615637323993, 0.2960561126267611, 0.3657577556309405, 0.3059192928321921, -0.5194324201269028, 0.7558996359583138, 0.6217944140666914, -0.7199663729166609, -1.6510141849634825, 0.43292045831043324, 0.025157019511247925, -1.1893764173854322, -0.21049925315163556, 0.09965490982217688, -0.3800678685805782, -0.5908204010476185, 1.3218988711609112, -0.6217462074156813, -0.1976279569151113, 0.8463686462455958, 1.0559662946343102, -0.22669963213078062, -0.3693394459400237, 0.9390507721903326, -0.026015600463171692, 1.7042379658999536, -0.37666806562901334, -0.9461187282349833},
    {1.9185094844876744, -0.306136870740128, 0.2882326126389186, -1.1909168444341878, 0.41353033326394895, -0.9014231031659088, -0.6192263392344234, 0.38642270807799856, -0.34606342773278237, 0.479785114121608, 1.6242981587284826, -1.180544736018595, -1.898231561602096, -0.573806221808259, -0.8435127835733476, -1.3778642483065897, 0.18118514534307667, 1.958080756018336, -0.010172347769250384, -0.19751008612748858, 1.6680020585429727, 0.014814434146708402, -0.3752192461667785, 1.208507098757717, 0.7367293847563311, 0.2646670720586327, 0.8638342494132031, 0.9071860671641782, 0.5454058083233698, 0.7936270914835207, 0.0015209992780539142, -0.3884224279183735},
    {-0.3415996544499716, 0.5380115993222361, 1.849993742578303, 0.17254427039334636, 0.6164473790007442, 0.25615221036256275, 0.7887761659029239, 0.844238379208442, 0.599988226098994, -0.8648473946839067, 0.8351359652250584, 1.3649614753126127, -0.0004301689937261914, 0.0535742761853575, 0.7232962980357387, 1.8447256312987632, 1.4016819024405551, 0.07827325561349677, 1.5676469989386046, 0.7495777828605414, 0.5695383898965359, 0.2626711272366141, 1.7373795359679598, 1.0467470986960072, -0.06252169602281293, 0.38060944397270335, 0.42772173007949515, 0.08804579775522221, 0.5771500625190279, 0.6190773356503344, -0.6577706347930463, -0.6233730849227512},
    {-1.8257941452445803, 0.18900331880390547, 0.6144853791999294, 0.8259379807269163, 0.25798334214808527, -0.7261961184478537, -0.5418910417144541, 0.9992001931463251, -0.6062686712816601, 0.7419928513715933, 0.22614806692788486, 0.4546547944092473, 1.5648132100106875, 0.5016120838722322, -0.7862646470987683, 0.03685321967844099, -0.3827666311111527, -0.8280490226616455, 2.712952652434549, 0.3888367967596544, -0.7395049721576593, 0.6303040396447561, -0.6863675825953729, 0.10542293016978166, 0.05525801344181799, -0.2931041937718826, 0.4666600663163717, -0.25453683197661603, -0.5980743323925141, 0.4664943727498511, 1.031129125024364, -0.08607931739117548},
    {-1.3341684936933087, 0.05318715482804349, -1.4307317179075278, -0.32783645127108085, 0.23384009786775958, -0.46099368401100815, -0.5345348739100364, -0.9039211755543609, -0.1539942412931756, 0.42438098949948855, 0.26259413769992823, 0.279204312806066, 0.9817593606592169, 0.4429732180207487, -0.3199150380612363, -0.5656899418550247, 0.02500739721226492, -0.41289607926188526, 0.4070970723493427, -0.6584902276438536, 0.2633847893789399, -0.2485897513242402, -0.6834693039603639, -0.8315011928449086, 0.48271303136178445, 0.30179982741784567, -0.7877411337995879, 0.2113306448877995, -0.08864182339129596, 0.4660174613340518, 1.1280885321053211, 0.7814469649793327},
    {0.07424535315262275, -0.7629601268789464, -1.120624776905344, -0.5582478146358687, -0.12911614582272923, 0.5611778134696208, 0.6061537636980261, -0.6926338083846154, -0.032633352604520535, -0.8100641949321195, -0.9535344187757442, 0.49411712642928085, 0.9393996752610512, 0.11563016736586211, 0.6717459645392426, 0.09717640435920742, -0.09421652492312844, -0.19071029339010953, -1.175419187525965, -1.6587605403353984, 0.5705373658999389, -0.560395975428493, 0.3036294599164147, -0.4825520254008084, -1.056785457961205, -0.8037590354140983, -1.0978641262916446, 0.048628834114233334, 0.08171604563488001, -0.02118071766016393, -1.0042626629180889, -0.5002390759475014},
    {1.2040854054550156, -0.5772615803821045, 0.262908922352901, -0.6140383033308067, 0.2783055408644309, 0.5237013763068248, 0.8009410389146304, 0.39724150347730497, -0.1494657072199796, -0.3777596189007143, 0.0006703197025685353, -0.20604656151501743, 0.15630193715670726, 0.3981786853757579, 0.04090773138723459, -0.2727703663824974, 0.1901019223825166, 0.42282430266210763, -0.9989286032696787, 0.3829760347432043, 1.300422113510916, -0.14462583012944996, -0.46259540311109465, 0.5009510249925716, -0.6238895880595497, 0.39802164020738706, 0.5330055258998406, 0.30927391126824827, 0.8156512079833113, -0.5830841111415833, 0.037827216637861004, 0.4360313356657686},
    {0.04110443467480267, 0.22317220197152413, -1.2990411044520598, -1.4265213785856798, -1.0284545877893756, -0.09292084180919226, -0.13923168076435832, -0.6051640221332204, -0.7329872177264098, -0.3161483797102056, 0.8682425697581436, -0.49340301891713617, -0.8253738935312162, -0.977985887503328, 0.04916377205017043, 0.43889727172974435, 0.23429182657738182, 0.2463961688524234, -1.772671727542725, -0.30370889706392706, -0.7604114230493922, -1.1184318644290367, 0.010892202860106465, 1.2723377478326934, -1.1603282648168645, 0.4904374085602808, -0.1678288682020453, -0.5954802428085975, 0.4378285170101546, 0.059129968650146233, 0.06223905798430231, 1.1902502080331623},
    {-0.0882046107803697, -0.6916872828351064, -0.07668531011784799, 0.23078342958654754, -0.09718446972785566, -0.09341504020308065, -0.42093893178760033, -1.6200760147748483, -0.18173877791503246, 0.44721010614883266, -0.08744043802495025, -0.38891739923288504, -2.0678717137936737, -0.5922185856971861, -0.2734421941845597, -0.22264938614490476, -1.2708790627296516, 0.05092555701962155, -1.4868581969552845, 0.3556213632579164, 0.5962002699668041, -0.6879671439711287, -0.20432928153621752, 0.33159250635918297, 1.0366412148941708, 0.37915669965776966, 0.5549979611962801, -0.751418170841332, -0.9160032134808352, -0.6076163021762642, 0.25443137090591894, -0.3304060756692764},
    {1.304370811681801, 0.19312809332610473, 0.2124780998875921, 0.9907123860816233, -0.5260370525782494, 0.28686385010106086, -0.4620747417314806, -1.0646807206167885, 0.46668421684768924, 0.9658984347008405, 0.4197715184726078, -0.13737864577238965, -0.8132662749569008, 0.06032723412640414, -0.04920567958992843, 0.18487652998826382, -0.51657984337663, 0.04379862970245867, 0.30356124580400307, 1.1353318318813455, 0.38373909777043624, 0.09230500399583037, -0.7114395362897894, -0.8429901071012047, 0.6777074089913919, 0.32275369046073715, 0.0903493933860116, -1.1217432356516626, 1.0024252203569515, -0.47794434470555386, 1.0509943114686733, -0.2518957032902286},
    {-1.1826266065702065, 0.6143208189212662, -0.014573822770936159, 0.1305972605526874, 0.0065224693991278926, -1.0815436003978331, -1.359889752140704, -0.5846639565571535, -1.6784873665025686, -0.41166856746057556, 1.3643164165435153, -1.078774214503825, -1.4011436017156755, -0.1854744600315, -0.8534665937076643, -0.5457528419738598, -0.8565530682109833, -0.5704195732790447, 0.9656507098302892, 1.2248472190079265, 1.2140467138546127, 1.2192108653731901, -0.8591509178627537, 0.9475281786243542, -0.020411592730768962, -0.0036667644308100186, -0.09186477729641251, 0.15099930134589445, -0.08007087213739252, -1.2283037510535773, 0.49872248665806507, 0.4207917286067449},
    {-1.075061613786122, -0.0002472371960323397, 0.8439617236852275, 0.4797454331496816, -0.12063280813915211, -1.2422045395078691, 0.9467512514966308, -0.4711255150898737, -0.39542320362388256, 0.021862234308144032, 0.23597878334467048, 0.07363431069185948, 0.8445757294506615, 0.623191061907544, -0.4707350659371031, -0.6102984875472653, 0.8025324249694175, -1.5610884515681296, 0.0014585862507819612, -0.2864072451225038, -0.42637266050431366, -0.3109918046183263, -0.3562033492273323, 0.2540718246129326, -0.5569319502133774, -0.19373206653463607, -0.5001558969501632, 0.3275550323540114, 0.2667820465940493, -0.10419183281241567, -0.13698843982660533, -0.8497685095289552},
    {0.15598031505117294, -0.7010565867436993, -0.08095690401313631, -0.7491527375823888, -0.5079305553472389, -0.12929984344669013, -0.879063928502882, -0.1450788774633424, -0.3113368006073586, 0.4004347250688669, -0.4746964005233655, -0.1690628146541622, 0.5276918393745285, -0.3595389038295572, -0.1971766849251687, -0.8522312039522485, -0.18649906677931458, 0.037781417638368106, -0.5602585735769523, -0.2468245739103404, -1.0990914944737238, -0.5382824732326511, -0.5581661524923426, -0.14288914526383004, -0.6033761355878943, -0.5797495456451306, 0.2017327428243435, -1.0874885724281107, -0.13324893494349602, -0.8514320219008387, -0.4050032513427814, -0.3881523489935122},
    {0.9602313214866558, -0.0004332928577584818, 0.5978277037155026, -0.6964495733451633, 0.8770008742335637, -0.47865458785902126, -0.976499538389794, 1.4905693711712287, -1.3737609668486783, -0.32445395620898, 0.515666146955152, -0.09698974074650457, 0.7951417219541944, -0.13612772326424308, 0.5699413980513803, 0.14694616282884723, 0.4232267445899533, 1.7866002962908631, 0.7070712979026856, 0.6084777984464871, 0.9715831307853822, -0.3392650694017893, -0.5369003789116711, 0.5673572354658117, 1.1258862304131834, -0.17372378819192544, -0.13778774887666, -0.014891283009244688, 0.009039777404260561, 0.014095827852754192, -0.58853734449464, 0.6136848003759573},
    {1.8463061978504856, 1.9639185953217515, 1.4273028557984826, 0.8072210628666798, 2.4706434750776, -4.515583723928882, -4.39517851945192, -1.117622959959955, -5.880273144350883, 2.18205571441741, 3.1303329162984066, -5.803227899858841, -2.4857035609711873, 0.9930867410847891, -5.506243131696531, -5.87307171991854, -5.682559725327428, 0.41886806548807476, 1.415887996561675, 2.9057731203742088, 2.85321320131005, 1.761779073571802, -5.196664349180666, 3.164337692863502, 2.46202232269743, 2.0916470827528504, 2.9377100010135138, 2.0199392925771074, 2.212935320790916, 1.7320911591394157, 2.8646547132413738, -0.6458707276578448},
    {3.044494738584245, 2.556677064926456, 2.3569841290926647, 2.2053659947112023, 2.819241477951628, -4.6494076396836705, -4.94963149377739, 0.8235015541544725, -6.27946963155963, 3.2313988145676498, 4.058230913685215, -5.5576130813372115, -3.9141382812906165, 1.8115584152776936, -5.32497932767023, -5.498631091811897, -5.730838483255639, -0.9843806174901784, 2.0496163688142204, 3.6434112188587, 3.839839948280963, 2.367579234910245, -4.961641990735826, 3.751958410429786, 3.1339971863574787, 2.4492851673376554, 3.8352524333586615, 2.47902253325106, 2.709373586988289, 2.571338292418243, 3.414758309006619, -1.4564425797369214},
    {1.3730523576626374, 0.028492642006190193, -1.033465539231876, -2.9651314934904134, 1.1755796565205843, -3.2330621117049767, -3.970055521158665, -2.9103648833487976, -2.205574566063691, 1.7204667929796669, 2.1818475451778023, -4.3028845156223685, 0.20388219578258315, -2.534023111899855, -3.4231108606162475, -3.426817986762676, -3.286807223174178, 1.1701649441295232, 0.9024773546051987, 1.9621842909339247, 2.0345474928573477, 2.439002868434245, -3.68373651452222, 1.7370808952396224, 1.3376100960457538, -0.2142333432321089, 1.0844410207705595, -1.003208467395194, -0.6203661685517097, 0.5943834251669649, 1.9826211043021373, 1.247572143407121},
    {1.1322267481899895, -1.1366992565353335, -1.1144964670691335, -3.180113233054845, 0.33657157389727566, -1.3081763170970946, -3.133089842728903, -3.117529129313797, -0.1695647473522727, 1.0651710552215117, 1.7515520464803378, -2.609519323835764, 1.3852467480439619, -2.174123718318893, -2.3790173689523515, -1.9779039011001749, -2.7909585274956124, 2.4654445346945955, 0.7122877135138735, 1.9629147720349185, 1.473683475630346, 3.317111542461662, -2.246254912994864, 1.3516497053803451, 1.9092962870923995, -0.7473734879017425, 1.9369180941402226, -1.1357156775444504, -1.1053336022516076, -1.1088721253098917, 2.267437712818521, 0.7952279840202133},
    {0.9945192444170302, -0.2481925634914908, 0.9049809163661673, 0.05771923082540427, 0.7499806098539976, -2.3462519255616856, -2.1143537245876067, -1.791268163868395, -1.2288777157453574, 1.5077206736293958, 1.6190167970054585, -2.493884729339746, -0.7470469531954218, -1.473811305294662, -3.3389748638633954, -2.076590460690328, -2.7275633676186604, 0.041473698391795946, 1.5552860014929009, 1.0923082512553421, 1.2656330624602916, 2.5574082521608457, -1.63698863771512, 2.20030594090833, 1.9129210820321727, 0.6754519939668053, 1.5845206867708446, 0.17231256175491183, 0.15904030373050904, -0.32277073023734854, 2.4847610584379733, 0.4790246088071761},
    {-0.10305800624220912, -0.6869258237246849, -0.5633996144126675, -0.9447354319155513, -0.4324328190773899, -0.6740404438468848, -3.047826907112133, -1.8547734598812093, -2.52635352180859, 1.9349031653105, 2.8417913767969, -2.791110610173187, -1.4084261086169785, -0.37840160351466307, -3.0932560651599923, -1.9829314512841478, -2.3709900909143142, 1.81236837605461, -0.5677665174150871, 2.1504096265213053, 2.4967006151662865, 0.8417317266556108, -2.5210028918744367, 2.343174265047735, 0.8731048304254356, -0.4108370494980425, 2.5046650216610105, 0.5797759602375205, 1.395684108862242, -0.0553400803519991, 1.4225960789075776, 0.4876282434590129},
    {1.4895330491479684, 1.3119735560062973, 0.6116065035039295, -1.6177521330053495, 1.0528268417769557, -0.813767049932862, -1.4131962371688305, -0.01814997086744913, -0.9406133573248182, 0.5516772495780579, 1.9412178847120065, -1.0381419156327913, -1.6100464834151238, 0.2919726784596491, -2.12250815849019, -1.8642102316783462, -0.8498211212713592, 1.5083115060061147, 0.07644026560126042, 0.48506685642132696, 0.22451953057508978, 0.8474617907862203, 0.25955298890958944, 0.9800660342600804, 1.2021354742655401, 0.19450670144528928, 0.6942002422205882, 0.1286859642081545, -0.15670231110495575, 0.1162459765452932, 2.151063849895053, -0.5332308277569726},
    {0.5168990892880457, -0.43160534983374543, 0.3539858826397926, 0.6433699481159803, 0.28488785551472506, -2.4477452053893205, -1.2353091474073332, 0.8420079255798235, -0.7592286373985717, 0.9855132364813584, 0.390888385371656, -1.6815587595154473, -1.1164594549881923, 0.36804912490323444, -0.8814716703087706, -1.3136051198383742, -1.9757600626599927, -0.8072615873813769, 0.12349031338437275, 0.8816026802507767, 0.35939600152673806, 0.3252404348195861, 0.2264730665908586, 1.9520144207881425, 1.0087752365683178, 1.5143982518669885, 1.096216698898819, -0.3436005732156143, -0.5594373910438422, 0.5266463101078391, 0.9537733216397554, -1.6492464963014475},
    {0.07170002875305476, -0.7238330827100551, 1.1843732872056003, 0.5501330515861997, -0.558272737682511, -3.3594863787644718, -1.9943263295697427, 0.3936777837314455, -3.787785031681715, 0.3786273628304965, 2.4214831391975564, -3.0839874355874843, -2.4431910928863956, 1.1531249665907115, -2.6001366920041247, -2.485330922149735, -3.400297026198294, -2.8121265388941343, 0.8692390234270523, 1.8313358801167032, 2.2726332632992934, 0.9795350887995556, -1.6384751414662666, 1.8818812266737779, 1.007133417652083, 1.8736828676332085, 1.6865021501172808, 1.3838302845452857, 0.6927717315587639, 1.7839159523439136, 1.9846814561825812, -1.690723163430049},
    {1.0367871494680012, -1.8691741774608934, -1.288994179412466, -0.38276972899890954, 0.1343716602913626, -0.760899219567937, -0.9763389515177467, -0.866037784609328, -0.7522255937531604, -0.16517249034219986, 0.07721408983513305, -0.9926094847339264, 0.6636828103955698, -0.598215551119454, -1.3750457665245175, -1.1725391847280524, -0.3982768360452013, 0.03868860128944768, -0.7419449155192985, 0.5252443982415075, 1.3682864478524206, 0.7288988045656231, 0.5457670632322734, 1.262417836597482, -1.6031772545166634, -1.301450125177026, 0.30276706825707544, -0.4494077377796711, -0.8449452614377115, 0.9817558036513665, -0.02271385643974383, -0.07293357522378169},
    {1.918180332232085, -0.15897094895414454, 0.9634342884115101, 1.152970426952828, 1.8739840461145085, 0.00980848482881464, -1.3879511196303949, -1.2251649473269435, -0.6619090453966548, 1.7405002396647797, 1.2215234740457184, -0.76566288581107, -0.33413062077265393, -0.09497493813958825, -1.3265155211677782, -1.4812406625645407, -0.3230051066997821, 0.47102547492394103, 1.5007489645203302, 2.5787065294523184, 1.5234875220943966, 2.2496171749555254, -0.8473885189426464, 1.7303959380951381, 1.4467772838040953, -0.7017516965797967, 1.7755173036046548, 0.03243137591438347, -0.2431369936043941, 1.5096260134633734, 2.167904964499422, 0.09904360021485542},
    {-0.17658446449198223, 0.27660082702176686, 0.3722162092457846, -1.0088318815899884, 1.4205041780905638, -0.7534557384808042, -0.6290714574314572, 0.18154564306585025, 0.40057173305556387, 0.31174768331642333, 0.803676133629371, -1.109364878231608, 0.301206162861553, -0.08125491697876643, -0.8325594800309626, -0.8278191533552075, -0.07784048163662627, 0.610470520607336, 2.0384090377510726, 1.7824921094661255, 2.7039011601527743, 1.5006837834622224, -0.23164017845902016, 0.19752993911719127, 0.5831488008085304, 0.016841303467594753, 2.298314987090789, 0.14301010287900723, 1.3805839147452221, 0.7139520454717811, 0.18188773129728036, 0.6422924137168261},
    {0.4734877030458945, 0.8291966595093972, -0.6341537040395331, 0.09113829830029713, 1.0249687087338737, -1.4995039686158262, -0.8973424897257876, -0.06108625608644757, -1.6827155348211218, 0.10675187348735972, 1.3225478628137362, -0.8996841667801025, -0.5501553732974952, -0.4440705207751656, -0.5563978116500152, -1.5742945440391334, -1.6668985441392292, -1.32841347822957, 1.9179069655171581, 1.0587703733107368, 0.2048282914940526, 0.36385482227573424, 0.16233964552817534, 1.3774326948526083, -0.04605126325648512, 0.46018094259293846, 1.2362407399402346, -0.8920455452537696, 0.46861248270800565, 0.45055034677953354, 0.7138058051770451, -1.14969275241326},
    {0.4125233613902711, -0.6188843564561816, 0.9348945187019138, -1.1336058246801581, -0.9374001697397764, -1.9881756641752926, -2.0687531944782847, -1.1431389924527138, -1.2387960685877348, 0.8474794767991624, -0.27348609622460834, -0.2522288085887254, 0.3605441897309288, -1.3663097603779104, -0.8845801965538325, -0.7535246350880175, -0.7438225308842124, -1.8139349341191082, 0.7059447768716294, -0.5773626212089507, -0.8867449853142113, 1.1941585696665828, -1.0467848455396322, -2.0158874804438467, 1.1826502785215056, -1.0049675839620704, -0.24357335995456855, -1.6040971729570828, 0.4783547880855154, -0.28960890671237954, -0.862072355914333, 0.3609863557911447},
    {0.9925912535754015, -0.16706773517202347, -0.8759173794213443, 0.07304618157111811, -1.1415132319833672, -0.36351490998455327, 0.1565496774929549, 0.46560459017499817, -0.7899421830022046, 0.04337821203731712, 0.021537905844272582, -0.5875529775753209, 0.44203921175634825, -0.46783358175337086, -0.7298655582697565, -1.1507755515329057, -0.12407787986653508, -0.5992361230779911, 0.19245042652166, 0.633820673951712, 1.0482872937260448, 1.070147889828022, 0.08207867218007171, 0.8396607614731028, 0.9047940932577917, -0.795887354661464, -0.18301220487715442, -0.1327810046505839, -0.58696750529236, 0.5023086232887891, 0.6262397773893401, -0.10035460753949615},
    {0.529213891279325, 0.20425025645322298, 1.5124060872229588, -0.15736652680279753, 1.067282362783162, -2.300507372287241, -1.7274803769018439, 0.5298097943833269, -3.175119474760266, -0.6399883132887386, 1.2100739408387777, -2.6345746963220535, -3.6208860279704327, -0.416509419680065, -2.171999804894179, -2.131510589874135, -2.511518821558118, -2.9020008870146357, 1.4412199210486023, 0.9342737335297749, 1.8621686844451775, -1.472986898200912, -1.4664299184897147, 1.0042394464008566, 0.24585639121008082, 0.4995028636002678, 1.299883982204602, 1.0955894378400997, 1.249970061248701, 1.4127440382314684, 0.5650144306514396, -2.347648366330755},
    {2.1666434771755037, 1.1611900769501862, 0.8299451019604371, 0.9141153200917392, 0.07303667791192482, -0.9493200144010359, -1.6851373571108201, -0.04035165800657676, -0.9601817254216143, 1.8001246354576592, 1.1960717494426258, -1.7724090090050186, -2.811984248431911, -0.6066535252511941, -0.935617221603143, -0.8150726972498427, -1.9746399088112807, 0.07374273614267869, -1.6840586951209857, 1.0825230318097008, 1.5162814376301852, 0.2946956547470295, -1.123276837226514, 1.7683642377820676, 1.3067379019686278, 0.45054121120247503, 1.177679782379813, 0.6512570454198136, 2.4482121380026935, -0.5668762759165209, 1.1898092921610124, 0.20855199337687708},
    {-0.5333233571351603, -1.300945973406343, -0.09742467911474387, -1.0228706571350974, -0.5189938030565322, -0.3681323354587786, -1.6086855582610415, -1.4793728796784282, 0.13635445907066623, 0.776356564700975, 1.1171098013558332, -0.7473258743271872, -1.5789264619778627, -0.8153775045644216, -1.287529255952402, -0.8589201320233688, -0.9650075074856079, -0.019245679256563786, -1.11379829243327, 1.797729087536401, 0.8980520088937137, 3.08995946607116, 0.11142808927151118, 0.22064941496915552, 0.5690369042859417, -0.2009709422859656, 2.137713100144946, -0.0689333201670281, -0.41489958380588116, -0.35149466491193504, 1.2356886943448473, -0.0982428936303532},
    {-0.6485624307849358, -0.9891204576240078, -0.7365410922196876, -1.566800066660215, -1.3643300983453215, -1.0110700242660449, -1.5695691705276291, -1.2071816677385896, -1.646759552631355, -0.9731376984038186, 0.2961912990914093, -0.9655652476504961, -0.37047561003194607, -2.002666992108187, -1.5394606977936898, -0.14720408056520087, -0.23036538835879392, -1.8340734336421785, -1.6063629703456042, 1.0873350797762809, 1.672445692621494, 1.6484832357584356, -1.2721292102409398, 0.38821561411270444, -1.6917665126838122, -1.6379202829539896, 0.6035963688955379, -2.27362428955535, -0.26295701014277734, 0.9396701420351082, -0.2766122452169367, 0.7681657858378653},
    {1.093552542701619, -1.3272842322104073, -1.9318783008799925, -0.5082680481668918, -1.0407255595518272, -0.33307171615549, -1.4371526169329256, -1.2814697154586847, -0.4099012301706914, 0.22575382174182754, 1.9425861685772385, -2.003291550036878, 0.29975246388047644, -0.7934739484258599, -1.2562580530201168, -1.3145492330905684, -1.5052121020856504, 1.548573560670694, 0.046083852742011315, 1.9911410335582995, 0.731722935106937, 2.2031614921398552, -1.190651162639802, 0.31798790327706294, 0.4388617744964519, -1.660836780682749, -0.17403639338365787, 1.0996269413550668, 1.1875442175916733, 0.494075540641909, 0.8453813122881937, 1.2672621764578522},
    {-0.6552834936015638, -1.41722471476793, -1.2844246457857869, -0.8645457304327051, 0.5416003791233719, -1.701540167305649, -1.676411903765842, 0.06634124585709944, -1.68889351779854, 0.5114529886791768, -0.01705152227515662, -1.6469443553949177, -0.79904356432255, -0.7171215306978718, -1.8553651053447937, -0.09979678272367053, 0.01005605437367223, 0.27015339804438854, 1.29930548208835, 1.2654441938676004, 1.0610705948340584, 1.5197770412612455, -1.7162910722009452, 1.7912708481956319, 0.32115741062885045, -1.2598521164829768, -0.286220432697515, -0.1315105320621568, -1.0332012705468594, 0.8643972608759918, 0.382719259358862, -0.12496183770417763},
    {0.512519286703007, 0.604512893237242, -1.7313413741788013, 0.7816300000097589, 1.7892588014161837, 0.3383561943886689, -1.039160455040591, 1.0604425674508988, -1.0267068793353626, 0.20000808613392257, 1.5612991341299276, -0.37384608315422274, 1.9879932995781904, 2.0829103169078595, 0.02617073294988362, 0.33389679193117766, 0.6185250229702516, 1.1556167725607267, -0.18882317884762995, 2.042595741753241, 1.9930451894205883, 0.43476004303032456, -0.8739863711166265, 1.0959568854706565, -0.8031188306564077, 0.5284269217832323, 1.512333918250825, 0.8649087106396659, 0.9627999972866359, 1.519713132356286, -0.8108829620994056, 2.122911740625865},
    {1.483478843211296, 0.8078123034448086, -0.14580911536303118, -0.4061110116591504, 0.06092512561632067, 0.0008758429501312031, -1.1590816940332398, -0.6994705250073765, -0.5623847389051906, -0.646632394685243, 1.2016519851844747, -0.9038768715256998, 0.10462551555682649, -0.48511563442740285, -1.0707644398150822, -1.6732114010308703, -0.27800059773546, -0.561130974901549, 0.5280940138801187, 1.8559964668389837, 0.7602806358061728, 1.5526165747176326, -0.3917710706468858, 0.6875209801654143, 1.123006574988415, -0.06621085539700508, 2.1009233974506873, -0.28400517176577034, 1.1678156382240956, 2.036967498689879, 0.4755055472718185, 1.4067999141676168},
    {-1.157389210070257, -0.6417415745209334, 0.9084952567757446, 0.05196497112282629, -0.10507818595502176, -1.0755204040802147, -0.2969930975171863, 0.6213902621527373, -0.7252643655384575, -0.5676436518825843, 1.4721397797465339, -1.0028918698767924, -0.23985519179388853, -0.6838994433804532, -0.16357256207887094, -0.8334500848095877, 1.0416729515366348, 0.5445154206611377, 0.8887149944260149, 1.7854678481113455, 0.4385213911738435, -0.35623313517512534, -1.1059619613697838, 0.5546239059731646, -0.8897848434222116, -0.1548422180022681, 0.24371457211475253, 0.11730555661202863, -1.3674077324192042, 1.0569263253117498, 0.785266610338685, 0.7159853383467446},
    {-1.9447173966024227, 1.8915095741799062, 0.892561570400422, 1.0697771735413548, 1.094235543309712, -2.368729405198491, -0.473061229974514, -1.341167995869804, -2.772423892427802, 0.6063699568366097, 0.3161888841081505, -0.9260751130374231, -1.9210799627154678, -0.5789421863975585, -1.2406265257070108, -1.7630569221435046, -0.6089844268700824, -0.9826472636522176, -0.6414517550666287, 1.1593417791687228, 0.8755246996058188, 0.43746188174970685, -0.8171638551346883, 1.638044059151823, 0.8567232547388484, -0.5519949751129338, -0.6100020900881757, 0.2752638989933264, -2.074836205676419, 1.1589965616039157, 0.948893539534031, -1.743863680538657},
    {0.8142912715213724, 0.5614501525823249, -1.4237824495919327, 0.9906654610693222, 0.779888530776164, -0.012669575588378867, -1.4768386800379785, 0.2048797948639434, -1.7148382127500914, 1.4066283016183154, 1.800582900035324, -2.236219717114999, -2.3823075756902212, -0.21352499364423774, -0.5038591187036591, -1.3467300491013698, -0.8406825806346231, 0.6497805759252866, -0.9748458914323195, 0.37792698816779574, 2.6931769558258347, 0.1278092063908291, -0.5034344944904328, 1.8890894272875802, 1.118497088331735, -0.8103799743737776, 1.0083243092078271, 0.08969832930112455, 0.855205127793099, -0.36336029136188647, 1.5587723358782861, 1.7658222163756534},
    {1.3641419536099317, 1.749241927972324, 0.35715346460368125, 1.2261656602989637, 0.694612595346124, -1.2449080420744818, -2.003890010820283, -1.057277605152745, -2.8817651094080965, 1.4312145986540994, 2.146941634544883, -1.3393370493513532, -1.460244203155648, 0.09418681358335934, -1.773801096210056, -0.18768292885997634, -1.5879353399587195, -0.16871347395386702, -1.1161197742967337, 1.0761077321852464, 2.3153270921121334, 1.3062607948268492, -1.80556490747698, 1.7470862382071246, 1.1988125376077314, -0.007085142865655461, 0.760901891207382, 0.4674267512165731, -0.6856937904069976, 1.4409491055233912, 1.6162121085065027, -2.906478145566488},
    {1.0709753354661746, -0.5874527469151686, 0.2571208976593631, 0.3118512682538437, 1.2585987196201975, -1.1027468181907598, -1.0585769932090618, -0.3966956555542212, -1.0412501014844597, 0.23087956532573953, 1.369551864891619, -1.6548391353982195, -0.5979880258310819, -0.7184258722953731, -1.1652310770585756, -1.709411060659805, -1.1603721414268473, -0.42118675699037317, 0.6899392143518135, 1.4471575463823774, 2.099452348908516, 1.4733922549932421, -2.127305366551286, 0.12194986492079028, 0.5481275675804516, -0.2769071313962234, 0.772101356076576, 1.0648769715728477, 0.7342191457897871, 0.6946629349988277, 1.506232957966971, -0.24509444236614045},
    {1.8401610654743867, 1.6637482503929428, 0.8349046837045444, 0.05330840852683534, 1.180809405593729, -0.7292944273821413, 0.4007615361522486, 1.014747205288622, -1.637051055431897, 1.1420884417514354, 1.9021710260023719, 0.02359016581737497, -1.306657048988327, 1.1885678985165105, -1.5930338634248715, 0.4708979395775066, -0.9437166716473658, -0.21906416098854523, -0.6897848831706088, 1.52032743908997, 2.051584905181904, 2.1956598216414758, 0.3239812426010253, 2.6997589803925806, 0.5462525504619544, 1.6556255617804212, 2.694164345598049, 0.6267385835333573, 0.6665130813985033, 1.4009847344553534, 0.3905139491538356, -1.2016635589060225},
    {-0.47912128481471083, 1.4018927898457887, 0.08716380168592444, 0.6674440996596893, 0.15085184113286237, -0.9571751368807977, -0.9945166315217822, 0.761926402658791, -2.314224009245254, -0.5454219894843256, 0.26473267956494323, -0.8051185646732838, -1.5307899022827867, 0.7936564064552523, -1.0511288732038082, -0.6335313784211092, -0.7089198038451019, 0.8230752088876969, -1.319661011217214, 1.4025002239169795, 0.14861731647560691, 1.1354087092852938, -0.01788591640616977, 0.9915955519808077, -0.19234887027222944, 0.3416442121542482, 1.5106340865195131, 1.7394506124908282, 1.8902134563857913, 1.8200081671626216, 1.372132799050634, -0.45901584119886474}
};

static const float b1[32] = {6.90637357990416, 6.830470229469609, 6.824372839508434, 6.931071274090252, 6.679788327438755, 7.2627368550253255, 7.238124650695174, 7.104580260934349, 7.301086776813642, 6.7091469587242045, 6.765462573858869, 7.0763845765303515, 7.188138467743476, 7.0782433850815085, 7.249170691399359, 7.3260195705421784, 7.103036753289362, 7.106574038357553, 6.944444404738208, 6.72228788158009, 6.849826460901169, 6.851745947278552, 7.192760068693557, 6.5456294514681135, 6.63149758090601, 6.936583490914146, 6.714753670938177, 6.908225707977699, 7.008938467589931, 6.89418609637976, 6.651896343870816, 7.256275804013094};

static const float w2[32][16] = {
    {6.250673494974584, 6.176929396808727, 6.332041582942302, 6.219880818561399, -0.08498230283131704, 6.6290717695156856, 6.027894333430291, 6.179398068435181, 5.67540918491353, 6.101880079642949, 5.439915929787631, 6.288856754651701, 5.909476273530597, 5.567071476582435, 6.331269559143066, 5.842981546226402},
    {5.7604504785308075, 5.9810513971316706, 6.005533882795146, 5.567532649351699, -0.5396635995940752, 6.035812074867559, 5.969871523106514, 5.748314917484276, 5.903878314971732, 5.97270872972427, 6.106963050960644, 5.859671621232919, 5.858292797632033, 5.204048296201357, 5.598335168817904, 6.139488468280252},
    {5.955665327994494, 6.140953974023675, 5.852750785515719, 5.5559021681475285, -0.22520442716293992, 6.00650301033721, 5.793626850217742, 5.636750610061991, 5.837901681621068, 5.764254708639449, 5.8356676705190695, 5.8764794475213575, 5.770215937953399, 5.351801421752007, 5.9399425816313585, 5.488149328258035},
    {6.199076657342976, 5.79521989375681, 6.148707357255021, 6.279827388648122, -0.053301172914969094, 5.460063740926633, 6.286983168273324, 6.60421148744672, 6.637603385418385, 6.119200164731002, 6.1185164130468435, 5.964105743043417, 6.184050160407456, 5.645898522357645, 6.0548551517154525, 6.157751892249666},
    {6.077685488613199, 6.022985160961217, 5.892259245550139, 6.417179926473909, -0.30893400391586157, 6.0160032203073355, 6.119330236368246, 5.907942807011166, 6.3397618830031, 6.047028960128683, 5.94721181705361, 5.900069467754531, 5.704813206517259, 5.507196559441279, 6.011399853167435, 6.150062753135704},
    {6.297443076542039, 6.4448034831153995, 6.894509390944856, 6.314770827559214, 0.10422128938898535, 6.059677014836905, 6.313890064654728, 6.678390515473111, 7.242716310452379, 7.100471040657321, 6.501399601736749, 6.311088381343137, 6.550425848364373, 6.340611213600785, 6.50216825335332, 6.756468539227366},
    {6.621402060064921, 6.655853602376543, 7.000546500910946, 6.506363357124637, 0.42637986192095245, 6.839819220647099, 6.5487040896511095, 6.91905627734835, 6.823403453907754, 6.73554151956457, 6.553423797110737, 7.004368510536259, 6.776450600498063, 6.343704965026547, 6.870280910980633, 6.667691008503033},
    {6.5524393274965105, 6.492368527704559, 6.2355130615684775, 6.261467229765269, -0.020486913320489845, 6.606614164293003, 6.437483742610327, 6.611254680549221, 6.324752460672323, 6.487204456559227, 6.357950792040551, 6.506329392043883, 6.404481166799493, 5.855710247719065, 6.450642415517614, 5.7661292843804715},
    {6.811368846207427, 6.55227059744001, 6.353931000633414, 6.470612208340295, -0.5639213259911832, 6.337846273630722, 6.492945719822058, 6.94344918817337, 6.723862811931055, 6.668155803418045, 6.246946706968507, 6.5393525250467, 6.588379514621235, 6.001563810973119, 6.568947991000092, 6.289256887447289},
    {6.276479644780221, 5.938871320462009, 6.363821035910093, 6.094534795717874, 0.07434958682081166, 6.124019431980755, 5.978055138071267, 5.697272301647933, 5.892482917062387, 6.051214540467847, 5.972156161816847, 5.632599698504198, 5.90871237528488, 5.554605677430384, 6.281162294144421, 6.143618487398869},
    {5.477827238612798, 5.887192282927988, 5.896881184187225, 5.648250884884335, 0.1384170850149098, 5.709181250721655, 5.647408627734201, 5.621484512195327, 6.360464713844161, 6.0243177950272155, 5.920437032079274, 5.742153742849265, 5.780254879983941, 5.5056170862825695, 5.5159550028583375, 5.225284871982333},
    {6.7456733904728035, 6.312730621159774, 6.333087203098735, 6.187512644748454, 0.10920839699347112, 6.793380525667846, 6.9198212397836825, 6.84660378520421, 6.1653085138320165, 6.791421096837269, 6.421016687403853, 6.928704038961229, 6.288129259420003, 5.740760273618828, 6.704744495225145, 6.486281960262661},
    {6.750072712628778, 6.292288647229491, 6.778608436254504, 6.346564170945175, -0.1364987512008955, 6.5958286486691176, 6.3442777676245585, 6.422953893050129, 6.750733554039986, 6.664444390521912, 6.032886332005532, 6.169238015013428, 6.474913286119864, 6.196092784818878, 6.174582523788212, 5.655602831789775},
    {6.055542741252551, 6.681591407269881, 6.648702617309795, 6.121116469853908, -0.6209090208957063, 6.324845951147459, 6.0134011199607365, 6.535699267738601, 6.286967289124844, 6.436305207148383, 5.922464349001366, 6.249299512996815, 6.286782322176013, 6.059345554690547, 6.508295553387789, 5.984461571355082},
    {6.738303089569041, 6.796523778727457, 6.709246069651469, 6.093254619821403, -0.122355250789815, 6.579576507152789, 6.734303255695996, 6.658543385524317, 6.292297013186994, 6.18447419567729, 6.471728212067204, 6.453563582268281, 6.472827971131321, 5.827130001966475, 6.869771125469497, 6.500479382161694},
    {6.395186237339452, 6.602628085775458, 6.873598187047896, 6.358268985169379, -0.05985137878181983, 6.323366055663669, 6.472406786756703, 6.787735550405395, 6.805177626598433, 6.935669330130269, 6.0921614409721885, 6.649095553606481, 6.078016648386323, 6.043634565769802, 6.724010965981009, 6.757987503835627},
    {6.56136582098739, 6.478658991798673, 6.708328385308218, 6.906619874121951, -0.09905264063157053, 6.35485692001236, 6.233997254853127, 6.923163210718375, 6.226424503442606, 6.7793847765536235, 6.5026118157160715, 7.083770566441231, 6.69189555501595, 6.526035087219723, 7.152555822510508, 6.72633829832614},
    {6.5490726100805965, 6.599074498838377, 6.199311418892938, 6.060600116008924, 0.15718461458610652, 6.321530250016526, 6.467080812861467, 6.4966711920379465, 5.798530655692306, 6.303087504287366, 6.348009990604599, 6.651327327350073, 6.620288161399012, 5.745660822119034, 5.822586623881286, 6.184594732573575},
    {5.7367004273140925, 5.9699373689921, 6.678394651690765, 5.908602248794385, 0.014714712799490747, 6.03137320732608, 5.642599399765524, 5.92011185040473, 6.082152471330883, 5.617117325346399, 5.739871647510078, 5.9719845931302995, 5.935352607879847, 5.132617550864791, 6.161333424162862, 6.4794972640701225},
    {6.312860731709809, 5.817936424449209, 5.758418228362783, 5.929512350482944, -0.26663800090032574, 5.871628797166776, 5.641051113096992, 6.022645165027025, 6.213868365278223, 5.581145940175071, 6.041864620024681, 5.473664542369184, 5.256210386399412, 5.708268714454927, 6.052774521300995, 5.623102479996868},
    {6.124214195092256, 5.878596115339203, 6.28060884948325, 6.246548368310065, 0.03165481178824248, 6.4127270087179316, 6.460032732509854, 6.303776456773227, 6.103691550205747, 5.872941825322136, 6.121667441693691, 5.805968559406147, 5.773621823818835, 5.482981659160401, 6.3083686185847405, 5.976001887394533},
    {6.077487892853063, 5.886734919072339, 6.210649040434948, 6.309313561093738, -0.12304126751148901, 5.9346549633915515, 5.913290316170327, 6.208564030018399, 6.267803672914854, 6.932086983102798, 5.709834065203514, 6.121114491490005, 6.224805588274253, 5.44636373207197, 6.333452307569672, 5.80391913481257},
    {6.778359568716683, 6.993408947861898, 6.8053624852376196, 6.7202369400376485, -0.18758596218569398, 7.072383370179001, 6.8236763853704945, 6.813880794397403, 6.520604548747925, 6.539469428565081, 6.725481871917194, 6.652646179791187, 6.885838539619671, 6.83275076290999, 6.6025166013369, 6.33937017435},
    {6.200138955079983, 6.089616037660071, 6.179162746689574, 5.701511463644056, -0.19844235739245725, 5.8592206842121906, 5.94285170759737, 5.725510843362985, 5.960841467714778, 6.012648485137195, 5.757556064931396, 6.018605693163969, 5.793646355024313, 5.335561453559598, 6.095903480912084, 6.221526967878233},
    {5.678361911727554, 5.930962394695894, 5.3514023029616, 5.993194430284075, 0.13409164907271126, 5.928337476893838, 5.766644758464032, 6.316766657122998, 5.930886901564956, 6.00645544891476, 5.833833051964153, 5.7456180537359565, 5.700081440760899, 5.5563227240063515, 5.9900475170657925, 5.887103885995339},
    {6.424426295594749, 6.105467253261149, 5.932210091830513, 6.112981290563522, -0.39904017676444925, 6.222618496855668, 6.436857837521773, 6.163412938771527, 6.210626947236753, 6.023375583349913, 6.374020370133261, 5.950987625311015, 5.806893688744722, 5.310053336963827, 6.281975977349633, 5.748942557763986},
    {5.9077923051704495, 6.048547657322969, 6.09882289981129, 5.808439428604394, 0.10867485599768428, 5.863607707305773, 6.095109501736696, 5.871459480383216, 5.748748463155474, 5.692852262470917, 5.798096740803334, 5.916944635022929, 5.804875882596183, 5.2481012247368755, 5.813369898115192, 6.572551515154523},
    {6.582018960872092, 6.185608922106686, 6.692421367378656, 6.29087700290443, -0.5214966924968859, 6.552057274048985, 6.162901914057401, 6.067869817460438, 6.128889649908605, 5.951849456912022, 6.067748781865958, 6.40762514930766, 6.0222905625908725, 5.618376643478336, 6.028726509899664, 6.269322204622422},
    {6.143770946296888, 5.926915795924767, 6.228961026775892, 6.0463085493616875, -0.02900692301165229, 5.861139375229544, 6.1800257241331895, 6.267135853992721, 6.19596710207716, 6.161011912381879, 5.9411065770476, 5.958079615746151, 6.018504286829332, 5.569148386556404, 6.4158939776188015, 6.152015452453513},
    {6.16122590448338, 6.247831564679896, 6.061966623835688, 6.446109154168271, -0.35298022013449804, 6.17836970843641, 6.696957222301421, 6.005095060772891, 6.621090335437026, 6.497126555330028, 6.206950519873053, 5.588126317405995, 6.038808563251544, 5.472346636880548, 6.0336982607635035, 5.967573073692427},
    {5.979227138751101, 6.111439225779014, 6.0742806772621165, 5.586924023286717, -0.16503779376546288, 5.843584530151441, 5.933059103866269, 5.764014728977033, 5.700915379622526, 5.592276338193651, 5.798013651449202, 5.5757393843612455, 5.7261875342655735, 5.332293877369861, 6.13906205560655, 5.955417370278386},
    {6.413933934844833, 6.288749615920121, 6.518176521389052, 6.519763722967735, -0.21743045928110719, 6.54036383836139, 6.009304974237943, 6.25384896175827, 6.307035467544761, 7.078528083744344, 6.159286119880221, 6.925866026056914, 6.215363684645966, 6.369304670066972, 6.2963383672091435, 6.531214996890433}
};

static const float b2[16] = {5.794872968030656, 5.793789926716695, 5.700394316977182, 5.7871665628304845, -0.10012598509811636, 5.791690887891723, 5.806218271250666, 5.826258262650354, 5.695040138049432, 5.892244606259743, 5.607487490522116, 5.563401031224524, 5.918938369584081, 5.86809213910519, 5.932713578220819, 5.854408957744431};

static const float w3[16][12] = {
    {-5.882764709154768, -4.676901260759777, -5.024826473180978, -4.99966616579247, -4.513890314137634, -4.899672521035892, -4.373566976746196, -5.074246680444247, -4.808263101257722, -5.00368900614771, -5.010865422702923, -4.3492760361200835},
    {-5.277020673445135, -4.743374428141161, -4.493291851946381, -5.018116004078556, -4.824497559824192, -4.643509707700426, -5.252892823786612, -4.436729847218816, -4.885427206375956, -5.24705525975538, -4.132092751733478, -5.099375832987354},
    {-4.918830681267398, -4.929919638255064, -4.918103641392323, -4.69601984439905, -5.072688383234723, -4.282260467355927, -4.444364326120747, -5.391499508250739, -5.252780501125829, -5.581127153812138, -4.816568574238584, -4.604039110306552},
    {-4.508268646545643, -5.3058465520896405, -4.478996137047434, -5.067211411686656, -4.832050770284102, -5.346596076168205, -5.212890429068322, -4.5996993688301275, -5.434401433780356, -4.993094327084995, -5.114366898742968, -4.867702136895004},
    {-0.257312579164464, 0.5428882875851707, -0.5373275914323741, 0.6288406691096543, 0.006560542666660361, -0.4362137926042029, -0.9448201840963635, 0.2832826363837567, 0.2251547563982545, 0.5900877238984521, -0.4716977737966753, 0.1647722771028881},
    {-4.955483624988433, -5.158811066258517, -4.8675167214707145, -4.896452035708152, -5.168884501902995, -4.413325508002024, -4.217417336319029, -5.127060653845456, -5.600766056345619, -5.093249854130086, -5.22263958880751, -4.912887657211679},
    {-4.313657561445559, -4.4964854888498, -5.589716533670938, -5.048825736943535, -5.064670073446189, -4.1531899476722085, -5.121714383363675, -4.744544710094491, -4.181233036414425, -4.693798432833934, -4.703705683256947, -4.985195010372494},
    {-4.540073348347524, -5.967594608262729, -4.464840570229253, -5.074027421657759, -4.653797208421422, -4.999440125862773, -5.205298812763633, -4.470955270779379, -3.792590693434786, -4.480333608868015, -4.428520800338845, -4.794933314457163},
    {-5.013386476349611, -4.74412605511432, -4.685999014809481, -5.083656308618634, -5.445181992648654, -5.164973598155689, -5.262531579308632, -5.140025059575711, -4.869490624187344, -4.288011856803468, -4.852774617224326, -4.484506115010829},
    {-4.344357170898872, -5.0783625576419125, -5.035768184568339, -4.919094789701568, -4.629537794835862, -5.261640453249216, -4.995590115155158, -5.167121615092714, -4.686209418059557, -4.611263057168332, -4.576397919360662, -4.642550288522279},
    {-5.245137032656482, -5.427962941268792, -5.055756131260636, -5.252274631064612, -5.082185945966077, -5.052885110667975, -5.239170373276801, -4.284268596110881, -5.712028929137539, -4.859816189451633, -5.246428045402548, -5.369228423818859},
    {-5.347645773832021, -4.843508002300135, -4.696574462692725, -5.198726950086017, -4.649959259986181, -5.367373085536147, -4.549393687601386, -5.133189725817029, -4.787593112894231, -4.629328891953126, -5.025770614636154, -5.274626661613021},
    {-4.340240213066405, -3.7531791336918916, -4.704756335291694, -4.4617879852533235, -5.280483788699359, -5.146730029579717, -5.626107885478172, -5.378314540344906, -4.935872654507456, -4.571932722175771, -5.489635447339364, -5.757397859961433},
    {-4.722680528840719, -4.410718988345662, -5.38151157269133, -4.431653600304297, -4.606042514295885, -4.397940853906653, -4.23621295599521, -4.04067808493522, -4.53440383094903, -4.755434494326621, -4.388322068918919, -3.933744298636858},
    {-4.402491596517768, -4.761110388716567, -5.02654249325887, -4.349881933147411, -4.434772753211352, -5.041236984157025, -5.028448750819916, -5.18343968018825, -5.01681500678714, -5.117584005086592, -4.924909090228053, -5.358040727677323},
    {-5.189243567314969, -4.7164939997089155, -4.6876794096961865, -4.563777825900348, -4.816488301439869, -4.800009950741749, -4.29599940734796, -4.666678986981974, -4.516456120531645, -5.090879804410167, -5.145117956761771, -4.533326832407782}
};

static const float b3[12] = {-3.3071155983293212, -3.185413518205219, -2.8064524472582466, -1.951865900023455, -2.658605435180092, -2.3058951852512157, -2.4379053626879865, -2.98870772387468, -2.813508135572619, -2.2318319528910933, -2.476053140115964, -2.044578211579616};

    // Input Layer 
    float z1[32];
    for (int i = 0; i < 32; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[16];
    for (int i = 0; i < 16; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 32; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Output Layer
    float z3[12];
    for (int k = 0; k < 12; k++)
    {
        z3[k] = b3[k];
        for (int j = 0; j < 16; j++)
        {
            z3[k] += z2[j] * w3[j][k];
        }
    }
    softmax(z3, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
