#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][16] = {
    {3.698139105821579, -0.1888373975296405, 1.627575066396052, -2.6529463575049896, -0.3248025919428945, 4.3924942009934576, 2.367511188324341, 2.7785074912884475, 4.963913186755483, 0.8568722996032747, 1.2086029125203321, -0.21259854382913954, 4.83765754149372, 0.5144788159420847, 0.8511225893354933, 5.052662374279677},
    {-0.4288402387252323, -1.9772332837589779, 1.046280868344346, 0.917379287206772, -2.1224807745569265, 2.378568384400281, -0.5776536038561201, 0.6059199696503478, 2.586205228009725, -1.9339381593672111, -0.9046451329337712, -1.0995765893566605, 3.2304839163633003, -2.0602960410650244, -0.05290276257684231, 2.0694600396477862},
    {0.03272639226659043, -0.6123727595363717, -0.6414532714904311, 0.5506988763501924, -2.4351000535713174, 3.380623702017058, 0.21129803770821587, -0.1957829378743256, 3.3041061794870528, -1.7545841605750656, -2.0218846792955567, -1.6583703533415195, 2.757663133841928, -2.6964182711028695, -2.2783016108024654, 3.4709241645795315},
    {1.6967787354880097, -2.073711010200203, -0.643646505912732, -1.8883716066998895, -2.3206289069326163, 4.486239643998224, 1.3207372585948314, 1.299200782562573, 3.4590379086613106, -1.7003127754824439, -0.72425077204014, -1.5409319514465138, 4.189280177098733, -2.6277971558416087, -0.2350372177973853, 4.368913792103031},
    {0.556141880537397, -2.0586067438183133, -0.593948938467206, -0.6463455189044744, -2.4679331381674166, 4.310039963562303, 0.9747393082245966, 1.37019983911724, 2.838505754412442, -2.621911062839555, -0.6280278996993992, -1.542255361240611, 3.7563048310609526, -2.809391808317239, -1.412482325813718, 4.334527798820136},
    {0.4072560437156074, -0.6922861945624373, 0.08600250921297958, 0.22091136631260916, -1.9790983192134675, 3.9198470961476057, 1.3118296018395987, 1.63479156075206, 2.92477255124612, -2.599581910437435, -0.3223674946932975, -1.5179624518666464, 3.5225119503263276, -2.3822194712298876, -2.2903813090386445, 4.429300305765777},
    {0.05288983721187089, -1.3793112339013456, 0.37554968986755105, 1.1999551960165868, -2.4439863424076465, 3.4132645434140554, 0.8374584388417085, 1.7834503295953512, 3.025527828913229, -3.043714614034698, -0.025735275035622292, -1.6764434820144472, 3.5484578700548655, -1.6316444813161706, -2.0519885110987786, 3.9169158460051423},
    {0.8428393962433504, -1.0484527503481444, 0.7408673956437675, -0.41332722724838244, -1.6860610541317385, 4.111959519050634, 1.495500262934815, 2.3271174174325013, 3.682612278408889, -2.3111581308418825, 0.25731005744423785, -1.6341780153879653, 3.888184519872288, -1.3748627214616205, -1.4740755787978974, 3.9215457896022756},
    {1.3963457739291942, -1.3796734094188277, 0.1898893749485414, -1.7136036844858773, -0.9113384847891726, 4.349846671908903, 1.8663987825336876, 1.4697839184806616, 3.4954272517565577, -2.157232125734174, -0.03586399426251228, -1.889226889183059, 3.663731036732031, -2.249942523824051, -0.41548038056586384, 3.862337859739258},
    {1.406851547096517, -1.4652122893387478, 0.6925929111605161, 0.011917710837877203, -1.9884742963772497, 4.438186954713812, 1.6621483806101318, 1.3758744359904498, 3.3935173969364505, -2.3899536536586687, -0.05110587917169195, -1.2483191442082513, 3.873248442102317, -2.3604431096262704, -0.1800843060735128, 4.139140039191926},
    {1.882390238229879, -0.9611519344433523, 0.8585774211978228, 0.3655160453109229, -1.4216795328506822, 4.406603125540181, 1.5930995811075845, 1.702799166555753, 3.4708267774057537, -1.9998809301545923, -0.18337566466318747, -1.0097198720572094, 4.53559796924807, -2.2957885628698924, -0.6126021017319117, 3.9012814780206715},
    {1.7577147240431499, -0.5905518776933353, 0.033238695741281604, -0.7490412314374013, -0.7278856488819211, 4.442597260419907, 1.8155335409713118, 1.5923792711334017, 3.2459817001771056, -1.6192266987901545, 0.26857463788199565, -1.3742937758663716, 3.946416182944193, -1.5230139505167495, -0.575102947234446, 3.454430773191767},
    {1.6194029230291755, -0.9529551574062601, 0.5534188484797381, -0.6212239886874116, -0.9972132653415428, 4.402240775151888, 1.622421024955336, 1.1113898649939558, 3.0783750127678227, -1.6240609882477057, -0.23876256720961905, -1.907093596412464, 3.9229419816843056, -2.151675239028638, -1.0629863547841925, 3.3368391568905826},
    {0.9766126476469424, -1.1066655548518045, -0.19499656999902132, -0.2982245587969567, -1.9820298450956468, 4.169957766011219, 1.1311620589026712, 1.2007719039421467, 3.2470509313971783, -1.889820717423455, 0.3383934581846034, -1.5846450327426929, 3.6478198689027677, -1.962326101002836, -1.462728141949261, 3.4290550883786164},
    {0.42755521286899895, -0.12501967449895385, 0.23719514652070825, -0.018563956627441126, -2.1014600634745175, 4.277540016782595, 1.1896369813687906, 1.4162144522184725, 3.536368512608458, -1.646289613343468, 0.2754012949983988, -2.1525115531889525, 3.554573321940514, -1.9470972454567812, -2.0530666972352285, 3.0710347601570955},
    {-0.1688658120461353, -1.5758586057186224, 0.2857487951936437, 0.33844525149758437, -2.396632112194045, 4.0343955674309075, 1.0969683708452498, 0.6475279234523657, 2.9138418190848547, -2.408372225599367, -0.44254571764021616, -1.9417818038085195, 3.090185975333175, -2.4666061516993074, -1.8531840381115186, 3.1648052487677694},
    {-0.37349233539921123, -1.0985913709112305, 0.05691391132159856, -0.8227012519293033, -2.568001002951195, 4.118460310866747, 1.0485230982983267, 0.13092797523257174, 2.940319716409981, -2.251064166782788, -0.6714867115454569, -2.178186332581922, 2.766029157731006, -2.6490058999546218, -1.9986431769022222, 3.29417148926615},
    {0.49058095718089434, -0.3147827347762805, -0.7225795814285685, -0.8888706875961967, -2.4536285628750503, 4.275148655174792, 1.0798673238028835, 0.5925756293507286, 3.5685531708510823, -1.319668585711062, -0.1124013279641101, -1.836548864238314, 3.1251375750777073, -2.420790648469345, -2.112596566064035, 3.5854223970252987},
    {0.9581546277031789, -0.3626943864131163, -1.0244036169656763, -1.052791345677546, -2.3836022816797064, 4.075605339518704, 1.0021734294816402, 1.2704315895934268, 3.8381641946771134, -1.5654142662652328, 0.10349203455393538, -1.5483695741602785, 2.862506245806123, -1.9617187679486163, -2.3462947908884004, 3.980200471488009},
    {0.874479977986993, -1.8481055425853594, -1.2123470347209986, -0.518470062107517, -2.088959460268973, 4.490654621499882, 1.165585838615672, 1.8786924191236936, 3.5423403854420914, -2.5016848277349237, 0.9896725277873646, -1.325135888042085, 3.328970181129225, -1.7091941322910162, -1.663638672421354, 4.29878963795295},
    {0.6810811020872581, -2.0531449983412062, -0.778826150044643, -0.33179345612288647, -2.145982347780599, 4.594193884567866, 1.2964100110744825, 1.4197776553270598, 2.946932879518615, -2.099475407333577, 0.5672992112178684, -1.4087468126971923, 3.5840919010023677, -2.1963426074596346, -0.8818533770308388, 3.4563935917355617},
    {1.1832680704733154, -1.7149191636889025, -0.8732279707039162, -0.934575090832466, -2.552385405400151, 4.539325093913678, 1.2826592038403515, 1.4937754542808646, 3.6981299759077944, -2.031504404996232, 0.04479005952398696, -1.6279230676681828, 3.773772721146382, -1.988786601331548, -0.8882153915113316, 3.855331529000641},
    {1.6295665159401358, -0.5780637940804202, -0.4230457578887895, -1.3984159347804352, -2.4878569578292318, 4.354202880193647, 1.4880254527302652, 1.4075008080221838, 4.501490915878527, -1.1254756496578209, 0.05484737360071263, -1.4667952712170564, 4.038187241590144, -2.15126726860311, -0.9034873060576457, 4.062825773306624},
    {0.8932176806661503, -1.394280353859861, -0.6944324994089176, -0.9723282132669182, -1.8759763412166368, 3.9810400404181463, 0.9481980061929834, 0.9327303774131853, 3.4577076342468174, -1.8317955510582757, -0.04001331690145218, -1.8751396773997295, 3.3278089711078094, -2.4020379118277546, -1.4834100293192944, 3.0840766642551958},
    {0.7229955500312085, -2.591620363822454, -0.5101777808941584, -0.31803811709233365, -0.8952796949181531, 4.123732434887293, 0.9629862101117164, 0.4668719836185853, 2.844411744723015, -2.239057753967321, -0.8013307703774512, -1.4232179081502738, 3.0851092463463368, -2.1742417760708856, -0.5463966484633147, 3.1309522113386525},
    {1.1647145799909266, -1.4566407769550243, -0.5881695176944911, -0.5124576883035827, -0.6894163219060001, 4.412228212816128, 1.4291443357687361, 0.7543099557710689, 3.0829288698840815, -2.002667312117312, -0.4485999109864967, -1.7445650264215968, 3.4299105996163557, -2.2090031422729943, -0.9400142060779902, 3.044977432712567},
    {0.49739248847378914, -1.749717617092909, -0.21592725588595282, -0.17551835954836928, -1.0443917713971362, 4.29085142266764, 1.153510169653933, 0.14885159895186664, 3.7394940490991773, -1.785173698191657, -1.2949943337751397, -1.7012296145940182, 3.5137098136780813, -2.36082868940749, -1.0952027423635, 3.290064315801164},
    {0.796903854369939, -1.8331827688132434, -0.838759374091259, -0.6883402918148407, -1.5451342783108084, 4.0051028082600455, 0.8507775638291917, 0.38024448681284073, 3.2150418184806675, -1.998585367189555, -0.9177891834815306, -1.695002339371395, 3.4153058158444636, -2.1966086211156113, -1.0998521658260882, 3.0825825801526596},
    {0.22736196735079336, -1.6387880268657764, -0.5636423271793166, 0.15792899764091786, -0.9581647460349263, 3.8610085375760157, 0.6129744918976585, 0.06261616752889278, 2.720568567022567, -2.2040239400286836, -0.23625416875594535, -1.3345299485939388, 3.054947224661476, -2.2520363088017588, -1.5825751032159416, 3.06211717367066},
    {0.4875760343188833, -2.513094613159706, -0.8466898527307629, -0.40169923138813224, -1.1537948514716434, 4.0136219749472115, 0.2859565584161808, -0.6687358408297065, 2.5905437554913875, -2.5158990106231904, -0.5292936237754045, -1.4602056362463314, 2.1102300629539776, -2.543895852832333, -0.6374513509886874, 2.1614476630047124},
    {1.6990472457658377, -0.47537901295264795, 0.2495129956912597, 1.452608040088852, -0.3246447891853532, 2.0147147873314606, 0.9777441078021839, -0.04400062401356586, 1.6591775513770775, -0.7028875883059434, -0.8454670381435833, 0.8022686909635689, 1.4736426232397086, -0.21414933910063064, -0.4921115034288527, 1.5961295477253672},
    {1.031054489792775, 0.12136261623840068, 0.7526333947162901, 0.4768212217638113, 0.3927688466541217, 2.244064398420572, -0.5448055109856452, 0.806004616655312, 3.14874462302423, 0.641222116965924, -0.5846309049464433, -0.16206628508658802, 3.2333773198057414, 0.15252629340594423, -0.5758528939991499, 2.4934591061719886},
    {-0.6891262792344073, -0.6148255778701639, -1.7577635142148573, 0.12654402719194902, -0.5057442627431081, 2.6284159693335476, -0.6081277228295016, -0.8188918262288732, 1.8253250092451794, -0.5212060969427698, -0.4147033179827721, -1.712789440118229, 2.04581932162819, -0.6323661627423954, -0.8707083344459978, 2.5568801466090556},
    {-0.624815051573072, -0.7475943006826968, -1.3280531882644409, -0.5092235754202858, 0.26615142558367094, 2.6928418228801214, -1.0800215449701769, -1.1137893309876519, 2.2728949690152342, -0.4720131972163152, -0.09688631783547481, -1.3302073805198857, 2.565922441011261, -0.3936138659634133, 0.209469837751896, 2.2524123611725027},
    {-1.018224408704688, -1.0272089651860181, -1.9154623417737882, 0.22933641539221866, -0.6575982316419099, 2.350616090608932, -1.6127579946718, -1.3837088765075238, 2.12559350201421, -0.6390899334996859, -1.4857392703188612, -1.0258692849829296, 2.574050202091982, -1.2544489204986582, -0.5966200982838578, 2.295871486551853},
    {-0.938711603395271, -0.2360008527590729, -0.710471817987895, 0.14452188962527698, 0.6809314416349066, 2.7457263748892413, -1.2534443671336986, -0.8169839090139407, 2.648326877337553, 0.4298552429789743, -0.43908308826750325, -0.7788685119747396, 2.4390753827520806, 0.283623441100345, 0.23644580377529179, 2.529186591216584},
    {-0.7465709391128408, -0.7577949214843492, -0.7266534425083986, 0.2594768769124739, 0.41066613568848254, 2.7844980265202413, -0.6053699127683304, -0.5760704599274861, 2.470511664797854, -0.006242832974680001, -0.5131969741022187, -0.5262602169574098, 2.59405127294347, -0.12610110137331187, 0.08216111473191579, 2.5375417884950893},
    {-1.5136993248290347, -0.9739728295033901, -1.8773929451812537, -0.24064218198285933, -0.10494843508111107, 1.933982291229526, -1.927907384247056, -1.6997526140132468, 1.9919383169410485, -0.9441287209074862, -1.1540305524628003, -2.2496859702109617, 1.755428330540583, -1.2976573542683358, -0.5387722103311293, 1.7483258456651896},
    {-0.8411747612207154, -0.17710071819290327, -0.9288455175249554, -0.32125592277050036, 0.19460118014612784, 2.537754787730822, -1.3634318831932488, -1.0574190624188107, 2.3309237276990777, -0.6406653375209932, -0.6352871505914977, -0.6844966279835323, 2.500236232037655, -0.43196589154747506, -0.1717550016031098, 2.4126156606062357},
    {-1.5731363250810289, -1.0706280858969877, -1.280954452457326, -0.24360575770371026, -0.8592811038638483, 2.8034516847053896, -1.6052610506298708, -1.6722269272134889, 2.500677060718215, -0.8752311595335103, -1.007177674905188, -1.4558266508775572, 2.3468008696489493, -1.136220903901941, -0.5641748423451288, 2.343819485759885},
    {-1.7651649043035191, -1.6138104699839555, -1.93360095280261, -0.46082258374999235, -0.41626537053471846, 2.302938144063317, -2.6084429410333803, -2.1039101561552154, 1.6298540633108463, -1.366832865555498, -1.8942975173032734, -1.87657568989585, 2.166364322067789, -1.540393634889428, -0.9586401935827258, 1.9615198037633073},
    {-1.6261289027267622, -0.6633653338722924, -1.300674717669288, 0.35033781393060837, 0.04172210406754623, 2.3507695459652522, -2.5790544787786884, -1.5492560969716807, 2.201297928038556, -0.11734448046089672, -0.6336156494268836, -0.9301668637537924, 2.376533894375822, -0.6378666292330201, -0.18084151211323943, 1.998308397413056},
    {-1.4104488643583375, -0.5682168214174715, -1.5188154709080126, 0.03250987541312129, -0.11280887562408277, 2.3711179415142873, -2.5338599339943255, -1.8510068113859963, 1.7181039530228206, 0.28271789226093597, -1.3663253642508073, -0.8073766460101642, 2.0857979228614134, -0.34131387946595, -0.02439885988173681, 1.7863181184844317},
    {-1.4097831176179025, -0.822835004304611, -1.4013020122421431, 0.39836044039695856, -0.04888566583318448, 2.590818404449788, -1.603298963360591, -1.2803829993123732, 2.0199141662929625, -0.24798168189425376, -0.7262488894792775, -1.322027640419991, 2.2573374792571124, -0.15958584978844653, -0.466465010061113, 2.3363800313581606},
    {-0.7595941788091427, -0.8360624984022155, -1.159548395040969, 0.10100133103224011, -0.15352544901933807, 2.363915443540483, -1.3841807331896525, -0.7211169133515556, 2.2732765644753976, -0.5186014366788012, -0.6581423134679799, -0.8858206303436884, 2.0229674109241884, -0.2802144849999916, -0.3290523930484263, 2.401016535614367},
    {-1.3686835203300884, -1.2159299585342294, -1.3989121443700834, 0.29933718223111827, -0.6216113935731399, 2.4210827977530998, -1.8671744995341222, -1.3722810971435924, 2.1047245428841297, -0.8671489592500083, -0.6671087012218303, -1.6895514353710142, 2.0469447222635586, -0.39846935598142796, -1.0186377648923817, 2.0949753758820937},
    {-2.1544685576767564, -1.148744385255532, -1.9424230842146983, 0.20789271859906214, -0.5131319652997494, 2.3427177471332348, -2.6354290253988495, -2.1571504001345354, 2.351834739273796, -0.13854849059085017, -1.211365101590974, -2.2365728691783238, 2.0611325044810243, -0.8398725573065683, -0.9043921833235448, 1.8254927754119141},
    {-2.0886355887475423, -0.45900017956548256, -1.308228085720007, 0.035040808404235145, -1.039397738534249, 1.9786585656807922, -2.735801150045258, -2.0355522909951387, 2.227104809501016, -0.26904304255325207, -1.2999295921862097, -2.0872490994994557, 1.7977663693007198, -0.68318566576571, -1.0617181723101672, 1.7693999980447523},
    {-1.8614899171844077, -0.4514324230457298, -1.4797154876815475, 0.1208129342669089, -0.5910768569850441, 2.494977239803967, -2.402095834708187, -2.1983207944379255, 2.183641130412789, -0.2770539105659747, -1.0402024174946936, -1.3946833102986287, 1.9160028165249965, -0.5902331666037388, -0.9107637900463434, 1.9571797984909096},
    {-1.5420267570283988, -0.787003020574191, -1.3873210777418756, 1.0105658871767729, 0.3024947239267872, 2.5416062259540664, -2.3596777492336134, -1.8884919131477853, 2.500406390492359, -0.2029295830944559, -0.7533020160062152, -1.0699865041604837, 2.4297954864195863, -0.14120787665952816, -0.8447052465232784, 2.290322594072064},
    {-2.6707956737061527, -1.8627480163061878, -2.3616021418656175, 0.4045591038301603, -1.0934558726120074, 2.3192721837594155, -3.0444618540269124, -2.8573056950177023, 1.3693940748716091, -1.184979228903574, -1.0328074433829653, -1.9420693437518568, 2.3465640763750306, -1.0720428349175655, -0.41475499586989734, 1.8505359625515538},
    {-1.9874571619982846, -1.1516030334014502, -2.1256016255762367, -0.14037786707378846, -0.9877780996651869, 2.805613989715919, -3.0341947893973034, -2.209917259412523, 2.0631209723489845, -1.5886184002861552, -1.6033240927001362, -1.5521603267926805, 2.2996790577945556, -0.7111913516371515, -1.5720806474769293, 2.2545790490172166},
    {-2.0085922284238387, -0.16427668121941114, -1.5535833178080865, 0.4404131740281903, -0.1924597468340839, 2.2289911493639134, -2.703583081437055, -2.595000326344665, 2.2974644023952497, 0.3564964237253941, -1.8393095446837806, -1.17465131327083, 2.330530384034703, 1.0770473231827529, -1.1630347353314736, 2.592105385268744},
    {-2.625930047747716, -0.2538808248568801, -1.5274475985585891, 0.5413117422390925, 0.1573510760578302, 2.3205226777034373, -2.9683188045028297, -2.5303996705149725, 1.9189608187013925, 0.1504493533553065, -1.4668170098202773, -1.2509248016931327, 1.740024990414696, 0.4856512156997392, -0.7163303333279953, 2.112954869456529},
    {-2.4564093482891427, -0.7658244848989518, -1.582913939836036, 0.6002092036284682, -0.034704450272404874, 2.418245560424558, -2.979750781442024, -2.4929670076954222, 2.2377660971554882, 0.08258849618777432, -1.3533290890320457, -1.2630872639606485, 2.0708636441245027, 0.18524885661656332, -1.7058437334902024, 2.084054736798446},
    {-1.966564608182967, 0.010536754152758211, -1.6464722915440382, -0.2844780229017926, 0.24996388989491075, 2.8691584543037623, -2.3566142276240902, -2.828424121863848, 2.085182379565093, 0.22748663416815174, -1.1214802544419546, -1.2618450834149335, 2.560551981074805, 0.510465114797716, -0.5396660747809207, 2.4871601534400303},
    {-2.6797140301696794, -1.4919264669687007, -1.8535891719008422, 0.8842473201956949, 0.027555169233071837, 2.315109707317826, -3.002136478011932, -2.666876470233136, 2.167829481861261, -1.4248019885067513, -1.9191896539844269, -1.993365540135476, 2.3381966596547588, -0.2447177220599711, -1.0635519297871143, 2.2359572286111526},
    {-2.621525079161263, -2.0631992422636958, -1.977262801964367, -0.06436781727297174, 0.24069644705703927, 2.3662566886669114, -3.261351152653924, -2.7164495092022527, 2.3384912181302773, -1.4886319335818599, -1.4188876980336314, -1.8264877721312753, 1.7678281766979964, -0.32612557545512555, -1.7181937692731881, 2.132910423610515},
    {-2.4469329573574274, -0.855786416278891, -1.5943028240636097, 0.23943117406373945, 0.2987608584690793, 2.7606541130288895, -3.2702090916986384, -2.5675897088941424, 2.6436361937414414, -1.442274319697162, -1.7014431919097863, -2.3684250181275392, 1.9917310838822302, -0.23052924529126045, -2.249741160378632, 2.3197654866256436},
    {-2.466225786657551, -2.7707217584042696, -1.4612433421002027, 0.03494890153225742, -0.4685413779180801, 2.3162903103796406, -3.039160413474187, -2.547303568315253, 2.536146884004473, -2.2274167476929567, -1.4941691779257913, -2.2755790248620302, 1.6754220967224547, -0.431503413731907, -0.5665905732157905, 1.7987826192922518},
    {0.22999043345948134, 0.43816931815017285, 0.010415092014620356, -0.10272680496490202, 0.22854256846241594, -1.11545522906791, 0.9525480220912828, -0.02499957611633719, -1.00538273672404, -0.8352836092819894, 0.5232204375199242, 0.8779294977252338, -1.131625610132724, 0.3991150624581785, 0.24139657696799613, -1.2075765874261593},
    {0.6766132855317967, 0.420606106468725, 0.2003572541505951, 0.1131467251864573, -0.055855855581458905, -1.0321109495276322, 0.7956426631633933, 0.36545784245479984, -0.7289787497438458, -0.19673837823542362, 0.26286330305299116, 0.4275265347005524, -0.8444607848484011, -0.07301723960086463, 0.3356139252657773, -0.7286136060883537},
    {0.9087709454019263, -0.015961352198865308, -0.024439389521302386, 0.15145584447795923, 0.17487847273900128, -1.1176651913672522, 1.1768534716990597, 0.7756308141844066, -0.9055302143188063, -0.09106917218541903, 0.2944404725155587, -0.013308673941843395, -1.0225216318008812, 0.10451162179903854, 0.026033251644839786, -0.8428411493677022},
    {0.9605112376134176, 0.028084274472021876, 0.4791921531664509, -0.02954923228376053, 0.19046576882350116, -1.1594005171015844, 1.1688557421469303, 1.1753087327426592, -0.7402992138868931, -0.07537927050358073, 0.45240548703683003, -0.23210831535400914, -0.7369937183469797, -0.2501845416823657, 0.1582457358689318, -0.7454899095730153},
    {1.104298490399207, 0.2331201636570294, 0.5270378940395096, -0.034734760700938026, 0.18877722557602233, -1.2183257556510798, 1.2179125975858525, 1.159409460751169, -1.1383064115252042, -0.28806811255178133, 0.49458476261808515, 0.7722627981695119, -1.195808248628991, 0.6227958356349963, 0.054025448542422326, -1.2463556252112051},
    {0.5564055169014319, 0.2224633461406483, 0.2918358062570167, -0.24983829562723053, 0.2449935121277823, -1.6473624699458722, 1.3942144542379098, 0.4713126823104709, -1.325643818940861, -0.7923993908305383, -0.036261753880102304, 0.22358864455418256, -1.4164059838555967, 0.2906915655686741, -0.09108715152840947, -1.3352336047465245},
    {0.3074642181665813, 0.25800596895013184, 0.34952796868089575, -0.3594097972150624, -0.23314146133369182, -1.8832057396275854, 0.46318183767312454, 0.28841742166468937, -1.4984314747187217, -0.5923659370886862, 0.0033457850557888306, 0.2689138149265405, -1.6021060577173827, -0.14805750622427452, 0.2209865327504857, -1.7708348076838862},
    {0.5237195733238054, 0.05047609444625192, 0.19049604375868756, -0.10322764874059902, -0.2084590913449723, -1.826693709412929, 0.5995816779939039, 0.4418309473007635, -1.6309687841302198, -1.0869520645102777, 0.0837223336427313, 0.39024712211374435, -1.5348367505377907, 0.15110115563709534, -0.31342296095336786, -1.4872074174350087},
    {0.5540033629271273, -0.14055588260211868, 0.6097158885846963, -0.29986598353678057, 0.3294245121243138, -1.7429796932955732, 1.416226208706172, 0.7549069626393363, -1.2329282283789451, -0.6379683223922199, 0.37107434433015074, 0.5399339326653493, -1.3838847616389665, 0.8605264360636046, -0.16021132378919792, -1.5071734519228375},
    {0.7101386141893429, 0.2722116543855941, 0.7232640748965274, -0.1517423508024411, 0.3928500535415413, -1.614704803811475, 1.528622906055728, 0.8134465233561802, -1.0859690751694255, -0.6649219883092505, 0.32005517736559436, 0.6303328545635272, -1.1777094630393727, 0.6373109226957872, 0.21640104568840118, -1.1515673195248277},
    {0.6171454504063192, 1.0293269223911956, 0.5510000796467396, -0.408875829694035, 0.09302512540770719, -1.6739475186984363, 1.1099252431804851, 0.620839274683575, -1.3830606609174358, -0.6044448456198144, 0.43209372757407577, 1.0699026913732954, -1.3862536501329523, 0.4908493939593396, 0.4155400758086097, -1.454943388744915},
    {1.0364132797727479, 0.6114071872424138, 1.0473578298231165, -0.04126795206400075, -0.032584410527848336, -1.5802298786043243, 1.5479744350999147, 1.0486035094479687, -1.184323124005205, -0.7688650544428551, 0.5328279392748962, 1.0572682473793014, -1.259179576283463, 0.3697867379825129, 0.22106080595324754, -1.1950323849292699},
    {1.5250288257189897, 0.6103632341908211, 0.7844085713377764, -0.15552672223512315, -0.06912623551955673, -1.0340959036549227, 2.1412402204309045, 1.5831346718640307, -0.676880381680977, -0.2975218055883004, 0.5492197842681538, 0.8712937169682663, -0.7824082317496469, 0.23882618909468512, -0.11806700761020804, -0.9322538052798552},
    {1.2010678091313516, -0.047018579062339, 0.6466342112243498, -0.46898101922855984, -0.6236470651036868, -1.2344658253492462, 1.7313163301831427, 1.2634626561335347, -1.1458385243354852, -1.3355827196248566, 0.3255593305209888, 0.4500489651292209, -1.2517957925378445, -0.6441713618334123, -0.4488166091767558, -1.0357427677330853},
    {0.7707442068936463, 0.13100600876236718, 0.29207088627668637, -0.3928101789709056, -0.5982395756702018, -1.8459955931850014, 1.1764695824261324, 0.5611211519787042, -1.4518488318035798, -1.523139649005721, 0.11563497862636361, -0.08957015737174917, -1.6144119946645878, -0.9225287109904897, -0.45624638413558655, -1.6310061356850252},
    {0.6946831436986495, 0.4292749918937921, 0.26943188706867094, -0.229215379743817, -0.0004123182383611253, -2.113811418787802, 1.4962007408953477, 0.834468866319379, -1.621281012572448, -0.7325576290085692, 0.016833892793295408, 0.6574990560246387, -1.6377019380397415, 0.29583136417024, 0.08061575030285288, -1.8490708389274721},
    {1.0011776976669227, 0.9701672268612092, 0.8908145315088154, -0.5019577255523625, 0.01632473236597361, -2.0102522141470716, 1.2567462526432758, 0.7233757266496625, -1.6223391598472818, -0.8525375002239466, 0.8169468996753482, 1.2649360822538478, -1.7929831278218367, 0.2740997935055576, -0.04469533420900196, -1.7637009681923872},
    {0.844198075372345, 0.006738101516334906, 0.8785941398477944, -0.5718786478146419, -0.5732766829992063, -1.8226905142090886, 1.368126282783931, 0.8269357656351752, -1.4354728798930945, -1.1858460306878313, 0.5929308107700492, 0.6082907918147258, -1.4082772886011565, 0.030732282027034017, -0.3563076474213669, -1.5144904909887116},
    {1.3525337187000472, 0.4869587726468297, 1.0429809052707975, -0.4022212180168936, -0.4723565610956145, -1.272094786269332, 2.0392238550257717, 1.3768578846257251, -0.8488015271001761, -1.0841205198054786, 0.5842505435332708, 0.5633107631950288, -0.8525826886263884, -0.10760440343083985, -0.2052170575219538, -1.0514157865029405},
    {1.8291560556303632, 0.8598936358532171, 1.2655236421071339, -0.04472080287086394, 0.526710562469862, -0.9384330614874443, 2.4951371465620746, 1.6818719331701302, -0.6530847818698833, -0.3236481703680515, 0.9606849875729934, 0.9593838250538972, -0.7836704909524601, 0.9000728319712344, 0.33730201943286214, -0.8432024894741132},
    {0.8625623471671858, 0.8012405857578283, 0.7231720786076722, -0.35987035544123264, 0.25076098023136795, -1.294213438046738, 1.3392405028973389, 0.8159988783036723, -0.9517292961191386, -0.9331973565402366, 0.3932504801697549, 0.7818622882384885, -0.8510958338057459, 0.36198297718584105, 0.03243817854700319, -1.1272949879563878},
    {0.4101371030241496, 0.2881677026046178, 0.21131649182829265, -0.06282785588067455, -0.33635422639557155, -1.5690424600684338, 1.0485331241441973, 0.2766551102490958, -1.1788854673969034, -1.1388653806345743, 0.2178690205954096, 0.08646475634433004, -1.3578937630539452, 0.3039568121276139, -0.32706914335129844, -1.5435571359132345},
    {1.021511863659404, 0.26574823992487195, 0.7821096908577894, -0.5142775396877001, -0.00953059255628489, -1.4476365707613543, 1.8550102815880114, 1.1189675380766544, -1.0813863477719134, -0.7742995297066947, 0.08317184880257608, 0.624238487586132, -0.7543239894749062, 0.25521968526161554, -0.05752570997094136, -1.0749854214124819},
    {0.9061426955012122, 0.39037729118106523, 0.6787717998350702, -0.10700836714408489, -0.18402175516391692, -1.5297886525460407, 1.649268656681689, 1.032206087146579, -1.3961480300344664, -0.9629893800842637, 0.3936955522561572, 0.9220625912978967, -1.6298826926927188, 0.504889207329702, 0.17722774522284213, -1.7840604451122692},
    {1.0928626503727432, 0.3514820156940066, 0.7163663960104023, 0.04317249490140909, 0.058622791554053165, -1.3907441991680325, 2.0820454516508287, 1.207422818809179, -0.7103577750501144, -1.2506065024332573, 0.16141664369348283, 0.4532336180511939, -0.9664475591226772, 0.2303419825888264, -0.5139848725785469, -1.262275965919972},
    {1.127633793403509, 0.44744410386724326, 0.6163216911761411, -0.30936633961504506, -0.31256350551762685, -1.5692546053505556, 1.657225569457447, 1.1391380670598803, -1.2510675957580408, -1.0127710453645304, 0.4358646708205503, 0.6197435384978744, -1.1407467719185111, -0.07205876612343527, -0.2944758521989902, -1.1526890533655347},
    {1.3597050549492928, 0.6773512592029004, 1.2482648383711392, -0.25271831510431503, 0.09018051526844705, -1.664668607615435, 1.986666151999095, 1.3764374472166103, -1.207582757230236, -0.37964758692977196, 0.9220100327286018, 0.9581774549380501, -1.296456654458638, 0.8369237039428525, 0.11783789695834795, -1.3469336641610448},
    {1.4465410456077927, 1.058333685791904, 1.116336659451281, -0.02366181472526308, 0.7658842547140562, -1.0231574782542705, 2.2426865852103117, 1.5125647571913021, -0.593112507127192, -0.3196406289296744, 1.0563429315562933, 1.0403410489591303, -0.5776386913877689, 1.1700015991142851, 0.18795712779027957, -0.7448283660333067},
    {1.5419985680701898, 0.8622812144996749, 1.332580281085964, -0.040748410015272504, 0.7393880840302948, -0.9902284188567912, 2.337685315363577, 1.454393199908824, -0.5190952917476584, -0.31469458589482013, 0.8989800990397248, 0.5318195317230491, -0.2620876265246925, 1.0213288412822379, 0.17482866325559898, -0.49255929386583275},
    {1.4048271641366437, 0.38499097528137916, 0.9861831849073478, -0.10509240797520757, 0.3938265138961299, -1.349928343735378, 1.974029878897253, 1.3414005721630113, -0.9662816909736964, -0.6184452317888995, 0.7470375038449416, 0.8043629800907672, -0.89816124756475, 0.42703230555020993, 0.12358568128395003, -0.8911196872497016},
    {0.8621789800986541, -0.9402653268998584, 0.27835134734016576, -0.06851857330092548, -0.4590950401915617, 1.687904377039877, 1.6396670873892216, 0.7041255936609155, 0.8750077880485522, -0.46471867366110325, 0.1522635409121899, -0.48188676788940793, 1.9249165851052905, 0.8608463765836198, 0.8155965900321154, 1.6005672771636896},
    {0.17862979197848206, 1.5475142337380783, 0.36060591794988145, 0.08785312795770946, 0.1065660792421815, 2.388431379855817, 0.9215168323482135, 0.8505009233543447, 2.2063018034870163, 1.1603745547599769, 0.6838499397554507, 0.09966643561609956, 3.005209417451437, 0.4008347439133262, -0.6514854108750339, 2.8450653851859258},
    {0.2600084731156515, -1.1682570562230141, 0.2597580983586849, 0.2565775280512066, 0.020554691620459423, 3.2434913657010123, -0.2029390844579879, -0.518021774515459, 2.5023054350357823, -0.7583776469146959, -0.10412155099443035, -1.6179608666385812, 2.3502054646375314, -0.3798402506019932, -0.35084327018920725, 2.5189827610393354},
    {-0.7254691477052486, -0.21784437017083105, -0.6844994518002439, 0.1276429434392468, 0.5710306164620027, 2.559826727645052, -0.9033899699569762, -0.5905624117398565, 2.128794077619218, 0.02455654750599819, -0.23120913984966404, -1.433546060607523, 2.115036193774065, 0.37934917654215594, 0.1339202591210058, 1.7872991164267618},
    {-1.464007095550969, -1.1789192796690415, -1.3221238353461038, 0.1727705682484326, -0.0795658009142556, 1.9351792565511334, -1.9570258115824097, -1.7265521360999867, 1.5330703406753712, -0.9165812017977103, -1.2101634173770521, -1.3758396629940546, 1.5595213420708334, -0.9773170805977173, -0.24334718492676685, 1.5156404666774446},
    {-0.8237888971305095, -0.27746936536202094, -1.0384588220763766, 0.1427970503133393, -0.13612162841340666, 2.1050846276491524, -1.14416482825982, -1.2136727227269752, 1.9971194929742808, -0.17486433458093809, -0.2512418834910401, -0.9530504844491712, 1.9776729887909048, -0.2465142100134687, 0.16512886708509647, 1.8586908690470307},
    {-0.35231364655401864, -0.276073626978293, -0.7309176352121285, 0.28461498712987143, 0.5962519375439532, 2.3410758678733132, -0.6461559541070143, -0.5153406656626227, 2.102368931911432, -0.29411687630943484, -0.44407554710007247, -0.5419560118225094, 2.4731975410425084, 0.036525713702216994, 0.708305400925206, 2.2515587493090576},
    {-0.7497763891759718, -0.3013312137136335, -0.852476333273399, 0.19166814164507456, -0.3132649291690493, 1.966646491834653, -0.9694916993817164, -0.6512459760428643, 1.7349908326484123, 0.1736583702164769, -0.5581336259878096, -1.0487812052198733, 1.637836697321541, -0.45371020270341006, -0.22049878587001942, 1.7455568830090613},
    {-0.9110063381790366, -0.5802602581811838, -0.668011302438963, 0.3475273663790936, -0.0030949706878763234, 2.3479626891156165, -1.4433505753055953, -0.9236618465969133, 1.6145921797896359, -0.026748446472294934, -0.8826193440396495, -1.2050172373585437, 2.231669919766166, -0.4699987651421164, -0.005917871302525622, 1.93553552505162},
    {-1.1151876949327437, -0.7962304662132346, -1.1637693882565625, 0.11478187942141817, 0.07461307024886449, 2.758014897054788, -1.1060189603941584, -1.0976088163721691, 2.268435058782972, -0.47934887258083037, -0.7281693452568488, -0.8324407969188417, 2.2727530665927898, -0.25497852536370175, -0.19907910582496677, 2.4269006156104913},
    {-1.814886172316548, -1.1325559820967452, -1.5555002928174053, 0.19041573802202716, -0.25156774141182875, 2.0167500262618914, -2.1514156088615533, -1.702562528500805, 1.7830695411637107, -1.2206205130967078, -1.2100333340340996, -1.557048939091051, 2.113405330524824, -0.2187626049516473, -0.7809858979126119, 1.8463896179043684},
    {-1.6917978396712157, -1.0902965388452854, -1.5172936199523699, 0.1672351185907798, -0.46602700190614743, 1.8554428240089302, -2.2602445919033367, -1.8060127137608661, 1.4366311459645358, -0.96031312207692, -1.1260646650806574, -1.8358787192111599, 1.4521651124984742, -0.6450048908605236, -0.19415526231194585, 1.5815265156066995},
    {-1.0640366120241904, 0.18676424857247528, -0.34107015950609537, 0.3239840295971013, 0.18901770261132686, 2.279771290060217, -1.5379462785440083, -1.166181652563113, 1.8792524219423365, 0.1541648335874362, -0.9330600759083749, -0.459433023417967, 2.2139915597111446, -0.033342277261676455, 0.5698143485881427, 2.2083648929084916},
    {-1.1835268810784962, -0.26874436061549783, -0.9650663971395824, 0.22447290719543112, 0.5598832719119127, 2.376965949672968, -1.3820498383907378, -0.8058644583193447, 2.1560278942881315, 0.6685019530794545, -0.2115294728212687, -0.8566235778026025, 2.029564307546456, 0.28975863194000784, 0.3635835636171381, 2.0413906408917173},
    {-0.48658479175522756, 0.17937053381735713, -0.47719240944954827, 0.1450331093424529, 0.4379954317637987, 2.3457106417481692, -0.37756067645000624, -0.6985976198006426, 1.8332038966451567, 0.7097659626696619, -0.08060623184716907, -0.11471935913705286, 1.868360495664252, 0.7646959747396344, 0.1518642864534569, 2.2541194334245507},
    {-0.7093714982264783, -0.532106715561824, -0.9767264384936319, 0.29472470531908007, 0.1245536920190781, 2.0378642647043335, -0.780697469361092, -1.0526748167309554, 1.8573952186459617, -0.35300147735424886, -0.41963455897541585, -1.336935523026478, 1.779072381374256, 0.0388639946098898, -0.23765983597321372, 2.3595829731942324},
    {-2.1194110476797507, -0.7463286071342888, -1.5472755070009399, 0.35774147299968495, -0.2924662616427993, 1.7866694659012725, -2.0705535036073335, -2.1428766589722823, 1.509267127418458, -0.022290388126945216, -0.7317418729313008, -1.3094571943958455, 1.8419472007070108, -0.3010787844558465, 0.6813784587783984, 1.6147216327211937},
    {-1.773172175680418, -1.1426020011745466, -1.6827893499991524, -0.3836376810393156, -0.7349058611738217, 2.4130037727850677, -2.2380630266987267, -2.0326332817644546, 1.6389041099343642, -0.2769350311542306, -1.1946598679261649, -1.5747380208734099, 1.7422743993018415, -0.7171864021682185, -0.2345769699306484, 1.962967806295729},
    {-0.9525725683504873, -0.13684354156059378, -0.7649372864413508, 0.42885506643037674, -0.08563003080460344, 2.615542551082975, -0.9911894722023185, -1.194921336218922, 1.9413066309242535, -0.09349130197238244, -0.4428165677085901, -1.2855547902157725, 2.1862085044252995, 0.18999500931209795, -0.3908846600565063, 2.129014882955031},
    {-1.53849177619979, -0.6277963093749088, -0.9037615904149159, 0.604477450404159, 0.3941640452527456, 2.259624518437899, -1.6770054132312493, -1.6115809648934982, 1.836949415478759, 0.19283233428259122, -0.5989884025371849, -0.8804712252750437, 1.984973777978513, 0.42327885081004873, 0.1449204961044589, 1.8878549931900659},
    {-2.050104129425927, -0.5893970483955758, -1.1640362424375845, 0.29711753945509367, 0.043472477963195394, 2.3415216135781383, -1.989773165135409, -1.9711838534562387, 1.7539630322176842, 0.2845025208513665, -1.206909428885267, -1.0667600213615416, 2.050490675177902, 0.631297895561145, 0.24303153845682068, 2.011276488675656},
    {-2.360116730350266, -0.9550638400806114, -1.666700438627951, -0.22917558361386406, -0.8096050516964876, 2.104993789292231, -2.3224027326050396, -2.3794930824885756, 1.3976743506670557, -0.9606026102762057, -0.9288988026265501, -1.9063533820559873, 1.4180495715897807, 0.6883808345943468, -0.6756255963995493, 2.2170718692965017},
    {-1.061641386354548, -0.29175302296307287, -0.3391075364291513, -0.09319363355679773, -0.1507603043842488, 2.324788860859027, -0.7597151609064052, -1.5381106604016557, 1.8178837852788756, 0.6745177393995383, -0.22637626824846846, -0.7516924327163484, 1.760589883784624, 2.2557736923578977, 0.3372974264521738, 2.593061797867016},
    {-2.295744830927473, -0.4656024948598199, -0.7176475284905363, 0.24379162140414826, 0.14473775491741137, 1.7351166935081903, -1.9545792722162718, -2.1746619000574015, 1.3675985525383052, 0.33881906629316916, -0.9184372016408467, -0.9659668805789757, 1.6426592062945269, 1.4382541711271803, 0.42266686276066556, 1.9189112329088849},
    {-2.3102074278282987, -1.2839580024686312, -1.5940544810822463, 0.5178049935275664, 0.16380359697663824, 2.243096742144323, -2.4097532010544405, -2.187186042251265, 1.6792586871508455, 0.0022904275014980096, -1.2728595477789826, -1.0959410222931145, 1.8161970137178933, 0.8489829600799712, 0.0543160881633588, 1.805460189110513},
    {-0.7788755411351151, 0.016733366142818902, -0.8537573024937739, -0.14739038521587894, 0.48750524889453273, 2.8640972457272107, -0.7020665968778594, -1.9681871726010445, 2.0103951231089554, 0.1355821424168619, -0.08840177772734555, -0.8711413236414582, 2.3692710573198363, 1.415913323041966, -0.25970061175112485, 2.987388066065988},
    {-2.078751859963036, -0.7901204898315947, -0.9918153136494924, 0.36810727625279605, -0.4358257959530436, 2.117263947977588, -2.208500321228677, -2.5888788051175236, 1.7502519250520079, -1.3001924414557722, -1.4864934050549463, -1.717589792045191, 1.6690906684074307, 0.5173392216188797, -0.6971688632419553, 2.1723357793574776},
    {-2.494213376047433, -1.4590399945943255, -1.5110776018752827, 0.15024349541174267, -0.34590932322533413, 2.5443766556647707, -2.3109990332532773, -2.679664472304131, 1.8428567013734187, -1.700973915538398, -1.268848691073691, -2.146069244014514, 1.7811786679930273, 0.48117764679690517, -1.148987733841989, 2.3015813263235803},
    {-1.602900152994687, -0.5958825259178703, -1.1478571140010811, 0.3529152813088029, -0.27484069865483163, 2.5075484254884404, -1.729889092478955, -2.0959631847414, 1.8983716080092687, -1.31849578068728, -0.9516068058704379, -1.978648186369542, 1.7972174026478938, 0.8162237823109348, -0.9715906894526704, 2.3119691404387988},
    {-2.677064710647983, -2.3313542403221374, -0.9325170253770908, 0.10299837651392159, -1.041368836793448, 1.8526929400199172, -2.1258986211015145, -2.9223977596601056, 1.5409867086207123, -1.6180613077561528, -0.7473053466024894, -2.0632617344939486, 1.3973597598474832, 1.162974998899037, 0.8428814716889492, 2.0560173082730655}
};

static const float b1[16] = {3.812638995246616, 2.7371625903496057, 2.8158254774453546, 1.1365680579927235, 2.1521993680379663, 5.721074136084811, 3.994089330185579, 4.106408976141685, 5.2202164696656785, 3.339521410443356, 2.4578797089694566, 2.7839479714825055, 5.609406561758966, 3.0939627801177525, 2.681225351967373, 5.435015670654823};

static const float w2[16][12] = {
    {-1.5860083861720708, -1.124760327186455, -1.8623304696637475, -2.214819165484875, -1.2017967073811116, -1.8846168537210122, -1.1865752902809394, -2.5438734054052468, -1.983337126683359, -1.0066158647020442, -1.82958889560364, -1.480904791963572},
    {-0.9079554678923649, -0.7096867487806162, 0.09955840600152667, -0.624689075395284, -0.937427189805959, -1.8348773226489683, -1.5789464904819455, -1.6964526883098474, -1.2415306496661414, -2.2102459390037614, -1.600526591753861, -0.8072823882806898},
    {-1.8137450391999936, -1.022471457049238, -2.153987594621531, -0.9627218435200765, -0.5132418444159477, -1.0951510322830578, -1.0722991199828413, -1.0949650808665863, -1.4926760726181802, -1.616176737963432, -0.7337286375187357, -0.5496563357650998},
    {-1.2737768674626746, -2.3722824118293424, -2.095379697975105, 0.6925584567752856, -0.8617303777256181, -1.495258235628568, -1.1749724395451762, -0.7395585743079778, -1.4025755590260465, -1.4528856158286025, 0.9646395741665651, -0.48775310836388497},
    {-0.742259145707597, -0.8940332263519635, -1.724720891143601, -0.8882707107329635, -0.38360592882201605, -1.8773490097354413, -2.07756931994479, -1.0217413651805356, -1.547418251132299, -1.084586230794306, -1.8923250583703413, -1.4615735168459096},
    {-3.1735173080201777, -3.0890141068516432, -2.9793263308050593, -3.479017922342948, -2.905758991331479, -3.4242869720960982, -2.980171091774788, -2.031928270490118, -2.8715904522229843, -2.513013587362959, -2.5245713827223355, -3.490421236088416},
    {-2.2465778591059578, -1.7862348031259014, -1.3845237267140331, -1.7665584362231335, -1.8553902742915431, -1.5884914774654737, -1.9344338964797443, -1.4976442164074453, -1.3502440026339095, -1.7494125951650297, -1.491587377706829, -1.978346469668341},
    {-0.9095549885141071, -2.0179637049442696, -1.6133060653618947, -1.437239575841087, -1.8841187011465943, -1.7125713077442928, -1.77711018447656, -1.1045373208078326, -1.7252414143601194, -2.0531001953618757, -1.8465595688298293, -1.4722102368189314},
    {-3.3443628631124125, -3.309515895402689, -2.486186485629, -3.099274742165482, -3.19884553849058, -3.35247622647139, -1.6013340131086922, -4.012214059308527, -3.241495174625275, -3.1245196698155895, -3.445875576073394, -2.8232350863956053},
    {-1.3784183401519248, -1.0335114680478175, -0.7753278768202266, -1.6085987347392185, -1.4417985118722474, -1.448779505888217, -1.2168694065133276, -1.7930684373591594, -1.1912535678337774, -1.2909540872736858, -1.778558119252756, -1.2465925288632536},
    {-0.6547106493118242, -1.114531604515668, -1.2584542069190738, -0.7529004087606853, -1.9795682535834318, -0.4895392660139885, -1.0442421287108623, -0.9493449679806569, -0.7288143513185639, -0.737763806867302, -1.6128036164229131, -2.168661152998596},
    {-1.256938841588039, -1.9311649481139734, -0.9329590226430049, -1.120284107811055, -1.3738746716048482, -1.5609122932656714, -0.8049477553365696, -1.035385267961387, -1.1655615003183262, -0.6484604149894367, -0.789554753379799, -0.9709938915859166},
    {-3.1311200710298817, -2.8588864703148245, -3.2807486007914255, -3.355095806055682, -2.802293037359228, -2.4357662002760976, -3.778357951314946, -3.1536050243026748, -4.012048238161992, -2.9299861003304217, -3.382196062283363, -2.7976604792755504},
    {-1.1683030683508697, -0.9297671665047454, -1.7734040823450523, -1.7551743738947014, -1.732023023642841, -0.8289327435481331, -1.6898780532155653, -1.7401131173210542, -0.8099664481605553, -1.8090348467423274, -1.064020419290384, -1.296302910904262},
    {-1.5113724497188559, -1.4813017121099104, -1.7491889563181853, -1.7292207070365337, -1.091124645013317, 0.3238177200858172, -1.7166252263887514, -1.1964642948242352, -1.9277481847839173, -0.3668439497063131, -0.851250486737833, -1.9045081234701846},
    {-2.789954242624637, -2.8345925686310434, -3.4460506637489736, -2.570318066305073, -3.3749884545143556, -2.8892210718770364, -3.705618111875005, -3.1577531824128626, -2.0743257754348594, -3.655149128004603, -2.9895524162113345, -2.958148404969617}
};

static const float b2[12] = {-1.7320290389803363, -2.8245552397344382, -0.7014190614655554, -1.3181566446998674, -1.448997388538574, -1.1501743682112113, -1.6285260612660892, -2.3707425184437123, -1.4740394156506471, -1.5218937589141448, -1.8228550969132997, -0.743906176245911};

    // Input Layer 
    float z1[16];
    for (int i = 0; i < 16; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Output Layer
    float z2[12];
    for (int k = 0; k < 12; k++)
    {
        z2[k] = b2[k];
        for (int j = 0; j < 16; j++)
        {
            z2[k] += z1[j] * w2[j][k];
        }
    }
    softmax(z2, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
