#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][64] = {
    {0.021202912416662802, -0.24839389352654614, 0.23546869181442084, -0.11865116592808572, -0.3313413980401665, -0.5022670556914581, -0.058588101275173145, -0.1457997539137113, 0.39165681935415547, 0.07239628783463406, -0.08185526768162069, -0.5407751902132981, 0.3454105144783634, -0.4326174053446088, 0.0011080231038614237, -0.3696987967997315, -0.5116697522486314, -0.5084070896359199, -0.46786677603773524, -0.0717828754711979, -0.4078865186913114, 0.28270534747402265, -0.5346673100855162, 0.5413055240331501, -0.5253192022778409, -0.27948042092353087, 0.034251908884021576, 0.1209615894923692, 0.36557768302929367, -0.21411683624048441, -0.266283288993254, 0.48392647581136533, 0.15373529597769348, 0.3977757851357152, -0.32096370195591917, -0.33286936588150373, -0.4568328044755435, -0.2008546002571413, -0.06374160728905731, 0.5861080119897598, -0.12561439943133498, 0.3468092168699594, -0.34363730948169435, 0.5420526110689475, 0.09594762974125362, -0.35992894643605555, -0.12583881761834795, -0.2991952157829014, -0.2477327983497847, 0.0022551336649906783, 0.24253358721122167, 0.4832612207463775, -0.4226075623113945, 0.6628069418799591, 0.5362606214363557, -0.18429881618210628, -0.273619830886834, -0.02237916197409586, -0.17948848075337515, -0.5192072056143505, -0.37004199272673965, 0.1722791113499851, -0.44663351465508394, -0.2711191319282604},
    {0.4646385150181119, -0.5493980696635553, 0.29738080943844486, -0.005826305998685718, -0.37010571760140815, -0.5654335793554571, -0.36553056592362193, -0.07977656542801564, 0.5682014970643747, -0.31306008621641446, -0.4428748749190881, -0.3002428347134074, 0.38952522542498474, -0.502302870268469, -0.06937555092367971, -0.6064700606297283, -0.42229492037590755, -0.326273578033396, -0.5244947100183014, -0.10451912525371815, -0.25095522146025895, 0.5308628573042965, -0.3803940558632016, 0.36195457211243365, -0.33602516315487735, -0.5707634009436449, -0.15863531975484393, 0.24969310376429843, 0.1866410235723023, -0.4383949936446083, -0.31661736232637877, 0.1748048594264968, -0.34449813044452704, 0.1436793538074243, -0.3879133311547687, -0.20201475632644209, -0.40043445947510237, -0.2594113120821199, -0.5331160189650727, 0.42975847781207793, -0.14627158472527088, 0.5063931414889199, -0.23225009716587533, 0.3693104223401875, -0.1972978911850321, -0.37519782198526974, -0.07309707644630864, -0.3842179852540679, -0.4418954390728314, -0.10243839714934616, 0.4330199807031207, 0.4427615450635753, -0.4273458161680655, 0.5446267718605999, 0.48325507628644354, -0.07051887493300985, -0.37420100759613495, -0.2626514568171681, -0.12344614684737018, -0.5435570280847328, -0.4138171731104658, 0.33401356104932695, -0.2315249550406703, -0.5664453105571351},
    {0.23273386051758094, -0.5035165205246025, 0.3910983608186456, -0.23499541799912696, -0.5252036121724042, -0.5955958002270106, -0.4949771252882774, 0.1383013227053254, 0.7180522010181682, -0.16536916063844923, -0.5276855905098039, -0.6011789543511076, 0.6562921185523968, -0.35754248508602116, -0.03335839928589065, -0.5227623613135559, -0.270968708331766, -0.5005002083107116, -0.42191922209812893, -0.31043087871251074, -0.28959534083590505, 0.573411059068663, -0.2358453996705305, 0.5413201878304796, -0.3845707836213701, -0.4883485726198299, -0.10002596067736529, 0.5522956718474746, 0.40208430324365435, -0.5233448238358795, -0.3664844121968878, 0.6273620760091255, -0.26028373221869683, 0.4653953050448193, -0.5346212405592407, -0.13030620488394176, -0.28465622596873696, -0.3584207325147279, -0.4857703512226934, 0.6794699678734669, -0.41415579185079526, 0.6533535865929186, -0.36113200736431605, 0.597523319576982, -0.21467237506041972, -0.34205516496257854, -0.4735577673616638, -0.3631569571736883, -0.25865715951527773, -0.19514183693262502, 0.5153707426679818, 0.6163785966791184, -0.6080128561394242, 0.5647847959150868, 0.5068376341270077, -0.11667980424196071, -0.47288988114480085, -0.5135627934094548, -0.34048784657784914, -0.47992677238239334, -0.4134259113997405, 0.2929894259656194, -0.3637474601778746, -0.2756280500485743},
    {0.40448445955247675, -0.5316676698868874, 0.48046740700543344, -0.20843539484150972, -0.4723489131499425, -0.44698170633500617, -0.5147780098773376, -0.2578273639607807, 0.6323266098355743, -0.5499461802143751, -0.46436497843517754, -0.40891444165157387, 0.4213495772283687, -0.5179771027810224, -0.1009826132750704, -0.4443520771978575, -0.7186115155102506, -0.29811525428861246, -0.4982765338271138, -0.2531574050165607, -0.46866604503284076, 0.06283581335534544, -0.4264147502839236, 0.4211868475447626, -0.44469695250507174, -0.551338833694127, -0.3135250507750965, 0.1655403386433722, 0.47063869849599155, -0.35153613877968437, -0.5531392696903639, 0.3803670660407483, -0.3391109576511823, 0.4339974086715794, -0.3942144655957239, -0.3810516337908659, -0.49390230251628775, -0.43561003999634823, -0.3740612123376805, 0.3727502559000656, -0.3716367236699944, 0.4431849056865508, -0.5919714286259957, 0.3337471294371975, -0.3786466967347389, -0.25203218186016374, -0.6154103280738296, -0.16999904550631395, -0.5396546579193111, -0.44598723282549796, 0.3457088960341054, 0.4351064538690359, -0.5252238761486717, 0.40077797221279504, 0.366520885682847, -0.45490513268825217, -0.610991345605536, -0.5915066008711733, -0.3106011549091854, -0.6343396025931892, -0.6363003694483647, 0.45702804417994425, -0.3588718051065939, -0.6340360413243012},
    {0.3761300741604898, -0.43123002294285945, 0.33583293861116364, -0.24354816559686562, -0.5864215167776, -0.6771693042916537, -0.42233306609839916, -0.39554738762059366, 0.5410699306551907, -0.6501645780587632, -0.7046667786773025, -0.5761858504110643, 0.48011543214536484, -0.5825868746299754, -0.24327937488148715, -0.6097854115488565, -0.49831734838931097, -0.608697513667363, -0.37111253529794763, -0.3412680091910558, -0.5261290941576904, -0.06171084941381284, -0.5252378128710259, 0.2761884535131746, -0.5945264737421311, -0.567642694910774, -0.3496770134172756, 0.2071720154186154, 0.5874509372907183, -0.6450830583324746, -0.6188159738701065, 0.6675321246835447, -0.5333002971419453, 0.29473948508574055, -0.6976538466682688, -0.23823876793632076, -0.7072207910988478, -0.4266511364581295, -0.4903924069648836, 0.36540961179676723, -0.3360252770179826, 0.2925318253868574, -0.6053263588585948, 0.2511848481510522, -0.3913590899525931, -0.3595027096454283, -0.6218067341239042, -0.20204937923857805, -0.551280541668294, -0.5518933996768757, 0.43089570977482633, 0.43710321327028967, -0.41784072477526496, 0.14082455557368684, 0.5198974060011556, -0.508012112338805, -0.49506342046698587, -0.5301143282427294, -0.5644686954775049, -0.482712435999664, -0.4758397098757565, 0.12867408872433866, -0.44368181816348323, -0.567219076367318},
    {0.2197566637637576, -0.6720964558300423, 0.13756303626581576, -0.5378825878055411, -0.3434273138569927, -0.5276257950069115, -0.2882937046670815, -0.24756220598481313, 0.1705813140855857, -0.5516355571232678, -0.4770910522843888, -0.6203297677326087, 0.3533639111230114, -0.49738711132667335, -0.17439509979871504, -0.6761547595745274, -0.3215601278877028, -0.42515230227409406, -0.3830387330930076, -0.5918131466116159, -0.5300340753768099, -0.26525862928109883, -0.4775110154533631, 0.08714274670048289, -0.6606853356038234, -0.6823119676875639, -0.6573801633347731, 0.05708725313104311, 0.32634738592725937, -0.3120953940017556, -0.619116531568755, 0.5000490277018425, -0.4029156522751092, -0.1586425160629234, -0.6535082977207192, -0.43739003609474136, -0.4496488268054124, -0.29787403481899455, -0.6169414023553412, 0.006398410564073411, -0.6253322614657844, 0.12316880291777071, -0.5472423536779774, 0.07505224337927999, -0.3407595094062186, -0.3657012927969725, -0.6812939727658893, -0.5205852212704906, -0.6831400780148441, -0.3601754444781603, 0.4551109720218951, 0.2946719123026151, -0.4999131108286762, 0.1699692565583852, 0.38440348887415093, -0.3752653129863034, -0.5011355438992962, -0.4129109337916042, -0.5789786673791069, -0.5269866759632549, -0.555421340475982, -0.15055850948307148, -0.5019419188578864, -0.3839540716073258},
    {0.16403445982725479, -0.5283000131869527, 0.03333271678552111, -0.32165798486658415, -0.6308158431490658, -0.3788751526043155, -0.6015624027467176, -0.5936399603056648, 0.034161917811014214, -0.6281281842472431, -0.5535262465154362, -0.4249497348318375, 0.08869945516996419, -0.37142769576451423, -0.4599634753431715, -0.4443956796642319, -0.6366882808744819, -0.3123663537019022, -0.47462992488975736, -0.5724090723798118, -0.5414186808187113, -0.4638377459536428, -0.27749179957606107, 0.0011188912367531487, -0.5756761868228761, -0.6321182445182383, -0.5960937158093241, 0.3285463192222425, 0.31436185780991543, -0.38276800839451347, -0.4522988374604953, 0.47609883450109053, -0.27019559545046357, -0.22334466010809398, -0.5750336531697824, -0.5021638570798638, -0.49817536621426695, -0.3671241167049311, -0.3969028279510195, -0.0721529024778837, -0.4981787310886231, 0.14347766148364874, -0.6510559095704139, 0.09185400952554092, -0.3057654963781342, -0.5794240446017542, -0.5943035586159842, -0.4781098462583441, -0.690701224419786, -0.6438297661782801, 0.3156776770276865, -0.017816012556965903, -0.556614278910501, -0.009026240744994939, 0.13527342640018966, -0.2971263967914713, -0.5730404746742201, -0.6122513477534415, -0.46814795613659094, -0.415871817152604, -0.4731842460980917, -0.32969816937043595, -0.32963483015809514, -0.3945611432317758},
    {0.10615246400233974, -0.48870041633265215, -0.11556666890134819, -0.3964726594180552, -0.5832049108766162, -0.47812434243983154, -0.3115427399074131, -0.2653913284924374, 0.10374069215916987, -0.38650978015035686, -0.45241523379238424, -0.6094484719770905, 0.279955477826616, -0.5552904912162028, -0.19838701594019872, -0.6430315077518713, -0.5473580329380034, -0.5445549881858459, -0.6262936863886247, -0.32338941463194454, -0.5431826925625642, -0.41799491446201387, -0.3416843298209835, 0.2787779491074651, -0.4086961101596903, -0.4055789087832379, -0.5675544119351779, 0.06369562073724282, 0.28694743826391755, -0.5291652553815521, -0.5211744998763523, 0.6228973082758783, -0.3595058679619768, 0.021862595100572518, -0.3938814021593183, -0.5822369970072699, -0.7275233987199833, -0.5728019958798342, -0.5738833534320128, 0.10697865567953281, -0.44220747005588656, 0.1656708506330621, -0.6752377119485642, -0.04106176067874994, -0.5108129623638681, -0.44624884913441215, -0.4085620341644794, -0.3483810434305739, -0.6589147442898164, -0.6464216414901317, 0.38674705803020454, 0.21116222295881193, -0.5436627321257653, 0.13037612003697813, 0.34509068745803945, -0.2285439455461239, -0.6143757257102465, -0.6605910523961641, -0.6110680328946554, -0.6756327199805057, -0.4145466412798971, 0.017683650109195308, -0.5737761335515984, -0.5653498856178172},
    {0.24545530473184285, -0.7468895494183989, 0.11729075259531017, -0.38822136858289585, -0.3336443925413688, -0.4776784374820205, -0.5360741097558371, -0.26465156195884215, 0.349929133749423, -0.7323005666312582, -0.4544228722797678, -0.4244054767497441, 0.11683546212273775, -0.6518675428546973, -0.18025162989262986, -0.6087626305893865, -0.5972198400060066, -0.5360630608234744, -0.43238194266537155, -0.6386443119892234, -0.3229866248136607, -0.3302609679130037, -0.3639857920434338, 0.33543248786018376, -0.33140176721275805, -0.5024008810869115, -0.6185287826301172, 0.006073743693854773, 0.5155301325641085, -0.5181119603675689, -0.3803725689657111, 0.6281814224564033, -0.25564791525938063, -0.052007410663810455, -0.5571563336877156, -0.5286271291449942, -0.7359773380213626, -0.5357817343132691, -0.4891539091795944, 0.3614718511868716, -0.43380469258903803, 0.06915429953720803, -0.5522903465654289, 0.34346556782561183, -0.26723210925182267, -0.25669952292484116, -0.4613479161223784, -0.30039529790338443, -0.5148813794007623, -0.5187149843528582, 0.3693387159051101, 0.15248095076551269, -0.7236400216236473, 0.27295038717570747, 0.3138752744494196, -0.33993692759379995, -0.5088891640130481, -0.5838094599441885, -0.5637596444721699, -0.4250296480948492, -0.6979064043936302, -0.1993247284920474, -0.4230172418849083, -0.4545108840260843},
    {0.23727181577407197, -0.5850788543139505, 0.1142400284216569, -0.26338037750313914, -0.34036231090687025, -0.541238257250102, -0.5864032270540415, -0.08974363895866122, 0.2405033794849667, -0.6334513442796023, -0.34327052827945104, -0.42423944438488626, 0.16803487881937348, -0.3810314707077593, -0.3858162977374068, -0.43873102470124714, -0.6642160339565185, -0.441692842264626, -0.6088667268323394, -0.5257601471899435, -0.5045786925927043, -0.1499134795049155, -0.6163510420073555, 0.34444474477294157, -0.409907463922512, -0.6168020241445007, -0.4552081472315423, 0.17711528699692108, 0.3008927868411492, -0.43759972537458774, -0.48402670433586353, 0.6020278356835246, -0.47747363428621786, -0.0909430290695348, -0.7236729933467453, -0.30967544847550293, -0.4564396378629081, -0.4254298241127405, -0.6230718189421569, 0.4885932209626863, -0.5006037527420588, 0.31638220095556463, -0.5715604878598024, 0.3516311647487075, -0.267086860486621, -0.3795764954804476, -0.4462793450691344, -0.24285032762923467, -0.6417393056732378, -0.5927595016010653, 0.5479869530225063, 0.3654713775563926, -0.714280880378114, 0.08584005318946127, 0.34613508328451276, -0.4802706654855938, -0.6562248559680779, -0.27371071542806086, -0.5513038031644226, -0.6724166212528264, -0.4085542559214753, 0.285124562136141, -0.3719344841126635, -0.6268084137063251},
    {0.326116478207206, -0.4670643869828895, 0.10597442836465025, -0.30961963714252816, -0.6314306586931981, -0.651963197658736, -0.35512007947687746, -0.19179083400558228, 0.15136244255232925, -0.6961368878535803, -0.367352151469724, -0.5416897750576921, 0.3675134189127718, -0.5345726388119034, -0.23715056331788248, -0.6354632144032906, -0.5204975574546229, -0.5833308987643716, -0.5591355034440806, -0.46360916757847326, -0.28678687253803575, 0.05456606614700499, -0.43442257902258574, 0.4265796691160183, -0.639049587711159, -0.3740175403623807, -0.6290561345538913, -0.12397752544671856, 0.4313032986209443, -0.5510043175164901, -0.37543062541169026, 0.16609924829520858, -0.3704095644053544, 0.09466903951387355, -0.5012951082298698, -0.6065155897113429, -0.6218205228680121, -0.3718151907844997, -0.47768393604023346, 0.248280699697706, -0.363238986218404, 0.10380114953641137, -0.48236816930509513, 0.4262927512617595, -0.4660769847076208, -0.5583191320394281, -0.3568866231450226, -0.3037882933669435, -0.49319009957513255, -0.39911595265461774, 0.3402505675857859, 0.6095302644890113, -0.40095564079015067, 0.034121571745933735, 0.30426658846470483, -0.5334949131865413, -0.6618371291851809, -0.30022429194556743, -0.2767902569245531, -0.5266983769478177, -0.5796020257836255, 0.04931245826787091, -0.5308140478355577, -0.6214391282808771},
    {0.05000610257465996, -0.6998140063097031, 0.14210094447990132, -0.4603663649857261, -0.44352612062822294, -0.541275689532077, -0.34598015666915233, -0.03443872593105074, 0.39324591321780356, -0.3596274375418893, -0.43935890960497914, -0.3794406427692402, 0.3324231007093015, -0.33991962489266786, -0.28734112530116507, -0.35110886255379925, -0.577493444231572, -0.6267649715264801, -0.35886906279289355, -0.5763808260845038, -0.5374727517450386, 0.10571348419408924, -0.6261711405501815, 0.3534104652897882, -0.5596626565929587, -0.5099253268433239, -0.2860419331496957, 0.2708483627563059, 0.20977196001934817, -0.3680095812997051, -0.5555885150446583, 0.18730021563053734, -0.22881610198181945, 0.0029514269126380073, -0.4837445184055177, -0.6286115362045653, -0.48965098732546075, -0.633477337771125, -0.5829839939671412, 0.26811693233127654, -0.36420078843780584, 0.1259257550912985, -0.4374972143709284, 0.4313198305811072, -0.3776535683724579, -0.463007411845723, -0.3478216388036152, -0.4358510311990197, -0.41835048499079375, -0.5174220788589483, 0.3944141716204031, 0.28109026010040966, -0.6643109405709833, -0.021862740103805726, 0.11595400089329805, -0.36662329427901824, -0.5849979560800755, -0.5359112940404754, -0.5723762015691987, -0.43877951065395143, -0.40059636162838913, 0.08591585474503573, -0.6355922870441196, -0.44928712396573595},
    {0.09425470627107974, -0.6773146112282353, -0.06213062205656789, -0.3013769462854367, -0.40254455960439495, -0.6586490977832027, -0.456315540299536, -0.32208879179000316, 0.4914786877658303, -0.6233058644410863, -0.5262161445399484, -0.6614948295856139, 0.20511747813669384, -0.3900515475216322, -0.5019653190128792, -0.5778548992105158, -0.7178000916563896, -0.39447969937313954, -0.5375982451721755, -0.3641351230867292, -0.5811179794963581, 0.08623839360362252, -0.32855804564037366, 0.47126823695675235, -0.38714001576531204, -0.580780894027081, -0.5755348357944087, 0.27745769844977036, 0.4828663395496745, -0.5841907507043604, -0.4588730587311639, 0.45582369796836486, -0.37839967470941965, -0.0323303379367595, -0.5275473967142569, -0.6485762459034426, -0.3873627186767187, -0.34385280065495416, -0.4234465906028074, 0.49951630579956596, -0.41469996148978394, 0.19543291455685635, -0.5611638283829163, 0.5461407407307416, -0.32858060825097835, -0.3201383110185689, -0.3545660077952009, -0.3704444284862463, -0.5799726706741672, -0.503107865044195, 0.436135067831944, 0.2377846793051346, -0.5693073381627468, 0.21926345840093356, 0.38084945500406836, -0.3184245085568729, -0.35217358762321077, -0.44418654833167415, -0.608672184164803, -0.48078619436065045, -0.5857047453374836, 0.1278818030805312, -0.2750460492321905, -0.5529343191205407},
    {0.20871025929436002, -0.5281335689837999, 0.19424389814561605, -0.4670835148335846, -0.3162774455564288, -0.5552845177570132, -0.5627002826233723, -0.1506232281660611, 0.19731638081343222, -0.5217363566632867, -0.3100060558675181, -0.42682413242505, 0.33358915642600256, -0.5664592939605665, -0.3541895236350496, -0.345610673831215, -0.6064027808841153, -0.3573180423267618, -0.3617167380959905, -0.5592604108642953, -0.5682404471058056, -0.09716554209439707, -0.4788870099465032, 0.22037542662542786, -0.48620034765674797, -0.6404456713768948, -0.2946779321116977, 0.0818514213338656, 0.4001141292513003, -0.4444513089676895, -0.652531397085628, 0.4942853204532815, -0.22593974307229384, 0.2982746501775426, -0.37198586625842683, -0.4475063599298228, -0.6414997554117435, -0.35039535472554045, -0.5255415479779016, 0.3052968277561084, -0.5407887496873661, 0.2886222817209171, -0.5689748836913034, 0.24572077971117412, -0.30581552426098363, -0.44657051657044666, -0.5971174676050324, -0.2804048172129351, -0.39238731156708095, -0.46055895016249926, 0.2090002988824955, 0.1965637312196623, -0.5429966526543345, 0.0006691205290744555, 0.11793880888399785, -0.39769851907443426, -0.5014191254866642, -0.5357059513908689, -0.3625176005718395, -0.5768821406801765, -0.4268036054738111, 0.23073883004407628, -0.4688642851195119, -0.5098418493746413},
    {0.3501768011622927, -0.3978818862638467, 0.23947175815092367, -0.46246002025813043, -0.6002213293842378, -0.5275618498556981, -0.4306022551617677, -0.435295270439273, 0.29994508664185116, -0.36893174879217244, -0.48764459048761244, -0.42023355450838135, 0.3938230593902694, -0.4974088227270886, -0.5347762060184353, -0.39099948257319894, -0.37834368936904966, -0.6062679450590669, -0.33811907669691454, -0.47749093642937557, -0.3669962484204398, 0.08265323246738103, -0.42752572188896143, 0.4423202469003296, -0.5576839189632539, -0.5087808012412087, -0.5598324203105823, 0.3345006221338494, 0.3110390108779177, -0.4011580450883677, -0.5271598289227009, 0.3173014970099312, -0.3153172120353909, 0.19508180087171265, -0.5035827151191369, -0.5325696682572503, -0.4251721814248241, -0.3392398933790034, -0.5575940981109101, 0.2732730361432791, -0.4632027059137591, 0.2451785697637923, -0.5141152098344496, 0.36613388744038294, -0.4752514132724894, -0.5574075879441063, -0.3122949938190852, -0.4328688604571178, -0.6415228095125509, -0.34352327834050533, 0.5358051273032663, 0.35082749732477697, -0.5912229741324391, 0.21947496766392213, 0.22830161371185612, -0.3010617414052901, -0.6370123568865933, -0.4969387301396424, -0.2802040152565722, -0.5100643788225827, -0.5697247155096506, 0.18482728905342669, -0.610592661901704, -0.36037590527064123},
    {0.30818093760192294, -0.4878037844951164, 0.06964902361234092, -0.24168792426048766, -0.2886320027999067, -0.6193204033982435, -0.5980924810034645, -0.2268108726869436, 0.4104385826124681, -0.38610882644857, -0.46370725380945493, -0.539457172744346, 0.32466927370630283, -0.44633448892015676, -0.3284116541548845, -0.49885054452396904, -0.5641265665746907, -0.5838503602733655, -0.5876804277075176, -0.43743828712898913, -0.3278101792180175, -0.013906242176058667, -0.6358601118495667, 0.4308804063454581, -0.43542087365625937, -0.47071715953090176, -0.5894875429254366, 0.40286936594766004, 0.5114145952117305, -0.34851556251231103, -0.47346807696870175, 0.5806840777794657, -0.518033254779998, 0.34881226462210435, -0.6276524336790659, -0.350604201227339, -0.6935536953640887, -0.6168291936749707, -0.4420420046263665, 0.16905567254059264, -0.5301529774886196, 0.19190332597424262, -0.5988313535680978, 0.33602280811190244, -0.41313960705163794, -0.3021838378475066, -0.3990438724767962, -0.4307503500014815, -0.6329350728538871, -0.4034551379290434, 0.4450174918613024, 0.4785396800683526, -0.5096216174356215, 0.3757433127434051, 0.34405469421435936, -0.3477503197654373, -0.307419371361624, -0.4290766959733944, -0.6693207582713507, -0.4467978059130045, -0.6560936927916936, 0.042805468504985913, -0.5169001570480558, -0.6386463705858868},
    {0.4717320677910794, -0.4992177126173881, 0.48221751668595964, -0.18622654270580175, -0.47878203154515353, -0.411505604926707, -0.504477036168093, -0.1756342115597947, 0.49672046035465944, -0.3380462162188975, -0.45837090302771544, -0.6068585664893753, 0.5200711615939939, -0.6619043229320399, -0.4896078469939836, -0.5509353099280988, -0.581896242025661, -0.35404148763140353, -0.3914946832502249, -0.4212532643484846, -0.501278479625808, 0.13672753849565206, -0.27829247065996066, 0.32703176805973455, -0.44312695012526954, -0.6590810308820225, -0.4649677537492564, 0.42220447735799, 0.2707062802740105, -0.30027452567851315, -0.5759253604996045, 0.6568351322665926, -0.3136965567636186, 0.44553497169024536, -0.6096150620725346, -0.2580020199328449, -0.6629063811722141, -0.351096882624787, -0.3711174928523857, 0.3731496333410651, -0.23128519052030627, 0.5489863446017366, -0.6149251128348662, 0.3448942472838244, -0.3912840089297594, -0.2767006543437447, -0.31487955340250595, -0.20274564801644712, -0.38224334179336333, -0.3383853996851767, 0.504439547023926, 0.29455376962153, -0.5155548878494036, 0.28696484226618696, 0.4232463701952949, -0.42861496608387145, -0.37548629682523343, -0.3277274930249198, -0.36929326742955126, -0.624526922238184, -0.3595270467748034, 0.42027850672632167, -0.4674966798497724, -0.46119803954524746},
    {0.32303643250703623, -0.41407404836747386, 0.4483986191014969, -0.3814180383556273, -0.5741309176947699, -0.500593684032277, -0.2463548014989019, -0.09500815172944806, 0.5525810441687234, -0.23441677839647865, -0.3705196424970333, -0.5648015997389538, 0.6974576989008399, -0.4118267634231609, -0.27492564939119774, -0.6004378328622996, -0.45363402492340754, -0.36304920769886057, -0.5032590117575871, -0.2503770033636726, -0.4846170816446749, 0.4582497773955929, -0.5578075371913905, 0.7135107532632164, -0.4853063570833675, -0.6372911096415198, -0.22901914769909032, 0.5195833446944259, 0.6139522105716277, -0.5994676338576308, -0.5562999848097137, 0.4436075420593407, -0.24379119861408485, 0.28989571298482864, -0.584998717501619, -0.3770883312466514, -0.4105750363032067, -0.5759698538948024, -0.27852366225033337, 0.69713730674807, -0.3010414422477203, 0.6531664993438677, -0.33616689222921614, 0.3720260435594665, -0.14329596761173444, -0.35844222892590255, -0.30361772188197683, -0.19762242719332657, -0.38805559854152527, -0.33479072217179046, 0.6695603601864158, 0.5428748866472791, -0.481937303217316, 0.47172066795990836, 0.38238770737575556, -0.37679356445636036, -0.2813103828699622, -0.376983284629681, -0.2671396686749635, -0.570830208038545, -0.5318106216008242, 0.43609630513920655, -0.2635581107046732, -0.3003999978488488},
    {0.25956709465848987, -0.5596587198553269, 0.3183505281895687, -0.31467850787866697, -0.42677009969212004, -0.574462855941643, -0.48557240174873717, -0.04678035716122291, 0.5439004211323644, -0.4224035838966989, -0.2968330641602264, -0.5967543066946535, 0.61819849839297, -0.3929070254937114, -0.3141337385594264, -0.6190973846516001, -0.5431893176451538, -0.5764593435521985, -0.4778210711100038, -0.24353163315089377, -0.45760897919582993, 0.3819061622917643, -0.5334598623368856, 0.544310895800355, -0.4308129264861525, -0.3133460317173826, -0.19868381495898577, 0.5204283941225966, 0.30585328757551516, -0.5064447852103254, -0.4877803188444531, 0.6231169674051882, -0.31642834737265507, 0.39086871919613847, -0.5982758783632378, -0.5243972503920121, -0.5722391034692852, -0.42718801946197504, -0.4692761626795732, 0.640871034981696, -0.5332924902032177, 0.4297786606151955, -0.6551637191461631, 0.5799240005395357, -0.011280318873609618, -0.26507634182669143, -0.48988872850942305, -0.3833921553833432, -0.2592373928992788, -0.5369613000518291, 0.39457460397060323, 0.4053125979672559, -0.39759237605873377, 0.2604157367967697, 0.6375453017877598, -0.2992623968655576, -0.2798449158252444, -0.4032739709400518, -0.5377935451690079, -0.5011684547854077, -0.6159271995046538, 0.4958908451369287, -0.31676270479906327, -0.5618296458724752},
    {0.17181384009454473, -0.5766141420160608, 0.4683108915632028, -0.5057703905987492, -0.4612987670550007, -0.6337956063306057, -0.4002315912854573, -0.09850526981956322, 0.5448517047331841, -0.5819324100066717, -0.39636360230844947, -0.4240626775091485, 0.5506682298097059, -0.4335608640039154, -0.25986114084545, -0.4692689712086505, -0.5444031535491166, -0.3280801331932478, -0.598329309738555, -0.32483064275461226, -0.5535408648052239, 0.3486102844891574, -0.4983318784313551, 0.44269803873229985, -0.30083963080070947, -0.6475217972906073, -0.5665992313573301, 0.4408061761149946, 0.5429643339621363, -0.5072334749036012, -0.6464185743103232, 0.37775752441796157, -0.24427861590160546, 0.15878936990395828, -0.6178065459822313, -0.5091592076588717, -0.3741625685510305, -0.5617957180012634, -0.36048197351528566, 0.5757220594938075, -0.33751647466741014, 0.3014247262366562, -0.39524980560236744, 0.5075629938095263, -0.07172942998088452, -0.4901514449621362, -0.45007322204413136, -0.38633016561239336, -0.3522294521715287, -0.3497328216681475, 0.5854223857814334, 0.41413998656824624, -0.39478481537537297, 0.40809742479400657, 0.5457123903069162, -0.4023150781423489, -0.5430027183705215, -0.36570971284475534, -0.5577374316825994, -0.6655109476375719, -0.33962608426435786, 0.2870637863590303, -0.5361178289357521, -0.48494430896936874},
    {0.42906885805347333, -0.6113860974768861, 0.43681172541475083, -0.16689539405849407, -0.3101609144197591, -0.4283543329305004, -0.49294942168511935, -0.23646381065287153, 0.6786605633954196, -0.33515211749690926, -0.5568150610009716, -0.6795041276527655, 0.5872571608602406, -0.6214097384225324, -0.23643691802950137, -0.6679617821017805, -0.43209633335945274, -0.46453301536550046, -0.6120133127853645, -0.23931221998754104, -0.25325097518112727, 0.3043628823335835, -0.634679519614565, 0.694868341106532, -0.4154477236239139, -0.4036502599608291, -0.4596228891469594, 0.3957666861304731, 0.4636659162348019, -0.31271629727531425, -0.47528816834605, 0.32386080217937524, -0.21086183263743039, 0.3806110843610012, -0.5270325086824978, -0.3158645340499503, -0.5283331952887483, -0.565058644956659, -0.5667816344929805, 0.5836172190192912, -0.35165133736098997, 0.4453805300175117, -0.34750750229118177, 0.4664485040437475, -0.3032348048422544, -0.26047206775010173, -0.37221762915273066, -0.328055818703545, -0.4175711384200096, -0.44103681695822355, 0.5199025726507434, 0.5925411494052101, -0.419858517463139, 0.29899213926494894, 0.3213943560429387, -0.20989083671737876, -0.3993267586568679, -0.24908529230597462, -0.3930441966769858, -0.49113013022774854, -0.4855784060089947, 0.23765979004038862, -0.5431578539234007, -0.34736818947840276},
    {0.560509869407604, -0.6455053163913748, 0.5906464466448542, -0.2747293933272825, -0.4782578871537235, -0.5656098758123626, -0.4744019774670249, -0.16380696582138923, 0.6753618553885179, -0.4840133873102797, -0.41094135340413235, -0.3907384130735411, 0.739227275454311, -0.4790092196230098, -0.09898313178937056, -0.6458507932680516, -0.4390932969993919, -0.5573804315168612, -0.43824265540243473, -0.18875197029744276, -0.36622380460213594, 0.5494869135853953, -0.6111901511018091, 0.525931265528682, -0.26917698126893475, -0.583306063224143, -0.23388111199295217, 0.3255218725316339, 0.44590789247664225, -0.5103897909911088, -0.5437622166960009, 0.6266333054592368, -0.1279076763169954, 0.3592485982510993, -0.3585293070597412, -0.5284058054254672, -0.5693130445797687, -0.4469512004807559, -0.5637311209262645, 0.6973269810570016, -0.49735913408710836, 0.6084416506276555, -0.516663415708575, 0.6447283104523763, -0.3196674946238245, -0.20760019666151086, -0.3062621795513012, -0.4033883881554287, -0.43987208316218285, -0.29418976355814397, 0.5091036154237896, 0.5132624823020449, -0.4817849487049802, 0.40520959432259257, 0.7396970343303728, -0.1285666520997467, -0.32858455793164215, -0.3063525766725147, -0.44929341813480955, -0.5114607724120643, -0.43165594044518063, 0.6485656282102541, -0.24521323491375, -0.6251164789861646},
    {0.4372194951758806, -0.25978942575701724, 0.48111864559618595, -0.12697792176522618, -0.3964491674471822, -0.5655180183804394, -0.13061954021640654, -0.084577690034321, 0.6660483014578953, -0.2253628264959899, -0.273985527234359, -0.5552087603246928, 0.7166704438363503, -0.3054051966405626, -0.09295587080497893, -0.5052317808002021, -0.6259383540611574, -0.4196338286858153, -0.2216652351790271, -0.08316750301211975, -0.3780867737993104, 0.5753673581588732, -0.49867703517811307, 0.6547472133851558, -0.4662962384039706, -0.5526639807202434, -0.16154196160847037, 0.5562826406252964, 0.4914500851583321, -0.22801631492549893, -0.39224587095474284, 0.3489242254898878, 0.021239763950926287, 0.6303942882013691, -0.4266309169539208, -0.4350784491702419, -0.35346522416484666, -0.20652048356149358, -0.163721529557336, 0.5082527761473243, -0.2543882016618607, 0.5877237638838434, -0.5448055137466692, 0.5650377802021845, 0.043976259890762294, -0.4673159345548154, -0.1284518289796065, -0.24634204711528057, -0.2523832429758518, -0.28896313800071494, 0.6573194216372841, 0.4856409377562347, -0.30530132005222704, 0.424921635216132, 0.7528086204333823, -0.09405880277349556, -0.3513147654541357, -0.16091181528134693, -0.4878440279345006, -0.45797844015386113, -0.2982863579757131, 0.5223723640461335, -0.49633791419054607, -0.30740376197560243},
    {0.41341749828738317, -0.3373248993042548, 0.5655659570835414, -0.41645880965447746, -0.20362921379961205, -0.4771964176226841, -0.23383766193044653, 0.022977277652167352, 0.42307996266012377, -0.3346883161836253, -0.3338039948378831, -0.6063766105782183, 0.6791610954729542, -0.3463033647646656, -0.21259584587559704, -0.5810996849598314, -0.5063157510419498, -0.3192870490932825, -0.3251510667188248, -0.3801186827243989, -0.35131659062281934, 0.35502669596657005, -0.37733613041514963, 0.6071886293973973, -0.31589579199695084, -0.4110636691119722, -0.37438895433318287, 0.19278800775659022, 0.5077117457573723, -0.5320926485091233, -0.5614613802013201, 0.4311930250695023, -0.0832086814259051, 0.48851471455004913, -0.2978156126188932, -0.29260322724194904, -0.47453850453997504, -0.5609387071503739, -0.21530195680739, 0.40448269663573566, -0.14255138736462072, 0.4270978919781313, -0.39765850448291096, 0.5173644822100116, -0.01204237200557064, -0.30896053309767496, -0.4874189108281202, -0.14643474439769294, -0.5801794590540965, -0.15000991739655464, 0.4447575979202184, 0.6566381409417795, -0.4835647786950923, 0.587458178249223, 0.6232642423884021, -0.4225552850348999, -0.5082348213882176, -0.18990553680919467, -0.5468442366588776, -0.44932920689106676, -0.4344662451432532, 0.573201256908202, -0.26898864782431253, -0.30571925362408},
    {0.24282315437955138, -0.6808467347985256, 0.4331662973791772, -0.2660198871244491, -0.24987794491715618, -0.5088108814599743, -0.27531617387830065, -0.04285310132880216, 0.4815339854878188, -0.6211068538252625, -0.498150104856558, -0.6877883689042499, 0.6373131470755364, -0.5785955317931875, -0.41830655376283415, -0.6712055739909183, -0.4391296331558481, -0.4020621927525857, -0.40659931060013865, -0.3290651958972753, -0.5221410538525061, 0.47093365612421734, -0.29152233817016343, 0.524064624583741, -0.5701196650532988, -0.6085929146192621, -0.4742892387799536, 0.15400256537394613, 0.3304585200109874, -0.4678634523866201, -0.36448776181643505, 0.5568821843014325, -0.4574165801490886, 0.5245616772709263, -0.4085552650667004, -0.5042161435538995, -0.47618803427116746, -0.2699157181870338, -0.6000624749728859, 0.5320343230978871, -0.36609058471033534, 0.5902329305736365, -0.3061769818459332, 0.46914595625979977, -0.3333540458003922, -0.2556687057550253, -0.3102713642449471, -0.1259333388160486, -0.6481319951087158, -0.29025207230163175, 0.535117063089164, 0.5054293778277322, -0.37694079337319525, 0.42639904404682044, 0.4794865198069085, -0.3523919024196689, -0.29456483209724177, -0.29947300497729223, -0.4880871510627427, -0.34395475778263834, -0.30785300048308484, 0.3315499375225102, -0.5554005507740543, -0.45105756676955777},
    {0.2598364791313225, -0.6418962332886657, 0.34529748455208154, -0.4461387307870374, -0.3558025688081434, -0.661731176089206, -0.5335392756139423, 0.015827263725651474, 0.4145653338223568, -0.44898683114193993, -0.5563022009411345, -0.5918832043748631, 0.6171464914330654, -0.4195173422059774, -0.4217573847729902, -0.6372850721316888, -0.4841536091705977, -0.38055573559791617, -0.5341179803604876, -0.15549121153701143, -0.25454583926015456, 0.2365321694444565, -0.2748199854222682, 0.6999329914348296, -0.41678348540187027, -0.48017227758551434, -0.17941971856317052, 0.3364514518203344, 0.5278450612511738, -0.3774800055542644, -0.38855603860107596, 0.38874862157931606, -0.15890544486527225, 0.41144779863302133, -0.6055336687812228, -0.5938640394395575, -0.3055962822748897, -0.2919134919811671, -0.4607197361718966, 0.6462522562959595, -0.24182492437343087, 0.5765257643109745, -0.2910253282249426, 0.3903546697172693, -0.278276655110404, -0.4300726309072455, -0.28685178576525233, -0.3360164318150873, -0.3189798398584345, -0.2444061950763228, 0.5655804772387035, 0.4287914082859574, -0.4597623016497665, 0.3531473241819464, 0.5793497253083763, -0.4266949799948305, -0.2960493881644959, -0.48253436530124544, -0.34946816076426795, -0.362164260491779, -0.6121962829941491, 0.5810784646178736, -0.3132529283353423, -0.4618772997425305},
    {0.493055895405205, -0.629193794934572, 0.5694153743185987, -0.313224449483278, -0.2792205176539977, -0.496553936866836, -0.22735736752764557, 0.034463428372244996, 0.6225236104283687, -0.5165904299255356, -0.5442325499599828, -0.3384761489934931, 0.5984267145789898, -0.3384538261695911, -0.37109798798338006, -0.37517904445731887, -0.5093147446149631, -0.3314479904543905, -0.40434030305850244, -0.39237174461780133, -0.2798974741402672, 0.49029110598168507, -0.2910703320309249, 0.4432436623783908, -0.5903640957995644, -0.5646556012265982, -0.20096201747938625, 0.28683149159794874, 0.44603305215951095, -0.4522252625906919, -0.36308153691522543, 0.6469979901553742, -0.3648033129120702, 0.5103564891773318, -0.5152423115613645, -0.43132154141002876, -0.5854893179804387, -0.5406882880588432, -0.3604459724595456, 0.737177185922666, -0.3864439984178668, 0.36213956174254336, -0.28077163914892156, 0.5285043494792087, -0.40738604164857695, -0.5017340798092028, -0.4474075754269758, -0.35184196826695713, -0.30506943095190486, -0.439940933942114, 0.6825701345238329, 0.4983021420011136, -0.6176214033247854, 0.6272130035489742, 0.5749865004271645, -0.22560355286633893, -0.33889185596284116, -0.31547975188598565, -0.24110333166403253, -0.4983856495637142, -0.47958347846796895, 0.4625216029440866, -0.5442592490398804, -0.36670966324980436},
    {0.5204964816146236, -0.44382889682408605, 0.6093269619091682, -0.22923181362744707, -0.48906120842490125, -0.36621776761197433, -0.34849664473361636, -0.21933065233574814, 0.6603585336343939, -0.46359475002390227, -0.5167621938729503, -0.3848713587008599, 0.3523024816785836, -0.44027349302945423, -0.24579454846744386, -0.4423412488354744, -0.6213019189638784, -0.6195975363560277, -0.5061028721238796, -0.38199662403095186, -0.4022711427418451, 0.5826542270036109, -0.2929814584158424, 0.5219726204477974, -0.4559391969184355, -0.38824470294257, -0.5017874138308707, 0.48122116613161725, 0.4950973811886094, -0.5354660665878892, -0.28952365787866485, 0.44890001707561433, -0.41644702846919357, 0.5227630833308143, -0.5716261231664347, -0.2916604495501445, -0.5263342499726194, -0.40012038710973225, -0.37949641414093993, 0.6467917222476496, -0.2275718315459567, 0.6272673345622849, -0.3007769044329621, 0.6257530748146856, -0.07606549863954956, -0.45827655308919246, -0.21356710998034886, -0.10259186235099324, -0.49782217092718406, -0.3833188335998805, 0.3610719206249582, 0.5208556486228487, -0.5623905050339628, 0.2837479251601711, 0.5269915037066543, -0.4694762246878265, -0.5611647825506263, -0.5091350162808633, -0.500024770595861, -0.3165597548372509, -0.559882625763747, 0.6045796127643187, -0.5942077714327771, -0.4659817196574653},
    {0.6125523431719295, -0.41458826417703676, 0.2755621321251005, -0.31071217207416635, -0.46343895543364594, -0.39911358152338106, -0.3237605115283259, 0.1074151455260791, 0.3735396782830106, -0.4002150675102363, -0.5627232361506841, -0.6755005028926444, 0.4027235783106595, -0.5852982863513233, -0.2190389275800846, -0.6571976784797776, -0.6368619973634339, -0.34837608843369033, -0.41102468103364703, -0.40657380960702644, -0.347819314437795, 0.4565772283170301, -0.45292044979554147, 0.4452457290746365, -0.4454313994722884, -0.4229181966708257, -0.3412973773193728, 0.35676933001584643, 0.32515178605460265, -0.5889608593737251, -0.4693767462541914, 0.4741615728137063, -0.3946914553239863, 0.515013908928401, -0.38899503028624405, -0.4241674946288542, -0.5878179279774076, -0.433679749707125, -0.4876559945770745, 0.5810196535260175, -0.4334003280575343, 0.5738611445902553, -0.5523618037230318, 0.6720037467577361, -0.25279588333816394, -0.20692798076781865, -0.37724349580128624, -0.11034921313331132, -0.5486171199527737, -0.36796912872521176, 0.6079943144598996, 0.6602761098659478, -0.5931761219754568, 0.42649888514844897, 0.40392945744586206, -0.48733956986532595, -0.5286125366369139, -0.20834173799127445, -0.3380058553173892, -0.3715606191980808, -0.36607967959231386, 0.6043064143066934, -0.36217828965986054, -0.36207049717127004},
    {0.5751088919739459, -0.6327945317581631, 0.5490420009128659, -0.34937534235636974, -0.43535303015263055, -0.54500895399747, -0.25513336367489475, 0.14306664384347959, 0.59999853667832, -0.20088724035310057, -0.3663540496531667, -0.4058666559462776, 0.5524412807088072, -0.3744526473234011, -0.2514402025866901, -0.5333568428131575, -0.5273863448656108, -0.4632358462593207, -0.5514025282932914, -0.5223080664826668, -0.3093211360853098, 0.4455715790466425, -0.5442555762763157, 0.5241091021481269, -0.4641587900001507, -0.6605781386018448, -0.20931662649818608, 0.34648364270862636, 0.453564846001258, -0.4192954992876386, -0.5254142300225728, 0.524316478260555, -0.14816828999392265, 0.29853996686579537, -0.5738111366117371, -0.512401380366888, -0.5742702559836301, -0.4058344450308802, -0.44815119854510643, 0.4411533860736658, -0.40580698711364155, 0.6563956967052629, -0.32718083757399646, 0.4232409293540774, -0.29482167416877747, -0.2671995242630804, -0.265303069012263, -0.34035413670330394, -0.2902453889973937, -0.27262887024919946, 0.3624029447912459, 0.5091084323533392, -0.38066910950425964, 0.45132897795270444, 0.6729395632962464, -0.4366848645503807, -0.39706213587783107, -0.2929877551117201, -0.23437589717879545, -0.5042787506314181, -0.6092164586316318, 0.35648760500928406, -0.37983147719875465, -0.44130035539282253},
    {-0.15198991485793448, -0.2438919476063089, -0.442333429891421, 0.03729708760461042, 0.16890944308263348, 0.01620443645389578, 0.06082594753257081, 0.13063823998584861, -0.20895737318844645, 0.020482242593660792, -0.012448981636998601, 0.1413435266360416, 0.23657640207645494, -0.09086973938391217, -0.41927705445264035, -0.30902823024957665, -0.1748128083559645, 0.18776759372405974, 0.06844783344300034, 0.08292862927371569, -0.2583902222332093, -0.4969552155847669, -0.14763145166542116, -0.2628013058996429, -0.1378489134567147, -0.13096132014406262, -0.12152621784937181, 0.3633739509455333, -0.10961316954941684, -0.49809907804646814, -0.1316956962461737, -0.09017266879124106, -0.08628574040230887, -0.24671447860803475, 0.13726838817354423, -0.4019658210465309, 0.03520259016710987, 0.2587356404540385, -0.4273205994378398, 0.0712134472184302, -0.1279002467635345, -0.14189799793345023, -0.29370492931860853, 0.035166614481281756, -0.19708179603407502, -0.3089182074367697, -0.05672017535420723, -0.5149150902649942, -0.27100835568356446, -0.3147340101124515, 0.169993726054338, 0.035772140994784575, -0.031818345083013705, -0.4213905257742583, -0.23287381414145011, -0.3586049694903398, -0.3549169020010829, -0.2832512522582345, -0.14855325829092986, -0.21503084426397567, 0.07700514678820969, 0.14485642929283607, -0.4599238928163571, -0.0612543900052249},
    {-0.2313601861220428, -0.5625937014940027, 0.0741583039918923, -0.04058828850577978, -0.1470028625015681, -0.4617693637214578, -0.08204257962889147, -0.4243865247842233, -0.151286032118347, -0.34263516308651554, -0.15278225677396953, -0.27940864780056374, 0.14206915133794082, -0.47045810824759016, -0.23511417886842226, -0.5990117310326326, -0.6210340703423838, -0.30837846994651297, -0.3405311496053613, -0.4697545975524722, -0.40275167108626064, 0.26079044793017125, -0.2518107476370017, 0.14189233050468553, -0.4882181514704751, -0.45223240253766755, -0.32318238279027506, -0.13679295324700455, 0.371183361895639, -0.43211855935686283, -0.2050555264180943, 0.3346214515203475, -0.16688207257332405, -0.04727468708796855, -0.33360123566957534, -0.3069354367750692, -0.2514419787475863, -0.06073817307276717, -0.5578996846468884, 0.10459422585734392, -0.3254483387169858, -0.22874655296921995, -0.2554953558586136, 0.301959127498928, -0.04788320686553746, -0.5893941477926611, -0.4536834800829645, -0.3983620367605657, -0.5342896314970502, -0.5147876050163235, -0.005626889172907538, 0.22471312334635815, -0.5057537201462671, -0.12984132808326437, 0.28610029115032315, -0.23900295253331338, -0.5374720272098462, -0.339410807852868, -0.12371251393278715, -0.5078375656306314, -0.2222933213465697, 0.027306658549473478, -0.3494883477624603, -0.45615730819791567},
    {-0.14457181154417267, -0.39826314019649817, -0.46228602322682655, -0.5558601167118373, -0.2839568815806846, -0.3157598719099836, -0.23778400788713613, -0.31226518477244125, -0.19625955349299318, -0.16590037110289554, -0.3978542736513239, -0.27299857321626336, -0.2407758841446492, -0.28234704379155745, -0.0867745458127331, -0.18141461766699338, -0.32788206046751006, 0.049644521659559626, -0.5213714066050044, -0.28476965454845554, -0.5846857512614788, -0.251310668550376, -0.4258906041050135, -0.0800560437557649, -0.3263475641458483, -0.19202532964924163, -0.21215582200684993, 0.021602715256963924, -0.11880864280392045, -0.47950785920613376, -0.47083559067235736, 0.04111236021333411, -0.09968879147206006, 0.12656455084649573, -0.30046015817643207, -0.3329431230551527, -0.1853149841694732, -0.32839759805825086, -0.11237164013983215, -0.3216443942915961, -0.31569957136800436, -0.11279355355539593, -0.2494714970109914, -0.1267263743159309, 0.1677091703611149, -0.25258335394852055, -0.4923370610676023, -0.452746626587617, -0.23532446498767956, -0.22867765252222932, 0.023605628217977816, 0.02583861676772563, -0.43356124129592416, -0.26400134093000616, -0.25958508674146963, -0.07278073675331331, -0.2852208900431579, -0.30921793431894207, -0.2468475134202621, -0.08481163022018916, -0.14912372202400317, -0.05596045923381011, -0.11051594543118731, -0.1714866915900202},
    {-0.23516362489243225, 0.03342908962150717, -0.45530520211654996, -0.128625142092048, -0.22192272178082975, -0.03258900834376185, -0.26683972627794, -0.48447644726308964, -0.1079105442266369, -0.15289679079722002, -0.4675409292331365, -0.39493816666155085, -0.182413604578852, -0.15887867632745456, -0.4050554575166536, -0.27398393073422106, -0.29346049078718145, -0.13780034453714413, -0.3624510064664342, -0.3229754394577816, -0.455892307330605, -0.0370390971538293, -0.26801205079809115, -0.1659626377310691, -0.4382319254261664, -0.3598505214636923, -0.22734433095895334, -0.28283637311067006, -0.23204359058490798, -0.31170767278357114, -0.1057246341636502, -0.03830241773257777, 0.12806948526175768, -0.05454921440635101, -0.184482655159202, -0.4431878647448318, -0.31995745265825104, -0.41370577942017195, 0.040502221324104304, -0.03124846171703964, -0.17710348038459017, -0.03955007394129249, -0.16504618157093146, -0.0894228366776378, 0.05657761184361158, -0.058095489257158954, -0.4211198018597955, -0.1442436723128911, -0.1661461188755504, -0.11749502407327224, -0.3223281218272836, -0.1261799947770491, -0.10799265258973875, -0.01637305610178548, -0.21210268106216304, -0.31498155059332483, -0.5004296939767225, -0.2504171634206126, -0.3508628068003679, 0.015883668010743424, -0.21379485425658254, -0.3820959132454611, -0.16868358639854486, -0.41658379659602596},
    {-0.36734052043269455, -0.5257746716958636, 0.030376006989113975, -0.25492615622517223, -0.20273041406941142, -0.39110727338561546, -0.22706437395307247, -0.4392281982641035, -0.10939922920357988, -0.3383240832203016, -0.3802195499551154, -0.24652718688936653, 0.17309747835473174, -0.1328597114997681, -0.10693568228526129, -0.4438447515484096, -0.21301024964193183, -0.3891259607353236, -0.24808402262832147, -0.3004632576312758, -0.4661665974672139, -0.14152534001502742, -0.44267080375268497, -0.09698673676292839, -0.4979298511392099, -0.5339182646452126, -0.12102762909100429, -0.001483693763719064, 0.025006910644539204, -0.2661132843936189, -0.2829285034867389, 0.12235678455100671, 0.08243570668720782, 0.0641594956367955, -0.4435866383206138, -0.5136547000897308, -0.23173727344353495, -0.4031631087633534, -0.369111657516571, 0.26200353178074015, -0.3490557216022175, -0.187445509302275, -0.2106394637086621, -0.09460792401059628, 0.12561725496551102, -0.16779406485993306, -0.4811189994557789, -0.41028571831798455, -0.5096805784143895, -0.4890100483729275, 0.04784588603262534, 0.23076203720161761, -0.21161793837594495, 0.01785606829835688, -0.09839294136335044, -0.18301698879699, -0.4665186458675685, -0.5300020115955556, -0.5574598426102854, -0.4963182848710301, -0.18016282272621387, -0.2546561920933815, -0.37769145279202787, -0.23585648677386642},
    {-0.4299280520832086, -0.2534558127872941, -0.36858515808345055, -0.46817718907102274, -0.17318827499658873, -0.41597024572752006, -0.4948327453790408, -0.3806803821593811, -0.03193645073496246, -0.5402083950953375, -0.24312287917899403, -0.3922514984407637, 0.03400855610430068, -0.290458442777166, -0.06100281207277886, -0.4333483838152379, -0.5823354484299594, -0.1793460716721306, -0.5744123591687521, -0.3509934733629709, -0.46184874223826905, -0.36426912689937935, -0.47033965884694356, 0.08814083189516873, -0.5938441028232998, -0.5493028385791269, -0.2599873535869942, -0.07049218456677851, -0.09477194490862577, -0.2509555315604736, -0.37132966143064866, 0.07238297822633791, 0.07770762195060463, 0.03201387611725923, -0.5701958615377595, -0.5410643594177071, -0.30584032484994267, -0.2884988121256951, -0.43488592229673745, -0.13788910859713477, -0.28317830146857537, -0.15024689662134502, -0.2752049263610834, 0.2679574935256781, -0.16052496667545615, -0.36872328819346, -0.4588233494841427, -0.5721939979956697, -0.4474443131878149, -0.42749730832110383, -0.020533425106287907, 0.08732251959482878, -0.6300278542673899, 0.00934461286510866, -0.2854131819436298, -0.46346068761630194, -0.5347428799832095, -0.4263385053388219, -0.45451338084684373, -0.3662693119830886, -0.46080036551029724, -0.17098862004657855, -0.3204683832341835, -0.5413452595236159},
    {-0.09019671810099515, -0.3638075547234679, -0.0604042102743307, -0.460866961488255, -0.24254745921825516, -0.3450361785109569, -0.48242253356722464, -0.4422764315508312, -0.3921215795042139, -0.4397266091587535, -0.5711891791811678, -0.5449164568018457, -0.3162492756715959, -0.18948480687759364, -0.16837011683084793, -0.2170666009388774, -0.5395194944605977, -0.5055459942101934, -0.398087324070107, -0.3089877840229235, -0.25646989234015766, -0.13411231893524583, -0.5922808973493542, -0.13224866206925942, -0.3035261480783627, -0.5017896374982215, -0.5585312594413661, -0.10005466409461915, -0.10295500787828085, -0.6360785063158512, -0.5661529322839992, 0.1258173844722318, -0.3191713892636302, -0.32596506006012194, -0.45133528915423393, -0.36709007126428306, -0.31333423043397163, -0.5774536928132648, -0.4751010167976214, -0.011576539241558369, -0.4300036307611604, -0.1172254002176189, -0.6321065404299898, -0.052970177522116586, -0.22903551334966765, -0.6007643198900535, -0.4332637226381761, -0.5443091522390804, -0.5941659632181187, -0.5359300119835525, -0.2008690771512792, 0.23297272567254437, -0.3268372975596555, -0.225717429841774, 0.063508858499085, -0.2193004415130597, -0.41622744735129164, -0.5066461212961073, -0.2423716649457392, -0.32186462763683976, -0.5184362821615002, -0.4208103007998496, -0.3653899008455356, -0.35728040053356597},
    {-0.2833370775878045, -0.2150285426939503, -0.10240092321916384, -0.5884533996200151, -0.4590175438733972, -0.34926022776408566, -0.25294068803361636, -0.28729218361948794, -0.3149414129369048, -0.5230792931821611, -0.26563218410005895, -0.40507854235233803, -0.047924945798323716, -0.18437370027257935, -0.19332065278740954, -0.3171930748616498, -0.2836545667747248, -0.47506354840183285, -0.23821346394409199, -0.17753904572818174, -0.42924680698116047, -0.05999172937215051, -0.21716738201282487, 0.13195661360261238, -0.2527843884402217, -0.45507992732956926, -0.43140673440096255, -0.04791348409922318, -0.055710715602486804, -0.4079451707785413, -0.18970342693745737, 0.1907474896236221, -0.24062119065139684, 0.18390025722593478, -0.38504708741401544, -0.6147904883510303, -0.35846488220422623, -0.30362995796325126, -0.2544198456643311, -0.07789531280259746, -0.5930255043507934, -0.23159942849993032, -0.5082490036761067, 0.16242327251930297, -0.013132878474158687, -0.35088093659167896, -0.5562329178000001, -0.6308144510064279, -0.504128632729172, -0.47901084096994484, -0.2275045619980037, 0.009568122424497803, -0.3228560991535748, -0.22484351806849662, 0.06890096381446505, -0.05798734228348659, -0.5019521791466041, -0.4029846837007324, -0.5208803573681282, -0.36300082977357884, -0.3426004115119115, 0.0507646570680486, -0.40366615245553616, -0.3324990291012597},
    {-0.02543739849583076, -0.2047643637123059, -0.42422492659873884, -0.5960753607353751, -0.4234033045179624, -0.5987428433822526, -0.13515224504659426, -0.1933450614438216, -0.004238107650150444, -0.4431950278840432, -0.5198623803705369, -0.23116891740845416, -0.19899475866845792, -0.3809203188242398, -0.3438887950840445, -0.1584273784252539, -0.29954278192968314, -0.4055348216085626, -0.5645941402561403, -0.2646034219135641, -0.6071009164210142, -0.28895935998139544, -0.2524465189969201, 0.15875901646880242, -0.2524101471507347, -0.5166166028611011, -0.25261281131476143, -0.10012360747647592, -0.1596488091977624, -0.38535039309391517, -0.4250570932291248, 0.3942655987942914, -0.03341064825396018, 0.15599378396396993, -0.2736662796661634, -0.399317378011444, -0.5027450570915966, -0.37265699757578996, -0.3675608544916453, -0.1406157706586322, -0.3155886869047261, -0.14331240706607362, -0.4439452840595139, -0.035662521858140415, -0.13800953629915824, -0.4312428859947047, -0.5167741966697968, -0.5059797654924942, -0.3305365105228822, -0.47223993235980705, -0.20375322679751542, -0.17265429399770932, -0.2917972277998041, 0.0665485237116987, -0.1284103391556667, -0.24407457824114306, -0.6288128573335061, -0.6150544492070766, -0.3330745678475419, -0.46560392209586715, -0.3718902625656954, -0.21192467733107656, -0.4413319972789426, -0.5382235738077082},
    {-0.32945163685312356, -0.494068527982038, -0.30527970490654643, -0.5778582100771458, -0.28430921591777775, -0.36096940245300047, -0.2964303198281382, -0.4648173840645931, -0.18527991791242873, -0.3493002365754096, -0.3896606043830923, -0.5835550699011668, -0.04212490166197958, -0.29910502799150734, -0.46839140966844683, -0.32491041997330483, -0.5910884116845365, -0.26649675769999553, -0.5711454370692611, -0.47908243563351033, -0.3317406846859527, -0.408883064437297, -0.6041513541310946, 0.16809382692643027, -0.6527492676762652, -0.5328477053450109, -0.39865147295479597, 0.2206850550071481, 0.12708824232991264, -0.3510963823633783, -0.3265372934646478, 0.35979695352242036, 0.08035086596889868, 0.15666571469842835, -0.5986707442793934, -0.48976320765626946, -0.6095666961082292, -0.38250411091764064, -0.49861513615648184, -0.0699868249559359, -0.30270071129802817, 0.050174354144809884, -0.521104107052366, 0.17741711388599754, -0.23049645726689905, -0.5713694654839235, -0.2622703162784442, -0.6201770048079414, -0.4220339121960702, -0.4876850693292501, 0.11679282648853709, -0.007638052222972973, -0.5941775883737558, 0.04204986208266451, 0.049331883790136345, -0.35908254226272024, -0.43820209748392885, -0.4971162684804868, -0.5488808403661686, -0.23135049407581998, -0.3869259566080632, -0.2772519582692044, -0.48023085854766684, -0.5350646265262767},
    {-0.09691279008216834, -0.1968328887097669, -0.32124168551949017, -0.2142056095775053, -0.30382826655172457, -0.18203094815721618, -0.15397536663048692, -0.1404801482523717, -0.04743908179639506, -0.521551941764718, -0.48397866156091246, -0.48113125121822925, -0.19088628089506304, -0.055021042461069154, -0.08673893833000038, -0.17793118498660054, -0.37437952326803003, -0.10664693118530025, -0.1673413015674002, -0.48343748697120353, -0.530222814451167, -0.2269778525432467, -0.21132540796363378, -0.042260296332310675, -0.4447938391785649, -0.49378967038587074, -0.1639581275292024, 0.05418648673505061, 0.22789262767171703, -0.42127681543679985, -0.24857646358485685, -0.10602459589989785, -0.2249063390930042, 0.03858922606189918, -0.29573538995151943, -0.2973076048364347, -0.3169017230035801, -0.40987743800737136, -0.22462488542701842, -0.13925026608115781, -0.547903234085277, -0.07506230894044504, -0.2142665411861617, -0.18460509827058663, -0.27284261335059606, -0.2545038367304285, -0.2107004165404561, -0.5995274023715951, -0.5489331698268056, -0.5796812270479558, -0.2603515486975417, 0.08742335575489721, -0.2907889890993368, 0.14841508760630504, -0.2283666648986082, -0.41198483754707593, -0.6133686001027834, -0.4772116335860555, -0.23912252860416364, -0.37994733116501045, -0.48788305541191157, -0.2579115137651124, -0.17417285047720799, -0.1634666652742941},
    {-0.3915804465624482, -0.3782259475700323, -0.22539978182060522, -0.25770927947121325, -0.2721449589415221, -0.217066107884585, -0.28744644960342863, -0.2883128521572443, -0.14422304429583457, -0.6262832301313955, -0.461443329179932, -0.27487333664834684, -0.08824835626943092, -0.23218609673650573, -0.4514302502859899, -0.3159174663395454, -0.4324355067772725, -0.34554020616940434, -0.48727539571475315, -0.5615548070221892, -0.5245141632147129, -0.3409618256542681, -0.4080848323354897, 0.0029057082633848386, -0.5185699242770189, -0.5186302872177193, -0.3080324270911677, -0.001465067268727867, -0.04697493969267302, -0.4118759548148032, -0.3923970001982474, 0.14088699078421615, 0.11599207431509585, 0.07390016542535147, -0.576910584375229, -0.6640912485460142, -0.5928314771103808, -0.3081757028800153, -0.5930510386386658, -0.06038145063149068, -0.4813846399857653, 0.09466187438954976, -0.3519286455535849, -0.11313834707745038, -0.15961505470312118, -0.4193598193687652, -0.6251056300763312, -0.6531906357138417, -0.47430243495531543, -0.5888793012326191, -0.16903202868329353, -0.03162076849697321, -0.3708061859089966, -0.056475917556818044, -0.29378957673921824, -0.2321455067501628, -0.6382388800127398, -0.39718049882779394, -0.25598488950161014, -0.5356645090824669, -0.4247429080997409, -0.2523981861583764, -0.48053664589682127, -0.5715421297498586},
    {-0.36808917194107654, -0.5222159020014681, -0.13263330212606345, -0.6865753486224366, -0.4288075542042301, -0.5499116691948953, -0.5925344641694211, -0.45797461972987963, -0.2385807834146966, -0.5264950428313012, -0.49035794149306017, -0.4162894243787174, 0.11632699211789238, -0.5381929329665195, -0.39451900434361853, -0.3398217551958625, -0.4197443606950851, -0.29312344967278453, -0.4834130396257322, -0.34883902413818346, -0.5936980551783878, -0.42667407212447034, -0.4517278663496892, -0.12099004158241805, -0.39413006388681016, -0.6613202697491294, -0.24423943044107918, -0.0010964157259099904, 0.1291388479688134, -0.5950615385052865, -0.55212932142499, 0.06863809640584922, -0.3288048761514128, -0.13148463549559852, -0.2966840759614298, -0.6248302322992301, -0.4427701436928892, -0.31671106023733614, -0.3150868682084446, -0.016249909406153323, -0.3387346199366057, -0.05452946852999776, -0.4792021559405724, -0.14686148587110803, -0.2925792653499966, -0.3132758071410501, -0.6727496872364405, -0.610033783695226, -0.4658003083762431, -0.47949403114268696, -0.014800618133207055, -0.18386819198130952, -0.4836690489819615, -0.15142739890975013, -0.08126012136120904, -0.34414961478210854, -0.3705836957420887, -0.3643735396081206, -0.5550765061223071, -0.3612593097639243, -0.37351762158501, -0.08062021134334173, -0.42024818993031615, -0.5370262924535579},
    {-0.15742122843618075, -0.6250287171143326, -0.4347070182428046, -0.4621312311946675, -0.544191695154184, -0.32637903528848716, -0.45397299448281997, -0.22879330800447725, -0.45389463001745406, -0.5252558964080787, -0.6373933717183107, -0.6118849271989836, -0.0299361150245123, -0.21405912247251602, -0.5321417776349421, -0.2832025530985965, -0.39207253113599333, -0.15768001997048103, -0.6394000783095194, -0.6387984234104653, -0.6642625530373343, -0.5678755711171191, -0.32322288199548826, -0.13306674246657943, -0.6370144581643837, -0.3248508771217378, -0.3244803302171514, 0.13557567836739068, 0.0790454574803469, -0.47017702225133895, -0.46907360744392096, 0.10566658252635973, -0.2825604520827632, -0.13345800069663052, -0.54137227838891, -0.629293711079062, -0.6697471816934434, -0.5537972892528751, -0.5232994502899813, 0.015103019514547969, -0.5208297739744961, -0.21302012652302846, -0.6437817861209257, -0.023295358346784804, -0.1831483633243245, -0.28821604917623533, -0.49638338456392644, -0.4463564161885261, -0.6301672108437658, -0.39512958357477496, -0.031119488815103465, 0.029679840945268286, -0.4570151085786701, -0.3077610352042568, -0.3516586977407375, -0.33377698633306646, -0.4221312689678976, -0.34040786244296195, -0.37925283875116916, -0.2619364764925214, -0.6197566759506186, -0.1857516893122834, -0.27043704799704676, -0.5473004935349953},
    {-0.1490415721440162, -0.3400343063457004, -0.3978057647882634, -0.33976254748681384, -0.3727263330277174, -0.35335602019693585, -0.26503052037044195, -0.43681863009911664, -0.20590530222926517, -0.42500350864065906, -0.625692416476841, -0.44723341877058137, -0.13689152331168444, -0.4407970190234546, -0.41533819923407916, -0.48336222402250206, -0.25280842816986543, -0.2088348912258317, -0.31079173076102373, -0.5840307521491812, -0.45592960863072485, -0.414115098900008, -0.4252885765424669, -0.21475224546062405, -0.4490069275269665, -0.508348610513687, -0.5735320879309903, 0.015081806341771475, -0.040512107942254245, -0.663351304744118, -0.2567588046431748, 0.23064096630825973, -0.16122596704451006, -0.19770096327099482, -0.45270389174179115, -0.3618570137697789, -0.5983817183326158, -0.4974914213201399, -0.4666170779414169, 0.048929693850674194, -0.4760127057287387, -0.00034306451436852327, -0.4457434458789802, 0.1657433625675433, -0.16881313176996998, -0.48828637446007794, -0.39481643519353177, -0.6608230805003023, -0.5707353664099508, -0.5400751870952832, -0.0658655215133484, 0.010107538697934348, -0.6970075723780778, -0.3151064347615512, -0.1384440074591329, -0.23452834289076674, -0.6284319527516726, -0.4278259406816663, -0.29896247389018066, -0.27391489692084287, -0.4603476482461204, -0.1121605440997034, -0.49141978885593857, -0.3634876804352163},
    {-0.457184744025143, -0.314359144690832, -0.3123462843101149, -0.5488812026691929, -0.4871579346249963, -0.4847287318820486, -0.28280028797020823, -0.5524561345139198, -0.22860402684032105, -0.5405090843507805, -0.44290650578484825, -0.4766179297129501, 0.014523931838674148, -0.28088092651026864, -0.4177070830626199, -0.34533694245761254, -0.2090301827124638, -0.3820257978947854, -0.5372985340076452, -0.439967620374979, -0.5552396817845988, -0.35001215983128187, -0.36406408905218296, -0.008368690254801506, -0.6653567797895704, -0.33408024929453256, -0.4796821739673761, 0.15435428336145737, 0.0760288160026926, -0.41219894726056694, -0.5553102803245723, 0.16547919358865243, -0.2886439647385259, 0.13046214881392992, -0.32041296085023513, -0.41246681207322516, -0.44496942965444103, -0.538124565086588, -0.23424271983680248, -0.323338996001489, -0.47791753320942754, -0.0394437933115141, -0.6084627136253045, 0.03173792001538855, -0.18678764656506933, -0.3161014879535171, -0.4054548645585526, -0.3433742798328561, -0.2938864114964689, -0.6363230782894168, -0.0002154541805666774, -0.13326708903249104, -0.5279634350665859, -0.2529827884792235, -0.11120558689151824, -0.14888402136126652, -0.47193394409610784, -0.6062756192676892, -0.4604733245403863, -0.3656277526646344, -0.46498419097983157, -0.28881621963148435, -0.48024798153493037, -0.41040156599398275},
    {-0.3732970832546456, -0.4527285199022036, -0.4539247530780394, -0.3755783664213556, -0.5700165514813813, -0.3844625368717261, -0.5118869537615157, -0.3851854869877285, -0.26940018559022977, -0.37914302984735093, -0.23468066484983352, -0.6036185177716745, 0.15208167030025924, -0.5147560668488349, -0.37388599260848293, -0.5018338947619186, -0.36412038023663795, -0.18650502580595107, -0.33567355283803374, -0.42102244327108623, -0.5707807773028049, -0.3991291313678242, -0.28682511170611924, -0.048398558331894055, -0.3921275152710154, -0.40045718646357964, -0.3184767924121335, 0.07015925339495757, 0.14681916763118014, -0.3429187040892143, -0.25965549930271653, 0.2435099468671839, -0.2866408050373292, 0.0908300700341157, -0.4116802572167288, -0.520507994133166, -0.5942821547439435, -0.44138336455686933, -0.5311030869406818, 0.07297872140791561, -0.4715673807852366, -0.23418027911136982, -0.46627816482717316, 0.18916793378602256, -0.1235341297392885, -0.5821015785030905, -0.3230784967692195, -0.46211276457642575, -0.3350419673292336, -0.5377274805807668, 0.0321696020018332, -0.027286683094747615, -0.54954834739324, -0.345828964074821, -0.03764666868282587, -0.31513353861042737, -0.37972835129564264, -0.4974468366077256, -0.323425860203337, -0.5282889465680721, -0.34588640034567253, -0.24647841272141502, -0.33047273217568074, -0.3284516904110119},
    {-0.3814570496440552, -0.2192471378572218, -0.20863783169456587, -0.5490371057246607, -0.42722475973576357, -0.40284962336820695, -0.48616435174514033, -0.439677953532116, -0.3921420729840226, -0.3856228904419077, -0.25676741886975396, -0.35246173942235615, 0.21094001266378215, -0.225822731881127, -0.5240473483224509, -0.27599130743003, -0.35666672534951205, -0.22949699025812265, -0.28383357640899565, -0.41660061368260903, -0.32844198833639654, -0.3566290474917225, -0.47219666952474953, 0.018563834600609064, -0.3855014497962556, -0.545743350703149, -0.33122044760933844, 0.13471722268075997, 0.15489010540623024, -0.5479750639945372, -0.4441406836734937, 0.1901480905764163, -0.21939099301574508, 0.2597934030397804, -0.39581633107387015, -0.2795561895303229, -0.4739435540010436, -0.2847407998513423, -0.4766286460091421, -0.023560069094721185, -0.6072552023127044, -0.3192003954722863, -0.36176160389706963, 0.25177507497916984, 0.15568755783210173, -0.5353093472417694, -0.32652471609969513, -0.6009306280256317, -0.1371817425434409, -0.44136781587942525, -0.051664346773362554, -0.24784612186881275, -0.3939729669378144, 0.03278672795780682, 0.03566935983681198, -0.22829164836856722, -0.3771132706137577, -0.4174371773769316, -0.34031873935094215, -0.41330321266090186, -0.5105706117577391, -0.01277693444617983, -0.3309486489445624, -0.44790836165807324},
    {-0.2858305421115475, -0.3828434340599075, -0.16579946196026604, -0.5688673517177457, -0.4913586122620675, -0.33457840246754994, -0.2455664586952283, -0.31786006120642746, -0.35508327303432313, -0.25674052847210377, -0.4381690333957529, -0.5312749801116755, 0.09092581899612394, -0.38205821620684616, -0.20311384007244074, -0.4702688097634052, -0.19754836053703834, -0.07375104870132033, -0.33323741616100894, -0.220351905346874, -0.6377809195158819, -0.16774819183357415, -0.29364941079356394, -0.20890235453731376, -0.5421171170109061, -0.32818005450966464, -0.4220775555256755, -0.08568349562727441, 0.04097028822525077, -0.6506350878570468, -0.2667375771268613, 0.10044116579850793, -0.23666737867072368, 0.013023365837445927, -0.29181554965094075, -0.3707236868973752, -0.5826320391885669, -0.393192809317023, -0.22541203909360188, -0.026467420964164184, -0.38540112454079073, -0.057184857683428146, -0.3967610827601259, -0.20136417450200575, -0.17586813501914025, -0.30991931653422183, -0.29396546359914405, -0.39914413704145757, -0.40135566559611296, -0.36282712544710594, 0.017404399473101337, -0.1734569013676635, -0.4258038958060132, -0.28737482649478857, -0.061703206413764033, -0.33089946762120276, -0.5635389551328673, -0.49439239506941757, -0.4833557422840695, -0.49594047670262575, -0.24481787385935572, -0.20958316975428612, -0.5332604223885368, -0.511320515429201},
    {-0.3353191141212479, -0.4168637401869908, -0.5776699810336194, -0.6882397572584572, -0.4275595104696984, -0.5217103708350694, -0.3282705474057478, -0.30359827238817794, -0.30242104226827377, -0.38047989123902515, -0.4479570311883035, -0.6433850316209423, -0.23856900765573624, -0.40318062361048074, -0.539087944295286, -0.22805548761344638, -0.3126708632631785, -0.26664961797358033, -0.49915636576613376, -0.374432016573462, -0.6201863979559405, -0.5095668761803951, -0.4113826396344027, -0.11139598875280116, -0.47075661608850927, -0.2704731658577667, -0.46480740133480225, 0.05438291884807973, 0.17699161047826587, -0.39559968777239873, -0.5671033142584154, 0.1575969902019292, -0.1284646718362871, -0.2911433310553489, -0.27394215319364756, -0.4719722241894312, -0.47868004960594635, -0.23238246704259122, -0.40391712099083416, -0.022354250675767823, -0.4310091138644708, -0.3774041210588357, -0.3550234161757426, 0.04320372072095401, 0.08534882022645564, -0.4168582467299795, -0.6855452094429154, -0.6449325051726943, -0.4192045829467159, -0.5217047740513436, -0.013347954290919216, -0.04012054622985178, -0.5320758114731209, -0.16326154827309727, -0.019486019801377923, -0.3593725176230059, -0.5619898535334356, -0.5729586402878742, -0.4719872996842626, -0.2939821068973458, -0.38176853031444447, -0.20453912555222314, -0.2333937543593563, -0.37421788184823973},
    {-0.23731608894120834, -0.3711209995805172, -0.2589864781179566, -0.5032558498684978, -0.6158132051158072, -0.34667080213754004, -0.6146166477782112, -0.5563508697156515, -0.2700197412180167, -0.41931018431191047, -0.6590370929777057, -0.4583983657896353, 0.05145351247380642, -0.5399641992853544, -0.47594555285041334, -0.32006144087927946, -0.24586313142096733, -0.4043822939613789, -0.48789843550474826, -0.33777136965033816, -0.5546413374566099, -0.4509204633763668, -0.38612843980950384, 0.11200226100235755, -0.3528054319031798, -0.2813564481935065, -0.6213817586329886, 0.10329286192404939, 0.19846992355653256, -0.4250832143525541, -0.34476609839577727, 0.20074001186032606, -0.030232682738120634, 0.1469096239289448, -0.41660896295798683, -0.3306855744847677, -0.6149452734361477, -0.4312153053357847, -0.5426935527803564, 0.02793679516058664, -0.6510839659764959, -0.17383574308018748, -0.6452111677526666, -0.16994538762114547, 0.030472800242876224, -0.40378634722435885, -0.7069797332678859, -0.6416493984160866, -0.5793042700333, -0.4539542814818635, -0.17362467261592038, -0.10840269742515606, -0.5768894286184393, -0.1486474322034339, -0.0471571274710309, -0.20553720923320054, -0.6871259103894777, -0.652724460236178, -0.3465962850484254, -0.45608836592125956, -0.5006927884092235, -0.2981308327444276, -0.36476099620150415, -0.5638599578041723},
    {-0.028900957164560915, -0.485399387108152, -0.08096411321779486, -0.40497975333637354, -0.4249580902819089, -0.5957055927998898, -0.48312888266739124, -0.2945276354855771, -0.029779501154377733, -0.35541278574770135, -0.6074876319819629, -0.4264851107575122, 0.3572855770381674, -0.47737052211457875, -0.23589494787861606, -0.4671694250296883, -0.4743321612764471, -0.3953905580377101, -0.48846934813978976, -0.4697221514489792, -0.5941026461213029, -0.13115733920812445, -0.31584135116978135, 0.23783856030832537, -0.5853390568098364, -0.668552706895483, -0.1319531470115458, 0.18728063330998382, 0.530636130785517, -0.47065665073988744, -0.33949723053740405, 0.571793334611677, 0.07162587748553752, 0.09916293206621458, -0.49031120881629514, -0.6232340236543986, -0.5617709387458042, -0.24265341359508946, -0.46719123830353454, 0.26078308868354744, -0.5490877413561362, 0.018027708347114486, -0.3473580473728593, 0.1343459206350297, 0.025307867795994737, -0.6223023255182673, -0.6301187336082769, -0.6172754786576913, -0.4996728044275885, -0.49754754851357774, 0.04093360628208343, 0.16655038531047311, -0.6907143556704585, 0.22427316123736207, 0.1975215258383952, -0.2764158217699642, -0.4034940527762654, -0.5026808683003366, -0.37556048825799376, -0.5687597321196192, -0.5551472317176898, 0.034116488085084336, -0.4435799111460866, -0.4829628017656126},
    {-0.3879664230313303, -0.25194551052768926, -0.0941704014303699, -0.43548029189698034, -0.3197653795733095, -0.38445765218040284, -0.24358653869852392, -0.5202605692569293, -0.05741782295484221, -0.25011967649267663, -0.38414350223906935, -0.41342025121269954, 0.4713823727828613, -0.47481593368349745, -0.33833269412007394, -0.4886081135974585, -0.4475722954216137, -0.2332763604198484, -0.36777253392750237, -0.4298149663233401, -0.6300713063534836, -0.5438407514035154, -0.3907850094736394, -0.02180479601230055, -0.6400795227245465, -0.5780967819192108, -0.22004786061197523, 0.571800359545317, 0.3918029939481115, -0.36572980094285823, -0.3657649129429302, 0.4501535573351139, 0.06945213143565225, 0.36504880370722825, -0.3186835009420604, -0.46417104834891865, -0.38803326777767055, -0.4216661778219191, -0.3974708714376706, -0.10742069265810515, -0.2895211664786842, 0.028254844115941716, -0.45784559765625094, 0.23427656263879884, 0.20026206830645135, -0.45489848459068166, -0.6489555393985085, -0.42498669719481724, -0.3444188616198239, -0.3045817628563276, 0.056882509664307475, -0.07915047688308657, -0.6647962837557306, -0.13877567525543139, 0.19860168564257266, -0.18028555416307288, -0.4224842180024912, -0.4323153344456297, -0.5034127987658422, -0.5761368199642825, -0.27288041934088897, -0.36357706071150375, -0.3846404902238935, -0.594227873355057},
    {-0.2797945152992313, -0.49801230205629493, -0.4656099555272997, -0.6124391451318184, -0.5489007690959251, -0.5409413646074968, -0.569901446734368, -0.31012373454772285, -0.4026186115504471, -0.23695387310077023, -0.638172399477159, -0.5114373923600103, 0.17716770172170246, -0.3895316874054916, -0.5295341993056675, -0.2896086676091505, -0.3377148825165305, -0.2045793270198805, -0.5725891315116367, -0.5069005660336814, -0.6812675984442714, -0.5901680221873611, -0.4540201493423205, -0.193504897302872, -0.4326435152134259, -0.32718253640748446, -0.5436883668088537, 0.2788948831354489, 0.41618624310947056, -0.7203947956074621, -0.255176903238722, 0.07948264977031444, 0.041397212960992615, 0.1371950625279966, -0.5558943542502538, -0.6247636025326168, -0.5900133288597051, -0.20678887762115641, -0.42941085167877874, -0.3153684591194966, -0.6485473422949899, -0.003994869934306846, -0.4700864881313714, 0.05063806789462603, 0.2547751834056803, -0.2971939655401321, -0.5337273596688284, -0.4716505628732055, -0.4214294466092544, -0.5661133823590492, 0.0878848304899359, -0.24285277586506898, -0.6722477867817713, -0.11144672322230531, 0.04317529411665257, -0.4589057299914195, -0.41830800874115726, -0.43023797563832633, -0.3469833344726525, -0.3337626384256705, -0.2789249096704509, -0.42550031370026153, -0.5230467213104077, -0.5417589046283974},
    {-0.3995939242465561, -0.35623585544798003, -0.5314838486537361, -0.4819708424524119, -0.2774951719522265, -0.477450838676347, -0.4830000317631457, -0.5893675622151883, -0.22402786063275926, -0.48727497066338354, -0.39026197694812, -0.6440063320051653, -0.13297553970042378, -0.4655223078744071, -0.218855241659937, -0.5706741903754978, -0.23914803816773977, -0.1208802008780888, -0.45616407592096325, -0.47246732948352527, -0.5539697771375843, -0.45968717494398503, -0.4329563829340448, -0.2933911358035379, -0.7020900884584172, -0.3805127239672424, -0.580282003290086, 0.13837500727048993, 0.27306727658124397, -0.5669951669394045, -0.44903500655802564, 0.2150933434490438, -0.1801675710564643, -0.1817395446864362, -0.47159548831573966, -0.4953755317199895, -0.5063842194687158, -0.4045285945064896, -0.4428955749964373, -0.233584915448596, -0.6354284210684551, -0.40192979038849036, -0.3581890435287676, -0.13380647074209606, 0.16408130021930856, -0.37369524650951264, -0.38533916234388216, -0.49207669098308315, -0.3744121034498939, -0.38643465519660924, -0.14559952318647681, -0.17285952643939373, -0.475813240754166, -0.404432014267748, -0.23462863233776107, -0.1838201577342479, -0.5137348382250504, -0.501262989248344, -0.32807623837710176, -0.4438219753549833, -0.6418881160457774, -0.2240923243190002, -0.3730065576102748, -0.43300530647335594},
    {-0.4264990685269285, -0.312633854317801, -0.20851646568834226, -0.5388964095735365, -0.4582000640519419, -0.3450537492262817, -0.4167549700288224, -0.4075126847187709, -0.1817260755200353, -0.3897547339309019, -0.35594109110467703, -0.5556203159930156, 0.38597038394261096, -0.24971097161182457, -0.5593431296872, -0.5861651259051386, -0.18397502460251366, 0.010686743403448785, -0.62887850449071, -0.19695638117203507, -0.5374515664648647, -0.27099391997265226, -0.5310849137119821, -0.08221785463476679, -0.5097600682185632, -0.5153033542381172, -0.40830475989701265, 0.2871411124491523, 0.36145222129565074, -0.7050686994647898, -0.46127501417059, 0.10296824248546345, 0.18899681592079803, 0.050767400820535484, -0.4549614754637306, -0.6545730996701775, -0.5441173285622564, -0.11956836251667437, -0.4156502348949723, -0.10901610774959881, -0.4706554915161896, -0.368382449091708, -0.39049640486071774, -0.14876923067364023, 0.2792652040230268, -0.5915931080239054, -0.3828683745184537, -0.6759639247107344, -0.43986382762628323, -0.4731537671350884, -0.09256452393425973, -0.35051624562703143, -0.671173289948671, -0.21203093999316303, -0.027537163887040722, -0.565353213335228, -0.5258441915306697, -0.5040707066902337, -0.26500825182458865, -0.3497855316544027, -0.3429918413626327, -0.20190538048527076, -0.47156903914668674, -0.538015025854573},
    {-0.23577408748740653, -0.5551411391888603, -0.1403327930408442, -0.5844004522455136, -0.5507117017051173, -0.3773308499259646, -0.3349351696624026, -0.5013458884972032, -0.21836521896864025, -0.2715867983859921, -0.5616274803370221, -0.3287116244504262, 0.2105219559557399, -0.37488064836764684, -0.40261027275982203, -0.333045230770936, -0.5311046154966398, -0.15787006449435426, -0.4214382580822318, -0.5262507453712394, -0.43021106358793604, -0.38456018290421495, -0.5459686941341533, -0.2940375277466404, -0.7071695307219539, -0.5603774300239475, -0.19793865339629022, 0.2240066117050581, 0.35862076829876194, -0.6781940052816707, -0.5224806264667095, 0.2952985168156627, -0.013110950042965482, 0.0029389577948336645, -0.5642948807717156, -0.40395993432521415, -0.3237713280437553, -0.11868122275224807, -0.4198271352840228, 0.0030988450836532005, -0.40303249691001575, -0.3616769747401039, -0.33134876252614576, -0.16642526043816588, -0.022181946033166977, -0.5352434664066519, -0.5650224238038691, -0.630226615921512, -0.2748977432271383, -0.5268118666323138, 0.17715562124395928, 0.040830366464511825, -0.3836860328776774, -0.1423752045587942, -0.20118164331070387, -0.411011751430219, -0.6481939670368352, -0.6187167177533311, -0.2636555380136725, -0.23451356729593115, -0.5437641949858956, -0.07272357666667331, -0.6030885097137257, -0.44634437827405354},
    {-0.5016765538552094, -0.48029618945902147, -0.3007985876982668, -0.6977287437725613, -0.3630590268919489, -0.47553850095173134, -0.468272178738957, -0.33138509265200955, -0.43233462742394607, -0.295807794052254, -0.6309500694695609, -0.4348005654390456, 0.21448299676748434, -0.4723366093881705, -0.2457325726029871, -0.4125837924335313, -0.3548771363898319, -0.4192883861446307, -0.6352865568626962, -0.44528398634840344, -0.39989233037854954, -0.4223483217112228, -0.30774433765031, -0.3526330527007872, -0.66738785229964, -0.4635748983187822, -0.4240882231321895, 0.32717820328781366, 0.015161094745469348, -0.4705319188254591, -0.2725990791216285, 0.0028762667944329215, 0.09009166590390265, 0.04622940897711335, -0.5618735079424303, -0.6945971327213328, -0.6886484515759822, -0.23781578206259438, -0.6011035792022178, 0.05427090566790273, -0.48946613321779986, -0.39126469895389215, -0.6671303173804324, -0.07968079746535982, -0.1680083725620457, -0.34481902618731863, -0.6511975302932695, -0.5668986938909124, -0.33423523433969593, -0.4775623485127455, 0.03981076454437842, -0.26519995191919543, -0.6915550371734194, -0.18206960948451453, -0.21198655796370533, -0.2278491625475291, -0.6355656966777568, -0.5209995490641888, -0.4832514566929117, -0.2486906205837861, -0.5526696637558958, -0.17235164256558233, -0.3848852324833704, -0.4136714334885064},
    {-0.34303340426836587, -0.35307736612331875, -0.36739007044878264, -0.6503266528768672, -0.6127806859732297, -0.41166633540451414, -0.28830980732842065, -0.33130885900463136, -0.5512646506910128, -0.5387817393278604, -0.6360844828712149, -0.349171975771778, 0.27084597595576937, -0.2944337804082105, -0.6009525955900289, -0.6402922985459397, -0.46541450081948593, -0.040066308456417773, -0.45405977764647093, -0.5716177167267747, -0.6324942147477439, -0.4555487925419768, -0.49641286303370324, -0.02380978316215956, -0.5234081312147649, -0.4577741021764613, -0.40306749335611025, 0.3697692909853137, 0.061313033445880044, -0.38799415752824545, -0.30056603258456804, 0.15729938082533443, 0.13296070797026638, -0.028447506143003017, -0.49447487221008246, -0.5404432924639317, -0.4580029986423171, -0.09091465097577428, -0.5768334867010376, 0.04278358424755182, -0.49376629981760095, -0.3627089249564201, -0.5253781394604056, -0.08854165115585753, -0.04674207740876676, -0.44458888501791416, -0.5385546905124104, -0.40970472883436637, -0.3759971102424237, -0.41281175997457137, -0.23031789694814042, -0.17181192912821125, -0.37869727882260795, 0.02380189992537014, -0.059414930536000055, -0.35850726076060163, -0.48863784376122943, -0.38116733850459306, -0.6254046009051603, -0.3049095101542512, -0.36199015853888067, -0.4186821142620306, -0.3312574161391474, -0.3848877746952575},
    {-0.5512117992367814, -0.3930739210127055, -0.46789236663305867, -0.6493544970023495, -0.4398312859406638, -0.2948811342983587, -0.3837437156043393, -0.4449157078077119, -0.48611035597788027, -0.43524527171095123, -0.5821052913378297, -0.4363508240007086, 0.03753568179174451, -0.2357128020241276, -0.3893388046015454, -0.5231318819768751, -0.27044369114624744, -0.18654308426633495, -0.387078302370484, -0.26404885306116477, -0.6841852863870709, -0.30395434504904856, -0.5356333991473695, -0.29729696682200585, -0.40443550370590453, -0.44341024443554194, -0.42319943451559466, 0.4154885592558502, 0.17933209307882217, -0.4367139279386113, -0.41117361174229194, 0.21854339305700068, 0.07979625693285172, 0.2543808617085218, -0.5177929825709652, -0.6351313260717704, -0.5909970948213917, -0.15554471144861295, -0.5570728559439733, -0.0033115994201521086, -0.3444255818880507, -0.19557820514107488, -0.5265707997227417, -0.006304356520399604, 0.06808276988806977, -0.49692033239157146, -0.7018366502468626, -0.7224295416360151, -0.4133704719152677, -0.32259299478431575, -0.2319858322742186, -0.22116573989735488, -0.5659558199796562, -0.023195323679912554, -0.20316191346439677, -0.30637435483028475, -0.6545328707485274, -0.3020607692908462, -0.3475762000776007, -0.3881635016830804, -0.29778248243799227, -0.4058300285597438, -0.4244606759474865, -0.6000625081290076},
    {-0.35580588667259444, -0.17958845620428066, 0.0231632411987423, 0.2490237071537983, -0.20778942618448287, 0.1003835115470998, 0.3003707304972609, -0.06859389387183225, -0.3518349225930397, 0.23417949692601484, -0.08195632322438494, -0.27962831244274333, 0.2569069995348681, -0.040188482417307145, -0.2583780028965916, -0.10493591713941802, 0.0382201414925422, 0.029067584703542034, -0.2700012970225451, -0.2750117319095748, -0.16118604853334542, 0.17622640631033204, 0.532409406415883, -0.16044399335934928, -0.0393971988969827, -0.34734743884949265, 0.2669501907852892, 0.4468217677569221, -0.3619399604480169, 0.3745696182173907, -0.09217870290629038, 0.03299022898293653, -0.5384707122458059, -0.437683013580936, 0.10453442284722082, -0.09153278309495876, -0.012645770744269433, 0.14687198259270012, -0.1179292263893428, 0.23629622778713835, 0.26202230188185505, -0.4545615365287691, 0.31250379813150775, -0.37084789088672765, -0.5212581671788555, -0.1410793728955518, 0.09707948795296194, 0.1189486293633416, -0.11959680473734191, -0.0861969904413803, 0.003235761845166179, 0.011147665533040016, 0.16279880351069576, -0.017825165668428514, -0.1903808353289054, -0.24712381052380064, -0.38902691078003526, 0.4581774969576589, 0.4988042097342864, 0.40898499803726523, 0.3464315475844489, -0.09197669260951855, -0.3834674600786162, -0.3964802658629354},
    {-0.12965353978918875, -0.16449365751075748, 0.4161970339934663, 0.5559454334754572, -0.4294451713412314, 0.13737212969516052, 0.4893349927625018, 0.01017337793306798, -0.03767060713351177, 0.0526244722125056, -0.3660233582585963, -0.1582550381800286, 0.14975102600168597, 0.31881453318222785, -0.6076716151555035, -0.2889106593184923, -0.2943305538028131, 0.31455802900947016, 0.12275929969125071, 0.21814752994139372, 0.13599805874069734, 0.10260719940190023, 0.36886531660595234, -0.26210832291399455, -0.26664108575306794, -0.2691719699325133, 0.13229743418106302, 0.24176212154009136, -0.32908736116409365, 0.08436685311423726, 0.014555450435401528, -0.35094508582075323, -0.2837719470711437, -0.08859092671010364, 0.2851276257458566, 0.4042236996965054, 0.27404798286517806, 0.15638082754367605, -0.12221814819333354, 0.10236636489732119, 0.44842167225986324, -0.35514905890690446, 0.26672739825619407, -0.03545078491548934, -0.3865607280328174, 0.10006554043169659, 0.118541833126052, 0.20146996917093124, 0.3468183846065133, -0.18701291949386073, -0.13249698057881837, -0.15392502188893561, -0.21847365073772945, 0.2861519516491487, -0.5885216925358856, -0.22936034918360096, -0.18098830317384837, 0.43887982682802923, 0.3348651572067595, 0.2614011889520759, 0.26847305946393424, -0.0744134641715793, -0.22691252621686783, -0.22640467677632223},
    {-0.26080331641536686, 0.03722936106077648, 0.5556211486820357, 0.4732290361198973, -0.4223534796672359, 0.11834547189951533, 0.49016855255919667, -0.21639628008847678, -0.41136590213369945, 0.49990132959660766, -0.4018658575389146, -0.4430470116211048, 0.4238360581218559, 0.4333674765610233, -0.3984059167799613, -0.1701860233145271, -0.09499481294231035, 0.2585177841645546, 0.04561659470361497, 0.1610367154662145, 0.03589230466315952, -0.007063861460200085, 0.5498293291890235, -0.38640114045744, -0.3683384814235157, -0.07522435555083606, 0.3079681756547515, 0.2172745358699723, -0.29817422548951084, 0.45308156466349486, 0.30231151546059043, -0.29952703321687746, -0.4887603621141229, -0.1684425236818647, 0.4240273518927066, 0.2995038512527083, 0.16997040215630776, 0.11339525141521223, 0.2063940652989448, -0.10655806736558093, 0.43400010167592623, -0.3143857565064963, 0.3053226805538822, -0.42824846009546624, -0.4911192463782375, -0.03299716790488786, -0.33434081263692517, 0.30201468737852205, 0.3942783963941165, -0.34342194901399486, -0.1359941303855591, -0.40534635925498697, 0.033108019743298016, 0.29844807212057706, -0.5144414209270085, -0.47298144193157315, -0.4377484294006935, 0.43834357387416206, 0.23540227684646156, 0.5770503890937012, 0.33629159236632666, -0.45401954641723863, -0.10683432703481567, -0.0461394328409307},
    {-0.32871173621973787, -0.06993539663621233, 0.27266815091182695, 0.23298680022039156, -0.314868599842771, 0.2807506281631599, 0.524456935480876, 0.06827198846989048, -0.22068801355605008, 0.47186877247926673, -0.14332841371488567, -0.2801699216491029, 0.5651954583401378, 0.05788015996594403, -0.5291258860629982, 0.12305943651409071, -0.14074490955779415, 0.34536804125594617, -0.01021629291856366, 0.16680451092500606, 0.09530833297713015, 0.18975715675350113, 0.25839082708139827, -0.37505443123826726, -0.1653511968818176, -0.1260846886119534, 0.3756740421505483, 0.33351340388155387, -0.11440458476490535, 0.41771282876003174, 0.09843272452561841, -0.38550661075012593, -0.5557465570550477, -0.16058727765921707, 0.1862015859772382, 0.41972336704272617, 0.35450211654658054, 0.32101070897314804, 0.3828796699412326, 0.20684205063795183, 0.2580193543334757, -0.32876238891000475, 0.11642494883156088, -0.16942785574257418, -0.24668990644959837, 0.19374499262782835, -0.3175365375015223, 0.17931428644383046, 0.39180403164660427, 0.09594584495484072, -0.3285605954445616, -0.2853915951269943, -0.011785945804354927, 0.398653935612174, -0.47019328076561295, -0.5657397808687022, -0.4487190598012485, 0.2887339319366229, 0.5753668502695934, 0.42094204379044614, 0.37276875640232976, -0.3334639075371673, -0.35582896386111873, 0.01695984868225031},
    {-0.17598116924804652, -0.07762205743928369, 0.5002204698624948, 0.2726438427655044, -0.4122843317690957, -0.03962517953787104, 0.3929972497596246, 0.018703568884237885, -0.012640277122458238, 0.33887775053844893, -0.2404359010944123, 0.07079668885473213, 0.39179701139480033, 0.3178263430774499, -0.25099237761249904, -0.015440255811415718, -0.03496636432691773, 0.3822663621876501, -0.16841783406574634, 0.2883647240808471, 0.3618427485301359, 0.2085266757692496, 0.10567011750549357, -0.2195928562660316, -0.1558052284890307, 0.03871200375753015, 0.554000878135725, 0.30921446196740404, -0.3656010118216352, 0.3980830654807167, 0.12446699753307963, -0.25934041484647746, -0.4376412566686323, -0.3536252638780685, 0.16286585382028482, 0.5127079896051493, 0.09470851506068612, 0.1046468891597051, 0.19165624006576354, 0.27920547099649123, 0.5278986440329682, -0.30690346857578527, 0.23754140012550223, -0.05523174993964447, -0.42504301191763005, 0.46854810568077276, -0.34305950946730646, 0.16081432212779725, 0.4221767524996779, 0.2116638529715734, -0.43288296594345005, 0.07746257530860133, -0.04794458654264258, 0.47836904874050207, -0.46889914032119306, -0.5930782362179073, -0.26715259336614017, 0.504403491830991, 0.3895268377283246, 0.10640175439793768, 0.14899825772400838, -0.12444698160626738, -0.27619492365498477, -0.07680276978330083},
    {-0.08318215902420142, 0.00011823712397305175, 0.20432054804782587, 0.20288977458685084, -0.10716846804267988, 0.04159251528975487, 0.6081726005933492, -0.3736282652622423, -0.024771432652423233, 0.5287477604457074, -0.374363289043615, -0.015062863852883432, 0.32854932643097146, -0.0214696431206477, -0.2378071037002614, 0.12301701185867975, -0.18827907903275015, 0.305076869956685, -0.3236255314431881, 0.12605342823338736, 0.21975361678386543, 0.07818835400843019, 0.10330203383484092, -0.05769644745302966, -0.25833335029040433, -0.4109696659698015, 0.20650790782800368, 0.37338805854607793, -0.4736995667325006, 0.18996647245359696, 0.3082758454704689, -0.3141928091451799, -0.5150095053616689, -0.4009278046891782, 0.39034851941383664, 0.28046120529000146, -0.05048903097163264, 0.4755458095774298, 0.3211838685265755, 0.22371615376345336, 0.5106694638804192, -0.3965830280743242, 0.04036178565401494, -0.26498328444087876, -0.40963898050052666, 0.39555597944538146, -0.42369580411316365, 0.3725225915229231, 0.37702887726684997, -0.0465545790885474, -0.11297688467768066, -0.32199162015198846, -0.034193088931118484, 0.47103197672912966, -0.3103663516835504, -0.32443455097474816, -0.3488994517938357, 0.3268122657491049, 0.1729090085975356, 0.2770414548660831, 0.4491770366191917, -0.25537851659307725, -0.3942401316433868, 0.0209114917856775},
    {-0.37332366527869576, 0.1960932546765079, 0.2933184151160971, 0.40653271969913624, -0.29865107421993686, 0.26286541507702005, 0.36444007509391874, -0.48678907672594424, 0.00616155954074811, 0.4394871128784986, -0.054002536768029276, -0.01356205092207271, 0.4895855171583786, -0.09159175218439762, -0.28907292090627756, -0.16420020708611305, -0.16811643898884243, 0.2405564654777432, -0.40052339556039407, 0.1245076676643942, -0.03747305096889334, -0.0466790711979571, 0.45109857145932514, -0.02636787606476036, -0.06231995426786952, -0.12343191912614541, 0.4322655057987213, 0.5710675021941022, -0.2144333480006789, 0.42156607401530033, 0.45995801632093886, -0.0623445785913402, -0.5822137702292883, -0.15536130076621033, 0.201881382113779, 0.22667189071580288, -0.08951316377057827, 0.3094852095488913, 0.24458476285374833, 0.18051150932288376, 0.5325410699136532, -0.2989423404496248, -0.026450947631908195, -0.37328926046021427, -0.34694149927044643, 0.3333068830391657, -0.3926442753444959, -0.05028418069245744, 0.04404186088874452, -0.014037545871174608, -0.23359194604502082, -0.3683022872059959, 0.049425017960669435, 0.5022258951777738, -0.3570481724937719, -0.5799431573750661, -0.38731580099677976, 0.4297227728677972, 0.39228305642254596, 0.2545851343899839, 0.22169330505397397, -0.2425736505508683, -0.4573675884018184, -0.0681500181840462},
    {-0.38155038892665727, 0.04754908390904928, 0.2317598550194838, 0.4774756597914884, -0.10573769839984826, 0.26934884062569725, 0.4512958657138129, -0.23166557515284406, -0.15963202778287552, 0.4120209874878571, -0.2804159134093198, -0.045197678875690143, 0.4702946246298089, 0.09529715112281731, -0.5883493444329096, -0.08397526118332858, -0.3784336283078955, 0.3822915864606917, -0.27001273618463967, 0.22560448803305175, 0.318476130005851, 0.08250663711716483, 0.5097069389086735, -0.06754386587328678, 0.048419390867572874, -0.29466193927310363, 0.45934399309781476, 0.5140841587065069, -0.4182281848278672, 0.33466608923858104, 0.40987627289052403, -0.38615522965432675, -0.41167807075225205, -0.21698717180550192, 0.2560772121366447, 0.21105351337807526, 0.14416937181436806, 0.16858641869228327, 0.21860806035261393, 0.1541839977804315, 0.30353777411480626, -0.434228255530004, 0.17173593459145897, -0.3317581035111208, -0.30784225575448776, 0.3354681422578913, -0.19934058584076583, 0.006143747828429929, 0.04742596562901683, 0.04275857342370235, -0.3925281689407173, -0.3386078952024784, -0.24413327048491557, 0.5606617993351188, -0.44555679621432925, -0.408339615589798, -0.4456202570995916, 0.25239845016737905, 0.1638947025195534, 0.3342030581182247, 0.4568472925779507, -0.4694037777762073, -0.18420179879755705, -0.05834088559494952},
    {-0.20362922077634096, 0.048759492193864856, 0.47562468295147875, 0.30410242257873227, -0.3156910501769692, 0.25660100422724863, 0.3024073340416356, -0.19679183250608245, -0.4066671404583302, 0.5010416617113701, -0.3993981804667837, -0.36481280902738444, 0.6483393765078188, 0.0743766166215839, -0.614384482174511, -0.03972700510001708, 0.01139288606486658, 0.15110170047122987, -0.1715562314726626, 0.2818495385408087, 0.42147204167049457, 0.25241434637905746, 0.2666440298530155, -0.2971283780202371, -0.199446372107943, -0.07768518055302763, 0.47204089453674264, 0.24754746774824676, -0.27395047387007393, 0.35108327964748187, 0.2529692462840068, -0.28057322812144087, -0.48168666983473224, -0.49874086065777945, 0.48835131487492095, 0.14461623560260017, 0.34182377361329397, 0.16555486906528705, 0.16796538166191255, 0.055571166909081794, 0.2586864337556189, -0.4700885672090732, 0.276733747057258, -0.07989844482906323, -0.5321454532757256, 0.15995112193592148, -0.2563948402860976, 0.19809163925169945, 0.16514342010222766, 0.055843137084057956, -0.08449052745612441, -0.1130345547700546, -0.19397866003599076, 0.6188363660050975, -0.48626755435734986, -0.3045437848962863, -0.16660139130064033, 0.6135515398564658, 0.35911864181715136, 0.42672967292874936, 0.30341034427879804, -0.4866874531364418, -0.3800699588154642, -0.34631874714372307},
    {-0.443500831087971, -0.12492552559711895, 0.4825360581480262, 0.47908191670272887, -0.17231618984629146, 0.05893593415870294, 0.5691727442652369, -0.3896348213666363, -0.3552528159787739, 0.3963907011048617, -0.30718940817242557, -0.12837178900528617, 0.5263271548892631, 0.3064079968891018, -0.5681428268558548, -0.10474529410857418, -0.1919197704407854, 0.27812290192951017, -0.14524868503945007, 0.02103608980311669, 0.24170131551134813, 0.13371973691885053, 0.5188107092216702, -0.4013430069773287, -0.07096007786676124, -0.39860495956947944, 0.2828341716812739, 0.5778249435065014, -0.37922532042043, 0.2621908237897314, 0.4980873803486774, -0.1648635193554253, -0.5021184854363209, -0.28601087693884897, 0.22587311958186632, 0.34601577202125916, 0.13115252573745526, 0.3856786213312727, 0.16042104205675736, -0.04236846129990258, 0.20680725992457316, -0.48898024706288273, 0.27729927467231213, -0.4002168041134747, -0.41321188569673306, 0.3376117585131602, -0.2656757380582744, 0.2608138057869835, 0.39651532139924067, -0.2493951342847667, -0.2538418735362308, -0.0601217195255532, -0.11846445725558682, 0.5073204255730083, -0.55753692029605, -0.4772865962668205, -0.22590704171615503, 0.5155079276242971, 0.21032592104834857, 0.4512439519846268, 0.1609478990757906, -0.30197319137965817, -0.0791713064710489, -0.08260440080787532},
    {-0.23013882435423683, 0.06356510608346234, 0.29527560744844905, 0.4881014698597844, -0.3589297400479946, 0.1216390532457289, 0.3086910952609443, -0.3900025779130479, -0.054274242652826786, 0.5122724708278591, 0.0488062441123478, -0.1636169720702321, 0.3887894432938147, 0.1782195016180544, -0.5279644815222944, -0.2067240065581944, 0.06430857858722279, 0.3948319799921252, -0.17026323240958496, -0.21112884490794379, 0.18212343983731236, -0.2003989892497232, 0.2354807501256519, -0.33965135851468803, -0.11810931197153729, -0.3345291735618385, 0.45677037852100927, 0.2678967903437964, -0.10909727068042101, 0.333888715490461, 0.5456748614768365, -0.20241895527135265, -0.2888806763162465, -0.47873962046983354, 0.37493344008182933, 0.1883810514873901, -0.0028464387665882566, 0.20515135805018053, 0.1553637065430722, 0.0835065485884064, 0.33889803441070504, -0.5576026767784182, 0.30960439474575957, -0.030584937214022903, -0.49412721073959937, 0.17914233516756667, -0.038055666848408595, 0.1347923771764232, 0.08391568718953064, -0.334127819383689, -0.3413340670225422, -0.30430920739503203, -0.07257894064112717, 0.43956168024342795, -0.5851177376946767, -0.5713814575187146, -0.48304810699438816, 0.28374565460395546, 0.23651359066236952, 0.43687738542977195, 0.2609519153004884, -0.5480447131046449, -0.14352056412558273, -0.07761820102222182},
    {-0.23138761461271867, 0.2556958903578773, 0.49142790596415803, 0.530013559231042, -0.5058463345964485, 0.19595319637003358, 0.2896935147538125, -0.29476378116607677, 0.006246503572868173, 0.24079507054560775, -0.017391682947659314, -0.06810714321957159, 0.36568133166910943, 0.04703256556859183, -0.5284938660991846, 0.09223156043113899, -0.01965861277504961, 0.4368302970616213, -0.24112728137237274, 0.17632609571341679, 0.42693932855821765, -0.16096066649334442, 0.4923266023608523, -0.4674021699946585, -0.36272551885183485, -0.21620782011047376, 0.6103272407829115, 0.5597229232162422, -0.3178645083982472, 0.22297889530755052, 0.5721594294903012, 0.06632950714392088, -0.4912519794709632, -0.4795954766477181, 0.2212108891058953, 0.31854098230689104, 0.1088149887372932, 0.23297765849379248, 0.14740192428334997, 0.38602354668975614, 0.3200997897168665, -0.29565723769198676, 0.27647497938118315, -0.06740834501419825, -0.3786053999400054, 0.2869842156130543, 0.018017549346866682, 0.06854123848885933, 0.07727964696814313, -0.1468138088075513, -0.4736492080582266, -0.2573434588168976, 0.13178884172775093, 0.6360080550747332, -0.5370433574316703, -0.42035631775863924, -0.5433180228590325, 0.509066526021629, 0.4548748056147498, 0.4260142887426465, 0.46605584853597004, -0.5449461632438022, -0.29095419155973246, -0.044549538874014374},
    {-0.5090550844242763, 0.038606489580773756, 0.37783383533450654, 0.5238510802598245, -0.22961929415350454, 0.21138148998963707, 0.32815319925478714, -0.41256437979895455, -0.20843002172620637, 0.3563495200825606, -0.32946793243525696, -0.46915061722440277, 0.47057076495736855, -0.029310317053883865, -0.5363346661610235, -0.10901006486108927, -0.38890369411019643, 0.48406203317466795, -0.22197030517161942, 0.14210509475739383, 0.07808079965894722, -0.05918801871528853, 0.6152910838669376, -0.20316107449099177, -0.2198655087912354, -0.4050712357876478, 0.29485448341517884, 0.4251330039422754, -0.2644285046108672, 0.2064192638840952, 0.27862778286167966, -0.1844266991218022, -0.32864308384860175, -0.5321932783239572, 0.2434603961034083, 0.18849252204490718, 0.18881050741663502, 0.3716486405063689, 0.10885988822521342, -0.0004438875271264399, 0.4033225186581232, -0.45887851766359083, 0.3021618045001478, -0.3178882545535119, -0.5311176247096552, 0.38732585304402933, -0.21128200308751063, 0.23501876137989697, 0.13485843818986332, -0.13466463957481184, -0.19188080619319914, -0.04316867193390314, 0.06879751722823717, 0.6551280506735523, -0.6166409557106535, -0.6219677435878607, -0.45930015443028327, 0.5594000775940832, 0.22043802772444773, 0.3560037131640049, 0.4678362163028714, -0.5512187551656403, -0.16937888417695313, -0.12589488779105995},
    {-0.3401390440309348, 0.35224481302721206, 0.31005761202022153, 0.6078855486946789, -0.10631857738857642, 0.08137727958731265, 0.26894604986867815, -0.5179690781248073, -0.3564290169533565, 0.1941755938757177, -0.3745855270132503, -0.4293158868179376, 0.25092070667527955, -0.08597650358139429, -0.48480481387570706, -0.1655568965848089, -0.370130055630158, 0.3860338113869733, -0.20124497177137968, 0.20853399397967132, -0.03837799408855419, -0.024535965918553247, 0.6029661619791823, -0.4196964804970668, -0.19075200095468733, -0.3970615275344309, 0.5345467799640614, 0.484001622913867, -0.4976658447181912, 0.2677374723147704, 0.38209466059923614, -0.30141867738649153, -0.5696108392211998, -0.4125383684207264, 0.3447669320762857, 0.4849075272855599, 0.10368155098524959, 0.5462265548558253, 0.23281445653636323, 0.20765955615406775, 0.4302460036880174, -0.3666691431769274, 0.0023220682629544773, -0.3070595531964835, -0.48359615373331016, -0.020003686348801387, -0.3506516149917313, 0.08879019926322293, 0.3440434976058378, -0.3164144244480873, -0.21874241658255533, -0.34513144873087176, -0.1709565956749554, 0.6004181715335855, -0.442891704943065, -0.4448213325125588, -0.18803247376128315, 0.6355289279629169, 0.2475582633593866, 0.3316100779425269, 0.21291297185917155, -0.14141526357736306, -0.15178173780698612, -0.30885270979257157},
    {-0.477776745548833, 0.30811547926254385, 0.3568171295659519, 0.571803692582982, -0.2478703061988244, 0.04058413414394807, 0.4980175288471994, -0.48288413518319395, -0.3352219462254874, 0.274026470145963, -0.2959073910961992, -0.46288330179056575, 0.3779224546834072, 0.017992727828239373, -0.6360761021370712, -0.4045018803847022, -0.15459594651030042, 0.22900906011633151, -0.13816327134752185, -0.1870979621845053, 0.16081508773927153, 0.06740892810169515, 0.4026314789788123, -0.4515326544385499, -0.19232393578117518, -0.35118855970560925, 0.48763963564378326, 0.5807149431647245, -0.2960751376030567, 0.3177953914406095, 0.34695661666642075, -0.17830651165568365, -0.5963222689300033, -0.34805355020826356, 0.29190839864116236, 0.2828396181682465, 0.20914544061378645, 0.3047363012010297, 0.4683715253938397, -0.053937929847502925, 0.3719464725632011, -0.4705064178263419, -0.05493676341126433, -0.38137333155869596, -0.2590504238060586, 0.08155908848703738, -0.009434070822060263, 0.26190660589859704, 0.4387546206784006, -0.22884548416646575, -0.2609925619467675, -0.3775666975160714, -0.2209848483081789, 0.2478855829852354, -0.427906924714209, -0.5367479119010578, -0.4103293913959236, 0.6033533128158471, 0.5891510082452143, 0.4258751977052913, 0.38542187085791657, -0.2553213433505044, -0.18290086175502152, -0.35720503672897624},
    {-0.5521637566544773, 0.22781073800249632, 0.49808922464604544, 0.3970680770790516, -0.5800923833294478, 0.04681653248451079, 0.2128139522542227, -0.21550865733893543, -0.1284647803127379, 0.4867031489936854, -0.23614374622699463, -0.5637232478216131, 0.3297413925651566, 0.0866743795137183, -0.530846786521182, -0.33701984049705347, -0.38323842015601983, 0.0322242304555986, -0.1878107165946577, -0.45433939784189664, 0.05274089594600867, 0.07241900843930713, 0.48812446070080245, -0.3742187000091015, -0.35758127964668973, -0.17718779389155098, 0.46612340120026635, 0.5498592112320588, -0.26513198507219715, 0.16260398522123076, 0.12084289109012783, -0.20842027869488203, -0.6480762421497642, -0.4606969264451731, 0.2595466048836633, 0.4877672281049162, 0.09980816293661635, 0.07989736769868745, 0.037566229624638514, 0.179988589312108, 0.5146316535114887, -0.4140014665876839, -0.08840031809430049, -0.35482669083328916, -0.23376426594555363, 0.17653678331697348, -0.23763912895441652, 0.30329430210481395, 0.365603719933088, -0.21303937540654003, -0.3442307875131163, -0.20572531377631612, -0.34751188717337894, 0.319534591308757, -0.5846015934748334, -0.6209848242104841, -0.35196130601091147, 0.4591086109529262, 0.22034933340221904, 0.5510884852282979, 0.24688333341099436, -0.3093454080811986, -0.10782195120953911, -0.41670605120552917},
    {-0.44337137556152395, 0.3363431732959995, 0.3894988497536733, 0.3816378592745372, -0.5932010673779207, 0.2076688897960587, 0.27125883859769684, -0.06674707721600011, -0.3622881533038988, 0.43896014922014504, -0.40176989748043695, -0.5668943650805577, 0.27574128631573924, 0.16232004953970167, -0.5566507456165906, -0.30552041340113095, -0.3946189838131161, 0.05013199315126098, -0.0970162558212001, -0.47051370557067307, 0.08499630077462779, -0.1591162499387791, 0.39168249291666657, -0.31465168706677477, -0.26860082143275443, -0.1918353147509595, 0.38971991011687984, 0.6233755032782636, -0.050989579806119074, 0.2558426214568758, 0.1355099079505959, -0.09363937687221946, -0.4932873654956024, -0.4755496929990222, 0.30782368690424233, 0.5177286855048377, 0.13018269559471957, 0.3653468659689744, 0.03775165905043342, 0.2966939514938893, 0.21134286483703646, -0.5151751651997555, -0.07600023609803658, -0.3382708036424961, -0.2861067232604111, 0.31308170003045416, -0.3207936969839614, 0.08034027270045634, -0.0066033921867288065, -0.41190734184221894, -0.40851146045268755, -0.006063773508626609, -0.21229145713586084, 0.3798712567236645, -0.3114222288895573, -0.637794876656117, -0.35844798499784797, 0.2997806603552835, 0.3514856673271477, 0.4675078994243398, 0.5164314705084978, -0.28882441239719936, -0.29096222778466724, -0.281241113415658},
    {-0.4980826522479177, 0.2055199650718924, 0.5673567548528186, 0.5616584050369541, -0.3467894377964469, 0.18735868168960343, 0.2799561882733203, -0.1037570853124559, -0.16688923534629385, 0.39767341075184115, -0.4046508240456788, -0.46888258540193617, 0.5221077103364262, 0.4082177897439948, -0.3552001753143789, -0.33314536614032275, -0.007762611215828582, 0.36847551272689943, -0.3563650449328084, -0.17848020068191014, 0.02012519121893259, -0.2973601521971094, 0.562146685153355, -0.35695805312954415, -0.35233164558275226, -0.23767477612427756, 0.6263231863698289, 0.36006991891348766, -0.3459933618159846, 0.39874057504859184, 0.06781828891421861, 0.03791677251184911, -0.5865278434825895, -0.5803200614730392, 0.4095831358358025, 0.4939602769596876, 0.34065340195419114, 0.2499297940352502, 0.24776910833637486, 0.05473104509143114, 0.48016644433189526, -0.3587444835958271, -0.03161935320480952, -0.2789709262800166, -0.2865484461973347, 0.21268621058420567, -0.07905441242511575, 0.35246772142285787, 0.2325825928420457, -0.42547882146809574, -0.46362186992339066, -0.13511041839387938, -0.003634467850218925, 0.2205576159508489, -0.47122252379060714, -0.5019477498280654, -0.30506994980182967, 0.2707936400271537, 0.36818953865263604, 0.28133491103456254, 0.39428926946796633, -0.6097252834917395, -0.3862831320362276, -0.48421978286655304},
    {-0.3392969481515039, -0.00895936366692888, 0.545014358121028, 0.36648952470907065, -0.2022652337501185, 0.149177009569005, 0.278341694629117, -0.2403671476126646, -0.37669261819376654, 0.31336302066337635, -0.09736617537986601, -0.2765870239607071, 0.4095887118536766, 0.2509817238265228, -0.2838437376003923, -0.16681445268664932, 0.07994287266535842, 0.18828275801192573, -0.08236439469958232, -0.3579266087898557, 0.11054651047473438, -0.12042745018274104, 0.594639410443055, -0.3836361326657277, -0.17094215338934665, -0.15410538913875524, 0.5491223564347385, 0.283633052276709, -0.1851123455691194, 0.44816739789726856, 0.3074153541175202, -0.246868773378511, -0.5425605663885479, -0.5917073206497336, 0.4110268186987697, 0.22477199043671686, 0.07276353236509968, 0.3867074313234161, 0.03809054326372311, 0.15860928495581428, 0.2832407172084404, -0.47151999852915366, 0.24003507454225456, -0.5059342932891883, -0.4777663742586457, 0.08548466176999958, -0.13922030144134806, 0.4093836178486354, 0.19197573057071973, -0.2874568604780719, -0.09489773786953903, -0.4530295207230802, -0.030776029264183644, 0.17289764806760846, -0.26378452209537523, -0.47077823172316446, -0.4875393601050444, 0.2937114771637572, 0.5240144627736958, 0.3783134808325203, 0.2606917604442851, -0.301629434391559, -0.050824541950726665, -0.2839907088486696},
    {-0.45655422296644704, 0.33962321592884526, 0.6397036907243115, 0.4756393725429366, -0.07125232671992408, 0.15745144992017565, 0.37333263953229556, -0.4580893544586027, -0.0837485719425852, 0.5290056997450447, -0.16537033769922455, -0.24720556958865864, 0.5904254516715586, 0.15840213914105558, -0.4283067678390935, -0.13102714402156473, 0.11391832698187086, 0.1472524916428186, -0.033852232772287064, -0.18816932040598647, 0.4538023863056694, 0.14345305915499332, 0.5058957634270171, -0.28659079114460406, -0.3221450159482986, -0.22889980074983102, 0.64732074633898, 0.2967957316524926, -0.3413436199393477, 0.3342640581519001, 0.5154720752565499, -0.009355036995021663, -0.3844771379439678, -0.44947559760421046, 0.4315100202713, 0.5419774959045941, 0.3112097149692965, 0.3795405059822505, 0.13277919890505074, -0.11745922219380796, 0.5586194882186409, -0.3909306415137022, 0.22735286217027217, -0.28332281194067577, -0.35674678383158637, 0.043079787509480036, -0.198812988351328, 0.1934536663066846, 0.192139741611689, -0.26957247842673376, -0.33908634354226, -0.22884170058275624, 0.09527452476688492, 0.23017576875889054, -0.4468214871794773, -0.4191176013129292, -0.23389684261229382, 0.6705814609514273, 0.31084133312650497, 0.4935104257064132, 0.3023379854132489, -0.5554390668624021, -0.16907978957418626, -0.40182203284875573},
    {-0.5593036174856097, 0.2877328914463064, 0.5425986622165906, 0.35354468799607247, -0.1267438589271506, 0.20557474712305368, 0.6235777884627147, -0.4361784738571501, -0.33844325179038937, 0.3174752871425521, -0.31837933147320446, -0.21767734119992477, 0.2585577290547118, 0.1089886461709951, -0.5133216320584668, -0.35632435585445066, -0.24060030462526724, 0.38017478360271134, -0.07589397695767623, -0.2326929163262275, 0.3780281237043599, 0.24870517087753322, 0.3791594821209583, -0.4225838986453511, -0.07536094212185245, -0.22987541924894997, 0.6101813761758462, 0.5019350765696634, -0.3477012120234431, 0.40243249452693197, 0.15240044467959388, -0.03606422860308663, -0.3730923822787054, -0.5109853531492067, 0.26129160414115515, 0.2754837437101184, 0.2812385153395198, 0.46913780815591444, 0.4278422647692858, 0.1257594491385993, 0.27346146232766316, -0.43116447285604365, 0.07381285208898881, -0.29102763394035386, -0.2948265062988822, 0.20918779892355, 0.0409032480259962, 0.19101238076527643, 0.24077261582195253, -0.3485928581048175, -0.49733877807163873, -0.28804057747023193, -0.14523064900042923, 0.46392930633621193, -0.46110330103014113, -0.45543831833178267, -0.5064807693432405, 0.6628163452899812, 0.537893989500218, 0.4165369510368708, 0.4239724627732522, -0.4758590843009561, -0.38404870848891426, -0.23001149027460108},
    {-0.2696668161174026, 0.26834296888311404, 0.492981029280034, 0.3262986073299699, -0.18561177788508454, 0.3127011763491053, 0.5184683950106898, -0.26326786431408494, -0.12239818258034753, 0.43537188448812253, -0.436256566951009, -0.4397492515806885, 0.5287984262546219, 0.25776745343366225, -0.5653441007705484, -0.17800041975771716, -0.10093387856565036, 0.12345442634678672, -0.2158399086382431, -0.23599144152812904, 0.2927133198073376, -0.12003325935538711, 0.6616852660315438, -0.23179792483008496, -0.16937659884348433, -0.27971380145981867, 0.6344104115516428, 0.6271945393510787, -0.2160355430257321, 0.19266908305513133, 0.5423461951354307, -0.30243557516235003, -0.621972071134854, -0.5953348245288098, 0.4725638164740724, 0.42392378568904004, 0.36382674833465706, 0.4125323192146171, 0.1753372084748962, -0.040969393431888435, 0.4750570260105289, -0.5181514810896382, 0.1064565793822283, -0.3495998246561751, -0.3477337836941859, -0.05068724136560965, -0.13227114173376736, 0.34135225274944525, 0.3939563791602965, -0.2939255279068763, -0.04980047333361785, -0.2219198582101713, -0.07624263760997199, 0.4958788571196157, -0.43971539953338445, -0.35761089138252805, -0.5615246242749483, 0.6576319562749121, 0.43247423580380573, 0.6687603470505081, 0.39583404739837347, -0.6075723802744267, -0.06249964211892746, -0.3476752038707261},
    {-0.4881957837525446, 0.16950286358394764, 0.34292127940706313, 0.2304006517689191, -0.5156962800447246, 0.12677333015462772, 0.6458961854943434, -0.4217821041292206, -0.3379345978513251, 0.21218759726979428, -0.16285646963469996, -0.2229825584128608, 0.4107660629299133, 0.3690809792300887, -0.4750341963799687, -0.2834094490280023, -0.0502874628843584, 0.34547381148473355, -0.14807786195873004, -0.11371524815578818, 0.05958577068523154, -0.2432914719043352, 0.5565998983436388, -0.30482812858089736, -0.28246696035697855, -0.522099765052558, 0.47215480072578014, 0.5246823604005207, -0.3123690575856389, 0.3563969317625112, 0.3760737395733782, -0.32654024088522865, -0.5970542364403975, -0.650669559188415, 0.4635688076746218, 0.25509845430594996, 0.41329476646761854, 0.224947756839351, 0.0678632528478287, 0.02732849422269378, 0.6155609297903076, -0.6036196428806787, 0.3316635304412887, -0.2877668454854308, -0.5065644990377929, -0.16288269080551654, -0.24345033810675978, 0.38957339040386135, 0.14148955619331932, -0.5136771987550333, -0.08303018206768736, -0.3779050291828133, 0.119470393644497, 0.40718118650798324, -0.41851396385591905, -0.5794009402603143, -0.5424181809817863, 0.5313023012800828, 0.6458136704472129, 0.5077514705751659, 0.5461140226146746, -0.35440082710753507, -0.39519261733154604, -0.17003443320604897},
    {-0.47587245323164995, 0.1570185676317111, 0.5593943245580513, 0.4291662255853542, -0.47734245601910286, 0.19025841087851306, 0.563429818993291, -0.16408273300527415, -0.45520576023337883, 0.36134314190028755, -0.3237052915776475, -0.5089796421385794, 0.5621540472490418, 0.1236268899510562, -0.6135883691268728, -0.386515146859163, -0.2252918212479897, 0.23432109955929267, -0.18942990746149996, -0.30870758418041677, 0.02417865546811084, 0.021272924260090944, 0.4647148834350771, -0.16901393145778634, -0.13479431058786787, -0.5366494479964308, 0.6260591952847635, 0.5429331817415339, -0.49681727961206773, 0.2109771929356914, 0.40487462972709637, 0.0030361594047243323, -0.36741654136553553, -0.4488886690183728, 0.5482629036441862, 0.31166169352186407, 0.3787498285525888, 0.20373038580446984, 0.14649430760901153, -0.0169671728700242, 0.57573446795533, -0.5629396730565258, 0.4571863876900296, -0.5341156296465697, -0.5395569987463154, 0.14429987246316087, 0.11169704002560008, 0.18873002855351842, 0.252571947868391, -0.4004615726698597, -0.26407089853183896, -0.16437015589954826, 0.268318726270216, 0.5893470675209651, -0.2911538317210982, -0.6098593505083401, -0.5592133547470172, 0.6370079873549378, 0.5921632955403532, 0.2919050985137978, 0.305076219075071, -0.38778041243068695, -0.07100900536829884, -0.24966402641890953},
    {-0.3420434854102241, 0.1121837364472685, 0.6176593934119196, 0.40652300947834596, -0.4504056686002807, 0.41752231482091046, 0.3199551460690187, -0.4511458863531478, -0.35355820655852555, 0.22687372737998726, -0.3406641529538039, -0.36976561764632365, 0.6460295705439708, 0.20444179832085582, -0.4011028319812757, -0.1547166986511914, -0.36936946359120315, 0.34945377648247417, -0.2965983857974018, -0.008640519829999716, 0.12445909336044012, -0.06009143522529126, 0.4776437942393736, -0.11785854054429988, 0.00032332456306643354, -0.37530916175643264, 0.6625936390261369, 0.4794243671764008, -0.27426783362234636, 0.23725479821644674, 0.35402262726509615, -0.2245568542802595, -0.5352012858797031, -0.46361413397588325, 0.5217190818294448, 0.42295589187091, 0.13626619214202498, 0.24382306869571277, 0.30944842683807944, 0.19437777743532417, 0.6393609652095184, -0.5999004177107256, 0.09921584788329858, -0.40568889245639006, -0.42979418770872097, 0.35167377381803333, -0.01120765364739771, 0.3255334982800941, 0.14285541655731707, -0.37702901326923666, -0.5085245746923494, -0.3237305833970029, 0.005582846383882524, 0.37868144943268334, -0.5061389621269545, -0.5799136955994179, -0.6065994944967591, 0.5195328244275724, 0.3177778126538093, 0.5685473382542611, 0.5649423000047727, -0.6265979592609117, -0.3886356410133032, -0.17839549371079289},
    {-0.5884917307726979, 0.30090798714580197, 0.6195249825782186, 0.5151476398506192, -0.3537524955459423, 0.037642852171109915, 0.5057117875022868, -0.26192847900829985, -0.4492814606467754, 0.20666278218695305, -0.4856664671236126, -0.3563809408152959, 0.35069762338742844, 0.3724804023493276, -0.5139113572987749, -0.08044402004782672, -0.24095737214929985, 0.25433924623623383, -0.25553772526394186, -0.46731240421723724, 0.08105886288284632, -0.0058636608225201906, 0.47629123358962244, -0.4266680526302593, -0.25196886195602075, -0.4463041764645861, 0.6697498468587394, 0.4097845096006548, -0.41073940244254326, 0.1488273652739242, 0.3791378949052021, -0.12160602370111874, -0.4596460585088208, -0.36209742166769104, 0.45664760846589136, 0.31394580730389443, 0.21185463694581955, 0.526270825037738, 0.38054536432064145, 0.08780367522411552, 0.26070552656073903, -0.5462533329699767, 0.39819148362026185, -0.2844895770895928, -0.5866585322979988, -0.09000348558875411, -0.03214865388574468, 0.28295804731370305, 0.06851320850894452, -0.5346629888450614, -0.4023737541463535, -0.2537162967643777, 0.07465948537408093, 0.34554431742148484, -0.29261229510487835, -0.6273514397185052, -0.604165058872485, 0.646407618606362, 0.560089833901597, 0.5107783981036592, 0.31784252574884114, -0.6101641420839874, -0.3100559397505121, -0.2564985996547275},
    {-0.5993172532751683, 0.040370292674774426, 0.6608941007533169, 0.5257558400877005, -0.39730022072644405, 0.3287645456494244, 0.2887670848032201, -0.32746792953687515, -0.27529028052468646, 0.4707180624928325, -0.17077797747712936, -0.4856402040887096, 0.5055600454796939, 0.15663484804709485, -0.6698917547547283, -0.28331118500137065, -0.0049863428008783415, 0.07005130744653598, -0.226017720313337, -0.1471108899995711, 0.16851182925716135, -0.027508638247693975, 0.6288419025421534, -0.2268078306139444, -0.2023400696019412, -0.4371827514602829, 0.675551440472278, 0.6021111860033449, -0.3981334639726777, 0.5012137571359727, 0.392760085672862, -0.33047563031242333, -0.6445625034558524, -0.6129418054726307, 0.38250299800625737, 0.19318846988523788, 0.391019706436246, 0.47972406015732855, 0.34357932380555994, 0.11556701122670675, 0.3972564868732706, -0.595927981398102, 0.24870652507927798, -0.4019369818541663, -0.590869852671915, -0.11951517737187023, 0.0415171865318484, 0.10018447433541301, -0.006521403137211247, -0.41319549226389385, -0.5209929903278043, -0.12704713052096592, 0.056134481896842905, 0.28031395341565396, -0.5294653138788992, -0.5555666501940741, -0.31940164551056727, 0.4249908107716858, 0.44038713576961824, 0.5862735909727418, 0.4349822323290814, -0.6650027115772571, -0.3743472925570338, -0.11401731038080673},
    {-0.45107885661824615, 0.3147043144030687, 0.467502265210989, 0.5515480928189601, -0.4598992478120885, -0.009546838909591637, 0.5816011440377263, -0.44622732254151515, -0.17619078086225487, 0.36858445004086093, -0.29051100493484333, -0.31764886484904253, 0.32165070461929784, 0.3033500454126908, -0.3466663500231031, -0.03739541002195985, -0.33525965429677135, 0.3694901162617771, -0.12390966971109518, -0.060656093669320656, 0.22608360931591912, 0.029493455814994997, 0.3323760963503953, -0.4382040778063163, -0.06721182921807577, -0.19723831293103122, 0.5945840054379052, 0.5244362026782269, -0.27975673966362363, 0.4157326453480596, 0.27160992213355145, 0.12768475124170764, -0.4825380516852113, -0.5155595642843585, 0.4104772817904029, 0.3653091358479031, 0.3838525249322578, 0.5799066483931568, 0.2342444606156512, 0.08961918318287442, 0.29619066450269377, -0.28484443806716947, 0.3823037183200501, -0.4862326695132072, -0.3477287981135386, 0.1387707918438049, 0.04538941393120491, 0.38311576074229814, 0.12291199192619749, -0.4157839521736064, -0.507304514355467, -0.1347407407175349, 0.20037324560773426, 0.2707451692184225, -0.3353088347433811, -0.6423184219019636, -0.31557855080593145, 0.6508525584441691, 0.4653519841512639, 0.6431629097306066, 0.307304867089462, -0.5877601421127447, -0.07194272542660221, -0.3486212419643499},
    {-0.48904844021059507, -0.07571248511664029, 0.6492556348505465, 0.5265588144828063, -0.5271630345360894, 0.30213912541233284, 0.5598229981957632, -0.4045887606241724, -0.23750820061157876, 0.2543548506755135, -0.37084335812281194, -0.43894718677433087, 0.6160651568236651, 0.2962519167226342, -0.6438493949125818, -0.32308333978682724, -0.21270875553126262, 0.06075673176076784, -0.13946192502851842, -0.307187141049536, 0.06800428444457678, -0.06698898525049586, 0.6219161826583786, -0.4772214593009029, -0.3074714886788491, -0.3445663096553802, 0.642829429483788, 0.4057842162504425, -0.19814113978687165, 0.23239383878901673, 0.2181899488769745, 0.12261687331672104, -0.4966639188212922, -0.49120777556305567, 0.4825613169542769, 0.4138655987922837, 0.07990047323063593, 0.40604975929673454, 0.25366856337986254, 0.16667595765087698, 0.5859775634624153, -0.5231901209887854, 0.14815622747349436, -0.44368098768097897, -0.5218022561502523, 0.013767037422070227, -0.29745878126692493, 0.11660982917914589, 0.025674554650655084, -0.5673894208379394, -0.35354079488682033, -0.12610478383082266, -0.01923848812871542, 0.5728436241003892, -0.2885118917299826, -0.6534863189850932, -0.5204111427015159, 0.4622058212075912, 0.4754336042329885, 0.4116993496537843, 0.18822378667437883, -0.5940420408034162, -0.1324016625979922, -0.36261701755825854},
    {-0.28845211881194294, 0.2535749167531675, 0.44248669976743554, 0.4329813432214297, -0.5517865634422224, 0.18224798066196649, 0.510847469653833, -0.2692331079843958, -0.4633228235027113, 0.23365120873550965, -0.4563522746961694, -0.225980636803774, 0.5722682294455846, 0.1265664095881531, -0.6634020441270716, -0.32814649607289154, -0.1828903800633711, 0.04316998921135148, -0.31899827636206673, -0.18437696890506408, 0.13343665688612594, -0.16462214614790063, 0.6446837946441507, -0.39942220724535743, -0.23368666054032822, -0.40280266485175437, 0.5920620531666223, 0.6157977275634386, -0.3233832077156048, 0.3573699116681951, 0.2410760832721141, -0.18302778529985297, -0.6733309535910547, -0.6113664520648119, 0.521094968836131, 0.5184873810578766, 0.1101175878808584, 0.3239773964904545, 0.3605479400909004, 0.12925474672685006, 0.5933880391305414, -0.5647504785821308, 0.33406401229970006, -0.2869922622347445, -0.24425451219520497, -0.19908127997188155, -0.09182366682675468, 0.4208110616903778, 0.023859689181612645, -0.45564367035873543, -0.5248004472654573, -0.30370330026447967, 0.12995493401702576, 0.5717509348498375, -0.27163704825603047, -0.4191671164661943, -0.6337455995102551, 0.5478874605253373, 0.4164309233634934, 0.4537388686616346, 0.3983289796746467, -0.5875227759851708, -0.22451498484188082, -0.35794883407520434},
    {-0.08316898369770705, -0.37165584178969996, -0.35431278935331834, -0.009926328581038247, 0.1359626709352538, 0.32155797399685787, -0.30180848073700683, 0.17071693980590344, -0.2858110072248817, -0.30354388292073553, -0.1806808956388648, 0.27965166924126894, 0.18807418070236254, -0.158676212261645, -0.2636427024309494, 0.03951706030736269, 0.3536168588792001, 0.30172380069005234, 0.09834678622089449, 0.12585898805704918, -0.36314536958665505, -0.49694547290230295, 0.13958273415905573, -0.0274202507520676, -0.16718290250412268, -0.2209034312396349, -0.007559656248077686, 0.4370254381602926, -0.0008341861592698725, -0.25919128913756584, 0.11261057215155434, -0.12691887408003377, 0.3040518034254961, 0.16367410429805038, 0.20578017408033375, -0.32233670656395846, -0.006072241735831823, 0.2847773199127043, -0.3331249605605765, -0.3987688792641545, -0.15669111412515282, 0.028402517086088833, -0.3795866927075855, -0.14525691481233768, -0.09613934950605794, -0.011056569089654043, 0.03086063697546705, -0.4000213470593349, -0.04645648947882932, -0.39238243985886945, 0.12849452078766777, -0.28645107864153146, 0.059738301668593285, -0.44055661257446743, -0.3333878919357029, -0.3864296520993543, -0.29678843669134913, -0.4078941230304323, -0.15339023078292258, -0.10310280370791156, 0.14502284486845682, 0.1719593855699833, -0.07028419672984117, -0.028453659209308504},
    {-0.024831526049181145, 0.1816516837129995, 0.27560715134560976, -0.2362152187528259, -0.1701140492775796, -0.0844862537298899, 0.10953857728572203, -0.32157299844677684, 0.30514613898065285, -0.18276780287290015, 0.1970832901583866, 0.07222702525473983, 0.25831512880792584, -0.08228843802638497, -0.07229390314230233, 0.12310356603679846, -0.31848523886663177, -0.01356539557844089, 0.205103781464197, -0.017147815782082895, -0.3577479314208736, -0.09493165346736188, -0.07434760402513199, 0.3426427786744709, -0.30847972395228884, 0.12848724483161364, 0.04647931495920007, 0.22711744237341547, 0.12215056309383444, -0.14971177288948898, 0.25522098632303, 0.34101259543301515, 0.12952289186351093, 0.26465782198780746, 0.05650494450885886, 0.1310752600737555, 0.18721206292196166, 0.08689564298646205, 0.12832922634723185, 0.1006314026230512, -0.16715767015246846, 0.015667083025652555, -0.274288686180201, 0.19125293756428163, 0.023177449223992702, -0.23251256618492483, -0.3591581557486212, -0.007461066089774115, -0.15935473935944525, -0.18025138923898099, 0.3672421200011127, 0.24099249633173983, -0.15508400135561637, -0.17712744601453623, 0.08863631745761315, -0.046102142779186596, -0.02763592136006465, -0.2273641324483137, 0.15053523958698997, 0.018432167860040812, -0.18602072658179702, -0.19355671681160347, -0.0029351475453525764, -0.08390510167182874},
    {-0.4282022007515449, -0.20541508203941197, -0.33288916060605733, -0.32504422133788696, -0.14898013628457624, -0.48642693696308115, -0.2981691937708065, -0.3734612394401734, -0.1912689771000731, -0.19070870790235459, -0.22217391456396313, -0.25622809578604117, -0.20661328622994782, -0.16599946665106063, -0.21934965951470559, -0.3500695939548827, -0.40401385096217646, -0.17144056400039015, -0.14709113476662128, -0.543208342664377, -0.34226589219801823, -0.47684056957881255, -0.20575843199825056, -0.31795953871071814, -0.5241121623760137, -0.4432746000990989, -0.5105378085496213, 0.22961780920191635, 0.05419369013775694, -0.5632110391932194, -0.5518856956963295, -0.013106519290779163, 0.22133441052177807, 0.08271577304931767, -0.39631969834931197, -0.5357302490253381, -0.2750376121995744, -0.382655364602946, -0.3130696967636297, -0.16269512154396928, -0.5444820722954891, 0.13910023462123725, -0.5403420179549306, -0.08633903814113011, 0.2471833422929446, -0.2970934724538942, -0.49691708816221625, -0.3944808606611212, -0.3475706731264975, -0.4589266207783435, -0.2406989709418897, -0.27969449414113345, -0.5576275487237585, -0.19469079299000105, 0.07998960493458332, -0.14567696961610266, -0.31057416048826325, -0.5304276963646593, -0.5560902591502495, -0.27836118339276433, -0.46557693207286316, -0.24722971408530475, -0.21056429396892787, -0.26138879191683023},
    {-0.15787213225663382, -0.2421662810656947, -0.4485150606371163, -0.18007718178884985, -0.0017977145848928563, -0.08699954433566531, -0.3806919530547432, -0.30574927877014696, -0.30107717729117306, -0.3792251419239194, -0.4572015188953326, -0.20873496157372762, 0.0581080056158574, -0.03942804798709903, -0.24864855817690232, -0.3322305333141695, -0.050116569991114655, -0.30285961669343203, -0.054116259331154055, -0.35433588120235116, -0.45812189213771765, -0.38139314719061035, -0.44167860348826227, -0.4265268314157448, -0.09174070422111669, -0.19436304443023622, -0.3496875595495795, -0.2742250951612823, -0.09867368481075525, -0.35221910770469717, -0.1389932700719415, 0.031085513113117715, -0.15420858518147257, -0.12659359487902294, -0.09805277240658908, -0.44282263745886286, -0.4479953241591274, -0.009847947418654817, -0.3666504023918453, -0.1393628479093881, -0.14667427958684048, -0.3101409718452785, -0.2608528827965303, -0.16774967255463066, 0.1351925174437309, -0.3611087707651806, -0.329618295412357, -0.4122458585637786, -0.09329202560021209, -0.4287921347829261, -0.2529629751884553, -0.004878907889000141, -0.1572831053934384, -0.14234376863028506, -0.26505822938933515, 0.007657576735228551, -0.35085376550227176, -0.09375426423623189, -0.3969479658688792, -0.030518691737364843, -0.03537348048968199, -0.4643909985505198, -0.32421333234605015, -0.1597615012479037},
    {-0.3302181322857846, -0.5134559292498593, 0.09236698543054385, -0.41979445078176625, -0.3536016759858884, -0.5381298876089401, -0.4826818359869486, -0.3982051731672394, -0.038922884618801314, -0.5347239029199203, -0.3471591049594161, -0.5430309254540314, -0.08252617065095233, -0.3781154754789101, 0.019537206909927742, -0.4343592049098561, -0.24993300359866233, -0.22328674989527822, -0.4171687837017384, -0.4245388653165289, -0.39421772775970976, -0.24069109590065432, -0.4432091452862246, 0.05805368889994352, -0.5206485618132725, -0.492830530649343, -0.1368770207934289, 0.13121182557035072, 0.10785777874114104, -0.2718324564138198, -0.3171860957324905, 0.350392008444536, 0.02676078166085336, 0.07813120950727596, -0.22834667594869243, -0.3281308384983575, -0.2718412019138315, -0.24039078863188257, -0.46061622945689695, -0.13655245474837238, -0.23824198061305338, -0.05096118102314842, -0.15782495513686542, -0.21094727237089309, 0.00399376180176814, -0.26374107609071595, -0.4349406867348168, -0.37468005285262707, -0.15566486730241672, -0.5117936209671315, 0.11338931571306285, 0.20551693449424538, -0.2933336145117852, 0.15643773546749398, 0.10023853976676396, -0.34318045610681613, -0.4751836028189097, -0.2062803289379671, -0.34540675266159787, -0.14062787408319016, -0.15462101348653093, -0.21553690832634276, -0.20841980143703892, -0.4165454781820139},
    {-0.054747803510444164, -0.2832424541243175, -0.1314173383499178, -0.43512830673195896, -0.17952920462112218, -0.26653474453953346, -0.11046087098451085, -0.49384349673560485, -0.08161611629290032, -0.4363659281504799, -0.4216127026121517, -0.30224718061201844, -0.22261744927844432, -0.2303787695187164, -0.13911209968273752, -0.17915205828707767, -0.24306778539246715, -0.2776350184294432, -0.47737241209613523, -0.296786213001306, -0.10143924671616447, -0.03382654924857198, -0.21988250637816562, -0.04618636935022694, -0.21559864533792591, -0.43056708263374954, -0.3844486949938958, 0.1778569628703087, 0.08667988665028632, -0.1486527058972847, -0.1364532775957709, 0.05670767660598372, -0.1996388842417055, 0.0038987787942406185, -0.44103691168729586, -0.3748165315465719, -0.22817787757815894, -0.4184311749094511, -0.47697888349429046, 0.11759757821387483, -0.4943654206239418, -0.29645460293334136, -0.2768409145114815, 0.21092769306199474, 0.15866065460021606, -0.11111671361640214, -0.321890665469496, -0.26049260769327354, -0.4615717367903588, -0.07046306124193714, 0.07906438276525433, -0.16258484415797872, -0.35844867197160446, -0.0317461843339011, 0.12287809795194948, -0.2722231294773385, -0.3094005293652354, -0.32941796327672757, -0.35509745575747703, -0.19157629570071144, -0.027815283548482228, -0.2210462679672226, -0.08553836153877344, -0.2123301098061189},
    {-0.014083853833674807, -0.4935974136665383, -0.14157387372584668, -0.1948485993082884, -0.31987090785936284, -0.36157265943723865, -0.16135649809762287, -0.29672451985027515, -0.25255713527865115, -0.30630450893415073, -0.33904797535800335, -0.4175796950825049, -0.15078071748076163, -0.39023991808838737, -0.0614175776582831, -0.434837601497779, -0.5290973241746231, -0.10773991845498683, -0.39348308935754106, -0.28289550902330035, -0.13680447916328284, -0.3268175095732542, -0.2305601530954752, -0.220860616014102, -0.5304015431062797, -0.22911955033500336, -0.2878749180253755, -0.08226110831099961, 0.2078233089032916, -0.5046108811175012, -0.2252788441902888, 0.12982222457131093, -0.2780690405616529, -0.1245739118146516, -0.4024905395670112, -0.2119002363573147, -0.3504082483398265, -0.21268835929214522, -0.5126765209951045, -0.09379043431382744, -0.46929308584793744, -0.13999009706314486, -0.5153732603979677, 0.07203654734055505, -0.10970697518814428, -0.3568565924007412, -0.24454087327753968, -0.37012808674747144, -0.2933641671014139, -0.2887600556532846, -0.26997594087685567, 0.05352138696901372, -0.298443850333957, -0.06853307259465723, -0.17400169628822376, -0.42696350462385696, -0.3717631251107271, -0.2774867180608712, -0.2690449108557844, -0.5102771684698163, -0.18124094346222466, -0.225052008660508, -0.23321876194100155, -0.4712867978524818},
    {-0.18622150811619406, -0.07555893895138904, -0.32365590093718405, -0.34982474084088794, -0.30389248883980974, -0.07002648901936669, -0.25092339398557034, -0.06622898101555533, -0.2444159338626261, -0.4888325510438608, -0.10723150554765062, -0.4575532699607266, 0.11387615612906675, -0.32559657220541244, -0.24839695054654526, -0.25486071496085494, -0.4632389273868069, -0.08062599405204104, -0.2125665188579319, -0.385529056571302, -0.1559240164453806, -0.2007117437710449, -0.21270890225767972, -0.12414824188323706, -0.14598662001994647, -0.4423974138313989, -0.26751984448299015, 0.12500273431087844, 0.06380982682421, -0.393534941688126, -0.17767310576908246, 0.16118136680780448, 0.07284211040640183, 0.1606206784568403, -0.10835336252510856, -0.33041315036701907, -0.1138804895436004, -0.4417557825179333, -0.3616324883560294, -0.030908503115029577, -0.5187551685462388, 0.046746262556281414, -0.2696863552333535, 0.2651575981994917, -0.1850824168123655, -0.20190475053936308, -0.17433606329351628, -0.4235276939289289, -0.32149876214281053, -0.30630045771169284, 0.10544152109860849, 0.12153595588319861, -0.33730179607650884, -0.04175118812229456, 0.04252943989179914, -0.30907831480993264, -0.3524588017567461, -0.25992895067827937, -0.41009490952436584, -0.2191150957474652, -0.18809633134594272, 0.11925404264008346, -0.1109845318307289, -0.2627686556229266},
    {-0.2702877658150632, -0.10569144138796963, -0.18599505735656205, -0.33776585411951776, -0.46646462510743186, -0.5486482092481723, -0.03904768161342581, -0.01660730046718459, -0.37098235110394556, -0.452396669336661, -0.3040105776299759, -0.3122086290078618, 0.19016847872507905, -0.5030917236239366, -0.02281151568664474, -0.16887488401339976, -0.5018319049186545, -0.17811993429271264, -0.4462771118970363, -0.19124042916943082, -0.22382203238761275, -0.3173375691590459, -0.44436467127194257, -0.1583201460590673, -0.23986664786939363, -0.5037884209833621, -0.14245426041605275, -0.049911093312643325, 0.009565416464599782, -0.5199988274479502, -0.10723397581593787, 0.22839471925292334, -0.13219846951937844, 0.019318889846349763, -0.2193064352985444, -0.5078938924539879, -0.2744236003971049, -0.211221966492995, -0.3294778060061561, -0.18926489536587812, -0.31266033920883834, -0.28259715845590877, -0.40747117935030674, 0.2274774761586931, -0.19864438656517328, -0.3691744979500869, -0.38447157904840557, -0.44105973753304184, -0.32998527363142177, -0.3569990279964072, -0.024140242858759462, -0.10471957419642428, -0.4932973527672137, -0.20787744671710093, 0.050028285467382534, -0.030256232017609474, -0.40544812306379946, -0.24678392231028215, -0.38337258910107014, -0.15271356789233628, -0.449860830520331, -0.098195563141006, -0.16842762211870785, -0.19897909288277704},
    {-0.13168508317638572, -0.21503096931654836, -0.3553836774748575, -0.4096495690574297, -0.2989514690041292, -0.5260378888949506, -0.3309517628710088, -0.24655326536159683, -0.305893539335863, -0.52091325416993, -0.3210878942780272, -0.21794730439074864, 0.1364711565945183, -0.46003864728470206, -0.3769288321687066, -0.08996724290116574, -0.22840409999841702, -0.29307263618597285, -0.42985545981354534, -0.10905470727150124, -0.6003738882797024, -0.1421142310172088, -0.5481549284390479, 0.14625463135174901, -0.5602226427375658, -0.4663349681285492, -0.4189959977838924, 0.1066683992812176, -0.01811405895839097, -0.3181426954028448, -0.37603796489308894, 0.26437176637621884, 0.2031328828780037, 0.13103890063294393, -0.48229728286368345, -0.4988936448805225, -0.5344040880886353, -0.43645315854413985, -0.3477697655662251, -0.2845886886850035, -0.41257606070114206, -0.19056179542333876, -0.2530076299808736, 0.1748294155040758, 0.0021371190179537646, -0.5266025439051512, -0.3382632861012004, -0.47251224433429456, -0.5715551820726807, -0.2518708071304918, -0.23324913138570705, -0.2657022050393666, -0.4764539101801941, 0.11601120587095548, 0.13525741041692577, -0.05890455245392152, -0.4866701399368224, -0.28388503685993866, -0.4323508547910977, -0.08643751461460547, -0.3133433927484593, 0.05163118890171492, -0.4061260370976064, -0.26791484147231726},
    {-0.4113188968889864, -0.1230172974368294, -0.4655446198239729, -0.019710951773830355, -0.08092023238565747, 0.055662909619094494, -0.3258763933969142, -0.4343727962867811, 0.009357043921726293, -0.4093842808515712, -0.2563827146252999, -0.29269727854289473, 0.07990163279605818, 0.11039682061546235, -0.15799396091809584, -0.010968925083438578, -0.15772209510273819, -0.2273386510320861, -0.08825869110432392, -0.21390823778620355, -0.5096567899951757, -0.030151431270408726, 0.020943351546855307, -0.22228595180619953, -0.36202467205769634, -0.046035286164916596, -0.1499718566110291, 0.0014705103385980404, -0.05256940327315996, -0.21764190005430395, -0.28833131588370553, -0.1196067198780102, 0.14299640330528662, -0.16577177002053212, -0.3549254808627726, -0.13979163424844818, -0.1820837902909526, -0.07924699691212353, -0.215384044565146, -0.2800517676191018, -0.0861537803253519, -0.16364239855981672, -0.38975304449966897, -0.04120757661818575, 0.09706733383546973, -0.2687143406013108, -0.35725172221134893, -0.4444637163316503, -0.446171237206826, -0.42098117575901034, -0.16094331024891323, 0.08705243081172988, -0.08002115586890046, 0.03642103138688927, 0.1380116923982293, -0.1634877840602393, -0.5164665129822652, -0.41651391346391164, -0.31021888115865376, -0.05571474498585881, -0.29365878623173797, -0.13050847095503254, -0.2845380790510788, -0.2093072369715676},
    {-0.44816297965074475, -0.39236653730210436, -0.4043575635939074, -0.4481265620747083, -0.35790931344389615, -0.1519427493811532, -0.22142497839149355, -0.38148360399044706, -0.21093373508962182, -0.1781303084636432, -0.35156675147139466, -0.1584956897035138, -0.027301600227668994, -0.420910723931367, -0.11311794597427988, -0.2081088881254098, -0.2766081442950225, -0.2011918173294177, -0.5745692992303464, -0.4596180829745384, -0.5765929266355982, -0.10982166861531147, -0.33782082788542506, -0.16718334169818927, -0.3793869370876618, -0.45579571357171556, -0.33074464331067516, 0.30799989803900024, -0.15406625611516986, -0.3589286653581344, -0.19856568324184373, 0.11124243481435736, 0.11353986287229784, -0.05878668668876625, -0.1348803778245622, -0.3224414877578245, -0.42433150450469936, -0.4273073095210549, -0.24256562213449126, -0.024465454871051104, -0.3975380645735931, 0.03586680984428597, -0.5072096873285771, -0.046107668416038264, -0.13263626437195028, -0.357972215120211, -0.4958602368093314, -0.579171216882465, -0.46848296663889866, -0.37656340033482993, -0.25859758423753343, -0.2810959554583277, -0.5317184915518773, 0.15945325405320163, -0.1708889754183142, -0.02159071938006525, -0.5653940445180926, -0.20966057154655182, -0.5406472640692077, -0.3589502993472343, -0.21092342778666173, -0.0033803489245396653, -0.5239130462617709, -0.43018903203920456},
    {-0.28480771470512056, -0.40676051078646636, -0.08207462517142596, -0.3358347418695809, -0.320398149041899, -0.37457240419845883, -0.44911130675720695, -0.3759923523773069, -0.10392699363577315, -0.4858534818544178, -0.32766025782556324, -0.3781509912852583, 0.21192702646198777, -0.20549895054482903, -0.46240626130783413, -0.36698986050873084, -0.3584995369441222, -0.12758564156483043, -0.45170464842084945, -0.4713937197227418, -0.2703103406440433, -0.1382717947007022, -0.11792760994843351, 0.007610999986620855, -0.4733363754047571, -0.31957978180360164, -0.4087564434134356, 0.14599604892415569, -0.13404433249396575, -0.5553497247981275, -0.32006858411637334, 0.26522216710838276, 0.06948814229525449, -0.13911205382835826, -0.5193182235119042, -0.6301330116840396, -0.4370652092413099, -0.4614835921846023, -0.38113601903830535, -0.17967940556291262, -0.3669424514393364, -0.008170216922155112, -0.2793514892184901, 0.04845277686449342, -0.18938068730826382, -0.4686134707865248, -0.5811882549554434, -0.5878496386059526, -0.5454265445752043, -0.4273260664221323, -0.04331314064707171, 0.029605053774386256, -0.4608937483628022, -0.2835913654898584, 0.055887904433864585, -0.2104192755741039, -0.5893901723925918, -0.28815921623493723, -0.1810541485246099, -0.07975664666703562, -0.49513744147255795, -0.12555428483073508, -0.562616550404968, -0.20130637189570724},
    {-0.06064363525687368, -0.2724505956611825, -0.23947682298412076, -0.36929022866521427, -0.4547013915524573, -0.25375251199604004, -0.538325930589368, -0.1459648388828635, -0.16335493073575966, -0.509067214476541, -0.43079382007767975, -0.5355127287370512, 0.1730183143114573, -0.34228502071535016, -0.20939202816141164, -0.21337634022111035, 0.011876044979575121, 0.12013707573583807, -0.5917794359141028, -0.30469101351503136, -0.29444459623571967, -0.4450296432435365, -0.06776852877216953, -0.318312020929969, -0.479331588466907, -0.24921881865108456, -0.18178788529101664, 0.0890244537005069, 0.20923326603111153, -0.5473342227837611, -0.40941506647596665, 0.3384889752244103, -0.10576132199326502, -0.14581798624207756, -0.24468030953343223, -0.36256337973049374, -0.290195533634838, -0.4706592269500879, -0.47116552106195014, -0.1671492171804102, -0.5706171944765953, -0.21070614967575915, -0.5219713601329964, 0.19851963993224558, -0.03732880612161364, -0.4413409242350296, -0.45957257395375684, -0.26137914838535614, -0.5244185311005126, -0.604397448261442, -0.06878880662797733, 0.0026844471232058066, -0.6495595107721072, 0.012310413231617719, -0.3356228620115762, -0.37350118394388054, -0.6122766025525607, -0.39363873258077803, -0.4772888673884238, -0.3055902426733255, -0.1735778584502494, -0.0601931084636384, -0.2678814064683481, -0.19891631291996928},
    {-0.04225771859550389, -0.38443904767810244, -0.19733333684861262, -0.34098100804021086, -0.2991973361497484, -0.11700246186002759, -0.42539366091156045, -0.15375347698541877, -0.32383919626947555, -0.2890206690271204, -0.3906267740497149, -0.2525484779293432, 0.24091922974494603, -0.15185673594431362, -0.03047402080039108, -0.4838518580283299, -0.1288550328205235, 0.040421827565382255, -0.2241379907677582, -0.4353780151461734, -0.6165870402991651, -0.4237963997863891, -0.3144937940772451, 0.08964121974852027, -0.5178725321716279, -0.5463474636746951, -0.4989781678411019, 0.44241991219685384, 0.0613327950201815, -0.5953520163134094, -0.34648082191122687, 0.4280239973853482, 0.10985471355278711, -0.09229362570998412, -0.2693972972558315, -0.29568404215954575, -0.5677281365740825, -0.2951520603199011, -0.4288674405803114, -0.17589619213461236, -0.45609005886157095, -0.12806773835256352, -0.6207718952023533, -0.021328564940486475, -0.1751578652577717, -0.41009381035708414, -0.22683578037398472, -0.6152457345058928, -0.2955790208210184, -0.3783023813785879, 0.16692963981044873, -0.15027382727419258, -0.27213403978664963, -0.03177095364172403, -0.25519647384704885, -0.03742816523585941, -0.5636468838547629, -0.5064787875456633, -0.2005739735045246, -0.18494265354840464, -0.5017792463597309, -0.30410188221267276, -0.22465446648318363, -0.2655237940938345},
    {-0.39792959301886877, -0.23982349279288404, -0.34209641007894037, -0.21333304164875824, -0.5432715443467399, -0.46890449703225323, -0.24734134450428655, -0.334450491185354, -0.06832694955150805, -0.427582973558239, -0.19368890536542155, -0.43850805626873446, -0.13239154323405358, -0.2893706855228038, -0.17053510431729238, -0.2671871557334419, -0.03525541023251425, -0.11136792290994413, -0.26738759552116065, -0.2243905436534537, -0.3318563020447804, -0.39462705058744757, -0.04778759316312332, -0.18405485033078742, -0.42987141691454145, -0.43147630673199405, -0.238137090186475, 0.10249737586454853, -0.09613131329932088, -0.5936333817456894, -0.28707019048015964, 0.38713260168468283, 0.12265898982282997, 0.17822328003369792, -0.1339935148544559, -0.4295800881100061, -0.5699504902385716, -0.21671455442591037, -0.2978786455983405, -0.2972647706078195, -0.4202508411653968, -0.21648949660573596, -0.6205449835777521, -0.2676461324555854, -0.21136241915466103, -0.5145984189118057, -0.3394372149277637, -0.5935877344108661, -0.2865086657685605, -0.3460087839558458, -0.22637311725033513, -0.209517215588668, -0.5513468908748809, 0.05553545959545607, 0.0749574732700071, -0.38172688027682083, -0.2508507407095893, -0.4723858631337502, -0.33437898260824206, -0.19461594660359802, -0.30380365791351455, -0.39719002365971856, -0.11045504831328679, -0.17121898892909554},
    {-0.12304644301451353, -0.25206724349604787, -0.4858088988600822, -0.349200139668002, -0.5311457666811732, -0.2834431164371079, -0.27854917272772345, -0.4364623341528689, -0.2789528642551818, -0.42203473283278997, -0.3091093173861701, -0.4227266253924013, 0.2024543985507042, -0.3731558993327601, -0.068054264161038, -0.08310973481114659, -0.038158960696822244, -0.04562545825196176, -0.19730165809509917, -0.5024784093170579, -0.36977676599490145, -0.31080195936832167, -0.15133132491744103, -0.17016960580325183, -0.24447788109122198, -0.4094565064962585, -0.4428681078438778, 0.1446339536001261, 0.028622305312979993, -0.4751248480322801, -0.19001065103643627, 0.30965432828843903, -0.10175105184987321, -0.040763295296939575, -0.33299038242506257, -0.2342835638213537, -0.3724043828565922, -0.371528652906461, -0.1436993221186914, -0.24313358653585057, -0.19545142703030355, -0.05540080773146145, -0.4728502021157007, -0.06270625909412868, -0.058412388378366424, -0.4973447574720532, -0.4085158758373322, -0.6119373879621642, -0.3554025219126277, -0.4887955400178761, 0.013302131114335706, -0.2691865497661731, -0.42293655318133616, -0.29729839216402576, -0.03074713236293514, -0.18058500391257648, -0.28310443862106616, -0.5583668156311408, -0.29203400553863124, -0.16762467850667767, -0.41868367413728713, -0.12317613077658893, -0.152107249401207, -0.11529115581834923},
    {-0.3513583753090236, -0.011820209463542472, -0.07680503710128449, -0.5154518534062561, -0.4810901767615444, -0.04239984492687699, -0.5255841370390777, -0.4811102183022018, -0.3341726147503598, -0.34826646222967195, -0.5291219557161296, -0.20021262607380064, 0.04029597314504809, -0.22252893189085124, -0.14698161765202483, -0.2521973717408393, -0.373493531069544, -0.13895988692259087, -0.5407533803146725, -0.15860966013771186, -0.5695591030877215, -0.4864963115080223, -0.29297900650385034, -0.28002364857353385, -0.5715268187771894, -0.49271339451800844, -0.07721112292424229, 0.13948420427057268, -0.005728287426100246, -0.5192530089171311, -0.3166450839859179, 0.2414210055212745, 0.18143067717675862, 0.2830214431645979, -0.35124932177341167, -0.5088933982487976, -0.3092450766954674, -0.13500420026179205, -0.3301910934140121, -0.17055145347665143, -0.4041023143231319, -0.3649851879229125, -0.21539452129712536, -0.05200849136457448, 0.06926499876798559, -0.29078069566469533, -0.42461239436268877, -0.46449002800306777, -0.1302731335026647, -0.1954774259082313, -0.008107061825990122, -0.43134020182172667, -0.5996635835552417, -0.06294537670308702, -0.30470569594706476, -0.40229203775594347, -0.32313896353318633, -0.5006509458019691, -0.4829154853999413, -0.5267331563104863, -0.41213988835823784, 0.012198628290716218, -0.11622411180143132, -0.38133167167642407},
    {-0.37928260073653786, -0.02434052976963034, -0.2662228778086116, -0.3877568150881746, -0.2988268598304877, -0.040569763994768755, -0.4594833358593055, -0.2957120440050325, -0.5111464039923734, -0.025715627599784817, -0.2940863465607619, -0.5098231451262322, 0.11946851627202386, -0.42400288064830105, -0.24997348078004714, -0.37840540237252834, -0.29878645742921633, -0.16479059649497377, -0.4312715169975999, -0.4453834343051998, -0.399300527475311, -0.3812769728887629, -0.13349010533418448, 0.004417351761045022, -0.30385514068530506, -0.21055483410334208, -0.321269040932372, 0.17018920760440456, 0.07410935777309455, -0.42124116862556327, -0.07089968576207907, 0.39428840622781347, 0.2004493249424355, 0.18078291930926468, -0.30589718301382757, -0.23064963049762413, -0.3229226349851275, -0.11177375768222235, -0.42606845673127874, -0.16375469322540492, -0.5200243733661639, -0.24200544400170285, -0.44051479024920837, -0.3223418148346664, 0.10211484519259717, -0.2964586645906658, -0.29801704191882056, -0.5887750512844149, -0.09051254660378429, -0.27041328310448504, -0.23084499072764597, -0.3890840176374951, -0.5460193331159148, -0.20188041858146613, -0.23902297667438974, -0.3304222922140214, -0.28195076809093755, -0.3746925340689427, -0.20083077275301736, -0.178553417678774, -0.29038285643423256, -0.40449364633239476, -0.23980133816389768, -0.3621367762683661},
    {-0.29850903110219884, -0.14194435331621827, -0.48950158593196863, -0.47927769840272694, -0.5204611785403195, -0.31099675443463815, -0.36222127991887154, -0.3746995343608903, -0.48807158934035144, -0.3177615926655356, -0.24123563107289733, -0.38968946528604814, 0.20986855957339434, -0.29448652246206775, -0.31193303085828106, -0.15959539155236757, -0.05467193070013928, 0.06498797951260336, -0.5236762080421045, -0.29726832460057107, -0.6488311474117113, -0.19657045754163666, -0.245933263742877, -0.05621010860841073, -0.29725780393601964, -0.18372922166770791, -0.502738010459974, 0.31884322332054194, 0.25710093374727105, -0.4951539169980948, -0.1264044884076632, 0.2059141447556931, -0.008142326897648704, -0.23370269039891323, -0.348497509258746, -0.5225000972728131, -0.382937435606805, -0.2555884898339491, -0.18910651146887686, -0.3398138970267292, -0.2326585845392621, -0.3872839711927865, -0.43203392507156707, -0.08256383064954104, 0.14838978967929362, -0.4446223988968806, -0.37506433861019134, -0.6179014679798256, -0.3795331146598089, -0.5490930326564419, 0.010792797557794713, -0.19901750676987148, -0.6223185067399538, -0.21350951156095957, -0.2150027320674449, -0.39021625963100787, -0.5175959494582489, -0.40903988359323484, -0.5152196189670609, -0.06907959121740533, -0.39978780413827864, -0.2523269175111511, -0.3586425623942877, -0.20660690418812375},
    {-0.41890082555071173, -0.19700850439440631, -0.4039515122591298, -0.3184708314785266, -0.5804737872372533, -0.22429019313599638, -0.5753390288068483, -0.5223462888787814, -0.3811073935974932, -0.3974926148279886, -0.4420362070137177, -0.530056525979164, 0.135033024053647, -0.43950738538619233, -0.27854096837425824, -0.2066576413870637, -0.30460487644117806, 0.11083176698792739, -0.5715438303497121, -0.41288649332934574, -0.5074113342654347, -0.37102245145160534, -0.08513543189859449, -0.2689010389672207, -0.651606274353379, -0.17476641368252294, -0.25626902408504004, 0.26714765328163353, 0.03226003715365609, -0.499470553082432, -0.16442311891514033, 0.27682923055641173, 0.017099175776361483, 0.1361264405482499, -0.21667318254225257, -0.4940733975952149, -0.5480301681764213, -0.11379083356606254, -0.35530325466428936, -0.4032818468392637, -0.5145030661681059, -0.23574453151965127, -0.5846383074615265, -0.16588845640537944, 0.26630185635504505, -0.4398563128392818, -0.5269047695117709, -0.3225934734108916, -0.21738053564264448, -0.6333174681593532, -0.003887742941439872, -0.020851072517145564, -0.6092064193995521, -0.30237960075360387, -0.15680545318469358, -0.49508451314293594, -0.4539808575143819, -0.6001130542592419, -0.4613950847045463, -0.4201250954401163, -0.22961245716846543, -0.4785857715990322, -0.2703919829499004, -0.4037438827387166},
    {-0.5570074769376109, -0.47647615944022675, -0.4294639941863853, -0.46681438051369384, -0.2921726457055319, -0.40062626694822584, -0.25472784092694734, -0.5345990091087537, -0.5237933950927544, -0.04587625949268178, -0.5671284702364048, -0.22503185147367943, 0.2563173351716774, -0.49742057484830654, -0.2168833031693915, -0.3271316538070706, -0.22596346671089004, -0.018996210517570306, -0.3571663278737284, -0.36524699134689564, -0.5678238046786991, -0.6636953711757854, -0.05133386358773214, -0.38578707830142783, -0.6070948724219324, -0.2756409887803536, -0.14533490536173363, 0.5617413860127485, 0.3657603329740328, -0.4769906168411285, -0.40676113816144854, 0.44850751282370516, 0.3784553203708672, 0.16969733236310064, -0.49351986822979843, -0.3389831788550791, -0.442221866825125, -0.07077470452897767, -0.2810148531304157, -0.4398962485416761, -0.4485719886908526, 0.06639295984855144, -0.4759260805261845, -0.05847956984392456, 0.3796762548766669, -0.2764286667152473, -0.6352662336832968, -0.4178037515286444, -0.02067923513401589, -0.316523427581621, -0.35532730569404763, -0.46676263016921143, -0.6091923962729582, -0.25134343895756667, 0.09865223736563904, -0.4130636804146388, -0.527382854057758, -0.43490929110389115, -0.5557846099361707, -0.2805907716939848, -0.3523098706269315, -0.3788835013208028, -0.32447459854470734, -0.20320204362623775},
    {-0.4847037636153259, -0.05983500360633802, -0.31215436161459253, -0.6056556186237343, -0.41420661500458555, 0.11654340308534289, -0.4895784786590804, -0.6149554554208113, -0.3931279372975105, 0.02864901713089212, -0.34428773961143105, -0.330797533463041, 0.3322225563844545, -0.046354953917709565, -0.1887994035753663, -0.4662831355650399, 0.1284790270865937, 0.19869453682949317, -0.5597470615430508, -0.3668379357929649, -0.6330676467136572, -0.5473067862114365, -0.1567974546872828, -0.20903667745967386, -0.36760573780860417, -0.5076087231663398, -0.27674010533255744, 0.5777742822475476, 0.49766183807163467, -0.5731203309910032, -0.23741470910276086, 0.17788815118373447, 0.3401962042936704, 0.4176814953290909, -0.2967550656519441, -0.5418561418029446, -0.4148808100795045, -0.02809900928345573, -0.1000593395987586, -0.553811574725984, -0.2838482645918336, 0.021505507112411504, -0.576372434750121, -0.40257216428800274, 0.2651660211246458, -0.6093661090549413, -0.6632925010886567, -0.702290074493554, 0.16054537150327636, -0.49917857158208295, -0.1525531600712037, -0.41300300840004667, -0.3045029973174619, -0.28154197183614166, -0.08063813516046951, -0.373339244689683, -0.29014513200386893, -0.21868199143295664, -0.21918010073523936, -0.2605000867262696, -0.22588735883956115, -0.3469734068668431, -0.2408532630082003, -0.1556036371221649},
    {-0.5577284112278612, -0.32926193480020977, -0.569897767335504, -0.4845290032497581, -0.20798410541203324, -0.012012487549169835, -0.29567582017548244, -0.4038788905496904, -0.4298583397590705, -0.3901531236473251, -0.4102682014768907, -0.5279109495525084, -0.05021876103924667, -0.45335291133870914, -0.3887058355105774, -0.43829771218949576, 0.10261242543594737, 0.16381431906609192, -0.33988323772808543, -0.31339315591730377, -0.5847314809049541, -0.3858437115924614, -0.18913411000461952, -0.42426171488099657, -0.6586320083155307, -0.570136387690835, -0.3525989571910298, 0.44887669346986275, 0.4136637511952743, -0.633311557055084, -0.130926902491701, 0.22843787916332395, 0.13892020945076086, 0.38283750445382103, -0.49780944614141426, -0.5668146193589936, -0.49367005766245786, -0.27117004104890013, -0.18939731224251366, -0.3181650060281137, -0.6281202642827368, -0.09495808693744376, -0.44972713652829194, -0.28982319522358463, 0.4111712432225413, -0.513096695369195, -0.7060928715593952, -0.7016576276299931, 0.012900941280584494, -0.25715829847692123, -0.3215931948808386, -0.41542597601430914, -0.6121962386537493, -0.43446951655387284, -0.17809480275307826, -0.25477755948976927, -0.43126726130454407, -0.35574465271049643, -0.3770014451882122, -0.26704483774453364, -0.22223937264478041, -0.31531475655355673, -0.288672897668853, -0.2634775021330626},
    {-0.514286422642984, -0.550206440160737, -0.23034471230498005, -0.6460498606091873, -0.2183341931292018, -0.23209538679913425, -0.29040172170996886, -0.6267011438264277, -0.30289631390744814, -0.2191478086651842, -0.3651322744852427, -0.4451115365514983, -0.021931374324627745, -0.49897501536398886, -0.18239149152543152, -0.24306198602908297, -0.29667789947295037, 0.03824708750778264, -0.5061255242113933, -0.37051974208711497, -0.5238248709408693, -0.35004897787434586, -0.5134708690337871, -0.36029096243224273, -0.6464635612415375, -0.4388699757901165, -0.3577290571683955, 0.21667936732338447, 0.12654595659188123, -0.5482231821008684, -0.5010353265872538, 0.07480139381966713, -0.15898140320434614, 0.13988340464468227, -0.5796624019931125, -0.5116192557690058, -0.6230621119671165, -0.2368773569745687, -0.35038204881088414, -0.27772011949345315, -0.45425846253232904, -0.15659859693037043, -0.30794876357878237, -0.17919745644277563, 0.0004115868874394652, -0.34010951705787706, -0.5801870692324277, -0.47659284419499576, -0.39695753303626014, -0.4783086441437379, -0.14011470523054287, -0.43386077718695815, -0.42313230646429756, -0.3594962728548042, -0.20400099448938222, -0.24191992644554774, -0.3605464924238307, -0.2653558952546297, -0.46422307082837716, -0.3473591863545549, -0.3390420036720204, -0.20550496527350703, -0.24935421993791407, -0.2845357852157139},
    {-0.4283114755396538, -0.16441128519698484, -0.6014665797468368, -0.6431501575330728, -0.20422792491354963, -0.033740138905780565, -0.4233283261481293, -0.28649122477242195, -0.2937502031469616, -0.1731267062385619, -0.3901210785466872, -0.4821594144179332, 0.35991517161158515, -0.0987217239642542, -0.526015584095402, -0.22156766579611487, -0.1953086617099324, 0.18369160220751246, -0.5243910478392777, -0.3572967185462896, -0.6434275493995207, -0.46194845892356207, -0.19353765687945815, -0.3636416662788082, -0.49781488089130665, -0.3355741171617039, -0.07621210061308609, 0.543301502127375, 0.170907531862071, -0.5392843467269732, -0.17353320046571374, 0.37550708419242446, 0.3286328109781519, 0.31356960765931335, -0.4935611352192619, -0.32174438194807214, -0.4006614467758912, 0.022440393265682344, -0.4821998199837946, -0.4813037288226072, -0.6224112320493315, -0.2806179469252774, -0.5028940314664978, -0.3403866498909892, 0.2796950345936724, -0.2825378870409363, -0.5572502036571287, -0.6345926895400016, 0.009156319519013486, -0.41279260749478175, -0.17473374968857666, -0.30155742134697383, -0.40869288356681177, -0.26426169301937247, -0.16763914599794388, -0.49624039465337594, -0.4794791578947145, -0.24515014666399518, -0.36134544461492085, -0.3729286103284467, -0.4646515505290976, -0.15376789980828745, -0.3516224185297716, -0.16882662153620848},
    {-0.5166956955138111, -0.42609034729116835, -0.2209920657961192, -0.41698930555039987, -0.27481259290575444, -0.31913712411102485, -0.4865637969825329, -0.5219256230859588, -0.46783325370046136, -0.18892764468481504, -0.4567812659819667, -0.1944257137631309, 0.3749274182149253, -0.271573743043018, -0.2657441272288179, -0.5246592605356749, -0.015468808862499194, 0.11134767702431562, -0.5105726810634251, -0.2512640741049629, -0.5634452607599391, -0.4323300138568922, -0.17972829265371534, -0.42545153762757876, -0.3734343066045794, -0.33594534380737645, -0.09473384097158746, 0.4460182950322108, 0.349413482579452, -0.7124941905622975, -0.13161538764322933, 0.05346406837655147, 0.27450769380296614, 0.16703101043275165, -0.26495669061188015, -0.3108118834150655, -0.6241822237863819, -0.004122667648579608, -0.15208860832230484, -0.5529711041499633, -0.3410169227067656, -0.008183659850076507, -0.31080942788539634, -0.18265894055519255, 0.0003786583251986013, -0.5980814813151786, -0.47335901058053104, -0.5562472716475072, 0.03454337099670389, -0.3570342911876904, -0.04008914593610512, -0.5345018861360059, -0.6490543500038017, -0.20066778912662012, -0.22917880449197564, -0.5099510032999518, -0.6240123561461285, -0.5029323256405241, -0.4124411393199355, -0.1312885146997661, -0.19159417636526876, -0.08686631098173057, -0.4632471829175344, -0.34013270843352705},
    {-0.3636176401489497, -0.1996647563191875, -0.27346545378277876, -0.5398148622724397, -0.5465890048545382, -0.3150037855427684, -0.3941560143670612, -0.23711090201642618, -0.4160933493070322, -0.2870706093727554, -0.41444339282419856, -0.43566797403596785, 0.2593260782364413, -0.5037123383056429, -0.1609713274834328, -0.3590660890571933, -0.003213471533307479, 0.09771723226947714, -0.45010042473187345, -0.4933953530921347, -0.37457988219213373, -0.5690802464422613, -0.1811713149088105, -0.43242077819037844, -0.5689045519312268, -0.5119663069175787, -0.30100845868787535, 0.50138415341504, 0.18635827984469874, -0.5698330982170399, -0.2035819515825498, 0.3295144695663083, 0.1379717855414465, 0.20893503858951668, -0.4010513319412935, -0.39361010639214045, -0.5112780913031755, -0.28119629595107576, -0.2453362079453659, -0.40119993167661444, -0.5791446498768296, -0.2433371367706865, -0.5577474841302771, -0.3340085119387666, 0.1969349684740757, -0.6203581360165242, -0.4834036926160846, -0.53990250832116, -0.01712472620250209, -0.5281856936540379, -0.08016891238007183, -0.20447664345083555, -0.36527110261954726, -0.06607300800296236, -0.0625112990682884, -0.4580392969067031, -0.4774307346699538, -0.46650272507499435, -0.5365705258347631, -0.23124243080110626, -0.3709219799303258, -0.4535235116704891, -0.37136696483268794, -0.5354228407125227},
    {-0.32281298123678864, -0.31505273431511466, -0.5428451966650971, -0.351492723003797, -0.45543607426554605, -0.07720096566702375, -0.3381298802707166, -0.3291464290694715, -0.6069061392663495, -0.06552150997001466, -0.611228853328593, -0.5481256068096269, 0.050990013750843985, -0.12900090225203256, -0.37633378951581403, -0.46489235428134185, -0.30624833835873727, 0.14772239635139958, -0.34545090360385466, -0.25164505045730295, -0.4300165505096774, -0.3352168816501495, -0.3036069253904914, -0.5023604788083021, -0.5248328655059291, -0.30865998283489215, -0.26313360404427755, 0.21707790070737418, 0.3385597580966412, -0.4377216468976169, -0.3438652337480763, 0.2276253268577633, 0.12908492099761526, 0.177435999282312, -0.3981938532283666, -0.3405654060563736, -0.5986032554828095, 0.016216643544951538, -0.4759071893084393, -0.4109166727485118, -0.6244426881248476, -0.12295547432507029, -0.3890749414378227, -0.3734226182243132, 0.1562494172823985, -0.5571226416964866, -0.6939300990975769, -0.57671389515348, 0.017338102824915606, -0.39457231730002834, -0.37671876393628256, -0.2021040121498463, -0.637384659117227, -0.3108154268656969, -0.21843358109464883, -0.19390870296515067, -0.36851751491892704, -0.2733789735170402, -0.28968390501026464, -0.4115695134111296, -0.32326793954397864, -0.23574191304005152, -0.21468330036926353, -0.3645138249404784},
    {-0.42125706530690854, -0.25386787187031656, -0.3622090585281458, -0.632235792402416, -0.44799434126513854, -0.06842190878307629, -0.42456515676929213, -0.4892101268528118, -0.3813252093796587, 0.08340956028607606, -0.34696960541854555, -0.2036142437243818, 0.2746439900005144, -0.059125333809135414, -0.3103122145226808, -0.15153800128542275, 0.1759165543598731, 0.1609155216660725, -0.5964616515672475, -0.266140405504677, -0.6543798205945834, -0.4016581438841505, 0.0007807028892564275, -0.2741294670590275, -0.6106822884342562, -0.46802641517691085, -0.10438465685590989, 0.5290931346476991, 0.3350134293143902, -0.6235033280766927, -0.09958391313389807, 0.2650502460959804, 0.10593881955900808, 0.3264527396785211, -0.26293954693478433, -0.5098781912338862, -0.4617171938924353, 0.06633282127884368, -0.29789548209126737, -0.33213600663583476, -0.4216745602335038, -0.25952725761012774, -0.5162026809723829, -0.33065717142876555, 0.26889076510601556, -0.4713271982456019, -0.6218424709754669, -0.7235120418214183, -0.03586645464292718, -0.37835847598390315, -0.34383503086194556, -0.4109064583545317, -0.4272266681823255, -0.17318822038140178, -0.04954922992951484, -0.4509443757919752, -0.30807001779285825, -0.40519561471652094, -0.437327949306784, -0.1266297851972806, -0.15218314705020727, -0.21598476913426215, -0.3915501240402652, -0.411383660704374}
};

static const float b1[64] = {0.6057107772730633, 0.6344548600828551, 0.6436566452998946, 0.6252678145723493, 0.6167074718179771, 0.5930205339038158, 0.5999007085865006, 0.5850119050190997, 0.6002912668219622, 0.6261678604190194, 0.5396247220242418, 0.6151131388728144, 0.6633859429792832, 0.5473442001012843, 0.6052010174548194, 0.644095586923824, 0.6385555802957051, 0.45163513098764896, 0.5765454267414426, 0.5875234379189279, 0.622419239512038, 0.5087981379940217, 0.6462913060672635, 0.5626337173515016, 0.6027767217994534, 0.5964579188312942, 0.5788547317890421, 0.6336911212448583, 0.49450787850033423, 0.6152955040993308, 0.5721008683837756, 0.5826057924734572, 0.6334996353720387, 0.6073278353225277, 0.5957049502715477, 0.6256265781463483, 0.6097468143656575, 0.5347063831687597, 0.49157855497383623, 0.6466598585013306, 0.6309667264125632, 0.6356744451512764, 0.6137753644302393, 0.5211089557880308, 0.46076258874037807, 0.57602290561507, 0.6087709430285272, 0.6437095597235553, 0.5826267329825613, 0.6146732314000999, 0.6014504894896494, 0.5141559623846946, 0.6142846757746052, 0.5934176949071774, 0.643914812631472, 0.6379565306091873, 0.6121173947417785, 0.619570359869273, 0.5741164271015045, 0.6289317101053773, 0.5551574619628037, 0.6080913009523133, 0.4630199453474407, 0.4901185149428361};

static const float w2[64][32] = {
    {0.3755553657099171, 0.4472906702688715, 0.6315398912671455, 0.642432642377112, 0.3782409307177711, 0.6010939691513894, 0.3134143611583686, 0.3567638354901995, 0.2835913116965861, 0.35387455518061256, 0.677688208910592, 0.33929067876274244, 0.46891986856977347, 0.2298247747926755, 0.6507958540538438, 0.6503236284918508, 0.6089675599771024, 0.6908809399346132, 0.5536119992724458, 0.39513089392022555, 0.7079702662447769, 0.15395760287784177, 0.4795163350214054, 0.3152965070798883, 0.5632645624262074, 0.6466086409866023, 0.7453059467432824, 0.1507135917111835, 0.7361230778217169, -0.07295344121556414, 0.4673275626757886, 0.14898535358544285},
    {0.5561764293320489, 0.3747803004272035, 0.6994880243880944, 0.28149463491751364, 0.037118349961493984, 0.6025858097844984, 0.46963123917179106, 0.5988065512368207, 0.6928694590421876, 0.44419279177856097, 0.2664175979995105, 0.41245868491261795, 0.2863088656408612, -0.22858578716651054, 0.5542971834949291, 0.26197358673261933, 0.33717420686315414, 0.8127870239821451, 0.36031526497579375, 0.5852657989111149, 0.4331251087445228, -0.09948802236794077, 0.7707169354898465, 0.0012957062941977091, 0.6793704010020307, 0.6763227454457458, 0.39576001528446525, 0.4002087717717389, 0.7420388991931832, -0.17219530182774948, 0.34511774480377877, 0.014380487638115549},
    {0.5827152248420376, 0.45121002095373064, 0.40978918691679084, 0.6684830007213328, -0.002948723727583211, 0.7779188625888667, 0.45862044721304784, 0.46297901369368355, 0.6231851227029975, 0.6815925569096978, 0.5902190740566965, 0.4205261986778652, 0.04863128642614727, -0.14765721222809114, 0.8139106367388463, 0.4653715155737008, 0.6913997237125574, 0.6067997537459265, 0.38804763395515574, 0.5950894840943227, 0.5471990893559661, -0.18378314518337283, 0.5128498833313563, 0.4010585037418016, 0.30270074838523364, 0.6175387292117117, 0.8652777912296729, 0.033957100209468676, 0.49161289596974866, -0.26797566208536006, 0.35927226526132333, 0.21191494583227516},
    {0.40194911750415396, 0.6913729598261369, 0.6202871359368244, 0.46136726421068214, -0.009354461239028779, 0.6502177760339714, 0.6285253222459921, 0.6870425614411264, 0.6660970782459643, 0.6353686298057267, 0.2906373081835834, 0.5726982097495917, 0.039949275639531406, -0.0158540148004864, 0.5556845009178905, 0.5635899165276815, 0.3412180218488241, 0.5126184492355977, 0.6943140005226526, 0.7448003774996086, 0.4917743261005433, -0.08919165695287481, 0.5786901875240158, 0.05562449831501863, 0.3087688183055333, 0.6560946955259798, 0.7204600447059456, 0.39975277319861224, 0.8171931089824926, -0.10692186597534013, 0.502948112896049, -0.08459869845406055},
    {0.3727888336777646, 0.2869728219400391, 0.5039271099246947, 0.37991563859584593, 0.3816839668130873, 0.7306425163877694, 0.4814190171589283, 0.4285430369011148, 0.7601800369913713, 0.6170249811410138, 0.2898909800804539, 0.45989500809587036, -0.0062329061773230875, -0.2339549343310431, 0.4112487001789221, 0.43278762599268344, 0.6528736089455264, 0.7571429287346141, 0.40893616637432767, 0.7698210089163909, 0.7830752584083936, 0.06694745496354698, 0.6825505738534358, 0.3010105849063623, 0.6203295558155377, 0.32508544401480427, 0.45142049464043527, 0.26566630512403716, 0.626729353666351, -0.1998055307306881, 0.3426341613968542, 0.06407621358758304},
    {0.590501037278945, 0.22086996021155467, 0.5361530087525483, 0.6498893311481708, 0.1682176772249678, 0.5925481002189875, 0.7351321775231119, 0.7661075225778351, 0.52940559691101, 0.7421757246759363, 0.5908373577725199, 0.3286009693423233, -0.05837184399171744, 0.17050492914268137, 0.6567352393539407, 0.7134619000929192, 0.73925169330753, 0.7885735849803425, 0.7217561073280884, 0.6755857171035575, 0.3516527310970653, -0.24438450951817836, 0.5025155991513212, 0.14227904003347597, 0.7533060368680529, 0.7793234867594517, 0.36562291016602194, 0.3562662727739868, 0.5021889184740704, -0.0461755021650684, 0.6100255780260216, 0.0180844196397563},
    {0.7613760008350119, 0.3426248506131934, 0.5485738213314985, 0.5792134230578272, 0.0805985406021837, 0.3559680209974719, 0.7022753818472389, 0.8252693907065326, 0.6388000758835869, 0.3877293251134745, 0.6188242584422374, 0.5570423002770106, 0.2184320195566574, -0.1733019741423062, 0.6383662076142433, 0.6261570979491851, 0.6047316205771041, 0.43256510637487594, 0.769963108827212, 0.7709224617252709, 0.44664570732880277, -0.2344402125563125, 0.5640683482177661, 0.5214206542557183, 0.3339401216342488, 0.7155656687968381, 0.8020411206572259, 0.29967513009979685, 0.7322784496357418, 0.004784745078271519, 0.5132583584115976, -0.2556027816762042},
    {0.3315974640253644, 0.39873282846930613, 0.5505098239962796, 0.5008971173590959, 0.12080278016358637, 0.5658316618996402, 0.42744338112465224, 0.4432433547446521, 0.7541341147369407, 0.7565596771575699, 0.5984377380264064, 0.6298457527527895, 0.4548064698761162, 0.03863611259929876, 0.6423268609233767, 0.6001116218173449, 0.8240389262299705, 0.4760265871999603, 0.6803785982305316, 0.5207870951184785, 0.6319548708709853, -0.026198467711103846, 0.7558663904787069, 0.5172145647765505, 0.6566453892107048, 0.813671240232748, 0.7942697630681708, 0.19975785392009507, 0.361431808989551, -0.07376866498650063, 0.7397848093061438, -0.1917095673052771},
    {0.7205063380841807, 0.43274119693170215, 0.2486625512104215, 0.5398306077237349, 0.40896422418430783, 0.48050768518965237, 0.5776177823023549, 0.5742781712588161, 0.509537430983796, 0.6107909492829862, 0.6834653004817066, 0.618170157778527, 0.3890344350948713, 0.17638496383654834, 0.7447409554438562, 0.3393149763391191, 0.45246583939851015, 0.7435293532794273, 0.6656092778371284, 0.5418369673360874, 0.4885986000146478, 0.0348418261679288, 0.5926957266854955, 0.13475959709365168, 0.49982548382759523, 0.44309864746285565, 0.7405482959002544, 0.09702854777676764, 0.6782932311838809, -0.2617416878945717, 0.7504597999677278, -0.1929818118821367},
    {0.739642431586569, 0.4980235317950107, 0.5578334720694607, 0.5885199706867487, -0.017957174606257603, 0.7641411802889894, 0.6461484102207959, 0.4423246695696023, 0.6886872534879244, 0.720645022406728, 0.31560996979493233, 0.5387278546104367, 0.20870798166796292, -0.128526289905333, 0.5666113009935683, 0.34217522205405276, 0.42313498417220363, 0.38409805884044607, 0.47659517710948385, 0.28836457741931015, 0.3186282613830574, -0.27625373026728367, 0.8270927670828967, 0.4800812231814625, 0.8040790073041555, 0.6065253129609559, 0.7068642308261391, 0.3313818133339076, 0.33780329785605673, -0.1366311262847181, 0.30433623465902226, -0.17024679130414805},
    {0.4048048422007772, 0.368049381733323, 0.533816582948626, 0.7493936627440424, 0.3886367138202057, 0.4898150327584062, 0.779204546735258, 0.3911002905504621, 0.5957443378966668, 0.578076657634112, 0.6378295392086019, 0.5901202117581258, 0.05253470370899217, 0.034966610558099964, 0.8087742653334025, 0.34125432948679485, 0.7023243794264569, 0.457388177741553, 0.3746043044840355, 0.6841334444592089, 0.6239744821814958, -0.06879585502763541, 0.410817509236822, 0.2858606875745185, 0.7142735289236147, 0.785702007784171, 0.5536915696231429, 0.24813038267307855, 0.5151256205313202, -0.0415826620458219, 0.6487794421709003, -0.0014946113833688604},
    {0.36728344244603434, 0.4479995955281685, 0.451222298987307, 0.563157825162082, 0.10424771108255322, 0.7864371379925621, 0.4157916101436753, 0.45277188753734326, 0.6312207196133307, 0.6039201683308003, 0.6580152670646949, 0.7492789303887094, 0.3947873051746068, 0.005424077347366041, 0.4338243383843397, 0.5471189035892066, 0.6145472043090316, 0.3051205228375781, 0.6243921067099831, 0.6835988370653739, 0.6647985199205246, 0.014181985329442945, 0.5836285548803976, 0.2923505830588123, 0.5105879377326786, 0.6968866073155922, 0.5327489544063311, 0.3524946602237817, 0.36185995251882336, -0.2034441089863956, 0.46216645091905795, -0.059304396898957494},
    {0.6838746324613265, 0.5135003760205666, 0.42635577945383213, 0.7468557938012148, 0.1137756195771833, 0.7532766986375184, 0.3632548297433828, 0.6392203273273742, 0.7358997147712671, 0.7148167883713061, 0.43624116217853065, 0.6708335147403718, -0.003249599683510744, -0.21931063212139396, 0.4100066705697369, 0.414297500003034, 0.4855430229677401, 0.5676013398780684, 0.6927489589351913, 0.36287512606671385, 0.6460967484760382, -0.09581247026134065, 0.6511583689999951, 0.41881917085090536, 0.676785628199318, 0.7416334227119062, 0.7068226815079616, 0.28169917425656293, 0.45708768917989284, 0.012404093300083546, 0.6884560137544558, -0.14029511449898271},
    {0.428383008286902, 0.5008145203575397, 0.3759907385909428, 0.3968560303825277, 0.2600435047701207, 0.4671550492443864, 0.7681538632594535, 0.6929172996081034, 0.7607570691788459, 0.7228124688079108, 0.3307458274812128, 0.4584340405022356, 0.30599374109536237, 0.15304552111443503, 0.6142630915798711, 0.702255577518193, 0.5338172231685486, 0.3319352117751378, 0.48022739123209696, 0.6356931681416605, 0.5422217649965069, 0.19270257728230844, 0.5040964560491397, 0.22803206126801626, 0.3257558514716396, 0.6265327357167108, 0.40090954328399003, 0.3096241599234952, 0.5758156150261282, -0.18171959730182052, 0.6212245282736268, 0.18812063117728348},
    {0.7907645400924487, 0.291961975044822, 0.3924752871925505, 0.6040836330320672, 0.17213391529135383, 0.7006222256421396, 0.36511851623743125, 0.7090330130052603, 0.3269402390556653, 0.37159792647552997, 0.2628803979798209, 0.4862625871030828, 0.2591269517377839, 0.043025006821821775, 0.5278461073568764, 0.3285156212084315, 0.5455748661366954, 0.5093493865949331, 0.6989479559173738, 0.7747126798474474, 0.40118404343315145, -0.028621785781552674, 0.7366386805242056, 0.09880363781643621, 0.5080726296004542, 0.768048078584663, 0.3765792326115932, 0.2538442346802941, 0.6035380086686934, 0.06995208417356817, 0.46031093103316834, 0.020072016378776744},
    {0.5628761632338359, 0.21108093406315373, 0.21437250409098485, 0.2993053709535855, 0.04409939424268453, 0.6042735746682174, 0.41507805866777037, 0.36776949419809996, 0.5190691141862933, 0.6785903184359622, 0.6888625995637663, 0.7124786818229257, 0.13628928971343016, 0.1468708064116862, 0.44133439070365504, 0.30329640804736346, 0.5038737036875099, 0.7518539268033588, 0.6249874435518604, 0.6580149580290493, 0.5813293695911635, 0.1076092500145542, 0.718130575993876, 0.4900149654251758, 0.592254138870475, 0.7270291432276194, 0.39189641367040856, 0.06070591661911732, 0.712956722796849, 0.005758941102267275, 0.42704609303297586, -0.18247886266611535},
    {0.6527046929776157, 0.31799246601535164, 0.48769098687946993, 0.33038570182229005, 0.18626733718519456, 0.6146440702909408, 0.3731796938704041, 0.7191093021252127, 0.36800350739515586, 0.4260532811140748, 0.40808296816934114, 0.6150038117365882, 0.3146778317385676, -0.26509499598028946, 0.8270506921595783, 0.5785866984181635, 0.4204670908913322, 0.32434015009886, 0.8217864500059826, 0.48038159255626656, 0.394141534987008, 0.08141488298730645, 0.43439137048031656, 0.3438697683320362, 0.43261803170395813, 0.5688848831904684, 0.40752030353141394, 0.2464510575956203, 0.7267919616001862, -0.029521331990188707, 0.6890878874125991, -0.10853296278146662},
    {0.6012143010258627, 0.710977322115568, 0.2548880523605398, 0.4992711412061849, 0.18429779101988347, 0.5467625478221549, 0.4345121195053685, 0.7193418075919438, 0.5597016067092233, 0.3763814525056099, 0.3420135848105302, 0.6190434509117254, 0.11709277266846028, 0.1613523463624924, 0.4281784984688208, 0.683760427559244, 0.5983149568095555, 0.326338422213726, 0.45014600132438115, 0.5867331247387638, 0.3372922454491199, -0.021049141826804528, 0.4172932808025194, 0.22853258114258818, 0.45444661597374336, 0.46822215439220116, 0.5019856501758551, 0.312868026100486, 0.3730080129524217, 0.08609846860995445, 0.7097104581632088, -0.04870389693402329},
    {0.4854510429172279, 0.24151901158036235, 0.6123753923987233, 0.6296618753849085, 0.0853570586604962, 0.5004974547486559, 0.6754488113028501, 0.35750269842622356, 0.580719467608053, 0.6535562860609304, 0.6318408486035108, 0.3329768047077674, 0.019636688192431546, -0.1435671808395159, 0.6491228826129377, 0.47877158592310143, 0.7015467763678994, 0.63323873840784, 0.5718345547607525, 0.6583581442718197, 0.6753089416282313, 0.06787334753621857, 0.5305071902500526, 0.3795383176271324, 0.359290348525966, 0.561156532139408, 0.5851008309013729, 0.18546319381359946, 0.6399948268322321, 0.02735670587703365, 0.2601841337576095, -0.21684854540273368},
    {0.6734525281117142, 0.28575825868949906, 0.7226696496669448, 0.4064349104843182, 0.2037855027283039, 0.5492719604273523, 0.31959565696579534, 0.5039447690508906, 0.38148837124783386, 0.44903986857990996, 0.6502400089584869, 0.5483468632453651, 0.45617935380535635, -0.04526428143428847, 0.40967049329485894, 0.691833004330381, 0.65167316141397, 0.6999235037991066, 0.719124705047379, 0.778603808728232, 0.34055068326291915, 0.17258623690395222, 0.5612547072502694, 0.13335016964341398, 0.6996903118443946, 0.6105233140703412, 0.4956014447319691, 0.3736457199116459, 0.6422683483158953, -0.21341539216697125, 0.616373900888158, -0.11725857107124782},
    {0.6343631934461564, 0.31369435542784513, 0.5974547240157548, 0.4090380809516481, 0.08360009640011926, 0.5994302238908396, 0.44243749725746584, 0.33036341020366433, 0.3923314734932356, 0.7568139274898529, 0.3066161295639681, 0.6014744950270791, 0.10081429141449383, -0.17153088326004814, 0.5934734753300118, 0.5625860182627851, 0.3444778280686614, 0.6806532215581402, 0.7640342579819674, 0.5461436456834514, 0.34074744094335574, 0.17437785593847413, 0.6296089007703121, 0.5021005937131077, 0.3262528247760629, 0.560950786744001, 0.5947473230065426, 0.2058873889201814, 0.7331735989299955, 0.19565183296111466, 0.6125590642528691, -0.032864798895848146},
    {0.5695642637353808, 0.6554033927298545, 0.6208616302243608, 0.45872703748526167, 0.030491300251971838, 0.4688171638887275, 0.3729805930331897, 0.4456084586143845, 0.7518380023487039, 0.7368303812893052, 0.4590156381679214, 0.40743302282663146, 0.21491851650249155, -0.22804163694963087, 0.7202740742993213, 0.5557958025655101, 0.47551846906457396, 0.783280342234422, 0.6300008395230003, 0.7258202649030269, 0.7449607932931471, -0.1972434627279481, 0.4790206609192353, 0.5895704301671381, 0.6285151648027002, 0.6046138258610294, 0.611875771831232, 0.25394781182677956, 0.38845288888741886, 0.07474743829461959, 0.658385658446905, -0.007324478081297221},
    {0.6587640046668461, 0.4791700192052571, 0.680771518753441, 0.7205971827858872, -0.01223002427063474, 0.5400392924219506, 0.6936396922278927, 0.8026935422263713, 0.3980237156865077, 0.299889782501313, 0.27729744034118503, 0.5432628055826967, -0.008535077327163607, -0.01935700172477119, 0.6934484825564838, 0.48048482651922075, 0.7061414288103638, 0.5938981942347599, 0.562159596827029, 0.5221243190348094, 0.5110754708566386, -0.002847161893709621, 0.4386943549959602, 0.01972680979010968, 0.40797668197724357, 0.36161588999921335, 0.44729329312972216, 0.1305988590238254, 0.7568707389641697, -0.04822162707896741, 0.7045634435626937, 0.05382070608407032},
    {0.3178012823028129, 0.4967787248396911, 0.5275722049855488, 0.40138195634976165, 0.32774249370740505, 0.4228611893048042, 0.5071497402505976, 0.7218797753515903, 0.45575051245719583, 0.6477338448854044, 0.7080487763551296, 0.31058972805094504, 0.4143930662032763, -0.09284654419228149, 0.5277295492916015, 0.4772202201814527, 0.7237678894117582, 0.7309580718765257, 0.8401184303462256, 0.7837637721207487, 0.4106972957814626, -0.061530833417675464, 0.4174225152927791, 0.36154954347853807, 0.5826414865769172, 0.3754604509517359, 0.4585365193064436, 0.1804051379300459, 0.5687643276790825, 0.12952185143708975, 0.7527797423399383, -0.13641302473162553},
    {0.3246883228307596, 0.3102704742556314, 0.641416597969814, 0.3960723415009874, 0.46791480644896627, 0.6815307641855758, 0.7493121215262257, 0.49547584937840666, 0.4384007229188014, 0.3740279517271206, 0.2834383773712854, 0.6469158889016428, -0.004721690803996157, -0.23568806784752905, 0.471066142879947, 0.6202141992747484, 0.7219785615086619, 0.7163709559508883, 0.7642774905535686, 0.2950901669076624, 0.8314636312074772, 0.18712054199023795, 0.4977513209253276, 0.489420308584189, 0.7614218134072369, 0.6797225301433082, 0.4275292099465898, 0.09571575453517288, 0.5531548553695541, -0.2172514254468193, 0.7439449600556945, 0.07481103388798534},
    {0.3364005751251298, 0.21155074326189532, 0.5083215300577447, 0.3794827439529197, 0.2968330760540666, 0.5403391593957244, 0.7442359929417506, 0.4551233033260101, 0.28703578002277685, 0.35902118486024637, 0.30153329517655986, 0.7356928484286467, 0.06163878930987651, -0.01165302629477512, 0.40736676108957104, 0.3058498663045648, 0.5617115992079456, 0.5095254322532382, 0.7221379610583579, 0.749634500434744, 0.7336746265504097, -0.18541692367630033, 0.8007776684658942, 0.38215989901579966, 0.7357829553013235, 0.46178070714643155, 0.5533459614127102, 0.045319943014339455, 0.4277671868877332, -0.08331010126724502, 0.5864503439036411, 0.043497125976044736},
    {0.6841193962505729, 0.2560596081535777, 0.6079869355830676, 0.4380225902277268, 0.2613891005114567, 0.5944277273116204, 0.5805059837613681, 0.7279021407529224, 0.7392651557020578, 0.30050197746059537, 0.6340457957811466, 0.5128299141897732, 0.333594137345613, -0.060651619499598464, 0.7195797172060873, 0.7624621248953872, 0.4272486331323999, 0.5594546648722784, 0.3674699061869901, 0.5123488341115113, 0.3785145800011566, -0.03562858671507812, 0.7482146188534141, 0.2912564096983072, 0.609686619489813, 0.6232267370058888, 0.716769743125087, 0.24946975085940698, 0.6316137419558594, -0.20002942833564122, 0.697033780430599, 0.03235194841532133},
    {0.5071174331770526, 0.6901760770151585, 0.32613645931847474, 0.7248471938698834, 0.5026018505426196, 0.5570342757808564, 0.6776833833345485, 0.7776166526391356, 0.3390636573553724, 0.4117731159154408, 0.6725954844987321, 0.7995707616106946, 0.33518637880048396, -0.22954716610720993, 0.6784757622678464, 0.7511983606771875, 0.5365857749734677, 0.3733788920018894, 0.6450821520338839, 0.3275395723308324, 0.7200643601865188, 0.014785674355725295, 0.6947529667675794, 0.4136254945663102, 0.57637988245964, 0.42960032333769355, 0.5878409298296579, 0.10370260630043843, 0.7947050980039779, -0.04894674396660945, 0.3593302520368254, -0.10802717444249882},
    {0.4926118120741613, 0.3154843793456531, 0.6350841503702872, 0.6471414906613767, 0.46462491035621506, 0.6925295736609065, 0.29268345150432534, 0.5825836445854524, 0.44845106645912813, 0.342018339030447, 0.6742077068455206, 0.5845453584908292, 0.06686692070126384, -0.023960898270316115, 0.3665893649649434, 0.2918492169794148, 0.6545396959069028, 0.5305121765887835, 0.48208711077298594, 0.7937826109305669, 0.6170876893600303, -0.02501739521165493, 0.5885415448250962, 0.5016587286090014, 0.36584250130067314, 0.3340910631374789, 0.6815714605468202, 0.013804972857128903, 0.3382328633979118, -0.09513734762550513, 0.4123504638999122, -0.08928242042412389},
    {0.4238273396406162, 0.22393153749022873, 0.4375692660731872, 0.6494434176289018, -0.027023537956878306, 0.7887512366647786, 0.6198804364292859, 0.5803067450491793, 0.5089345660846814, 0.6301858768831653, 0.6516867697612918, 0.763181243117706, 0.38002356534241544, -0.2552987416501451, 0.36307002325961296, 0.4654489818794495, 0.6588837404286313, 0.3345276645302678, 0.7947815589323655, 0.5386881447748845, 0.7223421243711665, -0.20222141255463472, 0.632683565704807, 0.2170259637995038, 0.37270842334722915, 0.5052740972045461, 0.4415912734981564, 0.355224132517263, 0.7265589122233077, -0.029621059435145577, 0.6267533223384718, -0.2487268272254286},
    {0.6219182548216694, 0.481783203389099, 0.6205770108807903, 0.6426889033111196, 0.38587687428864403, 0.6675752570150204, 0.30463938423442477, 0.7675445574894045, 0.5064013719180601, 0.7132862728673225, 0.4959189315668357, 0.7481059101289936, 0.03312038973868554, -0.04070854538030182, 0.4399098093892519, 0.3476297834563141, 0.595993044421135, 0.7848878244007341, 0.47922075560489863, 0.4244233229051326, 0.8269337342156798, 0.12925024474813618, 0.4138316203916108, 0.5060435224051857, 0.4468571853719332, 0.575900667513336, 0.40450308098561705, 0.07407312098102213, 0.48568262540870455, 0.1208742983877936, 0.5320896354352223, 0.1824750871204885},
    {0.3412214413447513, 0.7164079933342591, 0.7013672427856911, 0.45083793035894826, 0.34626652856399187, 0.3676605701571163, 0.337858566949016, 0.6108967256887846, 0.48802964919407865, 0.4160931812350798, 0.6408882014593866, 0.523484145363899, 0.3889124236017472, -0.03262394492555577, 0.32416686431230196, 0.3820379503076197, 0.34135037830920595, 0.3351764450077982, 0.7818365160561557, 0.7286859690165629, 0.3925181684378706, 0.3259822489249383, 0.4889358357007838, 0.46876749413894275, 0.5748571358524567, 0.5970349158949775, 0.7215207247223676, 0.4286211654066092, 0.6500027501648437, -0.015015472073374113, 0.5340097614544558, 0.0019586837878489863},
    {0.5481523304611086, 0.5477614540358154, 0.6098319334067502, 0.3762457510753257, 0.01968829347999678, 0.435583209846905, 0.5160489145315416, 0.7086305724363587, 0.42691557810997777, 0.5472079131602637, 0.49431897571935207, 0.4349257890365235, 0.19996434344937786, -0.13566900351076422, 0.35316311964105607, 0.478791713988421, 0.7037073694805962, 0.5844433040654938, 0.5932499954883894, 0.71085076911046, 0.7509650877459942, -0.19175413301824992, 0.8159071282053445, 0.2419575212953564, 0.7618750332191231, 0.7431682692797403, 0.4518582741214402, 0.2935984940999833, 0.5178169917927692, -0.09572922483979998, 0.45197779202480476, 0.0977397065306746},
    {0.3199833051807759, 0.2700513214511209, 0.682013647785172, 0.41506360638380624, 0.2341160988558835, 0.732319357215751, 0.596523479092301, 0.41237002246954624, 0.5006014788341041, 0.6326769934891324, 0.4538207958929788, 0.7925610020809866, 0.23670777373594581, -0.15371926286075632, 0.6169754897794908, 0.7305797262492466, 0.4759855679511847, 0.5549262545144826, 0.6858190019689318, 0.30751745948111614, 0.5359825364866709, -0.020070718219385456, 0.7816914522566307, 0.4986310696497899, 0.569240562813948, 0.36427369931109915, 0.5406284851604989, 0.4566148224710461, 0.6557399192681289, -0.2632645361447264, 0.6808664153280147, -0.232040328372914},
    {0.5934695709043385, 0.3045246222322953, 0.2987722471609167, 0.548981216439814, 0.4201109132248451, 0.4944026846912029, 0.6354757042182252, 0.721541233094794, 0.7451611851070588, 0.47187003771175234, 0.5388306662017859, 0.7750865341389459, 0.32635733256110033, 0.06903354799288132, 0.7081834695544851, 0.5537045475536767, 0.6909507281015747, 0.7259347238538721, 0.7660875873276627, 0.5705051875680633, 0.4098767210365234, -0.0495824080010318, 0.6054806099599683, 0.34781314058224055, 0.7932118819175472, 0.40854538163679127, 0.47325365280625575, 0.3872867992374954, 0.43799119534967335, 0.00546558869735737, 0.6827559892717776, 0.15144633616515873},
    {0.7147169365947781, 0.44211914668860597, 0.28456225079656694, 0.7740600532827344, 0.10769542780042629, 0.7309313540558876, 0.3244047093083446, 0.41913043760056873, 0.3533305743883418, 0.7739902272531881, 0.5494411579450441, 0.7043733594144348, 0.26654563926914726, -0.23674058043195698, 0.83245407114771, 0.6229802911594761, 0.3852514333429843, 0.7762482438527799, 0.6261649256253246, 0.7824253901042021, 0.40048862284931286, 0.026931950400981057, 0.37447236400352546, 0.13798508790213404, 0.632407408986497, 0.7899696472803679, 0.5345594544012164, 0.4582854286632768, 0.6654551393381155, -0.014331290220236784, 0.43305322177336003, -0.0072296648891778115},
    {0.7757805309055452, 0.2413412620226848, 0.18158895099363204, 0.753845152448177, 0.43550629246877914, 0.3764117586189141, 0.6068966972079219, 0.74732386917383, 0.2879264925374607, 0.3851289818129922, 0.540649178498681, 0.7594677367473992, 0.14007285717830506, -0.03069966359251904, 0.7431391202000296, 0.29075094470361584, 0.653685587803161, 0.485700860105081, 0.47549574993307114, 0.4517823915344231, 0.5695985583658364, -0.2502554913553168, 0.4396431761137842, 0.07380272178150472, 0.686161239841218, 0.7073522430861641, 0.3646860386465411, 0.274485283580167, 0.6743149621533111, -0.13138791444578346, 0.4114899046432924, -0.1734530203809215},
    {0.8208918212995743, 0.37092200794521835, 0.587460161309299, 0.3945755170305849, 0.2806750365727048, 0.33919753724497165, 0.3059304449351521, 0.6194102421159969, 0.3612565349657702, 0.2954997930901917, 0.40352684194798744, 0.4362799330563062, -0.07169332440174833, 0.22042978572114655, 0.7991952810232759, 0.6633052501268414, 0.6350917649486776, 0.6731901210504759, 0.4850832089103672, 0.3578863011068669, 0.4550776987479361, -0.1653720052467787, 0.5997966112869927, 0.38135348166539373, 0.4112225713318351, 0.7894327968475128, 0.7400219215637577, 0.45344276668861605, 0.39685156104002656, 0.032564026746005094, 0.2942525736508339, 0.05837663176027452},
    {0.6790276678897434, 0.49204553566409515, 0.7484346655956837, 0.6666832565615286, -0.04148856272742595, 0.778291597714278, 0.6144690768711087, 0.38221498454969005, 0.5107302215341166, 0.7341902405083645, 0.40988690662966804, 0.7823587985074077, 0.09235559014825198, 0.021693798226151424, 0.4222318133384222, 0.4776746405057258, 0.3548066057993752, 0.3486053651301312, 0.37299232553106254, 0.28717093251630493, 0.49082449174462495, 0.2025068527762853, 0.5845280438548465, 0.3736836984602705, 0.4589448342789939, 0.5969375405113172, 0.6938929521178621, 0.3390368630510503, 0.5736191197163933, 0.11649857381380126, 0.630767317378166, -0.13386418338416},
    {0.4930588675350262, 0.3499837243582399, 0.28055078616286433, 0.43699783648169127, 0.003827831932607889, 0.7572716073221304, 0.788099866505392, 0.8082971418315246, 0.8001992578922056, 0.5231198176133521, 0.5172243987920013, 0.4729575944177043, -0.018379681122073513, -0.2610573822007472, 0.48918867053322945, 0.42536381330965073, 0.44370786022790665, 0.6613169420411072, 0.35148336995568835, 0.6711112978658341, 0.5714099427765716, 0.05670491361000441, 0.7257492606180124, 0.4566154884625208, 0.7117004530541632, 0.5551753847687191, 0.6099326363391483, 0.11994798930212715, 0.4990613216683696, -0.14000228692983982, 0.3224679789538418, -0.22342337420799677},
    {0.7825121621298818, 0.2516802696040757, 0.4121846403046464, 0.3199519303107439, 0.3261805172852986, 0.815510646736938, 0.6637832867961182, 0.6315557969906261, 0.3895559325422962, 0.4126243950635796, 0.25761496285384994, 0.3598187252067424, 0.2624907891386698, -0.17217373190278457, 0.7829311779570145, 0.6396082569918993, 0.3664390010786528, 0.8232801084198295, 0.4864681128431848, 0.4716454636606872, 0.5644556117504089, -0.26022921997091164, 0.48934463882988416, 0.24160383186615877, 0.3894118763479787, 0.5029899645316303, 0.596977013421509, 0.29655352961368314, 0.5990502160200433, -0.1449879144372453, 0.3564916033717836, -0.018267565717982062},
    {0.38104888833402867, 0.37265754278040997, 0.35071815942280243, 0.6449617553514347, 0.1519631156831717, 0.6039930173234316, 0.5783266985339652, 0.7101235963526489, 0.3963423762301766, 0.31227067378493706, 0.6990728225219409, 0.6816525815491467, 0.2420935854033468, -0.14948235753813946, 0.7745218117628108, 0.7787235578454781, 0.42441335435187055, 0.4594377303764419, 0.7956476756167528, 0.3249476233362566, 0.8046723395930648, -0.256996480433313, 0.6867034928741215, 0.492157704650655, 0.5094450953531329, 0.5445597617031227, 0.8234203971572742, 0.08330395110814734, 0.7264634426303852, 0.035788536312163485, 0.5491506433923732, -0.029493209566671084},
    {0.5855688353179184, 0.21469951740509194, 0.6234625671982937, 0.6490590304052425, -0.017104456587278574, 0.6925975638821865, 0.6466379875074741, 0.6260284543950786, 0.694554918225015, 0.5600493207135505, 0.4451347771573585, 0.7091801379954097, 0.38622490824572625, -0.1935771106364637, 0.44772641401785335, 0.44549384169684847, 0.5714806222194871, 0.3961460689408364, 0.6451240108195074, 0.45109064186312, 0.45590875948234694, 0.048094075250888886, 0.6660672601938419, 0.48480834448161614, 0.3316920463759562, 0.554746983542715, 0.5416292907297952, 0.42430433979351195, 0.7060810188066302, 0.03791498349954136, 0.3481589360942734, -0.03919773483930983},
    {0.3674212545103844, 0.6744606246570188, 0.5616445367723104, 0.5661106260561402, 0.11438939141067846, 0.44931653217591416, 0.5154719546301952, 0.39950709395086603, 0.665260178832173, 0.8095894843349991, 0.7153626712849507, 0.6754856002622127, 0.4705252789856818, -0.21009110437942255, 0.5817333421031542, 0.6891799280314607, 0.3910627920806756, 0.7773562894350569, 0.48417814112695273, 0.7043370865309121, 0.6843030803129355, -0.2600026195283987, 0.5850232337048168, 0.41016802831621446, 0.7758935054617591, 0.659580663377623, 0.3887548658780273, 0.45536054236624945, 0.5808405870674401, -0.23483648880872376, 0.41744305700425144, -0.21193116818962032},
    {0.6924162113658908, 0.2582375451175437, 0.28754617521702974, 0.5772541080696137, 0.3131377785867783, 0.6054829677762381, 0.40428548090615957, 0.3862530981729799, 0.6854539237344717, 0.40822056498043113, 0.386510069519788, 0.49832194564191296, 0.4911235267607243, 0.20174180853545562, 0.5162644202178853, 0.5131113036850193, 0.35163220795617806, 0.3700055763096493, 0.4234550557396663, 0.47298142592484627, 0.7805871114411193, -0.24635424424934932, 0.4008473698496006, 0.4949496982669901, 0.8174761266071825, 0.38180983864579443, 0.4632850717844712, 0.1742510732189435, 0.687874858300862, 0.11499625062191486, 0.5322500758571319, -0.1941855768481899},
    {0.7796080254641867, 0.6535723770881271, 0.3481783611242453, 0.3469492949157604, 0.3923482578530715, 0.7013213302029953, 0.3963417891234551, 0.3274460204907834, 0.31531803108789425, 0.7213278769319021, 0.5522097714123163, 0.6765990290293235, -0.02389058880985427, 0.02895603923887058, 0.4238782573800489, 0.6082966057150122, 0.5898044300543118, 0.3379890624225748, 0.6071180278223952, 0.3706765259122613, 0.35378342232942417, -0.2102006328540787, 0.724102846108764, 0.17757210536055695, 0.49637159303029726, 0.5875705400925841, 0.46474046942137626, 0.25977979998989986, 0.5836044318642505, -0.10691520187332296, 0.2727137388798909, 0.019830528733148847},
    {0.3566916247888955, 0.25969179841462436, 0.1913546441054876, 0.6196143063964656, 0.18221714600772584, 0.669605706186841, 0.5620729579766104, 0.8087466361006966, 0.6863116673177987, 0.3649519643561171, 0.5097972185903497, 0.6228652875453836, 0.08769588319141558, -0.21429649482659976, 0.7215038156606141, 0.5055116638278694, 0.6047251762294348, 0.4026898065992516, 0.5883998003725485, 0.5746257133925112, 0.50874000285312, -0.13326390292106738, 0.7697045578437192, 0.15311629068364757, 0.6103638459707519, 0.7200161682688969, 0.7027434378070323, 0.19339279597979264, 0.3997619718962019, -0.051306368021982345, 0.4440177006777751, -0.1828306325481679},
    {0.38012442512684236, 0.3497521660944278, 0.21488188640244613, 0.7810602388360737, 0.35591048093764827, 0.7351517061515817, 0.3200276322338271, 0.537091984244704, 0.3376304415444005, 0.43819459485555873, 0.2873068907144734, 0.32485479714237714, -0.05270158354110371, -0.012543070068880481, 0.5479490189944035, 0.5427908634066598, 0.34672998140742817, 0.699174881385085, 0.7229252730386526, 0.7569890602563739, 0.7649638602768752, 0.2041511195340097, 0.3958139977507182, 0.12053814613654777, 0.6112868241371364, 0.5053466033200981, 0.5088996912171391, 0.3295850562816552, 0.7411037731144721, 0.1896866183142012, 0.5801767455781006, -0.1596701159316369},
    {0.6074819268134339, 0.440448223048751, 0.5596425055003399, 0.7713581546878268, 0.05504702319809744, 0.544572129259095, 0.6514375522840666, 0.6938546235634865, 0.6207873135910366, 0.38236125241370333, 0.6154545296968247, 0.6828144174950249, 0.051841386923824465, -0.07743005346358964, 0.6245073252707294, 0.6579778435004747, 0.7751814350406845, 0.5053433474730972, 0.4466648440757264, 0.31847842213312644, 0.3843512269186903, -0.07540573447848203, 0.557625466004571, 0.2868210093826049, 0.5953349093814214, 0.33508176143464463, 0.5504889240257358, 0.48312668405975534, 0.7558279701912195, -0.05784965394664084, 0.48520563856882726, 0.09278108415336776},
    {0.7943315532547758, 0.6548803290282112, 0.6073074198520119, 0.4684487029029636, 0.42614868511175713, 0.3374911084468502, 0.40657625317049007, 0.36669253706486465, 0.727475167844688, 0.7526554824672423, 0.37709990546325284, 0.5982055584088799, 0.39020838873862873, 0.21950754324127605, 0.7892893326890011, 0.5678181127304152, 0.7559721876559646, 0.8202981636291804, 0.49953860620394436, 0.731552045914988, 0.42469519999254085, 0.14903333184323717, 0.5521934495640434, 0.0730870241641482, 0.7119323849165744, 0.491207491827354, 0.7764045166960684, 0.03909022748011023, 0.5124909991998343, -0.2752970163601879, 0.3288008538647988, 0.03303785051704728},
    {0.5652009522688491, 0.758004949057153, 0.5581777295330034, 0.5488564041865742, 0.09146373456835227, 0.5050992450745475, 0.738820066566559, 0.8335042485881492, 0.42118284646367643, 0.3880802731434449, 0.63576311904658, 0.7200866393849605, 0.04873342958577049, -0.16244466136881652, 0.5835230583534419, 0.5313315348018639, 0.8067628910210337, 0.8298048879127581, 0.42430464800760853, 0.7346864066890202, 0.5437335142602133, -0.21859457803994414, 0.5720811023559389, 0.3640227518604102, 0.4286385056506633, 0.3693407269861749, 0.5712713487367354, 0.40595103354038853, 0.6692485215911639, 0.06870044679465823, 0.49128606731184377, -0.268308153982285},
    {0.5146399716298369, 0.5605615966313547, 0.38035580652913376, 0.7065971678433953, 0.4370999625376966, 0.3544188053190886, 0.7170670787250301, 0.5553131579782808, 0.43900188495634274, 0.7654861595091392, 0.5836464123389066, 0.31378739156730423, 0.24679307168778744, -0.21567013595699913, 0.5652978746339019, 0.3364697807558114, 0.7419390454348889, 0.6925307774773598, 0.4399569671740768, 0.6709097851134479, 0.7962010535552327, -0.13621804512093802, 0.5694594916553459, 0.3873294791933764, 0.3820661404634432, 0.5472897492829206, 0.6671760507798488, 0.07168066248123946, 0.6074390393966075, -0.20887189243475932, 0.3434767604591984, -0.1096120584492554},
    {0.5610764239779229, 0.5119783065543003, 0.29532674764219546, 0.3400855742154556, 0.07111918577373284, 0.5782745529571927, 0.44504262553962215, 0.7766723300480846, 0.6386814632968355, 0.6884490953820952, 0.3084441599195042, 0.600696780968567, 0.12817562956466602, 0.1295254035574189, 0.6661046889462883, 0.2770703636762756, 0.6856204112804481, 0.5976011712802858, 0.7603636654678431, 0.5038248236064106, 0.7922677425256087, -0.1729235048378229, 0.4590361682273792, 0.1965663141087168, 0.46949181636054943, 0.7814518379775987, 0.48969436515528997, 0.143111290602385, 0.5455946924734241, 0.19394099146699767, 0.6303815163799474, 0.19546732493550897},
    {0.43424251316194024, 0.49906876408054124, 0.662010991198842, 0.4373090681973875, 0.09165016106261334, 0.4022864206596901, 0.509343348185147, 0.6477332774220718, 0.49112712464729213, 0.615480090263113, 0.6498014432471446, 0.7614892328678666, 0.2540936678370471, -0.11548242333629949, 0.4137222301831517, 0.8084080578355065, 0.5956941029150077, 0.8631617324933875, 0.7339177662016527, 0.7055558531639211, 0.3769535640188782, -0.19683494806742038, 0.5114427685911976, 0.5143235077377697, 0.6924941544430714, 0.8486395652476564, 0.6960517096946208, 0.20580704862190458, 0.5188848328901271, -0.1664355092016667, 0.6355773133386378, -0.15227394488857285},
    {0.4904911795018532, 0.760226212190527, 0.3684685291919438, 0.4670085783710107, 0.4675918608457947, 0.6807792095987225, 0.3133221272621431, 0.6971742916992016, 0.4204275935739498, 0.3724441881877068, 0.4361093091187626, 0.3765241869907604, 0.11264027167143605, 0.13377946855138498, 0.47179102807643974, 0.6728957986615932, 0.5270007517392061, 0.5740509322461125, 0.7929098600357621, 0.725509761157185, 0.3939071131581566, 0.004175035289462792, 0.5333300079222529, 0.26661899276804474, 0.4587305477494441, 0.8022920332156126, 0.3848133314136936, 0.1979381841771691, 0.5748827850936215, -0.0294056879307646, 0.28183740583305567, -0.15283793144467747},
    {0.6354058062189255, 0.43946781396156137, 0.5938972378168177, 0.3184919457769316, 0.3295800372095996, 0.6548542658856212, 0.4578255954648809, 0.6604269008122158, 0.3927665972551077, 0.5237498022780136, 0.42289653887925927, 0.4506191537074074, 0.09632850251538327, 0.00392291433337968, 0.6099526221017593, 0.4893814777015545, 0.7953353450743247, 0.7301698667785766, 0.33956904086943707, 0.47273979776279546, 0.5088387187859926, 0.03655930750845593, 0.6481483793793607, 0.1749178626533106, 0.585158189266589, 0.6807097103306904, 0.4241074571529243, 0.3983309197335832, 0.6852304453833434, 0.15345444211469678, 0.2802320202312396, -0.17507240188493037},
    {0.4224806915449248, 0.24240128329415556, 0.6824833016657774, 0.690925001292658, 0.19041561475699162, 0.7505981050241848, 0.6609708362807533, 0.5046421408650884, 0.5814177996152438, 0.6176070872590148, 0.48314627191016973, 0.6100601345478412, 0.06593843030672457, -0.09940761974070325, 0.36408076440278153, 0.48660597498677083, 0.5915955628455449, 0.6306562480386642, 0.5969055262449674, 0.43617568070218227, 0.442684290620791, -0.18443598267399786, 0.7445375073559426, 0.1507966731556932, 0.6915026277708367, 0.7668792103631189, 0.45388389091553494, 0.5115935342175673, 0.6352363265763061, -0.09062148138507183, 0.7171849399543431, 0.16515029313368518},
    {0.6998048074884324, 0.3224442929482389, 0.710918807282415, 0.5960233100057647, 0.42213369439121645, 0.6874466610335971, 0.3819823859551782, 0.5376658893146571, 0.7587479078803425, 0.5852434783711099, 0.31633126084941254, 0.5128250403067806, 0.24839110792123437, 0.004248701498625419, 0.3588566611400987, 0.537163820377856, 0.38277452850001725, 0.3881089383393777, 0.6595435723695647, 0.36264010444062833, 0.6589299348266312, -0.08223277459589114, 0.7462711677190214, 0.1308481578174049, 0.3519297861304167, 0.6655651392964991, 0.765517467042155, 0.2922841179242915, 0.7211319929947803, 0.17048591317194856, 0.4472113331958069, -0.15813771381527444},
    {0.7336830094978192, 0.2780002830377919, 0.4495497678545983, 0.7131063602100841, 0.2089851651304301, 0.336169703438625, 0.6663365550894633, 0.8034800376996304, 0.491972944249106, 0.3418961963178445, 0.5334611756020531, 0.4658349867929359, 0.0702736308949368, -0.1423041446399471, 0.7726080018266877, 0.5857967358805024, 0.5931947913613188, 0.5767576384980644, 0.5105709429409324, 0.3534195593711458, 0.4564256012674647, 0.06981782026439931, 0.7023757768116051, 0.48221417963499785, 0.37268163959813366, 0.5393182532071015, 0.6858637230619138, 0.40321201467206924, 0.6798158590389426, -0.23532579843370557, 0.5740753719292019, -0.02400106732277392},
    {0.580205148376262, 0.2520457081676494, 0.228195251692965, 0.3885000470319817, -0.030356450333409685, 0.670568336829748, 0.6873712724673222, 0.497428234863724, 0.4906089362311483, 0.3004636160774496, 0.680837535712979, 0.6479936072975832, 0.03326351192663443, -0.11046761718404409, 0.46913502860365625, 0.551092164230419, 0.5888431755657859, 0.8006635977364762, 0.7989429430994975, 0.6201642096524379, 0.6703117327121942, 0.13763104881065605, 0.7459650782865298, 0.2264191024455133, 0.3264026060095953, 0.5872145008468582, 0.3662554891285213, 0.5130005296084531, 0.7338642926602571, 0.002564197878151862, 0.5500410491505097, -0.1680325750309802},
    {0.6007223745829136, 0.49675489059609007, 0.6394780425860472, 0.5733312932159671, 0.06844797474259784, 0.3957952388332595, 0.7657126742324303, 0.3762997436466422, 0.6690920598483501, 0.44155675958367285, 0.5906763236035641, 0.47035534555451625, 0.3597087865640661, -0.03260241092542985, 0.7402040232787972, 0.34960676328405577, 0.4899602855217014, 0.4492339565702813, 0.6089123478752153, 0.6887971217982081, 0.5026706973226254, 0.15357018756393764, 0.6762703423692549, 0.439860887753891, 0.6248868968285983, 0.6225209615223144, 0.6659487998924878, 0.3137207583250994, 0.7074666647222917, -0.15696299878947823, 0.4810887509766425, -0.17793346229809626},
    {0.40476557527949203, 0.5659144291276126, 0.7299758975257, 0.5945144013550633, 0.21392084896509633, 0.6340590925750849, 0.7138879115450889, 0.3592435596089603, 0.7618782660808611, 0.5167190152488392, 0.6176129701414718, 0.6944420772876437, 0.1740926373461889, -0.23317099245230113, 0.6170296055532412, 0.5766543698348043, 0.7600046270995009, 0.5364191741856608, 0.7769646226301643, 0.5611857804374321, 0.4572798368653743, 0.1657466485777559, 0.5095741271716451, 0.49858415961525077, 0.39674457827739545, 0.8405337132854218, 0.7712801571055213, 0.1648709165243664, 0.5926665798526983, 0.21192446992558825, 0.26454616675975406, 0.031360164729607475},
    {0.6619578983557496, 0.24763816968192875, 0.40608544421838544, 0.6262893492206587, 0.25744458818910415, 0.5122974286615382, 0.5008472366693019, 0.32246432744001463, 0.5092711321510768, 0.6703218400763592, 0.19656505329595408, 0.4464685371539355, 0.007230923875191576, -0.10865745801683666, 0.487348038634357, 0.3530044204555943, 0.4245429265214075, 0.6358796232870632, 0.4647484096729221, 0.59455212894889, 0.6897978670448173, -0.22380148124021, 0.3280477336323352, 0.08165156772642121, 0.7385614682848599, 0.33904071147021003, 0.5037278280647527, 0.5083525345714517, 0.6274731626245282, -0.1775364469257025, 0.642456030562509, -0.25180859940407224},
    {0.5823531646581577, 0.5006077275091145, 0.28023940493290284, 0.6184626466728519, 0.30844390257671495, 0.7538798923345812, 0.6646792876321594, 0.3478839797636008, 0.6082797595683369, 0.48194603764941074, 0.5583523330604545, 0.6503656524449032, 0.37373931964085455, -0.21676982035526202, 0.500858870321246, 0.30902614471501283, 0.6626566527324764, 0.336981466681135, 0.5095279077962338, 0.7425759717023518, 0.7229505610009558, -0.15915168617804806, 0.4155675442263875, 0.14827769096303772, 0.38280629267798433, 0.41725026967917206, 0.4566068745025649, 0.24564608100505145, 0.4619229850742611, 0.14662899745355035, 0.6033588174143752, -0.23809830150231076}
};

static const float b2[32] = {0.54342444247371, 0.5363609346376378, 0.4583520266442558, 0.5102874553656133, 0.29036765904784956, 0.5466079911542242, 0.5277043806757925, 0.5503606424119193, 0.5177003319810258, 0.5315651663486199, 0.4430703056180461, 0.5492774998701289, 0.2754929569932903, -0.03369329868034456, 0.5811183777515908, 0.5412413356788209, 0.5558807053692064, 0.5714134206799929, 0.5401193100086252, 0.5759465743088567, 0.5732526574211546, 0.062472361150902884, 0.5645686536478862, 0.3227688775089, 0.5591615614477655, 0.5686561242117708, 0.5931151775564311, 0.2949556930361951, 0.5304018178072598, -0.0697913128092683, 0.48506939238487906, -0.04299593347507703};

static const float w3[32][16] = {
    {0.9110004547658369, -0.2780014301669796, 0.7095491800573068, 0.5711167975473748, 0.28649041678673065, -0.25192441746088384, 0.7221329915140283, 0.42743995375228616, -0.31532905277206263, -0.14793912038357412, 0.3323369983626667, 0.44708942374612226, 0.1809491927222388, 0.7258797048584261, 0.2084365144545174, 0.5038488286317699},
    {0.8492339881001962, 0.1264310139717323, 0.5479743831309926, 0.27299734184606134, 0.5470463688079745, 0.06162881381581398, 0.40673043400567294, 0.8015035199778571, 0.2594540340614336, -0.22168579405752514, -0.3183746044694464, 0.3827508876295528, 0.29426619215041894, 0.44894934667978625, 0.3132036362584166, 0.31251129879064454},
    {0.41382525193813396, -0.003645444855614389, 0.44731043309052715, 0.7082368714423034, 0.9211095723792765, -0.23562840893808024, 0.7667997890402087, 0.26225739134610876, 0.15212616616826727, -0.24403501348564358, -0.16026790693937012, 0.4906277940389267, -0.14602379500875687, 0.8067283670929534, 0.17075651690976226, 0.48319978595989205},
    {0.8354893306306104, -0.15142141774323392, 0.6084012021962274, 0.5903435552529661, 0.6132505985636187, 0.06987297256641742, 0.6278633407548082, 0.5676063972501058, 0.08001600844235558, -0.34517931947310004, 0.2812218958434807, 0.3494388248273674, 0.1241103626131452, 0.6634339457700936, 0.48217533791716505, 0.6614350010983078},
    {0.44296314244626384, -0.07002767567546327, 0.08960585812802256, 0.4665450008247594, 0.5460093478630617, 0.03645452509742856, 0.41892501208845334, 0.3578843410013127, -0.01550896149836071, -0.28712646851543594, 0.017584143010540433, 0.33411076139374984, 0.07166386699651614, 0.12953369317668137, 0.5282839909461774, 0.6103130904189195},
    {0.3763717109956814, 0.09514825479198265, 0.9072852202821188, 0.4201923205036106, 0.8053023392544276, 0.046875258952714036, 0.16653015944358185, 0.7549362923465268, -0.03628917108174233, -0.13113032322926904, -0.04085782319588297, 0.87201180780217, -0.25338220874695977, 0.17850086398945492, 0.32996189087603633, 0.19521041920139373},
    {0.6928215787550999, 0.24598346132777532, 0.3918002475741853, 0.8174612411846588, 0.5377856547697897, 0.15659005201932685, 0.18746443379786176, 0.8858678771094007, -0.0894608859785536, 0.023947106549581695, 0.02878605984875759, 0.8031676294264636, -0.19523942580476922, 0.5264404245051386, 0.5383440879743079, 0.5845355990867946},
    {0.2810111632065501, 0.005632446174014855, 0.908242800093979, 0.3195652861341754, 0.651498388275498, 0.23948014452179966, 0.5388151637879981, 0.8088632892156291, -0.2574771580513402, 0.09823704801076609, 0.19921859665151848, 0.8118909547828153, -0.27577851887132143, 0.8318913899378431, 0.7245610406428281, 0.4943800071663141},
    {0.33912558437575263, -0.19356314727224777, 0.3922569866832792, 0.876312339237945, 0.9650829845228432, 0.24339012130711557, 0.4133892819683645, 0.7842518104380231, 0.23753732010303674, 0.3042016912537475, 0.31705117913170167, 0.9522514079460888, 0.024006987395438377, 0.6845085140669028, 0.5476740170486307, 0.39082611035564285},
    {0.7291274994100878, -0.29234336044172426, 0.48936703289367733, 0.8118552971023771, 0.6892558446088427, 0.09580216059592352, 0.3390949774396935, 0.5753718532763581, -0.3654747783731021, 0.07248939401569106, -0.16593088226192912, 0.3928984794503183, 0.24069527041317057, 0.6087031223638653, 0.7334963310744075, 0.7055200831692134},
    {0.888892502281035, 0.0555996835332591, 0.46448552533761067, 0.6159414182411049, 0.3642634234175987, -0.196741456714982, 0.27750070191073234, 0.4691720044270917, 0.2026713453802721, -0.06765284224392255, 0.06457443351168267, 0.45515000235330644, -0.08304056059002425, 0.6734560901265715, 0.6071928206669021, 0.4573915235276011},
    {0.6725293352429209, 0.053756482718573244, 0.5734766324005299, 0.5537031109435543, 0.2898941225275993, 0.07753420381122454, 0.5798495327277946, 0.4377464816273509, -0.23376256068849785, -0.05961630532351783, -0.2137626054653615, 0.7392221672480518, -0.3369089177193464, 0.6600953658400988, 0.2966216527687504, 0.6732642725359185},
    {0.05938232510854108, -0.37447692511657144, 0.27091733659521183, 0.500972694172409, 0.23054921845333393, 0.021737468689031817, 0.5802608423372597, 0.35548032350338016, 0.08114095255813172, 0.15658875626099628, -0.026167818386995927, 0.3109861565182725, -0.25658811139824617, 0.61855125542432, 0.5657370435664838, 0.4090314360047174},
    {0.22717601690656244, -0.11282299065932637, -0.2966098514213662, -0.21045609838718704, 0.03295322706082721, 0.2787020249680745, 0.2957899143206766, -0.1408269140353679, 0.06375597620955036, -0.10542976002463533, 0.06957963389619445, 0.30529143632575984, 0.28338645567708415, -0.0873895756536079, -0.35092065044528264, -0.1992503954482881},
    {0.9608267099338007, -0.29667865287671463, 0.32847924896262454, 0.3838033641469371, 0.8200398609275471, -0.25578240893497894, 0.12000848470971523, 0.9234097826697043, 0.07914431047663092, -0.18798480186128413, -0.10283691519927027, 0.48576872744817823, 0.02305604881724355, 0.7962028812913272, 0.25824196347420264, 0.6681794152355339},
    {0.4382425310350961, 0.09233891217872879, 0.7937415042334454, 0.25737796744943353, 0.6726414875018242, 0.1258032190206159, 0.06712611738682202, 0.8329136180952428, 0.049195815959662964, 0.30097201475141416, -0.002071115603420938, 0.6422416286652972, 0.30139287275023974, 0.34836967674087493, 0.7444947056135457, 0.728989672507043},
    {0.698782178222051, -0.28886457331924065, 0.9114017334767714, 0.5700722389096278, 0.5212086526114832, -0.35520501313103714, 0.6264981908094623, 0.6417070229532714, -0.08916534227426559, -0.29379044758672684, 0.2955929544596098, 0.3743409456271081, 0.06822703999545156, 0.6135122422422333, 0.6444877652091034, 0.6928787128078995},
    {0.5527192541127082, 0.2609929483653549, 0.6803554778910825, 0.9155804168769172, 0.9790013049994798, -0.3150576361609228, 0.3547371223766691, 0.5954973501769698, -0.1688840437949285, -0.1612480767926977, -0.18973904903829605, 0.5149365128287952, -0.33129048958533264, 0.5119687871867565, 0.5945843681894152, 0.3162223012494571},
    {0.9615456196744189, 0.06529123541696685, 0.6970248913263666, 0.3306252863069557, 0.8212993576081745, -0.2516503146718993, 0.21750569716534174, 0.37209342249127814, 0.1470622971949802, 0.2852523843373441, 0.2944753679113352, 0.8201009109430437, -0.34405886333348196, 0.49608095768780536, 0.271023283837649, 0.656273281568628},
    {0.6493618973500962, 0.048512626079277595, 0.6567835954083499, 0.772963995380571, 0.3395535244086895, -0.24592818377999018, 0.6504947224834154, 0.7635893671972847, -0.09278803727373189, -0.01793577390591499, -0.2784470111878691, 0.331314681058735, 0.2542696152166838, 0.8256504150099842, 0.16441380302155767, 0.4116897771864056},
    {0.588929599122892, -0.17539788572465384, 0.6199903222210612, 0.8190698142809663, 0.3932935242848735, 0.17329280831358235, 0.530286973371504, 0.4699329982651549, -0.14685502150787558, 0.25426604498821026, 0.057994731376028355, 0.8786833200463858, -0.03874005646070783, 0.5925848161951233, 0.5404786865800475, 0.4714943037224505},
    {-0.3539653706312923, 0.3291153206577297, 0.006344866045264641, -0.2169137345011437, -0.01003302886710716, -0.00899690861777267, 0.19378724659733262, -0.07819987736708937, -0.12147463647503451, 0.09415126071793926, -0.26292858395288454, 0.23814495743395356, 0.03050472556229442, 0.013697503278230766, 0.21665425628045376, 0.4193868451081045},
    {0.6882361449993488, 0.33149398094430643, 0.5088748007443893, 0.7385768653691743, 0.5515707632334286, -0.02158331040506047, 0.5620618506670614, 0.8270481434040429, -0.31446429135663007, 0.048632235021781454, -0.3101722366043588, 0.8054722790409881, -0.18478137809722642, 0.5317239284356025, 0.13805698884942974, 0.6260648457806314},
    {0.315956010528985, 0.01121371501570344, 0.4607825078820042, 0.5815164570223159, 0.2565831877406435, -0.2689550156677449, 0.08796645132510895, 0.6912510641284455, 0.20753378935208336, -0.18810226630810836, 0.17991340040525322, 0.3594567505681941, 0.22426860500115417, 0.6931797067755459, 0.6166305253174638, 0.6151181504092539},
    {0.34559329549343776, 0.08018381028223949, 0.48589824598247866, 0.6057373204250779, 0.7162184955756928, 0.04770528579541342, 0.6958241842322217, 0.7360866234720176, -0.07177137392972571, 0.07382530190573014, 0.11896151643504768, 0.9122400463958633, 0.11910498662834237, 0.8822858363569317, 0.16737770243877068, 0.7500879779234717},
    {0.5013858332177626, -0.22714940755502658, 0.7029405117582034, 0.7523480027703848, 0.5459845928292902, -0.1918970452726448, 0.40938501547820993, 0.7562432767556391, -0.13368568255545965, -0.3202657386657225, -0.08380289760565182, 0.5144658390945175, 0.16074188304964857, 0.7646997759718567, 0.6739534907053185, 0.8205511352610823},
    {0.699029227994531, 0.10316888313001533, 0.5926542576042811, 0.8472163565362132, 0.9444555996703234, -0.3793214131550257, 0.6083476912872084, 0.31320459077668633, -0.361756639091121, -0.32388209116770555, -0.2615224585417321, 0.7101943779678825, 0.02071987346405389, 0.6683709107529063, 0.37501726073873953, 0.5798428692805093},
    {0.3788431480036232, -0.31230845318716505, 0.15927298799189052, 0.2841409826099829, 0.5750272006473287, -0.058819916460298834, 0.5995172297611405, 0.15787052404200894, 0.15746944639272936, -0.2151154011678052, 0.21738189082099396, 0.3770144816751098, 0.10978210213060285, 0.10613776094042661, 0.5969985790814428, 0.27718591749536403},
    {0.6212899432370468, -0.01302754845168641, 0.9370961029300369, 0.534735692007083, 0.7892294309749858, 0.2648485534350603, 0.15963371552011452, 0.44421171560697026, 0.27123867399747636, -0.1019135241870042, -0.28154790380130396, 0.5715976577838303, 0.05396683612920469, 0.6697539106194126, 0.5837804205948023, 0.2746805919678959},
    {-0.2639436546591277, 0.09897867345782976, -0.23050345444620993, 0.17164893973630904, -0.07562668965988577, -0.20807225047970165, -0.1940501712553972, 0.03465982081321854, -0.07145045586509102, 0.131737958554032, 0.3317782576271502, 0.37750294452288247, -0.10885435738658926, -0.18804322710687252, -0.27542308599626386, -0.1866931833220687},
    {0.8059662200619373, -0.1921723703073796, 0.4045033193502677, 0.42980952587995924, 0.40585515737840333, -0.0013344470243116119, 0.3965092503176051, 0.7095365212521505, 0.07740526413251221, 0.13943160870382526, -0.024829717373395507, 0.5429464173486092, 0.22873148496509607, 0.3931650279711964, 0.6444616649644316, 0.5464593942677398},
    {-0.06229976050071449, 0.10303715919377546, 0.12488365815006865, -0.09169903025835312, 0.09432430036583161, -0.03439733153189223, 0.09822273714613605, -0.1761530439579905, -0.29075038430664535, 0.13134181195960498, -0.3159940549844418, -0.15732891944374133, -0.11826498491009184, 0.10774932427625293, 0.16441791999974517, -0.20652371199180727}
};

static const float b3[16] = {0.4122144331847722, -0.05628939309113614, 0.369996165144587, 0.44705389269168727, 0.4453135166224543, -0.02410244554688519, 0.3458406913343494, 0.43362958637446813, -0.030976181440158165, -0.008312258643754185, 0.054285284100063, 0.4227760194245318, -0.016285788182382615, 0.40831057005904536, 0.26479592850801864, 0.43470537022826683};

static const float w4[16][12] = {
    {-0.2803507102876208, -0.5257568422368658, -0.4389589707316929, -0.7286499152039677, -0.38910609170901533, -0.8739921793478748, -0.9964593182510704, -0.2697287154562598, -0.588078123004892, -0.4885661923541362, -0.5739518185925045, -0.6162690241160059},
    {0.08368470993264492, 0.37509473952902733, -0.2341974368726825, -0.31094152614042164, 0.23889572364554063, 0.23830764773006938, 0.14388753476349364, 0.38498696809227667, -0.4742165677645755, 0.09622804031873959, -0.049968224911813235, -0.09422383965837716},
    {-0.6815916094734608, -1.040886416144716, -0.5618326321347207, -0.5898571852755242, -0.6097584443373983, -0.6297670121146668, -0.6977702236412249, -0.1372590056286003, -0.4138269756719933, -0.7867306292639308, -0.47979618931330886, -0.27153724421115366},
    {-0.3099156586695029, -0.38122201796569527, -0.8092732361895588, -0.5136891321404167, -0.39865556908620414, -0.7178843171069285, -0.12622258575108367, -0.5634678654728037, -0.9136111999378728, -0.5709508603763741, -0.6483326230150027, -0.21869000922909312},
    {-0.768622550199918, -0.6487816251950823, -0.7085338134492083, -0.30650219293149705, -0.9854041794415315, -0.5042331515618853, -0.23386848211842776, -0.2976522092703687, -0.518057019597098, -0.562221230872362, -0.8001420818663307, -0.576318744990004},
    {0.26757848131834433, 0.19344425286460798, 0.13815322193216695, 0.3668196395623663, 0.41388949481223963, -0.222331462233098, -0.04355272530952962, -0.014107022452543503, -0.16324532325990251, -0.4377304522217289, 0.21090690135611184, -0.05179724020919357},
    {-0.8339195896719742, -0.21803604841899893, -0.13543711736180264, -0.7626655066718132, -0.5191796092093451, -0.039427590674129834, -0.9114528202734221, -0.5319880327233313, -0.13054123635401418, -0.5600488596983986, -0.06308447312754654, -0.7172360046010938},
    {-0.6610169335013646, -0.5099093728368848, -0.16999545066797578, -0.7176735812365785, -0.7143737608007938, -0.6752340992327885, -0.11617373090396825, -0.9071387579681544, -0.7027827623663583, -0.3685857663481865, -0.4656047082027166, -0.41423122817972235},
    {-0.39770229611907754, 0.4295432480990096, 0.3113178308773611, 0.4341102168995432, -0.16368539692763406, 0.2853061472993852, -0.08400589153514999, -0.15125054653700934, 0.21528943581725996, 0.12439069325480451, 0.13901081935541224, -0.33207357967330914},
    {-0.14575622534663915, -0.33876916109330246, 0.17519096023228128, 0.23061364860059694, 0.26500150732442157, -0.17134886279171196, 0.3458540357625601, -0.3464862356124924, 0.016704442053491357, 0.06144500262535259, 0.3260620025616478, -0.36052749538031437},
    {-0.5495379638981469, 0.3095750180959515, -0.12971147408437408, -0.019838087806159567, -0.458682231854561, 0.27000379304091165, -0.18202348879461278, -0.3111240239492258, -0.40427916670279623, -0.37744206343187375, 0.4032575768357204, 0.21828792452655454},
    {-0.17903376718087755, -0.47122344499011143, -0.7653276330124329, -0.3201906711402598, -0.5236244172497777, -0.39325066725121166, -0.5916555761448297, -0.8235691217887671, -0.29301216082132503, -0.7949887491310991, -0.7465487714644566, -0.9840125003399554},
    {0.24140116831570824, -0.09269650806262433, -0.39091106607120496, 0.09261701890879498, 0.1408695185164104, -0.058938456271102356, 0.42421045092934434, -0.4083699318947368, 0.09771002236452793, -0.2765705040746254, -0.12447082029113823, 0.23142850351003405},
    {-0.7098653664068922, -0.15029142440105608, -0.7801458862374911, -0.5008678096589, -0.2570425974072906, -0.6906869060989157, -0.6153718074844198, -0.8659947572133355, -0.485524422014018, -0.23073201316362163, -0.4917314497912194, -0.535697570711495},
    {-0.046036937762259034, -0.08776124963108142, -0.2747695330805514, -0.0010242864885478778, -0.46699154888867334, 0.017691390416883834, -0.7100314199014852, -0.38756903300829604, -0.7342320253561969, -0.5455763184948837, -0.3336064634472907, -0.09251183322375493},
    {-0.6746836300162193, -1.0186965202850866, -0.3773969549790435, -0.7294055888517997, -0.267169726890455, -0.2755497935765745, -0.3619756982776019, -0.3542158919737492, -0.30570353703052905, -0.3200658658623341, -0.3654306258571787, -0.7676106402023055}
};

static const float b4[12] = {-0.1761878271656319, -0.2865085941944551, -0.09389091697608408, -0.10039533468644297, -0.24020425598866785, -0.14746555999773345, -0.23391063020223934, -0.20798234033014218, -0.1904810817333678, -0.07802850392418884, -0.26793905290091785, -0.1855499923688238};

    // Input Layer 
    float z1[64];
    for (int i = 0; i < 64; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[32];
    for (int i = 0; i < 32; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 64; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Hidden Layers 
    float z3[16];
    for (int i = 0; i < 16; i++)
    {
        z3[i] = b3[i];
        for (int j = 0; j < 32; j++)
        {
            z3[i] += z2[j] * w3[j][i];
        }
        z3[i] = relu(z3[i]);
    }

    // Output Layer
    float z4[12];
    for (int k = 0; k < 12; k++)
    {
        z4[k] = b4[k];
        for (int j = 0; j < 16; j++)
        {
            z4[k] += z3[j] * w4[j][k];
        }
    }
    softmax(z4, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
