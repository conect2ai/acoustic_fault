#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][16] = {
    {0.3522054755081786, -0.743577983752676, -0.2184064423987198, 0.056776573231046824, 0.5305401144455418, 1.0895549547243397, -0.7650621424720626, -1.296255255164837, -0.9358162010252429, 1.5530823249765453, 1.2683897476882247, -0.8459565061760173, -0.03445437155172371, 1.9175066376569643, -1.0618411351841368, -0.18160081512087958},
    {-0.22494647152072075, 0.4655919887008698, 0.5812628228626154, 0.7380490305853934, -0.6895186165957314, 0.5178282438033377, 2.010859514088861, 1.8408289744421993, -0.032535021555644014, -0.5194388000007331, -1.0400146778930677, 1.0551099312860062, 1.238352975256305, 1.1155187619688824, 1.3069857049400773, -0.7758171169315816},
    {0.5499430840125925, -0.33501314955736505, -0.4725604820158081, -0.0028067025557453685, 0.3243286215088405, 0.30820368695233563, 1.1243256345651491, -0.10030149517980906, 0.17721324647691705, -1.2286652991444076, 1.0945149035740815, -0.2615434261284988, -1.5952441027578141, 0.008305644737922769, 1.2964203859531156, -0.5041122717213753},
    {-0.05031036579372192, 0.1786094562507742, 0.164110271325555, 0.23644808271963785, 0.4983324762658859, -1.2525100727330045, -0.009637972077853196, -0.4691908297801971, -0.4143869198553424, 0.5453835418756605, 1.2894542627264116, -0.02182764694551224, -1.336111419648181, 0.7435261464943952, 1.0301164573375607, 0.33823644344142273},
    {0.7325267634967383, -0.27241380983372593, 1.0143846323282772, 0.42718031640412757, -1.036311527194575, -0.8541559760896597, -0.19731085662677433, -0.7799794216352086, -0.033662868333316415, -0.3366460817236275, -0.8419779177273231, 1.620489031788728, -0.6103931293974453, -0.7849685382144704, -1.3737269658475502, -0.04494884213244821},
    {1.2217211179387246, 0.9919028984751938, 1.754207481613907, 1.8665945129575094, 0.5627042559973905, 0.6805741851863962, 1.1181039378077076, -0.4017152028037196, 1.1192443915217083, 1.3988128648299527, -0.7483073481392759, 0.48992812034496636, -0.5392395463361278, -0.7698140431045108, -0.48889047983933287, 0.0685091079031167},
    {1.33761452194428, 1.3846475807728915, 0.5942427645849795, 1.9395576980240936, 1.1493645640827017, 0.1043244820502301, 1.1291674621873775, 0.03316463339168485, 1.2764777309864943, 1.3263425980916757, -0.14404752987673441, 0.6902927569665168, -0.4395773708792781, 1.1082084616039114, 0.6563936342415561, -0.09430578936467705},
    {0.4051949917294453, -0.48994344650966093, 0.5089456658750037, 0.28328117425848925, -1.4628053753134926, -0.8073660374359164, -0.14751546741544105, -0.01614455704929965, -0.18894606679086423, 1.00065050169271, -0.8489350160947146, 1.3240282948252002, 0.15548807856207597, -0.38638188212898805, -0.3374352456022857, -1.1059634799349276},
    {0.9137034451246651, -0.13755328125303962, 0.07857507604961801, 0.1308100212582736, -1.3648864720120684, -0.8464363256852464, 0.8810086945682614, -0.9158272141423567, 0.022649399840051373, 1.1753062088467487, 0.3915227378492063, 1.0062141388251213, 0.4312503490727318, -0.4073258876710576, 0.8805809768646944, -1.1293033671804888},
    {-0.7398026895312516, 1.252517781314714, -0.40713327034105384, 0.4789980790149944, -0.9962661129421216, -0.05646769446812584, -0.49944617713637957, 0.289912280259701, 0.15862276431930036, -0.11008895887475513, -1.75204851226286, -0.46165090611513016, 0.6665233667933531, -0.07958209395096705, 1.6509101584700796, 0.35638034087379583},
    {-0.7199790096841776, 1.6129003541538791, -0.051555630510045795, 0.09084116431275137, 0.3556165166084012, -0.24053760385121542, -0.7663125208817803, 0.915065283945995, 0.6759428819806618, 0.3452850723500897, 0.015222619067781084, -0.08363789609725036, -0.429284346744845, -0.1920763599043079, 0.23127523300286104, 0.5908150028807184},
    {-0.31579810256941515, 0.16219140746238392, -0.06997451926696208, 0.16027890595675678, 0.2974258312289676, 0.005403063607578354, 0.8289452917168434, -0.4141596383141449, -0.9693887245672503, -0.5690297337827994, 0.43580558063898994, -0.6264335859962329, 0.09452770722465818, 1.1709211471187064, 1.1805180836216302, 0.2910862173825331},
    {0.7221118022649567, 0.8470119906274686, -0.7056772181001071, 1.0235550105713507, 0.435957463183873, 0.23916001003657034, 0.503335186134567, 1.3423100707165079, 1.0865886978149213, 0.072445958184118, -0.09170374553482612, 0.1184380614539452, 1.3723736713853696, 0.24201629764785515, 0.40996436366465233, -1.0579568811179902},
    {-0.7896444078759914, 1.6876133014154242, 0.9936927386265927, 0.4522157204231802, 1.1216731808252705, -0.5362295877853516, -0.06309979514036997, 0.5766274100378399, 0.5035591717257433, 0.8251049342672063, 0.42609957777925705, -0.6755211750069025, -1.014559991242771, 0.42051968341549373, 1.27464944334596, 0.03688188308373815},
    {0.7565949410192743, 0.4762808504655882, 0.6588486149998, 1.1228441435965928, 1.982840650117787, -0.23770457355166094, 1.2100713334258584, 0.27314344705664917, -0.35338776781081577, 0.9295591960775442, 1.8306496614807994, -1.3330975257629214, -0.7256248925668091, -0.33848159996393284, -1.2737449508378624, -0.22361232545980464},
    {0.056646215203297885, 1.0543852095249902, 0.06549087537324082, 0.9429658948610844, 0.4827617948411472, 0.23575345683128243, 1.2027377088633282, 1.2307421648122123, 0.8531833054250131, 0.4634746514114053, 1.302719183627308, -1.0327317958181887, 0.3687771027208078, -0.6025486082661886, 0.7305240626934391, -0.7447539016032764},
    {0.6706063081201797, 1.4787666538537476, 1.5013602962852068, 1.179569874294027, 1.8107613779391474, 0.1683312853002333, 1.2093292473811728, 1.6378751933803029, 0.27913784932837177, 1.724627928271046, 0.25691517274905135, -0.24587352969962245, -0.19641035592031209, 1.3389696498040407, 0.5378957974805111, 0.6402834833518424},
    {-0.13991566719527693, 1.5799989293473882, 0.5984705959181111, 0.4942325572515793, 0.8820309645875529, 0.18154918032604558, 0.4413657162209796, 0.39870581971819496, 0.44238005597659447, 0.3453756630369328, 0.6445946967303312, -1.064095801611852, -0.7382053439080111, 0.27461443943830244, 0.8338444895148545, 0.8379462936172828},
    {0.5172510377452761, -0.30160995119916556, 0.33875387827118564, -0.04055007980842523, 0.41829015280314524, -0.4690927964853961, 1.1885931520551654, 0.8862037289306812, -0.3872573998432746, 0.8377161063720628, 0.642583666714611, 0.3171788465523783, 0.33008272887813295, 0.12471913418554331, 0.0512995638232358, -0.6440727772866732},
    {-0.6890517458329039, -0.15052554145231373, 0.1407532256444647, -0.39447404929566626, -0.5686166714039385, -0.37779946892432575, -0.6247689803942252, -0.2042252472451191, -0.6332004981884201, 0.09741706689553947, -0.597739581489677, -0.6754509674925298, -1.1415481879170353, -0.12187877304646808, -0.5383196628417054, -0.023056767833099165},
    {-0.2852346388303638, -0.837553279533164, 0.4345263300511587, -0.4309291006128047, -0.011311544308880721, -0.7972895653833354, -0.712184888436335, -0.23100279938540946, -0.4875914660822197, 0.49666798023841124, 0.6793210018517434, -0.6461512817949343, -1.0222003852971473, -0.6135075820419862, -0.46231549643227215, -0.7131123680829891},
    {-1.077278936760987, 0.0309402834404059, 0.3231175419511016, 0.1877228848357317, -0.004090508416415383, -1.5564522177957412, -1.1681666932679668, 0.3065637425758268, -0.23075851075267978, 0.7724931523121256, -0.97858132043544, 0.08546922906875176, -0.07589604977171362, -0.8508286264638695, -1.2526206333352783, -0.18692961492399146},
    {-0.004813021236425674, -0.3637143141766023, 0.3626656125728391, 0.4455437747308775, 1.8966763995642484, -0.026598735814129786, -0.08193170313921468, 1.457351140566821, 0.0891930806688011, -0.1775990302341912, 0.9669028544918142, 0.16749560241500244, -0.44740730530073725, 0.2598620620129443, -0.40786520418761474, -0.7180712067606878},
    {-0.8774452504835746, 0.15110708147260635, 0.3061034494333292, -0.5882228188343099, 1.3047198405735565, 0.7559584332542018, 0.13995231709937953, 1.9543574301468942, -0.30365208753729406, 0.008656253952132192, -0.4923670196939828, 1.248440992869146, 0.5050127122185042, 0.020639953005456613, -0.4596948388716831, 1.1143422205223883},
    {-0.10915687603507154, 0.431732647190234, 0.3666470203093217, 0.028039847617741365, 1.6444012103876784, 0.8614021676196142, -0.278244621843261, 0.8328672090449151, 0.030670598928958563, 0.4472794613501631, 0.4099626800514986, 0.8645360564226193, -0.6777539308744276, 1.4982378546891193, 0.12961413165938862, 0.7289993945760482},
    {-1.020359480286916, -0.3003298624079891, -0.5202573943670064, -1.737445855111356, 0.7227038755833616, 0.3538132142594275, -0.39917436714243887, 0.23738422164821116, -1.125816747247377, -0.40195067655862315, 0.5781713924391627, -0.23354601591989582, -1.2583141298065763, 0.5459553395855795, 0.500730546767554, 1.2302054060210261},
    {-0.4985239705086869, 0.2741048647668445, -0.6178886221293315, -0.5109853567813448, 1.1150514880923983, -0.4163532282713207, -0.849135784694709, 0.8488917084229298, -0.5446831903888363, -0.40103371230111734, 0.1584134245988545, -0.4666118920634063, 0.3851624343854979, 0.45531209529483907, -0.7881345970254435, 1.2499461057075405},
    {0.04924824721753502, -0.1924663515228453, -1.0260772665073357, -0.36877653614171174, 1.062216860298104, 0.2088309956573733, 0.6977625982889877, 1.2829711640536654, 0.32708851593830823, -0.5428922554643578, 0.36003621736218855, 0.7449329826315101, -0.2623719111462649, 0.12990352452239728, -0.14588043597762945, 1.1782118131349302},
    {-1.1077787650853175, -0.11658142715642536, 0.4104729159817365, -0.48279754420956617, 0.3538266300480844, -1.0516788655378182, -1.2830666163091458, -0.17076249730313423, -0.5527351343797834, -0.6914959542495969, -1.0318917342702478, -0.5008344004254616, -1.2983757931008293, -0.32437138998958526, -0.25880226048747945, 0.705187072467464},
    {-0.051081577649443974, 0.21697515576440177, 0.20590220017248395, 0.3328650791815497, 0.8262075393997524, -0.3831723938593207, 0.25889850234398964, 0.4643772813523334, -0.15104668907398702, -0.0709019892765845, -0.13808833929294934, 0.3769185461115433, -0.1055206217593072, 0.1415005956737225, -0.3619683594268668, 0.4310615215005892},
    {0.4430220642393222, -0.30678412987145715, -0.8923011640434665, -1.1504705288764463, 0.5348743370810244, 1.1633761116623822, -1.3223642375143294, -0.21496517056169626, -1.0666993332732104, 0.977143134168658, 0.6914144367530856, -0.9240117498938898, -1.2178400231500237, 0.7798015451123252, -0.080946571396955, 0.012877798893229266},
    {0.12959997767415224, 0.7371090844655754, -0.7378257738078843, -1.030180665898702, 0.8226190638992078, 1.333098541772549, -0.2524241246973935, 0.9381274865625139, -0.7403169741527097, 1.3886781750216906, 1.6911083953428983, -0.3756446141823471, 0.014164517282099989, 1.3723133800399967, 1.0207222251389667, 0.5347408097069939},
    {0.9632889241523842, -0.5544233713268876, -0.7517088235590064, -0.24214633928803173, 0.4411293821166417, 0.9486594246621534, -1.0904553932834478, 0.4304389116066583, 0.0015106398430245658, 0.6072279954421268, 0.35947547630373006, 0.12520528708440615, -0.1175627615058478, 0.7310513615854163, 0.23285275359205995, -0.2253664783070529},
    {0.7013746501412943, -0.3166104909259888, -0.6905452289024914, -0.07406091665032924, 0.5150372501736168, 1.1452928097055186, -0.6137346310333318, 0.3427476177123234, -0.3526029063672297, 0.5706587178346568, 0.6118704201253105, 0.0636551711460324, 0.005574172944535333, 0.3811423073970481, 0.3090977814198548, 0.0368858876964201},
    {0.39865929085950524, 0.600379371764555, -0.3934717743721236, -0.3693825362413936, 0.786632481474335, 1.2269755682913306, 0.3097982492748243, 0.9756873382934294, -0.10973905757441288, 0.3140977029126581, 1.4130356108966389, 0.15778635095401464, -0.6344565627798875, 0.4047973199267133, 0.12121897465804543, 0.6242652997224407},
    {0.4382060659185391, 1.1340713327172685, 0.2901340637616906, 0.1436204302680373, 0.8423381274141202, 1.3458636529780124, 0.5989524342808696, 0.6782006977760504, 0.06067701808509954, 0.31014484599946174, 0.8242217440474238, 0.4083206583628077, 0.2030186907764954, 1.116784369180759, 0.39017661700869677, 0.8370761797606903},
    {0.1867510130372495, 0.759600784194686, -0.5609269633248452, 0.3292682634941995, 0.93593154892535, 1.1668114524014588, 0.41570062387433415, 0.7006648245760435, 0.10764124616495027, -0.13059304794630003, 0.9007838898371673, -0.15103607371664104, 0.05318691965577874, 0.40663667275472337, 0.47129408295929837, 0.5619044366944833},
    {0.27132823240707105, 0.01213312334752207, -0.37375675718996937, 0.19595600848105116, 0.9706174343585335, 0.025616536685224747, 0.08504456857113456, 0.40846479127140983, -0.1881300879134598, -0.33119803620353144, 0.3838431003469175, 0.3239011712182424, 0.17161117078396648, 0.40976829691534483, 0.01586840600721062, 0.24230213646562593},
    {1.1354529181198159, -0.05955453930069648, 0.018143641007188155, -0.026620677667912762, 0.8409981062984518, 0.11428171987756137, 0.3163665186491535, 0.5648974179486673, -0.0739282235493261, 0.39819935957138797, 0.4905342862654879, 0.290617542082613, 0.1711536964451717, 0.6843736822938439, -0.17339284243548106, 0.23268400841958234},
    {-0.3915149346319062, -0.3367062721165332, -0.43357410993379797, -0.12314752419373386, -0.7366779204885363, -0.40164750655818665, -0.19136870074622614, -0.6519940331252442, -0.4491685802131756, -0.16730637005142765, 0.020548624044477257, -0.429611691926119, -0.5340914018548135, -0.45707066419770837, 0.008163365720766078, -0.13193616153481877},
    {-0.39609697100961044, -0.1355839652055822, -0.41783276057802277, -0.12800218824812346, -0.6837156577626449, 0.17451289670509004, 0.0068194705813939644, -0.5290881390723372, 0.0993051435589171, -0.3221712878584486, 0.36112892579053507, -0.6937908426992696, -0.28355852512943286, -0.019135363389729265, 0.5020226154389329, 0.4481762697966672},
    {0.6886262994933714, 0.029841722673340662, 0.20192155919513366, -0.044004099447873764, 0.6477075974495441, 1.0245532974802525, 0.23904314223025466, 0.4687063853932032, 0.19684768121067026, 0.37269389760639693, 0.12477178150703215, 0.2001808984322031, 0.49791306070226043, 0.49469000434652177, 0.20087049352734573, -0.16866999073432498},
    {-0.6619579418426731, -0.6830620264363156, -0.06576438087130819, -0.35752536765693754, -0.4426419400911119, -0.7722210715471356, -0.5023336082724331, -0.7088322571239601, -0.5503894877183428, -0.17774282934912436, -1.0087609884030975, -0.11859054826764699, -0.4563766692368997, -0.7078112288428993, -0.06653887439390592, -0.47815249003219207},
    {-0.2494353483459082, 0.31778199516472594, -0.058124815577485146, -0.5320721141260797, -0.2081036900510013, -0.7055362242848525, 0.29697758771807736, 0.053771857922621735, -0.23415129176350336, -0.6094290334911256, 0.5374383112595094, -0.669122227665265, -0.35128723447146565, -0.4714782362706367, -0.027202131288033164, 0.1539857549147251},
    {1.0514855114014465, -0.04477729159509135, 0.337112571293777, 0.5143205698605412, 0.46024068367705995, -0.03057721008804502, 0.3895776329941789, 0.03338636066818885, 0.04037526045837902, 0.7426459050092904, -0.3251922036029071, 0.7974702324832432, 0.7382182952548237, 0.5235237817070574, 0.14929759010202068, -0.19997972625596627},
    {0.6683408468414319, -0.4010228684701995, -0.0074282704501232154, 0.12469545118237096, -0.17448931634420597, -0.4944334903350021, -0.6146910923362188, 0.15569539234235755, -0.7439264180754989, 0.07941025477124129, -0.3452979252662062, 0.1771390978472184, 0.06674176356152813, -0.1811178638548517, -0.04763724155902235, -0.0014125750318908696},
    {-0.15201619312565876, 0.2620475768335402, 0.13425475500101144, -0.3101974932643252, -0.6267049359637534, -0.265797179792189, -0.0983860301552928, -0.1590314504897571, -0.6185373265639975, -0.60569655650877, 0.47891075151721646, -0.21197235018995236, -0.587240414247876, -0.5776147080167506, 0.26384430147256854, 0.07765737867361414},
    {-0.2748877363896265, 0.16182377882406362, -0.2205358697615601, -0.4752116740488873, -0.27334481951410355, 0.4856141849116099, -0.45468056173449195, 0.13621126523098004, -0.08349705960206466, -0.7811505898924836, 0.25702731242491034, -0.2545894999911837, -0.5402768839120345, -0.038192966039752224, -0.2065737103965837, -0.3824502997234685},
    {1.0578423114666484, 0.007003645777071176, 0.3501823052230597, 0.5356480990699731, 0.05937673084067841, 0.5692437881368219, 0.23973801406107628, 0.37946499889034757, -0.25756847208891065, 0.10620151669547677, -0.05881091106717444, 0.5730266256559812, 0.5120027780792242, 0.7366556017127721, 0.12633436387187907, -0.10834748890826475},
    {-0.10467704339226348, 0.3908386378258278, 0.3089406476241931, 0.11241534289553963, 0.37112432029591014, 0.7383754313208315, 0.7073335530448607, 0.2348291381871047, 0.1524267460242292, -0.3246449178148317, 0.5416863714265098, 0.20534090614726527, -0.1347954048371206, 0.42430228580115037, 0.2187447004502988, -0.323205525304802},
    {1.001608339069742, 0.5177730728922134, 0.584704725210035, 0.48150953523682805, 0.28292074238355097, 0.10776423636786256, 0.43173805857181186, 0.7455971785206549, 0.30234948758495134, -0.3656522461810694, 0.4521755128691972, 0.6489300531464017, 0.03954951464028751, 1.1712761995429644, 0.6170337877703528, 0.21339726299020556},
    {0.45879501503560005, 0.6818026583937253, 0.37090754558256367, 0.10874300830759977, 0.22386534804229472, 0.12727446117642396, 0.410757961926558, 0.4647929656109721, 0.24990012286154695, -0.18309682646833816, 0.3370513357392855, -0.08423598301321673, -0.10680699655013268, 0.2889802452382527, 0.16658428829782576, 0.11923783871266325},
    {0.21442705862422282, 0.08148892357204285, 0.08824285674641656, 0.13618000052120843, 0.2859544973258306, 0.834962931975442, 0.00831753314227614, 0.2960570211451943, 0.009295674469909624, 0.14272590904488838, 0.46876572263685257, 0.026006487434924837, -0.13362876585457723, -0.07156510117013384, 0.35225253940761, 0.13490382535537612},
    {0.2772168367716666, 1.212756208520519, 0.44314301662617983, 0.1885175437060968, 0.9269124894942893, 0.47906611856128234, 0.7300270157263591, 0.6495968074680161, 0.06409026697782327, 0.03121851719391362, 0.7030598444398003, -0.08642523836006388, 0.160064129452931, 0.4855827781821788, 1.018526237910944, 0.578837993000754},
    {-0.858877078374015, 0.7847586241778604, -0.27205080144790234, -0.2730355526983379, 0.33840483291963525, 0.19219904231652343, 0.6214171309164593, 0.3114812865779673, -0.3080241534329016, -0.7243985111786191, 1.1594650805786348, -0.19428965677024398, -0.9018056397271176, -0.5180142872170532, 0.45785334031826425, 0.0772270056602463},
    {0.25738052644066023, 0.6155311491272695, 0.1218579744779113, -0.36803455540905966, -0.06823170613644623, 0.12893123912344354, 0.060362247089876975, 0.23442972446567592, -0.3684745009360988, -0.3035338467820172, 0.31174833970679994, -0.08662170857454957, -0.03343738474726541, 0.07441853559184068, 0.3891626727640377, 0.6874163829153952},
    {0.6007608091856267, 0.8643199389934013, 0.5741315078543544, 0.39677513783265717, 0.48589773680792636, 0.3460046148071937, 0.6739158477990834, 0.5414124389899467, -0.14280944485694846, -0.19871725542119514, 0.5263384055563289, -0.11325760466334478, 0.18196695802101892, 0.41806073472136873, 0.4976784515809051, 0.15705974722045482},
    {-0.2577606649709886, 1.1315382741346593, -0.10660287236593945, -0.33568109741499236, 0.24081730317866568, -0.2810559429393363, 0.45722221893242776, 0.09634085466726275, -0.23317126229375376, -0.7555039184150892, 0.8665530348151653, -0.7256993560955228, -0.9508563340552394, -0.1084478323008149, 0.2969952147698698, 0.9117611287816334},
    {0.10023078206715988, -0.3814112212623931, 0.33878534035065005, 0.6309241921709412, -0.31531203738699515, -0.11666917901471857, -0.2720266842978022, -0.025298269995318784, -0.20424773996118023, 0.21537454711168555, -0.2263504636382322, -0.057502333685897807, -0.03748160655990037, 0.0933819980968894, 0.16933875473918142, 0.26534547460471614},
    {0.6956362250106773, 0.7364525161828402, 0.2840429502598138, 0.1596466169606362, 0.6261913892234091, 0.9960919656996944, 0.472649760699616, 0.5713488551880418, -0.15433894988034938, 0.33541953658645557, 0.6135949450390937, 0.30215309769509774, 0.19575895017430878, 0.27612995868368095, 0.6538965389791911, 0.6156542405218475},
    {-0.4994497413446213, 0.14945540149661937, 0.09026219326465848, 0.4025612497941614, -0.35720244948974306, 0.24093378320909267, 0.43587224784332845, 0.05810830807294286, 0.08277626866577165, -0.272318844662509, -0.0025622854364120273, 0.14332451994334036, 0.14513875884938107, 0.22763013389903405, 0.26083802810996615, 0.39788130198666066},
    {-0.10090695359294305, 0.574392315935831, -0.2821765209948734, -0.4538152057743923, 0.41092427638204, 0.11557001559276008, 0.674193695105105, 0.0011994848181674151, 0.22653991724736397, -0.07540693981914692, 0.38531560208188287, -0.6223742964908843, -0.4122015333154549, 0.32841139541918146, -0.023523496129766612, 0.4173477971757027},
    {0.7879896510061696, 0.300718319987464, -0.2102386063804122, 0.41914767922016843, 0.47388781136251945, 0.22693177521880278, -0.26364072175232584, 0.3769379821688706, -0.1926222114920227, 0.0723704092231501, 0.118068227327969, 0.7202001146101867, 0.23651883179898692, 0.4307230896463114, -0.2605894767430806, -0.5003104536513386},
    {0.5515387138538789, -0.1971696929850109, -0.06685254609200986, 0.35534075869776316, 0.31035207276888266, -0.1828060482884481, -0.07358052843568351, -0.06774194526495769, -0.15922855788154172, 0.4592971696970138, -0.31661556053642514, 0.39022631157207305, 0.8547200211409509, 0.1362046821437881, -0.23826697966714935, -0.576011539117189},
    {0.26645237995592447, -0.5832988352416593, -0.01439991466053859, 0.5474063226267252, 0.00817348484248252, 0.08126763065283868, -0.4017293172693161, -0.3098421859444598, 0.2546338624186281, 0.628319524300568, -0.33315734044877554, 0.6334304850277171, 0.22336402129628755, 0.07447213292892392, -0.11870719568989362, -0.2202874029783937},
    {0.27927897850569217, -0.7555418401691485, 0.14442961978968452, 0.10527882324012315, -0.346794517885827, -0.22401369118509779, -0.6445182006674787, -0.3040960500501198, 0.7365431436477677, 0.46338787578762125, -0.22953364039758914, 0.27559075416316514, 0.40528722964669794, -0.5695594436311285, -0.32378219136196335, -0.15631877603360747},
    {0.34972014940519675, -0.28070783740696437, 0.3168694354935855, 0.1970127390003911, 0.151277554933391, 0.28784786643981475, -0.08110783042828075, 0.29818372053077, 0.5245161658245322, 0.2068045334849389, -0.3490172672222212, 0.2833612570694583, 0.15722902512994474, 0.22763965728695917, -0.06113511809599613, -0.2761184724939859},
    {-0.0035415195929235435, 0.3325910424355155, -0.0829658035664924, -0.3729546362811928, 0.5457821613801185, 0.5111892737597786, 0.0018117420286862661, 0.2722393050667448, -0.1145700531511188, 0.309098848891433, 0.5525443356304579, -0.08005669435428094, 0.13761188161182, 0.3441774571173441, 0.3851961956451677, 0.09140071300017207},
    {0.17800987391531317, 0.5599495743947112, -0.30374977726902785, -0.19306737256062206, 0.31965949197552435, 0.13614786437609305, 0.34555662461584197, 0.42552781952444185, -0.1374474842343878, -0.1005865961500513, 0.7152878439936129, -0.24496643566614565, -0.011339539333861613, -0.09351021749600551, 0.2523788391958703, 0.11864309506609841},
    {-0.23176766627695747, 0.26335825526750684, 0.5194144252282601, -0.006240146519713447, -0.3184812536775665, -0.19627544720429524, -0.09459998115502537, -0.20236283932230134, 0.4849386214684487, -0.15649736174009174, -0.17188764413553226, -0.23876173542310392, -0.09575662724224415, -0.40633884388147967, 0.003971982511650598, 0.3263544684235933},
    {0.025413032389493606, -0.7682257724830734, 0.038903584407041204, 0.5213179638343783, 0.38139266680444495, 0.3941487698290582, -0.016551170864003, -0.04533322946346395, 0.11514299105915232, 0.2549726269245793, -0.3751778042993173, 0.5835177735927992, 0.6443162272375434, 0.0977634613187371, -0.2194871599532023, -0.12524927986684126},
    {0.3002745297120417, -0.4872603145922558, -0.11324379594465929, -0.20778398221164304, -0.27919594676719767, 0.20113170444432837, -0.44998756935755385, -0.043503949590277625, -0.3179537712417256, -0.04321549536932838, 0.009614773576870886, -0.26145008504387557, 0.22975350083652377, 0.0954151682055316, 0.06768495368310656, -0.12181745119303548},
    {-0.5667886688482726, 0.2975906539016641, -0.24004838363650793, -0.3834019188416424, 0.038213905288241506, 0.3188897392892391, 0.27828551313553795, 0.03835903455012023, -0.4560170229484719, 0.02347349748266197, 0.3969200110701339, 0.022358143817741753, -0.48166849327052563, 0.08757814861384265, 0.12963686946204017, 0.06940605593128821},
    {0.4133255195872136, -0.3795022730247512, 0.03324648129065917, 0.5757930343720821, -0.2304699199098532, -0.1619355872488371, 0.18879864356708873, 0.014710629625239046, -0.24509499375012922, 0.4396790648587586, -0.29284164906044347, 0.5621302026666349, 0.19330735878261993, 0.02388978793047359, -0.45428865833248905, -0.4807932642376469},
    {-0.6746231166881834, -0.4375080221467748, -0.3329332816638935, -0.44566678669374726, -0.7628415019896351, -0.5230649015824316, -0.3870215228876923, -0.4037378451984012, -0.09439920775390308, -0.12350925692582954, -0.09270275585447553, -0.8006777678357785, -0.5234533633124856, -0.43902729585462325, -0.11690207324147281, -0.08264022207486757},
    {0.6282694832054183, 0.26808269104122695, 0.38493523217721387, 0.31455400943991724, 0.23954046906718854, 0.4867347089794205, 0.04728904584628902, 0.1303054602064507, 0.39147556636189396, 0.443783779536165, -0.28487378121483126, 0.3017227939058468, 0.6320413690325655, 0.4313761922149517, -1.0814655305703739e-05, -0.2780424747722827},
    {0.1696252220825269, 0.02952024842713194, -0.19878826478370362, -0.14495061305371543, 0.5039787463498921, 0.04755331534258991, -0.057712555146695314, -0.13200178286626135, -0.027197491152729507, -0.08336775378113921, -0.0054194132004997, 0.060722268764941675, -0.1379364012118979, 0.1141920386364674, 0.026610104774837034, 0.06939019858187281},
    {-0.02485607570567892, 0.2526570534716358, -0.4542785954127962, -0.5292366924994238, -0.18017722068489084, -0.33353747041666704, -0.41252551410743, -0.15320261732117987, -0.3840876829885203, -0.23136588050209012, 0.024459983352707555, -0.5692211462729179, -0.5114022060434065, -0.37516142814280407, -0.029661091524255813, 0.05258305183493201},
    {-0.20759826965478306, 0.4036910791741033, 0.09057297867207612, -0.7124079114786291, 0.16080889421251782, 0.33623856970380755, 0.16492157482806985, 0.18005211225075765, -0.18483880289132307, -0.330375536048565, 0.31683226257557606, -0.71708662099272, -0.610235130795152, 0.24253169468271002, 0.38011324429450166, 0.6219601237249222},
    {0.919395036038679, 0.40403011574459124, 0.19239887607835648, 0.346028660548416, 0.6130821430394273, 1.0658388048394718, 0.0971595695532883, 0.5901478992940977, 0.12820374916343738, 0.5191881099614946, 0.7889934269493473, 0.36850246268325465, 0.39815726026920567, 0.3893039643157389, 0.26507930608655955, 0.2661785735503787},
    {0.10789823644871532, 0.06515043411641887, -0.2873572545301762, 0.4362828461515829, 0.6455789465635158, 0.022177374100030036, 0.4228516280868266, 0.22245802059127243, 0.16357971944262137, 0.22826476279725386, 0.14471379816096328, 0.4668873513929478, 0.3071776502678667, 0.38030596734301914, 0.2834350815241926, -0.37822385779594797},
    {0.20106002284801378, -0.5514263702053205, 0.47114569242167836, 0.3768512085122905, -0.008436757938874257, -0.06896510232801613, -0.13277871206998867, 0.16481576247680124, 0.2142267619220709, 0.20254008660826137, -0.45554769276977214, 0.025398667673177996, 0.07693491165014255, 0.11002915305327379, -0.42303091105393253, 0.0393507646318358},
    {0.18017469359142346, 0.6934943034455114, 0.27709388144336844, -0.1971302238689973, 0.46787256214782985, -0.0756648927825815, 0.2684193004439217, 0.37310894574389103, 0.18885399687555623, -0.23264779105956349, 0.06824451073253071, 0.009343362604588495, 0.00804727604359311, 0.13569030065969478, 0.11980507818166036, 0.24755132962192175},
    {-0.1927984847151903, 0.6548569493416138, -0.024561549281827518, -0.2687290886426911, 0.5241799580889547, 0.5021981302724055, 0.41446432102668057, 0.40078917773550327, 0.006340724385259188, -0.24227167023606, 0.40675123313291683, 0.14068714162486662, -0.06022153947526291, 0.30098258833661534, 0.14052699650586323, 0.4602765976047508},
    {-0.8310138921578987, 0.464655349528168, -0.3207900523250881, -0.4780755011749258, 0.21372602523452988, 0.46320240366009097, 0.4864067347431421, 0.2538661025539785, -0.15419390692820387, -0.08922148782009512, 0.44469490026814296, -0.12044635914293027, -0.5371609415531494, 0.0967934588883669, 0.2604963496195012, 0.4160385531865118},
    {-0.3874937054167563, 0.08929458874928907, -0.10697900867848048, -0.14739438539365063, 0.08951851932924634, 0.457240622543638, -0.052994085205167456, -0.05040760489730108, 0.2543843020623592, 0.051135843705159, 0.46556013179540856, -0.2569900570565505, 0.4125815134784766, -0.2385076726859688, -0.036392829092140554, 0.26881862451815935},
    {-0.5938541439572693, -0.6000215998569131, -0.6050010455273734, -0.5078438751422839, -0.6289422741683847, -0.02609834526426408, -1.055670187348364, -0.4310943329747774, 0.02183594603860353, -0.10187198885700047, -0.5312625533959487, -0.8196431739174507, -0.29455533517709476, -0.7417640119346949, -0.2676743496259572, -0.19702189786407595},
    {-0.18645563151317582, -0.12301154341633296, -0.0050940000602994456, -0.3157076407793141, -0.2276798383026504, -0.627427671102213, 0.009299564873584602, -0.24411664915665948, -0.289728277653063, -0.03031903611582576, -0.37681063360731626, 0.1481389031976211, -0.43912223365466985, -0.20372356232385963, -0.09268934682591344, -0.40149734031363205},
    {-0.0010619877925792732, -0.16368428425110912, -0.17670527511736106, -0.1908482340498328, -0.8058831385545967, -0.9183226225212902, -0.39418432586804114, -0.3416384739732999, -0.45827632707796845, -0.41385840589314793, -0.31061553719410195, -0.1431082864290784, -0.27007470045178794, -0.6052656133024685, 0.114902498291076, -0.37760071413526936},
    {0.7344622608112233, -0.06138802651513965, -0.14053533976413507, 0.16358452102898027, 0.5106660638676603, -0.16109937843357292, -0.12479002438911127, 0.09003873687971131, -0.15396967310661688, 0.2644125105548665, -0.5278775557381258, 0.3420360691820701, 0.4069588864096224, 0.16460775815833206, -0.6558518269692559, -0.3890961943789183},
    {0.33918012628002536, 0.3752530583050634, -1.4510807104847456, 0.07561655163087198, 0.335069537083161, 1.3032327422099583, 0.11360597792927887, 0.568914707278354, -1.3321007502827307, 0.9568363902931724, 0.5937667442220058, -1.7643583202300885, -0.9826553530889134, 0.433456666529183, -0.8141561184241233, 0.7216702941014128},
    {-0.3096306499124326, 0.698466142836794, -1.2735695685808246, -0.19793698494777198, 0.44789299865938537, 1.1263118149357392, 0.7301004298730004, 1.2677773404549677, -1.1877586676262737, 1.1265152225020945, 0.7039379110814591, -1.6131482174328153, -0.1984395603041212, 0.9245395153086525, 0.08219758791735808, 1.1426769270140096},
    {0.11171525619556465, -0.0170128789400261, -0.5598555981593576, -0.6051734076743437, 0.07126923287469211, 0.6406446330067052, -0.5906979635659191, 0.18509672670452396, -0.337254310212736, 0.05584026269033055, 0.5929665475190786, -0.46901934165931936, -0.12697171553568506, -0.1943368269697543, 0.1267005143224072, 0.25367138105404624},
    {0.06166442061695995, -0.16169867017626358, -0.669525983708426, -0.24841107443905344, -0.13305030758027936, 0.990178833735723, -0.49822416750704224, -0.011527449440817605, -0.6559320074612327, 0.1941951115807481, 0.48138663401811776, -0.06438204646732766, -0.2160578464751391, -0.044314084603713444, 0.3392524039399582, 0.14281004381113183},
    {0.019479968377289728, 0.8966031433935947, -0.4030960153510027, -0.6663531065450091, 0.47538866475639163, 1.0780441669159704, 0.3593874663373378, 0.46063785212423036, -0.566078892330103, -0.005516712294509446, 1.1500630287243119, -0.6263817309481113, -0.2875125977202412, -0.0969882848144866, 0.8786639927699084, 0.4669870572915936},
    {-0.07929703058566517, 1.3340103082782975, -0.20331071627083291, -0.06301304759382585, 0.7641307332624707, 1.2487659407403349, 0.5729667101330133, 0.632903302146809, 0.018078737539316977, -0.11545671008993169, 1.1077294410413765, 0.1481099574831581, -0.1317338806520046, 0.7072507138883642, 0.47598455897542324, 0.807066596238958},
    {0.10976593459875422, 0.7950271729932573, -0.16059584408767, 0.31081691865440414, 1.0713918896119097, 0.8677628137158226, 0.7398716618902389, 0.5094646547359531, -0.26276257527396, 0.43341821385529106, 1.0180800864241533, 0.04543854093458769, 0.3396336767318759, 0.40787471151708926, 0.32210033863169746, 0.18966345525299041},
    {-0.5249131284998229, -0.7572133073299466, -0.05154706340429934, -0.26424866859178475, -0.38388900815733906, -0.4261414068706376, -0.694302753546874, -0.4913443473398417, -0.6517296896060936, 0.13162258598226675, -0.6183139659717124, -0.12782585456035683, -0.6007324799347116, -0.6998448438215934, -0.2364528260912932, -0.8064164521448716},
    {1.331654136214154, -0.0990213690551059, -0.28810505596435876, 0.4129292297977387, 0.4318028504870853, 0.2310946592485163, 0.32457211207126296, 0.44624081388669723, -0.4418327709238612, 0.9536928214826551, -0.6621875149871927, 0.40904322618738537, 0.17732128940051012, 0.7292037837274298, -0.5541691365910703, -0.6342325940998661},
    {0.45833858454142584, -0.36203270699080614, 0.13556579868969718, 0.46718168334370386, 0.09023219676067522, 0.2631003899658018, 0.264204844978934, 0.46794516569060074, -0.148347935464866, 0.7456008520241842, -0.35565591802488733, 0.758548704354507, 0.6999628458578432, 0.26429873544781174, -0.1339113252232306, -0.2678055128218197},
    {-0.6641511057648352, -0.09014859693194197, -0.09668591919848216, -0.4465277188200752, -1.1003236554057738, -0.15421886550980124, -0.6950613412927267, -0.3891896429791598, -0.3449058463329479, -0.5514805451063423, 0.33050198851402207, -0.8971986242271054, -0.829477604952486, -0.5020138735863307, 0.02990409206988395, 0.4466554280422263},
    {0.6232423064545881, 0.22885730777955476, 0.026981825997993026, 0.1154869122068533, 0.6777989439930827, 0.7949433315445461, 0.2452644076434511, 0.8074009001433136, 0.43449362980844525, 0.41292722454786923, 0.5285771809614017, 0.2843104323654865, 0.0562824560093318, 0.6423596327149265, 0.23816766419829383, 0.6646238058740255},
    {-0.03485475071432644, -0.4658597191003233, -0.15372516986891446, -0.20236429357307953, -0.15910858702025835, 0.33170174357519583, -0.3467132219282647, -0.49409056923048755, -0.6407636050101753, 0.21212668355528475, -0.4309471454506105, -0.019579316919812476, 0.33369047773487986, -0.1249975758291693, -0.22153979929668738, -0.35709848174471986},
    {-0.6523054926230548, 0.6431822462416821, 0.22313813935036217, -0.2285109498266231, 0.13417777946578932, -0.6370386806031448, 0.5495368406452739, 0.2525692076264804, -0.5120084133078068, -0.3912217308860126, 0.4442814969263581, -0.34440902308059085, -0.18653312987637005, 0.45152577064126254, 0.032563961974836936, 0.4014641210076313},
    {0.134575622772801, 0.26455961110613424, -0.08032183024785534, -0.3948865167503936, 0.31319587898094964, -0.2647002405060035, -0.02759119814620649, -0.2923968747185075, -0.16676694148341034, -0.42610421803897436, -0.4159680515445484, 0.0037311083137585837, 0.0031488184358739795, -0.10877542774747798, -0.05569087681227965, 0.16051414253467655},
    {0.46129144209661366, -0.3529087454139265, 0.0825148228598679, 0.6533341773728703, -0.15245511398892142, -0.12542752524548043, -0.10181896235858356, 0.17975449709798375, -0.4779593665328285, 0.4272200228148384, -0.9111740947332041, 0.6239985370008388, 0.41527178163461476, 0.5119504866587052, -0.2672980257690945, -0.28041281081172614},
    {-0.36238522150833363, 0.7255750794963419, -0.4522679940659384, -0.33502961419861316, -0.4702617892203848, -0.6385478011399429, -0.010674532966144602, -0.22831198721150206, -0.7838981145887407, -0.6552550490695691, 0.5769026572167445, -0.8386869383399719, -0.6932677089461723, -0.6610897301103054, 0.20122782597951966, 0.5509832889491385},
    {0.4252155730413797, 0.2408842735480254, -0.511199452192794, -0.08437795073080812, 0.3191289547092273, 0.399499279955445, 0.22915475049223522, 0.1927728877690751, -0.33728383707699966, 0.32715215351353183, -0.16687742402350222, 0.10783322292766377, 0.06041742420663554, 0.5624227532878245, -0.08056984967612589, 0.13764845334411474},
    {0.49782269425057923, 0.41696108028500173, -0.051588058823074316, 0.3133926115907934, 0.2929694129306375, 0.5243208360239338, -0.013649003548187032, 0.48901335844504273, -0.0933937645628712, 0.4922518736865822, 0.10957989099206332, 0.19166981072936484, 0.18710317197464107, 0.49067362891505534, 0.07566572887332844, 0.6070626839168983},
    {-0.9551752563146118, 0.17254145699227866, -0.2794309410353922, -0.6502037217069764, -0.25240196162612333, 0.13394266236814362, 0.1358542315326842, -0.16928178500561908, -0.7665309963655087, -0.4811209635615197, 0.1514503025356097, -0.6320632370429573, -0.695270416897823, -0.5274795026568779, -0.2148875149409513, -0.38395856221857083},
    {0.6041596473425943, 0.12337993271482582, -0.2566382520720135, 0.010253258443953714, -0.23697676204665555, -0.10387110393887529, -0.2663836560779218, 0.1616965916553923, -0.1840240290879253, -0.12924212470588353, -0.03908511595843581, -0.060636011733976654, 0.04442977038717628, 0.7498008353564316, 0.07200891825645102, 0.7163265474215675},
    {0.050171771839037566, 0.5245618811632546, 0.18724501652710762, 0.08525737046859921, 0.230898110484385, 0.07770770053818374, 0.20293245633744594, -0.19875958579328726, -0.008434031576188925, 0.14374299488527167, 0.013609119284833632, 0.15701291640799456, 0.4183980264099322, 0.6096595036440114, -0.02025841533705734, 0.5204982305254494},
    {0.09487699733922297, -0.0027922447741567636, 0.03761730806328481, 0.3502299052817166, 0.48202966634054945, 0.663476557714635, 0.10648029928012105, 0.627599680318325, -0.2313634832063624, 0.03718684117392822, 0.43833638965136573, 0.1917198812972517, 0.4269329468304734, 0.3831476799411084, 0.1431997914298643, 0.22049653800844485},
    {0.8560617802139042, 0.40450824106409006, 0.387025837265106, 0.21497683256694244, 0.6268192285699338, 0.3148417580834043, 0.09687700147084996, 0.5070510592286123, 0.5941339547745295, 0.4755236906535642, 0.01124789277926008, 0.6536511502170292, 0.6152930870254654, 0.55339025866534, 0.095833358893583, 0.49290562822149553},
    {-0.917725238864826, 1.0330348768924893, -0.2082151424881979, -0.6647940780296979, 0.13848633839650046, -0.2708257700847948, 0.40709199322362083, 0.11425082348482193, -0.5735901449779973, -0.5049444622843623, 0.7508497538213639, -0.5444222464356052, -0.698557554664498, -0.5255503482873366, 0.17501398525645562, 0.35260821416814875},
    {-0.138908974265253, 0.5847495958278333, -0.20685994271630792, 0.037093605853161266, 0.7408853081376336, 0.6011352850695468, 0.33130522087848224, 0.433831595286766, -0.03674063937334831, 0.07100830136453162, 0.4511338744111659, 0.10442700585341354, 0.2655407065075371, 0.454235410427002, 0.15002483116823245, 0.23444002789852497},
    {-0.6026467447059142, 0.5637747449786638, -0.09179059148718823, -0.36630412562060327, 0.3839904273192453, 0.5657340129250187, 0.20084494536780795, 0.17086084528744133, -0.20116555067506595, -0.0919249588814647, 0.21838812734527174, -0.44699437136412007, -0.29659306182882705, 0.0312958504646995, -0.15909064518231475, 0.5789026224497537},
    {0.12419852012054788, -0.008167664167821123, -0.03397129413877528, -0.08114516716555273, -0.26274858724976363, -0.6102910683572537, 0.0873960879415374, -0.11993970948933819, -0.41017944994592115, -0.5775077423869535, -0.01119584494287894, 0.18103993320779913, -0.31079723135552567, -0.027229870325183324, -0.1359823498909896, -0.20792627210857295},
    {-0.6692659990894206, -0.40431218299217064, -0.168289601806459, -0.09798017111965504, -0.4779177306321921, -0.5138597093517038, -0.25394158512035947, -0.29097253328438166, -0.5235784001364816, -0.4596837057581879, 0.08568674499109641, -0.6347554395657643, -0.3683421115001904, -0.14969814358501676, -0.03226043537769664, 0.21434562876487495},
    {-0.06056564189781786, 0.39560577101153943, 0.04164010025891279, 0.03874515909718781, 0.1611646280255957, 0.13768903646476588, 0.3373324806322832, 0.5673152980603944, -0.39075017632033154, -0.09071459163092903, 0.10956321094130529, -0.3613118292969741, -0.2551300208290742, 0.04629229162872697, 0.24127346493169766, 0.11319455128130929}
};

static const float b1[16] = {1.827061606824974, 1.477128424431015, 1.4691662906018579, 1.8065514665100062, 2.2209003195110584, 2.2409053118605002, 2.0974494780171735, 2.4780018299836906, 1.228900831469973, 2.1494515239851393, 2.1038915522811554, 1.8806375678065308, 1.8397851999402337, 2.230294302416878, 2.0041184940490036, 2.1328308884216636};

static const float w2[16][12] = {
    {-1.4321028726762774, -2.122242900731027, -1.250250145440905, -1.6487607635464518, -0.7418236326804067, -1.02471722634892, -0.6558675120976281, -0.8581961437835154, -1.6130476936116016, -0.4271132524889194, -1.1613613214060774, -1.0785786214375352},
    {-0.6535473963086067, -0.2533338871756466, -1.5028979297952276, -1.1452978186638318, -1.7257264449357437, -1.2644559098452668, -1.485817666620984, -1.604548529859377, -1.7008587690457289, -1.6197770107057086, -0.9032960746477632, -1.7111231022722146},
    {-1.026173535080046, -0.5864387941611288, -0.2527081771269011, -1.4236007436255131, -0.5779452149316305, -1.0794188029968228, -0.30375054440538324, -1.4692923578775228, -1.5253569832433251, -1.3646793583855497, -2.107377131273341, -0.7207011729120674},
    {-0.5344604328189763, -0.3804471726862713, -1.3485620283891748, -2.1124239648894605, -0.9758060375100107, -0.4674692295092999, -1.4763352618680483, -1.579838018240461, -0.8735491445630204, -0.0043468583983054575, -1.2600680530732542, -1.3672403231105918},
    {-1.3363148435882966, -1.6648448866272005, -0.6010425057259918, -2.2848453210773974, -1.4184720503320685, -1.6668507100429002, -1.8194056432109729, -1.7081758663318285, -1.055696095164516, -0.39187677907266794, -2.0575456921426056, -1.622272963743261},
    {-1.8110243098369971, -1.113117603028146, -1.645261177972794, -1.3461654718614706, -0.56373609272202, -1.0848665543441656, -1.6239862836854073, -1.1991348328218465, -2.0161363636778717, -1.492517677922179, -0.5979247444232128, -1.1259706085525654},
    {-1.6016934549918018, -1.795925705137234, -1.3907776910491836, -1.3029514248118272, -0.47593085758354653, -0.31447440254639675, -1.1526092064883156, -0.5238317673956905, -1.998672909437121, -1.046872799065373, -1.590027490440867, -1.238918998331805},
    {-0.5382596662534339, -1.164169052120117, -1.8066355442767772, -0.7232496413710903, -0.6310794090198499, -1.6347470499990122, -2.4533787653862347, -1.5663811339993068, -0.42645140526630515, -2.39193038273999, -1.1213167262347967, -1.767860190469833},
    {-0.5393675759049914, -1.4373070333607278, -1.5761202498316984, -0.7375143110689014, -0.695986063084711, -1.1729334192285494, -0.9006741952710787, -1.036994342596154, -0.9021385296886053, -0.38240976721328035, -1.1403128862849874, -1.333804851415321},
    {-1.1648947593266095, -0.2758133693630145, -0.7532068366031447, -1.1360389847510821, -2.3193960937410503, -0.5351296350055564, -0.5472844122569382, -1.4997679433867515, -1.0789403926095753, -2.0148772733678686, -1.6266226249738207, -1.9297695440965006},
    {-1.6289726152754582, -1.6851485811639058, -1.188081568802455, -1.297616281386809, -1.5736976810770524, -1.601469402096586, -0.3414703867834874, -0.5151823671654993, -1.0737592266416833, -0.6158083837478666, -2.0025990621580143, -1.3909114759160457},
    {-1.2995824060092527, -1.0923015146473878, -0.6596315864739669, -0.34099201380353206, -0.6922134328652642, -1.961011014064114, -0.19304547417223206, -1.8331902804221925, -1.317514925742507, -1.5771228587463946, -0.6697744493726966, -0.5111809407125512},
    {-0.920286246422642, -1.2786559312887622, -1.1686298864071174, -0.1553611885851124, -1.3361402044638713, -0.9379682706056836, -2.4964895776648497, 0.42142357828958227, -1.114451036235412, -1.6791055961842, -0.669388058225978, -1.4786262166210564},
    {-1.3947539721786744, -0.7442836852625255, -1.7692382293669764, -1.1674818547119565, -2.3773274811279754, -1.193760504550943, -1.3426989989393152, -1.422743828171505, -0.6550440716330276, -1.142428907501044, -1.2454969224813175, -0.2293921680589708},
    {-0.2576221643453384, -1.9644005307369279, -1.4972347885378932, -0.7057530230923574, -0.8331887770574717, -0.7260148436885673, -1.0992517329755247, -1.6537159432374073, -1.13938822672697, -2.108762345470451, -2.1770905681112738, 0.11990095396020571},
    {-2.0008906064474554, -1.1193444780942559, -0.39520784661526576, -1.0291614513677942, -1.5080329035639706, -1.3346864590715162, -1.442645770395535, -1.3028495772557442, -1.0247435468278292, -1.3507610315689158, 0.25599138069044897, -1.3836574605016574}
};

static const float b2[12] = {-1.3167950467261782, -0.8022954392930987, -0.7552935963886006, -0.8736014035307654, -0.5641778867500241, -0.7155131895722981, -1.0114421709807997, -0.7054767255753117, -0.6635880884314276, -0.42295353390304, -0.1733938751518767, -0.5962013484595555};

    // Input Layer 
    float z1[16];
    for (int i = 0; i < 16; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Output Layer
    float z2[12];
    for (int k = 0; k < 12; k++)
    {
        z2[k] = b2[k];
        for (int j = 0; j < 16; j++)
        {
            z2[k] += z1[j] * w2[j][k];
        }
    }
    softmax(z2, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
