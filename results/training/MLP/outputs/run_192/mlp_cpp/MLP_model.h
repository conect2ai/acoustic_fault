#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][16] = {
    {-2.5818483610679586, 3.9180921104579096, 0.10393559334239223, -0.5973095342278723, 5.225644490258126, -1.7000337671529226, 4.356227975072882, 0.8263425374342986, -0.2655134414918136, -1.186166644193679, 1.1219733178863733, -0.564626595994665, -1.9620843496069797, 3.80277906176731, 0.41634735241303794, -1.445062964696808},
    {-3.853794950483381, 3.830246024016849, -4.247575170144021, -4.267746961901544, 4.802529212139428, -4.291649843697398, 4.166504036619552, -3.316516031598509, -2.3084325511936354, -2.999819249457348, -2.5032838291747974, -3.200398887797679, -5.064503306044619, 2.5124000541026, -3.70918216184491, -4.249356888200293},
    {-5.634048584416602, 2.6199634641104717, -5.027947884662516, -5.511958621261926, 4.354196097054207, -5.6404264281933525, 4.275179949688299, -5.27487413146363, -4.854616596283011, -4.553722827739554, -4.363325355973548, -4.529829358620646, -6.242240067394317, 2.9946168276918805, -4.404424430156928, -5.920651736702832},
    {-5.909879231529244, 4.319231448466916, -4.674959201537672, -4.956028421637963, 5.070033601987594, -5.3588953897564, 5.177828815900747, -4.371920606963167, -1.9081853377403137, -4.4274942643428705, -3.785293509094571, -4.617493490621954, -5.96887366599374, 4.678556813334654, -3.4812872805360615, -5.787417671839111},
    {-6.348862307818023, 3.648929409262639, -5.007283152467255, -6.089510142036878, 4.0782307019271276, -5.976309005998145, 4.533482634947369, -4.914818287858082, -3.3460003113471655, -4.298378422562267, -4.59731033898209, -4.7208745710007864, -6.229468259313749, 3.747580704893983, -4.559589932479644, -6.111124222922662},
    {-5.907079987466945, 2.7564859639573336, -4.50859833713696, -6.327947380349843, 3.2428285135622374, -6.131457190756278, 3.6337308490785336, -4.478478734141221, -4.083437431976287, -3.6458018158234853, -4.8577931097527, -4.271761391247883, -6.564704790595638, 2.5349976841846003, -4.531816912607479, -6.020305593286234},
    {-5.115777751717173, 3.0524178160380124, -4.391191290872456, -6.251793919583453, 3.689472872423035, -5.461714856255756, 3.535096013570214, -3.8677717270247354, -3.2116540875282973, -3.5745739559050063, -4.305875254748391, -3.8958000559582455, -5.933752371372329, 2.6358843989103646, -4.603266717943722, -5.532357676601515},
    {-5.616880635812755, 3.784003392571674, -4.413656489802459, -5.299934739040878, 4.5687822509416725, -4.87275783892843, 4.610761458603709, -3.89924706561812, -1.1810857783045747, -3.874063289225571, -4.135674811029249, -4.28951964548016, -5.600714442342019, 3.906028870561717, -4.115015951054765, -5.2644833154911845},
    {-6.21964924541848, 3.3775349384893305, -4.668428808201723, -4.822347374692208, 4.869075222726101, -5.228564145281154, 4.738845094184985, -4.328397435529864, -1.1213340574752786, -3.986136280123639, -3.9049020383507362, -4.474786612096505, -5.879128042304253, 4.301964765360908, -3.8559683679488606, -5.685854096205647},
    {-6.062872228693567, 3.9090011510114193, -4.844633871918178, -5.468978033809127, 4.89178952307916, -5.5001876372514715, 4.974740236322242, -4.00885805881166, -1.9640674265010276, -3.9458009742342623, -3.625280984052872, -4.470714083756431, -6.179023942070035, 4.403386832546885, -4.410555016183462, -5.6190861808460335},
    {-5.525871521441325, 4.327150842538866, -4.812437284668021, -5.026619562720588, 4.6286060316187925, -5.287874782712766, 4.850195065845607, -3.5764241836463717, -1.5389847125140295, -3.2834656926726837, -3.0947455467223524, -3.7075047746492586, -5.981168754851234, 3.589322352518955, -4.202239595552771, -5.428262301886103},
    {-5.750693545278989, 4.137123416820974, -4.893846025486646, -4.468832327877282, 4.8026627621936395, -5.154740586385015, 5.054860247125839, -4.651579906566773, 0.16386088887464773, -3.882964770678449, -3.9112543268620614, -4.550706952790158, -5.291756373532616, 4.316883572479513, -4.29492049411661, -4.861957923165855},
    {-6.123856045403517, 3.4721985532370097, -5.4391100749716985, -5.0217314378798195, 4.33407707174525, -6.1233501488363125, 4.7781703755198865, -5.606915866931913, -1.4104875806180415, -4.940263626099292, -4.700924908610845, -5.298834984249486, -6.054046198462789, 4.019925703942896, -5.062157216154353, -5.758725221497308},
    {-6.495051000123439, 3.237936632591888, -5.563584324902624, -5.640843000957696, 4.1659283958464774, -5.848620728557544, 4.420634163557929, -5.605020787746912, -2.3879431552932546, -5.111452353563492, -4.903339673337363, -5.43117582818836, -6.140241547040098, 3.764426764878054, -5.473045228591908, -5.911145523985912},
    {-6.185769144498831, 3.0864574848196806, -4.763197688508354, -5.4951788255621565, 4.671830267374584, -5.806977202530884, 4.991967193628481, -5.107700026560336, -1.8767479413371928, -4.255440412305251, -4.699910912537041, -4.789661605351592, -6.014452112122743, 3.908766420400315, -4.978951379128688, -5.531141265374126},
    {-6.149023403976882, 3.144140067137414, -5.4824895608425654, -5.908152818264302, 4.428207255198766, -6.145196365576412, 4.775160821317732, -5.467204662752451, -2.7838220145350903, -5.193712332617222, -5.0184942311892415, -5.505973607986403, -6.459677764607999, 3.7954625798116983, -5.120509899155378, -5.8777742311095205},
    {-6.317944715972715, 2.920694261755422, -5.3697679661058215, -5.77669113853187, 4.626937152819087, -5.940461183645351, 4.926396216406811, -5.574621140302358, -2.8205314978126923, -5.103310750564604, -4.829393175968927, -5.518010678217426, -6.339104553223523, 3.902965405220234, -5.021328751456353, -6.020969572815108},
    {-6.100738335367885, 2.991176470096002, -5.035494497462243, -5.235626485629053, 4.675518657237456, -5.880461422106085, 5.178663717188276, -5.472519196168292, -3.229553599857936, -4.553808896890635, -4.8121035035440505, -5.282289085412082, -5.982279607544287, 4.358693792252056, -4.922046478799629, -5.593012265665265},
    {-5.886641111587042, 3.1558276715075846, -4.526069461172935, -4.9826958978068525, 4.59880902362294, -5.664128361665131, 4.895717974085436, -5.559599885856632, -2.712129352599988, -4.678108334860432, -4.746934695291245, -4.917836731593477, -5.759178267769325, 4.647803414885711, -4.493217654048909, -5.493805957133968},
    {-6.434691944024252, 3.9194326763427507, -4.921525992334099, -5.011862589283975, 5.269090519117732, -5.55289366810023, 5.230898528161329, -4.9643490085903546, -1.293597148446395, -4.38102004703303, -4.270485662838805, -5.162393760775567, -5.897336962069083, 4.849750485626047, -4.72889723722558, -4.942388944662204},
    {-6.306852621506215, 4.099060850951854, -5.836406918724341, -4.695167091130236, 4.889021533306361, -5.970264485239199, 5.243163065380956, -5.239792720930472, -0.8875492462068449, -4.815003658566495, -4.9188989074125145, -5.584991735676187, -5.973390264515757, 4.867679238939367, -5.288315777011713, -5.169925661859191},
    {-5.826341864803301, 3.8761160792694698, -4.876593997211318, -4.212429877074291, 5.046063119309064, -5.403578514687117, 5.4613290644295995, -4.876675877595506, -1.2281295802700753, -4.481509991370069, -3.91741200111918, -4.560217468402732, -5.556559209278041, 5.015863227223038, -4.367583551941149, -5.045088977745356},
    {-5.405408110770224, 3.9480202077533804, -3.9103407797059986, -3.870195238005318, 5.5640491441491005, -4.999925594175385, 5.575926840467676, -4.612530066148083, -1.7960196900855312, -4.0657065160539885, -3.4993124694647713, -4.379037419987064, -5.241076964501783, 5.029350053953151, -3.3736964773547453, -4.806486969445406},
    {-5.630345377966295, 3.839210171168197, -4.550617865298757, -4.3670533286877955, 5.193741757269895, -5.317365864816909, 5.338700426398326, -4.931594395649176, -1.3715106231954044, -4.619079102411546, -4.0686248623075265, -4.636702944416485, -5.254660467909758, 4.818074072308452, -4.27684038956332, -4.959086415399512},
    {-5.908091763131188, 3.773572736671244, -4.808889619232619, -4.608312122957856, 4.871976940119077, -5.564685429785723, 5.2496794185758295, -5.068816126502739, -1.5043193482166766, -4.288809867530575, -4.01604882344533, -5.140387744988072, -5.619048262542606, 4.164592266070642, -4.269462847292594, -5.350947474756026},
    {-5.8140061531721425, 3.9274334285803536, -4.993465513577346, -4.665503441700014, 5.014417872297902, -5.482468493036211, 5.4752598334804095, -5.028689989503284, -1.82990813121392, -4.475679874080306, -4.345360879598815, -5.098810108698605, -5.620021799643207, 4.937255641354497, -4.558043597520611, -5.321266680031079},
    {-5.632684420674086, 4.004157319988123, -5.1322822401108095, -5.010429719262737, 5.032438431232557, -5.830549293971508, 5.165925873842049, -5.148282794915631, -2.85577360301312, -4.317733271847015, -4.379397609609563, -5.057628587264605, -5.943927146964014, 4.147561196458087, -4.331784211347962, -5.609116987888207},
    {-6.01620657998738, 3.700491099466076, -5.267957962231484, -5.434671890431625, 4.785976248062265, -6.148072612144939, 4.721622083326795, -5.1514927088774, -2.916050437406494, -4.651385301914192, -4.601497103117774, -5.2036379558810335, -6.301345818430931, 4.2699573053927695, -4.396315485928777, -5.654212346447266},
    {-5.963870008740015, 3.6133672545435065, -5.196189223017229, -5.282809437997245, 4.755847352616885, -5.972009223672411, 4.78195377934014, -5.349708999537172, -2.9559383327776874, -4.592967981312308, -4.646881016231347, -5.306698068147168, -5.955365859996671, 3.9244601176700584, -4.973112249579347, -5.627996401894822},
    {-6.229455860480806, 3.4847343935808017, -5.900257073192751, -4.835199428194079, 4.3985187753937, -6.071689264465405, 4.656274417445455, -5.339485669259246, -2.298988659289826, -4.91675161002361, -4.906150715370193, -6.075364773022656, -5.8388137850148105, 4.070221025352322, -5.179079879786074, -5.39130325500572},
    {-0.483103547097682, 0.07728909809494332, -2.7503349467168805, -1.3684407328688393, -0.457792856275679, -1.8933494633677252, -0.7864854938281538, -2.468632179861768, -0.9707942662302906, -1.2208681098508583, -1.6340423955915206, -2.912511492546736, -0.991241815715147, -0.37792416058032147, -1.841277732790277, -0.9704134223462542},
    {-3.4131111111171286, 0.390209750741054, -0.5414837462009618, -3.5683689724493495, 1.9096297571926961, -3.9543265829660355, 0.9149422922240593, -0.07987304179858185, -3.0979442975368876, 0.2735991300024508, 0.7147184829986666, 0.6350448942620225, -3.6062001705634317, -1.2399030605508745, 0.31184651083949844, -3.4949765872947998},
    {-1.4687310986702011, -1.789224437274987, -0.70462386156245, -1.0031952352903062, -1.2081503504603073, -1.4964150243322176, -0.3189223682322246, -1.6493276737789877, -2.177527979689105, -1.279305887501712, -1.7792468601845273, -1.4188956272449111, -0.5733416006737608, 0.523554219999273, -1.0712762746435922, -1.3168608977070375},
    {-1.1584851193252304, -0.8610922456168769, -1.579563352973526, 0.3452439119439826, -0.3803004433969909, -1.1111514148167312, -0.052680428335780814, -0.8289542837505299, -0.9489156803202097, -1.6109849483728644, -1.4791224293693428, -1.9354777705333661, 0.46773660356023966, 0.3506561216057462, -1.4790452848964304, -0.3734299306225242},
    {-3.894715229951237, -0.9962570256070079, -4.2343827358519, -3.47950166077907, -0.8311577272006772, -3.906059516866568, -0.2223860991438655, -3.8358660431074165, -4.058581324557202, -3.3588736929198095, -3.3503404650110333, -3.655621974204885, -3.7730462014165487, -0.5427278309273765, -3.389031724041541, -3.9410072763568067},
    {-3.4672670764782993, -0.8532280397777692, -3.001790216701546, -3.208235380382523, 0.5222248071006315, -3.364642090196721, 0.35923097868502885, -2.86377797396072, -2.972600201832152, -2.8564167675537586, -2.8509800730179053, -3.0885854721385115, -2.9505874462568284, 0.11967916738581663, -2.3724520044696713, -3.2329159324755135},
    {-3.441452070405121, -0.460965091680755, -3.9671376619682417, -3.655709052796749, 0.44510663538153267, -3.8703065491793933, 0.33644335983530566, -3.4513539829350472, -3.2576791135801018, -3.1382730535691103, -3.37403365704664, -3.454818377617366, -3.4792855051905898, -0.5087655087145951, -3.354187970306594, -3.7477725241506064},
    {-3.0408234141316037, -1.2885914680690302, -2.8603573580248254, -1.8932321072538154, -0.000968365470964711, -2.2420376844172853, -0.11278232269248893, -3.211770349680856, -2.619447374233982, -3.496498506355326, -3.6266984628848973, -3.1970154386289704, -2.251482753809089, -0.375137536951059, -2.457227211468447, -2.4034946666501593},
    {-4.061157202658944, -1.41302353380633, -3.3251529729769547, -3.125614185120859, -0.420211757218785, -3.4545848398569494, -0.15370063290927444, -3.1405529347602488, -3.535507954370147, -3.012042113777434, -3.1062454380694624, -3.270114423027517, -3.4213916036545373, -0.8217298403146048, -2.8430699221693843, -3.6382525145100635},
    {-4.159948305963038, -0.39872116265622215, -3.899708504224255, -3.62919188087314, 1.0064057526670949, -4.134676675641758, 0.578274848351588, -3.8807927673489853, -3.237306191054271, -3.814554567182273, -3.806236673026373, -3.7796363635840518, -4.42471358436032, 0.8355908031893604, -3.5298649241274545, -3.841286163242802},
    {-3.131458244195741, -1.6805748842667607, -3.638723308223566, -3.219035349007571, -1.4935299512472884, -3.954032190092523, -1.486377519928339, -2.5956608641709256, -3.429438113035756, -2.6950090227031023, -2.9657146072078424, -2.594602111049288, -3.2989000812774782, -1.3699213897843536, -2.5996801395082327, -3.665407140772175},
    {-3.2577414038602392, -1.68298938333811, -2.958684837275472, -3.6519122324395243, -0.8682425218962568, -3.7845413340044423, -0.4111765473749725, -2.594450681455309, -3.2017787608731387, -2.571809207641228, -2.9531450034027036, -2.8740043091108007, -3.057183351157717, -0.6357846291627799, -2.5318131929739294, -3.4724450797605675},
    {-4.4320412093153525, -2.054600450872772, -4.460821803777126, -3.63696880965522, -1.4031522100191942, -4.090102728465957, -1.1429189288257906, -3.7870309175882975, -3.769015474307548, -3.62634730872306, -3.443997183382301, -3.877052230814423, -3.832272753626868, -0.9946192993646441, -3.449444758832548, -4.085720459155022},
    {-2.8714197503225907, -2.2998363342289583, -2.781836630008195, -3.1706952799749324, -1.2043776558296313, -3.726145982005135, -1.3706806697005294, -2.75436253810089, -3.2108093761453347, -2.6582003637316243, -2.9641744333433575, -2.858429018152339, -2.937204684389652, -0.9044207659838223, -2.6005637841206655, -3.470165192416021},
    {-3.9818841974315267, -2.3215225962481068, -3.3060109436883063, -4.245978495181433, -1.0091767938019125, -4.460042557345149, -1.8483897362833694, -3.5607372519076317, -3.840242703813235, -3.4291804074949996, -3.435444589910559, -3.5530442751381672, -4.0940721516055625, -0.8175066794591855, -3.0910942662464564, -4.656810347904043},
    {-3.4385179675859208, -3.2243515384647616, -2.639294302191278, -4.184484227291936, -2.2188033303092385, -4.283717975993655, -2.017185233885221, -3.2379877849280363, -4.361292379331896, -3.6125067612625594, -3.6831494104951554, -3.5468903598791024, -3.8580813583422446, -1.7288439853921163, -2.856632443250486, -4.283229244678636},
    {-2.6907577500988404, -2.1936858513668076, -2.238409109312203, -3.2336016971436923, -1.0167979217312442, -2.7716820554215325, -1.393912722835737, -3.2605174458649384, -3.4402814188967064, -3.8126291726110515, -3.317750247290538, -3.3936590437763723, -3.0719128015635997, -0.8380482061945042, -2.414948043927831, -3.356951069231653},
    {-3.77082617302986, -3.309910318074676, -3.0446949014669213, -4.139925056296987, -1.1691976279956673, -4.084235257787119, -2.0706785814162543, -4.148124150298028, -4.429611314855069, -3.8795536258191072, -3.9518687958232097, -3.7716740145564067, -3.7454155167822036, -1.1244333615527964, -3.2857144992444605, -4.185430608794287},
    {-3.068704965454579, -3.517859628768207, -2.8262589038763357, -4.26221378604303, -2.844100960795461, -4.221225180171327, -2.5174543812086747, -4.409211967430088, -4.794375269145952, -3.8772355943944934, -4.258460490206501, -3.8537664523563673, -3.588703260532675, -1.939692748656024, -2.9088175146134074, -4.559979718030894},
    {-3.3089316971234353, -2.6845549012635215, -3.5812973669044537, -4.367865562225341, -1.3365578637367652, -4.23192446636767, -1.971228844147913, -4.403253474566212, -3.997625681464211, -4.176232340685695, -4.47757555866724, -4.205412188389805, -3.4405003134117256, -1.3709555965491775, -3.6897472791973303, -4.116966951991533},
    {-4.002509411950676, -1.9649286831406743, -4.503771955954885, -4.4099433058752044, -1.8936518307742618, -4.585885191018502, -1.5248890462426807, -4.254931519648221, -4.210592787473949, -4.898501437644234, -4.929706125756358, -4.862697715264307, -4.269309153815181, -0.8496421484180046, -4.4263927559081395, -4.678523598294613},
    {-4.250484216845014, -1.4953558842511636, -3.431584736749356, -5.070185302861679, -0.9651113287776116, -5.314211802885178, -1.5957911983721527, -3.641660710784729, -4.825100378799122, -3.938555635370415, -4.364598360036725, -4.515819437708481, -4.4928888322967575, -0.7336993117950372, -3.5905442902967133, -5.530442141836182},
    {-1.9792910818014713, -2.1438264020940276, -1.0256204633814467, -4.25891606825334, -1.5488527634811526, -3.310610481332288, -2.088586190873304, -3.013193159863806, -4.374061077529831, -3.5963233611636576, -3.770572687316529, -3.2752894349282498, -2.797680914539012, -1.023486200778268, -1.9842413386845856, -4.001278051157704},
    {-2.6039353550938134, -1.5970325214065348, -2.8938577007700252, -3.4401103199251915, -0.5943318988997677, -2.6649791696758522, -1.2790012333492016, -4.167035054985283, -3.688214626306953, -4.2734698394561486, -4.855241804746645, -4.4538508590417765, -3.142179628061545, -0.07685564169518866, -3.2510880245717675, -3.321207504622702},
    {-3.571563513976842, -2.671887042220643, -2.9402678407229437, -4.266185708302137, -1.606308955742246, -4.155291454805075, -2.3444653581778456, -4.614451709401907, -4.110468047669083, -4.663640111367421, -4.750653548564916, -4.714125831544687, -3.8902904220167724, -1.308534841494367, -3.663521150954064, -4.245457525122828},
    {-1.7508530087662946, -2.8078029103507194, -1.5591975843658017, -4.16387775873291, -2.596827037817609, -3.772909660453895, -2.6795166680553653, -3.8599173383268304, -4.684979225046714, -3.8745766534419883, -4.189865368466078, -4.0316477403206274, -2.01199445549763, -0.9164230630842577, -2.1038273642555674, -4.40361303940847},
    {-2.0516837531289025, -2.7248462593946634, -2.50688462697223, -4.430143120102425, -1.6793803864536163, -4.397551801341816, -2.6522844111602146, -4.212135446769788, -4.637790472995086, -3.9595940412780597, -4.0743849983074005, -4.148635175868162, -3.595073809482364, -1.4457753878052806, -2.4021689115741216, -4.611916257696964},
    {-3.4174436690547747, -3.61605855440069, -3.6112791806369002, -5.191762768733557, -1.7849109683325686, -4.951479540923864, -2.6756076204072246, -4.866944232734158, -4.940784475396496, -4.736298239511803, -5.109706890454876, -4.988473588636588, -4.120161508895871, -1.6814058125013134, -3.381100817090154, -4.901934482798731},
    {-2.642761055507071, -3.768816382837565, -2.790843121132762, -4.740190078391522, -2.257522256634557, -4.623615660120631, -3.0563491273921186, -4.615308443450118, -5.064693554811096, -4.550488393207138, -5.074834553310235, -4.706137585603281, -3.950102491468831, -1.6673259570619714, -3.0670391309474874, -4.774499749119662},
    {-1.9029110361372554, -2.8772974605188812, -3.1080213704308357, -3.6421231948347947, -0.7485439517838653, -3.404265922736621, -2.6322762488590823, -4.114572740309191, -3.7429102369058347, -4.581593849912777, -4.7244850633047175, -5.134218501717019, -3.495854750784615, -0.3716674380107721, -2.661735912722578, -3.4414704589746035},
    {0.4137594392799567, -3.3960708111641007, 2.6615589554683714, -2.986025360161142, -2.5331326905225158, -2.560831898502406, -1.8973212579976217, 2.199922601674282, -3.387440299190439, 2.933519900417568, 2.9031135246538855, 2.13022540469285, -1.656326266114585, -3.6664782391073483, 2.1459697583215678, -2.725380728736968},
    {1.7541163610697066, -2.5003077189673433, 3.040549619073356, -2.028833032115521, -1.7118711665929813, -1.6218662033883968, -1.1675474364661804, 2.819614905355356, -2.965753456287576, 3.2798911705214855, 3.645881083303234, 2.919493516251328, -0.02147458650692552, -2.549052769685216, 2.6391784630750523, -2.0013406347660867},
    {2.2617898249904265, -4.20792496967766, 4.359658800280077, -2.7239719935778504, -3.3305757393587956, -1.920097507098864, -2.5076636181290644, 3.3671015152700443, -3.997706498194431, 4.246235772891299, 4.157891349971221, 3.592787384703152, -0.44522310407330906, -4.112886627519521, 3.5733724703483993, -2.614074999140831},
    {2.240695964719138, -3.369984631599527, 4.016530184084782, -2.0939977664625156, -2.0642800886026054, -1.1731271418309186, -1.008535835234617, 3.8220535969120055, -3.1098893300474124, 3.8896423671441465, 4.0511271512246845, 3.5005427598680283, 0.33921565428505246, -3.6014453980321264, 3.6141801335169896, -2.293876563534787},
    {2.882037917718152, -2.4572729846605563, 3.8251334745691556, -1.6292674797628282, -1.2273942009528602, -1.0335406752436398, -0.013999781727138004, 3.9836645968084565, -2.6500779388066116, 4.005239125020539, 3.9750240203051246, 3.670971548051536, 0.9056571938206851, -2.6564650377843013, 3.5065773458684424, -1.9813896535181494},
    {3.3738096719477584, -2.3738637276114334, 4.300018842001635, -1.6865520968320706, -1.4886830143422085, -0.5522108001308526, -0.7626558304251376, 3.933106896641276, -2.3817027432857616, 4.329827789410842, 4.373204975636629, 3.8760474655039485, 0.9643553851574728, -2.804276860170067, 3.9035474206709115, -1.747670640383253},
    {2.3058750267441144, -3.817401461051572, 3.84744317932519, -2.5530505546995417, -2.692754175665625, -1.7709738867225076, -1.5740281917752177, 3.468837299350977, -3.336517456941226, 4.212618004940952, 4.259895927552665, 3.560319913947531, -0.04057697022153788, -4.170456614118175, 3.4716196589774464, -2.3575580141872052},
    {2.2145947836801505, -4.05388519877642, 3.5095313914146478, -3.200266911755532, -2.7968992580494145, -2.85702389356213, -1.957098760734072, 3.692016541729146, -4.16122899445779, 4.155566589609564, 3.9088663925912486, 3.940630015565417, -0.5162255552929138, -4.00014044119943, 3.269578526158003, -3.106513609633379},
    {2.6474430090318384, -4.320386755280787, 4.424020118877128, -3.413063564667335, -3.016101360471866, -2.7117838511592867, -1.8218871438220179, 4.262394945135761, -4.256549759917897, 4.500821389627926, 4.855526233959249, 4.461123037242664, -0.5931984669808992, -4.076188998980134, 3.937941087720934, -3.5083996633719177},
    {2.3566268590713344, -4.110200915588836, 4.687479236398985, -3.3139520837544985, -3.2712885840801524, -2.773108715369384, -1.9649631250140933, 3.9123621175251535, -4.0164216659954235, 4.701688741732188, 4.515120869106864, 4.160155240500067, -1.2584365346833972, -4.097555324294137, 3.92167293169575, -3.348761207948861},
    {2.45284808474466, -3.609698926377666, 4.671950768997175, -2.3559113333763766, -2.6149233047164104, -2.0657860457569748, -1.527439171632707, 3.9187600696704283, -3.6874300781307277, 4.833802020744129, 4.625496503256608, 4.325154956124498, -0.6188657092890406, -4.085382910063797, 3.8783961454445217, -2.3267737377608695},
    {2.44483724637938, -3.783688897605601, 4.700162656152604, -2.9756670428384595, -2.6186666421119305, -2.4032438229220885, -1.5894073733506298, 4.1586294074265275, -3.926777722933188, 5.064040196402323, 5.055480872352616, 4.584095934118784, -0.26678314786111235, -3.9458207536239804, 4.141093300424226, -2.9321933115718064},
    {2.6194792700727767, -4.108883429524815, 4.639515922965713, -3.0622287038637537, -3.0250301318669512, -2.356421589888812, -1.8369739409410009, 4.344167926970482, -4.037865569428048, 4.986339642375851, 4.977199419809465, 4.500739383186212, -0.6920391426411748, -4.195844062644165, 4.210828973135557, -2.9803613046569732},
    {2.027870734665956, -4.12751697554566, 4.063872271843627, -2.9264394603214408, -3.1857112163306027, -2.2967658149918693, -2.1430409417227407, 3.61697586890363, -3.808270902634361, 3.9527438510712685, 4.2010697765438145, 3.686475826386469, -0.7065629495324366, -4.286481390708858, 3.4373858695547224, -3.229519893500669},
    {1.4263278671583928, -4.370010685100171, 3.81045200561835, -3.209237973573677, -3.447287821682949, -3.17940928535619, -2.3494196769297, 3.246789948861668, -4.136256359853072, 3.970009491977331, 3.907733092799434, 3.311850354965039, -1.633136429895829, -4.773775757096053, 3.286224820954816, -3.4383395153367835},
    {1.6663427501200998, -4.476995781839219, 4.158478209812812, -3.1765218462530656, -3.452061755251951, -2.8696864581924237, -2.5166012136728484, 3.8201556018081333, -4.219644665955869, 4.62972773812058, 4.176995838121652, 4.324786502074383, -1.0250007118371192, -4.486249465480103, 4.021669483656468, -3.1502861419491084},
    {2.0555497412382633, -4.624620932335815, 4.856003445976002, -4.059048893696744, -3.4312242269936033, -2.967313072021862, -2.195782860360833, 4.407570233354994, -4.592761419000785, 4.919658583200885, 5.019617955405809, 4.728342539111246, -0.7405984343212619, -4.277490557142557, 4.269857739857246, -3.608885601361382},
    {1.8191239933303336, -4.092415802300698, 4.508948978107456, -3.8165644299425483, -3.387826145236022, -2.9283603722074205, -2.4815304000423173, 3.9167469169758107, -4.505495663925464, 4.777161933884687, 4.876559510600064, 4.191066780191563, -1.1803375510276273, -4.31618091233694, 3.8452621003691365, -3.67138560164469},
    {1.364475751110892, -4.419769976742801, 3.9729580273746476, -3.9014451501629224, -3.2742890620531777, -3.314503197517065, -2.0083572613844303, 3.2870445980873573, -4.384886703683826, 4.310774628447429, 4.494322455029325, 3.845757414711299, -1.3102793593053736, -3.9660281309877097, 3.4429200118804273, -3.8189086720878547},
    {1.6091727696998093, -4.479453647211176, 4.817271985055224, -3.3571080473887642, -3.264794325321913, -2.935710450695482, -1.9550102340810196, 4.055937577153889, -4.243938394558507, 4.667836636350114, 4.9140899350535445, 4.444635254846933, -1.1255743035196448, -4.4276139883434205, 4.050450994999709, -3.3346507290827936},
    {1.1096802156642296, -4.527238663184429, 4.48126232687976, -3.3630721717652383, -3.2367845673651936, -2.871724870530689, -1.9429264573238794, 3.6093887832073337, -4.212022401779198, 4.658937956460714, 4.421217976561158, 4.2048215175763675, -1.1549939311030903, -4.495150126004535, 3.8226320024990854, -3.190564976948596},
    {2.141527251131751, -4.559467435802069, 5.007617453962768, -4.040662810274565, -3.614710565067711, -3.5002102334679965, -2.1850592380696323, 4.232187787910214, -4.659613917003674, 5.056959854862974, 5.016573367071106, 4.706596502577028, -1.6491621943801742, -4.892988638993841, 4.410742950421751, -3.89731830337771},
    {1.8405485423883674, -4.721503881668113, 5.053256136444713, -3.8209814416705994, -3.6036820847558944, -3.415405476564404, -2.2344799590971958, 4.381711947906936, -4.68891741463449, 5.242819133970988, 5.007960081693994, 4.680011602015407, -1.3778758998772629, -4.7500606805583026, 4.562102318634523, -3.677445649156395},
    {1.7268734694339156, -5.00129593187097, 5.133131113256952, -4.273977753538382, -4.332093229922943, -3.5141712315016926, -2.7014989209669125, 4.246217735503656, -4.898944877278192, 5.11093045501227, 5.03357129621155, 4.495486063354948, -1.50192792374494, -5.047112664353242, 4.489556814175292, -3.9992562492450046},
    {2.0456174779651874, -4.8393946866040025, 5.193891565067549, -4.008945382431579, -3.8892786145646907, -3.2831579226003065, -2.4588753978648246, 4.3280486260881315, -4.730236382642329, 5.218756093051009, 5.038772109288013, 4.89172420874168, -1.2799122620709946, -4.9254177830051855, 4.501893847079006, -3.7913233698571096},
    {2.169931383793423, -4.888457911776407, 5.268658461791128, -4.080972549616436, -4.051908318005154, -3.0478955918883925, -2.725305701230714, 4.69099561086631, -4.956381259990971, 5.236594465666851, 5.134235066132955, 4.9050821134866265, -1.2679737712396453, -5.0607293869912455, 4.589334044694063, -3.811930803414252},
    {1.679254474999666, -5.283937202185338, 5.14112586506992, -4.426800795674599, -4.307347063029132, -3.8386854125231182, -2.820793232797076, 4.70538075945736, -4.991067315145467, 5.36734608384046, 5.048682682786764, 4.797478814159645, -1.6305348459182112, -5.3939712253383645, 4.735921287759568, -3.987960892433982},
    {1.5965440349247273, -4.620306119910987, 5.41514518035205, -4.03010162550833, -4.104246873005128, -3.2998729228934036, -2.1648693886636883, 4.578820033218859, -4.847289914809334, 5.1222302612027635, 5.109258175391379, 4.644516514022864, -1.4501798324075024, -5.18514126662574, 4.475675773992372, -3.8382030229646737},
    {1.568120681288948, -4.819769589294795, 5.183024553367913, -4.085120440597821, -3.8590936985353737, -3.5192555327778883, -2.312412889272319, 4.718069658603228, -5.109745413283955, 5.2989015971741695, 5.255708810800464, 4.856881449314671, -1.5073453346493146, -5.216535337798749, 4.590843999357974, -3.767468478787303},
    {1.415566456287157, -4.927358211499432, 5.321337153936205, -4.492577126119682, -3.875688254717223, -3.964472022081821, -2.1181827234647908, 4.80753083705536, -4.88923460710811, 5.360418492492735, 5.568415858263962, 5.0921919317096425, -2.187887919113571, -5.147683987051386, 4.573023641035255, -4.14139708973281},
    {2.2754823408121934, 1.3235005785880196, 0.33298208807127244, 2.6875366173615145, 0.38652093178637087, 2.1744872579618377, 0.48868764592286423, 0.3643069380237536, 2.2564223558650895, 0.10586178278774276, 0.35508571219279095, -0.016779457981968282, 2.3871875162304974, 2.0909411263304536, 1.4392482562617608, 2.5368365488305673},
    {-1.896686464156318, -1.3070025206454992, 1.2075236563878766, -2.887799501173585, -0.8466341362786881, -2.3671876591432444, 0.7973009917892006, -0.1667807641779468, -3.430643970504629, 1.2182123525708186, -0.4800404796253458, 1.7581601518517032, -1.4805961470298215, -1.3405042137350616, 0.3115432639660059, -3.191355292301959},
    {-0.9989260153417944, 0.37021809498725106, -0.9811651202660971, -0.2243572968935981, 1.079428303920872, -0.7304635524452637, 0.32591075931336433, -0.7628800094772478, 0.5067945519151107, -1.2187205086731758, -1.4701549857023997, -1.3737878112359394, -0.25944781179194665, 1.8922859415191073, -0.9511483675022144, -0.2710935263719666},
    {0.12547879505847917, -0.5891024413536144, -0.21156176250740633, 1.2855432290724913, -0.01194274154140986, 0.3258784936678622, -0.7330930116492451, -0.19596493428936615, 1.0282016418021986, -0.9815310763504966, -0.8631847840332979, -0.9241622045250194, 1.2909038048001724, 0.6812966448452814, -0.3811834175735119, 1.0635085195287028},
    {-3.4002951603941365, -1.2272208262038113, -3.578489785747865, -3.5228886403578685, -0.8998395440075809, -3.1239951758542674, -1.2169598766840186, -3.3955488099479108, -3.6327934168935263, -3.362503165218485, -3.7267685595932774, -3.6408849711652493, -3.2518557051685297, -0.6666742041678043, -2.7810178877413922, -3.5554391405329544},
    {-2.878633994881401, -0.25617633691945413, -2.420031574014871, -1.9189197414063013, 0.17399935541620482, -2.1326586524604783, 0.12651535773990963, -2.5037381319778875, -1.669101762892886, -2.5404892948685385, -2.442378944456761, -2.650156776712876, -2.2607853477807267, 0.4355347029465273, -2.3734432675300625, -2.274367891302118},
    {-2.09793225631719, 0.4626656029792313, -3.5235852009801865, -2.088678702688484, 0.6532702649931093, -2.406756949379473, 0.6664888640233353, -2.948740743076013, -1.3506350320332565, -3.065108785019812, -2.8574724997569128, -3.1960256277688126, -2.3468069622610557, 0.07990535596045183, -2.819494535681166, -2.568893210576922},
    {-1.3267256729620314, -0.6973762106147366, -2.24904488701357, -0.9277973785622119, 0.6250134862415061, -1.2899566827426878, 0.0005919469873750037, -2.2222773660597035, -2.1216422500624317, -2.3088172443644246, -2.5721792499911604, -2.421266698354562, -0.7867880307053405, -0.20741623388212152, -2.092049339265143, -1.3800719713734564},
    {-2.278082954211285, -1.046666746880952, -2.7273649490021037, -2.1255964914799717, -0.6724682634163696, -2.1981903033717947, -0.6852313930448083, -2.241654173785918, -2.698032903834944, -2.126166031789541, -1.8271434001560112, -2.404187512665893, -1.41401983867325, -0.8979436400778117, -2.055377377487288, -2.538188559909446},
    {-3.0036546411042138, 0.07621536674682512, -2.8151375266179453, -2.189390617844781, 0.18596020012216297, -2.7359444920032607, -0.08447814649846809, -2.794219909122075, -1.8104226948700546, -3.016654579316781, -3.0139255103332863, -3.068526504326215, -2.4793512535272146, 0.5335784030509976, -2.720969940609302, -2.2304718231038128},
    {-0.8684340765381017, -1.9054759580901772, -1.688046239920741, -2.590196870145795, -2.3640577027840624, -2.9583815897578023, -2.2740620138838787, -0.9718721413830016, -2.7069097299593228, -1.1477243307366758, -1.7853805105992666, -1.0972763061931734, -1.650600762783129, -1.7868277025620676, -1.1120828245067655, -2.387960661161924},
    {-1.7703336078003113, -1.3940460645039687, -2.409818042224654, -2.2575997721964027, -1.4152834487787254, -2.3329503835254317, -1.5990331496560661, -2.164123579633854, -1.9636592158411932, -2.2941651760498245, -2.2505603627139448, -2.05192535188313, -1.7527856437839013, -0.9577347652533588, -2.093508551562218, -2.115861310667884},
    {-1.9696590967003804, -0.8856139640118207, -2.5457971567473257, -2.034882979443743, -0.9421679569769441, -2.0321601332004824, -1.3606016807633934, -2.288208522471966, -2.0483775533220565, -2.3486496736248843, -2.5298511867743243, -2.4362405768200355, -1.732837546564632, -0.4881294376828929, -2.077560478525468, -2.001060530886221},
    {-1.469971426490988, -1.1145901058131096, -1.298654851661504, -1.7498371292123085, -1.0448334035355804, -1.7611711138408908, -1.3824569455187874, -1.2803671514980142, -2.201435467711986, -1.5919270580577987, -1.6251697785429116, -1.7054614446613836, -0.9284513449340253, -0.7947665688177187, -1.3381544219848622, -1.9110800740396825},
    {-2.8718562311355043, -1.68366361989407, -2.3000831352590407, -3.31621283683167, -1.0737759306393293, -3.232627847677114, -1.622140450856998, -3.3373870515030415, -3.377156257038858, -3.0174577177515522, -3.608243606016264, -3.339895584622243, -2.9033170838705797, -0.6366719035989893, -2.4408405289977844, -3.250815339313573},
    {-1.4088062816115627, -1.296262017812816, -1.591834665980352, -1.907218866267872, -0.9054078286833241, -2.1377587311315924, -1.0965515098627308, -1.7766925615810405, -1.7402633228659883, -2.083078095442862, -2.5245611710841533, -2.5209507425403253, -1.8455219941492627, -0.39377460382506746, -1.566974872920132, -1.8576728743293713},
    {-0.049271480627373854, -0.6874802688393332, -0.9247420328676719, -0.7434577225064654, -0.7232163764968689, -0.28599996158255614, -1.7227092681965332, -0.9305372611486168, -1.15552536788432, -1.9694787169418393, -2.5167405985800686, -1.7856620694932333, -0.29067010651003294, 0.5002577908495376, -1.3105538574480007, -0.6532556830084386},
    {-1.2478233640087255, -1.9283186285666871, -1.8832503263216374, -2.0267436211811534, -1.95261204863385, -1.6319829239120616, -3.3774659867922594, -3.103682342297017, -2.6122332795201606, -3.385192347549537, -3.7499121270203726, -3.4381429264037977, -1.044859303449389, -0.5949798443824658, -2.267163335550255, -1.879142393969389},
    {-1.293351929184806, -2.7514008476062637, -1.4308247379719676, -3.4246594473139327, -3.1944953356556054, -3.091884454876144, -3.829197869593658, -3.0553656166641674, -3.8425272314432752, -2.90823710207626, -3.2402958967945334, -2.7597167937492215, -1.7728640746321298, -1.8088778585225622, -2.1938576590282746, -3.2613209073929164},
    {-1.406149712068515, -2.4055807061542724, -2.033590010461267, -3.092916792454369, -2.0985573885061477, -2.41992047713854, -2.436519494878015, -2.4476099831062395, -2.8238742748586163, -2.6629036969506474, -3.1951850708720473, -2.567180860172, -2.1877954835780717, -1.9431997433309196, -1.8914550272417856, -3.0336518318180987},
    {-0.6317471503141929, -1.6434228457873783, -2.673920886612584, -2.3884028640192927, -1.4251215684903547, -2.1154922607552744, -2.4093880400982757, -2.8547810797924824, -2.6328588786212097, -3.6846291286261352, -4.018031431330905, -3.723058948601204, -2.3502483307176396, -0.24531893593201787, -2.5958702983456092, -2.3691695861118354},
    {-1.127768885925746, -2.3449581184824755, -0.6529027930632905, -2.7151042843345508, -2.365631580033661, -1.8240525673668222, -3.326413501512141, -2.229015250018428, -2.9644207409818404, -3.172798600054687, -4.060642933716615, -3.4379006595001678, -1.279260222315318, -0.2544743128334042, -1.6752970828958689, -2.2705376171411418},
    {0.6505974094406296, -1.5984396045749765, 0.30431310418178503, -0.9082102757313928, -1.7558988141771124, 0.3850509641202129, -2.9032569097903296, -1.691333847286011, -1.5951312475289767, -2.5896379692587086, -3.0929274894497687, -2.7570395398069616, 1.030187951307684, 0.4754989254140291, -0.9370333415451627, -0.3566549251573348},
    {0.12296491816953327, -1.6643229865375435, -0.9633956442486816, -0.9270571987844213, -1.7888898403130027, -0.047734256985094724, -2.690325453650709, -2.901262444534822, -1.6598335799358914, -3.441529745637579, -4.551375048110467, -3.5541988569739402, 0.4607822802392243, 0.10145721078560699, -1.7576831028542883, -0.5693722369189795},
    {-2.1015173050048306, -2.770559605687359, -2.081871364938186, -3.1549331885759835, -2.952103628528001, -2.710160427568059, -3.646638956421973, -3.604520020038272, -3.6200316506350143, -4.018053109015829, -4.414588544620656, -3.9912283331195644, -2.3543817668114215, -1.2631584248217878, -2.753565058082347, -2.9913678425966834},
    {0.42752757348708004, -1.5410575778625495, 0.012531351936071765, -2.1538727272693285, -1.924490787095042, -0.8875041348536845, -3.1336955500456227, -1.7410991484519747, -2.6716011539014084, -2.1581659276454404, -3.0278706999447897, -2.404839299339565, 1.2540641857517105, -0.005828809289561504, -0.9183106883712496, -1.6146348706642093},
    {0.2638636121017977, -2.0148260433210945, -1.1060053995570773, -2.393537403515086, -2.5021811402700918, -1.4029497493621348, -3.482529659349988, -3.40062967646012, -2.315528490499999, -3.114113106933156, -4.612222117061815, -3.8922348257516908, -0.3759717129635988, -0.5963603436687419, -2.2191686277702454, -2.11706128842288},
    {-0.8192533537612002, -2.8770183016086115, -2.31640271893963, -3.3589863872140246, -3.0769599897440143, -2.3777569676839625, -4.086655694336497, -3.939372482167544, -3.51314303606769, -4.378397392986236, -5.059311852730838, -4.613278178434453, -1.3860154393684037, -1.1194714512431028, -2.5372786579787214, -3.0205407321017135},
    {-0.6106489571772546, -3.3380200773305058, -1.2982774838501954, -3.0052321658315386, -2.9136427336211628, -2.2294996634096975, -4.116160691551392, -3.946980849514392, -3.456155214377664, -4.085461342658883, -5.198961499501704, -4.207986825173487, -1.1708707749304779, -1.3878763719307754, -2.7836593181152467, -2.4538386000044548},
    {1.1274634122969514, -1.668297991860037, -1.1175750970404301, -0.8264554520740965, -2.0591441846868075, 0.03457696764912074, -4.089778033397933, -2.293804178095659, -1.4699931365886947, -4.143563897364872, -4.59209890911016, -4.369871637857636, 0.24557281905789818, 0.08224180773327748, -2.0409378114169345, 0.08387226104077024}
};

static const float b1[16] = {7.4365575286595105, 7.483630582593947, 7.375236905811338, 7.263851281910632, 7.3580539690212685, 7.504248378126394, 7.280132698631861, 7.081248087962372, 7.43055681547432, 7.194903907861724, 7.371484885945528, 7.33993582793322, 7.281039129698247, 7.360964165436921, 7.129076570574284, 7.46321400476982};

static const float w2[16][12] = {
    {-4.248390899566118, -4.137041545336612, -3.648958677424018, -3.645177789741048, -3.5659798183450127, -3.3643072819280184, -3.9428567048390617, -3.784338818604591, -3.9814483684904256, -3.7917556411677187, -3.21243405593183, -3.9283011929733136},
    {-4.889542156261402, -4.197082322854682, -4.4038697233422415, -4.3811191985878075, -4.393215189832773, -4.183090107216222, -4.629242832765247, -4.260016415915246, -4.433529103368273, -3.8657524609437552, -3.9912072363339313, -3.44246353202761},
    {-3.625336512901907, -3.0214813351701513, -3.711856625510912, -3.7196052856004926, -4.374448642973623, -3.555114923068291, -3.676403784734832, -4.063174826239758, -3.2969114381278097, -4.032679306485425, -3.585908084567372, -3.7937262752533742},
    {-3.898468517513627, -3.779281376037732, -3.5278518484748305, -4.273448721501302, -3.7695373626543383, -3.8690135951119555, -4.109303262671785, -4.0705896988216645, -4.10302839469927, -3.4473881806324256, -3.9147299514635487, -3.906475099018444},
    {-3.834574931296741, -4.2643068172513, -4.663769217446874, -4.309425778463646, -3.505398886434566, -4.07302269079115, -3.5673323460378823, -4.814455743496801, -4.245817600796307, -4.611253023126879, -4.487915594630815, -3.905859063110617},
    {-3.7558068938869122, -4.241069972093237, -3.8174526843433236, -3.450319148122278, -3.4668063028302365, -3.62854617117932, -4.317089675257532, -3.9162051345119107, -3.3482628761289206, -4.315175685594118, -4.086733053247522, -3.405730985159203},
    {-4.429469289997294, -4.467386807498892, -3.9769480530899366, -4.205673111025527, -4.882337878348984, -4.539758546359661, -4.552080647638597, -3.789687849195362, -4.525598103234838, -4.212440908482501, -4.407261532232838, -4.738460546473989},
    {-3.453456517025753, -3.9843424975183033, -4.429087778007293, -3.466412609576914, -4.064183464062823, -3.093172100149275, -3.9006957803402877, -3.822338713354589, -3.7980864896240045, -3.0883643034275177, -4.115557477336868, -3.454896669097618},
    {-3.7222408468590173, -3.7386130400557804, -3.8908072936050027, -3.849233721851346, -3.848121179841005, -3.8047930247826445, -3.5998173517986243, -3.7574232469116677, -4.121088222053809, -3.9848925086809683, -3.887448207671659, -4.115757878028825},
    {-4.143445293213228, -3.9582599818830504, -3.9775034840320385, -2.821591520267749, -3.9688841978324634, -4.336333587478079, -4.139532914306886, -3.48711158278059, -3.6643062950488927, -3.7433492756330975, -3.420501478865952, -4.6213234074572},
    {-4.108809372180868, -3.9293617765156688, -3.831427434768241, -4.338785791712198, -3.794842098788856, -3.8814633707168484, -3.148922800075219, -4.015120859746197, -4.438109397787799, -3.447367681009842, -3.836805506067214, -3.7152263376287036},
    {-3.5147431844666697, -3.7156239257806805, -3.249119307047261, -3.6398321485945937, -3.567064586075176, -4.044210056375653, -4.183163822171064, -3.5958635987724596, -4.191579524525457, -4.275121260052763, -4.206129674579281, -3.081713642552153},
    {-3.6439128564864043, -2.8285167905389845, -4.0064641613763134, -4.024870888859261, -4.193988087936619, -4.151124060114355, -3.8149443173564297, -3.575605073775246, -4.070560063101029, -3.787185415011963, -3.8419296204989206, -4.17249502065061},
    {-4.24922274131908, -4.370307245942171, -4.03992614840202, -4.3672436739094165, -4.586028296983116, -4.348233741015034, -4.417702623097068, -4.157765448847112, -3.8275703560142786, -4.32584170181085, -4.181505822812223, -4.9147183919222766},
    {-3.514577312576662, -4.112606058480071, -3.5333774857006692, -4.897733297692, -2.9201982663981156, -3.9408865479955355, -3.6265623984986974, -3.9401948324695066, -3.2306708469881538, -4.112312733611341, -3.940794154901509, -3.847408011434161},
    {-3.7538506561019367, -4.048221205434001, -3.9364666568949107, -3.4850652934476933, -3.9022874631114437, -3.8828652100876933, -3.297701818513356, -3.717293780963214, -3.8254090938229695, -3.721111226623416, -3.5883614343339247, -3.941995701729681}
};

static const float b2[12] = {-4.892037462274385, -4.638941631893157, -3.4159434212444473, -3.934244060372158, -3.7547837219572635, -3.614685740366819, -3.6455863621767173, -4.9877609958727875, -2.41378387976941, -3.995226331874189, -3.417885820426087, -3.1854481117063793};

    // Input Layer 
    float z1[16];
    for (int i = 0; i < 16; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Output Layer
    float z2[12];
    for (int k = 0; k < 12; k++)
    {
        z2[k] = b2[k];
        for (int j = 0; j < 16; j++)
        {
            z2[k] += z1[j] * w2[j][k];
        }
    }
    softmax(z2, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
