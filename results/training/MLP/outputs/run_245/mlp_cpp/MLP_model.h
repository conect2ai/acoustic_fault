#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][16] = {
    {-1.2728177670651974, -2.2212065605076914, 0.1342477407657724, 0.18396470540185844, 2.432678310750362, -0.4602967409121664, -2.809310722786519, 2.9218686844262427, 4.252432712965742, 0.3452245171905514, -1.943780501479891, -1.2044434791626932, -0.9134950796795719, 1.6097643855404913, -2.39233517666674, 3.970858138029879},
    {-1.482400998617328, -2.998098456363909, -3.043993027949571, -2.2543694255224747, 2.948854457498506, -0.046515561232463774, -5.260106881574764, 0.42641824611382695, 3.763848208766143, 0.7459238531912954, 1.723478840776429, -0.8697927112502631, 1.013002388631521, 2.1584523921627543, -2.932742633522952, 2.9137150801532976},
    {-2.0612302699445157, -2.6096861609337956, -4.438322307077982, -1.7567915731578172, 3.6366563313065834, -0.6418160299454176, -3.790837848013087, 2.095424720973, 2.6639612181213206, -0.3531547799090795, -0.02176867859357948, -4.14923909904659, -0.05696147680693575, 2.0211908193973565, -4.884492882327065, 0.42055799009795564},
    {-3.605484665729546, -5.160942177469447, -4.582038119179949, -3.625245467566426, 1.718673016810234, -3.444499660181349, -6.2528594107672335, 2.1260479761064945, 1.369729621996294, -0.9201428954185528, 0.3854817309911928, -4.029571013085405, -1.437642471988037, 0.12278850949665576, -4.147862614238629, 2.3143534196028157},
    {-4.2147967281768475, -5.879996531828056, -4.788427196742253, -4.045820446938647, 0.7705925024016622, -3.068092134958102, -5.192828361701852, -1.2568165758550174, 1.6850821550465453, -5.563486534619943, 1.4671711881265896, -6.21629867045681, -2.9048842332796037, -0.5893937155758621, -4.879933436633299, -2.137318853636203},
    {-2.866354425908233, -6.3061108984711645, -3.811700323981524, -3.3424437678861767, 1.3523919403080167, -3.589399288399774, -5.334737632119656, -0.055121198331526934, 1.710952012661102, -5.333658910523318, 0.29549378759154815, -6.4264949598350025, -2.9289849660719045, -1.5733692301397388, -5.021891280250463, -0.9282495471836778},
    {-4.6770544151756, -5.69780608600685, -5.866998811524906, -4.817864378269634, 1.3257516516460017, -2.5508608694152297, -4.6892555930913264, -0.4603607553310312, 0.2807299162183378, -4.588298562638696, -0.3932778385008882, -6.789162847536782, -4.698569266164488, -1.749516001808793, -3.023013445289248, -5.15303486726873},
    {-4.6163557997055715, -5.6535588059759565, -3.8964636422246657, -3.2677735217696413, 0.8288551410978182, -3.6107613275251897, -4.581214079077023, 1.6925314430924652, 0.3711399535607749, -4.444683111015491, 0.5712070347811082, -3.4176868321405305, -3.655226623435536, -2.7963020479273717, -3.975862942266567, -0.9401037274035873},
    {-5.333343618556993, -6.316224525750652, -4.366562682129287, -2.5130583520274548, 1.564455619366293, -2.607018140566937, -4.621323491559608, 0.6588479118259342, 0.5987795981619772, -3.440512443270968, 2.1347185740188404, -3.748815549517846, -4.680593308175733, 0.10755363147274712, -2.155943137800699, -0.12740841700982183},
    {-4.614781068832936, -5.778046883030828, -5.314891369343955, -1.84535065892983, 4.731238084413665, 0.16819854173769544, -5.012030725949851, -0.031055420320493552, 0.6756248859721415, -2.446789353868001, 0.8472932838993705, -5.000757648030796, -2.0362606175531743, -1.9980798784011027, -3.861219754115598, -0.3804659747162012},
    {-2.1514405566205896, -5.695876990564396, -3.2918887035145197, -2.840776944346839, 2.650981735389155, -0.9691477684299531, -3.1557777202458777, -0.6919188526581694, 4.232138957022262, -1.5258634454217894, 2.4303785894979417, -3.896375234452925, -2.33592551713161, 0.9045300095966815, -1.9088835271320155, -0.17181444226156964},
    {-4.033426022525743, -4.978974723130863, -3.9466131253812797, -1.0779613179523275, 2.641019740442998, -0.26692197937793166, -4.6391762783715285, -0.3601094603401833, 1.248648403070189, -4.520613284301483, 1.4505395506597838, -4.674787073588903, -2.265027519493078, -1.6076837043989856, -3.6155624551321797, 0.3254100883588529},
    {-3.5911009126981783, -4.5576308011938105, -3.752958798110363, -0.9635104818972511, 2.09203832229678, -1.929308232508808, -5.733280605281007, 0.9674669761812404, 2.0329163581828924, -2.463505129954556, 2.063123682555378, -5.671293177937419, -3.6848416970328985, -1.809628942427146, -4.369614031119515, 1.9228596347460727},
    {-4.081315790717552, -5.5268822496342365, -5.3359087809037, -4.0653131522831645, 0.9837255338739549, -2.1697509382163864, -4.98026958046587, 0.07770391029467001, 2.5488976397988488, -3.892121815876122, 1.3264813617611997, -4.180832808186469, -2.0105551425163677, -1.3339327162486014, -3.59145154014982, 0.44480192313834205},
    {-4.467465721875884, -4.754289004651272, -3.6317002604874293, -0.9020394490995173, 3.6920571415848245, -2.7281943443164938, -3.9839943877152293, 0.0019060006572665027, 1.952075430778056, -5.361282477832346, 0.9686422934684629, -2.9535098669888296, -3.712925790749845, -1.8382615179002417, -4.798887235791567, 0.23833265765686978},
    {-3.777722182801747, -5.059662772287899, -4.199807258550626, -3.771341100214768, 3.024373763703767, -2.0896371208779367, -4.9894713867287495, -0.9208806844933658, 1.1300739018617199, -5.247269741492479, -0.16408954563954417, -5.663454395636305, -4.312027929813653, -1.4786875660691634, -4.372146696393416, -0.3331921299816397},
    {-1.468797383012095, -4.752992141161327, -5.331802971932446, -3.775613245629207, 3.503537560787417, -1.6961402992671526, -3.677749708727611, 0.2935899082836456, 2.5490509777103654, -4.891924441438613, 1.9162782148686608, -6.831589548506435, -3.922710177587073, -2.7064079484698658, -3.177756883244369, -0.21886615027064266},
    {-3.8940578356012967, -4.906711412711892, -5.437589218190935, -2.424934537606455, 4.5273232971847355, -2.047802744610768, -6.190397017349358, 2.468982247788391, 3.5324196167197472, -2.5214375224862873, 2.4112804034304767, -2.8230089870011015, -4.451444870805971, 0.17900461713134014, -2.221561137865223, 1.5016749194847125},
    {-5.353809853839676, -2.4854595459857474, -5.427052168073621, -3.6771805295255025, 3.9734498588733267, -1.6356224377369644, -3.203408868794295, 2.800542430074306, 1.483014327085156, -2.71475799592528, 1.471325365223468, -3.8042151732571985, -4.525522432853372, -0.8577456043600166, -4.234006303111086, 0.45538143106484263},
    {-3.2206641688250683, -5.252633707928119, -5.202932008736061, -1.7765259333148684, 3.015032380181752, -3.501128878364779, -3.681685608875654, 0.6655054496727872, 2.0207587149281094, -1.7740239860263773, 0.6228222137809505, -3.3401864016992757, -2.548489713053528, -2.763559611016178, -4.252864361003055, -1.1312377962087454},
    {-1.1285478601476708, -3.366751998201288, -4.589583068450458, 0.7758436532655777, 3.7050663155866594, -1.5482534373512187, -6.312628547448748, -0.00035703971345495437, 1.6532504282788332, -1.613236084887364, 2.9527667947671747, -4.975914293793687, -3.4102362249155562, -3.7124794166698143, -4.659989586573024, 1.0920791752717396},
    {-4.479995539815577, -5.777707565062755, -3.3048775620409128, -0.6564291468186669, 4.670669472326897, -1.6574384073975008, -3.1611911447063905, 2.6800844990948476, 3.5475633674672986, -1.3363779364375548, 0.33034023953239555, -2.257760862889218, -2.069317452915068, 1.4454961678601344, -3.199914763395413, 2.7699856836085868},
    {-2.37925619713715, -3.842708566152976, -4.662758586146895, -0.8990256362590553, 3.8838839964184713, -0.9306425482991975, -4.580758828825945, 2.465429531324963, 2.9942204921245197, -0.7910308237470078, 0.8165401941909347, -3.911930207067102, -2.5292128747762286, -1.3203897022014914, -2.257424834254428, 3.2966284705882796},
    {-3.742694655705187, -4.5212344753103455, -4.263719745511777, -0.15444048615267525, 3.191788084459122, -1.6317980716805955, -3.6893447708036016, 4.689058145367373, 2.3153160016135854, -0.6657110030597653, 1.477971047827715, -5.678083314203638, -2.6393349771966856, -0.14415443350840404, -4.0234890604894575, 2.6428311239983646},
    {-3.217753169330744, -3.731235770073955, -1.6590920926485455, -0.8648251518983799, 3.78386088632229, 0.8043791674847767, -5.7175375646022015, 1.831064453363217, 1.992528965518787, -2.0222223814417895, 1.6752096923015694, -4.699118412519844, -3.3280459509890243, 0.4855125693484258, -1.4411345225216956, 1.4384388462743662},
    {-1.5399650258747524, -3.9305429894204886, -3.936273842716066, 1.063744768881072, 3.643597680782791, 0.30810420352668455, -3.844424894394792, 2.8720189326206627, 3.7146101376879206, -1.6065147563818531, 3.48998805693669, -3.0166689511891343, -1.2826929467277477, 1.1080726807718524, -3.7777157254500766, 1.5614320733872302},
    {-2.841672836234044, -3.7697041810889016, -2.4808163190536874, -1.8643123024589356, 3.6940176259166413, -0.46967346246952624, -4.533965192793571, 2.6467875159646606, 3.248791660984728, -1.7517206840540382, 0.9455091591997425, -3.256271902573779, -1.3525981192097598, -0.3871602596219424, -3.728935833214642, 3.3237322652793466},
    {-1.204739142687658, -3.461313989801791, -4.521813942473319, -1.8797423033478775, 4.931164013676993, -1.2790253347547174, -4.103038641792889, 2.7811180995582383, 4.228220287601139, -2.8964659959508827, 0.05374843890945668, -4.2784357916180005, -3.509861516901647, -1.9094546226296207, -4.963265200090079, 0.7504038960277553},
    {-1.3873006828575787, -2.582120843409924, -3.767229474279866, -1.3976482525815876, 4.427031262304245, -2.159481956355512, -4.5312645359932535, 0.9555621565828032, 2.803680371662235, -1.7363998796515847, -0.5328972869796332, -3.8357227226825477, -2.8792398622433146, 0.4400993908306038, -2.78467840670858, 0.8690135574015152},
    {-0.5351257454380691, -3.895244885309994, -4.044605943885135, -1.7250442632569105, 4.0448601694501605, 0.7631233378507732, -3.6363833938873134, 2.4853722621017944, 3.4792914007847386, -1.048178027817648, 1.5949622138015762, -5.553040697561485, -0.9545341899705659, -0.3970151791730299, -1.9486659997653273, 2.5323833608570765},
    {3.3067268699571875, 2.6785720053003472, -0.4073691276852124, -0.5429411852395382, -0.8983901813396171, 1.100628462808089, 1.1371267481814156, 0.03908303200090721, 2.572551136112088, -0.5999371692591077, 0.804968514040634, 2.9651709898017966, 2.4267217606746754, 1.631871724907293, 2.3044996523683943, 1.4999007457585587},
    {1.41584218133376, -3.2025759679693353, -1.4575913925962298, -2.4551483444745337, -0.008913029662679534, -0.9661746500726162, -2.266181060305662, 0.37273388868115287, -0.023909775076632573, -1.1552135691709273, 0.9001410632371665, -1.7615764212683287, 0.14550235626671448, 0.9526091185666125, -2.0609169766101303, 0.0019581051830501713},
    {-1.1805817493091633, -1.7098153929923212, -2.07376672851454, -1.9028303745406951, -2.923105351425875, -4.087785364153904, -1.4664314370386453, -0.37434952956364176, 0.7169619633870388, -3.625938555421296, 1.5848575548219987, -0.8490690268607312, -2.9494182308558248, -0.7784754372805378, -1.3584317841227997, -4.426943848564435},
    {-0.7234894436920501, -3.517311250461783, -0.4510855881742235, -1.9096285170899034, 0.22577541391972303, -1.726803833268232, -1.596070279699934, -0.25268935691011707, -1.2731399793042688, -2.0930389301965278, -0.9171573399578036, -0.8253072214926753, -2.202054146960003, -0.8000166548409812, -2.1710135938922996, -0.7955303756013138},
    {-3.0967083757797393, -3.1137528697073225, -1.9962842386316377, -0.4415947674468963, 0.6536090827355314, -3.0410882498389515, -3.041897184023042, -0.742797447462709, 1.8148676586145982, -3.9725340578817883, 0.42081509805920664, -1.0804055771371655, -1.9032232394177395, 0.8300866035167748, -1.3361992412784196, -1.3964603180032966},
    {-2.1458153452693915, -1.6620144109746782, -2.4956854583190937, -4.33365721157661, -0.07550157626041538, -3.5541469779077364, -2.234549631085163, -0.8158234055920416, 3.346196469109539, -3.24786488208134, 0.6591262577714019, -0.6261648829889479, -2.3581345816893635, -0.06388363929888763, -4.651490498313925, -1.389350918503261},
    {-0.22703864624503903, -2.516884842153878, -1.9840536420858887, -2.5907776263321582, -0.5046330759432167, -2.2546426564753905, -3.4398729783322803, -1.82247032650726, -0.5697102703893293, -0.2434058092872458, 1.9472594747137109, -1.9961388071400987, 1.145574039870003, 0.3000815582302352, -3.086504695247258, -0.8995057300858582},
    {0.28712070778269433, -2.2463577533558365, -0.7227010817369591, -1.6950029352340508, -0.10249296311293449, -2.647184484421412, -2.3800440234830167, 0.5955399561388472, 1.7028990051349544, -3.9751649543112957, -0.31495655337272993, -2.400230183119203, -0.25646784840471754, -1.722081600960583, -2.0035121380311094, -1.1653982304443313},
    {-3.6592309989344725, -5.473217635263458, -4.718712915375794, -2.7123943526636634, 1.9829785395055246, -2.7831874268511783, -0.9253275886161023, -0.35633029109934344, 0.1792114495634713, -1.7392430371957388, -1.2297529208569864, -2.7413992471487187, -1.8958539188651673, -2.1767254066859625, -2.257242195499214, -0.8085103604093911},
    {-2.011174205130153, -4.183038373748695, -3.761270336141198, -3.529202090229454, 2.5137744878027815, -1.8852562522738432, -3.752090829012675, 0.5113162899047006, 0.7331185563210689, -3.9878459498735674, 0.36341513242323387, -1.6329307731312404, -1.9666041356139157, -1.2729720659322663, -0.6757808100580308, -1.7328977495526265},
    {0.6263692821554443, -2.037526222516485, -1.8277053523964022, -2.098019626897869, 0.6563292127585327, -0.5331430246934211, -2.305923296586022, -3.6072152342362203, 0.9413721321901962, -3.161379447909345, 0.042151504644506205, -0.1668968952340224, -3.520585795643733, -1.6775738287989903, -1.3580025816402321, -1.2634767946913161},
    {-2.285927635051419, -4.407215332728601, -3.259237090954172, -2.029739857910457, 1.1615271392101048, -1.9582961077162866, -2.1901368064432236, -1.203073915319434, 0.37971298660745323, -3.8485637264772112, -0.8432775219813595, -2.738157236841969, -2.7350213411645496, -1.5640139231143275, -2.3112945976456762, -3.6073803988023068},
    {-2.5147909913122155, -4.169970445095956, -3.2532928864166206, -2.1711316099093145, -0.25746827334136047, -3.691669431880782, -2.773357969576482, 0.6331400659483255, 0.7442073527061652, -3.0253883286026344, 0.3153403027387565, -1.718201743696589, -0.7053357494565957, 0.5931566451005471, -1.8143089996156159, -0.9936509199267299},
    {-0.9270752406676115, -4.274114106582275, -3.472801108621895, -3.2981842019555616, 1.7013369667741343, -1.683914344412263, -2.1246258456697866, -2.0419439938828203, 1.008862941751319, -3.3327627844754386, 0.5911966794732472, -1.3351402473235594, -1.5698534857916204, -1.2723194051701947, -1.4992425551132464, -1.6231819773633136},
    {-2.4054002316828376, -3.1151650673139852, -1.8768538384604971, -4.397104012433269, -1.6328766044201364, -3.4070007257739574, -2.6663360590653142, 2.671336766537075, 0.6397111490248888, -3.909375527514163, 0.05101905731639065, -1.0426273603748293, -2.522814260584484, -1.9612711265189557, -3.2736641632027768, -1.9633488654789928},
    {-1.9392439640201915, -2.278370668317666, -1.5614292530782468, -4.254350862475514, -1.3235828612936533, -2.720358625701338, -2.6012690347316263, -1.5592753566551598, -0.3188954594047379, -4.265273160629373, 2.876592838910034, -1.0341204098996861, -2.1089983984594247, -1.3563148314061653, -2.3374998784254286, -3.201133467017181},
    {-2.746753004105887, -1.9349754496428135, -0.9105067128232616, -1.8610791651398568, -0.8825065044972037, -1.9201256820002686, -1.6228073700409085, 0.4415333866659907, 0.0659154971062332, -1.8731115705754848, -2.5108134661935826, -0.5886506080762133, -3.1768630943539096, -1.7132344165227629, -2.286785700416708, -2.2906847390955645},
    {-3.059652919953889, -3.255681675788975, -2.66941553918602, -2.401330045686553, -0.4634473716943162, -2.4884974292424435, -1.3276283116341445, 0.9328254665326544, 1.2358642630003256, -4.033153484656331, -2.295959028193119, -2.2928810555923085, -2.975281121703263, -3.031224868048874, -2.1966776960863146, -1.2833802959275444},
    {-1.9604142415827202, -2.869816751166139, -2.1745351045047667, -2.6226681747168183, -0.8111144705951944, -5.013030940856088, -2.8876881772661487, 0.32080567535546817, 0.803687728573447, -2.8985374251507277, -0.2879107042654259, -2.308304005591852, -2.740203887875805, -3.649811166073045, -2.6571538550501663, -3.637845117736282},
    {-1.4323278785788356, -4.266397898474385, -3.2653085030179385, -2.078886032413816, -0.7110412296974948, -1.2295737435131853, -2.4548055896849057, -0.5670172155917064, 0.3170126770987235, -4.067702349020003, 0.12710070408028135, -1.1887528781314045, -0.8022803890436323, -0.44456094737355156, -1.3027815280649173, -2.443951012280977},
    {-2.882217059628823, -5.2669564217693745, -2.4017112959682465, -2.7656144908826676, 1.4670217254208082, -2.5972731752890375, -3.1675350135678415, -1.9597116501420742, 1.4838152911225526, -3.3120871380300305, 2.584383393053263, -1.671329591904539, -2.187984198187899, -1.5823166105386748, -2.2587025488842007, -1.806657304403484},
    {-1.0220395612340625, -4.095251082246502, -3.6623265554832543, -3.0945140988547224, -0.43168817924658, -2.0526751530914664, -2.9808943017098657, 1.9656091258111759, -0.3096715212240237, -3.751319995679679, -0.3009025100260178, -3.637031451863895, -1.7443553135711145, -3.307023249464468, -1.7294413103944892, -1.9262734896943183},
    {-1.4784205136136543, -2.818069223758355, -2.065051394789504, -4.029802940486512, -1.4514769004440289, -5.88850111188054, -2.6059043280302516, 1.0515797731550414, -0.9804225609899236, -3.406025526526148, -0.8688745744922156, -0.9232913693828765, -3.601575295600334, -3.545637527514413, -3.908454919162785, -4.220388802513117},
    {-2.94488854441458, -2.5026583996250613, -1.860938256636905, -5.2581476643552465, -0.24578253292115887, -3.818424622768304, -1.085457902158149, 1.9066387851403144, 1.0049033314716398, -3.196192485885537, -0.9743264399043335, -0.41334315722217774, -0.7716068543965081, -2.039889330249129, -2.816631025429634, -2.429266548144328},
    {-1.993906910423885, -4.178528749076489, -1.5675060758811206, -2.556894260695085, -0.5565927132616763, -4.320816848412174, -3.3691320626743235, -0.7721864065713443, -0.7994287089640185, -5.289589594015719, -0.5404713580735998, -2.7631252771773234, -1.7265945130874276, -3.7594915087796097, -2.7690617706876166, -3.6266811279126223},
    {-0.09033038404277455, -1.4917806853534927, -0.5230966054424024, -2.9120648747242686, -1.0196992837514756, -1.6214296940217876, -0.3680229638999831, 1.4971828687445585, 1.189642126804094, -2.502902795576957, 0.9278678951475543, -0.7169822314591399, -2.5978793299776632, -3.045163446827571, -2.903228815937544, -2.755026830040308},
    {0.267838078957061, -3.2206157147613093, -1.1915833825588253, -3.1768838730472817, -0.29702922306535473, -3.13280078899623, 0.192388182228933, 0.9021676521368076, 0.8465677892663535, -3.1484489537745493, 0.9226923864903483, 0.19847045755209902, 0.2137578583695828, -2.9515756037809133, -3.3628775444446637, -2.6605783412173167},
    {-2.8173049984105885, -2.270012422328517, -1.7345524603621993, -3.090543735985466, -1.319661785065576, -4.604680627449222, -1.6740675338566213, 1.841245375701714, 2.1869357375889136, -3.626505620138464, -0.8210876880367299, -1.1531234589360448, -3.227820889609171, -2.6764335707484626, -2.190582033087893, -3.0306589123647316},
    {-2.528887565444904, -2.391869653688411, -2.4740949006705715, -4.482121549531508, 0.2472433330702777, -6.122050412360613, -2.308840095045179, 1.0467924529954773, 1.9187565705285627, -3.1540807546428704, -1.4099891472341421, 0.003790736631000366, -2.6955119644139893, -3.3822561546781547, -0.7983108344855779, -3.6178869662191593},
    {-0.39697899697223654, -1.6351963832771739, -2.5182561656722853, -3.5451115638425046, 0.8351063344455559, -2.776295594707885, -0.6675981082069594, 1.73744525655384, -0.33139006996757664, -2.1665959443865623, -0.25958027032538067, -0.06866857524437325, -0.4901641867578554, -1.6711905478366516, -0.9461030965493334, -3.3186724036164827},
    {-0.6117127428048755, -0.01048422886087592, -0.8117250956419431, 0.5888960428892568, 1.6380329277250814, 1.4068189423951953, -0.11160507477384685, -0.0410575512382183, 1.1880974785639011, 1.0691356941837538, -0.4295369471156552, -0.8077733479455083, 0.00666243966412077, 0.7275126655520807, -0.5162324801181868, 1.3906979789235143},
    {-2.392606534497173, 1.640675906667809, 0.9756651203915391, 0.406972489147924, -1.8267551378242466, 3.0628541392672384, 2.29032697567911, -1.0870877928842235, 2.1063780730348136, 1.2661464466288517, -0.7536498627297556, 0.3811844846356447, -2.4436069561930154, 1.3560296928895892, 1.949063140223184, 1.9703512376197019},
    {-3.985097107484603, 1.8515834068514883, 1.851777881021762, 0.49912870681800536, -0.26414589133555083, -1.0286966667861481, 0.8370541856639699, -1.321512477619174, -0.09532586449749147, -0.6866830801777084, -1.7396871886514622, 0.9776992806253653, -3.7810799372686383, 0.6055709984153806, 0.8648647997777801, -0.7396685224819086},
    {-2.8086970312357606, 3.125527795680161, 2.7308774997430967, 0.10022450001749157, -1.7632159364861086, 0.6747419144124331, 3.047477490359875, -0.9959323041180379, -0.6120489898985229, 0.03127614182583631, -2.763298404876009, -0.21659255414754974, -2.6981455727961996, -0.2959119261549892, 1.2328252554971688, -1.8249247572243297},
    {-2.9033052229794993, 0.8568885058449923, 2.497319527792623, 0.5006448204154226, -1.9753904431329719, 0.40191258456041606, 1.8724334494539565, 0.3176328440815342, 0.47457618292221904, -1.8007791632779873, -0.40896110393197554, -0.5049620648616115, -2.78306143349405, -0.7258367249663467, -0.4958172953354764, 1.1748403805679357},
    {-4.994200668798596, 1.685520869309101, 1.6318826352644238, -0.2231164702741786, -2.8471248498289707, 0.5759923859906354, 1.7017022039244198, -0.6516217321779313, -1.0524246162266702, -0.8432047028605615, 0.15105575856056455, -1.4819211451259497, -4.01840199339396, 0.3909378492870982, 0.08428577488563403, -0.4375304826460007},
    {-2.9706428508537366, 3.046915766585393, 1.1185626383979603, -0.7729143315539839, -3.3624265507743707, -0.6390166587846392, 0.8476412767678829, -1.651057198647311, -1.0645017069458629, -1.116228444867066, 0.40543222778661975, 0.18219126484015505, -1.8059049931995848, 0.6284172382799492, -1.0234828102021116, -1.1849389249927234},
    {-4.233365221742891, 2.5242017193310167, 1.9210403707143462, -0.5877474965633759, -2.5475832102097438, 1.5644662396188753, 2.523244005374242, -1.2758492350838428, 0.5216618214511353, 0.7808646664157718, -0.5823103285072998, 0.001071704116288354, -2.0447924798640797, -0.09222897053756104, -2.048276025695708, -0.14911188123334018},
    {-3.9783407566492155, 3.3195876551331636, 1.3812459890927669, 1.346304468855108, -1.5092225677536268, 0.4682096819526673, 1.7093941990772168, -1.2339934656185827, -0.49879174606120175, -0.15917784027697823, -0.47833080257326044, 0.7418346065416248, -3.151513331727047, 1.537043409221204, 1.7712195269089996, 0.5385419381481199},
    {-4.781828020383522, 1.7995451635997046, 2.3385772609757502, -0.38667642310847083, -0.8543727302868436, 2.0365325125643587, 2.176826328302753, 0.23330984606691968, 0.060294500704689086, -0.3276155054251542, -1.7640208574045897, -1.0196621371810484, -2.6716120111843225, 0.4563701299859959, 1.0196239258848685, -1.3815792865744694},
    {-2.7164923472581926, 1.2577854411186264, 2.5274236222326594, 1.0766561031447337, 0.1495329676960935, 0.005932173078997967, 1.899831569256668, -1.2034322210386443, 0.9385704838278109, -1.948415081447454, 0.2761213646736602, -1.0523831042654594, -1.7838553537115758, -0.3134372750174354, 2.009473234767023, 0.5949840290121293},
    {-3.9615044707601914, 2.4115814665255746, 1.72369293940713, -0.1320688172276787, -0.21530788454197586, 1.6452935063184408, 1.901424566861656, 0.19883396543595233, 1.1860889224329256, -0.5150023525924495, -1.3240454280749878, -0.5557505734714103, -2.5742782984597103, 0.8425239976929217, 0.5849641239451587, 0.1588285513307673},
    {-1.291227857578336, 0.9741397609859029, 1.932253281778392, 0.32141693139262445, -1.5761361154401912, -0.6207174537920254, 1.6454875504819853, 0.4650651276936798, 1.6495023632218173, -1.4237750121519923, 0.3944071682125345, 0.7469362380175169, -2.0672251458615305, 0.9620665379456652, 0.577263031839469, 0.10061166205739513},
    {-1.6816591385845459, 1.365116212465667, 1.2639784650056625, -0.1826605444509341, -1.185748228006813, 0.005264897160308121, 1.1216078588131264, -0.5916797302498419, 0.4662468745745037, -1.2672389662050947, 1.2424733536447254, 1.8042511822075251, -2.5669392603059373, -0.33460137252845795, -1.3432789480686869, -0.695676866851467},
    {-3.171735930859312, 2.2776368668519744, 2.5326393316598823, 0.820972835574988, -2.493414488510912, -0.9334472550708397, 1.0976037114580308, -0.8628578653167339, 0.2261674512880222, 0.44996317445032347, -0.259048817641552, 0.9619410006968758, -3.345568251050672, 0.24876632997103856, -0.9817331151352221, -0.7658148724978382},
    {-3.22522860533356, 2.043271582732007, 0.3942629773865923, -1.68958993763951, -1.4386684334565012, 0.5296879626531131, 0.8842773989508268, -0.37147556940688625, 1.16638110469871, -1.8786098641889808, -3.1895825946276877, -1.1067306298526287, -2.2169382763777943, -0.33156691693023016, -2.6654707526304438, -0.07640526490315772},
    {-2.670527975666887, 2.04523433437398, 2.4615862156122366, 0.16457594157938618, -3.365033595189702, -2.385111514339143, 1.353617609548881, 1.1314823414822026, 2.1655157126656213, -1.954043344598906, -0.7396488579289102, 0.020702590697312465, -3.9202224494485716, -3.058023183845688, 1.4160959571821006, -0.7059045566635019},
    {-2.7173055177320675, 0.9043587853173579, 1.7918611151857544, -1.1197347810682654, -0.8542875626425162, -0.46549219838998285, 2.7461449007164203, -1.1212572403666432, 2.343820584579145, -2.132563354454446, -2.266903122225353, 1.8935564446273296, -1.5419044974615526, -1.1911530368995, 0.20232293570001977, -0.08587604327299965},
    {-2.5003122897712675, 3.6533119688515168, 2.403680964199957, -0.07966102494754783, -0.09232921671090076, 0.02852196886628811, 3.04835570611867, -0.7587349969208138, 0.54175763085757, -0.8113072031812576, 0.8882186778785951, -1.1682119541147835, -2.1360978298857183, -2.073131750327151, 1.1051483076301722, 0.8390652221817465},
    {-2.0341967254161792, 2.8685127586437087, -0.7128814135247202, -0.4146672114241577, -0.22368486850738148, 0.09799274960178474, 0.8844296859862066, -1.9060012580578691, 1.9236195458479133, 0.10840154361081168, -1.2277658652528163, 2.1181394546414736, -3.017781010048334, 0.7699962410823883, 1.4453477221118638, -2.8361858620535965},
    {-2.5506977815141827, 2.68861225201049, 2.598790162022354, 1.2646893068061893, -1.0944756647759581, 1.2794817396130749, 0.5298524609934443, -2.1742457077255177, 2.3761470602746444, -0.2474080365416664, 0.14843443894362304, -1.184638286299688, -2.475931016132926, 1.3273852799426042, 1.810690294299029, -0.4936851540112861},
    {-1.653507765122173, 3.5875203173958408, 1.5313674608538534, 0.8063063665042018, -1.0515795872624418, 1.2755837275488286, 2.011435616192043, -0.9774634442561301, 0.03401429161162465, 1.8582491696164527, -0.05397930221184119, -0.1559818005377151, -1.0375652105250786, 0.3553604903523353, 1.705339561169685, -0.9914929813079607},
    {-3.8534940777656206, 1.4301823755220806, 1.2625613854903295, -0.660610503688425, -1.854689658732949, 0.957461247810315, 1.1995928166431569, -0.7451710862735079, 2.9856592181295993, -1.501345827493483, -1.9747644354297027, 0.06547620518697969, -2.497294129470634, 0.5757171435547861, 1.418069938116019, -0.745902199749958},
    {-2.2111015469750224, 0.9504217300568436, 1.3645947130069813, 0.11784710225443301, 1.5661146269970754, -0.8170927897356736, 1.3557269635579385, -0.05297701122298575, 2.9381059124798043, -1.544225523294812, -0.502623463210201, 0.291575155738707, -1.96435148591315, -1.0453666551168928, -0.40945188293436907, -0.6299663421888765},
    {-3.8581571526808482, 2.178290266342278, 0.7594847158765095, -0.19279880445450417, 1.0167021254444815, 0.015483282779407739, 1.6594165830290608, -1.246586589315341, 2.861299077789569, -1.5032524396935598, -0.5985594475412622, 0.5011104237720715, -2.526747124967349, -0.21534319251707906, 0.44604358559452706, -1.3157701542866038},
    {-4.466205299021442, 1.937970265419316, 1.2995544696177748, -1.6582999287475664, -0.3218212238666882, -0.9970616615049493, 1.2769905101435277, -0.27751350221587806, 1.442045595351093, -2.64315046386229, -2.015062366635067, 0.6239411570554834, -3.580641174930461, -0.18779076031209718, 2.0769305175005717, -0.8804134305938967},
    {-4.309737439321937, 1.3396654241635648, 2.0611664420926923, -1.2478350209419407, -3.1524011271789414, -0.7159940155447476, 1.417456774253865, 1.2201185556364562, 0.5243100682374101, -3.4437882480530577, -1.9818650656054129, -0.7955124158459799, -4.091593229806212, -2.1802045801665195, 1.1426348481363504, -1.950340386031959},
    {-4.104834835297213, 2.225067786667172, 0.6450628086065523, -2.207233616256718, -1.0939043988996533, -0.8381396714580732, 1.8174879859346957, -0.7741390848552364, 2.2420851107546866, -2.4506825420330443, -0.1006327812800727, -0.7364566075393413, -3.2019948834907366, -2.132920518039447, 0.04599212911527006, -2.1683850842495525},
    {-2.4583581490925486, 2.8698126766165837, 2.852221766980729, -0.9490800764507327, -1.639049399258733, -0.4539591122178665, 2.121224602223876, 0.22504712964579449, 1.4726663475582904, -1.9049375321418147, -0.4375806900680448, -0.22885659355538077, -3.4983855885217885, -0.4214868891141033, 0.6026193691300575, -1.402889120903834},
    {-2.492041959018149, 1.3539249426731432, 2.8368024544157477, 0.7709692951865211, -2.3499635844692595, -0.7781707002547835, 0.9145437087703346, -0.763903470830687, -0.12517083693862743, -2.0434267501813657, -3.1119642429687375, 0.7165168733879698, -2.0150573273737087, -0.6138647671107681, 0.6016813700488748, -1.1272751777920291},
    {1.5919920039961548, 2.170524979792037, 2.595276172546144, 0.01412001657257463, -0.46431749260697713, -0.07795708811276, 2.0910315461698414, 0.37409134505152897, 2.3587302442678038, 0.7170146693641529, 1.2781110804405416, 3.642325022360176, 0.19848072758235666, -0.3374168811384414, 2.1605902939769583, -2.577845791047463},
    {-3.4958032540529698, -2.8171099071203827, 0.32443026079919646, -1.802141842681846, 2.1197006255762236, -1.9642499498509811, 0.2481597747391355, 3.242933023171897, 2.0223276576956106, -2.282968712206814, -0.10461023244453017, 0.0016768610620784758, -3.375719405432977, -0.36767575765177835, -2.4619454043020896, -2.159298843460408},
    {-0.7966737187650424, -2.338142574716115, -0.057804100139622575, -1.687647630739758, 0.92101569349125, -1.4736740948874683, -1.5105508520526802, 2.1978997655071164, 2.1458564013727375, -1.8334949774474631, 2.0295428756410177, 0.0034394918368760917, -0.6569604428040867, -2.7079698422636587, 0.9695092263644334, -0.9991864727157387},
    {-0.8370240497221537, -1.6006539630838457, -0.02507106343907972, -2.1732897375144407, -2.0500031850076597, -1.731081649380835, -0.8080180803292654, 1.953749096753829, 1.923151388109814, -0.5657728212875178, 0.9465848705051894, 0.3563964758996558, -1.2775930841922452, -2.6553214558081346, 1.0155481155226913, -1.0578272499098824},
    {-2.092969800781648, -3.208053980961026, -1.8848281393162385, -1.4956796568371333, 0.8882529864495239, -1.502772601948743, -1.2677167012340012, -1.9698446102945055, 0.48138966335685857, -2.972206635388214, -0.38432196498191895, -0.632233877068154, -1.8838930364960444, -1.0653010813491715, -3.2528497520669486, -1.7944498488341925},
    {-1.6102414891203976, -3.5268638717890775, -1.2843673028668106, 0.49672739256842585, -0.7565904353591293, -1.43171507681425, -0.6576569219243186, -1.3035363803185112, 1.5576109257623558, -1.2121191556197286, -1.4142049040635203, 0.07293903848425967, -2.7193792240474224, -2.0094994772340127, -1.50044648566329, -1.6373271238801927},
    {-0.34928798148508866, -1.7284812670071976, -0.15789224139257924, -0.28972251504120805, 0.644049029525541, -1.1527969939735427, -0.9426214655053414, -0.4441389896047107, 1.7757060345961906, -1.853325946451738, 1.6121934649415197, 0.25258956658723186, 0.43528469357246236, -0.24399443291238349, -0.24990744202718113, -0.001900225612897095},
    {1.1541685301623759, -1.496435355921118, -1.737600181545414, -0.578216887857247, -0.14930340820147953, -1.286839196277209, -1.4709613632631455, -1.4855966225441624, 1.8159988793675188, 0.400324393651426, 0.2038885079492069, 0.4699805499117174, -1.2861301163311019, -0.04862147371976577, -0.43397357373151024, -0.46333917575603895},
    {-2.3318495858651893, -1.6306478937302984, -1.3725256358452533, -2.2523857082542955, 1.150177772068981, -1.0876088978285496, -2.8085587995115846, -0.6205976421913189, 3.2263454577388857, -2.490602007896588, 1.5569269612880214, 1.1569167729413292, -1.699986266306149, -0.3052941208810186, 0.11500790189950061, -0.45415105552870194},
    {-0.9717831162067424, -3.6918030315296, -2.2745526433961767, -2.09849754525979, -0.9356204809298004, -2.438042538339405, -0.6527764053250301, 0.8705710017677477, 1.0846655702544112, -2.438858418095139, 0.5553868516451959, -0.6258844311263895, -0.6682169903877944, -1.1275407714950492, -1.0875070422007214, -1.85214821730644},
    {-1.3109407532830983, -2.54476501027514, -0.7682350873156794, -1.1633470270866624, 0.0478359923324069, -1.6262006926547845, -1.4139009193228367, -0.06163031246580097, 3.9688220859287644, -1.108391161160367, 0.06127482343292153, 0.24485003465205613, -2.436241679930447, 1.7450513131172947, -0.49828949656087534, -2.038309514330916},
    {-1.2240980212948542, -2.6434197669542168, -1.9547286706479068, -2.3291748973999566, 0.13321035718414256, -1.9320748320138281, -1.0831792304308576, -1.137463973098544, 0.004803402555654799, -3.3748704357343966, 0.5662834477075886, 0.418370624828035, -1.44033993478509, -0.14869442006303307, -2.5117039775269343, -4.298711187521879},
    {-0.11210211019144466, -1.4510036280922451, -0.0031719420603692947, -1.811165630655209, -1.0481269485512295, -1.4428715624089103, -0.3775756207362602, -1.26284184090239, 2.96283247333563, -0.9462541350880941, 0.019369711850665022, 2.3028204288341634, -1.884521421071647, -1.1787535793261827, -0.1340710954562625, -3.349124798753573},
    {0.05993104395418822, -2.7734499068342076, -2.2615148377581304, -1.789684526004414, 0.8080947553162867, -1.648936559580625, -1.685906941061312, -0.35254296665210794, -0.30899888002049086, -2.5648096764746784, 0.688030742378647, -0.8712759321090526, -0.6377031006816053, -0.8346995148008275, -2.836030771451353, -1.7809434962139776},
    {-0.6755113174491856, -3.6798108664207607, -1.6535171118673708, -3.1884157514011218, -1.2906507298837142, -3.500843053000191, -1.5989623604340686, 2.9110366984902325, 1.0347419252901466, -3.251246809019715, -1.259976536046439, -1.3345769995224337, -2.2542583004813457, -2.2528761473883883, -2.3415430426241084, -2.898405127794035},
    {0.06685381819670182, -0.8942162451867877, -0.8020001954008303, -2.5276165289146904, -0.8240438884190955, -3.137155921093655, -0.5264455082670226, 2.6240398089796524, 1.3012682460958103, -3.632815946950835, 0.29961625418309074, 0.3640734662389087, -0.7005413515444814, -2.7890171015645553, -0.665015739660602, -3.0955409557206157},
    {-1.557731015630141, 2.034457826477159, 0.2410699715275491, -2.189522460056096, -1.2917233897527698, -1.2288404427921442, -0.11939876372913552, 0.6913164225736743, -1.680704155567787, -1.3485689815436765, 1.452184566538934, -0.9338420696604649, -0.5956936075174878, -2.639979714764108, 1.3148288479560306, -3.339809424604192},
    {-1.7109605970183985, -2.0904109523954704, -0.3183456064159668, -2.6582449714443683, -2.002505427660147, -4.226267337999978, -1.4968881911148724, -1.0901833082994425, 0.47150042968670136, -3.822587397255222, -0.04923661763045, 0.12642761783652778, -1.4602767713325695, -3.0065624802872217, -2.0156154078908006, -1.6505555052112775},
    {-1.3182848703427195, -1.0905313603008875, -2.073099553345401, -3.6590887802476133, -1.9617250072146344, -2.6022677704093007, -0.36481482740765436, 1.540768815842081, 0.8678450050312684, -2.1259645835965526, 0.35901305001467815, 0.9050447754342829, -1.7649988939343657, -3.473409063084496, -0.9095886366411908, -2.288215353901841},
    {0.5656792093535284, -2.9046624172383773, -1.8114829115892277, -2.8589997056909318, 0.5521601769139022, -1.7440806504242519, -2.485830486405984, 0.6129535323951716, -0.785296374549624, -2.471460396201016, 0.3041901393254294, 0.7436698504066891, -2.160344675308398, -2.2469867646267536, -0.02962766462914229, -2.2857093785209366},
    {-2.1275313181710342, -0.2539005045725275, -2.4319978488848952, -4.1595052633203915, -1.7239950286110015, -2.794922258323612, -1.2246166299270822, 0.15634221345823318, 3.3122114130120424, -2.471206215900093, 1.0526988300831333, -0.5846653965995144, 0.6670216059876649, -1.5418956549817613, -1.63536712561852, -4.670290218059706},
    {-3.289771770972299, -2.57050991513385, -1.7728678843974803, -5.507714089824891, -3.0095647175275455, -3.7841562255879606, -0.9601128849364783, 3.573335822476049, -0.20429649209060183, -2.209536114000198, 0.20225426140919664, 0.9361785963094068, -1.5508876197949035, -3.0214209103001233, -0.9336569190460572, -4.957076316343896},
    {-0.5775002063686233, 0.5068406524946546, 0.32416785054211134, -4.000826523426332, -3.5744709682030145, -3.4621644557880615, -0.09556953790667097, 2.892532772988411, 1.548718874893271, -1.6416525293245057, -0.4442810101582417, 2.595685290047045, -1.870475767560556, -3.481008452549799, -2.610972921984425, -5.72956588168059},
    {-1.717266434056671, -0.7312962973351138, -1.436411246314178, -4.3063361061851655, -1.824472994415098, -4.96279314711177, 0.6240742313988366, 3.674290065245137, -0.30539087642468876, -2.6382471290034917, 1.0823935183766977, 2.6659469095960833, 0.5768617189774424, -5.292457004722631, -1.1242193563522118, -3.957790431389963},
    {-1.802458380663745, -1.3225386238145307, -1.0481596743042187, -3.931254508268157, -1.1811055558570613, -1.9356003480245356, -0.14635867510761938, 1.1716951563211515, -0.3097733261711571, -1.9821722024767994, -1.460299831776068, 0.9853395142685423, -1.32477718224205, -2.2358396761502877, -2.189195076287934, -4.0353457799149846},
    {-2.3793283939597916, -1.9835194255674484, -0.6772453795002457, -2.76730684675872, -2.4820218658096227, -1.5805426620358305, 2.0533031209671186, 0.5268061927725222, -0.3172127571121288, -3.610338567809781, 0.2177867733033384, 1.7811062691682291, 0.17189011324496495, -5.408775494914988, -0.12670673788340683, -7.942789827369006},
    {0.3701282148107988, -0.6520915239222801, 0.3417193754155218, -3.8064040808941035, -3.1098682556506954, -2.973473276104863, 1.953690333836176, 3.8795808421972637, -1.4778438718983025, -2.800205734702874, -0.20891660615973712, 5.050841807673842, 0.8206316502768284, -3.3977031882336317, -0.6738260387043545, -3.4369069935731376},
    {-1.7733069500497705, -1.1197122168375837, 0.31032539687795824, -4.980650308087278, -3.321941969838606, -4.370092135148544, 0.27732285793192435, 2.2588631337543563, 0.9593656451643329, -3.985551831190659, -0.5879134010498975, 1.2043434432905, 0.8300943484211512, -3.698044778389296, -0.32616381315543613, -4.304292134317468},
    {0.8911272662233471, -2.3726223357425553, -0.8043348260403652, -4.6228607230560534, -1.6645840082427164, -5.060976219766109, 1.4288062704174262, 4.689932423976571, -0.9769853770876291, -3.1668378051242008, 0.8624074922884972, 2.492050926027142, -2.650839130934467, -4.553919039005413, -3.5371490743113734, -5.671347026117246},
    {-0.8978694159752559, -0.6692154878915706, -1.0009080895581692, -4.450778485355232, -3.227266003062815, -4.69676447634932, -0.2671241602348815, 0.921545165086334, -2.9518807610136633, -1.3703308636809843, -1.0056326575155028, 2.650020337771091, 0.1251056516155845, -4.4522549881611795, -3.3705325892919493, -5.828293087173838}
};

static const float b1[16] = {6.811420742806104, 6.302044045909328, 5.419577086805035, 6.437019445400508, 6.4384705444890855, 6.112014382652477, 5.685940331984361, 6.153471133317301, 5.41493930683058, 6.712720531860932, 3.4359140211296726, 7.027707541959355, 6.422286246385144, 5.472772303245778, 5.502020179950091, 6.888633874251872};

static const float w2[16][12] = {
    {-2.4045075243894707, -3.1921055624042007, -4.119313414363697, -3.091088247109568, -4.057450604165723, -4.357841627763666, -3.1223271606736467, -4.515554335590029, -3.976646944757772, -4.02688424781681, -3.43576545015412, -4.210603356578841},
    {-3.9099322580148934, -4.222454550269903, -2.816084668344578, -3.3485583499196454, -3.4213219036771156, -3.6560532289451166, -2.2527102646057515, -4.107005746749105, -3.049467118148116, -3.9887809797980105, -3.5947939677366185, -4.230273754478301},
    {-3.256882983731534, -2.4781310346218355, -4.463103020890655, -3.746774106694986, -1.406912977511999, -1.229062230420115, -4.5529072329187015, -2.7322791403820608, -5.17507458864331, -3.1251985269805265, -4.552574853459699, -2.221067022489454},
    {-3.4683166423145413, -4.126675606897741, -1.1479265352300192, -3.4801619558756003, -5.185748340730769, -5.007487482345649, -4.697776080200884, -3.1996071751947954, -3.1823863716783527, -2.865490474785305, -4.3050380073348355, -5.417821868054561},
    {-3.2032223795817525, -3.06882458819103, -2.877541639876871, -3.663143646101889, -3.2589329913236322, -2.6578001340222985, -2.7358138963819707, -2.2245906975002447, -3.662803659874102, -3.7426211921147012, -3.5490422826865236, -2.707886897734622},
    {-4.563312754835621, -2.4025509623142023, -4.984314175315589, -3.054331906110765, -2.9080723658391934, -2.9288409458717055, -2.7572939375055854, -2.325060029593113, -5.303453451512254, -2.249694915850715, -2.56492672555506, -2.8122398969788693},
    {-2.6671753408772894, -4.1074251090246, -3.3316318128543703, -2.76102085754726, -6.057225289315455, -6.403339005606335, -4.340757499484494, -4.118047353011249, -2.8696252019661013, -4.420748554425296, -2.7558317007926125, -3.622760291037544},
    {-3.4479208715844565, -2.63246871908384, -2.612330033257014, -2.9534257358081977, -4.231054299581157, -2.9060967619441507, -2.476732179755658, -3.5186169365501954, -1.3704184987320625, -2.484364029687314, -3.3361861592106092, -2.8088768658972523},
    {-2.3327442235414573, -1.9410715137955974, -1.9216781543328068, -1.9235994333934303, -4.231391402059626, -1.8030778255008684, -1.9926854664329037, -2.584568671457451, -2.3084062553427596, -1.380581246980484, -1.909233077469391, -1.4554260360388762},
    {-2.2689936279981047, -2.7763172904306885, -3.51522513479069, -4.502176668911498, -3.88253911410841, -2.3299381045959695, -3.7774574191452053, -3.8444956638306578, -3.5434424241870355, -3.7946438344330624, -3.7997062123465333, -3.5425421111922764},
    {-2.1835667581503517, -0.7645297647308774, -1.9024938196374692, -1.704385106861901, -1.9212837822014615, -2.1972310411678975, -3.5358713974865323, -1.195474507807495, -1.3558953671054772, -1.9808432090917178, -0.8458672604869065, -3.4140568751812714},
    {-4.446938731223004, -2.605148086640964, -3.8700799333628266, -4.839319166898176, -2.502556987347209, -2.6288729575393295, -3.400451692601403, -2.743944291366611, -3.6310479462481697, -3.2731262570587396, -2.9358800155481624, -4.476596427503109},
    {-4.915848136317157, -4.577660977697221, -3.22803546073916, -3.046352127372764, -2.8351509634049568, -3.0023312516686502, -3.793291442857542, -3.291732795956364, -3.6225172276635633, -3.015644769805798, -3.543004133497623, -2.050292874068495},
    {-3.9376989053646443, -4.54031415544642, -3.5746440189914783, -2.6316412188210045, -2.7339779940254827, -3.7768235743977905, -3.1876017716363623, -4.522785953560209, -1.7071273394436843, -3.051410169255122, -4.011123407233507, -1.4705367429151384},
    {-2.862083618638299, -3.572621376163286, -3.508574421825735, -3.031240288793611, -2.902028560007559, -2.6987654398889362, -3.677809003284639, -3.462151089388793, -2.3715825145570575, -3.8222963930485117, -3.0630317132877605, -3.2975493175643225},
    {-3.4327048493268126, -4.145012744045395, -3.7735000933605995, -4.065722098111191, -2.5618196964660953, -4.135653075398471, -2.785034467539635, -3.6347751344867514, -3.591297344101561, -3.6225642583099558, -3.1211110234819186, -3.9656205718418533}
};

static const float b2[12] = {-4.121348571290894, -4.254052388806409, -3.1581964342737825, -3.4862953566304036, -4.112856908445877, -3.0529018401040533, -3.3761985139049826, -3.809227378445896, -3.2813742301099738, -4.098931207809663, -3.397067924997996, -3.410158111912116};

    // Input Layer 
    float z1[16];
    for (int i = 0; i < 16; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Output Layer
    float z2[12];
    for (int k = 0; k < 12; k++)
    {
        z2[k] = b2[k];
        for (int j = 0; j < 16; j++)
        {
            z2[k] += z1[j] * w2[j][k];
        }
    }
    softmax(z2, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
