#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][64] = {
    {0.5422161342418336, 0.07192292306185963, 0.3840534418338628, -0.23900173177001727, 0.48377535662888727, -0.36310631463032883, -0.17712909729809817, 0.12207042270966169, -0.03255432957184086, -0.22409469588273134, 0.05899334133192123, 0.1628521151769629, -0.32374421131780684, 0.48698695539315096, -0.3826043026137667, 0.6482855168655793, 0.4515015968912067, -0.07204293358761045, 0.4162690814298537, -0.23876905604915508, 0.2237519095162978, -0.020434340843987518, -0.21933055750011082, -0.2959528875676539, 0.19629487558125894, -0.21154786665315198, 0.16281033796825523, -0.24211833085027193, -0.024374898249316282, 0.06756343293743049, -0.0021005444110700077, -0.30228526969231634, 0.3383232194429752, 0.11784908844337252, -0.01477205772160789, 0.11159047750379386, 0.5177221077379125, -0.09924191280343847, 0.3805776009007625, -0.27803312228078536, -0.2878540109399128, -0.35346154275869784, 0.08575989244676864, -0.35349026851680665, -0.09701379159228668, 0.06606407875099964, -0.00038229085961475413, -0.45463512510162324, 0.21452415790958093, 0.3612681603804076, -0.5301772556079111, -0.05450160608596555, -0.20788738357086833, -0.2617420245945827, -0.7053045041770077, -0.33159066808165955, 0.2109166136704719, 0.4318046448369533, -0.4631167597384477, -0.5455367932086234, -0.16334932231290333, 0.5905646383757588, 0.662881882581499, 0.02520255433979263},
    {-0.674027130621221, -0.188439393689428, 0.2700291145602472, -0.6534219408981099, 0.5605794459978122, -0.44164135596188936, -0.28958072542723706, -0.492054689978542, -0.19561000282545687, -0.13357499273203427, -0.5026501824196999, -0.6690034540251003, -0.3641935322662754, -0.179023793334763, -0.5464786762066763, 0.2779864132883733, 0.7486818341017394, -0.2682829905317962, 0.18519093500816405, -0.595530060308444, -0.3934023756585858, -0.2978267869399109, -0.5461379192000121, -0.13312139718612273, 0.6784899854531558, -0.527486332048896, -0.4491934582918603, 0.055246484820097405, -0.5963846421321358, 0.32652056963416326, -0.5596734330449601, -0.5362232226573466, 0.2846223275407166, -0.0691444004867121, -0.23598940284231396, -0.31240318948933604, 0.32343491024678933, -0.6818233339602895, -0.2714696933582194, -0.6017958779189397, -0.4767230363314128, -0.13230432108325482, -0.6033713000107261, -0.30784632489013336, -0.1502394706651243, 0.46120698718634245, 0.5068038753619548, -0.4798131807620257, -0.5311021327479682, 0.4989610418551095, -0.38055158954253576, -0.87606891018336, -0.5100113767371048, -0.42032258118481247, -0.23629681397618657, -0.5520335476684515, -0.07976736448452962, 0.36346900655042824, -0.43813050023173705, -0.5663311212534061, -0.12422715782061294, 0.18285734802434958, 0.48016388456703296, -0.3568291090368711},
    {-0.25304402564896994, -0.36691643782336525, 0.6083834702059023, -0.6084202109063097, 0.5933600508770277, -0.38827183139473476, -0.2440212118097233, -0.10116157082579912, -0.7575626426174136, -0.5137615799124671, -0.3249853222977955, -0.4733509821619866, -0.46792655613876, 0.3047156444939943, -0.5142382703338169, 0.4794082712039374, 0.7879802833112871, -0.3163421262438577, 0.6858187665030193, -0.7099255192964798, -0.33891656366088635, 0.03931266035695051, -0.6360939368693931, 0.05066362455474151, 0.7457855236128555, -0.5605170696799286, -0.46996917842867014, -0.17710066990527137, -0.2697437675622733, 0.4547438084584314, -0.5330816464655757, -0.820766203903133, 0.43559871200970524, 0.5012958703764275, -0.5258247223236331, 0.20361124079060586, 0.7902097625769797, -0.5153218431465226, 0.026419450559671584, -0.850317579017924, -0.48739647998768537, -0.4093600310133308, -0.5906171676806484, -0.3151766431885695, 0.3647018442627091, 0.5997840052087386, 0.5349587797141226, -0.11877806045196956, -0.2565778732575907, 0.5946724701934777, -0.13440705126407768, -0.6155012924851949, -0.21417216841171086, -0.2834365913853897, -0.4636653278183992, -0.5520553092008562, -0.141687538463479, 0.7233635616069993, -0.19488385996936824, -0.6107650129037699, -0.5146566591547267, 0.4585357111713963, 0.9070432096969446, -0.5155159863184642},
    {-0.033910921580400336, -0.7317693688182544, 0.73208473433622, -0.6702957305465482, 0.7266692074805466, -0.31470303356894735, -0.03534187956148481, -0.491177090643371, -0.5362499919548713, -0.45564153749613245, -0.7208382887925627, -0.6074320083418263, -0.3084855393146233, 0.36583302013287355, -0.4276238334676079, 0.5789568526821354, 0.8001837221402952, -0.588113452648086, 0.284989019834272, -0.6406906215983539, -0.402198717095421, -0.25763054761821214, -0.7021048633098017, 0.11501226650124147, 0.7750092136250836, -0.41508949506719084, -0.6225988517763399, -0.5724244203605152, -0.49180584147808876, 0.4364102081138277, -0.7611516730508864, -0.342322971828389, 0.5637585357852923, 0.4159412851454478, -0.39377455043188525, 0.4157713674985608, 0.875323066675265, -0.46562963803805374, -0.18766773623772748, -0.7749945471201272, -0.7171839497524712, -0.6571629577918217, -0.6070550567532009, -0.4000512541845005, 0.38176138994978615, 0.5624341085557096, 0.567196736766672, -0.4398499936511016, -0.5665176245922305, 0.6589735516017383, -0.4333628690826353, -0.8276245199342247, -0.6129046382920939, -0.37481926973237867, -0.4819808812913781, -0.5328107820757081, -0.21138996179257888, 0.7639712236021127, -0.2580200579887653, -0.5965652666799832, -0.6454352116714411, 0.1665294696290061, 0.6150331367673849, -0.7335471711816111},
    {-0.02946330437161265, -0.8479321204842918, 0.32357127806081354, -0.7304956698766621, 0.45044974253288617, -0.29945343619827114, 0.012145976454252192, -0.4568111196383239, -0.8610325436727675, -0.5112026219648472, -0.6459622053110159, -0.4935466712520548, -0.645082865023556, 0.2049302014206984, -0.7444253278621644, 0.3717708119737333, 0.8052486361482987, -0.5619560174807167, 0.21047276108551483, -0.4822465589017774, -0.5825627811085393, -0.1425242232876247, -0.7194615924344667, 0.11788211616875226, 0.6576441934565899, -0.5328974445124272, -0.4179924820120652, -0.5626084493706618, -0.8665267818345349, 0.25009001715934986, -0.7560506615611273, -0.6095490087289674, 0.6082962417096749, 0.5354505115629385, -0.8520068963147663, 0.12023161925108201, 0.7551915438862463, -0.6094770437343447, -0.2852495180715255, -0.8019256314896741, -0.4285220442571699, -0.6573658893867224, -0.7895674950488971, -0.3894249342418949, 0.21526877608175102, 0.3064096468517012, 0.431967354850289, -0.5850512322391741, -0.430516740034492, 0.5596417374560408, -0.47436519186257453, -0.5992447405568138, -0.5151960684166869, -0.4512585621287441, -0.6977395629856225, -0.7482159048518536, -0.3749684107249425, 0.4317284153982515, -0.37333307627685003, -0.7657888662363207, -0.48253617068092075, -0.0026300704385903598, 0.7695575510009447, -0.7158868213258024},
    {0.23175223334483133, -0.49768006853131813, 0.2789559977793551, -0.60902615904036, 0.27992225136231924, -0.4688784403732261, 0.029002344770679242, -0.4300331716928797, -0.42561208915938115, -0.5644894911029755, -0.6577641671968063, -0.5017562764910852, -0.4126864754855334, 0.3635371750593858, -0.7328622891698451, 0.6652006169146323, 0.21472580786808923, -0.6539449170950987, -0.032424314090769166, -0.4081995764250506, -0.5574515358583619, -0.20111648507542793, -0.8439374962864763, 0.06682784764094964, 0.5451245842844983, -0.36213199674288504, -0.22222155070374236, -0.3810108803474002, -1.030667086634827, -0.028180159768920923, -0.5049769532294158, -0.2589605634459005, 0.6657743875998716, 0.5452063518265418, -0.43317860691553056, 0.2035060316900423, 0.2171982233316431, -0.6144871857954007, -0.4079916704574644, -0.6816570191716306, -0.4920583998468697, -0.671706130531601, -0.4155318419050418, -0.40564662991779077, -0.03275629714004059, -0.1250029653416076, 0.2763210302396022, -0.3792005000800158, -0.6603171399140437, 0.4358346582248431, -0.4637112037273463, -0.8831747373934732, -0.4884520856165009, -0.7024804699162902, -0.97092420204618, -0.7230446634248311, -0.47929572273941, 0.5551448624848626, -0.6649925051224096, -0.7400165562641807, -0.8095804887660559, -0.07258659439518363, 0.6645631536489671, -0.7098262159881501},
    {-0.20165395574304795, -0.3983954972604832, 0.5674952205040688, -0.6172905981889859, 0.0726562092398956, -0.5507604575917496, -0.2582789010098373, -0.49148970293850924, -0.43379294735103696, -0.7102631444004028, -0.6844739596081054, -0.341542801237428, -0.41174899097297085, 0.3292484559779826, -0.33666764047293135, 0.2133653870850384, 0.17425880799815435, -0.6338498409081035, -0.1694170381276779, -0.36741669310550046, -0.5409163851035512, -0.33466477498473696, -0.6280948656366482, 0.09412428207016893, 0.1459594949289629, -0.47881587742785225, -0.3776878972657951, -0.36723341547303584, -0.6941490069324531, -0.06644924755125854, -0.6032714433822322, -0.5782743615155371, 0.5898585450622755, 0.19978037607894045, -0.819452553847686, 0.012760803665779077, 0.4120778983989826, -0.5921502517784543, -0.43270539439250555, -0.6470427371653097, -0.5871484498604675, -0.6147097749526651, -0.5507636295251711, -0.4553979618148492, -0.0169636032496579, 0.007965670959169256, 0.04932721858680989, -0.5792130446159633, -0.6540567515611472, -0.04153228305468409, -0.4655045997687961, -0.933133491223864, -0.40412734108246373, -0.630477732883961, -0.48901239296045945, -0.6593351987039999, -0.6472214785242691, 0.43853880415472796, -0.6404637806608403, -0.6066715350586575, -0.5943342404425054, -0.5079646269795385, 0.39091461095861435, -0.5326262523229853},
    {0.11802140468151762, -0.668294905761438, 0.6735025475052467, -0.7107652086498507, 0.458538307908434, -0.4190289479310791, 0.05770781263869338, -0.427289431888905, -0.8145996679067324, -0.5410967567381411, -0.6699960559843894, -0.5155898700163185, -0.35923581906166785, 0.4806515186305561, -0.44513239413185923, 0.45757305953098654, 0.33065219049948624, -0.5953601550320787, 0.050537884619867905, -0.5570001088882167, -0.43492893920304304, -0.3120816282741464, -0.8153883458618726, -0.20356538552704545, 0.03340935745780528, -0.449710058677955, -0.6036073753341399, -0.553217538377503, -0.921728788160755, -0.04353984224439523, -0.587914626439246, -0.5417070079143307, 0.4222300887937065, 0.44893093148869545, -0.8383931874623942, 0.05985055487245652, 0.38264963141270125, -0.5319943545682587, -0.49928682800739455, -0.7594501301973958, -0.7102393337330903, -0.8420817932093035, -0.4512138661673531, -0.6055615583482513, -0.07820600229686832, 0.021522154112238137, 0.2872131209282028, -0.5011029431390388, -0.4912554472089056, 0.24233235579916687, -0.49431285950160275, -0.4621601312677764, -0.49252026195374216, -0.3384845006539882, -0.7783315231050951, -0.562338480159648, -0.6928629396888355, 0.5877710388123822, -0.5342640594311588, -0.48052351181021996, -0.6654427705679532, -0.11157166864046313, 0.34604146793873486, -0.5398944043764893},
    {-0.1490877830833483, -0.5821168159734549, 0.33440159568033967, -0.7995122136214694, 0.6033241496011084, -0.38032085652271497, 0.006315367258706922, -0.46199205345341143, -0.658214004283652, -0.6818379171047653, -0.7452195630825813, -0.5158819243004059, -0.5054502005084663, 0.38391359870497344, -0.6432434537749736, 0.4849192189225075, 0.3236441462930319, -0.5935806983993022, 0.14202129441440256, -0.3491177302226452, -0.5013867818355925, -0.20796625528892432, -0.6214360664738824, 0.16214367130093488, 0.5750643324384703, -0.35244111132296835, -0.3907049672118691, -0.41769914021954735, -0.8682474458240133, -0.21547343015292433, -0.5998609645778792, -0.5319620622893493, 0.22058295729914237, 0.27548637846360274, -0.605778324794658, 0.08218755146114297, 0.38490564427566437, -0.648360209591152, -0.10061278426712737, -0.7374970793085092, -0.87057529517039, -0.6760305254472533, -0.6736752813964906, -0.7502161423952994, 0.16930321832789028, 0.5721977749881267, 0.44899654026601854, -0.388388566790117, -0.3839950078720946, 0.6223104069850249, -0.36805188062124183, -0.6127531397446316, -0.35785116680618245, -0.4331205078355604, -0.8347507689692353, -0.9188072328050283, -0.3684657831010617, 0.43173964507080803, -0.5036799485272646, -0.5373659741643224, -0.3264207516987154, -0.1306340682994186, 0.3360683143297481, -0.7444137427982702},
    {-0.2222578590539973, -0.7344655992322398, 0.5632394453699092, -0.643613981235981, 0.572881356337537, -0.5454000416513919, -0.061925351419976654, -0.5095924788290741, -0.6690037314709707, -0.5401547324914244, -0.6589791436538209, -0.5602580287167949, -0.6547201400958701, 0.3881343146532837, -0.6215945990431826, 0.3120689602049848, 0.5407739697785083, -0.4217017769841669, -0.03228337050988893, -0.6366240088171335, -0.7154936774422899, -0.0832132043012256, -0.6957352133557265, -0.1312935100936971, 0.4266080882393412, -0.7225942315323018, -0.45460529205144257, -0.5559861419447265, -0.7559923710015529, 0.09472686676982373, -0.38404277579482293, -0.7230191877570877, 0.3686324359208627, 0.26885746461910126, -0.6946749535338582, 0.02149300404421761, 0.22080466857601772, -0.47377090531631366, -0.06748648686776054, -0.7032788834511613, -0.5126069916701743, -0.5901231934092912, -0.6749610977035148, -0.4360919194582947, 0.18878813817031712, 0.6021421973133693, 0.45972724089193284, -0.3445032536317079, -0.8463707072679587, 0.389082506391261, -0.4049161589458038, -0.9486464566801609, -0.5559534049301931, -0.5112407220438846, -0.6661705815793358, -0.7087968879181346, -0.37299892078997043, 0.8925595090314443, -0.44856681046250796, -0.7339493832133323, -0.7938093182215951, -0.08557456407407123, 0.6461454242321516, -0.8576783643817403},
    {-0.41542391420536606, -0.45330797009353313, -0.3434277788732076, -0.7254529778073544, 0.5928424369876337, -0.34720100562022205, -0.26846176640252645, -0.5901470785914669, -0.5980758446147003, -0.26226622036545827, -0.5660260614308504, -0.6945885715326802, -0.5724417005552451, -0.11653045907662427, -0.5018995113550336, 0.04325749523120387, 0.482399755279643, -0.5930622272062993, 0.1376116006577633, -0.4248199774314386, -0.7269083568176008, -0.22142553112337435, -0.6909803525569997, 0.16484463797564058, 0.42126960865244745, -0.43843666212559385, -0.4850884909154382, -0.47455609456606834, -0.8498567799255061, 0.012641490507906581, -0.6362034451428082, -0.5177016019625513, 0.1849619803019488, 0.01971819535166097, -0.572615758121321, -0.08221445809521148, 0.2670235675163438, -0.6968243891266038, -0.49220568857514446, -0.417562824939399, -0.8196618848954376, -0.589655217793991, -0.6657003548204653, -0.37014281583589764, 0.1113481929857913, 0.4062504333479154, 0.6674763818904088, -0.47812923415206743, -0.706902557219005, 0.5443721429106148, -0.4277986336838172, -0.6655965830842986, -0.6250249500504208, -0.49564883360108963, -0.6467194844378479, -0.8330647015246546, -0.45632254258937865, 0.19185253009595118, -0.7914196731338711, -0.7387907850028387, -0.5587395705400053, -0.44842476374379425, 0.22316375232014685, -0.6675255331065286},
    {-0.2765356092084772, -0.5749532887191076, -0.1170854781329257, -0.6717759310691525, 0.47057838601185503, -0.22970640477243048, -0.2487366590393157, -0.40799017393507, -0.46452960056966713, -0.5845063297912511, -0.6066422406702671, -0.6812214983567397, -0.5935705768198525, 0.06907600204359347, -0.5425839929091791, 0.36420904925078, 0.6091721982549795, -0.7178997705639198, -0.02506479591646993, -0.5612533831866094, -0.4965897638451923, -0.38472156278921343, -0.40246393097677985, 0.12930135013868133, 0.42106209299699743, -0.49976376184014987, -0.6084430922438033, -0.4975202579527824, -0.6043625119972225, 0.13326393035179554, -0.5068491463727569, -0.5291310494223215, 0.411884304213809, 0.17052498092902982, -0.45401900855654215, 0.005899820349728405, 0.4128411711521633, -0.5898894615046286, -0.15234215284619582, -0.7721467975821231, -0.7276887322076523, -0.4085940408837756, -0.5048301551480049, -0.5715469688831416, 0.1039909307593613, 0.17350290371121704, 0.5071797860318361, -0.4930415053179539, -0.8072473826420622, 0.4251593882516253, -0.3969880610448864, -0.7351075825579695, -0.5738121678487702, -0.43784420574202576, -0.30423580650366483, -0.5779485133161362, -0.5289485028330477, 0.35246706770151, -0.42773952073054355, -0.7677245899009456, -0.6778076529258218, -0.3033405323730365, 0.20815682316355832, -0.6861540562050714},
    {-0.3694615868676078, -0.5604722116816749, 0.31197903860941634, -0.6041788676283071, 0.43449092332922873, -0.3436703272767282, -0.03207872759814125, -0.40685507185354836, -0.5804887028509607, -0.7112201458598048, -0.9489479809501851, -0.5980335174024516, -0.6601799776419004, 0.18842986487993485, -0.685504160439636, 0.33139837735183475, 0.6118673168428155, -0.4523949755507063, 0.1343652806131775, -0.7530705365627223, -0.4680614285339721, -0.11951734013926021, -0.8695328688934046, 0.14313967323877377, 0.668140632119291, -0.5207248755951941, -0.45710126858440764, -0.6974174384698659, -1.0451601835252056, 0.008931710725433568, -0.08766216602795647, -0.5171263023727821, 0.3297686712877449, 0.15640777839479783, -0.6428574079964782, 0.263951458734971, 0.2867584188718365, -0.5022689328518587, -0.45627701062535736, -0.8496905097533743, -0.7694286049216346, -0.4822047301903867, -0.45813967672631756, -0.5643162477305175, 0.48868056674996946, 0.5479771557403451, 0.585702817406707, -0.6006293534566969, -0.6038841504379945, 0.7143471298746075, -0.45396148698321415, -0.8941871269770971, -0.6016622438101159, -0.3489159267676529, -0.5110064802867272, -0.48115986747203565, -0.4037123126544842, 0.5770401118671132, -0.38595241957211474, -0.6436216680929133, -0.7463000740015553, -0.028577562220093257, 0.062227227579820986, -0.42785505225965736},
    {-0.18224824117668095, -0.6746520095905059, 0.23889492803802007, -0.5240869179824079, 0.45662672082451317, -0.6536860298025005, 0.10322230282851938, -0.6111569801067464, -0.74190653054161, -0.41135280781020633, -0.7618293495590125, -0.7102419607128296, -0.6025682360326583, -0.008051173148881213, -0.6355772478053563, 0.15975337988738103, 0.5015144520423583, -0.39686060558202996, 0.23859799294906034, -0.6321966164532423, -0.4847832950026311, -0.39907453571407875, -0.5791922991953244, 0.3309566871215228, 0.6132559522731977, -0.6272519107126526, -0.3060839924387587, -0.5962037657334149, -0.5531211761405032, 0.26804636572723783, -0.5372947612173821, -0.7040135075777755, 0.4299440206425858, 0.2227108818175188, -0.40824806735075553, 0.31262494184198714, 0.45957832520645725, -0.6248966875943359, -0.6033633123955501, -0.8211891190881969, -0.7388723552502073, -0.6672679783356179, -0.5561717486857496, -0.5889990304535098, 0.18647182500744194, 0.519103942572196, 0.8129557218254467, -0.6160604696763037, -0.446275874709231, 0.549403615892059, -0.16769125569267182, -0.8392034141127229, -0.8506177863819369, -0.47570911960609424, -0.7150715493726498, -0.6639017746554003, -0.48848419051664843, 0.3152032751669786, -0.511701507359103, -0.5803447532542073, -0.7346879239950811, -0.13418675240532968, 0.253672871282091, -0.6534034714811396},
    {-0.1253670569788593, -0.6201423186424234, 0.3394352724908368, -0.7948077368773235, 0.5929172477025164, -0.36220414193944805, -0.07790316592826926, -0.2655318003826298, -0.599844644932532, -0.30554052953727273, -0.7770187325574879, -0.5666490382995958, -0.5614421553470683, 0.14782166868589164, -0.5752415877779262, 0.37008805271479706, 0.6032584853385335, -0.7075019983246141, 0.24907340689768914, -0.42600190793444376, -0.6378706941189992, -0.004924015532003312, -0.7171229324824971, 0.29183385330443123, 0.21119965529606974, -0.6428705129992291, -0.6700467657093403, -0.4143927832203764, -0.4691748642452173, 0.1459915816834494, -0.5140616178325491, -0.7860368596450427, 0.163300055032893, 0.14882099574803156, -0.4331249563634051, 0.06117227137621354, 0.3681935692905402, -0.6829765787874094, -0.5450067569415089, -0.5492066067385476, -0.6234725193381626, -0.6576852663042404, -0.738274736562295, -0.6254439222063549, 0.1802063884779208, 0.5270063419731992, 0.49068847814135264, -0.5803155860615948, -0.8078232111918567, 0.4591288068886576, -0.13072575478132792, -0.64587780387362, -0.6440412415184683, -0.402886269208723, -0.46437681730927877, -0.606464282766677, -0.47752718246028536, 0.3688825368056047, -0.3127139697378581, -0.7880209025433677, -0.4852768565420213, -0.000149065175106934, 0.4551786062612829, -0.6783689770084717},
    {-0.10370078142995405, -0.5023028170034817, 0.47080281518806516, -0.6371002369712583, 0.475513183394252, -0.6035995921454056, 0.053152196485358176, -0.3439731609175797, -0.4355206447343894, -0.31583553567849654, -0.6971271881539938, -0.6524455468112598, -0.6038204520693509, 0.1377551039121728, -0.7549052694499215, 0.11069506917095419, 0.6281160939209051, -0.5402913689051938, 0.20688500388073763, -0.4817901322107972, -0.3118650477695394, -0.13638401183717794, -0.6116859429441, 0.11758452889861704, 0.532412439274095, -0.5746978716528673, -0.5541356355300646, -0.48228779554696155, -0.4440880806890904, 0.3734519992886448, -0.5293096693204417, -0.5946981438507466, 0.6878293687591502, 0.34501275653355584, -0.43009708818187337, 0.4140700878130268, 0.4052609493378289, -0.6243917164905307, -0.6187926624810045, -0.6554782946166532, -0.5621899169598195, -0.7166355171092462, -0.5120372435248854, -0.44668374257555454, 0.5960689617207217, 0.33772907223371534, 0.24448214343942895, -0.4796645801208913, -0.6975124224139042, 0.7751817703385396, -0.2953440534309986, -0.7189064392889662, -0.7070604247970915, -0.8289914190781242, -0.5275546226068741, -0.6540255572499541, -0.5744016883679908, 0.5652198869736231, -0.3405287334444625, -0.8352834868706212, -0.638051121677816, -0.24893605006167097, 0.6027534621513871, -0.6186883163256535},
    {-0.2513883642183331, -0.6238983441797472, 0.6064571521028401, -0.638294876662783, 0.854977170084791, -0.2889221998406237, 0.04151534225647511, -0.5338347490682434, -0.3979649995152144, -0.42949712907549964, -0.617240376862357, -0.6035708776258367, -0.6033978256042336, 0.6755758857562237, -0.4429536703732881, 0.6376694973669668, 0.647973859370586, -0.3857830135032582, 0.4106770099214783, -0.48280341779811925, -0.3335382162202124, -0.05021533616233064, -0.5670407420803026, 0.1996547812659604, 0.5583711950005399, -0.4910724304979088, -0.4200455434281812, -0.5812034295464434, -0.6095821854717566, 0.5897562113565539, -0.68101825505433, -0.6670900902640416, 0.6156877399745183, 0.6179332130797242, -0.6943611827421399, 0.4960522163631112, 0.8306102063087326, -0.7519947839993242, -0.37662873501391964, -0.8463493676032181, -0.7238205122553846, -0.3674019674201604, -0.5392077432605341, -0.5407540649034818, 0.37170937049069197, 0.5655308332779699, 0.8507517596192358, -0.35792039651949664, -0.48190523996742746, 0.5960586639556398, -0.15108138978610522, -0.676671693912105, -0.4867141474930564, -0.3702419648639019, -0.3592017251030593, -0.5740986143843257, -0.4088724417273851, 0.7977192102406858, -0.5913831648743715, -0.5832026910018877, -0.45223156064213343, 0.446751803064121, 0.6710519804001454, -0.702249085086145},
    {-0.23292293791918411, -0.40885565636328186, 0.5709210760689587, -0.4616299386188805, 0.5037803620429524, -0.28931311819802347, 0.2510445668240051, -0.05620648842907168, -0.7649269919147071, -0.26986490744376956, -0.5053240954806519, -0.48251922761083293, -0.5218605281457286, 0.22972807236041956, -0.3898533228824654, 0.3867940693950449, 0.6435266792894127, -0.30926594114911965, 0.6009731643802587, -0.42956933144055204, -0.23896160342843892, 0.17344088427004184, -0.3773943799159229, 0.1659810678003132, 0.8113123938553966, -0.24679095189961361, -0.2467981157072123, -0.3626347265155184, -0.23802364318448557, 0.40756619307857844, -0.4042755688872471, -0.47722891613474816, 0.4656750646557562, 0.5727086215681361, -0.4722480023803134, 0.6087007921274811, 0.5425948884513608, -0.707442039603911, -0.2289820145040914, -0.6823484691901802, -0.6053925799852934, -0.47352492533652357, -0.5935928783082265, -0.40663222835466567, 0.4961419816633189, 0.4824492211682119, 0.7068284685689424, -0.25967028009822024, -0.5429299144432724, 0.7119501989896236, -0.2612737579665158, -0.5076425200114141, -0.3836132277755661, -0.08606987694716328, -0.24246763539586438, -0.5737381754543379, -0.40426794782545444, 0.34221863990901796, -0.3724274264126538, -0.7391026142849313, -0.45288044614983924, 0.6381715310042129, 0.727577401758705, -0.5968783032839482},
    {-0.2960540962609371, -0.2732876718721038, 0.4947367782022362, -0.7117370965849374, 0.7465596830142817, -0.22157002295602843, 0.1497970169913808, -0.10460974441050641, -0.2846236955183071, -0.3625931891285675, -0.5887846468980954, -0.43311885036413333, -0.3430630952506468, 0.5128166132185727, -0.5254776397026109, 0.4268504791980581, 0.7218604331618216, -0.29875253142778285, 0.5057664584885162, -0.19339298069042274, -0.4465203459274127, -0.07526404737954265, -0.6473531546999075, 0.26814995984048723, 0.799550568413299, -0.5116164430229414, -0.34795917858413605, -0.423944639441003, -0.5620045760354246, 0.4800827253182963, -0.6094774612635698, -0.511858106440334, 0.6116254934124882, 0.40310102853953295, -0.3585974760561252, 0.42623111955754095, 0.9963278354796193, -0.4195121644558791, -0.07480066750149292, -0.5825231037530166, -0.5014841320064161, -0.36404528393862, -0.41204567271212245, -0.59119394836656, 0.4315011484882678, 0.7736020571450608, 0.7338030143174349, -0.44589508876535716, -0.3838765175097765, 0.7231335809741635, -0.38231338619880856, -0.25829994820582425, -0.34162646745350056, -0.16121767534733747, -0.5877365201427917, -0.4463762700159089, -0.3354873736058553, 0.7512452617734198, -0.2533436974336596, -0.7370330977752892, -0.48273720780281815, 0.4066082370987832, 0.5777038597324492, -0.33008753087979303},
    {0.008556231683760313, -0.5747679091136744, 0.48992417832880675, -0.7209707504692353, 0.6174485530381464, -0.38185151118367744, 0.09778669155689473, -0.6130245316449832, -0.5993268722712992, -0.35944313388824767, -0.5326587162946229, -0.7032290509144079, -0.3547091860182786, 0.2589543527184488, -0.6075853549898331, 0.3366221255514855, 0.7077155554298046, -0.46766157105620537, 0.36767099864850467, -0.44240940946093915, -0.6911637024090489, -0.061699987266256875, -0.3551617196858642, 0.08728675740278366, 0.7949414378485262, -0.6774967537116026, -0.10216099067718347, -0.560439971705207, -0.7813449461425249, 0.20446363596396835, -0.14722877018070363, -0.6298489466511294, 0.6148732581069105, 0.38703299116905415, -0.6770493647051737, 0.2488288199035602, 0.6405651309180875, -0.714634514281614, 0.1108363211118599, -0.429510554628293, -0.6824744062820721, -0.4912276027487499, -0.657914605256677, -0.48545147022270185, 0.2672576035421783, 0.6719812549828778, 0.6460873231728365, -0.30191794568207136, -0.19177762913321178, 0.6946560729863959, -0.21212391487560658, -0.6155828927039292, -0.4050388404588374, -0.3185494633168137, -0.4581327488439042, -0.8133619079087203, -0.3894510686832592, 0.6330643157065299, -0.5630528662314519, -0.5685555107231429, -0.6615527324845539, 0.5309706937460634, 0.6776793639593743, -0.8109800224796773},
    {-0.30493259172018905, -0.5538666279469898, 0.640548325043398, -0.8701756939638534, 0.7879249435742893, -0.33945998489514956, 0.24355428258067965, -0.37361461822120734, -0.510072503178874, -0.40059818083921983, -0.7629418870758826, -0.511860500923198, -0.5744613914592912, 0.11856658243732014, -0.5263429665552921, 0.4957423420849082, 0.6555851841560233, -0.4786690753410676, 0.26027554486497106, -0.6538354500717497, -0.17057386096564645, 0.05784194611174502, -0.5222544248910659, 0.33933195644672925, 0.7040395716275551, -0.8039664667585187, -0.6104429293790177, -0.3735427798398621, -0.7334942914679391, 0.3939653843056953, -0.3470584511510199, -0.5880510444597189, 0.7935538171603251, 0.31117280781989604, -0.42976875307158835, 0.3349562176625436, 0.6584659220035801, -0.7912406039979877, -0.35932404155623165, -0.47817507311845175, -0.7799173487064597, -0.43671900082659526, -0.6547784361821819, -0.5201931658927796, 0.5476361225807351, 0.7716458339557224, 0.7675244125294365, -0.46981767673555075, -0.5268738704144379, 0.8449595782553415, -0.24342475218274684, -0.6142901487051945, -0.5204203097744596, -0.5591049591311594, -0.45842960745016637, -0.7288056760369551, -0.7348384328834917, 0.756114116161329, -0.6122985962896679, -0.5697749646164474, -0.6817214773775775, 0.2095194993505137, 0.7697531186303892, -0.6223564429538527},
    {-0.3198214178286648, -0.34218648817270075, 0.4910285893130904, -0.9038159731668655, 0.8486835359817471, -0.25946521421217456, 0.4197003566144586, -0.5450746906081693, -0.47365092071098863, -0.14939010637627065, -0.6385513243192507, -0.5304071576052244, -0.5006774568634431, 0.36265484056124625, -0.5372230182754728, 0.7129005587528079, 0.7299817848324637, -0.40331664961892094, 0.4186773579176173, -0.5272509154364796, -0.40727462484304805, 0.16265059094964388, -0.6859413909460459, 0.28673014028465704, 0.48431321573028857, -0.7977568823684138, -0.5532540950183591, -0.18149648630365342, -0.3092449569268652, 0.45465945814301356, -0.3830980423251604, -0.5705530690812516, 0.5756784059975362, 0.13838387186464463, -0.7460880757846144, 0.7615636530059979, 0.7766355528962837, -0.6759490732918894, -0.11711540020929269, -0.8556170486119694, -0.3803423908075222, -0.5075429858198504, -0.5250896726078155, -0.31857146702793865, 0.6132510429782735, 0.6697573190187446, 0.521240023168776, -0.25332670869884816, -0.5230171317153868, 0.7504187541133946, -0.29246656007444066, -0.4371069053380368, -0.47498386525946845, -0.10062635709784404, -0.2952818816787933, -0.49678961034059127, -0.3599657024069098, 0.684421493497474, -0.5991142261934103, -0.9259056075481648, -0.7376194448137386, 0.48892700569681247, 0.5543353974395037, -0.4876268965618881},
    {-0.17839421308051343, -0.3940254040464405, 0.4734641619685331, -0.5109756699572381, 0.8434959248576309, 0.079086164475507, 0.28066673853790536, -0.16626303081524352, -0.0368949544660161, -0.05595992913915696, -0.5586155533166359, -0.6403236834021423, -0.6059956627800526, 0.6417555097971887, -0.26631856718690233, 0.7967599278743569, 0.8368812851386497, -0.19219260874887975, 0.5017000387764764, -0.4991432591282026, -0.16920156978225465, 0.2902465607749095, -0.2780182908070097, 0.5217845078682223, 0.6452050519351444, -0.4381334592203065, -0.3426069468976778, -0.23308691391742195, -0.25328350586600434, 0.4047050235409793, -0.5064159413667879, -0.5246583229999755, 0.48803293008101634, 0.6467158345774446, -0.22998666375357307, 0.48967717236216873, 0.623805953838362, -0.6219385851216147, -0.1943376853508244, -0.4739448274280837, -0.46559497719452236, -0.2053908851660002, -0.6356047904819481, -0.37985159169696986, 0.4697838962702487, 0.6778106981502467, 0.5375033219467555, -0.11791125047128864, -0.44146233367426146, 0.8951604097253216, -0.37487000180447405, -0.736416753133255, -0.53916597688472, 0.08204054112807412, -0.2798365160015974, -0.47197120533200027, -0.15546675934198223, 0.5720824923302004, -0.46718348587780373, -0.37613088822841595, -0.35424628767665417, 0.5781446374931651, 0.7270754253146471, -0.5988753025481315},
    {-0.33150040688484517, -0.3500836284321052, 0.3866052797377679, -0.6703263970223732, 0.7646535928056173, -0.4209107410204539, 0.08778021720350242, -0.613181796842404, -0.49377495611830174, -0.08723149970482974, -0.5924447076077067, -0.7987423110229555, -0.6869318832185304, 0.4032586317127951, -0.5471011532121647, 0.644100412592552, 0.8127480815073864, -0.4435876500412543, 0.4108560956654083, -0.3867987573144974, -0.5742958143666489, -0.10939221342276367, -0.4031256190929081, 0.5141046636592629, 0.8308478245685483, -0.7397296241704107, -0.5765241814296707, -0.2121272286200511, -0.5736691411023395, 0.4069403846398463, -0.5225599300570881, -0.42998546667935944, 0.5213707548593624, 0.2935475283591554, -0.3778984257110839, 0.581550807350294, 0.6758785597477848, -0.41345970896549333, -0.05729827714724475, -0.46812214691384885, -0.7375120940825982, -0.3535208758755039, -0.33995680331301326, -0.027581073456361644, 0.5028665466994702, 0.34996681056303797, 0.7345465127779535, -0.3429506286164358, -0.5082475487875431, 0.8351160857635915, -0.4108392639086323, -0.5047667337326156, -0.42225007322609776, -0.18011343100252558, -0.27120860443942774, -0.5939906819329952, -0.3940674965512241, 0.611333070007974, -0.5084882604286542, -0.716300593722168, -0.29550375259830225, 0.43299384782358713, 0.6219846994402296, -0.6594459633194332},
    {-0.318450346683134, -0.7545262275310948, 0.3888444525082993, -0.6457922400203544, 0.7452353027270122, -0.4201242782157218, 0.2818339994907075, -0.3890215475946888, -0.3487926592656409, -0.037683455902056046, -0.7903447230997334, -0.5463592026751798, -0.8378591988632955, -0.011947349870044227, -0.3851821133031894, 0.41065175593710995, 0.8109218638342387, -0.21363290701185786, 0.41220668838583624, -0.5782015184175647, -0.4024881864754158, -0.02329776067625062, -0.7199720341034676, 0.2935032208227681, 0.8318819904588453, -0.5442209222743192, -0.3584050223613731, -0.04700700526519091, -0.4785203702185497, 0.430322578737885, -0.4791885112556349, -0.4589903917588519, 0.4999778878200937, 0.18331407282178558, -0.4683327879541665, 0.27924735963674313, 0.6110241132787226, -0.6338163253638069, -0.42228317059416354, -0.7177781837324279, -0.7187674367322308, -0.28393177562988986, -0.7852820756331143, -0.11639184950923814, 0.3284568970805455, 0.6326333194795126, 0.7267872323196309, -0.5402892820549394, -0.6779298613161965, 0.6057493862113547, -0.21937526724480147, -0.5550193272810142, -0.5584292211413835, -0.11579375581137921, -0.2055577113814, -0.579117560775518, -0.6651283765423385, 0.6790175637709922, -0.5350076370213983, -0.7734731558257999, -0.3531559987054569, 0.2726915469035517, 0.6534959105287886, -0.5795337709951232},
    {-0.2714328372855857, -0.39188716917065824, 0.4422089173233066, -0.593961381140986, 0.8264514864100821, -0.33280432471483923, 0.21705401990221326, -0.3378486977852085, -0.33406527418256543, -0.3479252234319083, -0.5205022473589628, -0.8125632171840697, -0.17962034320382014, 0.7525328659336064, -0.7026827404861555, 0.5284721105378349, 0.7271957072059381, -0.348662164868914, 0.32205274285802027, -0.4760911641251216, -0.2091221332451244, -0.044907152368869274, -0.7089369255269734, 0.3688772957822582, 0.8065409550756846, -0.6319996797645602, -0.4758267796636285, -0.1645858962941376, -0.45089116087378006, 0.4607248438281191, -0.40732851243730184, -0.7176529114679542, 0.5997798291597618, 0.3741572825082374, -0.4218651818778448, 0.26026039105646903, 0.3895581114850707, -0.655406845087991, -0.15131588059514361, -0.6977816322446633, -0.5837137220039429, -0.10721822907396412, -0.6111709488602223, -0.20040176032988705, 0.33987030372870125, 0.7396018998358351, 0.7170633574458076, -0.07739942696996223, -0.7518254344451658, 0.6504964596591939, -0.12781678151888837, -0.6507659334276963, -0.4697411828518654, -0.3208617839233764, -0.36999773455931345, -0.4954727403532284, -0.35243235444099946, 0.3908643056669282, -0.4148028332553327, -0.7217341912194727, -0.4229817700488307, 0.479532600078095, 0.5044132112309186, -0.5501329884606965},
    {-0.16281148116704, -0.3279166889808754, 0.5684187710507298, -0.842996262105585, 0.9136391768856145, 0.0028188097764526446, 0.07140837631276804, -0.6532373481130641, -0.46325752119092556, -0.14092402485181307, -0.5692193280810504, -0.6844444102137143, -0.5234211339452471, 0.06264696576626627, -0.5854163316446067, 0.424269824570225, 0.6770255595927455, -0.5434850147380629, 0.6054010923628671, -0.7164695519461821, -0.18967904099803065, 0.08137481462957705, -0.4436569075378406, 0.4783484267636327, 0.44486262043083163, -0.5574438103664159, -0.7934310277272183, -0.47046501999636087, -0.1637885537742525, 0.4609071206569962, -0.4836040503393212, -0.4143679902145128, 0.6927963908658624, 0.31994584017907696, -0.5377254175144559, 0.5006323412756064, 0.73867247607652, -0.6720206262441095, -0.32630489004494617, -0.6296761349581609, -0.7482281904342541, -0.6070419735790183, -0.20788888227003033, -0.5883415594155529, 0.5819117611410568, 0.342101282128144, 0.5516691641191249, -0.4241986854713987, -0.35815160476574, 0.7535145756523772, -0.06474779550137291, -0.5811067141903349, -0.45618708813618364, -0.44722216423609656, -0.23258884655995235, -0.6596141565810089, -0.4283426603994296, 0.645270804435276, -0.43322388968787773, -0.7060076714452174, -0.587077804425331, 0.31421131546274617, 0.5666888621400409, -0.5854085380425591},
    {-0.10652698664799044, -0.6195378704391844, 0.5017979204581942, -0.7258941762652629, 0.9497201147530369, -0.4457895072042162, 0.2392083401253216, -0.4087184816181372, -0.5017627453898805, -0.35068774476223513, -0.7161456670268592, -0.398647117107727, -0.6308623244961956, 0.25457962176186344, -0.5202269399519953, 0.5526652007194263, 0.6750936078654499, -0.22732412469937657, 0.2793562679685551, -0.5071046622776374, -0.3019740207601008, -0.11431282167837671, -0.6035633961126508, 0.31609257919558625, 0.768353358250553, -0.5001087395197157, -0.4997165146245129, -0.3854408980988992, -0.44381620186263626, 0.5733234143960109, -0.5671325859930719, -0.542095162348776, 0.3994618312205909, 0.17417886493058354, -0.2743807785146927, 0.33584800466105036, 0.711198346370428, -0.6089417674810137, -0.27105210408844277, -0.9295086889640495, -0.6135729467354425, -0.33540908604382746, -0.5510137093205828, -0.47163108888246, 0.5699741465482497, 0.7161650633057639, 0.6668140126904333, -0.4089416146308942, -0.5965112521571768, 0.8053986997087881, -0.31472008334872736, -0.6277532068586281, -0.5490698434930077, -0.44332669446142225, -0.4421112077773121, -0.5678271764859072, -0.22779230902952435, 0.5988859376114941, -0.19247306771298037, -0.7600198433498433, -0.4675920468073092, 0.6128230829757783, 0.337966028728557, -0.6294046809467799},
    {-0.4471796754254753, -0.32039147888627717, 0.5289173951858505, -0.6206437942975906, 0.5699372378588258, -0.2140349862215386, -0.04635627214803259, -0.7176813316328546, -0.6367845306363479, -0.42257749804402883, -0.5913952461616506, -0.7243302094870856, -0.6106368192046072, 0.12151828811160757, -0.6480968220810084, 0.3591137679907945, 0.7719526006067837, -0.4664453893867016, 0.32995207979864405, -0.5701520374274469, -0.08990284527269214, 0.031113416952699795, -0.44790675775393374, 0.4776468476450041, 0.6383417914866704, -0.4332562106539012, -0.7650597504177366, -0.5044035096169658, -0.6962177931484564, 0.6206383663914443, -0.40117284204531156, -0.7170476086392359, 0.5385188214851703, 0.15250507132098237, -0.4601436970501813, 0.2139426243446998, 0.6174519281810454, -0.4104435952237766, -0.39163277835634985, -0.7646964623804696, -0.7658842595732884, -0.23206753961429624, -0.5700197942836004, -0.5580653485424101, 0.38604030380765514, 0.6304881959056509, 0.6399128818630216, -0.4174809166765974, -0.530667564333327, 0.6052437843507225, -0.05549407166068315, -0.5913998010096181, -0.7161165375484511, -0.2431674350411578, -0.2799220156848204, -0.6690149495832409, -0.3207815335364219, 0.6493149833780432, -0.5763894683966017, -0.5250463332605598, -0.6411918771823297, 0.37903116817549426, 0.6070622747451975, -0.6913926778201216},
    {-0.5373434563498233, -0.34343832239505917, 0.7407130744245582, -0.5921581961236699, 0.5229029131133017, -0.3077207944958582, 0.13546812279089573, -0.5905584212058858, -0.5773509419330718, -0.043858692677852806, -0.3034432799014007, -0.6703283445703603, -0.3827518427377449, 0.23822028662939218, -0.664144704299464, 0.42940886904978187, 0.6782357603517664, -0.36584945543269043, 0.2497776880206313, -0.526893407432737, -0.2469559000120853, -0.01962136635533704, -0.5205288891701444, 0.454585395942692, 0.6305379878882678, -0.42576656766381005, -0.4728301594553357, -0.25982021766703195, -0.671806745533368, 0.49226318801744134, -0.7509452837099778, -0.6375109234182194, 0.37393502720826144, 0.15176223623939392, -0.5209971151102716, 0.4896141874768044, 0.47890411866146376, -0.8746559095030254, -0.4545793084908077, -0.7167336850369422, -0.825905514475197, -0.24757413964715097, -0.5780092818072462, 0.030096870120193117, 0.46460662433049005, 0.5686934476438248, 0.5445579900573104, -0.2371945731246994, -0.5628438793535439, 0.8635388159908882, -0.2928197271866704, -0.3632550577246543, -0.5270951087076192, 0.1030088300682592, -0.1300420954005759, -0.5981192436091314, -0.25589310186745406, 0.6450270950403304, -0.43822027757444043, -0.7046348537670927, -0.4195790507418997, 0.550566426588455, 0.4292511912451422, -0.6076451102441159},
    {0.03403236210604214, 0.02013685965492546, -0.05201558984557307, -0.02879517642926036, -0.40733095214897724, -0.45642431383380483, -0.20662153213015771, -0.0014653919595435246, -0.3346843243659403, -0.4455363238666866, -0.44472677533871874, 0.14504879631673992, -0.13219585381592203, -0.3567686542284391, -0.07638175507247603, -0.4469327897977888, -0.4388579968046614, 0.16180596426929517, -0.26838388499713245, -0.12471014024008754, -0.03539021350546929, -0.48446640843474276, 0.44025026356252817, -0.41252548746749484, -0.40189098805710793, -0.017614281102051436, 0.04442839037237445, 0.1149140309238399, -0.3704812407203205, -0.6690556412012706, -0.06989647294064724, 0.024578582581925263, 0.24347722507879888, -0.15492036032894355, -0.26400324583035933, -0.4210538479457676, -0.449099999914968, 0.027192390443854433, -0.3023302575718443, -0.1562978332925918, -0.03789949315562158, -0.10812230381071165, 0.02430430436106916, -0.23271740249478962, 0.24734751544480144, -0.5393761723772542, -0.35935279827786026, -0.0838348750340691, -0.22816255013725362, -0.0545286412203144, -0.24639362557955508, -0.13481452169923738, -0.0003339095838307453, -0.13961054166185285, 0.418755098278596, -0.058952027750354886, 0.14440014623926278, -0.2521441227379197, 0.008315117480394344, 0.005463389766041311, -0.1494166435623511, 0.16644948445769933, -0.45215500173971995, -0.4627146278501355},
    {-0.18360916489196913, -0.22652851429784804, 0.17807564337744616, -0.33487334465304486, -0.3405390024824706, -0.2364328941953049, -0.3909823231797121, -0.3510911252391876, -0.31733251833095283, -0.48602791273128826, -0.3292085726761055, -0.17653448338074473, -0.4274884981922525, -0.12204713601452842, -0.2647625071049455, -0.08636545389157693, -0.11653844904732265, -0.06738216994990855, -0.28671961654160416, -0.25972293773569216, -0.48016402808516834, -0.014726143333802835, -0.5041404165072949, -0.500673128304856, -0.26900826451936816, -0.44413204653991883, -0.2799330554975717, -0.2151520486775308, -0.4591453469908695, -0.11390020525189874, -0.35120209022157245, -0.3827452206042136, -0.3019338779146955, -0.562328028666049, -0.5925145165408288, 0.21717913248755724, -0.33901329602637775, -0.577089268959941, -0.18660983517592808, -0.7190754132582292, -0.5954367449115616, -0.6116000924183794, -0.4530356528954566, -0.4501307895530147, -0.32547171013636567, -0.17560690276540716, -0.34267841155982465, -0.46091754884103353, -0.42533412726555353, -0.13992771294961764, -0.3949332459276641, -0.6519704880682752, -0.3437624597650965, -0.522106086501417, -0.4569058882592784, -0.3102691996544578, -0.13202460068211397, 0.24591350725665811, -0.29988626888852565, -0.5771075229255771, -0.3634621991370925, -0.09077370418172391, -0.07991425403788618, -0.28995894022588026},
    {0.40239586516291675, 0.05119024334519877, 0.2565944542020771, -0.36609643426956984, -0.32463792850957096, -0.33023068381628495, -0.5058513323666853, -0.031004803948634196, -0.39441674761538886, -0.3622876218996337, -0.049107381067184964, 0.05014405230901445, -0.3541685877760489, 0.05512560747065872, -0.07499164787383128, 0.13619460755719762, -0.5636257862176751, 0.2184068486116313, 0.2899763706838208, 0.1381357646308275, -0.5282943994282385, -0.32412663465969765, -0.5722028465481119, -0.20745423166262944, -0.1680149089506289, -0.13354207830443887, -0.008333368776985688, -0.43970323687582946, -0.13078231907755986, -0.5620423876492219, 0.21494569144073153, 0.40916054206296276, 0.05910307185429886, 0.16431471733334088, -0.5664955143855274, 0.290608498379432, 0.004950838533006539, -0.25640619811894966, 0.20657650751868875, 0.04131461808306419, -0.2848094016045081, -0.6611870827594443, 0.29733816442903577, -0.3240735862364649, 0.04071717770589707, -0.07060292160511754, -0.5426237268895902, 0.0708955669414586, -0.254858472052325, -0.15291743373428707, -0.31504201892440736, 0.03785837544629464, 0.2355453339131142, -0.26380040863753285, -0.1897709651053146, -0.20198523102437144, -0.4589135292645026, 0.20813585321172864, 0.08349255136230518, -0.3563534898831924, -0.2940399607131031, -0.12151048517754238, -0.23450131306855576, -0.13605420542208324},
    {0.21867566048827944, 0.20879347643750698, -0.19731619462193203, -0.2708373697676026, -0.2047646456215507, -0.01597788803564963, -0.37318684074462116, -0.27021409715619554, -0.1970601415477194, -0.2645294747610404, -0.23507700414504784, -0.20100266341639988, -0.25277348171722486, -0.1894529168300103, 0.08154856548511875, 0.010938936089030498, -0.3248112675024487, -0.17087308498106324, 0.2222242057909138, 0.09030289122360054, -0.190357527365261, -0.5201104778797062, -0.24758982188899925, -0.2676046398947381, -0.28720724734505626, -0.5476590656984066, -0.3898384450965041, -0.13341823005343925, -0.16923671085787031, -0.5092412927925711, 0.14648648522125152, 0.16435824886879236, -0.4921005604713628, -0.1346510018650945, -0.15771541082129575, 0.041368149125636564, -0.04461720689003411, 0.0007573008156578215, 0.07101565353081324, -0.10119322920517884, -0.5831995946033816, -0.42108605750234546, 0.13881738020064216, -0.31454971012732097, -0.048877332577711124, -0.34311511626176033, -0.3416015313353997, -0.2094421484034523, -0.15259081174425274, -0.07223096395191046, -0.4179628615716012, -0.10103564284530227, -0.4503328369914903, -0.06168014622417274, -0.3245363411392875, -0.18667897429339503, -0.3599231643644066, -0.2093859685850096, -0.015249087358910948, -0.17802881036869703, -0.4698545656428033, 0.06060065881626898, -0.312271130564795, -0.3536278341694614},
    {-0.000785166142471254, -0.13020690376676375, 0.08191147714925061, -0.5095498370386401, -0.15056295664594915, -0.4302291255199213, -0.26060196838076266, -0.22269168131132352, -0.4079615951341733, -0.29252215598788167, -0.482978666662741, -0.6983981597912884, -0.5144612151124192, -0.20586226798489674, -0.23610114594766682, -0.34333614158583786, -0.314836236029369, 0.17581931161468753, 0.321082367456467, 0.11923150584832179, -0.3808695348442793, -0.6064487291756882, -0.5797726146640751, -0.3695247542141783, -0.2545052422029068, -0.6419971058506124, -0.2702743370444026, -0.28997516023631414, -0.4971018259983169, -0.19905568110867253, -0.28057265528616354, -0.3701858687091509, -0.17736980498027485, 0.25534873327947744, -0.4624617388913943, 0.10522635914744279, 0.08675245036804752, -0.3489599366501545, 0.05669624897965776, -0.6194250552396682, -0.4865421378615736, -0.4322148044983322, -0.49772296536547983, -0.4923254779376517, -0.3839027491891711, -0.04029431659364173, -0.05123756725873664, -0.37110624915387325, -0.20398611434745026, 0.09146886341026271, -0.6844097899620131, -0.39536162485236237, -0.5123963806531266, -0.7026277693114383, -0.3737424072696336, -0.6136551640011049, -0.43929020496310694, 0.1923958022020961, -0.2830908802674081, -0.6247651835524187, -0.5260977368923524, -0.01909769880057133, -0.2094389177506681, -0.8005857203352946},
    {0.279203330877825, 0.07229203258973171, 0.09818098289279834, -0.36973687207595396, -0.2909269455002955, -0.4236022146388627, -0.6007689090820558, -0.14299598984874695, -0.45594866795146943, -0.49776015780463256, -0.3042364445410908, -0.33430941215534354, -0.20136344270036027, -0.3016319625778765, -0.21459316220826113, 0.17133944042564356, -0.3427392459495625, -0.1709823509436259, 0.28538585988406856, 0.09330809570144559, -0.5507735828860574, -0.4935424505377636, -0.5542155643722136, -0.31124026270031, -0.34785596442108063, -0.4183992189394835, -0.3024813864632783, -0.33720227197225267, -0.27207958594893616, -0.3032217027366484, -0.00863624224541532, -0.19151905046364281, -0.045674328518179534, 0.11005675951660233, -0.4890915179723915, 0.02009359265987228, -0.14526129464589935, -0.5583665217648702, -0.014630586921631366, -0.31355537031854974, -0.3214715813356479, -0.3985736745571727, -0.1245205649331498, -0.33412804841494625, -0.10660396739859412, -0.35851198484292474, -0.3912611749033666, -0.5265299776256303, -0.4500666315467948, 0.03279058689717477, -0.4694147629024612, -0.05653453346291551, -0.18635267631094268, -0.5807317446451075, -0.5880597064170882, -0.4588789974210519, -0.41986743107833746, 0.031716931264591026, -0.2122354704750442, -0.2835701752835137, -0.15572808238141933, -0.2976819286081437, -0.04086539033598476, -0.3369348824986498},
    {0.2574183348186027, -0.05280594361124137, 0.20366037972433074, -0.4506433535809865, -0.5096919542696524, -0.41008162880538035, -0.4461582203133364, -0.2687965564047325, -0.8569579577812553, -0.4737064569041008, -0.7475843354932583, -0.4286578177357514, -0.3922060463509149, 0.24397122626141146, -0.3309521065273517, -0.10955434170458347, -0.5825442854376851, -0.3746872876917797, 0.10621421967179925, 0.29393815102892584, -0.5441958020616077, -0.19245792322806873, -0.758331818317301, -0.6882212623689569, -0.3381587989073491, -0.15169702141341945, -0.3176026465376343, -0.12173765069000426, -0.500079775540019, -0.4408812880221369, -0.23105539235397346, -0.04945151876979889, -0.1995582699709761, -0.017220328857919093, -0.3910310533698207, -0.36833521518222934, -0.29215865366006216, -0.7511081925753262, -0.3171516328993308, -0.22287638061251366, -0.5410598301616889, -0.38156454920897803, -0.2501724941837519, -0.6837961762840545, 0.05344152180805712, -0.44200991236577597, -0.4004031727344795, -0.3435242214847064, -0.3693119470833547, 0.012135679062820941, -0.38394128122538923, -0.4788040437632417, -0.3663779843480955, -0.6259487339117558, -0.54882872467834, -0.4918904438017596, -0.43186970559908094, 0.026029655483655323, -0.24476602701708755, -0.4252615801552165, -0.5422261402295362, -0.19232627661788068, -0.23622777787056426, -0.42270545939898424},
    {-0.19804528650563583, -0.20807557783678615, -0.046301356607091906, -0.28480623815698114, -0.12188847619610667, -0.24300376117553227, -0.48183998672494666, -0.12701720425910784, -0.4447345229233076, -0.907239291759288, -0.38971765303133904, -0.1397705303968944, -0.22950393667043267, -0.2770989807241115, -0.17281173705653766, -0.13594669471613877, -0.060374955378036624, -0.150785502979962, 0.32696062402092246, 0.09361100053589992, -0.5327463141214781, -0.40873797360659764, -0.3226004386659685, -0.6585873653887815, -0.2895942885875013, -0.16507833413237438, 0.1766892855873446, -0.6332323273758148, -0.6013650643596875, -0.38949419010632735, 0.10066364576771969, -0.03586241974776444, -0.4028940986823035, -0.25022501139310493, -0.28835786214839926, -0.445321787194919, -0.23054393313406152, -0.11250557660507395, -0.11092572694728993, -0.4356253314190242, -0.3490026575857438, -0.5887846373181058, -0.18737598949826986, -0.5327915610408224, 0.04921499603361549, -0.23036203384932602, -0.22365421523038675, -0.3575822390129188, -0.3819700357005739, -0.047307279916964685, -0.5746588746303548, -0.36212381756127776, -0.0455624004443234, -0.5017949210122472, -0.5293228327065783, -0.5720169340311055, -0.23006183211891282, 0.10315565931117915, -0.39539252387741647, -0.40988778906192846, -0.39436345554666097, -0.06764784856328636, -0.27813350821873767, -0.27231886865047444},
    {0.23412999401530257, -0.007912140961637506, 0.17883280578365862, -0.5021677105881317, -0.2859271220916144, -0.21500671769818863, -0.3870660527987724, -0.3261036486421148, -0.46838862992842756, -0.7421998733363089, -0.38707372753218183, -0.041737257248674935, -0.11266518122041218, 0.12283584077512015, -0.41459529323680283, 0.03919673949173576, -0.223688795083621, -0.32243301893612075, -0.2046854955115616, 0.18976168947217173, -0.5033643347560919, -0.5454661378237741, -0.5948206345530969, -0.5300479659073272, -0.3056622943113999, -0.5242804747920057, 0.14958307627765724, -0.5226793931340157, -0.514259203600578, -0.36247095358355835, -0.06708519085502322, -0.07768458272690153, -0.25811956420309895, -0.12444154489010817, -0.844481022456558, -0.17156378768663572, -0.3980620987307441, -0.3281332454129026, 0.28144744763627677, -0.4468017275119983, -0.4005190513825291, -0.4995628742462651, -0.32178113474344444, -0.8700440394253152, -0.1547033064620325, -0.3012917891635979, -0.27822617145826417, -0.37664403452963835, -0.6789825212725334, -0.186330640099801, -0.48330734132324726, -0.1781018938424439, -0.5122837004141899, -0.4461993346112156, -0.5245396458561885, -0.40914788079181197, -0.19060827251868662, 0.05327134425182458, -0.01960884704490623, -0.4035442850158934, -0.442124770335061, -0.1583404956609528, -0.13994840547599027, -0.49585541669748123},
    {-0.1376408221886632, -0.2177712208359225, 0.2559028009186326, -0.4213659644693404, -0.714918184800929, -0.35829594623736166, -0.6557185761330546, -0.08213375846738398, -0.5341379699115315, -0.5700128814381157, -0.6850882061687897, -0.2809748246817182, -0.48425872777301965, 0.0640042192548054, -0.4171450101466028, -0.006798320992677302, -0.33274971863461705, -0.030147784943828856, 0.13935536577433835, -0.05746271525117921, -0.507601012922731, -0.5612744401002875, -0.7042362911830916, -0.5462237594879756, -0.21379475280529392, -0.5830263863045863, -0.27646881411963303, -0.47961695179350905, -0.3344329719143983, -0.40883221509050727, -0.007287274621734236, -0.007723921070973167, 0.11747098516726798, 0.135728145418241, -0.4273197943728039, -0.07900843527961829, -0.33854835666879335, -0.5708348729980048, 0.15555791478826328, -0.6175316353525967, -0.254957654716788, -0.5677539866514496, -0.10490953457432886, -0.45654672555722564, 0.0344361032170486, -0.18398475303400394, -0.2807906740908244, -0.32350473670449326, -0.21536106646653153, 0.021340168512261254, -0.6238074903236706, -0.4573309182469978, -0.17745388972590753, -0.42651422491057805, -0.6697513518237692, -0.41610197058995463, -0.3299730363741668, 0.08638248942709803, -0.18303013742253296, -0.502669382382668, -0.298123991720589, -0.25319177536496273, -0.1647563545501546, -0.5776310238828912},
    {0.36316576700333975, -0.16376970948541375, -0.19215210822490014, -0.1506113810013891, -0.7124725029072951, -0.37401981089751796, -0.6948238905823931, -0.39050714864462027, -0.3751502682430797, -0.46951265694126953, -0.4120438176888821, -0.2856255741657494, -0.3017621740533015, -0.2516992620274061, -0.36821167348153677, -0.47459707574681365, -0.3352229947335174, -0.33638256092723745, 0.050377167997859774, 0.12069440305272403, -0.38332395096315564, -0.3300805452295986, -0.502118901152905, -0.9151318050679305, -0.3588017687159444, -0.22759815354302648, -0.14556046460050176, -0.5646658708604241, -0.40207224107134704, -0.35540853811865725, 0.1821428630517081, -0.16246334616862398, -0.10359886879566954, 0.05914732987676703, -0.42694501406014157, -0.24155466779687237, -0.35446255787000397, -0.0640187975758683, 0.07024033361540769, -0.594609158027258, -0.4393281083144787, -0.2638057474727349, -0.3951023776618186, -0.5501110594352813, -0.07264734481650895, -0.32869788636608827, -0.013257695718764189, -0.24766867532305814, 0.018188137275763516, -0.03200296551185289, -0.6179147790273104, -0.3551483546423738, -0.49639004217071, -0.37931583392142354, -0.5772814201871654, -0.4234674377696047, -0.3057469896418444, -0.2270117142278195, -0.1663061443728856, -0.14712144629396387, -0.4654470694936561, -0.14384136188801525, -0.18404887747021398, -0.24464638776651573},
    {0.10398036470202879, -0.12388542510702465, 0.02457693876102999, -0.7044236577226555, -0.2564827632889998, -0.40358172351387755, -0.5683218385272646, -0.3138362493144197, -0.4454744784758458, -0.4107200347118467, -0.4326438539873983, -0.09128878021566997, -0.2968783324839613, -0.1342376585063376, -0.40616625266128664, -0.26327623314383436, -0.31798421859945847, -0.31031686415862836, 0.022838423193674746, 0.1242892272213898, -0.41067485973414536, -0.4993040953288442, -0.645661476617657, -0.3546004114288808, -0.3030927619582465, -0.48265151423427965, -0.06004995761897961, -0.4322963854992139, -0.32497193610898195, -0.40763619873273377, -0.0658243600549151, 0.14734876429279406, -0.1357535959369063, 0.06852848615610747, -0.5079988936317134, -0.5736944232335666, -0.24160907075607943, -0.35486561445901, 0.25706186230187394, -0.31951786048045744, -0.7780813310955857, -0.4542135503625871, -0.29837209317804864, -0.607837653552725, 0.036798775775583055, -0.06380116503015128, -0.2816272087259536, -0.274447120095219, -0.2916229663468088, 0.07598903399529723, -0.442216958117271, -0.5470338998967881, -0.04331648026052102, -0.5524444867016571, -0.5211736798430945, -0.29510105917116086, -0.3557295380028693, -0.07967664105588518, -0.10734987731663828, -0.28530989731311096, -0.42369895591568757, -0.02036259011014194, -0.20236464135944213, -0.33088554302396517},
    {0.008756314823630497, -0.4204311246142719, 0.16014168192282294, -0.5925327570716378, -0.3715883909736515, -0.6114124235413303, -0.42697396579078845, -0.3766582903553349, -0.6886153184227312, -0.723943155585997, -0.6486641037679489, -0.28631519656570315, -0.3154488210022436, -0.23086922026198928, -0.4633716563331777, -0.11504848804631752, -0.19702888235733598, -0.10666198278841342, 0.09518484989883404, -0.1203196626624728, -0.32922638962856854, -0.3138355056671969, -0.45088592567609975, -0.4225428524098535, -0.5925487410374258, -0.47929062703403963, -0.21839424880900246, -0.7253222255195253, -0.5052277063542767, -0.8008238550757802, 0.08813226318552206, -0.2235182158261418, -0.09275438865689764, 0.0730646548124812, -0.4331196614773059, -0.3031938139336699, -0.024541465723730404, -0.65515913487705, 0.08382900385119467, -0.5414081772183119, -0.3612017142744547, -0.5572680035466682, -0.4354750532770556, -0.5008579699514606, 0.07446375161927803, -0.3606776928795452, -0.21526839775618703, -0.1763942378765449, -0.2544185276066486, -0.09131817647370938, -0.5329091719358149, -0.5568301899267776, -0.44189687320738913, -0.45105170499550373, -0.7868878522357509, -0.35064980557561287, -0.47989794390524226, 0.1351160151302031, -0.14964802377610173, -0.6472150681034814, -0.6899786143878107, -0.08188307045723521, -0.2889584291714756, -0.4038479073539194},
    {0.013414946238913796, -0.21507818562606015, 0.09928977633729806, -0.4365788098119517, -0.506111050904959, -0.716835400139275, -0.631976193068938, -0.5450528436582532, -0.39267962739644613, -0.6472505932175491, -0.6332480918196677, -0.4919944360708187, -0.5982283553314185, -0.2825409606407805, -0.4174132983982662, -0.3951378384230143, -0.20301058633302071, -0.11043250699936796, -0.0219295068489242, 0.09210832261954742, -0.7947002684252733, -0.6214544736600408, -0.7582089516202299, -0.5519321525732619, -0.7566290195420581, -0.7307218815953704, -0.2263596509587002, -0.27277685787375194, -0.7508082088290557, -0.397457520399615, -0.23623258783645562, -0.18978787189572066, 0.15286366329364892, -0.04868500526283579, -0.4100567416761788, -0.5142737746077716, -0.3152988338334626, -0.6479637087017278, 0.0545530577731386, -0.5372601756559289, -0.3765730901203881, -0.6736175820110504, -0.45781809967324455, -0.6575818971309454, 0.13443571455311976, -0.0555681040827471, -0.2563224920562698, -0.47742819428896216, -0.5114930140607371, -0.39101978434862433, -0.4363927899507325, -0.22524631225569322, -0.5789327763152672, -0.8312105086603043, -0.512787096623862, -0.451543704702201, -0.46558223997667186, -0.2300640706162775, -0.35872161430100014, -0.500783667919367, -0.36031628368258806, 0.04999277878459101, -0.165842628351681, -0.6457774942871616},
    {0.19506537797144946, -0.21708280283545128, 0.09571830490620038, -0.474847002268372, -0.26143803665168086, -0.39825786109403616, -0.5945647784138168, -0.35701941799945375, -0.30458669931804183, -0.7702629944946047, -0.5941337543710045, -0.26625939122634773, -0.3839692679253907, 0.03183183006533402, -0.30694787121920497, 0.0769907587570744, -0.5768481682589593, -0.28734628489242076, 0.0842949354801957, 0.20495348218772433, -0.6340928160306325, -0.5021916879133622, -0.6075047938130135, -0.46792081356441195, -0.3736120282117737, -0.20377934336648126, -0.06362852781279339, -0.27879486160613753, -0.5974914122674467, -0.383281196490249, -0.25929125768255523, -0.036058348986564126, 0.03288635454146038, 0.4835863896321121, -0.7310393513184766, -0.2214179662287235, -0.23787775641325334, -0.7043324380071232, 0.06030743678901694, -0.7316381797701765, -0.25926378390487304, -0.6647980463845075, -0.07161486627954718, -0.8609926989431654, -0.06887765625194417, -0.2980076958120883, -0.487045055999366, -0.452251054359346, -0.4092048352899656, -0.11323980888091822, -0.6259941741946629, -0.5905625995137875, -0.3165056600965189, -0.5297695343679493, -0.6833584055406564, -0.4504462511118539, -0.16553014972850993, 0.12589008463982274, -0.08261650959716413, -0.7309022164289783, -0.38573348871527824, -0.05087912929954567, -0.05658920703181512, -0.533737576675568},
    {0.056595317849692295, 0.11329169076798239, 0.29657788411029035, -0.6113312521189175, -0.6436322034161336, -0.5372453363290149, -0.5633514092987773, 0.13920537536687513, -0.5039173869594705, -0.681068859864883, -0.33137482888836844, -0.3488162587645442, -0.36322616166489413, -0.08268964014668646, -0.17677062080293213, -0.040912242589615316, -0.6057489423322132, -0.15818252578879496, 0.29028345511907444, 0.16901249611143915, -0.7490081926415117, -0.4697248300847711, -0.4718430572821307, -0.4066682315784946, -0.44845982348818436, -0.38730287029740224, -0.03400461408653269, -0.48047876242658577, -0.5024763724751218, -0.42534278600857217, -0.10894717282086865, 0.1354453616261381, -0.13358319274184147, -0.08465685964644902, -0.6473015288987307, -0.11377290304881373, -0.17090550377101313, -0.49508431822028226, 0.3784209404201784, -0.4329442651462908, -0.24101107114358036, -0.8852181888078418, -0.25169571237858, -0.6024156539065498, -0.12905729482962233, -0.40791716530149896, -0.44180120392250244, -0.18561941023113948, -0.18587181118417806, 0.07240998747796777, -0.3980407106479185, -0.3044625140732264, -0.4644351886333761, -0.38367324546846887, -0.7393063959185762, -0.2974352683301823, -0.3293306070357015, -0.11437581193728029, -0.34984521762050425, -0.4953840595033704, -0.47020261050645723, 0.29042036472060234, -0.28939274363817497, -0.48620354525966314},
    {0.36076634377845246, 0.04720722731453342, 0.08328676123369298, -0.7371930807255967, -0.26752390711336976, -0.31795240432558997, -0.4867553043125394, -0.07353104253449232, -0.39097022084296684, -0.5926978168122146, -0.32695084204700525, -0.20109212084187095, -0.4900962975727321, 0.1622031369598853, -0.3750301673727586, -0.06139199545845985, -0.35804112269618965, -0.37256522510603646, 0.33609500942153225, 0.024951995133309042, -0.2787691494550883, -0.5410682780136882, -0.47787702140792204, -0.49207349377348925, -0.4339627294020436, -0.7922545847746689, -0.26041573304778937, -0.5094779418522438, -0.23962387772745924, -0.1587211706941049, -0.09193714817363359, 0.030137606592006157, -0.05302599247481774, 0.35244518452266416, -0.6948345628460472, 0.13530821454373088, -0.08171431212391839, -0.2846085679798107, -0.033017444516611344, -0.2839445301351367, -0.16869072049507264, -0.5789002360521139, 0.08907950624312466, -0.8202134513343214, -0.2288880346827061, -0.2665622526466995, -0.3423293972727553, -0.22510209627222472, -0.13592435184847718, -0.1462218827658705, -0.5522865339487488, -0.005459768607188924, -0.2984949649839329, -0.5251976975245903, -0.5599872290528871, -0.2679841406043509, -0.28132684594273005, -0.027926204185946248, -0.5090450111159307, -0.38781331334854835, -0.707898999977029, -0.06446527444866974, -0.2634209026580501, -0.3472280781972138},
    {0.12160366747923688, 0.10431457626909635, 0.0744867434511312, -0.4005115081705116, -0.4388958974756425, -0.30718753636599755, -0.5171932831757039, 0.0683684292012291, -0.20090285743091676, -0.3280958310888239, -0.1909696521264742, 0.10973688612037229, -0.32359753901129973, 0.4035013380450924, -0.3288589539102227, 0.42284359743195044, -0.094249431968545, -0.24389395359485944, 0.19542928897864012, -0.012792491724866779, -0.32621141336129567, -0.3348878118573143, -0.18231457270448737, -0.34561139466176843, -0.05242312131993357, -0.2810581717425225, 0.3289686526815971, -0.14585318151439475, -0.17252696775082785, -0.21024699150132292, 0.02443698724798422, -0.013727411031220634, 0.16485403935307108, 0.13918385996427482, -0.5169789641142852, 0.12645456243881098, 0.20452561929699428, -0.40572611399421693, 0.41295665048964814, -0.27788143388498976, -0.22707442531580832, -0.6445685095259047, 0.35612022988957465, -0.5471388334074493, 0.008948782814556223, -0.07415039122857564, -0.1755437277347735, -0.42757151540609906, 0.009669139915317017, 0.1003853197261932, -0.7423549862573001, 0.040699787602900106, -0.448970118763465, -0.49017621285325286, -0.5235288335476158, -0.1944595002042969, -0.43909971048351043, 0.01858633874215224, -0.15834019209884503, -0.37959559274385685, -0.4207102816458504, 0.07806439062457486, -0.05501031749724914, 0.03703621531775185},
    {-0.049519350381642985, -0.0645058237901167, 0.027833820872181426, -0.6365651819045646, -0.39849165500784595, -0.5909405270146919, -0.3626868385596879, -0.17989663681608106, -0.48473151103946166, -0.46705295458791435, -0.553158570406509, -0.16646610028960163, -0.4524044602607854, 0.23133814075640846, -0.585035321936764, -0.3774168397827162, -0.3640173702643668, -0.4275459169391585, 0.2879320106932706, 0.31885989271264703, -0.5711542937155095, -0.318596575331958, -0.52115831624798, -0.4336913226336489, -0.4020380860717703, -0.16270752525846394, -0.014251096079499849, -0.7010810138906843, -0.4662531940865599, -0.536925796837261, 0.17213195433982, 0.29526082225520073, -0.32246073468958797, -0.2467215484070799, -0.27889172504452925, 0.23476134504512544, -0.02185939488975915, -0.40509606734748904, 0.18895696865756573, -0.3128190567974712, -0.13683427258286618, -0.4199987087255183, -0.04161377621909826, -0.5542507933115726, -0.06271983992666423, -0.38368217038332214, -0.6248173231006122, -0.4179793461512442, -0.04765072586014454, -0.246886470792997, -0.5422308878365628, -0.3645887972209399, -0.07012303731857482, -0.4025782842442721, -0.4573199764756793, -0.2971557639603643, -0.34351994049059287, -0.11943067618305821, -0.29931347772294326, -0.6057621540502122, -0.5753405874892834, -0.04896465794844067, -0.3490148729532422, -0.3033820553010089},
    {0.16260874455425586, 0.22941255362175747, -0.057054777105376875, -0.4993519697271783, -0.28993904722721925, -0.7497081612273901, -0.5608352162781959, -0.3496926900701944, -0.648977586912517, -0.8655071614781372, -0.3893492880301969, -0.00675594494029409, -0.7304957431689441, 0.0853030502749564, -0.5821576656729585, -0.2510402326622842, -0.49603563312330484, -0.3443903616601906, -0.09306017137335898, 0.09681348010737627, -0.7631510845358012, -0.6173147549658912, -0.6884730474685912, -0.6315082761766921, -0.6698145575739463, -0.6094691672624681, -0.0997603981594779, -0.5631762692468387, -0.4162485392091807, -0.7503908350134706, -0.21077913147356928, 0.008385961228033928, -0.1901744319862821, -0.01095942726089954, -0.3370969459831667, -0.25523183827155244, -0.24649188208667971, -0.7749629005888081, 0.22348304518311093, -0.33818486448246843, -0.5564538019293439, -0.9061709325909272, -0.1782160833802692, -0.7276332352121806, -0.2230990401463998, -0.33680791012516187, -0.30628836330645215, -0.5709558539063266, -0.5271179005199685, -0.20951520212147115, -0.7859489605807793, -0.4377617147789565, -0.37149544276298785, -0.5392807350046875, -0.5406562929161722, -0.5630036818087669, -0.447555881130514, 0.024246768597267408, -0.30073156627215103, -0.5038213950367747, -0.45787798458367523, 0.05062674373432767, -0.2130804200917489, -0.6363928117292134},
    {0.05814680372463238, -0.1485947596060415, 0.297610171390143, -0.46711486983440714, -0.07812701203630434, -0.7870185288462754, -0.4884223472290008, -0.15918822358366216, -0.7540729711014702, -0.6275539720144513, -0.6116768138801337, -0.5473953952196121, -0.31563367526435526, 0.14552971726616176, -0.47160093668634123, -0.23204453709568867, -0.2266581913445468, -0.40902281989484274, 0.23605827050349323, -0.09488718340148784, -0.5625665928699003, -0.509511788438823, -0.7741038536875049, -0.5157844759124546, -0.28894169197952696, -0.5109817005497799, -0.22424418657216574, -0.49060859344283025, -0.3360933252045702, -0.592607105340369, -0.09765063832564094, -0.07092225557239631, -0.3283989559571217, -0.009786080589585149, -0.6122590971690559, 0.1457852900723532, -0.09444808189073858, -0.4197585317720377, -0.030221411577855805, -0.45028988627977506, -0.6275413888602855, -0.5597635155836836, -0.11330570756305008, -0.6302817650370448, -0.34376995321349263, -0.16589194426866474, -0.10254279327770728, -0.27158182704611405, -0.4410340243038006, -0.0018937403260485335, -0.563021945592911, -0.3977898921862055, -0.4258354379360856, -0.7461510015617722, -0.49047036527091337, -0.3397300027620962, -0.8539431590223193, -0.06839060495446607, -0.39058493415999357, -0.7401351513230131, -0.7827602892177952, 0.03381418494161529, -0.33353000686177525, -0.5192003251634004},
    {0.43827133122921624, 0.19060799920106086, 0.5921476542223347, -0.34168358071901545, -0.10689031268666215, -0.5998093925261487, -0.2926171033031326, 0.12394235129441278, -0.42826554917429505, -0.679972022777938, -0.4698865622877071, -0.3788354258519383, -0.4327463493661979, 0.09668153134754613, -0.5121188693084975, 0.39472551870594863, 0.024427075447434218, -0.14669404323144034, 0.452907573173768, 0.03459574619726007, -0.6258272533757543, -0.5495812200660186, -0.78600241602189, -0.40987747779670725, -0.19934319658373503, -0.34720812397566625, 0.16106919344998477, -0.4745918111035545, -0.32666416066507753, -0.26815367654084765, -0.09289835958443315, -0.0280002892141474, 0.38880459067335665, 0.3410022083166658, -0.4535676857216297, 0.34408453237504355, 0.3595340469416849, -0.3434576175770515, 0.13998052714524195, -0.1711830500068744, -0.10331405899249152, -0.6668309223166601, -0.1283370567890001, -0.7195216054251463, -0.037383108094682614, -0.3046553086307291, -0.21756282120468395, -0.18719341889210644, -0.2216527754224515, 0.004973728670075463, -0.6438959644494456, -0.31133282140151525, -0.34484529742781816, -0.4907300814737431, -0.47293269253916165, -0.20905188678182793, -0.4460481273736873, 0.258783029347628, -0.27599686792827127, -0.5543462561157525, -0.5091941283614504, 0.33858954538805874, 0.2764136640342567, -0.3377850812786418},
    {0.6356366966702811, 0.46410929288023217, 0.3799208119092025, -0.015783787441928637, -0.3751138991123794, -0.2956450526200638, -0.5265536835717419, 0.1095675952599274, -0.6019063098910644, -0.4485534587869648, -0.11615768054598037, 0.5182970200052859, -0.46058510735224356, 0.4350064347723655, -0.22129930990043659, 0.33974030077499684, -0.4490996699374338, 0.060927764673161335, 0.19784936861581368, 0.3956483047403955, -0.316367092174722, -0.6321507438241994, -0.3308367514346325, -0.4918991639051501, -0.5162626327989215, -0.2808679261125943, 0.3428687158901726, -0.4036482990015691, -0.3026534122761097, -0.5810776481053833, 0.2762857516839359, 0.30617158018140905, 0.44994431387084793, 0.203047172362763, -0.6002401567559917, 0.4213058812290605, 0.4757776307773829, -0.01663938433115964, 0.2742195998062278, 0.13463335050804395, -0.025746391679056953, -0.7534072160099295, 0.20796964675676644, -0.5252112427667662, 0.04507344204907336, -0.20364910455765903, -0.34696788769044257, -0.4437799810441767, -0.10968032379012523, -0.37691060997315956, -0.6745618299173847, 0.30127161688222037, -0.04528481273524019, -0.5091293844766226, -0.702447007368632, 0.2932475144088941, -0.11501751249608379, 0.1300839188766523, -0.14640554354654448, -0.32170037095615645, -0.3911223301117335, 0.18107715138891442, 0.16697067497773968, -0.07398498585638695},
    {0.1691361001061059, 0.39584223375729227, 0.1233530178918327, -0.6128813290238234, -0.6273799852928128, -0.5015769438395153, -0.8648072034540124, 0.027884867959853586, -0.3002330645062407, -0.48248814713853033, -0.6857620831429193, 0.06038286233711831, -0.5302693565726347, 0.035646103751064626, -0.48293575650656567, 0.46200875654166224, -0.3646843079649646, -0.1403483930075484, 0.09089166242869245, 0.2950384746286611, -0.3317685077731697, -0.5486565890090026, -0.37784880175407176, -0.568247800832159, -0.6614651180024554, -0.4626332648499524, 0.17326931941631088, -0.30075339176992627, -0.46572476979510696, -0.8279616089737131, 0.07137124403561423, 0.19420180010874513, 0.14957258659920414, 0.23680849458593936, -0.6285728940299886, 0.3154014942731005, -0.015442888752486622, -0.10128853074154001, 0.3722369508889947, -0.02316986420486981, -0.23541659734813414, -0.8219421093278276, -0.043465145656591514, -0.5155722763414756, -0.2758108235312806, -0.5373331508752517, -0.7747994924579068, -0.37285296692585435, -0.5984536249237757, -0.30679078930294096, -0.7441624222767995, 0.23178302115630392, -0.3335425863796548, -0.4289918211605578, -0.6971144900695201, -0.05857084023382923, -0.4400950064125174, -0.012549249526706021, -0.10849193675046571, -0.21654010969452567, -0.5958780145489051, -0.12374142877985252, 0.01659563675273682, -0.2692290664926278},
    {0.20733689844875844, 0.07910516688527688, 0.05134187290876003, -0.599296952557807, -0.1673526266779214, -0.6928736598132343, -0.7512913661115552, -0.17500188236269618, -0.4667858185034974, -0.4940596709478025, -0.5575986106885295, -0.12107221031034839, -0.5015290598749715, -0.002843485978608199, -0.6335185735246662, -0.17597209527809132, -0.37726599754197715, -0.10796100858401649, 0.04504696527175658, -0.10188716370012421, -0.6545792419470828, -0.5028038914065762, -0.3955730682416434, -0.8237809235271701, -0.5054546974417335, -0.38067370530422684, -0.036783281718701266, -0.5635004609582293, -0.39255196203735315, -0.6458416976376559, 0.15546776382969876, -0.02612521754553264, -0.20792031920145904, 0.18819432033135075, -0.7436644190113079, 0.1041484691125789, -0.2965127666575808, -0.4192555110635551, -0.08856597736129147, -0.6029596199591507, -0.4790725552598331, -0.5663566655051626, -0.24981555174964584, -0.5811130496456265, -0.03630613003766867, -0.589574768721859, -0.4317206705165663, -0.46542331964054945, -0.5332231356947063, 0.10547522592490856, -0.772449969304076, -0.3577543695365038, -0.38968558704789596, -0.3874544004679011, -0.7647520525019181, -0.30833419626309255, -0.6931314042406401, -0.1985777087240673, -0.20785934674793763, -0.4844130697845093, -0.5471555901043335, 0.10184413139527762, -0.21954199284159368, -0.8176882468592744},
    {0.5177028407575823, 0.25054533991393657, 0.26539225791068116, -0.403172761422018, -0.410190615091819, -0.4167157611322156, -0.45079575849081766, 0.04918654866170466, -0.5573433252303069, -0.6704283000930725, -0.2696200923824656, 0.39765405671371545, -0.3219157271795753, 0.04791290289998698, -0.3268426521236276, 0.20310219009586603, -0.5621327102977612, 0.054355309062332005, -0.10158359182384806, 0.19233138150265708, -0.6165400936824893, -0.479311182975392, -0.503381485182634, -0.6008560932481263, -0.49199756039998305, -0.14508168835009547, 0.346024330514714, -0.5266658846639002, -0.0968926397813163, -0.6573524128088796, 0.020588170102540708, 0.2239535674723171, 0.33263357299161983, 0.20365418732726, -0.5195709525151355, 0.11682485998599139, -0.06486812967908934, -0.2488990413735655, 0.23778804767479703, 0.01542517406779726, -0.14838425433630056, -0.7838358945614468, 0.45800516257432144, -0.4898220527479437, -0.06840111929856686, -0.5700901933772644, -0.5571915149107484, -0.2135914213101402, -0.020322292434166188, -0.3599287831386771, -0.5944687212310832, 0.1166648540279274, -0.28358069553127147, -0.6970836794240847, -0.5444716784579049, 0.2473243557986957, -0.5290178249972407, -0.023150985039777267, -0.05628979494873339, -0.40013662352801715, -0.5936003816862451, 0.16315651825234354, -0.3695903122171132, -0.4001467986309552},
    {0.4533228632212633, 0.07094547946990888, 0.33001123861714043, -0.41870704569031086, -0.38424276058450746, -0.54889329555899, -0.5275932380344512, -0.1263075513799499, -0.598477615948068, -0.6761010644830522, -0.28190623846650287, 0.008610284510065099, -0.30930027095452495, 0.08014810791679523, -0.24202970553338685, 0.09824183799229691, -0.6463073567761148, -0.09944334137260603, 0.2285310799474226, 0.34155687327525713, -0.3581280529086828, -0.630895686935299, -0.6333567228045829, -0.49323295946326046, -0.4717332437391368, -0.514468220360305, -0.12587427751753613, -0.45204592132606103, -0.452181440871772, -0.43752068925126075, -0.18074169054853678, -0.11026130637795081, 0.18236448268829666, 0.20505261868509655, -0.6195859262630219, -0.059742455350440066, -0.07403323140303485, -0.27130201994161, 0.12351367801728412, -0.18636775574881495, -0.1492965873867105, -0.5034081463864161, 0.04291818710270459, -0.7545967400711777, 0.06271753087291174, -0.39643500760197986, -0.6969397402931773, -0.570862482120524, 0.049486325968103574, -0.19473018292221803, -0.622867452728622, -0.02122044356728908, -0.5854912393294204, -0.37312044423930096, -0.29396028300896576, -0.22900064656201238, -0.26160238616569714, -0.3068270882144595, -0.2748991362183212, -0.8237876883021241, -0.44791309234961735, 0.1563086748919142, -0.2197678212103919, -0.221244446106623},
    {0.31102904116779584, 0.25993748430299773, 0.3365914672073265, -0.2890705169753656, -0.44383970526832695, -0.7887447264212363, -0.5067028857551289, -0.18246499147811032, -0.6964276439843831, -0.5937813116027993, -0.26703169579119224, -0.06482925892109487, -0.3815249127003921, 0.2703328423918779, -0.5540734131066292, 0.1795350309527006, -0.5634991202517484, 0.1159257654405241, 0.03296695718350741, 0.0239253244730239, -0.4462762103892826, -0.5563547477510637, -0.5710113310002297, -0.5929778622343668, -0.6307774488454961, -0.23985056548714098, -0.15614605428140885, -0.4320622858551557, -0.3912005825122062, -0.7174378130078435, -0.3525298760258286, -0.13564498992047655, 0.35172569483763416, 0.16681804120201832, -0.25460071041521554, -0.01669409249493535, -0.33880932765708227, -0.260332981435437, 0.2213132845160764, -0.24843280471630363, 0.07321527456688669, -0.8176783069809508, -0.36426810451638664, -0.7721440178295388, -0.09358085639430598, -0.5319064431076452, -0.5000021236931367, -0.36168497419458706, -0.38404972132823073, -0.39514366529533296, -0.8386480166219281, -0.4345652921668592, -0.40368071697712254, -0.8256462545636002, -0.6048242763023902, -0.159496642521767, -0.5677871963360367, -0.08496294515814776, -0.26289320928118043, -0.7402633354731408, -0.37471998502132364, 0.16841863006834404, -0.44161124640768723, -0.5251781064958314},
    {0.44037195107398036, 0.21170706829655825, 0.3701983057233487, -0.379739266120043, -0.5298912805041271, -0.5104994501596177, -0.5766082518715201, 0.2167850045198393, -0.4506756011654733, -0.7423940723025212, -0.17498193460940392, 0.23542197143122107, -0.38837333428051174, 0.16391698026192278, -0.5894085220279814, 0.309989455421089, -0.33016103632955124, -0.12047493301841228, 0.3907811047116613, 0.37811209602794016, -0.37261538683629236, -0.53876671131394, -0.4784816951798609, -0.5164196742498435, -0.5677571318659165, -0.5000936489913533, 0.21820679512651361, -0.40838963917198423, -0.48428426247933454, -0.609026541847867, 0.029789061110603556, 0.11904946831455751, 0.08500839577457668, 0.3453636432334496, -0.34387632562575443, 0.049272575391741076, 0.021832642638719243, -0.12424191704399416, 0.25682953454499186, -0.2882479039758435, -0.13687965914857483, -0.6932197160921656, -0.184684401788707, -0.4726656710097742, 0.026249541899485238, -0.5016426953135764, -0.7094939079541221, -0.40608451425194697, 0.006142356615658282, -0.29570785562451024, -0.6843109244588874, 0.17964668003282572, -0.1996737968582548, -0.5897218282944211, -0.4752932413391401, -0.21508257682094506, -0.38978539659175043, -0.15262467402532315, -0.12182632253723845, -0.6764290652034639, -0.4375426925742135, 0.319634296010122, -0.2840762353301108, -0.3740501652743204},
    {0.5205017829746788, 0.19026212867620776, 0.37250567382345495, -0.25875850460897376, -0.796808436476258, -0.5249504033141236, -0.8559234830991471, 0.325812670362002, -0.43942982442414197, -0.5246871750296991, 0.02328640079366687, 0.029703003748805003, -0.41167904605654654, 0.20839762998484815, -0.5696672200744545, 0.21622821039302492, -0.4788347094492665, 0.11625035464692048, 0.43440796220468864, 0.2752728544248759, -0.3559582163179034, -0.4430638405074354, -0.47873889422351645, -0.7102646095483153, -0.39045315276492215, -0.21678337992968016, 0.13008523136222844, -0.5247022590271191, -0.5048564136905221, -0.536634144023265, 0.369894910401939, 0.129179365899589, 0.43586308358550485, 0.15307866981294843, -0.40294962116560645, 0.1588998586229125, 0.24899838924644274, -0.19854067110144583, 0.57043580597842, -0.3777467372647944, 0.11709172103483675, -0.5115088492433961, 0.2544435074591523, -0.3654269816655597, 0.09903728968002927, -0.5222925385705232, -0.4348295840013888, -0.4515835676426256, -0.25466278172247825, -0.03250352603646491, -0.828770463109025, -0.0471977216147993, -0.17024669654701136, -0.29430421658819556, -0.49975211910187906, -0.13728103015676746, -0.40954937891257553, 0.028537624717861854, -0.1214390445580015, -0.4164447453479708, -0.1519565587225408, 0.4299227070981179, -0.24702148664427365, -0.035127890355671966},
    {-0.2216045371416878, 0.315296786078213, -0.2995953521072289, 0.5401215853154943, 0.18948281483360246, 0.21251087060920876, -0.31412000132966894, 0.23812687542536165, 0.08209481763873866, -0.37969791089642524, -0.1210149538170544, -0.5453311240201225, 0.004276431911252274, 0.4309243528231256, -0.5532180197814545, 0.558742715039122, -0.20461052543984456, -0.5400644685611585, -0.2645491940142553, -0.042302493630122784, 0.24104717361788963, 0.10197237886716243, 0.1650067929104943, -0.2943513431015862, -0.024129995222898888, 0.044602634668127736, -0.6165899089741106, -0.1613392758445264, 0.39644423012091473, -0.1567927584345661, -0.4678541428081361, 0.028619537663560072, -0.5700649309509788, -0.537419760724094, -0.11592532070175114, 0.3355652082354397, 0.1317758353176116, -0.022453073301536966, -0.5070064389489193, -0.06780515295986222, -0.16027753065663783, 0.2145881963625868, -0.05960546709863522, 0.10426064155866804, -0.16295644645812643, 0.020550742846981846, -0.0565751746801276, -0.6037110611477025, 0.17460082591846876, -0.11327918893279136, -0.09367196004877809, 0.069406866182777, 0.1433732075827161, -0.40799437093558505, 0.3398554897031372, 0.09959774320515823, 0.07473128552274114, -0.3665774108424038, -0.31225840987444703, -0.5622810051645579, 0.40209277232267016, -0.07670988852215645, -0.32431462415613327, 0.2193903310778874},
    {0.29626469682653783, 0.22654398899281078, -0.3552709557340079, 0.3413636348337198, -0.11048286121903245, 0.3754368031198761, -0.30314953294254665, 0.3509759441226363, 0.5818660839255446, -0.2926320307852806, 0.07228427633269623, -0.2039448901292089, -0.020741527049568935, 0.2727663898472716, -0.4183389510883019, 0.49825588157773537, 0.12958601555811272, -0.31784614580912435, -0.34628829459257904, 0.013705826347538677, 0.20845947938997572, 0.31202152533892563, -0.05068792060337017, -0.46989157921978186, 0.08346037116995786, 0.34907507179882863, -0.3894541288686158, -0.4125989194512042, 0.1271374153561093, -0.06106674181836365, -0.2851301502412752, -0.11091980974055539, -0.16789953116308587, 0.02119268622171424, 0.1455541514053706, 0.4225055767549561, 0.3589328654080433, 0.3964233358434739, -0.567712029512801, 0.1398623439371665, 0.2985499995696833, 0.1767721981694896, 0.21263401262318787, 0.02383489223000823, -0.2167826407158207, 0.11370933428248323, -0.11656282611867809, -0.6227166639103708, -0.15564106329198896, 0.1295750492171738, -0.3384446566506206, 0.2757903354372425, 0.17450881754881858, -0.1802646747201805, -0.0041040715179406426, 0.34144896353165316, 0.48519857208189965, -0.190924626250114, -0.11954201527816884, -0.4205102594037881, 0.37741131377784315, -0.13135067896503577, 0.220333070757382, 0.37223854283127333},
    {0.4676041157776901, 0.43857609306956474, -0.4742142677945713, 0.46506846452527223, -0.09867654305408216, 0.23000166980837264, -0.49990896865786605, 0.4426835972622511, 0.6825324720090873, -0.5629681537097322, 0.41198657798716437, -0.4825973327490075, -0.054402410480877725, 0.31316149128109055, -0.4691751449828528, 0.4945603430001902, 0.19071189951246978, -0.4805377039102734, -0.4727947393894188, -0.17283171528232336, 0.3621815953635692, 0.5320420574949771, 0.363531244141825, -0.38608809915416487, 0.04198674342847719, 0.4178033959149996, -0.8492897576572923, -0.43727988932267786, 0.04386584560172649, 0.15208560012170524, -0.20702886427342432, -0.24681402236252478, -0.33565157063489987, -0.5117917505632784, 0.41340836975307266, 0.179165976001816, 0.4440122137593981, 0.591638328214434, -0.526091551963278, 0.0344223181179142, 0.6643065970844914, 0.10194086930106785, 0.05756466549004742, 0.3468695382528208, -0.7467091916798334, -0.018129154155734833, -0.1355192542727962, -0.567139063343107, 0.19740743687754075, -0.23257769639859738, -0.4578786480317029, 0.3397169264945536, 0.19640623114970723, -0.3051680473404715, 0.19211100933284223, 0.5297639560518239, 0.6209462991903235, -0.4505072245701432, -0.21444921886004448, -0.08331649288583785, 0.119217370631546, -0.5611478358225565, -0.2551255116214283, 0.5808205589109953},
    {0.4476346591057101, 0.2479772370393451, -0.3727928882371469, 0.33930626836382294, 0.06901299356647636, 0.35821235407676527, -0.21928765818905385, 0.38225069913922644, 0.18262003205992772, -0.4917175652733597, 0.15011477591127953, -0.4870168800860901, 0.09475958929176385, 0.41782797717050774, -0.30337936007144195, 0.5678636016032452, 0.05616683510489774, -0.5516084155050999, -0.27035633723652547, -0.23735193320486106, 0.438380908496649, 0.7129492224244881, 0.25467579775373134, -0.5763440316069715, 0.08495492826648893, 0.2913425418504039, -0.4496677912042283, -0.3882914478367083, 0.33477778505361433, -0.035679244381359325, -0.5549180573306324, -0.5367600949374539, -0.4026298683422218, -0.5157889987711826, 0.2867447390424811, 0.4528951788770155, -0.0011428681498321276, 0.44585561698475257, -0.3811393246511534, 0.20125190774465232, 0.22428019860540913, 0.22815029061126915, 0.23570185617985384, 0.18042075393477217, -0.4303290962141889, 0.1664093470335562, 0.2034976481877728, -0.28796242810460226, 0.29575419715185836, 0.013792854834371248, -0.3382623398125088, 0.028718232232089382, 0.07877381621724362, -0.3847829175749138, 0.018788436248669035, 0.33472174031788465, 0.49970649924690125, -0.4377317737978849, -0.22050040352479122, -0.08187880894265913, 0.5650113520824098, -0.2771009044776965, -0.11562805817988647, 0.6210360149523028},
    {0.7100148828719213, 0.3979776649867173, -0.13369908866650485, 0.516398495619633, 0.3268040671339564, 0.21826285729796144, -0.13863083221859332, 0.21785987670996615, 0.3268292953804811, -0.5855082970798832, 0.0633842686477243, -0.5023167152508602, 0.24386457205260823, 0.2286537792785892, -0.4611124842196015, 0.421198625107197, 0.2849721412416249, -0.490492891557553, -0.3374250705511775, -0.386005888113452, 0.5249164720930223, 0.3167266020190751, -0.262599712943885, -0.3714584120910025, 0.06780466217656793, 0.19049919813360142, -0.3656295889132083, -0.2989514863934727, 0.23024660004084044, 0.36037599999273723, -0.39971341503886126, -0.5974079793868033, -0.1574843421684594, -0.6282181356853076, 0.2876721571890167, 0.11949124994455228, -0.10527321863445355, 0.5959047517405912, -0.5343732049028997, 0.11587443328187286, 0.30092344457333753, 0.16032560165862542, 0.2734019646992433, 0.09665315833781185, -0.1624850893302139, 0.250759772191041, 0.20573955723611007, -0.6771653149631874, 0.4595018420804362, -0.12324443818589201, -0.1590450453002593, 0.5753888587277798, 0.4840728771150817, -0.5412210379918656, 0.3823498575527935, 0.5224442498176308, 0.742370237636112, -0.4657533392246753, -0.505062377530042, 0.05908520843738976, 0.4753935559850726, -0.6839746505962397, -0.049886831120062765, 0.5835415094065278},
    {0.2416973476698306, 0.4351336798954531, -0.0035433339166943377, 0.13439677074478726, -0.08199445759308556, 0.10560125417597221, -0.3796352376336746, 0.3490727034134829, 0.3853524084437585, -0.21036359814289157, -0.024673667947590686, -0.605281521146511, 0.08889667453841425, 0.21529120570526997, -0.3912645228464544, 0.6000979891704359, -0.1065227660480521, -0.3743540674820368, -0.6589831627083036, -0.13307859022999746, 0.5835630147070913, 0.5149438734953582, 0.10896689014833143, -0.27421709892759316, 0.24026113538650634, 0.32534948225450433, -0.4188910235062648, -0.3145489144018332, 0.011486727930250492, 0.26133765441162593, -0.5696338200055918, -0.15876044801297806, -0.08247617906825108, -0.48380903636182515, 0.08705858925442465, -0.1518140711235537, 0.40636387358262654, 0.12738920901598608, -0.2942689952777717, -0.010147550360799269, 0.4324141128148209, 0.4659144299680258, 0.1359810330839366, 0.08135468506243726, -0.5320609999168479, -0.10671330901937019, -0.014116145510213405, -0.4363801387123126, 0.15542278483975808, -0.22537406102921326, -0.040741136864447726, 0.22835374093189728, 0.20034717225526458, -0.2840957997754049, 0.046717274009868484, 0.37046455023447417, 0.2441866192247302, -0.33616619885579446, -0.4229030919115665, -0.09788687066259515, 0.3946490884502599, -0.5723951374612924, -0.19658575273905202, 0.6255385109787421},
    {0.04461208225594145, 0.28757558502083047, -0.20856033585722827, 0.4347599146213435, -0.22293855261522344, 0.2682620887762993, -0.09124527991471527, 0.4088886842760024, 0.32600382666408, -0.09341714907949829, 0.06075064035186691, -0.47241586116336204, -0.03443043652543505, 0.3271008125213467, -0.721142964252961, 0.3745666514242856, -0.058432595449336634, -0.7143894180024861, -0.3956880566695597, -0.27939932580075727, 0.15076991037407947, 0.41536598745129666, 0.3115419115753856, -0.4580246594925, -0.07421973932979557, 0.6659491569764798, -0.44599627859013413, -0.4776553218525226, -0.02328721013751412, -0.19698512908329352, -0.17338219793844287, -0.2381050461214986, -0.4308465753387667, -0.35515328701941323, -0.02197725253073382, 0.054398568545804216, 0.43830012277997243, 0.03901010100170441, -0.334788462796498, 0.04059178454451673, 0.34496791097032276, -0.11636866044860864, 0.490641447278535, 0.08671177980395858, -0.4949624833905094, 0.03538476924802009, 0.05958304426174384, -0.44076713814865065, 0.12359554855155044, -0.23620039463904588, -0.3684060549587125, 0.16840006960237883, 0.23036116745689156, -0.36463370950967033, 0.18828369485080987, 0.5056240958641223, 0.537676472648071, -0.4223033524285301, -0.585687332081961, -0.19187584653164266, 0.45969736301183506, -0.4682382607662388, -0.2691373329292162, 0.5218752449948736},
    {0.366512907761076, 0.35800355578824866, -0.208883493720851, 0.5206604086851435, -0.049251018391879925, 0.435583862344347, -0.5968142237375696, 0.42587219798350057, 0.16939050733324126, -0.23684414877107496, 0.46145397951068906, -0.4627051782290362, 0.056023955592754505, 0.4212551675249413, -0.48241789676049124, 0.48189004140812236, -0.2284821487533614, -0.512258702790567, -0.6901248736483445, -0.45650811673672836, 0.5845455274453716, 0.5479375021458334, 0.13383264640879405, -0.35766676103176614, -0.21113298523861382, 0.5774039376355615, -0.7414881250687517, -0.47388322128563254, 0.45261461267387354, 0.23602806999578624, -0.5270090157773004, -0.29811913274531765, -0.5416770413253446, -0.8076290551976673, 0.07803338559151679, 0.28954050909230494, 0.35900964486800885, 0.09722980747697468, -0.4785168000858269, 0.10626290986221441, -0.0533235838818581, -0.19133703884739647, 0.3342687447133294, -0.0023458828454766796, -0.662849461270548, 0.21785977529477923, 0.11770885978090102, -0.5893067356351139, 0.4348750654909066, -0.0068891767812167635, -0.12157325807718877, 0.578467247500692, 0.4769528394613269, -0.502131695916961, 0.20636952087381386, 0.4012831400053861, 0.5741150209985202, -0.5288344624347817, -0.45849133503505285, -0.16703309107326664, 0.3611827426278236, -0.7092028233574681, -0.32041132512358017, 0.5452340972965083},
    {0.40454120474402677, 0.43524125734055796, -0.3099368376742188, 0.3427582006100172, -0.020809447244485232, 0.42157839682717746, -0.38620860330834106, 0.26173063118126927, 0.47272066713482164, 0.08002458285839731, 0.5563355377909478, -0.560214850825006, 0.30307774901055123, 0.6515569564525829, -0.3680660265318471, 0.7199651060452278, 0.15610605847048956, -0.5276439531374708, -0.5090872945742959, -0.20685314486274028, 0.35962915988868127, 0.6534946690255399, 0.3147902065803467, -0.40647913026259547, 0.16931075276720162, 0.6917172102157206, -0.6076683787632171, -0.2336424398636395, 0.5574443556172909, 0.28382860531960874, -0.24962934286860752, -0.10979939557372856, -0.5389384709298797, -0.3104736951340286, 0.10616736554957776, 0.7954236452126942, 0.503136402081123, 0.4417275812619185, -0.6005424037719869, 0.2365535743618041, 0.014234355596804065, 0.1677204306760443, 0.43815995653185075, 0.35049357966998645, -0.8034501677122777, -0.06169755605229047, -0.16797023818704052, -0.3089313395633914, 0.1699996703509487, 0.5577598677025553, -0.0280295777410894, 0.12912355745818951, 0.4415252087244025, -0.6333980906735498, 0.3660328906810032, 0.37627671448445077, 0.4406906572082139, -0.2977870928916422, -0.5818407658265576, -0.2973502268730403, 0.6829048052667892, -0.5948312142166379, -0.2537500190209576, 0.5263225461661777},
    {0.6460754391647301, 0.621501768497227, -0.18133852769196243, 0.3379016721246718, -0.262297415766445, 0.026662480495916165, -0.44259725893351154, 0.15827953242590828, 0.504001648271323, -0.28046006588924904, 0.28728291465093025, -0.2371726535908738, 0.3780558249787326, 0.4321668466989202, -0.41597791776766935, 0.4797439031977674, -0.0006990486774757303, -0.3884600821766279, -0.5002087095873595, 0.16061952396504767, 0.4367703207163797, 0.7055097759842587, 0.22444318247304815, -0.4677034256788398, 0.15430521753442208, 0.8332839455996099, -0.59106165898105, -0.39251211497547805, 0.4691647453215911, -0.044528629922297995, -0.3370945859673478, -0.40953402290081686, -0.4642744409864701, -0.6629073664638648, 0.16593025146738494, 0.577429847169067, 0.646481748267779, 0.4251209677190308, -0.4738053056419548, 0.4297880878155162, -0.050938242061918965, 0.26192821930632404, 0.18765787840688247, 0.26947148373055124, -0.6713238187395476, -0.1268598556963322, -0.050325988404894835, -0.6347607135112897, 0.5009088616266885, 0.36973817396448644, -0.4616020508808096, 0.034638109449723245, 0.5227300339740937, -0.3612482282885614, -0.11298736398851453, 0.6803849886334798, 0.4827182036300318, -0.05792772172031029, -0.3680921897482328, -0.4056458115640931, 0.4756767203772475, -0.7447257565082581, -0.3247734269530394, 0.5991552196307935},
    {0.8346725497612278, 0.44307950314971634, -0.4141403343617028, 0.4841306005267925, 0.2199910133054924, 0.009914537519155935, -0.33022318556701785, 0.3260385409020486, 0.3809905008331741, -0.21320468768179454, 0.33242070326688894, -0.3981016224670936, 0.41007332717004685, 0.7071413376577373, -0.37664866812077974, 0.6505914209126472, -0.32994399199713126, -0.6590201542241831, -0.5292510188941449, -0.4544070008515144, 0.3410905716721213, 0.3671545071678924, 0.10574222919781702, -0.6263610045970017, 0.09375893928688893, 0.3501180521023066, -0.4257573891339249, -0.38547313866199145, 0.4023922459631774, 0.21074020280402866, -0.2940183278472219, -0.4706032504778541, -0.43179402212818, -0.5371428859415032, 0.28539407372764014, 0.3540505007523589, 0.5307593889194174, -0.045266615462512094, -0.5316830813226234, 0.5063761218293499, -0.008818340951234615, 0.11179188954155221, 0.19459209299755756, 0.19262152790595705, -0.32472224459035837, -0.09644283528622072, -0.3008176644855043, -0.6073260792516318, 0.32460225260552295, 0.0625437708649251, -0.544528483099378, 0.0549660681259226, 0.38886744920747646, -0.22784357903317745, 0.16525296810282647, 0.5199852456276639, 0.4934901721440455, -0.2985349488297913, -0.22555956367104424, -0.39593199746417623, 0.2613814049806694, -0.43610353210555963, -0.08513044823198931, 0.4657061033402307},
    {0.5176313843836142, 0.7492195504571547, -0.3163751766707578, 0.5187637614512125, 0.11029142767872695, 0.10200130899534314, -0.6625937693032745, 0.31581998676462947, 0.24805279112191383, -0.32304922578123013, 0.3375253901413996, -0.6012331031290212, 0.11943081769386778, 0.46115316376167986, -0.4562374549080363, 0.8510487940427246, 0.008436066766588281, -0.3203815288817946, -0.37099505317401493, -0.07090457617629374, 0.35912817006363507, 0.41157068945663194, 0.5324721187570757, -0.5624208337694764, 0.18042062393490993, 0.34678189914701457, -0.379624366629865, -0.6172834108837252, 0.29054270703610513, 0.26030442193324393, -0.2532963181287663, -0.3438482379884553, -0.5154289617286509, -0.7341942687183477, 0.28557547512166115, 0.47342430413316133, 0.5892594957481776, 0.11066065607444091, -0.46636070026828463, 0.4549270483150174, 0.15661189169681056, 0.3420315246440796, 0.20956047477202722, 0.15935746524742167, -0.6006024874497811, 0.08612879152180548, 0.02452928439013904, -0.3419112614755884, 0.30999422883856587, -0.10982061368721556, -0.6166929233677804, 0.1325836023704548, 0.5532637238442988, -0.3367482953918073, 0.19474511860285332, 0.36481881349633594, 0.5675943687494501, -0.2780543962112324, -0.5028789565298334, -0.46877811532154573, 0.6228156877911949, -0.7489347767445839, 0.03190423876551978, 0.8171262543611462},
    {0.2816156775555278, 0.07994978982978619, -0.19308664511920504, 0.3946167285831415, 0.17019772902064353, 0.4614308554445079, -0.5228379036712653, 0.18985724551870836, 0.39131446991798674, -0.22406662812208364, 0.4297218323460493, -0.6708091046275374, 0.1362785804386034, 0.3114308456050819, -0.4513129755919316, 0.5538445921705601, 0.12245402629242293, -0.29962394227177397, -0.5725790550730094, -0.10016597557485583, 0.6285771752011541, 0.49612339233962605, 0.4263794206324156, -0.48564425861598187, -0.011405071412452993, 0.5587343287944919, -0.31545490549753863, -0.5978062283598811, 0.7010283574095432, 0.18074122945727308, -0.5061229803146713, -0.12866486459613832, -0.8592557533197667, -0.7149431258213426, 0.38595523413161614, 0.3859883335262545, 0.2617466402646833, 0.22912590877018066, -0.38361130776723773, 0.09211586596176867, -0.07237508461246522, 0.4450560166166417, 0.387362576023587, 0.2867257794656438, -0.4857973085404471, 0.07629064893820817, -0.3044431728080228, -0.4135728085386877, 0.16050258593854308, 0.10818673158759934, -0.03659528460742627, 0.07888870343889555, 0.27870439709436257, -0.29861235426215715, 0.2983511970562633, 0.4198279774575424, 0.4936681608034314, -0.5247962506163347, -0.2953057242815267, -0.3305996473890997, 0.6673923636958023, -0.7564251033290912, -0.25487127043602137, 0.5597206247818246},
    {0.35761627072165003, 0.15055088648868983, -0.3652501211355726, 0.6141321121806278, 0.04431542563683659, 0.4525169876269593, -0.48052390874785744, 0.1687321140869117, 0.1107099257840958, -0.3252372764803695, 0.3620301852119692, -0.3555826500954458, 0.34451774800168494, 0.3711682713466917, -0.33442219568469406, 0.7184000275065582, -0.12343236817134727, -0.7931887535644949, -0.7013857564697572, -0.19081010449671382, 0.5383187144693189, 0.30486163236151254, 0.3485134877806482, -0.39794357968078065, 0.20497537225444898, 0.25812858620430995, -0.5273839681201035, -0.3786933098236054, 0.27919250713991817, 0.030752687042834938, -0.11240481876976349, -0.10624527064223324, -0.26324658046318605, -0.6113862982880142, 0.20784652253211816, 0.46425040020628106, 0.20238356198861326, 0.22136899966380513, -0.2716335365670771, -0.03916797845724575, -0.3344344177763337, 0.2208958670689849, 0.2840712934360481, 0.4449464214532312, -0.47145966901561864, -0.022379606558906296, 0.04226125965786391, -0.786356397754622, 0.17995620134601276, 0.19341809664439308, -0.22122726668163856, 0.43950582072708366, 0.22698646562019043, -0.2950574002928386, 0.15260499041670647, 0.5674804631794281, 0.6508360638244775, -0.4152769367303195, -0.45107534728670656, -0.5282863543412016, 0.7337778679537217, -0.49865301910641074, -0.24322428100939367, 0.5225014631841767},
    {0.0507433478457437, 0.32433167377962474, -0.3910747535702772, 0.44412105650874095, 0.044420042167117896, 0.36341171599087446, -0.8030251333709479, 0.42395894768663267, 0.007113675886677546, -0.2911483795059841, 0.21445405268139847, -0.33184589342782683, 0.43400322617666737, 0.442087576032163, -0.41928804051840063, 0.5524567633439931, -0.23966720392738025, -0.589733561394848, -0.6881231460020564, -0.3465228005196893, 0.3638952187454945, 0.39394723185190733, 0.17325650782783164, -0.5924792573825263, -0.22178205100622408, 0.5690159413038625, -0.7452148819472966, -0.19398529973971843, 0.3865474727731279, 0.05333429100104315, -0.29148751817196855, 0.13566925770162777, -0.24718724682206672, -0.6323745520295807, 0.4806435312094422, 0.367751804604201, 0.20147470419772862, 0.05485675257915145, -0.41992112881449606, 0.26960872079185655, 0.08347447743126284, -0.02680394343946699, 0.1298794689322504, 0.14371307051762755, -0.665784091620439, -0.23096236139665763, -0.4311807447676472, -0.6975864799447395, 0.4499502720363975, 0.14965985943139848, -0.5903954183024808, 0.3065882671660948, 0.42177527107325263, -0.1706806460704944, 0.23578912029751678, 0.4965769468236523, 0.3791698081713111, -0.336719560053075, -0.4711964914857899, -0.6269093161228283, 0.2821693335193396, -0.46554840253195673, -0.3374717554043792, 0.45399380269044615},
    {0.38535009810671544, 0.2622562140763787, -0.4143775698655233, 0.5649342759617673, 0.276083451402679, 0.21085763872150395, -0.46725709690547357, 0.6571582168050517, 0.22261412754014695, -0.42233065297835515, 0.323256367576653, -0.46340335766419105, 0.40907625355018373, 0.7855012990919632, -0.56061926013049, 0.39059033224878864, -0.20588856704830694, -0.956458660289079, -0.8241948803123718, -0.1546371259448103, 0.4290427315073374, 0.36749813547505816, 0.20452437289508496, -0.5051866285852635, -0.029156731599344003, 0.4305909735267686, -0.4539249721268135, -0.5844711096830525, 0.4295964225807226, 0.03949803209089276, -0.7387697673556997, -0.19250937898023862, -0.2830634686771046, -0.2977248555701942, 0.3983584251442517, 0.3047155135699079, 0.18893794585612195, 0.32097556280548684, -0.5476494368905125, 0.24313895566315905, -0.3856725702206638, 0.22290781614109842, 0.11607784426361527, 0.08119771416687685, -0.9023907420137268, -0.13268353761054552, -0.30805939623316525, -0.6976545250416988, 0.4322001739601015, -0.1120432236723903, -0.3672396872285681, 0.2972078876547252, 0.6009971151792599, -0.3416819601477226, 0.16984628897449444, 0.4115970156671898, 0.5306303208106502, -0.18184893215807757, -0.4578831539486567, -0.5159404367647684, 0.591637350632803, -0.5090151914642524, -0.4781590613822145, 0.24034129656098996},
    {0.18552754319463172, 0.08907188508209746, -0.19002181335091062, 0.5812314283046841, 0.26409229137937634, 0.20814043806648783, -0.23410866943065012, 0.34510407956887085, 0.006876282934355538, -0.614079053201396, 0.4466649992722648, 0.0015327956612646264, 0.029447786637115222, 0.7011570744865082, -0.6459247282763974, 0.5370424824910947, 0.11046092321847864, -0.6160309907173375, -0.5403140240061863, -0.5039563275067377, 0.6296650433556927, 0.5913613591274663, 0.5543942809829969, -0.717267021303849, -0.2566301026229795, 0.6170962037629728, -0.5603148745311065, -0.7161384951158545, 0.7180978389755454, -0.051597963699203754, -0.4171128716710203, 0.004617643921505066, -0.2365776170227789, -0.6654189097574826, 0.23830143950916238, 0.6459979053768883, 0.5486474058999186, 0.43548102265626565, -0.3809773420907753, 0.22743801318984297, -0.21994930892203646, 0.06933210539930917, 0.07328435774099312, 0.3142249216709762, -0.6413028747661325, 0.1349484191666429, -0.13157765810281982, -0.5517405777431452, 0.24283661115032643, 0.20058679513593858, -0.2549710230518344, 0.47793463316519463, 0.5324690840533024, -0.17441070641024567, 0.48241790180425004, 0.3471529529200228, 0.5755933346828112, -0.24746666683611332, -0.5096794809047046, -0.4894405177925359, 0.36715217158329316, -0.5772335461367315, 0.04451156577434553, 0.61085504265758},
    {0.5552049710257165, 0.30641739574284943, -0.04835631983352676, 0.5638685122756258, 0.0670538980188575, 0.24233260265092002, -0.19079498297365957, 0.2311329645472576, 0.263651431650541, -0.5921428258021335, 0.43922024278665256, 0.1937314820899125, 0.21071019671614083, 0.4443734733336687, -0.3593095177241307, 0.33975680012542336, 0.03562075516835197, -0.7149923527692632, -0.7108644770904652, -0.34679297932180636, 0.3558368300207616, 0.50774918969632, 0.6545216757885287, -0.5277249567752316, -0.04588481355670342, 0.4487170363448633, -0.8422559828601446, -0.4745467505569885, 0.7465046480366171, -0.29217408634862246, -0.4334876640766174, -0.054497581036375656, -0.31727132502744804, -0.43052236313268216, 0.22486962279093456, 0.6234855947969858, 0.4043167518481055, 0.1974063218798234, -0.48773366371009963, 0.06769341697446754, -0.11702882296926126, 0.10519319847917136, 0.20146658283078636, 0.028384550125972092, -0.7357752969980735, 0.11223441605194935, -0.08525505768180039, -0.38236352615880764, 0.5573578180543265, 0.0744426342510979, -0.20641110727542228, 0.35211258788419464, 0.41045199797863696, -0.20472209540879313, 0.4547153934360577, 0.5536577105593787, 0.26943899361699225, -0.5411240344604074, -0.9126572244268552, -0.665839160707369, 0.2237283949213403, -0.5732770416671068, 0.04495550355129076, 0.05589068222176023},
    {0.20723546754317862, 0.15331557143606153, -0.3018112488480465, 0.511894278802611, 0.22741882473184974, 0.4427301718075401, -0.48750041211970246, 0.4553777499664634, 0.5013519984205442, -0.6096334173870281, 0.21251986014560598, -0.36208853406237274, 0.420357939262914, 0.7986235542809662, -0.5254245261087542, 0.57883234790735, 0.0179575664127675, -0.6714923341661279, -0.7360877985730784, -0.1538725453774894, 0.5828888088403031, 0.4496638495045972, 0.29825520373495545, -0.17185675573174206, 0.07858677630051701, 0.442650091514268, -0.5325101755620316, -0.5496533936133173, 0.42292246866423294, -0.0934940012362635, -0.4369244755636719, -0.30142980464984404, -0.2812685494267975, -0.9035147461677381, 0.4958507783863957, 0.6209484039312289, 0.4503313624673515, 0.07157326261846769, -0.3463102614839859, 0.06020213680972892, 0.05581478240578524, -0.40339782992653966, 0.1742135225345102, 0.1133843943233278, -0.565243851286876, 0.28013083547313017, -0.134622687775979, -0.5583250552952737, 0.3592096053144302, 0.012904240599662381, -0.4148401268541605, 0.1563784493563427, 0.40776894810706027, -0.416681772596347, 0.13181735915758422, 0.4387835865349462, 0.5646003039357157, -0.5575991092612191, -0.5738051972782928, -0.3724278316784065, 0.4766962374775878, -0.5867647548160899, -0.08073006603037033, 0.3227285290983162},
    {0.13412909837025502, 0.5782448752701811, -0.16775285610091162, 0.14993413985921505, 0.10001916235912925, 0.7230868028169738, -0.4095241738354091, 0.6800285143772975, 0.31881245679061754, -0.16608767702855076, 0.17836507072845376, -0.3670583637370089, 0.47951881954461706, 0.463291601733206, -0.5094158989648794, 0.563963561486701, 0.035207949970265225, -0.5184897113998529, -0.5394536482104506, -0.007392446813747466, 0.36073699471929016, 0.6085035815352897, 0.4158066533026123, -0.24615094591237416, -0.19073660153050648, 0.3627840873169203, -0.6068209546285177, -0.5655739806061078, 0.32194741820349865, 0.12998823629465986, -0.560350746051089, -0.061257384862469316, -0.5170352837586929, -0.5590289503453716, 0.36139157803109545, 0.5240419994084292, 0.23267858690103416, 0.0022987438175244026, -0.4692303937257747, 0.14906705894786598, 0.10235006475548643, 0.2759774619013376, -0.0681848858060332, 0.10359052044158633, -0.5698598550966109, -0.2339130137769127, -0.3594913532632454, -0.5469596766534947, 0.5588126484722029, -0.41688088653093824, -0.01192418810564178, 0.17664205342062123, 0.5707861204356658, -0.639331656768662, 0.45507094416029, 0.5617177166464513, 0.6668081353815309, -0.4096641968881756, -0.39286167991784954, -0.22273183713250883, 0.45233785121575537, -0.4723961526532723, 0.03564993194485721, 0.6357554646106726},
    {-0.038485074773043415, 0.2570869374466092, -0.29787216350173606, 0.6545543355591696, 0.39696141909241145, 0.4504156300669952, -0.2739629261360234, 0.6466532324465939, 0.20320755568075177, -0.37024218765119987, 0.3932927536137489, -0.40784931714229733, 0.7653981022664897, 0.6876624746354536, -0.7193436831140616, 0.7207176904571383, -0.03764026138703249, -0.651088947629696, -0.7001707680335142, -0.29265928053073637, 0.8054509852315501, 0.7681480411712659, 0.46347447086353205, -0.464274774343313, -0.020326834184179333, 0.7638538459933955, -0.8207645285797283, -0.838535339661854, 0.451461484588285, 0.13634987618067024, -0.342322760173857, 0.14048164593621879, -0.4570899315678885, -0.47910593813645674, 0.49082400704830903, 0.37089299041268725, 0.07495221319146185, 0.12098027452036053, -0.6530116175925461, 0.3870777620342013, -0.017828588377459095, 0.25527236920015695, 0.16096260352450178, 0.32077295641179726, -0.7006417459191331, 0.08059649422405013, -0.030111097998702797, -0.6550263585118347, 0.411062866451073, 0.02292420628693812, -0.376757847705781, 0.1653872853278343, 0.409014031407266, -0.512701629139893, 0.0656699962874724, 0.4164831296746025, 0.5717984552701668, -0.10594582385831845, -0.4312844989256062, -0.03552761930960022, 0.3695607866290427, -0.6864765864186123, -0.48893378737611676, 0.42402771646687587},
    {0.22234567348687903, 0.30337252477236226, -0.4329708345560083, 0.26372785261567466, 0.49404025656671513, 0.5192999369142463, -0.39166067344530225, 0.3071796503081991, 0.12344898313669096, -0.5033952971341097, 0.5972716673208318, -0.5390264840681623, 0.4216760787120102, 0.8016312710101903, -0.3808631732894101, 0.4140413132627645, 0.11529432420696177, -0.37395002348036405, -0.251963669280392, -0.1722357847747962, 0.6577024319418657, 0.47760213362025944, 0.51882713697332, -0.30368307530893396, 0.07720822251178294, 0.8040225098069687, -0.5761928665883449, -0.3459354629117289, 0.7925771457003925, 0.3194143546997279, -0.35127918782251727, 0.008474195001983096, -0.13695981062840915, -0.5759153549677366, 0.24008044455915606, 0.46666764364754376, 0.342848273500185, 0.1109755086579219, -0.504381960849906, 0.198045244203253, -0.002323626557369849, -0.1942135229626407, 0.04968915329673668, 0.24718500912963678, -0.529227367967547, 0.05670921634112708, 0.1718599659457305, -0.5801600604792979, 0.4120625407367937, 0.16960113133873678, -0.4433029578193614, 0.3888025897311633, 0.535308359438778, -0.46952807788054535, 0.2441826147867537, 0.45045335477105974, 0.7718254680386932, -0.541678103852234, -0.5303006891672865, -0.49480673961627325, 0.7495419472852152, -0.656061948115377, -0.41530249693799887, 0.5551006990813467},
    {-0.06607443984401963, 0.5413976628540418, -0.5456708073731086, 0.5153675172849211, 0.07887804096332218, 0.5258707138115103, -0.7743454470954381, 0.6686091424474341, 0.13071766063902382, -0.4717840635092957, 0.5439188538966014, -0.3523349734118129, 0.3624530684411334, 0.5551165484527538, -0.5540932834447296, 0.4061255089021315, 0.23831931893317337, -0.5909519983998275, -0.27906618239236186, -0.27297142738404007, 0.6141271297698474, 0.4938741860600054, 0.8532870091247052, -0.6626155816255276, 0.1918716493309378, 0.4792003833118625, -0.6944154668352475, -0.50510722492969, 0.681781892320524, -0.06128016302726585, -0.5106730552398673, -0.19684858870009553, -0.26080072437536594, -0.5026290774972306, 0.4559424583964292, 0.5441372444334628, 0.13148338092937828, -0.18335553839869093, -0.5581841147357351, 0.20580097641565737, 0.33378761326555695, 0.03180822961227238, -0.04626600598693113, 0.36121553023839204, -0.5926426900697633, 0.05898461511130766, -0.11825582494841327, -0.7962734409983735, 0.24051329318423403, 0.13350272013735465, -0.6111672533293643, 0.3415062996372889, 0.38597333798297945, -0.6328440363846632, 0.15761574729024524, 0.6089060869989216, 0.47857398939605206, -0.42913519802425465, -0.6267700051608556, -0.472790813592168, 0.5245959548456312, -0.7333356447372732, -0.3335713106119947, 0.5833305713216668},
    {0.240557915192244, 0.12491213929773477, -0.34690086426534894, 0.6028157587087405, 0.18321003199991007, 0.3140547287194053, -0.2456664771017411, 0.5503755633978173, 0.29715545136517557, -0.4182822165766827, 0.5323627217757437, -0.3516081659629298, 0.514122663386617, 0.4788583438145951, -0.3818473577333849, 0.6500916509697783, -0.008753056160739316, -0.6200860541035073, -0.6689306614608054, -0.3891981031407214, 0.41996325917919664, 0.8483556441219819, 0.7738967453567369, -0.2018149191104105, 0.018281933956290634, 0.4677843384402444, -0.48513845394678917, -0.32702773562762344, 0.2654169226842388, 0.2379937544054509, -0.6934940950491432, -0.16895574408972566, -0.5105827717317634, -0.32376546249708843, 0.6589176984026138, 0.5148976619140886, 0.5144713796827047, 0.14155498371647796, -0.4618494231812549, 0.202854676737071, -0.02649461181430041, 0.04206448930086209, 0.10396012025999897, 0.5827365916942435, -0.4926146140825707, -0.17081274753659176, -0.009510461334261835, -0.7393217794468563, 0.35007383612478976, 0.018478834983213385, -0.5834954676728068, 0.47372067021265013, 0.4287606471040334, -0.8647045183585422, 0.24321944351389083, 0.3273289631897669, 0.47435775195581104, -0.3861580288152114, -0.1139854617482662, -0.4523318246575463, 0.5519656750634886, -0.77623734625184, -0.4202287345268489, 0.43564782078810926},
    {0.2994727388368566, 0.43823435248521464, -0.48655378254677195, 0.5314348210044111, 0.1571935635441434, 0.2556524987981254, -0.3854723410236726, 0.33371019205162744, 0.7171345765840841, -0.5262827747266036, 0.45826021057043986, -0.41039665049974866, 0.3803800552371227, 0.6199821492167791, -0.5122742858068713, 0.6780101452017003, 0.20488203596559995, -0.6706386661152374, -0.6274165952245201, -0.29094935592581267, 0.7210732202316013, 0.3607847118065439, 0.7138155746992605, -0.2865570594761471, 0.004787677435124015, 0.43987179162881496, -0.4812203169059112, -0.31740393908102577, 0.41119197885123787, 0.17107528144864442, -0.5580717459836639, -0.2467589315383737, -0.5200721536203742, -0.7666564191179095, 0.6219835699815749, 0.4560623376778365, 0.5515932170805207, 0.24836915845809324, -0.35250417292158437, 0.16249751125469925, -0.0953690312383227, 0.1812899580306545, 0.14726005836769976, 0.1653877574273927, -0.4222019951469149, 0.07701911051470099, 0.08428582979843974, -0.66835560844658, 0.5402451578814546, 0.3094529020629114, -0.4493612512121042, 0.2817140357128211, 0.45962909187519496, -0.8255779463426418, 0.43556907221603025, 0.639069455351717, 0.3880587365798915, -0.3093356618670348, -0.639815731215375, -0.5674308898803438, 0.545730172643987, -0.3284470402242713, -0.271669901260679, 0.42058873204396546},
    {0.1412635821853134, 0.2973235365329804, -0.26232950180891507, 0.7243326751886109, -0.026277049577794247, 0.3792096821800094, -0.460829100052883, 0.44313229607917304, 0.5525826064069486, -0.5364275811707034, 0.26843578843245897, -0.5046989574205872, 0.025830672895552846, 0.4439507815238295, -0.7004806853521509, 0.48437261769597445, -0.08801823605608032, -0.58750836461204, -0.7371681201055998, -0.23719132090548842, 0.6359767170284473, 0.709443953281128, 0.6921255690774474, -0.5355584512039622, -0.12030685257789682, 0.46347660105573607, -0.7952944902519352, -0.6647025481959913, 0.2588628208872269, 0.2383541810396327, -0.4835528351969216, -0.14233972879022663, -0.2485234674231101, -0.31468237196319554, 0.49834287701011853, 0.6345946058033742, 0.03637276914289719, 0.03430528351860059, -0.5314377937449314, -0.08315741052531184, 0.108279554791369, 0.2544271843050061, 0.1842117984372803, 0.10989901176951127, -0.8036178444798798, 0.018401365792219692, -0.18423477058514795, -0.46138510155094714, 0.2954741970272082, 0.22683466569885116, -0.3262182433782538, 0.17466364039999047, 0.43933862869911683, -0.6098464480535158, 0.34027202734789275, 0.4171760536535298, 0.452127835605753, -0.5080425303108643, -0.5904961866562294, -0.34470953656383835, 0.5258322239790635, -0.6103074336549698, -0.27827160389998523, 0.4216980345811044},
    {0.5569794807836801, 0.21122965967101767, -0.05520816462869537, 0.6541085795049056, 0.2352507586138575, 0.3742862858127526, -0.4401413326367629, 0.48994469147322184, 0.20858290175934083, -0.40480578671458006, 0.6197138137957398, -0.4491295668218239, 0.199215235750706, 0.6362246171512389, -0.6680404249815758, 0.540789214518992, -0.08916641564232898, -0.4420888095910531, -0.6802217511989955, -0.18574606104282781, 0.42284964135855624, 0.3275943427901798, 0.5152192827725052, -0.5037244321632771, -0.16264674763217898, 0.5937549857979861, -0.44495582893393415, -0.6884025650983708, 0.5083494774189095, -0.13789626814839276, -0.7478341120293048, -0.2776534389628515, -0.36092789723835794, -0.7022949946630901, 0.6436705263880836, 0.40269462669041683, -0.027893706443357362, 0.042103249669564205, -0.616696918941753, 0.0453753927429557, 0.1347987555004371, 0.3907826574450431, 0.11691036149910068, 0.6530632552591534, -0.50742188016269, -0.19838749740668968, 0.018760477291105873, -0.5448241291608775, 0.26948023202009835, 0.21520847765308826, -0.494205108339177, 0.3009896742826398, 0.5529218977064944, -0.4634211331180528, 0.14135417356541014, 0.5107106454635743, 0.6044385682771283, -0.5409124473712528, -0.7631590112561664, -0.19171882289513095, 0.35336986300022166, -0.43078641123448846, 0.0669971606591635, 0.4451753917237905},
    {0.34629655761162725, 0.3941268369260894, -0.2841974342758938, 0.816995147351013, 0.19395503483801252, 0.16478721521491788, -0.6139475978014814, 0.6057057768245777, 0.04421909555092503, -0.49215223066040087, 0.11939716354124202, -0.39783665648512606, 0.11366656971074796, 0.5762899753424566, -0.5915085293975852, 0.5832040809289096, -0.03918991513048236, -0.7262631109299563, -0.6899268394837059, -0.35228807685523117, 0.5531234597326646, 0.5656297759303256, 0.4475705906185445, -0.4288313539415337, -0.1625402934254638, 0.6592331564568008, -0.8422152526076688, -0.6811702306032453, 0.5318541255313303, -0.22702368349009333, -0.6495915974698101, -0.2575386619658918, -0.3749543182561157, -0.7662315654867373, 0.3392327463406071, 0.5483104840393944, 0.4229230279958788, 0.20676025744680682, -0.5276339694238183, 0.21843087348041415, -0.029845831335693403, 0.3399192375089003, 0.06240666463050208, 0.789526173120382, -0.4387930735189547, 0.10529675871185419, -0.25330584407203094, -0.755688679045552, 0.1956772444351223, -0.14456317976681862, -0.48833406274570823, 0.3396732111351907, 0.3916163710104078, -0.6274158476115808, 0.10230529634190959, 0.5123842507728547, 0.9494506439124957, 0.08126350737007335, -0.4018365164594837, -0.49266473794910637, 0.5926628621903377, -0.7296677777131557, -0.3535769851718942, 0.3700876464118312},
    {0.46995728198741893, 0.3661165807864553, -0.27446536930340054, 0.5992070531931037, 0.2768868902763402, 0.3463058541243399, -0.40407171778282863, 0.41019477819099853, 0.4185158305867403, -0.4827438936522099, 0.4194032379962595, -0.5181127003806032, 0.35676955110423947, 0.7208574332355462, -0.4475200319758123, 0.4573301556224896, -0.005657810911119037, -0.5266422897771423, -0.45758788795301686, -0.3892720696259633, 0.5439031404696284, 0.7271681606385998, 0.5622191630354056, -0.3650786348812423, 0.03319502502799834, 0.6549934420697267, -0.5713008411706065, -0.6410077558268125, 0.3664895114440277, -0.034426336726396854, -0.5680441868437247, 0.07442741957103338, -0.35041007953369646, -0.5366659696901449, 0.327529490049318, 0.3895587798695222, 0.31501189522242257, -0.04263163999674739, -0.4391221495274837, 0.3269650579807298, -0.11715249608168248, 0.15601152543336136, 0.12707165146592225, 0.30690665332211015, -0.4725024216437463, -0.08502036952804984, 0.09899417105277072, -0.7182449829609053, 0.46781138878353346, 0.022250928154623376, -0.5137776572496733, 0.43307889093422197, 0.5551012278875233, -0.30502181994050925, 0.02836815539045279, 0.3792440162783712, 0.5676141136967032, -0.42254299417764596, -0.16284829694361744, -0.44301574787818104, 0.6089534901898542, -0.4378485851755384, -0.5598658195239348, 0.40080785774150524},
    {0.28663750801461, 0.3193031192105138, -0.08548626485763479, 0.8733337819817063, -0.11634363238262437, 0.16039633541913817, -0.5629265553223343, 0.6436532197977808, 0.3255990320803859, -0.5602101141056683, 0.6042250473539861, -0.4483459024546841, 0.23138697844884074, 0.42738249104016374, -0.581498125670656, 0.4845446639139821, 0.06783958632051153, -0.6757173817243612, -0.45915321215259564, -0.173663103849472, 0.6724314054991106, 0.5530400192829543, 0.3729057099213094, -0.43231497830257176, 0.31036747115787733, 0.36794306487009537, -0.5945013148300445, -0.7392612314239075, 0.550994637334319, -0.2593171525890328, -0.306993099889464, 0.09698839730795676, -0.6533194712186554, -0.42609711480312834, 0.15224218271836265, 0.6091214202781582, 0.5486566430040628, 0.11980590864666169, -0.6343404214507352, 0.37411394160363926, 0.2778135181847506, 0.14485998954474666, 0.1665345277093888, 0.2730788692794484, -0.5256537171926047, -0.10175597862579167, 0.04512232574699362, -0.7060437712482416, 0.20216626104173868, 0.05396705570187177, -0.464838642665547, 0.3805387363304611, 0.4733868050560912, -0.6726648408260033, 0.0426599382707758, 0.6120856457481679, 0.4101840725748672, -0.5063455335375712, -0.4123386436457543, -0.40629585270582813, 0.5741010763832036, -0.619993431510336, -0.3544928219700753, 0.4177345600375362},
    {0.23663707824910912, 0.3309854227539952, -0.18205540407837806, 0.5194857522984514, -0.3492832797819201, -0.2004646156792111, -0.00423062000324699, -0.14699469892580572, -0.2204992856452203, -0.5562973879021892, -0.3133219531393294, 0.5102011459868389, -0.06605916721331645, 0.11535698155905708, 0.09000863850910654, -0.44505862970909665, -0.4438100034722366, 0.4417930480220366, -0.2782634702324046, 0.13295718186093533, -0.11893129160852552, -0.3349264164458684, 0.2681596622250737, -0.31479633696786075, -0.49937634084782273, 0.25545776801155895, 0.24752348781592926, 0.21986255288631043, -0.0021239754040035855, -0.68030668474716, 0.3898677765176823, 0.21125928046429196, 0.10092064514663221, 0.04416438789975027, -0.07523837867778263, -0.3570464384732089, 0.043645542319223955, 0.11411939677692286, -0.010841276356902171, 0.27888447793602045, 0.21178833407406186, -0.004523538662084976, 0.2661674204796252, -0.31993303847017257, 0.3273637966677158, -0.4501312476610846, -0.5123135419920729, 0.0610067642563719, -0.00549740162323012, -0.1514175295384286, -0.11885672472037442, 0.42199209348231903, 0.2654863121960661, -0.3933509182146387, 0.2086841785675121, 0.38295414129075805, -0.19849303658700457, -0.43974591016170794, 0.1518216733639839, 0.16179695691933402, 0.26019423924587276, 0.38788716628243675, -0.3525334473779224, 0.3065293064173239},
    {0.2882284202161086, 0.09030650828758033, 0.21462689133735402, -0.1418291522375337, -0.3331820496221729, 0.017911272079808797, -0.14848798836083596, -0.0453828768638662, -0.4609173130318373, -0.25547073209626964, 0.03645902623060686, 0.0920837214180254, -0.12256742565518379, 0.14139004018311196, -0.20529564804226347, 0.22731311063892334, -0.17161437980313163, -0.030464279014499003, -0.16340736815797918, 0.212068148417261, -0.11751411573469796, -0.16834400873855615, -0.0320951859469645, -0.2530739293797203, -0.4777161224626571, 0.009794588101082908, 0.04576792859250766, -0.22826791489494525, -0.08574853599418206, -0.34446369113267916, -0.19114647897114084, 0.20404916316798088, -0.2905678013940302, -0.17320518114824146, -0.12181807162830513, 0.46348948098881865, -0.1577599955859124, -0.1292939313022552, -0.36628490773328215, -0.16724864211274107, -0.09821125054813555, -0.5847687682409622, 0.2610991983307283, -0.3939243766738073, -0.20864421153213664, -0.2243590827179384, -0.31839618242076356, -0.17480532317031774, -0.08236915349511975, -0.1511423002624528, -0.3292605787081768, 0.08698745247322828, 0.21504888375570222, -0.45019148343258103, -0.19966755169434716, -0.05095753129091951, -0.05326051683674646, 0.14791142836215115, 0.06173384782623282, -0.2110390328770297, -0.034991760875575526, -0.3224295667245916, 0.2361614130875547, 0.20747599145507237},
    {0.3423585598009235, 0.38748524792907807, 0.10066343774839806, -0.3702905744749105, -0.43221270138119594, -0.7253598681894062, -0.5160879756142652, 0.06262462906063443, -0.36938984415958126, -0.36965278807555946, -0.13492006458589825, -0.27906406801060446, -0.19935418440283154, -0.031354595362879704, -0.2327851310019119, 0.024769354506454618, -0.5003012918442968, 0.4153280973574689, -0.23644074371578339, 0.17834961067149452, -0.15839864980306517, -0.522203947025402, -0.6014035904188196, -0.304314322781018, 0.047505000001868365, -0.41705843992148406, 0.2754014426473749, -0.25418402118123423, -0.29693129562031606, -0.4890776833388705, 0.4241696266262963, 0.10141586442135993, -0.21168559933134026, 0.08450037984005637, -0.48417814281397975, -0.2271321172172488, -0.14066045755232962, -0.3748136158644628, 0.24546036622437653, -0.3250124553176716, -0.27855502891056855, -0.5286220391925052, 0.07211000260919846, -0.24617579632053474, -0.09569800550577573, -0.3359627629329408, -0.5862868734200525, -0.01559896765416641, -0.25153920561754173, -0.017291715368152556, -0.3813906703930524, -0.308486575940725, 0.014433196219823625, -0.12042975982602373, -0.49596013496976954, -0.03503488355290512, -0.2458848425661473, 0.03279983219083233, 0.13178440728377983, -0.3435942556646993, -0.47415434391589556, 0.15999003910361148, -0.16009211257701808, -0.042542449196650955},
    {0.3024541974487724, 0.334940010271882, 0.15510463088658938, -0.2909218487957936, -0.26012675998394275, -0.34968016656303574, -0.36372578102829034, 0.06930106560411249, 0.27951154339610235, -0.16133793143819009, -0.3739293110221937, -0.2293480355997759, -0.015502187760744728, -0.13050535259428483, 0.21635817361900841, 0.15247912310944828, -0.4835334428807817, 0.16214892685456445, 0.36283705509955905, 0.35600715138050565, -0.06201296722580051, -0.19891174296399564, 0.06297565878805027, -0.19427788165244392, -0.5168850069533805, -0.5849033394580564, 0.15550592008763375, -0.37413481018076944, -0.19878132756234582, -0.32012963448371884, 0.08436216945831683, 0.3148155692742507, -0.27014554271841873, 0.2703554936226792, -0.061935935084326266, -0.029847719960788457, -0.2590851271518222, -0.05568418220028961, -0.09751434114978726, 0.17901542030668247, 0.028812001460363702, -0.5704787024710093, 0.60460533936757, -0.1027884068960773, -0.2588448731739154, -0.2326211212834882, -0.3133182479708223, 0.07253261648551536, 0.14388624520317367, -0.22417542875157725, -0.29591041650447075, -0.09751761989545103, -0.18244428591014655, -0.17846073247105976, -0.3204864590995896, 0.21004102770890218, -0.31639322379236245, 0.011755983083228679, 0.007861234813080164, 0.029617311750723872, -0.56730274486776, -0.18396092290668095, -0.3188290506966012, -0.19386653675686163},
    {0.25495063132525264, 0.3331411364579822, 0.16658941167978641, -0.5942870616513604, -0.18485098243483553, -0.6192861763151918, -0.19505612206156023, 0.29699186083267337, -0.24421326631904874, -0.12212051532298628, -0.1880221545225739, -0.014185120262957355, -0.39401618951071155, 0.33437637226005446, 0.10436587036933678, 0.2220449150514795, -0.022909024737877502, 0.17890896020854002, 0.4523705829016734, 0.022693974235042727, -0.25341921013957397, -0.5224644602250218, -0.44067033369234776, -0.6307286857532226, -0.1770944176996285, -0.13614565988245778, 0.21470298317837222, -0.42014720313114295, -0.38237437872718577, -0.27013368119018405, 0.38302882072798955, 0.01026652063876871, 0.269437862818438, 0.20983169085736325, 0.054866786491440535, 0.5828687311428272, 0.24065949321275612, -0.4873835907831535, 0.22755201085855684, 0.01294626214883342, 0.13822516588491351, -0.3162879750724727, -0.23851275299330676, -0.2735688043482852, 0.024822953846611887, -0.12537845512244652, -0.18166919917021257, -0.32217028439856504, -0.04764614766174997, 0.4473897137748916, -0.33658027878520375, 0.32995466328206713, -0.11324416908906824, -0.6830870346617268, -0.48067131633502175, 0.0684713309617347, -0.15552631379046802, 0.11995443930477842, -0.025734437959081185, -0.3452257920140054, -0.7109986361059064, 0.07079450522687854, -0.08104629953223091, -0.22127459693384854},
    {0.3672106787972567, 0.026429796569922264, 0.25009387431293517, -0.2508789905688349, -0.17013635003692568, -0.6528275703082888, -0.3820623221996153, 0.17565609013568576, -0.39923229675055355, -0.11123980704502162, -0.2240929753540626, -0.15564323505642885, -0.08117718132475085, 0.05532719048460755, -0.2662685764979548, 0.13217413898625893, -0.17071384914458815, -0.4630543017585423, 0.1991321975818462, 0.009244377338769604, -0.3842029278829928, 0.10261507010924403, -0.35417659847973126, -0.3438702598643543, -0.1805070581524603, -0.4093225676588747, -0.28196495314668535, -0.09762598155506247, -0.39175829033332144, -0.18451805589204276, 0.3395199584731712, -0.4036554627873657, 0.178623060444329, 0.10482526354339497, -0.3495254542362747, 0.21255757980592177, -0.16174704094949885, -0.6585705176287499, -0.035110270100132464, -0.4000959059695762, -0.19352970023649968, -0.2498673827424114, -0.06747385488452105, -0.27592628096471683, -0.003675829638540055, -0.05151669254294308, -0.31062955228261663, -0.2526123570685443, -0.17937327390725816, -0.08642212174234598, -0.3982446355955141, 0.2477261167481815, -0.2859198046854407, -0.48554601432062217, -0.01951556214289781, -0.06912823978979114, -0.13441183731618003, 0.10838047811180158, -0.3847516025209058, -0.2628575319425868, -0.18382193986522574, -0.053916691708825966, -0.3096042428352701, -0.183437239415223},
    {0.317547595235768, -0.18767242140982832, 0.06933936628436715, -0.3535845776343971, -0.19682652713599003, -0.7788631643539017, -0.3018865698735634, -0.04196851195642592, -0.5560156343540706, -0.30312300559189587, -0.5742463745830098, -0.20519921471867636, -0.05349802312936981, 0.14604187333816213, -0.3132112479095403, 0.02668751912233528, -0.2960991127873478, -0.4253111337601296, -0.017952825927650698, -0.05542765476306338, -0.43615852928771626, -0.1957520029082788, -0.3156461272524273, -0.5979839823074791, -0.2765662068018866, -0.09543330142846816, -0.09977848900945518, -0.179446907054515, -0.2708778907065245, -0.44954377797477735, -0.12702949565006852, 0.14034615202766607, -0.25449155150691805, -0.26526442017034774, -0.38164882668590344, -0.3291724890627889, -0.22683221538345646, -0.36059824946775293, -0.23513182585453044, -0.16099310187612087, -0.22352059698666016, -0.3886611843319029, -0.04908513167453733, -0.705249930342045, -0.10953491895912058, -0.25003487550256126, -0.594929527559982, -0.17658864528944843, -0.3377811093162146, -0.27502891088933795, -0.4363851102719949, -0.2104973874613006, -0.3654977718211866, -0.6907450394893103, -0.3205836385314776, 0.08695858890894893, -0.4131723044380794, 0.13136339116497275, -0.1902082686297923, -0.55734133456416, -0.4177641127039191, -0.12889350077984166, -0.0874126593197109, 0.03623532633607336},
    {0.3531161415094947, 0.04621407703300188, 0.1346384563887792, -0.19248454748963528, -0.056118128591067226, -0.2440638271181736, -0.15986244669573213, 0.11013265479416424, -0.5176344348583035, -0.650971159733901, 0.0028224709465593206, -0.20238139461688306, -0.4116666978783901, 0.06495097146837459, 0.04304852026684899, -0.010972183330217272, -0.025512307810966417, -0.009436564389298545, 0.2475135673464104, 0.21172084545966727, -0.3350805193725423, -0.5761499122781639, -0.09931952608444858, -0.647976601143177, -0.5260946569265991, -0.46416615090720564, -0.10234547972460131, -0.10482270071563453, -0.21199332150359917, -0.2723986143961647, -0.21739099083095806, 0.1842792177503739, -0.3281459443369134, 0.019116566040716893, -0.2883457102849211, 0.09399372465466266, -0.35059212939475126, 0.08349108804648823, 0.09646565732424445, -0.36855041769354896, -0.3199904172483605, -0.49498186696052415, 0.20284401307120603, -0.4291412228864659, -0.12711285884207402, 0.07727551061856106, -0.4426524333008776, -0.02853660622734622, -0.24214645878118393, 0.09209357716161364, -0.3202717776779929, -0.11549239071629122, -0.01717056692762238, -0.5078551465893326, -0.4625817370158286, -0.4234240538359794, 0.06373176612076964, 0.08357468351258572, -0.1679840301684703, -0.1787095480575117, -0.28961096984768275, 0.03330334901167447, -0.38613675000401027, -0.3093118886994567},
    {-0.16129519009988794, -0.13173975813378028, 0.08462420913642046, -0.20621366667171712, -0.3195849715329409, -0.5684009190867386, -0.46255896707394417, -0.2716018317963464, -0.2871626160276754, -0.4832679782398686, -0.2824010606440042, 0.003372849313838711, -0.09371150653234435, 0.14207228933268035, -0.23437252303473743, 0.09306703877063884, 0.008220996188937589, -0.07767800328022115, 0.03624502787590078, 0.09343149919756749, -0.18895033000001005, -0.4689380274623911, -0.41335032502836155, -0.6972082271502554, -0.4513343804630952, -0.09862390548161908, -0.050273900018043785, -0.10060783993110822, -0.42851954178243323, -0.5369462161411555, 0.061033286040160825, 0.18741005932873475, -0.07807701585247513, -0.07706338812983901, -0.3800750553101645, 0.02085294404460279, -0.16988431561880563, 0.07337031375499839, -0.01146781505260371, -0.15068458808291682, -0.2517989754213487, -0.4808522089648257, -0.217015490269319, -0.6625554632145833, -0.182020590575311, -0.3419580939163945, -0.19213681199868338, -0.3822543672604972, -0.40412914545435197, -0.1700202591727257, -0.3706122541101667, -0.19840383483664498, -0.004920531690465517, -0.6225382200014159, -0.20787169755898552, -0.32015851679312235, -0.4561959550970232, 0.1156224200158392, 0.06975839687648255, -0.4617506742876261, -0.19839100028532874, -0.19215609369472778, 0.04863355469320951, -0.18006960648297174},
    {0.06449967487022921, 0.1714419062355289, 0.41479519754066635, -0.07961895750862101, -0.5823783468605246, -0.690169473392863, -0.3439728654857288, 0.2653352468603306, -0.46569493486577235, -0.31920268729830176, -0.19955199847283472, -0.3652628643015323, -0.3008450931508682, 0.056091105444524926, -0.28479378839599523, 0.005357575593168959, -0.32364702022990693, -0.2262341450288285, 0.29801355048712785, 0.13664353659674802, -0.3140831945928176, -0.1541311762799192, -0.46734091631632424, -0.48882715833077917, -0.12267655955947454, -0.3968965473617232, 0.12752730346463212, -0.14926427011417268, -0.2974544657299015, -0.013341987836670972, -0.2412144069132287, -0.03865057061861146, 0.030670784064089, 0.4011022884316451, -0.4424982596176199, 0.33423589620463323, -0.51992968723016, -0.3766446477036255, 0.07028281444573654, -0.3353327892174328, -0.21647419843501256, -0.3939238062536098, -0.165429050238432, -0.27583521799946487, 0.31816505036114967, -0.29981295601210245, -0.5403367679046243, -0.17586999802214368, -0.10531459893080333, -0.2756693052455206, -0.7035967844323435, -0.25982458744799414, -0.2910913668621442, -0.39319206128446693, -0.48536270023101824, -0.27578816738583123, -0.3481870511862101, 0.0040545116530223925, -0.2404757919155872, -0.2724118929791179, -0.5025582154388795, -0.1371738500151013, -0.07292206879200525, -0.3147791656520567},
    {0.3264221377745138, -0.27311365271659344, -0.1185257452551241, -0.24226881206355128, -0.6792131359563498, -0.42153083760563825, -0.2663651307972257, 0.036454237936612614, -0.4645623287389418, -0.39972238948755645, -0.021963999127068205, 0.153938092478863, -0.33484603685920966, 0.0827404264922761, 0.060232782526555805, -0.2710986503124076, -0.41478744590934724, 0.06874543479385675, -0.011395278123772062, 0.05080008569220699, -0.5068827819031639, -0.25412176868397013, -0.5858205754876215, -0.44581182348958664, -0.22130976062793514, 0.10661051623971311, 0.136616037022765, -0.10498383751583672, -0.40864938249183985, -0.5869379278222914, 0.2214822434653854, -0.15303418463319363, -0.09170383577390216, 0.23574373739520474, -0.19856371743659706, -0.43597429060617676, -0.6785597096163352, 0.22531160493010044, -0.38707612989771417, -0.11826439237265395, -0.12158819004033118, -0.27710549282077235, -0.16117999944528585, -0.43576412632710737, -0.07889879880171427, -0.4207824957820388, -0.0712992109628542, -0.1382471821076026, 0.038406878059972956, -0.39678813494689913, -0.3031385551005236, 0.00870822552189643, -0.22491954765639452, -0.48644510048584816, -0.4584632612073653, -0.19399757889313646, -0.0923862460282134, -0.11624683412384516, -0.02810096582030281, -0.0359133002465416, -0.1508310414211266, -0.12622979771593054, -0.4763713849714345, -0.07445303286095699},
    {0.26423619383853303, 0.060083076073618596, 0.09981469090893669, -0.4865705475518393, -0.8734559530093929, -0.4967953234356828, -0.31681883677966693, -0.04549349698142173, -0.4988977746970107, -0.2808359090137212, -0.5397238754321856, 0.19137102214491167, -0.45163436865060685, 0.1037366731914923, -0.15957438609138813, 0.10776758464602389, -0.30989533754731263, 0.033485880669136006, -0.08127285720367555, 0.19676687711320084, -0.4601756107562271, -0.37982640811796736, -0.3543163486590197, -0.36717944728711405, -0.42934226528786373, -0.23850831424758726, 0.33445249703568325, -0.23312053627588103, -0.49013356829517285, -0.41706405099355903, 0.2478800458496037, 0.0018846514653006825, 0.13936564186188843, 0.3044952197441407, -0.40034151006541563, -0.3266083086338551, -0.28229279096840376, -0.4057643305738679, 0.048526934092323566, -0.0977276806628103, -0.19789230092618632, -0.4385584846481681, 0.1662362586333012, -0.5248671799294649, -0.17035709791734044, -0.4883066834991221, -0.4582540484376352, -0.0017307689029232658, -0.4133374405826896, -0.2931521147550848, -0.4518152312292518, 0.18428162140858842, -0.4155403110486228, -0.4623373285625358, -0.5306198801764533, -0.19667281487338287, -0.36653958017935323, -0.050785230379862954, 0.2596236134494327, 0.04371153188130902, -0.4601603171211793, 0.03256794469123522, -0.13373611756880774, -0.28408499026979095},
    {0.4474818706263367, 0.012169050911882985, 0.08912093014412714, -0.3954799199905509, -0.6047543731031157, -0.23484233128141807, -0.4127739055237823, -0.28855554656931937, -0.3153100184777043, -0.6680500890266154, -0.7283599163821373, 0.024738157619794428, 0.033983869531238234, -0.3485106304761428, -0.2228008883238031, 0.00844813608478079, -0.1420664453768055, 0.05992998530668318, 0.24138681048978025, 0.18140421893457823, -0.23208981146474872, -0.5895380013327689, -0.6304537025268334, -0.5054072852199399, -0.5561922349684888, -0.4645293979256877, -0.23050896073179766, -0.3657862804536383, -0.7039603579304662, -0.30624606977768815, -0.05949698392413652, 0.2612454482714237, -0.20908721619464643, 0.08761057554087409, -0.499328861154993, -0.6327915301693289, -0.007221990740328363, -0.3838707947148344, -0.07289023425668682, -0.3704133273213262, -0.21087546368778343, -0.5412201922663694, -0.22487675660661322, -0.6457218774233559, 0.014195328432384934, -0.48089804473805775, -0.43966831941431805, -0.2671354635516148, -0.25929672586842073, -0.4368721563834889, -0.47663583705325147, 0.08195251762536934, -0.1374351511064732, -0.387407622476527, -0.6362320289037885, -0.4132842680597407, -0.32693244994003673, -0.08717550742528041, -0.07213631029295257, -0.5258556124642709, -0.7472129532838939, 0.11069878531467113, -0.20000456925674656, -0.25044359263759636},
    {-0.09970163223180198, -0.05344385354841017, 0.2699519200460204, -0.4483906507271254, -0.5086914429911092, -0.2416260118575859, -0.33647187666196604, -0.23528228929112202, -0.24867832306838394, -0.4926309412528413, -0.4363224434524809, -0.08030373496482814, -0.2878380459588531, -0.1385273043110346, -0.4199625769143728, 0.004636313978955455, -0.35002387174866434, -0.17590348763600233, 0.41535664000149386, 0.456185691360859, -0.7502884901407263, -0.5694478326834647, -0.4282745396745866, -0.5721835166255367, -0.11976682356603797, -0.44185787987057124, 0.0008058769694981408, -0.2664792912013868, -0.2978586723266395, -0.23886628108874172, 0.22067508835624036, 0.14652991475934182, 0.11861582886828886, -0.05703264459639398, -0.6304360361928388, -0.2190131730461224, -0.522194948014891, -0.17531221536454375, -0.09390465131394074, -0.35063560044708514, -0.18457751677265838, -0.24752259337181756, -0.2933733945763075, -0.5164174396562081, 0.2950454576027964, -0.20661820887664362, -0.3627188868872577, -0.2620666789292826, 0.14993027945230256, -0.4107044112808635, -0.43997914410537, -0.271753381767297, -0.26458080851424803, -0.4130599512967988, -0.6632053684624151, -0.30262803475320704, -0.5840569060180945, -0.3705564845119905, -0.060009905081790035, -0.5321467707249029, -0.3986116759388392, 0.0321297024356615, -0.03780397286666158, -0.30107480907044837},
    {0.6516720628627548, 0.04314285655714333, 0.3195835546158776, -0.0855898622181055, -0.20789629128983023, -0.14996729341038365, -0.2051683621595316, -0.26751346269678844, -0.6048126526057592, -0.37423490630676365, -0.057734268235903524, -0.059745429590584175, -0.2575404532014174, 0.23543416593133815, -0.1758090066746368, 0.045808726898334436, -0.49172679737015085, -0.11493676541456356, 0.30872190614813555, 0.49966371211284993, -0.393737040741582, -0.5602959498333181, -0.5822332112586448, -0.5324550577026855, -0.3903486896296194, -0.22470832564392493, 0.013393207614270647, -0.3998873869718251, -0.25396881504595165, -0.48432893932629556, 0.09747496777988658, 0.2938541004435322, 0.33053037821347353, 0.3904855614461796, -0.293705054622085, 0.05946023467101607, 0.19003950549921422, -0.17351639345487163, 0.008459510377884002, -0.399389691546238, -0.12391450823814719, -0.49874534216399247, 0.004518242174977253, -0.5900153893907862, 0.06165003708530701, -0.39424206727107763, -0.2936269842829156, -0.13072941288096787, -0.017172572762868633, 0.012432430365348046, -0.2252214288265339, -0.013924382344836514, 0.07539045695520963, -0.3288399536093141, -0.07739768622450062, -0.16202642026147301, -0.2627002948841511, -0.2707821298465372, 0.04402189724655186, -0.10976286862739061, -0.1609179842262693, 0.25307839762562506, -0.026540336245440884, -0.10240462208195181},
    {0.3572725501370312, 0.612610530590379, 0.3951891514396165, -0.3672490062916204, -0.4823968862050051, -0.5284189836842685, -0.38987593182607283, 0.40831605033713303, -0.31443980351224415, -0.513402072912098, -0.31009021263866754, -0.14745672442736701, -0.4183291258828929, 0.10356704887634356, -0.6674352947163682, 0.22259684930501117, -0.09279975732922158, -0.05877572916096826, 0.21110332540087676, 0.44215712432945986, -0.34652687100486035, -0.5484225977110189, -0.5610094689712956, -0.6974154703923392, -0.4313963838317527, -0.3812955705592979, -0.21513897950419228, -0.1763687254619258, -0.23802555636149658, -0.7008702205258184, 0.007089151100226687, 0.3793241588674888, 0.05684320888015229, -0.43044441585198034, -0.36909815800225815, -0.09815133206745744, 0.0742361274353569, -0.20472528941157228, 0.032258698645807486, -0.09967872186746124, -0.0023957999375550615, -0.4553600985366734, 0.15572373035450543, -0.4686316270622389, -0.34472201743256414, -0.43429588584338774, -0.46922179355532806, 0.15720554573137074, -0.362487211913481, -0.19649822601367148, -0.4757989483269976, 0.14702968029615804, -0.23739900812756254, -0.6652866939165357, -0.5308185496254826, -0.2829970370750703, 0.18268669937415374, 0.03668049594266627, 0.013177980202632208, -0.328439979696216, -0.5316247103659438, -0.10633071711554734, -0.06990416128003141, -0.165316900803751},
    {0.13621918850858145, 0.5659659377468751, 0.15502658377422265, -0.13767106005200405, -0.46100096660179407, -0.2067004028021756, -0.3908219834161391, 0.5299618572479364, 0.048529010338037436, -0.3831696757979619, -0.09738972862668381, 0.15785043296337134, -0.03692266137606042, 0.14685296283387536, -0.1682367041548438, 0.19817039460422867, -0.323993984256292, -0.4757680479940971, 0.13194128832538432, 0.132948711043395, -0.15583349168122265, -0.4745753916177152, -0.35414362728300663, -0.3709474019273974, -0.4350766708124871, -0.23786361983343132, 0.1601645077114237, -0.26712126177866047, -0.3789665990889435, -0.505603189169116, 0.17911898445045146, 0.37322132264976166, -0.28611644865976116, 0.22242498278628875, -0.5039092627865018, 0.13288939840366978, -0.2123050593425433, 0.055484540037433465, 0.14955575382858546, -0.39336585153964077, -0.0954682219889758, -0.5555838986608588, 0.18106529441946156, -0.6669714176927484, -0.10255608435994207, -0.38090954251748926, -0.49607608991449115, -0.1812749574180351, -0.05240858614440458, -0.44708542739717355, -0.6527211600183003, 0.0880933166090908, -0.14810669116661052, -0.46264361993799497, -0.5804426260969974, -0.2086471503242287, -0.16922061228927596, 0.005246633960436863, -0.4867129959084879, -0.160934389752529, -0.6164409971232743, 0.1908355674856468, -0.2048317681095597, -0.4570303074765141},
    {0.14592946713701027, 0.3736219869157238, 0.48020426564908003, -0.08257142648049118, -0.6493173105367037, -0.4079100606538228, -0.29810473543213306, 0.48800208056215283, -0.058773140841995426, -0.4222079126899686, 0.08474050695161062, 0.26047253940646387, 0.04835255287539244, 0.599296059922486, -0.30265869476973, 0.3337899773581726, -0.41486614333331157, 0.09338052558218032, 0.4611728056093518, 0.1232588312338445, -0.08715958725071302, -0.4243769896315425, -0.1935052913987547, -0.7030376874439853, -0.2451242724759059, -0.31812501813888056, 0.24381493810050814, -0.38030911042185883, -0.5745480004760003, -0.5862069473069204, 0.2843616513491509, 0.35601276501068746, -0.010045004237169707, 0.20409095883802175, -0.30045553989054896, 0.16136888424196116, 0.24337384564388298, 0.4056968670166856, 0.39125917039492664, 0.15463971656336886, -0.009454938440770265, -0.4687772481915712, 0.3104338987496014, -0.5181101081892118, 0.07642552989549176, -0.2723636086908731, -0.4917163011612934, -0.3382739639543965, 0.23230818109455473, 0.029867818335818492, -0.45470156092314407, 0.47884162967352445, -0.07688107672409372, -0.4391566118124193, -0.5918787784719151, -0.04886795980665496, -0.40234646011407854, -0.016202682650348074, 0.08115406608869191, -0.006790863433089039, -0.3378313632529948, 0.4729574791946556, -0.24032596477676607, 0.17336681524214484},
    {0.2873503710848169, 0.25215631651617854, 0.20034960045773775, -0.08204443173988024, -0.5303709077731079, -0.25136753713584686, -0.4665235012592723, 0.29843464790533475, -0.466214381346903, -0.5090692616268538, -0.1409829451029055, 0.12823765813396273, -0.13597433275483858, 0.14844657652904114, -0.24010189039637272, 0.2188610682012257, -0.2248746409424857, -0.12643367988385248, -0.06549185695877938, 0.13362015469750105, -0.4336720883042816, -0.5287172272913703, -0.6097979892984295, -0.39351006182570203, -0.49528925572754734, -0.10047877018908415, 0.38685782536169067, -0.34939065986512124, -0.17811065594290615, -0.5865490902380791, 0.1781048200339488, 0.32100660257738667, -0.09459034408714216, 0.2618131918363629, -0.4857271268255145, 0.42362758406670364, 0.09267636343446943, 0.10109442178623577, 0.31306307024140106, 0.1872991285393268, 0.39546061683264594, -0.7717273173241923, 0.20799629519741553, -0.45731906938706135, -0.15330384991196852, -0.3141351054346646, -0.36315920414006225, -0.21695204213210528, 0.21747400579603776, -0.17427298108858946, -0.631860311806418, 0.14193067799808576, -0.07499279453151714, -0.2926071596588145, -0.5748093018863802, 0.12186572721199654, -0.17627643554265543, 0.1482695605478918, 0.0969791882347872, -0.37619600026435523, -0.42122100859401035, 0.2249820740006186, -0.24387732596246023, -0.1224575820860775},
    {0.39892153968324723, 0.25495293156693855, 0.25867953336522503, -0.2548377344460475, -0.33726157825928177, -0.33739047600767175, -0.4185506422015609, -0.04586942869475566, -0.6822363120595478, -0.4304244360362467, -0.3701102042197202, -0.2969637971631795, -0.20996676291569308, -0.22403039748502462, -0.31447356979495, 0.02897038168491158, -0.3626239898027079, -0.08943179305719835, 0.07317520461017622, 0.462857875242924, -0.5153120842184278, -0.42293068543378415, -0.48867316827468343, -0.5619864941562616, -0.5257644542634745, -0.46196609690984614, 0.08432086764734671, -0.27474403283554294, -0.2411627065972401, -0.7090068418750479, 0.1703657391204807, 0.3462403515113916, 0.056246899611035434, -0.08119658795138869, -0.4633154125863449, 0.13042204158010837, -0.27068797178669324, -0.2739855885580564, 0.3613788503814087, 0.0667679616822775, -0.09193290663733934, -0.5265204386672034, 0.038738202899951446, -0.4639807102628223, -0.31029688076126444, -0.632466744772673, -0.48943121588536637, -0.2581779709170613, -0.10969870823975515, -0.2492998850877982, -0.5245532753901062, -0.2649403293795907, -0.5000616732651713, -0.43971747256062516, -0.5982944568894244, -0.10699140773991576, -0.5773924041972738, -0.18427814700541276, -0.08380607968673653, -0.27533421865394636, -0.5207794718274762, 0.09710887637353287, -0.28485439377244187, -0.24235390593392425},
    {0.37156494527969924, 0.5291335104123094, 0.41150545725251836, -0.24859047978388085, -0.6475500365905822, -0.39193977804442226, -0.6373924616976965, 0.540953304349251, -0.49135359953039653, -0.5431776043987369, -0.48024883497474696, 0.030634175620427074, -0.08907674001082923, -0.02795404156810305, -0.3668193708680305, 0.15383477990628902, -0.5072498449923221, 0.02049207255159302, 0.06777770413345083, -0.007086291075863912, -0.6622493773542768, -0.6686122762241359, -0.26526396770184724, -0.5164129843115141, -0.3369437523565031, -0.3791208109839664, 0.07384552904907439, -0.5397506646313868, -0.5811714591951807, -0.6692622718575081, 0.18668461042490092, 0.43527594233358385, 0.20284285868226484, -0.0992341286944564, -0.4500805565081053, 0.2384796591215003, 0.15708644369844324, -0.40086344771543814, -0.08659555325460021, 0.24227918068834498, -0.025504837017793755, -0.466282232408888, 0.19710994396680906, -0.6324689148403496, 0.14652059603645393, -0.5392609776643232, -0.3444081709660073, -0.5266112030759511, -0.07766021395818436, -0.037931332918047705, -0.5943287084497143, 0.0009618819647378983, -0.1728153849186849, -0.3595110238005937, -0.8420653320842388, 0.026701826516184902, -0.34239849202691797, 0.06389697565529161, -0.2539302331018751, -0.3817345557422628, -0.6053002631380959, 0.35554306921246054, -0.22362130575922448, -0.1911184171713535},
    {0.5185744953123412, 0.32872565575857254, 0.49942250765009977, -0.08873696453967087, -0.5643789708582192, -0.7949092414252814, -0.4764116272759547, 0.2792377949132637, -0.3566932951083266, -0.7229897078227953, -0.10957320013625539, 0.39428985850873716, 0.01519149393198433, 0.41587853464212315, -0.3467806362970828, 0.434310953149993, -0.8107150096985739, 0.3419356585754624, 0.2318228772322017, 0.41335675955903683, -0.46419109088324206, -0.40446807968481563, -0.26428546577642464, -0.49232888092711835, -0.3842172039275224, -0.0462410955058561, 0.5131686481890813, -0.4105220193048324, -0.22067948203172955, -0.9347720809472102, 0.3486031375192699, 0.3289855976450326, 0.6188430362005322, 0.7729937765628453, -0.2655938902922155, 0.16653953569093624, 0.4524037077591041, 0.054244043029162664, 0.5043059563657949, 0.005442992407124958, 0.30774789045524786, -0.5567734631581074, 0.37744536784951427, -0.5522879678638398, 0.18430028171878088, -0.45299556534840996, -0.669514569921131, -0.344674268655102, -0.07108386737180943, -0.09222316543846143, -0.6406854939686012, 0.34053844280367535, 0.045282062617327486, -0.42339955035853755, -0.4179931981329758, 0.27632290342717114, -0.32621508342109656, -0.07286149852338553, 0.1323693053684497, -0.2218426008304233, -0.17336896203669555, 0.44232974391503355, -0.025723964295301174, 0.01473524169181146},
    {0.46253071521031297, 0.5925773970675763, 0.3010407743235323, 0.08767048342817677, -0.7355540597684324, -0.7398944200445764, -0.38891360498341054, 0.42401263824306007, -0.4822093365408302, -0.5886550160525688, 0.02546975120606539, 0.5928684035740954, -0.35335808844382965, 0.5080016747722992, -0.0511351678021479, 0.4594212130018365, -0.6183031679467247, 0.1344674478148605, 0.3208885388985575, 0.5391701069476116, -0.19746996111068932, -0.6586978655818767, -0.05937252900301731, -0.46627381465784695, -0.47427569690255955, 0.028954806611143618, 0.5286535619759354, -0.08132848755234161, -0.07521074597078631, -0.7852012824713704, 0.5359556257106541, 0.8724664968263414, 0.5480513035413942, 0.4652679777909973, -0.31619920508283417, 0.3929718752563421, 0.27974013534341635, 0.4742642898202485, 0.3441764461872078, 0.42845094379325205, 0.6010430278516444, -0.8002580891715825, 0.5908508279457297, -0.05169974259665002, 0.09280703668578949, -0.5723630852706132, -0.8398388272913081, -0.10906515942913858, 0.0232655091660071, -0.38620516834668345, -0.8982816578316779, 0.571041046737966, 0.36852144450062224, -0.407008283584877, -0.3296580165629137, 0.1962224927745556, 0.12172061559538332, -0.044839939580661604, 0.19031855420518964, -0.1671914501398307, 0.2593939945698172, 0.2327573245052716, 0.11641406200285186, 0.2476650509853541},
    {0.5254296779871603, 0.6271888188263638, 0.33974857775564105, -0.0593875618067796, -0.7217013242026663, -0.5898039653707654, -0.6741502024853023, 0.27299633219709313, -0.26214139315992563, -0.7086526987486848, -0.16578380284833535, 0.4942656250961499, -0.08234426111457051, 0.3983199037429754, -0.09369049632012959, 0.3627310506862438, -0.6092155210369092, 0.25596073602405284, 0.2990343198764785, 0.5878168885528993, -0.3070666643832249, -0.5553350272352124, -0.36585084542609214, -0.6728172644181724, -0.6306704996645411, 0.13982466659360152, 0.4268749733465929, -0.2752691924829597, -0.463236832016142, -0.6761002860467469, 0.28686361189986664, 0.5317866183532154, 0.18683131528315922, 0.05658306505502776, -0.4120667406682683, 0.1431415108491714, 0.18631683210089758, -0.005799585113551455, 0.23482314588697914, 0.3753671585758599, 0.31946760985078343, -0.4172154786814697, 0.3305734323919823, -0.41023912334800716, 0.25246147537745384, -0.7488854643487755, -0.5782874140250442, -0.6609067298506648, -0.10032199304446333, -0.28123569606582305, -0.7612273830361856, 0.4332772809445613, 0.2561429624660244, -0.5213934718043838, -0.7472728670720555, 0.20512479640633838, -0.3509774381961863, -0.10668173922908547, 0.11300444100585408, 0.14992489705625253, -0.17031819962892988, 0.21932899397727706, -0.26166299094653733, 0.04395214112454454},
    {0.45407936017321276, 0.3172691784081026, 0.3077259799038317, -0.34256964996780453, -0.6625940112311812, -0.6989866815224324, -0.7698490645073826, -0.0320793029792723, -0.45082763978099594, -0.8517394186569575, -0.3129252537932537, 0.1670916410408629, -0.2701015435376122, 0.24544979019270513, -0.4327344557805161, 0.1667930765238801, -0.6598356235266732, 0.1209872489877651, 0.3716756348154305, 0.3688484911920757, -0.6543819415152784, -0.36662919674033706, -0.11941861120340899, -0.748646149350167, -0.48191537608887863, -0.1669214208212809, 0.3556708514751625, -0.27767963556693137, -0.36670268985565735, -0.5672805631754574, 0.23363432362976916, -0.05932780302492073, 0.1752975863518656, 0.09393293764274722, -0.7980448995712381, 0.1569806539370737, -0.1415226514437108, 0.09048213784589781, 0.2776445432814911, 0.10688164438994997, 0.18647182158436965, -0.8494723576287657, 0.3481051361588688, -0.3784320456704763, 0.03303297205644916, -0.6734500026311611, -0.807588747855131, -0.23722887082840086, -0.07566965014559604, -0.286597151816692, -0.3581715855965078, 0.22813971486270687, -0.07859078613853783, -0.5376773749813281, -0.5903129029440969, 0.035040152579065446, -0.345016427523245, -0.12380528848422388, -0.076910887007613, -0.287550163498348, -0.10084457437195095, 0.303528745418814, -0.24646980139131036, -0.41489449004400586},
    {0.6947055859402269, 0.7077035366159976, 0.1922914425240087, 0.2045947251676411, -0.5580602951835121, -0.480841473482254, -0.3267117943367059, 0.30949860373257865, -0.6181875030570887, -0.4871951657593207, -0.11656742913065286, 0.5281458260307051, 0.022548091797225427, 0.30138743071020224, -0.2694974902525161, 0.15944274357868202, -0.5109554192004088, 0.14080304113233968, -0.02625917648290289, 0.47565804030884273, -0.03717354000772344, -0.410564098596694, -0.035670060875632785, -0.46474088549583603, -0.6477077375963844, -0.057892218873270423, 0.5806124532575931, -0.4046727540083246, -0.18924268877735403, -0.7693611326996522, 0.3936401085374363, 0.3936442288671119, 0.21349059674238952, 0.48204855063698665, -0.5941325844885422, 0.15127020854333295, 0.3079697082442818, 0.21975695336195017, 0.4340064346526931, 0.5378344200468307, 0.3419910851843898, -0.6730847759705821, 0.36803018179517116, -0.5839147065866424, -0.17417354033706925, -0.5477718465167697, -0.5709691707707875, -0.1873397738888535, 0.057764366279663595, -0.50163673441402, -0.6951031472836852, 0.20016030735405138, -0.003233875755149832, -0.5589786454609831, -0.6923258940914051, 0.36167788600822903, -0.19835585754082385, -0.1762943497330583, 0.3089816773734928, -0.3205346900281446, -0.40881777734385344, 0.5410082810690128, -0.19632496452179288, -0.004320242825038946},
    {0.36531932690888713, 0.4350847627607794, 0.4327630235006553, 0.019465305856505043, -0.7857889319084963, -0.6157787632683012, -0.5555039516210344, 0.4046507913864007, -0.6259197691983037, -0.6764869787389791, 0.1370657375906705, 0.1993816155793263, -0.3216745717304977, 0.17061707536580478, -0.30666794209153214, 0.19390844729174228, -0.6513212831634705, 0.08190578041759244, 0.18911374782491217, 0.35753336422193754, -0.4459571511084992, -0.6135659941700166, -0.3379811944608317, -0.6410802213521857, -0.6406567787089582, -0.21797077355076191, 0.5483885546595252, -0.6168085735291667, -0.486250942989746, -0.5958249964959146, 0.3886363872199823, 0.6844582886446098, 0.3967588201249339, 0.11731828167573861, -0.7074323185164461, 0.1101544059611618, 0.20167081392585345, 0.2531224459852684, 0.3701658032411242, 0.1673340857911488, 0.5224791745290477, -0.6457693764086735, 0.3046321216478943, -0.5646512828956833, 0.23432082253367592, -0.5093835608166072, -0.644285839905553, -0.18748219022058077, 0.034192152466246045, -0.675028564496178, -0.6678435719889513, 0.14087815054153605, -0.1857484629160761, -0.37948737065075844, -0.5641056506938431, 0.08035262107503001, -0.37410630412336454, -0.20927096942638812, 0.3897391627962625, -0.1562641070189448, -0.28481270320511076, 0.586188595523958, -0.4434056022601597, 0.11318808235766345},
    {0.4118486478371809, 0.5886973290222682, 0.6347746937050542, 0.060066849655373414, -0.4224772819297898, -0.5433748703417873, -0.5464538265696665, 0.39605731585635967, -0.7418797527606293, -0.604285104097209, -0.04270541626519712, 0.5157268237243126, -0.2834431834753812, 0.31907703298669116, -0.5865556259164103, 0.30832290721538275, -0.8262222388651291, 0.3361485867588652, 0.1375760298483067, 0.48408332252380293, -0.5363853744362935, -0.4912321565180613, -0.2548273615371113, -0.6649962109194689, -0.7250354151310562, -0.05114390654472504, 0.2986697757709023, -0.37684320517004166, -0.20398876133647742, -0.909089905517455, 0.39782398174426686, 0.5637646276797662, -0.007902383902370679, 0.39680163343715763, -0.404168092895048, 0.42646430399046886, -0.1407133051507724, -0.04141111415878723, 0.25717917908710514, 0.2951156863411133, 0.42240094968503555, -0.9175859190612312, 0.5530557607664724, -0.620602477269516, -0.12324220783016891, -0.6140787137339405, -0.6893642446672434, -0.38593224101342516, 0.01530775324900745, -0.4857301350740296, -0.8202390111990002, 0.42195458708144634, 0.14408587036165346, -0.7278889469393622, -0.5266024427078564, 0.356455458458722, -0.23661717555029405, -0.2670455677302786, 0.3021253223444293, -0.20370729379083055, -0.3731925914493558, 0.551085398000349, -0.41161887976177236, -0.10215245531709363},
    {0.4338786222794576, 0.7753777108711616, 0.34859078648869224, -0.018004197240191415, -0.6966832565295179, -0.5127480549045876, -0.5135318185213115, 0.4739407142219695, -0.8497868946410174, -0.6372080314362364, 0.00653366272562417, 0.5948589139257324, -0.1645401476635129, 0.25128443095322833, -0.30741911613689704, 0.2961578989441994, -0.5751100600727739, 0.2898403109332822, 0.3286965345097664, 0.611686424537863, -0.09212807493018102, -0.5708252748998592, -0.2327219862644792, -0.450305510765651, -0.6054677434103723, 0.056614893273997706, 0.4359480134774683, -0.39467519223431974, -0.3768422711395847, -0.7521304418989978, 0.10764853493429655, 0.3087354469003686, 0.017594585119708493, 0.3651252627138511, -0.4764715646101139, 0.3445995977424983, 0.05696172367526649, 0.17464732012247533, 0.6510502552709013, 0.3475431417127972, 0.34674528716168873, -0.7527196723811473, 0.47983300945001, -0.441705326427955, -0.11346509768511917, -0.43903133356444746, -0.536231121052201, 0.07810140278620757, 0.2051405601022469, -0.7859972786775371, -0.7692063756318875, 0.3996043083312604, 0.07339564629178803, -0.5992443653119728, -0.6447425601921505, 0.3617146448366252, -0.3143355566965204, -0.23248440716542174, 0.30430029245139967, -0.38636030143689126, -0.35689663439271985, 0.6180567504437564, -0.44114874445059515, 0.20303000747973168},
    {0.6183123389586411, 0.5865378132478756, 0.4631441753654687, 0.18634537951548522, -0.7144142220665843, -0.6943409413929361, -0.6491932745348585, 0.24429408435157357, -0.648468193790614, -0.5291206424030581, 0.2621733014298866, 0.509356128084943, -0.2600564710874535, 0.46324574195782514, -0.3188329858730737, 0.49829499155646156, -0.6873083501887882, 0.28395079971175696, -0.0020052038852338577, 0.5004163387191314, -0.24730260471334542, -0.5584810526463992, -0.357618962881446, -0.7103225307293324, -0.671534458074797, 0.11810395543819081, 0.4375264974014132, -0.35246437597053354, -0.20578247899210772, -0.6197086519471, 0.31717587676519005, 0.5100449436221136, 0.45954087521448916, 0.4445294359809579, -0.2526678319624109, -0.07276161721440794, 0.4082383237013991, 0.26434600540978426, 0.4030077579584448, 0.42048398954248306, 0.7123104065390619, -0.5014644645931635, 0.5391247845970164, -0.4911774206484174, -0.050090438442802365, -0.7950306942165382, -0.6746200446081191, -0.28961027636540243, 0.04668527713982888, -0.6345526371960313, -0.69987096111157, 0.36260011987709173, 0.16042850152800572, -0.35676893534679927, -0.8020837061173411, 0.24062208485513073, -0.3012560405060652, -0.29381235103836484, 0.0628106711013437, -0.14600230455636892, 0.04328303616886621, 0.3578382890514819, -0.3493992767742578, 0.2678776772671431}
};

static const float b1[64] = {0.6554874663320334, 0.7360415349218522, 0.5521019188275662, 0.7812590509511126, 0.8202683628109516, 0.7245909745121619, 0.6006575581245596, 0.5741172667052592, 0.773077505377253, 0.7676807468302793, 0.7549492486607827, 0.775961985086447, 0.5691346987978265, 0.7158234110335547, 0.7580985742714992, 0.8350120504659655, 0.8146485366208004, 0.7660581945106233, 0.7029294444965375, 0.6224333275120811, 0.7759639389687837, 0.7898527383814604, 0.7716758653919941, 0.770935351934517, 0.6883345518821539, 0.7146170308805692, 0.8162473938582292, 0.7195591665197907, 0.7168380567783047, 0.7690205402258237, 0.6807894537579532, 0.7695525019351148, 0.7277430917409631, 0.7463937740124906, 0.7999107895640882, 0.7796099806629924, 0.7590867144113795, 0.7165043648992613, 0.6645631013582672, 0.7099938615293722, 0.7250958696783548, 0.8143777535937762, 0.7017966453948139, 0.7800779595825446, 0.7392373210907425, 0.6017221229158123, 0.7376460667776835, 0.7905328826710901, 0.7143581525930432, 0.7607100306779357, 0.8009459623896312, 0.7954827955507572, 0.6563330376633516, 0.757253473181094, 0.7786496746226805, 0.7852382242899465, 0.7139842378153454, 0.7307873102580463, 0.6103873348853772, 0.7654395945152872, 0.7478646093329525, 0.7424644229145125, 0.6374959191458338, 0.7804714802525802};

static const float w2[64][32] = {
    {0.653782248809184, 0.46297486196660287, 0.3910357568880063, 0.7448239971777639, 0.6586388642218804, 0.6360677842408561, 0.7690625590862794, 0.42697572418043567, 0.7068750814323768, 0.4252117201976126, 0.6646975450791299, 0.76932172695032, 0.5609981318835476, 0.6225895266774195, 0.9125091798219155, 0.8276893739420951, -0.12263135690686626, 0.21819108161688702, 0.6732925591282944, 0.910299405794251, 0.6597579432984282, 0.3061730510692139, -0.057306593803667066, 0.6036271092944122, 0.4231768337776785, 0.9230534455224332, 0.7370610436622101, 0.5906585852840279, 0.5340209319589558, 0.7208109093517836, 0.5718912568967072, 0.6975773913849228},
    {0.2573134537533923, 0.6431325801871169, 0.6664982819327051, 0.691161162167162, 0.7615086735292877, 0.8790895280718954, 0.897499414602978, 0.4291506817800169, 0.44286423640290185, 0.36449826257658524, 0.6223073546871412, 0.7733222306003016, 0.5082974787903735, 0.6461287869289867, 0.5039934446733365, 0.9675261739231806, -0.22429528708191795, 0.5358866754927499, 1.1084251151638236, 0.6489920336928139, 0.44953288357977533, 0.7361520967259707, -0.13823829278468663, 0.48144521954701214, 0.5701268834596116, 0.9965508455888105, 0.8274880466032571, 0.6914779707915685, 0.9060909922840453, 0.6991426534555043, -0.03268603401889725, 0.8845187234513795},
    {0.1437996045403276, 0.6953114642412347, 0.37322103941642515, 0.722594625361348, 0.5565363869176803, 0.4514453767144862, 0.7580964657526303, 0.7172161680046252, 0.39556236992421473, 0.6118539383864059, 0.4138582396793424, 0.8598468124519267, 0.5774504576106638, 0.587537358956243, 0.23325290146931407, 0.43282135431211993, -0.036711102317719256, 0.45840792943684466, 0.9492408917205406, 0.23518736247625027, 0.45765837450390545, 0.7022951690455495, 0.07000164955936554, 0.43508630769662726, 0.6756202167363022, 0.43719737141564907, 0.4258662933338883, 0.30451593503122737, 0.5428969689579859, 0.7276824723310218, 0.4068283107359192, 0.7633453569698773},
    {0.35658482145869885, 0.18763689461889546, 0.15059070297757973, 0.6532703879424291, 0.6434965212814101, 0.6522537404541435, 0.8588256619442036, 0.7651350090146589, 0.8197954595588878, 0.437573788727427, 0.7088842755109349, 0.08873641933588697, 0.6131845568631792, 0.8249251536925295, 0.41635096203092375, 1.00908199108177, 0.09599185349510089, 0.6800274387697169, 0.8987893868834441, 0.4558755245708553, 0.45946050206394107, 0.4264555935493743, 0.031875099195245914, 0.48793884437753793, 0.2591425135323791, 0.7299977900791422, 1.0521451267843813, 0.7779567365937456, 0.9840544142647902, 0.3036943632438069, 0.5832714447868794, 0.8406103484059053},
    {0.43572024890135064, 0.5991878080490807, 0.4224544854092579, 0.43033165049971933, 0.7563560669171758, 0.5457850675116449, 0.7431912721262924, 0.37956545563848465, 0.7607928495527291, 0.41196242592693344, 0.8550060033288793, 0.6208367582364169, 0.8458900442713109, 0.6670935478014383, 0.6439857005230331, 0.6706915968704557, -0.15529280539733564, 0.2960431729111543, 0.7074222137080388, 0.7456626301497474, 0.5284601421998851, 0.9394870223890164, -0.0629337076315281, 0.16655547785603683, 0.7011583763116438, 0.7181205293348386, 0.8132679192602495, 0.7479365430594705, 0.654653012506921, 0.6970291805533148, 0.5059022893355777, 0.27549448172332996},
    {0.3866163787314012, 0.3697601522006392, 0.40474579787773396, 0.554692744933708, 0.6174894638532308, 0.8735635686045331, 0.4361305961083326, 1.011656598448179, 0.7899890379654079, 0.778881920171517, 0.7247071668372808, 0.7187772048861322, 0.6024760094358631, 0.724972667444227, 0.7242967188521575, 0.4378974648751794, -0.05594888511909041, 0.4026571138024654, 0.9007712037702154, 0.6936603543616815, 0.38754114606772005, 0.7028772643804657, -0.05570305820348272, 0.556881085721766, 1.0073125213081777, 0.939383860033349, 0.681506654700977, 0.648483994159749, 0.956940005996084, 0.5692629124769908, 0.6583322574299284, 0.679113399504402},
    {0.23725082290249988, 0.49678722383602336, 0.7533921812675571, 0.6134950385984135, 0.7654826156163265, 0.6171133441100618, 0.7369115311316441, 0.5082741062183824, 0.8925245277831356, 0.40486956859981543, 0.6893599712852643, 0.7488748669570361, 0.7576008410962574, 0.49637484752027206, 0.4688275037148305, 0.6313234485907157, -0.051311840137323476, 0.41921483401913345, 0.6441741980156739, 0.8969789996935104, 0.4453016796735957, 0.6015467549962431, -0.5340953042908183, 0.870979891835759, 0.8512113424058714, 0.8788352507269045, 0.8005564743840178, 0.9635619104295273, 0.2945929619734599, 0.3357464078607551, 0.29925145769005346, 0.6444510637191897},
    {0.575105576936667, 0.7423277644902526, 0.4227248208597372, 0.6947060850773465, 0.6334042637183463, 0.4325636865725354, 0.40583395664988114, 0.4935696402901414, 0.665098984024021, 0.5128223363722298, 0.6723512462360054, 0.4296035615347523, 0.9162981463102492, 0.7261495248423242, 0.5687905762637754, 0.5078757942062789, -0.24725068648661866, 0.4256778365501399, 0.7377154631806183, 0.672329168615029, 0.7677481229473522, 0.6320134140697315, -0.031221672730979557, 0.6314384328963448, 0.7634594967795805, 0.5878167327023855, 0.7588248579401695, 0.6363389560368483, 0.3825901598311024, 0.6578994091411509, 0.012502791638548071, 0.6947394877078715},
    {0.2950892411585766, 0.4561354530616023, 0.5703555255319349, 0.42112341378576884, 0.7842205890656948, 0.6211165698909775, 0.6643274158687139, 0.8222273400479376, 0.5694264579993651, 0.43672111359571797, 0.818109838616738, 0.8030273787633626, 0.7864779351685566, 0.5226965100453117, 0.6952282822800012, 0.751390890477342, -0.012449371743025978, 0.5052635299790793, 0.6343043701191308, 0.5382639257876141, 0.37774313007153626, 0.6766585571939852, 0.28966351894673525, 0.2583313452861904, 0.5484360425220582, 0.7187603839426745, 1.1062230398087962, 0.5789569976597216, 0.6951516997060109, 0.3635109316550178, 0.19284176085605723, 0.6663588740190973},
    {0.39205144346274295, 0.538597124257941, 0.528870350081093, 0.8527073279225917, 0.9865883198212929, 0.7885835152210992, 0.7415214997218721, 0.7354797030014976, 0.8022973914526659, 0.6429371967620269, 0.3566596612947524, 0.933291988891356, 0.5511018019953325, 0.5184748006823849, 0.6247052119192122, 0.7759620893015284, 0.30303861456558295, 0.44891248084544627, 0.7960532032145492, 0.82202555988215, 0.013455881848344335, 0.6384609248636495, -0.13558599551004386, 0.517516016409132, 0.39648994221253453, 0.8166490216380263, 1.0890897253975735, 0.9486545795842521, 0.6676603677386362, 0.8329111960479457, 0.1902868640438366, 0.4950553031072073},
    {0.1963537063074203, 0.42831980340044684, 0.4310975629814414, 0.6878718162001531, 0.8423946647242667, 0.6956324759474625, 0.8911847037294524, 0.6980050984529146, 0.9506489572235479, 0.5725673454140306, 0.35564268187740183, 0.7913077121989182, 0.9271267724874416, 0.32108222910508805, 0.6631298453490861, 0.49482308900456906, -0.09104057930644385, 0.28899599200890425, 0.8288196084438292, 0.7156770835269205, 0.09485948461296449, 0.5704392114300517, 0.24324343752218322, 0.6793233904333015, 0.6114979552570652, 0.7909675257882487, 0.4579015955316164, 0.5298506012091944, 0.9248144893206955, 0.7045230663739077, 0.3915266322781164, 0.6059477154228547},
    {0.3811895355740809, 0.6214885714619933, 0.3851596664652452, 0.3796609736675576, 0.9309464545097271, 0.7025323063649066, 0.6939875721937613, 0.9845541206487068, 0.7559944664234125, 0.38220266547431714, 0.8661174707798981, 0.6920626360546638, 0.8212150698307069, 0.8453849814746628, 0.603056890534265, 0.6479525922639574, -0.3949735289945204, 0.49800721781472534, 0.787311174747735, 0.7545230130612667, 0.46599523435747064, 0.5427880555153991, 0.05385011228609284, 0.5934345107308732, 0.8601237757446029, 0.895256282218022, 0.7028237562763574, 0.5404973071220384, 0.7733761161636391, 0.7700028416893341, 0.39337700582305507, 0.8607444679618175},
    {0.39775495023603763, 0.3951973678628105, 0.28023164917064264, 0.6124141923292988, 0.18695327541970735, 0.8071059316775817, 0.46953888803540406, 0.7153411631731038, 0.7700450184656771, 0.44299689163600414, 0.5796543978020853, 0.6288772593688643, 0.7685383165338179, 0.6025068997993449, 0.8065945136391367, 0.8232315517701837, -0.26312736737539, 0.8126083388714304, 0.6180779905845672, 0.6090709493765059, 0.24578952284910202, 0.7514156217956974, 0.2651657982431426, 0.4913839994986382, 0.48657414041013103, 0.6485927328912353, 0.36177353079558644, 0.6999474165734221, 0.47776537854901213, 0.7877041827116158, 0.4498019975017842, 0.5137945558892757},
    {0.44982651484119085, 0.6616130929270679, 0.2604415846805511, 0.577767972153863, 0.7483333710348248, 0.5532015190762315, 0.5306452565537664, 0.8225541283659616, 0.5765636221930291, 0.697367216410513, 0.6798371233772937, 0.46720589245400096, 0.81600822592789, 0.7787697357540896, 0.6238492305846878, 0.5048537577336166, 0.026180160822533365, 0.8415326549676335, 0.6467240764985922, 0.4546863996335066, 0.615683849518021, 0.653846704438789, -0.38614635701410405, 0.8227105619018081, 0.486702369487304, 0.9012878609128737, 1.0115647219404673, 0.5009012944568486, 0.6973921017974812, 0.42597177901643135, 0.33091614428385496, 0.8222331336016375},
    {0.5109651474510232, 0.6867552579681484, 0.7908093659631754, 0.5796582340974845, 0.6735076971047906, 0.5656603010480349, 0.6216570702774981, 0.6081438860564962, 1.0212573078156086, 0.40028717501983807, 0.48043171550531333, 0.4390599414838903, 0.6855994135203304, 0.8244723218877399, 0.48063305982974686, 0.8721121781277064, 0.21675949646981907, 0.5703773984853261, 0.7354070041148011, 0.4412097866795791, 0.21533610982574874, 1.033632266803498, 0.005416160455093972, 0.3545533119478825, 0.3530597136986441, 0.5797977593222183, 0.5855241132952829, 0.9420948475795446, 0.5431088120718955, 0.7326030734102993, 0.361968745354473, 0.647683460742624},
    {0.7798954456056615, 0.4643601713125023, 0.31923203824522006, 0.8195096462688815, 0.9064021064492201, 0.3104257603446869, 0.6253781440698147, 0.7193270965646383, 0.8310479406277521, 0.24793737486625267, 0.622968560530772, 0.7659332008447496, 0.9491161762400003, 0.2730695926184591, 0.8885672666319822, 0.49196994296381386, -0.10520044470756233, 0.5464528737074225, 0.7164341060277267, 1.0378061364697568, 0.26763306895506583, 1.1568042255418256, -0.09148179470210958, 0.6496163510131439, 0.8844611233068418, 0.7461479193664081, 0.6426065304542821, 0.5354374996893763, 0.9640676931538408, 0.7089484077120114, 0.509208453600753, 0.9090355444123603},
    {0.36269110559945195, 0.4284740408097907, 0.8222183342260277, 0.5689217454337168, 1.0492378490909517, 0.26519770227908884, 0.6679349528705976, 0.8274514586804904, 0.9892804788057328, 0.46631220212444474, 0.705417623227562, 1.0049560050687105, 0.49621123081796337, 0.7233965650417892, 0.6699964160942713, 0.5297877583996905, -0.07325046476270695, 0.32033382426247, 0.8662324368812188, 0.807868081691712, 0.3966273196615098, 1.0608588393309029, -0.11988750921354227, 0.7166278716802489, 0.7157806550803593, 0.8673447307310105, 0.976430626274922, 0.6271799349730832, 0.7031516957189661, 0.48871129374697464, 0.1881903084814142, 0.8865769197478379},
    {0.13355987525525026, 0.6985660592861166, 0.5576953312587994, 0.5217902905361934, 0.860412384299233, 0.23794500562149046, 0.47778940904865075, 0.4466470689997949, 0.6933853087037112, 0.6479805692761793, 0.8831894972695676, 0.6654653133680514, 0.8685729628768561, 0.648216811657262, 0.5944269043413365, 0.7775337032302931, -0.04159259541177572, 0.8712070144396382, 0.5343538611810001, 1.063068010076362, 0.5618208297066823, 0.3148807721543237, -0.34731287500166513, 0.31293262592072063, 0.13265246369255487, 0.5874295618534513, 0.49642031556842775, 0.8217709761536219, 1.0393884494118932, 0.7165607235692384, 0.3364056756386265, 0.5177888696798889},
    {0.3424110935054757, 0.5825856976563147, 0.5784658995246135, 0.9761133774639735, 0.5402178879297715, 0.6428854091285521, 0.4540049836180636, 0.8870117250283587, 0.790688504635994, 0.432312339742578, 0.49895866844715386, 0.17635264847374546, 0.5071703860736149, 0.5138273802426672, 0.8474202213542331, 0.2004922272518881, -0.20376217686206574, 0.39246595681982693, 0.947292613236079, 0.7339124920261478, 0.5295906223974053, 0.566057705619416, -0.12597055418744743, 0.536639971737945, 0.6376010573652487, 0.7685047333581895, 0.5650061246374961, 0.8371217036620558, 0.5803215927798289, 0.3995277510398275, 0.56246287282887, 0.5781293954053681},
    {0.572864061453596, 0.4207980572406266, 0.7584012630369855, 0.5374056958111778, 0.7295850360356936, 0.24517416348035484, 0.7176576828566913, 0.6205928950637553, 0.8484965332498275, 0.6071599985574931, 0.4465091769352047, 0.4101625822646317, 0.41052382898131506, 0.9272624693908117, 0.40079818926621646, 0.5549226145862839, -0.10893510553866571, 0.5317249317800163, 0.7560318753482704, 0.5645832318326421, 0.5614446372497117, 0.7768587053910273, 0.09406261893123348, 0.5827478111200606, 0.36101261519216343, 1.0170947498151037, 0.5586852387687622, 0.6446215738615535, 0.26037351008950965, 0.7829362557406614, 0.4428356186770693, 0.6433804270933289},
    {0.5951642576343719, 0.4136507133005631, 0.7694157042088675, 0.5486266030884989, 0.9339359569051502, 0.3925092408284386, 0.4782622941666025, 0.890638251094597, 0.828445872186574, 0.6568218502699396, 0.6585476402620662, 0.6750168079291228, 0.6900466557315298, 0.7907817707036534, 0.6206070941168795, 0.6690088490926597, 0.05593068521222769, 0.3652325212340098, 0.7665835302724416, 0.7750632645742106, 0.09669336013797404, 0.7085360280508125, -0.20300319809537834, 0.6273308577509091, 0.5758038421554138, 0.8836563950928278, 0.6477176147435509, 0.6571543592849717, 1.1444037890402265, 0.6332241432610407, 0.44440085398451223, 0.6155707309875393},
    {0.4414267682030802, 0.05083271441921947, 0.5696808657561365, 0.7868499767305249, 0.7985766766144055, 0.6621997238573258, 0.7260119020085243, 0.8425181587396069, 0.994983327501873, 0.49781903345094847, 0.9729450393989123, 0.697946542923045, 0.8593438981227257, 0.7919302201003394, 0.49916322847620365, 0.7282202487076449, -0.18424461691266583, 0.5470659674280344, 0.6035704775368133, 0.775017536630141, 0.37418694487770016, 0.9315005384393117, 0.10758873229953728, 0.523911472308843, 0.5600585159183794, 0.5209191200804817, 0.7385985709207221, 0.7273892356285306, 0.668484317044075, 0.684641479395087, 0.3699524248995425, 0.3986550844924677},
    {0.37912543715319647, 0.43412313925565604, 0.458444008670457, 0.7419632201212033, 0.7445540754148284, 0.3236543563430156, 0.7082524412984973, 0.5912559695621007, 0.558362722920738, 0.5166976277062143, 0.7877408809174529, 0.5314389481790724, 0.6782698538982973, 0.677815446058525, 0.6493258552859116, 0.8660637636493448, 0.10728663880570796, 0.7073984682432333, 0.962395577162953, 0.7779429487012719, 0.4191839111884662, 0.5863025281556551, -0.12342889069659009, 0.6664010631478593, 0.49059598828840084, 0.6714948219677415, 0.8617273293497603, 0.8705653686812598, 0.6772291447865485, 0.5616417346085442, 0.37691529464219464, 0.4085153335133281},
    {0.39875582236965457, 0.2664953835580628, 0.5178335277599545, 0.7274072117157477, 0.7891796778782101, 0.5650557104447037, 1.0610373316287114, 0.6165305965931794, 0.6021934603349002, 0.6892665573779501, 0.7817277719024035, 0.8934166125778946, 0.8244369880310991, 0.5864282296026977, 0.8746937645889279, 0.8519228704204127, -0.16132857629797134, 0.8877452192435815, 0.6402981854584257, 0.5845076459351655, 0.6237011847087137, 0.486913199874761, -0.15198970364377354, 0.545312238328705, 0.9351890917394511, 0.5346304828769018, 0.8372821778104534, 0.2759281269260397, 0.8680671845007123, 0.705215420446185, 0.3387729594051647, 0.7450874735369613},
    {0.4791362955443778, 0.6203069502370306, 0.5087130413193154, 0.7913881661265811, 0.7529238676492778, 0.6888881656359981, 0.6458917502112823, 0.5224814046506598, 0.6063232615718558, 0.5847328436270521, 0.6954369343594494, 0.5539646948623802, 0.7146496618288434, 0.5623024173099123, 0.5726686954810172, 0.6555052285043084, 0.1081835064641885, 0.3853852543488417, 0.476073891235052, 0.7177538367462971, 0.43723547523246553, 0.5969532328804, -0.021580573421396868, 0.5454331046163221, 0.549371950428647, 0.5287617937507958, 0.7638864951740866, 1.0690681305632646, 0.7117483413817435, 0.8336609781462943, 0.4095533586749505, 0.7981725403398425},
    {0.44825450589256355, 0.6347670994690784, 0.5310744207523889, 0.40546597154627534, 0.518612596431438, 0.586231355401798, 0.5020174222633613, 0.7199242945687522, 0.8899353189928327, 0.36358746775846207, 0.6804957656768367, 0.9327633763533061, 0.8073402417373393, 0.7913240970395747, 0.7265655782723048, 0.45829293528493514, 0.21486488590061076, 0.5818756082422681, 0.6131009360449486, 0.7122453931834091, 0.4731791226960634, 0.7033882990086353, 0.03058632991229556, 0.4065752242396917, 0.8216610602281565, 0.8847580455805446, 0.7992789767612968, 0.7541798446816137, 0.9552291772553329, 0.4049118216986118, 0.08118986560942763, 0.3417394736755692},
    {0.5517257283192445, 0.5180433318548612, 0.5007859277319064, 0.6849935567521181, 0.8386552103727916, 0.6096187415322936, 0.7826998532176319, 0.4149701092160534, 0.584608865429892, 0.48636230600968106, 0.47052066013878524, 0.5929114238088573, 0.8682451487937566, 0.5629040832481159, 0.40783301522857995, 0.3774547002498957, 0.11327878510874086, 0.6729579350358754, 0.7236099547543445, 0.885159824972694, 0.17260901271537138, 0.8233853225388534, 0.046346478295851715, 0.6478522624385995, 0.6380457269766869, 0.6348448954968273, 0.839470516321874, 0.7526540171735496, 1.0058730873076427, 0.5726878645312413, 0.3713193024475105, 0.624370784087326},
    {0.8078517052003074, 0.4327790587936173, 0.5469928827134366, 0.40022506637295685, 0.5405915698766655, 0.43159764679824947, 0.452249168672412, 0.8582322658290155, 0.5072885784373378, 0.6531967288670985, 0.744909963934694, 0.5356785057086118, 0.6155082841613391, 0.994776547921416, 0.9438418617655319, 0.6042951694674176, -0.02093057609940488, 0.3853461254112522, 0.6320174432419208, 0.6139226242389272, 0.330651175140667, 0.7962106323776487, -0.1521075661244868, 0.5724249647357136, 0.7801170398409224, 0.6528728175552321, 0.6315490532506104, 0.6796089745428613, 1.0018584053436375, 0.44518506764913907, 0.6759976619501824, 0.805487350467645},
    {0.5461178180390831, 0.6080807800440726, 0.5419208438240392, 0.4494360207417586, 0.8475963989699629, 0.767080872143093, 0.7592672738723019, 0.8626691645963702, 0.8809621140671172, 0.5290103415226048, 0.6222437826156255, 0.5604946790746226, 0.721091937341637, 0.7748742668297666, 0.31908266489973064, 1.1207675734730909, 0.13294236514482874, 0.7777330372440364, 0.7008658759513293, 0.646484704407629, 0.3794914978733631, 0.56575244244043, -0.12453986331781326, 0.7463807182299628, 0.5983020080261572, 0.4534361863903822, 1.0439105385589917, 0.6450397240020674, 0.8769168711386461, 0.5812272842785662, 0.5029289926801059, 0.7838649674825952},
    {0.535188325087942, 0.9421794508089661, 0.533272193751902, 0.7507379447481204, 0.822305079959711, 0.4565786818972267, 0.8209993796597612, 0.7285574189494877, 0.9740102784770217, 0.7137219921549968, 0.18587334936782507, 0.8821875154226129, 0.7341388149742298, 0.6659389134230406, 0.8116056166327623, 0.6152181421243278, -0.03902005084889181, 0.6154098632506659, 0.716897876109081, 0.6121383155292925, 0.49368482861252144, 1.006950693265242, 0.12128391759480028, 0.6440554780536416, 0.6784080676662175, 0.5426074602356997, 0.6297416938086469, 0.4992831682960001, 0.8939348106823958, 0.2117504477892492, 0.6688163271707523, 0.7123116202732919},
    {0.5604306212753123, 0.4315004428754691, 0.5342593207462982, 0.8319974212617477, 0.36356104132097405, 0.42486020902173166, 0.6792295980056899, 0.6356913919727412, 0.7155898931788369, 0.7578991803861036, 0.6587454088332514, 0.49079989352397013, 0.78608233405951, 0.6429569393118366, 0.6263280477619235, 0.5702887986093823, 0.14543767958866516, 0.7659554503043688, 0.6424126786985148, 0.5222362545404668, 0.5061227639231196, 0.5995911471540678, 0.15856320101877797, 0.5738195162204824, 0.6681988595443484, 0.6097198033133636, 0.40250369470015906, 0.7615617165670265, 1.0409355470179122, 0.3655822713528767, 0.5019981887570759, 0.45384536687849497},
    {0.49531552472560647, 0.5013493841674372, 0.46536075577753166, 0.6163003260782982, 0.5427884520491256, 0.3128233800333016, 0.4728465107857264, 1.0667809609728787, 0.6128960440334288, 0.46502266191553254, 0.40936144095020044, 0.343308603835656, 0.6327654737965427, 0.5985080044924898, 0.7216916498122178, 0.775161844582756, 0.09869243732755414, 0.5363726773518313, 0.9075455910837842, 0.6619070581285269, 0.3238587654785363, 0.5066157981157948, 0.0006822633996419735, 0.6654685470787163, 0.7737605090284974, 0.35240007561248765, 1.0080002939016133, 0.8359168764145534, 0.6142727728344174, 0.6384709675811202, 0.5475453747792929, 0.5242362161825952},
    {0.578984495945682, 0.7159078007382849, 0.5958053259769555, 0.6799907950496861, 0.92613135181378, 0.6623263842311502, 0.652131382674564, 0.6565815761682229, 0.8606494915522536, 0.6311217499148135, 0.8281147579459556, 0.4774419130998827, 0.3896580758321212, 1.056508692565505, 0.5532794615264425, 0.44976470311674704, 0.1676168574539752, 0.5774260129881196, 0.8475976689178275, 0.7176250846115549, 0.6304569856582812, 0.8451692821780972, 0.2574478407225363, 0.7050113734063002, 0.8952656978840055, 0.8889255202391094, 0.7676331640053657, 0.4557329709660049, 0.5892938813763086, 0.5302536520249113, 0.6904765037873453, 0.8370776868249103},
    {0.335571797527565, 0.5139812159772372, 0.30725096849825534, 0.42299382663629415, 0.7868404703244756, 0.30049097017369825, 0.865097035014996, 0.5970093746589119, 0.6232038961770262, 0.43667913192858887, 0.5971104510963176, 0.6062115736806106, 0.7920592879837417, 0.5822961610846443, 0.7348566540639099, 0.5547472756823697, -0.027190059621344347, 0.5312882637604426, 0.44736290563762293, 0.6123335612587334, 0.4759193037532355, 0.4134591119359262, -0.2920381220441653, 0.5789399263519376, 0.6799712099371077, 0.6991500505410987, 0.8269176845898942, 0.8146919146989661, 0.8647811851105344, 0.5646980633975607, 0.28115428038333484, 0.5980696489223445},
    {0.3086909864589764, 0.26820179620350826, 0.25512706300321875, 0.6604334583690119, 0.7029600184408391, 0.4050759742322644, 0.5132866087286813, 0.41961222392226294, 0.9210316683539731, 0.534202809889807, 0.5589180470431052, 0.3748334044598139, 1.0820704993021701, 0.4297145062841825, 0.5579317769631177, 0.6018639652577548, -0.2531787786641857, 0.6130451082312872, 1.035864307924172, 0.7172348615574032, 0.5435264819700197, 0.7306863483691982, -0.06045462276497029, 0.7039052928735586, 0.4793234902937984, 0.6928742596954831, 0.5887832942138839, 0.667356275887472, 0.7887859805317149, 0.6377295292156856, 0.7747017140593472, 0.7159088388236661},
    {0.5651282023241581, 0.5830918438858788, 0.45048817662780716, 0.9404294093881437, 0.9727553307849686, 1.0092470858003657, 0.5497111727038789, 0.36622689943329406, 0.9424466972064705, 0.6859760735367009, 0.6688074765944899, 0.32003168090733375, 1.1003698718478345, 0.6482318377738331, 0.5188832596319468, 0.7976926257948873, 0.11809241980454502, 0.575296096048846, 0.8723428775356754, 0.7290295741769686, 0.8450880207612409, 0.8854919950309865, -0.06924361101428546, 0.5514064697827055, 0.3640857785012325, 1.0212729928427653, 0.6913657682086095, 0.5846581179809944, 0.7330235729591956, 0.7427452177092333, 0.2665167192372501, 1.1168140383107492},
    {0.5114108313009529, 0.3450777391558989, 0.3877391731197025, 0.9197556583684308, 0.7396594477189976, 0.6022360288168118, 0.881389808714874, 0.629479580114266, 0.6311941860241106, 0.6059959548109051, 0.8243754801353698, 0.4842102376869692, 0.8168587048059118, 0.7739053719942289, 0.7128929514515853, 0.5760328023949123, -0.030660228191578463, 0.6958275369558284, 0.5768203145300116, 0.4148269729677076, 0.4273159274412883, 0.8223669393677135, 0.28011417798739924, 0.5723884293306855, 0.7953232586545521, 0.6287070758184888, 0.8449495223881573, 0.7267221560194708, 0.6841566535825467, 0.6987766317799856, 0.9270162772973737, 0.6832680045898097},
    {0.5421289769660875, 0.8455356678306937, 0.46424834892664907, 0.557490822609841, 0.9263486326529681, 0.768860348120983, 0.6996363888696835, 0.6600134468674775, 0.7081860977468554, 0.5871046859047357, 0.7259291375720923, 0.659748012070299, 0.8953523908003909, 0.4946315340832016, 0.43334957599790874, 0.6561159229568518, 0.08447023377558213, 0.8550271535302096, 0.7398917431214049, 0.6415575785001975, -0.050261894833518846, 0.6771078399277594, -0.10852582062306117, 0.43300521978946477, 0.34348157428907844, 0.5060549447865754, 0.6816593434221905, 0.7010457912893016, 0.8088065438486548, 0.7631937751855775, 0.5811471822290221, 0.6333641177858894},
    {0.5855658150020512, 0.4391529619971381, 0.3349490762712848, 0.42542915943890863, 0.5614396413036752, 0.44548418621423524, 0.5793636957063912, 0.5185765535483537, 0.521522911605923, 0.2654839441305661, 0.5471060040478863, 0.45195976318749065, 0.5737103706210982, 0.5798648812200362, 0.8079856010518702, 0.9262635495522882, -0.243569346272065, 0.5777694742215513, 0.4676396003117827, 0.5641680133081236, 0.5473528436808706, 1.0894526236934416, -0.20111919058211125, 0.23412550932560205, 0.7144072057402979, 0.7895412815526022, 0.47481199181732847, 0.5392861673789014, 0.45160599636843435, 0.8489339392916125, 0.2820516786617032, 0.7659557818502597},
    {0.4428651057662584, 0.2145187530742005, 0.36987580925412805, 0.8912118587528869, 0.45449938223339986, 0.7405396161064626, 1.0813738492724572, 0.5679062021250745, 0.32060020204045675, 0.36445478062517295, 0.7651342532467893, 0.5767362400208651, 0.709189703236987, 0.81520848038676, 0.6206507534261918, 0.7504778381448606, -0.015725315763465003, 0.5749377744358579, 0.610699580567818, 0.5044277923920532, 0.21905851944076438, 0.40339014367408405, 0.08042237849340553, 0.3281417876059, 0.7497323888692935, 0.4986311138407302, 0.6616443971693838, 0.6306772442733124, 0.9755597861874827, 0.6840715437492723, 0.6771912055718371, 0.34661845720828605},
    {0.23313923054281832, 0.5348548958591465, 0.38428468355556034, 0.6844708650353468, 0.7218789242094, 0.6827574582407298, 0.6663997265221399, 0.9163841779702903, 0.5693839262710376, 0.4389997797970578, 0.714398725356574, 0.7889179113032233, 0.7517969796070999, 0.7479951818079161, 0.6705552582451576, 0.7624359502789188, 0.015596426334857234, 0.42818632319362304, 0.7222321021527558, 0.5095415150285932, 0.3444072792739009, 0.9095352065421642, -0.054145637787216365, 0.6350317782847871, 0.6071049780660107, 0.5082835181321139, 0.7475246878354574, 0.6811278562159612, 0.7645313374340214, 0.35931433420696235, 0.32185341396426953, 0.7702023512423537},
    {0.32452469517926147, 0.44654353399939734, 0.5104254473778922, 0.7830455625499189, 0.6916030684807889, 0.5354606867285734, 0.5903885280496735, 0.6670274175298696, 0.49966527820540996, 0.3632149691996338, 0.710405301788603, 0.6757508134331185, 0.7685862759427632, 0.7584337663057753, 0.8056009559636231, 0.690733488440146, -0.044894178466855325, 0.5593640591903218, 0.700859374361722, 0.5452621591608982, 0.5558905318341035, 0.78852747942755, -0.3195827209038159, 0.23192875273127234, 0.4256744484235622, 0.5649438341525092, 0.7535623904932999, 0.9139827809674556, 0.8743517421867066, 0.32677489584445985, 0.39103150990753455, 0.6702125356781929},
    {0.5569961628234893, 0.38446462489328004, 0.4732506053117687, 0.8861369057667492, 0.5559376531708414, 0.7001954891245883, 0.2524494837361977, 0.7117530196852222, 0.6216598644702386, 0.2040520469468033, 0.42442000713234806, 0.3634166996825434, 0.5243781350583411, 0.7625828164656077, 0.6307842299166482, 0.7071304516274914, -0.4192981749553502, 0.8242821655171706, 0.9445482146361125, 0.5187664430679358, 0.27042214588952906, 0.7680355556463719, -0.2444008271721278, 0.6356717307122894, 0.8921044511588816, 0.6286327230891883, 0.6044619942305355, 0.5638806520529399, 0.7083549992588708, 0.5373596085668498, 0.25716632304771525, 0.2958097605807874},
    {0.4998473089911192, 0.4865801719748129, 0.30645049055294366, 0.45917907207981523, 0.7331751713242312, 0.3715883355135126, 0.83402471096797, 0.5561405942593433, 0.9343134601594258, 0.9488236843629103, 0.7890956580146488, 0.5092211537336004, 0.8532120991475819, 0.5536588858674245, 0.3852596596695877, 0.8439942667413384, -0.40305007744160853, 0.6970706335024602, 0.6182181756064925, 0.6719732875790829, 0.3552735147798704, 0.41573952151668564, -0.07551271202924995, 0.45644251633423566, 0.8459877085808377, 0.6141201907256658, 0.6569398411960439, 0.8506144159422845, 0.8252003079930577, 0.5920657528635859, 0.6204674238844168, 0.9060225341269988},
    {0.6179684634290049, 0.740755055109913, 0.7680273333470301, 0.7059798599014812, 0.6068855766959953, 0.7533754408332436, 0.6395789109740886, 0.7972524986864385, 0.6759586855096221, 0.36755047524403894, 0.6663860660136622, 0.6768674378673069, 0.5906427774721776, 0.7456141544828647, 0.3991098700098463, 0.697148487579166, 0.0266171543617189, 0.7742408381642631, 0.88317658681157, 0.6781893383066151, 0.038412912809931955, 0.7656410262080258, -0.016839332358979327, 0.7102135481089406, 0.5679631350244201, 0.784980288758386, 0.7924008773312804, 0.6367172191436142, 0.8496700077062279, 0.578027478322418, 0.7190421923347974, 0.7522903589806257},
    {0.699707422893061, 0.4138639276311517, 0.8161829894047119, 0.34462579007413313, 0.8891590871120433, 0.6543985742440755, 0.6239220139266414, 0.6014669195339821, 0.9311296115185859, 0.27369108412228405, 0.7193125122248611, 0.7072582949685067, 1.075626724411802, 0.4668839174280137, 0.6012188661412737, 0.5382347450016046, -0.22420558002360394, 0.20513742620926062, 0.860435112939826, 0.32081102972512576, 0.5839985192765884, 0.939306989920107, -0.3104534628907714, 0.701005680271616, 0.8646809054078625, 1.0704487364749826, 0.133126166811572, 0.6651901689612665, 0.3338736938423992, 0.7550027749478443, 0.4703113152045743, 0.5250687020771043},
    {0.5290799673003179, 0.776480218630825, 0.8461334588236828, 0.8828944265457154, 1.2114006632902277, 0.4874286721626771, 0.6955188136863097, 0.9122238644152029, 0.6469954908755308, 0.6643812639157692, 0.5080937779973912, 0.8242182192932711, 1.0770660091040767, 0.9309004878554358, 0.5350602266469875, 0.7975566227348974, -0.017336468093060404, 0.7424237020480192, 0.6401121242553078, 0.512280262293409, 0.35309513393807046, 1.0916927718927187, -0.08327588902542125, 0.4893828127115623, 0.7087881709050914, 0.7090068213950692, 0.3278302573679888, 0.74067832633943, 0.4972728799088103, 0.24967593599661744, 0.5815094534132219, 0.6475777532640046},
    {0.5972017639874886, 0.4404968457059508, 0.5134332459727636, 0.6562563361148827, 1.0479200720919524, 0.9722942216885512, 0.6261831576955745, 1.0520632307710063, 0.8217485565463434, 0.4910895223661834, 0.4438199273020876, 0.5457512385505167, 0.6038034271002937, 0.5322410564467601, 0.43389635203668486, 0.5018572002654015, -0.11799551974184001, 0.7313030665851857, 0.7466016008401811, 1.011961202668393, 0.45788067763595347, 0.9846865204278341, 0.16675322013169594, 0.4958063179698039, 0.5261517140192128, 0.5240811461515229, 0.9048815686011945, 0.8127407790887354, 0.8735287036707313, 0.8002670985838208, 0.4613545947031652, 0.7781037129864806},
    {0.4280215415268341, 0.2864553609282525, 0.5353400292101294, 0.7854550882288349, 1.1193390699500545, 0.5699720966752726, 0.5983945270763057, 0.5823513258186833, 0.5665051261396239, 0.4711095136834086, 0.7059742133216103, 0.4208633758504209, 0.6330902667670824, 0.48915359690693294, 0.7395771489548061, 0.673245355792081, 0.19160452380686516, 0.565342425169365, 0.2624215531755587, 0.6254523246972888, 0.2215973791392963, 0.6371943149075511, -0.2673282545727716, 0.24174785733330192, 1.074248382477647, 0.6168391391375184, 0.6908046805620721, 0.8998323725652819, 0.7157711227166831, 0.6793612735298493, 0.5159723021760765, 0.681923627847062},
    {0.31981234623321625, 0.21450205892271312, 0.33589421906081735, 0.6286251360690315, 0.7944216168100952, 0.7956379719000785, 0.9318963450656198, 0.6837406584772006, 0.6623726948414072, 0.4859395938645343, 0.6006014901572079, 0.8104062078657286, 0.7676317076885057, 0.631673225065774, 0.3052007027034015, 0.7546413516832076, 0.04456831758720132, 0.3012877710706759, 0.8793108708565881, 0.6143919950989574, 0.9101905730944366, 0.7990852471159321, -0.057285792788975914, 0.5054638981382112, 0.6399668831214527, 0.8331991153812285, 0.7658499725424838, 0.8673737359927909, 0.8081625365434276, 0.4872738399835717, 0.6043743360256596, 0.5439977061413049},
    {0.3134159478817439, 0.5970777015592729, 0.3062710419716811, 0.8422475123055753, 0.9405225432757308, 0.7068915706239628, 0.9993225520727049, 0.5556458371365638, 0.7670737682637865, 0.7140849701939579, 0.6033444323642372, 0.42082296449328593, 0.7363477870196078, 0.397281005435245, 0.26548428225283116, 0.8077996765569921, -0.056251525541034665, 0.5225892772391625, 0.5407541304494571, 0.7090460372181902, 0.4702625220296081, 0.941896578835431, 0.08511830405198567, 0.49312372898015744, 0.4220305052966433, 0.744061177769895, 0.5122358846609493, 0.70704741017226, 0.8693169191162424, 0.48056905027256275, 0.5256127975201942, 0.6291462662550747},
    {0.26486319354013, 0.5029919399133315, 0.5158498951624744, 0.4140499365535691, 0.9789102651519345, 0.7403714785201259, 0.8969070260874085, 0.6300068521126896, 0.5729986218356272, 0.5289134017905869, 0.5493760349637383, 0.4388077798855988, 0.5640644301069407, 0.5543908038720005, 0.5761306531173764, 0.6384164191582958, 0.08505793556281978, 0.56689660965475, 0.7484164612738008, 0.7559298105498174, 0.43965955041200616, 0.5319799585167038, -0.3651089985150396, 0.3978899246050276, 0.5176913097424264, 0.7959868775292809, 0.7863376540274747, 0.568207534189425, 1.0629507004763277, 0.5528532068336703, 0.21235495196475723, 0.6818362023092178},
    {0.31613089574054914, 0.4297601696452098, 0.5747613323339139, 0.380644613657592, 0.5612808326681754, 0.11488099112327337, 0.5494145091201436, 0.3589240609138019, 0.6683343654456438, 0.3154174546837417, 0.7542647074622051, 0.6439326493471711, 0.8811247388899216, 1.035428252627105, 0.6435639235720478, 0.578834641891084, 0.15660733350331282, 0.39935750919730456, 0.45505256526916604, 0.5549004342654517, 0.5820913839068654, 0.7605978949046892, -0.09273134093303427, 0.5906403425945429, 0.5661197211609409, 0.4674173618429716, 0.9742179002921845, 0.46611605433548187, 0.6025564307591937, 0.6541976416688009, 0.5831073009167747, 0.7981757183454019},
    {0.284663561413152, 0.21293118807707492, 0.44582812362183255, 0.8657169942625161, 0.6713035016804236, 0.5171914264956892, 0.7193423234605196, 0.7251091573055746, 0.760358501861066, 0.5543166763103161, 0.9366074334031181, 0.7120599285420284, 0.9387917524548465, 0.3158549757684476, 0.4252300545599149, 0.5482525321810832, -0.030315169557116824, 0.4780370858613223, 0.9156243102610839, 0.8028160643826727, 0.40079449211735085, 0.899960255387126, -0.292146642155493, 0.8882449813671971, 0.7620100467069781, 0.6092433604416995, 0.8478069795498715, 0.5914634242738864, 0.7117756989782672, 0.45558509532351077, 0.2603256825522264, 0.6718707899291779},
    {0.5356572130418744, 0.46284936972911184, 0.45728104340780834, 0.4197515886879553, 1.048048023316746, 0.4362374586418216, 0.5365663107676206, 0.8076950712993103, 0.5145134950931162, 0.46994521788672433, 0.9545093291991763, 0.3741949187740725, 0.7622729167952362, 0.6873248130628238, 0.6573211629501884, 0.5972115297354403, -0.11504369079981844, 0.43532326464751775, 0.8778376726855692, 0.871845129184972, 0.7013047410361188, 0.9718290700108854, -0.08905338383292076, 0.6841298271291778, 0.5007230052611075, 0.7012896135785583, 0.8258238915195296, 0.5510657637452899, 0.6622381871303504, 0.01427708119857155, 0.3501986843957056, 0.5912208173412347},
    {0.5975329711208207, 0.503488306777287, 0.3692697398102553, 0.7874539530457565, 0.6830299714098275, 0.34138760665685625, 0.6631837525320133, 0.9293294040298196, 0.5597554922684573, 0.4417064502368343, 0.6056881964531481, 0.7302071864236163, 0.5055430963160435, 0.9643197938937653, 0.7373437662947991, 0.7859798971306421, -0.21179394040853092, 0.5163642357961673, 0.6095775006124992, 0.6069988194969191, 0.6303672507191193, 0.7962097072290668, -0.09771873634083733, 0.39851605289806835, 0.736277041377304, 0.8005313412082671, 0.9296755661032045, 0.4993285055293652, 0.8841201183469892, 0.803795686786878, 0.3714682352819183, 0.8652692972988077},
    {0.29398475971809185, 0.5105746355262157, 0.1908905500524916, 1.0122710251924858, 0.6279175344780398, 0.6437804535257167, 0.6482858729527112, 0.7057287738155407, 0.7820388348457623, 0.4551098715480406, 0.6978296521972666, 0.7433620858603869, 0.6019713777299847, 0.8016504430011298, 0.7542050716453715, 0.8613747862443469, 0.20054698883797867, 0.8640763669206565, 0.7020474649304227, 0.4354421975294984, 0.33275511485642806, 0.6812658212760967, 0.18107755044481327, 0.5109944968713451, 0.8055939337781112, 0.843093677921193, 0.6316168103404326, 0.7259837729997307, 0.6690043356486126, 0.7851410896021297, 0.7686408759826755, 0.7167269729084389},
    {0.6554545253113877, 0.4654309452661559, 0.766604578024152, 0.7381365346311148, 0.7143735077176037, 0.5114716725031326, 0.6843055315720106, 0.6127028985774385, 0.8252810022362139, 0.5245410712719416, 1.0496529659623306, 0.6488609345173493, 0.6086456497850012, 0.7603724457883662, 0.879329800629776, 0.6127577609193391, -0.18007590437182056, 0.6810036939900829, 0.3595573435577665, 1.2133999580678032, 0.38002223519639444, 0.5202937503830974, -0.17203725483299334, 0.489226263632173, 0.5880956347123049, 0.6603874544955558, 0.7059899905946063, 0.990118292840849, 0.7565261322194388, 0.6305291653775598, 0.6701650397511049, 0.6261253096591934},
    {0.8388687342217859, 0.7398399034515621, 0.49644995579940726, 0.6525364678641596, 0.6505597579737507, 0.599438720306996, 0.5793420772436304, 0.656436141410291, 0.3297814255237715, 0.5529021723610913, 0.7513367458502105, 0.771315196776609, 0.5617497773740868, 0.8649137206342107, 0.5873795642787643, 0.7537519346346357, 0.046352787409705644, 0.7853897502439278, 0.6278015435632872, 0.74591653642516, 0.7543459753486558, 0.2081018773940595, 0.05310064440927391, 0.5438012113173953, 0.7398904779614977, 1.1042348050542485, 0.7876696381789948, 0.47312895215821704, 0.7324784108237652, 0.7588749052333423, 0.3417158092029908, 0.4405408749922938},
    {0.718922344899604, 0.39515757257533224, 0.5004091131356752, 0.2811380012920793, 0.62854807527962, 0.649950046935703, 0.6492955610307214, 0.840995630722524, 1.1718040984308018, 0.3440820235379679, 0.6488236118025783, 0.5728404793219762, 0.7388322170933905, 0.5296413978086032, 0.4793801758660559, 0.6966319493464035, -0.3183005282216709, 0.43957651559174293, 0.5357768544915551, 0.5161582011463687, 0.5787123711922633, 0.6395253627483752, -0.27876838488460454, 0.5582469387942199, 0.43682676417169114, 0.9462316788389918, 0.937385883992377, 0.754713145191459, 0.9522106169764846, 0.5412169081289333, 0.19689072499861834, 0.5779028291494306},
    {0.11105197332416264, 0.3302342235608433, 0.34764674500376463, 0.5351477032928462, 1.0321377365852171, 0.7648930057342416, 0.9582164434824709, 0.4966918876939779, 0.5406566645288327, 0.20301791423495164, 0.7731176328181039, 0.6556342018045059, 1.0056644289622694, 0.9160857331579217, 0.7466062477228588, 0.7600283906922976, -0.23195662126768035, 0.3247531069964755, 0.883447338214393, 0.5671677323655016, 0.5214028726500671, 0.6442403542652873, -0.06335652711109141, 0.3612998779665773, 0.6417540529747457, 0.4359587423777563, 0.4659579829182181, 0.8143019386434166, 0.8935702051760919, 0.8349845622423183, 0.5909986123310671, 0.615512642520622},
    {0.5587252684198758, 0.46480652216546026, 0.6466265521596595, 0.7416310895057958, 0.43220448853861004, 0.6679663998423007, 0.7158845464537062, 0.646848937434561, 0.6679241821961599, 0.4136568960101601, 0.6484732919495652, 0.7087726179623829, 0.47559472320931295, 0.8631114319028385, 0.7048893217206796, 0.825716319730981, -0.0029499727117076307, 0.6395737012287996, 0.5989662166261069, 0.5245838120311745, 0.15987422396757378, 0.923929101394801, -0.049977503285012666, 0.6604676618900289, 0.7461053613610568, 0.7915264484382248, 0.8596481920412181, 0.38063598175324836, 0.950589299317573, 0.6281104959790229, 0.31413784231363767, 0.6605080588813262},
    {0.40227752567237673, 0.5311577971483771, 0.2547721741573935, 0.730248445584352, 0.7260642885690215, 0.593835194275974, 0.7269962661119455, 0.9592568880830522, 0.8528845526125802, 1.1082020989476866, 1.1447412885053523, 0.899337395773076, 0.5438611331939696, 0.835288814163638, 0.7995296914143801, 0.45959459832410005, 0.04350733233307369, 0.3514699395405318, 0.5317666324464344, 0.6976576550649316, 0.4624576545839586, 0.8095256171465066, -0.041792977192666426, 0.4637836205775691, 0.6203803225282821, 0.8084973469890389, 0.8534732560543694, 0.26345228676152205, 0.5670956191892427, 0.7583423030212647, 0.5780082889000895, 0.6197413094810575},
    {0.40806679653895567, 0.718642461621747, 0.48018444532068866, 0.5759169868980308, 0.8571234538385761, 0.643689567129901, 0.7924783179121222, 0.774026083677876, 0.9745565658900398, 0.45089729842636517, 0.5119298536001888, 0.43646756867452036, 0.5464333061862642, 0.6744608881181605, 0.49125308056693634, 0.575458189177419, -0.20179579295994265, 0.7077288687923556, 0.8284827529353405, 0.33212034321227457, 0.44331249815830953, 0.8552797649481897, 0.14318966457452614, 0.8929702214778799, 0.6277011273180019, 0.5687528928654654, 0.9670114970844809, 0.7407208153647641, 1.275771594125556, 0.5273607748213622, 0.43135093302573824, 0.5076863789874911}
};

static const float b2[32] = {0.4020811458751024, 0.512243094261937, 0.4134522678306525, 0.6454409867047698, 0.7176882546852323, 0.5253705297360219, 0.666045155426675, 0.6955340296209881, 0.7371537091711445, 0.46551078325244555, 0.6031112000425963, 0.540918039025321, 0.6851164836813878, 0.6541721338936016, 0.6167895239471527, 0.6338521442680289, -0.08718418701574936, 0.5557072321229284, 0.6436154652689999, 0.6711628709920526, 0.46996987285108016, 0.6874063298171098, -0.020400063604578002, 0.5062048523096996, 0.6639309492572025, 0.619582102351145, 0.7062268193875114, 0.6487691705176912, 0.6916501798669059, 0.5722455636362733, 0.4624861153603907, 0.697674967657084};

static const float w3[32][16] = {
    {-0.06361449971069491, 0.3084167720155475, 0.06459548139855016, 0.8574579982202885, 0.23200071329170624, 0.09256475312221599, 0.4890178502915293, -0.16354364910816416, 0.5277312158506205, 0.12202833049961555, 0.9062848093308773, 0.3871614431501093, 0.02883374055141595, 0.534575525798856, 0.6853616348304542, 0.4703010281567502},
    {0.3229977151169977, 0.135543988616309, -0.5600942603774671, 0.7633857724794427, 0.7312245428189599, 0.029906637255459768, 0.10943483249791049, 0.05159969669437808, 0.8730804053225512, -0.10971285432964505, 0.47101886566039963, 0.9535323067972243, -0.19561524415955336, 0.501795316361091, 0.47625954900555373, 0.7426559144058487},
    {-0.31568365973472934, 0.007548087835942932, 0.2453879979569433, 0.388738515353714, 0.4614492230739832, -0.11706982469913535, 0.731390823073447, 0.1207571398034069, 0.7906055956720417, 0.06154227736078509, 0.5587362830707164, 0.7475397902023267, 0.22521671904424184, 0.7604054321509821, 0.45464408861209826, 0.5222987385869334},
    {-0.165635401573841, 0.24691312717829075, -0.1879632697621224, 0.5599493125047855, 0.726516476397299, -0.3997905290528345, 0.5246255081573988, 0.38695361064963013, 0.46575242316030124, -0.5617212127434714, 1.047580302425773, 0.7776519493091126, 0.19446131338440867, 0.5459515639192932, 0.9021887407851737, 0.7062358313388771},
    {0.08594506366026254, -0.25866281677024283, -0.2711821540348039, 0.6689765070604771, 1.034234988928783, -0.24919202220415732, 0.7349371626764988, -0.16563652560226738, 0.5449852248679314, -0.01784885685992501, 0.9499357116973048, 0.971971989019229, -0.13146049433847998, 0.9269676101169007, 0.8642429482849657, 0.36269086462955547},
    {-0.006332471836708402, 0.3253512798844131, 0.10799579122872478, 0.8992865033597404, 0.5654250718715733, 0.06336971900588254, 0.4504832597157596, 0.6048361387056764, 0.6864849823482788, 0.04669098096399523, 0.8887089289511183, 0.583563837664687, 0.35130820093837173, 1.0491238709202826, 0.31018480721112884, 0.8860884654294493},
    {-0.5206295051028147, -0.04280491975515683, 0.05870229147149495, 0.8470162855668504, 0.730924807814695, 0.035702771210228065, 0.7864472031252836, 0.08519623037288795, 0.45426586459863316, -0.17446567962312368, 0.6364003995634573, 0.46046211049448676, -0.2592306046884922, 0.8047259464920226, 0.6735217684172552, 1.0187842032856835},
    {0.15866078624233063, -0.6051517461295234, -0.005054721488625579, 0.90911670812109, 1.0071782894706518, -0.4983007759542117, 0.8445509786721501, -0.12441603012133029, 0.4599837136009465, -0.16376003475501555, 0.5621699841342889, 0.843196324395253, 0.11074341285771444, 0.41646316017308477, 0.8492150565680429, 0.6446596012164767},
    {-0.3803938221267848, -0.10281036609032582, -0.00978441065969482, 1.0393312672856645, 0.44634490583525976, 0.2683618698025943, 0.9329608787246342, -0.6069256542323518, 0.6166912700788049, 0.1027952512697381, 1.06609358300639, 0.7917679728427843, 0.01098313103204689, 0.8829609172351428, 0.8758834448859347, 0.16465886633065213},
    {-0.03921420845775726, 0.08771406816352767, -0.06199876942650378, 0.32161949432693265, 0.26058048507584286, -0.050688333006610804, 0.9836423652798337, 0.11158062760510405, 0.8147254040262923, -0.02118244782968434, 1.175501993298542, 0.8580036735312294, -0.2581483814653164, 0.762454434103899, 0.44943795296340633, 0.37030509008421597},
    {0.061593723110444296, -0.009868675810307277, 0.02075533368679567, 0.8136058394889338, 0.9706243597661747, -0.08582311714849983, 0.3264171980647086, -0.04305658995679536, 0.8620820601791576, 0.1906119319904861, 0.8953009275769269, 0.6515847861915292, 0.2339662491082361, 0.532616320947908, 0.530367768970881, 0.6434250492031914},
    {0.151199114671164, 0.22339765468869663, -0.05765458981039977, 1.0950760830936905, 1.0686034087229377, 0.23554371574752167, 0.6158234825317423, -0.18803992553082827, 0.9017309845246125, 0.23078250060716313, 0.5248285286371491, 0.9239361661770882, 0.11663075061150864, 0.5753067070508568, 0.6148354125842681, 1.1495270798854396},
    {-0.08833258035153435, 0.27065580913937826, 0.20147758488891687, 1.0261404012764488, 0.9213553771390974, -0.12035116693043503, 0.4942045462114864, -0.047386045799532, 0.3468174655955542, -0.3568074215462642, 0.5816013153135744, 0.4306263531874425, 0.05084745950326485, 0.6428319932784811, 0.7585425570415013, 0.5979690406400335},
    {-0.18385824423071473, -0.23878123202446735, 0.31579703863322783, 0.7386259658973803, 1.00725417486659, 0.03724913841089994, 1.0712315202226013, -0.24129181165111455, 1.0271663035122947, 0.05323139524707175, 1.1009854238186085, 0.6560402288813935, 0.6538924258779515, 0.5320551249625123, 0.8362500580103155, 0.9046517205145477},
    {0.38845702322224074, -0.44078910191302045, -0.3963979609124158, 0.5570813613600476, 0.9187956337203564, 0.03759600454787775, 0.5747141944835433, -0.13987028459218084, 1.0182095713199906, -0.32970500358033056, 0.5783878570509116, 0.9483590233960102, -0.5429878219664458, 0.5827468260281756, 0.5918232190952342, 0.40179978551669093},
    {0.37153944653715865, -0.08772194630878898, -0.13497001059279115, 1.0637158543713814, 1.1284470622077902, 0.016141364353561276, 1.0621644188724906, 0.09125652165547468, 0.8084821888170601, 0.14738273076996938, 0.7862323425088847, 0.5045640456614365, 0.05368894244342038, 0.8190857612757001, 0.7054138965395065, 0.43302658286455625},
    {0.020737393700221686, -0.39392717248350534, 0.2104187442320006, -0.14184855084064543, -0.06037406168445691, 0.11483470091344347, -0.21257478430448998, -0.22380431326508385, -0.053850062703435335, 0.39926768826596837, -0.1392945430024515, -0.19951291702992385, -0.4692090908901715, -0.054920245798200484, 0.16231324237693942, 0.05285065948417392},
    {-0.3243085804188144, -0.1327451795995845, -0.32206079099261753, 0.49332507844203005, 0.6036689266332009, -0.015629194682503424, 0.8044167293439072, 0.04784147043295919, 0.52410897175339, 0.36456837352959093, 1.0642612553307018, 0.4125913394771438, 0.08736776430100114, 0.6648923985134053, 0.567648933633129, 0.38641217524171373},
    {-0.3796108516898465, 0.08497886719450011, -0.4741744627145842, 1.139098983216641, 0.9384802572816257, 0.14831965166138864, 1.0940799107481272, -0.11982666784722881, 0.6627217807907152, 0.28788891812732637, 0.8219673526363107, 0.79614822168447, -0.04956921475003807, 0.7050130217909183, 0.5060354049948523, 0.8899882273827904},
    {0.20279183802074136, -0.0796771701140384, -0.02951611985009828, 1.0406085699384413, 0.9544712241083281, -0.4048212118273889, 0.7129247570902945, 0.04975844973179111, 0.7252136457992431, 0.037762884560241614, 0.9312792765524337, 0.6140301041198252, -0.3446463813376326, 0.9199820000541362, 1.1278156875516483, 0.4642698560253454},
    {0.5619306748285252, 0.2503639870949285, -0.06058025027489548, 0.6934549778388057, 1.0158956465942781, -0.2797907532095204, 0.35322921776172855, -0.08570863362172854, 0.5779233960243357, -0.08180743091391708, 0.5836075663877652, 0.8480609836700638, 0.08465417277861384, 0.4817762565051123, 0.454141831147382, 0.6595477892529695},
    {-0.03628323383075357, -0.046097967320624676, -0.18252311028506926, 0.8632073834957444, 0.9826751217889376, -0.06066700840054877, 0.5487645454642747, -0.5063153343061239, 0.7385789756954703, -0.08173444107163944, 0.7819465068797982, 1.038821302629278, -0.05341065304748705, 0.8848592099101467, 0.9613397561486348, 0.8945967633377463},
    {0.20071676096400348, -0.5211108370701606, 0.2964102781226753, -0.07332855748669283, -0.07985373542886015, 0.23068261983909927, -0.34019288041183515, 0.014314301640292055, 0.470121528545608, 0.24648469678238732, -0.41407013825828715, 0.026591596529373446, -0.11542176544780679, -0.2005807055346755, 0.07199771565417099, -0.1768996597896077},
    {0.043977513444411295, 0.02392181368101575, 0.7288969096037768, 0.892968860574752, 0.521584142687125, 0.4896904147852025, 0.6544102748180298, 0.00213196361560686, 0.6463692511786635, 0.24267398527064446, 0.8829110711403353, 0.5860224699401179, -0.009703586203985448, 1.0451431844372139, 0.46957132743911506, 0.551971528081043},
    {-0.06791907507495981, -0.15545743132045012, 0.19422724427035187, 0.9041593330826576, 0.8131920829790075, -0.012833941260529275, 0.695027307908041, 0.12443830783968396, 1.2041975328361727, 0.2228502203195896, 1.0080679746298997, 0.7936644519644872, -0.13754135784510374, 0.6055809257707805, 0.6620019716837904, 0.14596659633297754},
    {0.3083704896293213, -0.1363766534658953, -0.11756006298976436, 0.6120101323835732, 0.9990793502354524, -0.06300894227177439, 0.4226999263174439, 0.23123218107713503, 0.8680372488964498, -0.022184712556199224, 0.6885359572719204, 0.6865356613615591, -0.3479075150180723, 0.7724544028470659, 0.3935858967927258, 0.62158326876736},
    {-0.0608514167178447, -0.3426614618377917, -0.06180331260682201, 0.5329610102831404, 0.6167796982603139, -0.3497150861876936, 0.6726644440749389, -0.42833486233993323, 0.7951361989826417, -0.1571246894036553, 0.9222679119165201, 0.9767328313149604, -0.3747639280120379, 1.234984701360878, 0.7431256047760264, 0.6487445822503735},
    {0.16531484470578303, 0.1609015495605992, 0.038029883919585616, 0.9028305061015057, 1.298514597359302, 0.08406155344306004, 0.6517475876778874, 0.04899217127525003, 0.5663219688301262, 0.2232473518137721, 0.5431727335896946, 0.35692724037706297, -0.3720111535584368, 0.9079915053893246, 0.7678561247330434, 0.3675899627686767},
    {-0.041752694494584824, 0.05096532534059185, 0.08431070562367121, 1.0986189593252536, 1.3036152969314685, 0.06789995046997757, 0.6944379691385959, -0.04221310516240629, 0.7244852005248967, -0.4245482536820756, 0.8133427817076343, 0.7189440570402953, 0.04000151689465878, 0.6437438004618435, 0.5619222999997436, 0.6901697242716461},
    {-0.029688709750982905, -0.205035635680913, 0.43356520657844694, 0.4628712262467195, 0.7819306708827641, 0.14942294462460556, 0.5506807192069639, -0.3675129611143263, 0.6427488360309459, 0.20231052955820403, 0.5369335509641323, 0.9381947105533074, -0.02893125151835246, 0.8253928012544407, 0.3468882587106591, 0.29690400006432566},
    {-0.7074536543698648, -0.08806580084085733, -0.16181148848677573, 0.5403008903633209, 0.4143550503617396, 0.3704928960863752, 0.4864513226239242, -0.006125951790655971, 0.5171892109290127, 0.02650456045169196, 1.0719246633285584, 0.7923480250261073, -0.2762541820084332, 0.45144436491685175, 0.29253308327689215, 0.3586275292413912},
    {-0.2558289078128993, -0.2782187584165213, -0.18179655909128953, 0.7724027089558554, 0.7315149014747411, 0.2112971640344239, 0.9500993814127617, -0.27683874111182655, 0.6935964940924682, -0.12815056408543676, 0.7673175668541851, 0.16533605170326673, 0.2795883668085508, 1.065636122494583, 1.0026731398152249, 0.18806265508305967}
};

static const float b3[16] = {-0.061150471982935946, -0.02860612925871411, -0.005604185511290867, 0.5645946174261278, 0.5171870418293344, -0.03559041566121401, 0.5351816819811634, -0.03435384909873555, 0.5124109412587037, -0.012802295516714034, 0.5464493233307268, 0.5240632488478102, -0.03617204561234264, 0.5145913441373742, 0.4754481544109496, 0.31118294858161905};

static const float w4[16][12] = {
    {-0.5137047310422679, -0.02676303340877501, 0.028957264658553868, 0.3995716676110907, 0.4796060150154582, -0.4295525026554051, 0.11427342496213229, 0.0705114889031963, -1.0614538837018292, 0.0017657746127252383, 0.2649649818052663, 0.8766743809071412},
    {0.27683290811302336, 0.21256498620572317, 0.2609469565501265, 0.1340272397491938, 0.2753896341298589, -0.19177151453490193, 0.09561187772683494, 0.3480858990985833, 0.10036884735196837, -0.0891311357049084, -0.21617492274112607, 0.504251236257198},
    {0.554931037649777, -0.1401727255652773, -0.6918521720770474, -0.24400404360509248, 0.33145491621538153, -0.20054336917435636, -0.2499038196637094, -0.19418332283712153, -0.4920084865285156, -0.33782157352137276, -0.04174714797369341, 0.5217870811446272},
    {-0.3771540352893054, -0.3537471985836721, -0.6538803497126325, -0.4952593011015122, -0.48322011869361203, -0.5589271665365918, -0.6811984417406929, -1.009969735471761, -0.6379780212448173, -0.5466268954792759, -1.0700905296142487, -0.7585324630882501},
    {-0.2822230595963113, -0.6957202381366545, -0.6779495397558921, -1.1350060951364882, -0.49127811384061437, -0.7091144070905936, -0.9315766769567382, -0.19201232742748775, -0.755390942505306, -0.3988286247482209, -0.5733392447305955, -0.7501166648081835},
    {-0.010255887085884043, 0.09844469678441861, 0.12320370742616706, 0.37735987997950704, -0.26935861222218055, 0.2166501149506388, -0.09342882848232027, 0.08150535200484159, -0.6790250721685696, 0.9176324626805926, 0.38186075668426944, 0.2873148151889973},
    {-0.3541507637338684, -0.6677728147410746, -0.7509402669491868, -0.42757329006474726, -0.7291001467107012, -0.5045778972556528, -0.2514372503344312, -0.7952503401783687, -0.31197244660054335, -0.9026246677937233, -0.4185685840633874, -0.5866395362507112},
    {-0.5966026833466073, -0.01788867922932364, -0.06601626739137995, 0.274313645824549, -0.5639789439424642, -0.13133851349531225, -0.01768275432557425, 0.12101359737329948, -0.6953316552414754, -0.06346936525051633, 0.33732840446370793, 0.27323857169189936},
    {-0.7066340674898888, -0.6047428110081929, -1.0110474998194248, -0.5577905762554649, -0.2220895752058213, -1.1219308450002246, -1.056698836766035, -0.8385620608693574, -0.33689793388236416, -0.2948357881523866, -0.44851973868319656, -0.43947556899340856},
    {-0.06897994495088942, -0.3714714303292011, 0.3690993469083299, 0.2473615504964674, 0.45719050548206214, -0.17386420309867423, 0.31661589092905973, -0.8344517467006283, 0.3089328243712832, -0.3296956742101565, -0.008979389312728184, 0.5160858680595121},
    {-1.3653522189631888, -0.34782075429372455, -0.14945609323128842, -0.9334204535774941, -0.7147421461784449, -0.5339532839562765, -0.839433110891513, -0.3074281065801063, -1.015644822911783, -1.242400451293508, -0.2096307989015022, -0.4965311227439789},
    {-0.5591950299269637, -0.4850711564898906, -0.21881084523035416, -0.6530256277806391, -1.1804345757234274, -0.3969793358896086, -0.24858745496800308, -0.5607920620870102, -0.9814962496656924, -0.8962970584222214, -0.9990639418908835, -0.4366877937819596},
    {-0.33970958205418184, -0.2360964746339421, -0.059102131102603934, -0.13357170071434288, 0.07736994207091304, 0.05590599492023946, -0.12967367657974832, -0.11621754540221997, 0.5120734296305669, 0.1725133031302667, 0.8750046968487523, 0.4851875227635651},
    {-0.4382603385610064, -0.33846341620454895, -0.3428354124092161, -0.2905102437052924, -0.7551268082659084, -0.4208059813629167, -0.5688006851747947, -0.7952662798834468, -0.08097663144755465, -0.7804291916456133, -1.2178365957807522, -0.8115510970961552},
    {-1.0897317932335149, -1.3496262665095498, -1.1908352068729633, -0.7018921920119985, -0.09738413926171068, -1.0630620687802745, -0.7466399392858619, -0.4030688610494596, -0.6281711766243006, -0.10657223423822156, -0.18735482372823592, -0.2997634758948553},
    {-0.2597619851583012, -0.7600990474910009, -0.5267677457970794, -0.09785376179874529, -0.8403640406494688, -0.09993751289759704, 0.06457867981785771, -0.6079141731943288, -0.6530136807725443, -0.1529665561107143, -0.2225847777298381, -0.8858661907639638}
};

static const float b4[12] = {-0.19805660561318558, -0.25412315439905203, -0.1863641965476143, -0.3065441388041079, -0.2221138654137344, -0.23247520926064708, -0.2653574506370223, -0.15328387515269287, -0.18159222993869403, -0.25426391551737, -0.2490767236140403, -0.27602783916579315};

    // Input Layer 
    float z1[64];
    for (int i = 0; i < 64; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[32];
    for (int i = 0; i < 32; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 64; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Hidden Layers 
    float z3[16];
    for (int i = 0; i < 16; i++)
    {
        z3[i] = b3[i];
        for (int j = 0; j < 32; j++)
        {
            z3[i] += z2[j] * w3[j][i];
        }
        z3[i] = relu(z3[i]);
    }

    // Output Layer
    float z4[12];
    for (int k = 0; k < 12; k++)
    {
        z4[k] = b4[k];
        for (int j = 0; j < 16; j++)
        {
            z4[k] += z3[j] * w4[j][k];
        }
    }
    softmax(z4, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
