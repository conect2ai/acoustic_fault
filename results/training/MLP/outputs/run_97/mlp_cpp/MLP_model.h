#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][64] = {
    {-1.7115644526226064, -1.3264464267443101, -0.7945692711056994, -1.0637592546097445, 0.039232238626411786, 0.7597487359458786, -0.775762945748575, 0.694521082296768, 0.2366549270090076, -1.3446807191339727, -1.322682499016973, -0.12715273921638626, 0.1389972294584529, -1.3300430696298442, -0.02983716704126003, -0.8805061543005868, -0.2666159478290993, 0.5159424495303581, -0.8902298444116639, -0.13534505578415085, -0.3676296802581476, -0.9682722979699496, -1.109312587711277, 0.28729771338247706, -1.6994776837773338, 0.7443031285747594, 0.740454996187273, 0.5144627686701575, 0.6251295549561288, 1.0425699450893975, -0.6231546707558842, -0.9059327088812618, -1.1380679556328241, -1.2055942616229407, 0.33955634227896875, -0.9654149806686927, -0.9759721989846127, -1.4501730768240755, -1.3610694482565406, 0.20871574263524814, -0.6465264491411185, -0.015608919556066506, 0.26539243759501446, -0.35644803943051134, -0.502137739128019, -0.2671656491695883, -0.9480405477772882, -0.6861082952167589, -0.7075935713453166, -1.136143849921439, -0.1907925992257765, 0.9353232507619638, -0.378663904970713, -0.1765180694914289, 0.6652913075165223, -1.8913812457083983, -0.44028274746427665, 0.42865815010385283, -1.1233121441151086, 1.0097833406779055, -0.2780472483666432, -1.1066113678126945, -0.44569927844681795, 0.8623604102260977},
    {0.2594793231749602, -0.7911364501041085, -0.06290959518151916, 0.8468023688128135, 0.7150783682604323, -0.32063869036085485, 1.0170506169687394, 0.9584983910762902, -0.45921587679223264, 0.9133058195242068, 1.1894386224983668, 0.6249631734277814, -0.6235476469119188, 0.21976142652447486, -1.1397901217339084, 0.9962112565978813, 0.023435844870092447, 0.14798326259326508, 1.2140595387102469, 0.22887104695468719, -0.30664965675567407, -0.5930339906448533, -1.026827000175075, -0.8844731039106909, -0.250018528307478, 1.0415404368045567, 0.5247536476987344, 0.46739208469508464, 0.1072454125322585, -0.6339140508437302, 1.1019353338313487, -0.42388733607108586, -0.9296660410568783, -0.6167139483937757, -0.41416438549055734, 0.2894669151821748, 0.5962542577611797, 0.27518233836177375, 0.5159099130126201, 1.2176795452152123, 0.2761284281653998, -0.48679657684255534, -0.4979816640967444, 0.34574095547863193, 0.46233343396870713, 0.9675969468295859, -0.6009851323567482, -0.9799559813352048, -0.8270613344279648, -0.4338833873850483, 0.33140637531523065, -0.13901082522411012, -0.6012412842417514, 0.13121371719103037, -0.2417122816802365, 1.0929062936469292, -0.08758489985036998, -0.5134524676179929, -1.033874510344517, -1.1737051343583151, 0.7265710294368919, -0.355197990810677, -0.8031317101493158, -1.162669178891619},
    {-1.1411302971075625, 0.7700683340308314, 1.2118998222255584, 0.014146985691720473, 1.3415492996485772, -1.346908158847912, -0.07513322779376633, -1.1606709594019768, 0.41977611033707823, -0.8998959141872913, 0.814192843500801, -0.6092867876219266, 0.39085216850600113, 1.2661603866688902, 0.7072128514396715, -0.2516857480026141, -0.8536441908864492, 0.3729331724647662, 0.24058705288712778, -0.035006934952142806, -1.1380206139827989, -0.008828982777146306, 0.04125421130358624, 0.9230168563776717, 0.08480473231682803, -0.8310881817362812, -1.0064481097179478, -0.19203231268366594, -0.16818100330281885, 0.12546026906297655, -0.8267670506896801, -1.0415017263516761, 1.2606956954125654, -0.6977370645751493, 0.18277941485044247, 1.0541384064083823, 0.835290172974984, -0.4864535512698734, 1.134863525351064, 1.3166849894853898e-05, 1.2596595304313112, 0.1744712174126341, -1.0996607278660864, 0.5978096604193276, -0.9732947066018829, -0.5081185347543119, 0.5177082274173911, 1.08467313883358, -0.671636365795754, 0.3276916913512267, -0.6475128713580964, 0.6251539405360781, 1.4301002622659682, 0.5253019488597358, 0.7689958358001704, -0.6820337973150078, -0.09112666164487883, 0.08675426360786159, -0.9170519321074384, 0.7431453516626386, 0.2626331297676565, -0.016524055161550078, -0.5585191900146219, 0.5718866822195454},
    {-0.6988360396784404, -0.5035368915816871, -0.2031968682616049, 0.6520512824001208, 0.382079022303696, -1.52787698499492, 0.42220289008062156, -0.6154488960435853, 0.7568407780483418, -0.11497768507532728, 0.5794351611449374, -0.6214596530199874, 0.3134121749023755, -0.28204189681268094, 1.08557570420835, 0.27684596648922527, 0.09676124928689658, 0.22296957707391557, -0.748139625011954, -0.620705696047646, -1.0219808203644445, -0.1551458706787378, 0.8057423825339414, -0.3640449576103304, -0.6436449074015554, -0.7750858590514136, -0.2042590415806631, 0.5726784788849952, -0.4842695893319632, 1.3884133747750713, -1.291745981303522, -0.8422057205482447, -0.4804992677856044, -0.7275580771953821, -0.01591716266550696, 0.883193648678705, 0.6951791410854635, 0.4778882608992772, 0.7976345252858109, 0.14581344658622758, -0.2215109340997128, 0.3211685720006026, -0.7755828174234003, 0.41584580923524467, 0.6345360534481789, -0.82798566875792, 1.241300569260037, 0.864810080014496, 0.5516926464661951, -0.006650797657160084, 0.7017466877843443, 1.1108852671766738, 0.9686454996433095, 0.3194587330621524, -0.34165468845775704, -0.6869765891899221, 0.19488664030130637, -1.0540526274893733, 0.20700778109256218, 0.34987480685801686, 1.044983107828218, 0.03035506433982533, 0.1256185373479835, 0.7822007570575915},
    {0.5211769193553725, 0.16984874470532207, 0.16809127524880885, -0.6248236780222279, 1.484465157197263, -1.4621415306026648, -0.6183369554277783, -1.008426092218452, 0.6406114013112668, 1.0516564949769247, -0.5141690246603032, 0.6324671815395543, 0.3529015526886361, -0.4260506724901953, 0.403068509740807, 1.5399031646849135, 1.1358776542649187, 0.943409637522489, 1.0220815769692568, -0.4075675082788935, -0.221734478620247, -1.0381745384465788, -0.33659541943668897, 0.46437623331359523, 0.5263981629588874, -1.0779659445330647, 0.8487733799484248, 0.3801942824150967, 1.0493828427186929, 0.537481581591706, -0.638783903417801, 0.8624101979710188, 0.8661784787603835, 0.5406591738992139, 0.07836832228849963, 1.210043223621514, -0.6284349978541319, 0.27844210382711165, 0.08482767170887744, -0.9536224730769614, 0.8726575968377926, 0.27033653306032934, 0.06792519287683228, 0.47992639660060704, 0.4535651543137397, 0.712897109047228, 1.3059709926015006, 1.1065939520356627, 1.3288403768412302, -0.7892860585421054, -0.25036189704775924, -0.2049957773526603, 0.6515447393920673, -1.2699515520014684, -0.3927540465483421, 0.9839283023093321, 1.3326402125083878, -0.11717768784991484, -0.9325084328551946, -0.7376218715312238, 1.431662095718836, 1.1405261231365105, -0.49700596988494616, 0.6324462929104231},
    {0.3453869567424947, 0.22611188964020149, -0.4073758893215651, 0.26942407023257026, 1.1981756194713589, -1.2091935034994503, -0.23315773133932705, -0.8155216637997826, -0.27801122280032986, 0.02159580672746414, 0.8284663490843431, -0.14712935373002914, -0.037884216264585976, 1.7677845579232494, -0.5694868732723617, -0.3575060565694717, 0.12474019208226408, -0.3460230486057666, -0.5187489237108651, -0.2697877303342395, -0.5435028980830031, -0.6206834546485802, -0.047480966451529, -0.16801913113392097, 0.3637126705691695, 0.15076580707303408, 0.07635240566225568, -0.2158562291627944, 0.8873439953277688, 0.997804850581329, 0.4694102961384211, -0.2355322858167551, -0.16083824868942143, 0.6312200553668443, -0.9812358745634865, 1.2987465166902088, 0.46186725854227545, 1.1665532707749426, 0.25537269069470886, -1.0270273831162489, 1.0790724800413005, -0.8869589405191517, -0.7958890997223513, 0.7967257351421023, 0.3192375826409198, 1.2930691615961243, 1.3522228306005373, 1.0713020019454418, -0.5517225309268934, 0.5475090601814293, 1.0170763414871182, 0.49433424653511154, -0.3989752735810683, -0.549846053387694, 0.15922157594055644, 1.0287456185307375, -0.7883159622629805, 0.9541745119721375, 1.1023773924644953, 0.38898090578835354, 0.930392022761255, 0.02028204734419882, 0.8487880441965538, -0.49248255210929914},
    {-0.6672579123329859, 0.5558484300618493, 1.0008615285455913, 1.3433857147050416, 0.6306272163129664, -1.23901831623398, 0.39322888529053424, -0.15919888315784622, -0.5959452095185774, 1.5062182496194902, -0.8160947659523795, 0.9216988525436706, 1.1365016664719458, 1.7037871220651377, 0.8419510058754722, 0.24715319640942857, -0.16428175200423747, -0.37166017425049713, 0.7277352710372573, -0.7649821369630097, 0.3518396670710232, -0.3396181331936998, 1.3592694214820282, 0.8423669195227402, -0.07821333752330815, -0.6370058586849671, 0.8244892575837967, 0.7507142187842263, 0.24398464554487775, 1.4519579024783031, 0.08212938805397599, -0.6619207206775377, 0.49829674651167727, 1.5403584641814407, -0.7046889278154094, -0.4601100603205724, -0.3176168466748709, 1.2748318991816938, 1.2653027864774773, -0.9180210104029295, 0.6866817118618813, -0.5838645488794404, -0.7741353137660082, 0.9010867424753469, -0.7539685411994598, 1.0118068602799464, -0.43969833515423873, 0.4999386191733246, 1.4959116561541366, 0.6476051214670054, 1.5606183269690996, -0.5095831429955284, -0.6790983439682968, -1.0283912026655677, -0.3705372381886374, -0.6609466337005131, 0.9704988292914886, -0.5251820778769435, 1.155046569449644, 1.445772660856764, 0.2767454417289568, -0.07542255448421807, -0.27625037579444406, -0.26711661859422825},
    {-0.9211009057309182, -0.6703085133728927, 0.09429769695974279, 0.3591231081530526, 0.32908205294403714, 0.6977243832402376, 0.22250071619122225, 0.29667903486038005, 0.3353401377320188, -0.3465228765952223, 0.16367802682783214, 0.32719759508503576, 1.4211978581258005, 1.0298397452084376, 0.7807150656633913, 1.0854750687885382, 0.989108119730896, 0.418275490599684, 0.5417882185967298, -0.9117684343972726, 0.3754556742559399, -0.25452059159139606, 0.631140076058188, -0.2697087003481366, -0.19271333990340733, 0.6901248198975009, -0.32077447922497965, -0.806762827875074, 0.1334937402510526, -0.9721304035382252, -0.7300533722799124, -0.5319489921803149, -0.865600209140338, -0.3895610881089075, -0.4378145998736404, 0.7806837617524551, -0.012305636052807533, 1.0939160341611387, 0.42577534679819695, -0.3494762473324238, -0.6537066903833663, -0.5818975636478159, -0.7948705597658935, -1.1001910713181948, 1.2463135729928998, 0.5615148136754253, -0.24061933230487165, -0.4017164990382336, 0.5969539813308002, -0.003825459130146537, 0.8255899349343233, 0.1259788804102469, 0.3657480895960653, -1.145070400644536, -0.31379979974694266, 0.9486302198511093, 0.6404045567387493, -0.8876402529500811, 0.14940701663080413, 0.9086520282313492, 0.3239116047173202, -0.17017294327084856, 1.022278821522891, -0.8358997872482928},
    {0.5781269079771916, 0.7654026486065142, 0.8948765891261274, -0.0733346936443964, 1.0577295102237003, -0.7974348614387511, 1.1638525208568566, 0.865998305007787, 0.7689776126528863, 0.09545389130370192, 0.9755169700730406, 0.07874654212133374, 1.2934060000262173, -0.19480766368476887, 0.5306709538085101, 0.9995868196985808, -0.12961105480116186, 1.2396157547177347, 0.6490518472741578, 0.6565474631985638, 0.18220857647891878, -1.0396009666085178, -0.20295316708348993, 0.05285586168991083, 0.4478685866285071, 0.6690183942037732, -0.7108037357485472, -0.13255618213737339, 0.7745593278428897, -0.9475457338363524, 1.1209997070223157, 0.1253527432796583, 1.0191200027933556, 0.6464602683275426, 0.6180106888215866, -0.07173673364401717, 0.7739013296202527, -0.4617371648046367, -0.10660360219053226, 0.13422275699831268, 0.9247367590507242, -0.08031441674908346, -0.7921393708374985, -0.5582620359370326, 0.5276579511445801, 0.8541629436918452, 0.2985236195282278, 0.5750422062125593, -0.3242292099321316, -0.9174119589975139, -0.5479796808808077, -0.7380340161563688, 1.1079026317274214, -0.3327539922134175, -0.7950012036301244, -0.5235551622562753, -0.2594894123250413, -0.38496222324092244, 0.35902509778271646, -0.9919748042998024, 0.2935195115625012, -0.7090263507616166, -0.7215981414834219, 0.6544237376118612},
    {-0.23280039449829681, -0.7492806849380715, 0.7857264347622765, -0.9125324380591505, -0.9060712820447412, 0.9152524858021794, 0.2999739979295522, 0.1511909341004271, -1.0646165829233438, 1.0516678676916706, 1.3011653937708778, 1.0638998743321046, -0.5946350626398359, 1.1494915526685388, -0.26458079343424207, -0.6217166089932006, 0.345897281856561, -0.27023586664154986, 0.3600237758683096, -0.452679410955546, 0.8000561301058478, 0.5619331702096381, -0.11841394544730685, -0.4519914529676685, 0.15757224721912766, -0.9754919156615897, 0.22059754751850563, 1.18045735593776, -0.19876511707692548, -1.04631821876873, 0.9120994014080029, -0.08109467606282335, -1.0328890269570576, -0.6004300573343535, 0.8267228817859988, 0.707774560415233, 0.27135811238656815, -0.9912532882186614, -0.13613383341673946, 1.1446409079788469, -0.5730500547390958, -0.49275290423423956, 0.5149230926184147, 1.0594238162350196, -0.09627525540349252, 0.9437338557143634, -0.0533215408584528, 0.10838546655675756, -1.0120688290318578, 0.16342134431634928, 0.29992736493289873, -0.41813090182789014, 0.39832095679270824, 0.7423829930129232, 0.08224854202881873, 1.0826219412239395, 0.3738530083778234, -0.48867745921339445, 0.3709485522386562, 0.16795788406071, 0.6506469325396327, 0.7569277855828833, -0.9392739238161081, 0.04077501163000177},
    {-0.4077716808237238, -0.4852958129943547, 0.27216408953570437, 0.2627088037650067, -0.6049803414686472, 1.3947543427352382, 0.1125648238110486, -0.0694758770076332, -0.776323197687205, 0.9503735062138834, -0.41952610172024124, -0.36736530510880516, -1.0138138791024682, -0.4040241349990056, 0.9380228649223837, -0.4456972687358442, 0.9428704319833853, -0.917667862139352, 0.7863165164414454, 1.2762448483441005, 0.2811897804509083, 0.2277787004875359, -0.3536522577885784, 0.18977044504850163, 1.0146869176977147, -0.5013830499245215, -0.6115286225318356, 0.06168088731057077, 0.4736317755222369, -0.3355524937493975, -0.7837315669940095, 1.2497335436969124, 1.0799587141250584, -0.19963152174843035, -0.45844122265700576, -0.4964179641852327, -0.3381630268413869, 0.47804506299106636, -0.8351902030244679, 0.7262644223957629, -0.2040252552480195, 0.1385814008296924, 0.829073922066377, 1.20528837232378, 0.6657917334762804, -0.3646957562704834, -0.6722565601323087, -0.3749308672033308, -0.10423143793185254, 0.39621285446934046, 0.26103449463772194, 0.04546829153727444, 0.5566747379073382, 0.6373255459244932, 1.338062003437896, 0.22739299199222313, 0.7159418144346976, -0.20419805133218705, -0.15886791451158946, -0.920538779988498, 0.8328346899575214, -0.7424433503193698, -0.10012996710647962, -0.6635405208652493},
    {0.70357500307286, 0.9751918459991793, 0.15795700840272264, 0.5298023592235362, -0.3794717932509943, -0.3234198679723077, -0.4586270105554095, -0.4131248878734402, 0.29242639983304414, -0.0025839490935741834, 0.987888775886273, -0.14429299245436275, -1.1860547662350003, 0.009880430020087356, 1.118518414469564, 0.7500340626436631, -0.4760884540005351, -0.9684972582056828, -1.0049376310807112, -0.6998929169352585, 0.8477140936012587, 0.1097632473201775, 0.5871815173315362, -0.7259888326047613, 1.296389905700651, -0.2511540114476553, 0.1882213954496909, 0.666976716603807, -1.182978167020409, 0.6585974056543973, -0.7907079201754534, -0.7137125892508226, -0.03657747509407487, 0.6389168291393176, 0.7090986008061233, -0.67905409828061, -0.2925631371811577, 1.1535589160368003, 0.04576639422996964, -0.5411308536252595, -0.4663285218558741, 0.10837078751294262, 0.8814657353963815, -0.9975024575242659, -0.35831845167565296, -0.1317869003140272, 0.4690328436146112, 1.2216421287998296, 0.1089527295651299, 0.9926012527170999, -0.6208347970186695, 0.5338180737736016, -0.7628808219791854, -0.9041003589477918, -0.8707258498227254, 0.9533821629899332, -0.2717467388965175, -1.3534725871605346, 0.8977259851810996, -0.7727278287696944, 0.8053767949824728, 0.6113577013546079, -0.3010244768194996, 0.9376194629369676},
    {1.2772656950461199, 0.22286663622809258, -0.11111907170919706, -0.4277374864169099, -0.5513693913984778, 0.366090276907674, 1.1423447982638448, -0.8713226857533797, -1.089051004934501, -0.3974797284885388, -0.7738437093825952, -0.29783487322745367, -0.9002905059750399, -0.9809002180750036, 0.335273325148912, -0.2557674181520364, 1.133190402066751, 0.006318621498473522, -0.8278218989818856, 1.526369580294194, 1.0966266077260756, -0.8583042738889661, -0.29180630088120074, -0.8473014387021799, -0.11948558306545531, 0.6258300074699895, -0.6865856897284573, 0.04498134680660337, 0.42447454480726216, 0.2173201789896421, 0.44009981021544825, 1.0645634677738958, 1.012114195303248, -0.7120717333842252, 0.2923642421332113, 0.44592308058821206, 0.7323394008398533, -0.9617151231302072, 1.1865223831853366, -0.2306741347241937, 0.8647239719505617, 0.9269595183031133, 1.1115746529684816, -0.8175516052334928, -0.9653462769965889, 0.3960033494462732, -0.5945001719063407, 0.5958206305940765, -0.40702613666376375, 0.8432831399019635, 1.0289956912105038, -1.3700888063256371, 0.7472799206221385, -0.07402720858501921, -0.534470837853367, 0.035857220266253854, 0.05819380906147026, -0.7421280485311352, 0.2954134767782197, -1.1641981318266856, 0.13065972726350966, 1.119330436349966, 0.5295265791583436, 0.6382834750930323},
    {1.1093252029376492, 1.2064612559896788, -0.6103793861994169, 0.7396397928934578, -1.0827384071619481, -0.6268796936903164, 1.086283920112629, 1.3942993662934127, 0.06490194699024326, 0.4588575587134876, 0.3123726168424257, -0.8125399324265775, 0.6255836389415832, 0.30262353083572346, 1.1618962476084977, 0.4312186148822043, 1.1901705785553711, -0.7718127223554433, 0.6451859543391038, 0.3451092182066147, 1.1369173592588342, -0.45223513068188226, 0.23014314297689187, 0.2635890207306541, 1.326059391704215, 0.9080219781196528, -0.2677748783717393, 1.4129667566340436, 0.1639476605992149, 0.6642689344806821, -0.1404627719668937, -0.05751525500134999, 0.45520931904688244, 1.15511441062024, -0.34535919864825204, -0.5556083026304844, 0.0931826340399785, 0.8936363137725067, -0.5212390763025082, 0.8025783809807974, -0.07299196356421483, -0.5840680985753782, -0.29825948638535194, 0.8228036325765629, -0.8655228662713095, 1.2803116730305852, -0.8339573368933567, -0.10007671710955204, -0.4834190103380854, 0.41004823213722713, -0.34909837287666196, 0.5916685291132687, -1.2574242079583444, 1.0992000625561935, 0.4237074291418239, 0.6564531019388667, -0.3763680410433235, -0.3984458248207775, 0.7378808948522845, -0.5602682127080351, 0.11450886761564373, -0.45495843281708, -0.9359141265687347, -0.31750625816743316},
    {-0.26086542628306014, -0.9055801331749446, -1.3010856153968031, -0.0964350366451194, 0.05883746101735842, -0.7475679943974839, 0.2945934043451253, 0.47714828774281876, 1.206293766278411, 0.23556523351462458, -0.9838871709102142, -1.2845037328058482, -1.2329799021958048, -0.8539177319916151, -0.21383539871395, 0.5131103205418003, 0.9589515881383553, 0.1999109994292556, -0.4136507913804913, -0.7344926886741836, -0.20608697477152393, 0.3708326626506648, -0.23442349470145502, -0.4555735952542376, 0.07141883428511009, 0.4189422580909165, -0.13648255119250124, -0.5841821345137069, -0.7433666772536826, 0.8702708354018803, -1.1032391807049633, 1.2002167459866695, -0.04749220754430558, 0.2991523613218187, 1.0694981273789308, -1.1169447171607536, 0.06855804432685841, 0.9713473604771587, 0.9746320716011684, -0.9785297530705739, -0.8194801239512884, -1.0639004028080177, -1.0956085518290968, 0.9530419388311167, -0.13409265648024757, 0.7675473108890001, 0.6375104844006303, 0.35618860539425745, 0.06869210397656639, 0.38207430962697747, 0.484280320709396, 1.5202180501310245, -1.1170192576130944, 0.5240310100688872, -0.3796304154795048, -0.7089731991732691, 0.222966238048685, -0.058195022127360156, 1.2995845857466826, 1.2049416311552523, -0.31908677563879595, 0.905946210162293, -0.0373285883043429, 0.41785123182642725},
    {0.7609017019430122, -0.22611866151143512, -0.49840527650858546, 0.5097156928343841, -1.1077944796209303, 1.1449957865215323, 1.1109109901409382, -0.7713076743543815, -1.153072065856157, -0.7190669675292427, -0.598603799435074, -1.2120037788539026, 0.5005751603360157, -1.097910205561781, -0.9058519428720996, -0.7665652683068652, 0.101042740249685, 0.48131745663762476, 0.4780125205945038, 0.16228533537010464, -0.4310826565717375, 0.22471312194254256, -0.35140728096418833, -0.36614840482705385, 1.1771517802489195, 1.3197971720158692, 0.24064343390607482, -1.4231212904036694, 0.18239461105053498, -1.2216525432137704, 1.0680210051009673, 0.9578676624790288, 1.2476298941226953, -0.6308027776139838, 0.8040439179176666, -0.6778063410597732, -0.1459058460540874, -0.19404083465702193, -0.5554654300742666, 0.7965216868822959, 1.1762511651830672, -0.3244817364398385, 0.9713311926994335, 0.24870667207427402, 0.7539660360139094, 1.440915466963205, 0.44774033343967756, -0.7444340060103886, 0.4044695218693854, 0.08555178332648955, -0.5723486726898127, -0.4126041052097015, -0.4368643981738228, 1.231709247335017, -0.6336387492207773, -0.9540194309443534, 0.08001554345306688, 1.3157177515842597, -0.0836405944107832, 0.5664684700095346, -1.299882118603349, 0.6591666560240159, -0.06434563641107545, 0.7362784969550977},
    {-0.5211404641407797, 0.3496665683126285, -0.023130195382568997, 0.9603879509975, 0.19036275127636013, -0.12766726366960654, -0.7835249162205827, 0.4610425822200707, 0.03071669291051933, -0.009201335079196299, 0.16873093575457382, 0.7589972751846904, -0.21055204231386287, 0.7632992724724271, -1.1262745853111102, 1.1974478340882493, 0.7167005658658044, 0.1772059433106673, -0.6090266717749616, -0.39710199524143364, 0.7043958744186137, -1.0448897273589433, 1.5145386714582274, 0.6290878964404446, 1.5563289875677657, 1.1279573456140806, -0.6634431094262405, -0.38743097754455896, 0.19915012012232194, 0.7688338462856933, -0.36280458067673255, 1.4561651765253985, -0.2915700109168728, -0.11594299104677439, -0.09889991185241039, 0.16625360596561214, 0.400158604699661, 1.4088213076190177, -0.6335709150401341, -0.2581971779064983, 1.1648144933500506, -0.973834429505238, -0.4188421502066622, 0.9597556611780831, -0.9483104038187814, -0.03913073346689491, 0.25582559597723264, -0.7945332287477375, -0.4965862258662036, 0.3152337444671148, 0.6921573923820312, 1.1202175308177322, 0.6478505150634845, 0.6328086309845651, -0.13085897300887886, -1.050942863777127, 0.4568860716416148, 0.24878431376266416, -0.15565274636892468, 0.4303984781599448, -0.02809368189464487, 0.6844433133900363, 0.8173258585962819, -0.8011831903856989},
    {-0.9842194529324232, 0.8320821808435803, -1.0481967748720102, -0.3181851691970331, -0.006681290793841235, -0.17190431415414953, -0.5927614121996757, 0.9987239599021125, 0.41044334602711213, 1.1169420313282532, -0.8443091033280992, -1.335353053729206, -0.12611568526930436, 0.48214607295020423, -0.8125270644017402, 0.21114664690091406, 0.9849802584718272, 0.8547864795274338, 0.6958609294669929, 0.529236398315249, 0.2634648847928204, 0.9449845712401003, 0.9151296234963081, -1.0174840819080062, 1.243565667676693, 1.0940477622447988, 0.5790453729156083, 0.15794157671216824, -0.8165815086655208, 0.5253930905082503, 0.6923840127097147, 1.1428247689788662, 1.027535819243093, 0.7909501543040306, 0.7901881769109236, -0.138491409108148, 0.5620816047226492, 1.4284482575858413, 0.7925462123993274, 1.0470773072527217, 1.0537368874422077, -0.2588862813114989, 0.3926442273585859, -0.8283512693784959, 0.032270253760741864, 0.04316148638297285, -1.0754897141352509, -0.6207699575933868, -0.5211790678557461, 1.1746737348340845, 1.0476588493935772, 1.286022522923436, -0.9929896210195743, 0.7206342087948221, 0.11416171799635173, 1.0584937746192555, -0.0617489467571804, 0.596507926063777, 0.9086626395671161, 0.049906429943278686, 0.010923845631107917, -0.09117630548620083, 0.033691756902228184, 1.0424448310900212},
    {-1.1059560944771196, -0.5313594194630502, -0.5696636603985689, 0.7913191177665669, -0.6163936924032347, -0.524644017601267, -0.40307444422210026, 1.0462200783230733, 1.0987258058402596, 0.8373246684670005, 0.5692362991225953, -0.8698431320855636, -0.4988620133042938, 0.0938339328218809, -0.8022675148993246, 0.17993833721901795, 0.527310261359074, -0.4608846905827061, 0.847023145580989, -0.8925528501056352, -1.1449913463460468, -1.1684549005830314, 0.03435318981709372, 0.8520631532076098, 0.3204500766456214, 0.08196276418005843, 0.3335970959993188, 0.9363399592332183, -0.9499639968030653, 1.232635147008219, 0.7972000222011372, 0.5809280380603471, -0.6846825911031982, 0.6855590757899171, -0.7177639506177589, -0.08895819378261419, 0.784402077535903, 1.2070129690793008, 0.11571503403002062, -0.5168251542066383, 1.2323471129785364, -0.9572216650940027, 0.6042620472297313, -0.5834650936235338, 1.0903554635588777, -0.04915856070875939, -1.022591422238158, 0.613632619472514, -0.01029175090200601, -0.27568144049380994, -0.33543622055761013, -0.8192133454668424, -0.25601773060054445, -0.001642657044066361, -0.3051364199126225, 0.5910758956002374, -0.4198450159870428, -0.6424171217406547, 0.028379341599550016, 0.3808523209596074, 0.9344248998230047, 0.0552639990741292, 0.6186764359220119, 0.4756929847480282},
    {-0.7332069016474816, 1.1308108832140706, -0.6661934363008571, 0.0498232322350941, 0.4902583771178876, -0.5803656796123271, 0.23456448257271398, 0.4023237619580444, 0.06628774818249761, 0.2049838306582222, 0.6859764548015616, -1.3224046930385893, 0.4016884410159652, 0.2826404184796944, 0.07454553737769753, 0.9889602101425274, -0.3943478008569843, -0.25314792173678, 0.39158580480199706, 0.3276220150859678, -0.018507576905084533, -0.08778215463293589, -0.2203895917694175, -0.8002895128336562, 0.7720606654285478, -0.6706737517500533, -0.15860977446669972, 0.5732181188948909, -1.036985207134864, -0.36671883501821667, -0.8603894301312076, -0.18967370368483671, -1.000670267731551, -1.2702089429227061, 0.7637688234380866, -0.4497981814942563, 1.026980521948272, 0.8782305953646982, 0.718826151640244, 0.7956006164308973, 0.8394212802139474, -0.09735179664790343, 1.0367998781016732, -0.34183925102255647, 0.08875995336837271, 0.042781021815760295, -1.0431626275663703, 0.7077983276559712, -0.03998284172631733, -0.36442027311042907, -0.66051207712706, 1.249600143146128, -1.3558476544590594, 0.0742963697968062, -0.10466688064427161, 0.5966245014585811, -0.5450323315685779, 1.1469677961257747, -0.4665824439824685, -0.5988225874084809, -1.0258358739694096, -0.4664644859096508, 0.7999650934034394, 1.1836985357268737},
    {0.6436857846488574, 1.1030900392362175, -0.6722335601283861, 0.288187163656006, -0.060030181528924344, -1.2180842768706708, -0.86774756601949, -1.1108112167872841, 1.293238250802665, 0.0127078695655911, -0.5517120553476594, -0.8896190212779457, -0.8104306418085939, -0.49149343822000946, 0.5794396550124624, -0.44886520063639757, 0.1679499371254292, -0.6279142904541762, -1.4163258572296589, -0.21325833855508766, 1.0380746140714672, -0.42119656660833765, -0.5411357251247068, 0.4108092684574809, -0.43860354111602706, -0.5432543553054064, 0.5839705251320925, 0.8672221215169007, 0.1911465553825442, 1.072349350954395, -1.0526461436702397, -1.0330588123155278, -0.9009694802398766, 0.47604991349475595, 0.8192174076558412, -0.9652343563210917, 0.5982460924214615, 0.42809593618998704, -0.6095287180200955, -1.014923487743358, -0.2210906333502311, 0.7751845984536976, 0.9116755526449393, 0.5258022584535568, -1.0048344530141704, -0.7280918515445285, -1.0138162032991862, -1.0695964882898323, -0.6408048944116852, -1.3168488602530843, -0.8623402064753135, 0.3567295397467214, -1.346464036464338, 0.29163057129302206, -0.944874812857911, 0.43522618790049966, -0.13726363364101896, -1.1136262673276314, 0.8076391663492241, 0.7230214561351375, 0.34038476798407274, -0.11872205732314925, 0.9080973336827247, 0.13974714153925713},
    {-0.45863009608527794, 0.9764758354724544, -0.35450609113081566, -0.5713537028673167, 0.7158322782709002, 0.07955348196468774, -0.49752468148317797, 0.7211128951246364, 0.6936509292942465, -0.5746795403344802, 0.23962597452874748, 0.2202447669610475, -0.3970323961796442, -1.2197799307939474, -0.3269036020391349, 0.4336860596506891, -0.42547470743232974, -0.6373846790088258, 0.5766145573170371, 0.4450964583390226, 0.8253460782419151, -0.440506076412448, -0.17729152858812502, 0.20045844420737663, -0.24438005316029718, -0.8999338776577802, 0.16120864082167713, 1.3118396768471083, -0.5816583966432111, 0.47288313467370874, -0.5026898747046546, 0.7893557950419854, 0.16908454232899572, -0.885402102692931, 0.4928416307515167, -1.4136780797096737, 0.32959780775784403, 1.2064932424196215, 0.9420679039397908, -0.023140906792937333, -0.08287730560344543, 0.4209542825577306, 0.9552791671342219, -0.07286339683863771, -0.7459255952667524, 0.517464300938649, 0.82270476710939, -0.6207478896296128, -0.4191346474754712, -0.18708744435994684, 0.7395917156189922, 1.402343493432592, -0.7442996688421932, -0.2301275693195712, 1.419557231657413, -0.4453917604597512, 0.8145393811486115, -1.2304681350119482, 0.7104204318517866, 0.8345265746455713, -0.009047735797217805, 0.3258475790814102, 0.548293090688471, -0.3961042817140968},
    {0.5111078338558884, 0.5522643790522674, -0.8302338002447186, 1.2414482660708208, -0.35212194650419265, -0.9944818610671264, 0.9150958405136013, 0.46210012768673564, -0.18071127401450587, 0.2727971549671038, -0.06390266980387452, 0.30895434516991516, -0.25199283664446437, -0.7434641535452055, 0.8162042486294652, -0.373642810947829, -0.7009853486793763, -0.8997325105722228, -0.608283444608889, 0.5459519041540407, 0.4254822580044582, -0.9847775510021717, 0.5202056479101032, -1.2350695882808722, -0.5619036189684516, -0.752556173901126, -0.134184599683483, 1.1039497758592365, -0.6546474595046432, -0.4746569052209206, -0.4229607229741002, 0.4326981940630239, -1.1814981482247582, 0.2201619927831047, -0.7450463029453517, 0.4652832133342274, 1.2928972946522659, -0.4226630542037498, 1.1653955863672678, -1.1180611341995237, 0.4258649529824333, -0.3007172372091357, 0.30065660477679756, 0.7784185367669093, -0.9122273785368714, -1.0035753163774266, -0.7210025179093201, -0.3478920841869969, -0.8043057756875949, 0.6192011358128602, -0.06508566845475952, -0.6157892223943814, -1.2283421922738542, 0.1354725430096262, 1.320469299662891, -0.9991499027423443, 0.3387384186365726, -0.7567101190558057, 0.029382957620993067, -0.8371180396083663, -0.017852954835695607, -0.10882976109447853, 0.7944879376307069, 0.9981574860630729},
    {0.8935548136784811, 0.9931548712562775, 0.960817131400579, 1.1516902013930452, -0.2985789821394047, 0.8297138711642067, 0.15946523303512747, 0.5794195871319675, -0.257968750693894, -1.339778796184147, 1.1754663989991534, 1.1484574958791642, -0.13572242773301882, -0.6158025164712231, 1.1012142289714217, 0.3395288779309093, -1.0379541330074504, 0.8207811796380136, 0.4472857998892001, -0.9383257346216226, 0.5287413356079894, 0.38329587184293146, -0.6224580492158507, -1.0286618931686893, -1.1208924631154824, 0.4254340291913629, 0.5147558619486775, 0.003720643371250958, 0.2623473674368998, 0.5183588623518837, -0.32752707477498777, -0.9679257335372097, -0.6632529145363432, -0.7541718823995996, -0.02570933270380331, -1.0227353584689924, -0.8338452331544798, -0.3620603747404017, 0.8565562678446926, -0.25925916280101985, 0.4536662870545737, 1.0757305131069232, 1.26067045549061, -0.5829775712577691, 0.5079491949854525, 0.07902368314413533, -0.8466896339086434, 0.27620871328566554, -0.1654876898336912, -0.1466493503945991, 0.9090606705893823, -0.3122999803639562, 0.29887395899704966, -0.6557221738927874, 1.3397472393341576, 0.306564958206688, 0.46575543019369603, 0.6549320622402864, 0.31790078479063927, -0.7978201867249588, -0.23393816247215776, 0.7753305660176008, -0.7206671223659229, 0.12183230140893561},
    {-0.46229919675250963, 0.5966313167824497, 0.011033645675361773, -0.033227326622200966, 0.963907474821125, -0.4088724320131026, 0.4306061012799001, 0.11989373154621531, 0.5119092072109445, -1.1369439012390776, 0.993504399540867, -0.8362359262519372, -0.1313953282521233, 0.9066542342060021, 1.185713763422102, 1.0196682911196562, 1.0582537668311662, -0.11759491173453997, -0.2409811281993362, -0.11242063469679356, -0.6651562234267855, -0.6956941717931409, 0.3273389479410912, -0.024377987202116928, 0.7968939073076947, 0.9428878171930362, 0.9477136923367582, 1.1996305042122304, -0.01013534391824451, 0.8939858995599093, -1.1180339788764957, -0.4338888994191936, -0.5902171418302307, -1.0252417339913917, -0.13027522222926546, -0.9193314505953845, -0.08957134301462155, 1.0755803714214094, -0.2395100910092174, -0.7308244525085706, 0.002070878639749157, -0.6806163543019097, -0.620289592419929, -0.5752481897675031, -0.03749218657739575, 0.07596260460971052, -0.8176743959452627, 0.9925752967305698, -0.6724638912053679, -0.6563401308158149, 0.42116731863462575, 0.2239319816154407, 0.3934353357602722, -0.7815269019464289, 1.5324135237296401, 0.6427914263395866, -0.5779487340438746, -0.752322966360298, 0.006243757389451447, -0.015213156993001267, 1.3734248025713665, 0.35990897611696454, -0.7500389229288686, -0.8137890506601662},
    {-0.7418357403031778, -0.5838129986015206, -0.7090956467651568, -0.6774455400689184, 1.0573525836887432, -0.5902882007457023, 0.7141730784743515, 1.164553035883737, -0.2750612415210052, -0.7053043274219947, 0.04083824901336622, 0.0003652643221349331, 0.8419790909473084, 0.1407860450157175, 0.4181887352028115, -0.08069211191691947, -0.7053363704017525, 0.4824361535243299, 0.8912155243432176, -0.9471574063016941, -0.5011972891491925, 0.9685657038967087, -0.44480504669381965, -0.6320950033870183, -0.07096631953142508, -0.7220415601925934, 0.8037816682258663, 0.25786858073597574, 0.29553144170370516, 0.7426986026080852, 0.787679374014077, -0.06757828093979674, 0.18606543967949002, -1.2190643862785324, -1.126094126953309, -0.07998198259682922, 0.02101040026689421, 1.064351153789459, 0.4621763351167689, -0.6402112204015316, -1.235951659125035, -0.6479434310413048, 1.3217012272968762, 0.5571534837381487, 0.45253338602484616, -1.2281059477058338, -0.3035191290413109, 0.44221708772778195, 0.5029456031300014, 0.28589316034160395, 0.9608401499469246, -0.8439596213197847, -0.7836081212991768, 0.548709666812725, 1.2116428251724103, -0.8313218412908833, -0.30734649134886544, 0.09481305635997372, 0.7031480585413928, -1.0279730601615427, 0.8678449238952098, -0.7679838902477911, -0.5238421850159838, -0.6524915209666813},
    {-0.08238198943003491, 0.5142065772192602, 0.44650212455250726, 1.014415719029037, 0.23836247328873497, 1.1939906620986867, 0.40886054177442555, 0.2431383649173486, 1.1039002059283822, -1.3205284083224496, 0.7936837319532103, 0.9433531067008392, 0.2983892138522799, -0.9315758685297759, -0.8314583350423425, -0.7596451532338905, 0.229500619261056, -0.7798615370580065, 0.29840296440724, -1.2728744853888032, -0.16752502523143173, -0.31847852464961685, 0.7515893077154144, -1.4066881275358059, -0.36365723991628623, 0.2126403183523092, 0.8496554412537688, 0.8857901900324497, 0.7104390072203015, 0.41875197951941284, -1.3284128725581892, 0.10392813431152947, -0.955308387195017, -0.7742996017596266, -0.0022645113267550127, -0.6398550207172643, -1.0515055725592877, 1.1100287331796, 0.053972120413614884, 1.1326725865115166, -1.6019503398611927, 0.24073518101359356, 0.9561837553501863, 0.34357307215474403, 0.7448935878167946, -1.4443584170784243, -1.2171081226219584, -0.6376589333705356, 0.5181235748428275, -1.4334492814430746, 0.042372896120874276, 0.6650921485620902, -1.468900040020182, 0.2829637028502216, 1.3054823631082504, -0.7946701912004093, 0.7873326122368436, -0.8571259341813685, -0.31170510384627564, -0.5684731461236845, -0.476782051740453, 0.6254045778739754, 1.0890340747564704, 0.5081562547867791},
    {-0.44795518549823987, 0.6626297771347028, -0.04447723798919014, -0.0913649374796038, -0.024476081285168698, -0.17266670670950096, -0.42305853553649536, -0.8291162825911184, 0.6718137975937424, -0.8934888780394871, 0.6201934230789304, -0.47691307380527104, 1.2831434890744429, -0.23676549402492889, -0.05973101863789507, -0.24795871205499184, 0.5993769909795135, 1.0824748698260942, 0.1115517910178115, 0.7417858983189048, -0.9166177228066698, 0.07829179491832577, -0.5389389742556626, -0.46615004627891976, -0.21257904035878467, -0.9363613482708099, 0.40995411965807804, 1.2409253650835368, -0.6803327962809177, -0.8824475263114084, 0.3527887126176936, 0.21803787496867197, 0.6367412322461625, -0.38152990232022693, 0.5916718202795404, -0.10615571677325386, -0.8995799525966499, -0.6205247182059956, -0.2793054435944869, 0.9835560482449853, -0.7433056262534978, 0.19391375599138894, 1.0480277439285781, 0.6463954691574678, 0.6356412848268672, 0.5944063430428554, -0.4893266856909379, -0.89972667139885, 0.9016916870692757, -0.7778076911018346, 1.1437013610874949, -1.1354233453178586, -1.2201771557359218, -1.1325520065291765, 0.8864832385563991, -0.4090870437806528, 0.19756583711664083, -0.30441140837813446, -0.29383047970303133, -0.8745645467976615, -0.5707799071299817, -0.023500401544539317, 0.7154604513240397, -0.4594196266565822},
    {-1.3326082871294922, 0.4824766463240403, 1.2357446572501263, -0.02645715923084188, -0.7850239515322144, 0.729274715336182, 0.6952843076381788, -0.9341333721990694, 1.4513836830589655, -0.24771674500969607, -0.8113334150133431, -0.5159468669495386, -1.069318938394925, 0.9378021473849267, 0.3985807746865204, 0.5553801384729952, 0.6247533582661127, -0.3584496005269872, 0.3845188567284536, -0.431572525552256, -0.17531544236234106, -0.30980000991766526, 0.838600942030275, -0.4770748973803012, -0.6525694891180538, -0.487362308582547, 0.8678881004611199, 1.1957565823489833, -0.9664560650503851, -0.03341188754251782, -1.3205928075402567, -0.7191334250681679, 0.2880185282621023, 0.6409629192270072, 0.3160978969027619, -0.16510869160634667, -1.1133594362585506, 1.4101252616078994, 0.537042824994852, 0.005425587947883146, -0.6861444829624646, 0.5770874529863832, -0.3507598646965013, 1.374214991991505, -0.5805198194982236, -1.0907219065710032, -0.8065179530128262, -0.44747645532219293, -0.15871298167548423, -0.45099644100463565, 0.8138073334410235, -0.45421501700723954, -0.7666286293295732, 0.2892960725302764, -0.3297476627903381, -0.6383669264624908, -1.0085351931597937, -0.9128393074832517, -0.011449926978585568, -0.689179772981509, 0.8278779201546488, 0.4496900074584258, 1.0144079838930116, -0.24828857939002583},
    {0.09391954583154488, 0.2479661151996825, 0.7052725992129499, 1.1798833796194625, 0.31057337227883564, -0.821275400520156, 1.0136094636439745, 0.4517838274031776, -0.19905953246570882, 0.9030494032121752, 0.3135065925433648, 0.4656242596476218, -1.2873225551874725, -0.4588287513532754, 0.5741323515900913, 1.4666875446036867, -0.9463731894340437, 0.5188636096394698, -0.35150791294608735, -0.4657685563803629, 0.15167717059318497, 0.5301929643352377, -1.0471760368082643, 0.2602041855037367, 1.1837698459643688, 0.458445248693401, 0.21198494438278925, 0.37019927319469564, -0.34078472913966357, -1.115941722527114, -0.45814747023691993, 0.9118265546289818, -0.607645905487899, -0.7772425576495071, -0.09411695902006566, -1.2904860882257596, -0.483915745076163, -0.008744475230689712, 0.364022037460668, 1.0295952258011054, -1.043156928472844, -1.0814174591399648, -0.4344501859176067, 0.42668436169269386, -0.23680664854618763, -0.6625901647681103, 0.028908197617047666, 0.48824256037941677, 0.7104998585519747, -0.2558743873261731, 0.6687977739995489, 1.1023103207745486, -0.5510452408031767, -0.37167755492519755, 1.2707212448945582, 0.39159316266792205, -0.13584277078025525, -1.0312489787179346, 0.9077353550144018, -0.8590071064677945, 0.028457455609194486, -0.9519684484573844, 0.627008954092984, -0.5826332962730081},
    {-1.7346509267562946, -1.6214432847443219, 0.6082710516515615, 0.05865479681229561, -0.4255705462244016, 0.5802551647439576, 0.7304644584905963, 0.326426445665423, 0.432607499864567, -0.8187442893913472, -0.25453220891999057, -1.8994308674526856, -0.348412944904717, -0.751601163896607, -0.16349087248463212, -1.1656438151676478, -1.4668192333190786, -0.9626843503326369, -1.025861553450472, -0.007721542140919297, 0.1450167141656254, 0.2240412899658916, 0.23326339008834157, -0.7725733267909981, -0.4227830203634034, -0.8997716777356465, -0.31193795473556796, -0.6087337640309025, 0.5127289960781111, 0.1050876027785604, -0.3282963023205331, -0.9985981545025755, -0.5462241084843543, -1.3865720021306205, -1.2392164027741488, -1.074232068681903, 0.18634389193323705, -0.11384966432994433, -0.24914334958845386, -0.8123578857419418, -1.5000771634480587, -0.19894777958008772, 0.5655369115474882, -0.8848609515457636, -0.6971378850025222, -1.2147003554461333, 0.1540855973639755, -0.11663166617668365, -1.5890483418755623, -1.7813991887134817, -0.03500994445400606, -1.0034346299481622, -1.5926203244293273, -0.15126553759840977, 1.0050892399962748, -0.924936721636083, -1.3758128658580149, 0.8446067715326503, 0.6102194787599372, 0.18661973439076807, 0.5074308863111978, -0.901516418158151, 0.5386984777431681, 0.4787078525112939},
    {-1.4666452845298008, -0.7270007410485815, 0.8177151495291548, -1.4760425102547245, 0.04915196458832581, -0.17082046785470203, -0.3354704366817449, -0.7484516868598355, 0.5262169097129851, 0.29189190928273895, -1.4881707936399708, -0.7550001843094585, 0.21880890105333917, -1.4546103939693162, 0.3766258549797679, 0.07167382512014388, 0.6898583080634574, -0.7534786766342643, -0.43628773495301953, -1.3236190666169492, -1.0564961310824406, 0.0920982733799989, -0.6244690487675881, -1.2183569774528513, 0.6417398590026514, 0.6749866833538172, -1.0058353249620289, 0.21555830070938264, -0.8797428686662851, -0.8435369940725351, -1.3176742897688898, -0.7774998130764955, 0.3429458432760802, -0.7390375829591491, -0.19363852235442755, -1.7970706792017093, -0.37941190355783455, -0.40657275559987505, -0.1996813484543529, 0.16236143565847594, -0.2290830993075331, 0.2542437141414196, -0.3025269057702481, -0.12745917329998058, -0.6347379847544281, -1.4680010303063278, -0.3824519743254505, 0.9912855470042321, -1.5871994753130594, 0.026262344096887574, -1.1260556929142347, 1.015045909866076, -0.12648702197904327, 0.9340415002065284, 0.11743570607676267, -0.18377696653707515, 0.4383505885411559, -0.885073646247462, 1.0590632747728947, -0.8930210955790175, -0.7953706114123364, -1.2838240858119596, 0.6458050529361553, 0.024943066210355067},
    {-1.7090737536774705, -1.2763855701948992, 1.009120055035703, -1.3068001199677355, 0.3113774937818461, 0.605212212649749, 0.2681279446934445, -1.1082261815804528, 0.6759490515143995, -0.9820117318871207, 0.7552750549758116, -1.3127043412956498, -0.3331833987080433, 0.3908018743968627, 0.8485712385618848, 0.23799489746233043, -1.1113380462871234, 0.04923498812549292, -0.4336485012193953, 0.14633136827638552, 0.4734177606836478, -0.09702041569405416, -0.04387086744848172, -0.4906424259752432, -1.3430972406185935, 0.34210948728529705, -0.40596643763011614, -0.710911369178761, 0.00661228260702037, 0.6827885663471447, -0.9249929873963615, -0.533804899940824, 0.4204101210399049, -0.9002089239962291, -0.9619315469971838, -0.9753656016233913, -0.6152355569902642, 0.7899486552521601, -0.5014180090599725, -0.3548545352053719, -0.5273703692063456, -0.6123889015585977, 0.7606913249396056, -0.28876907046926353, -0.3347280532342, 0.14614291785196276, -0.8406167957359801, -0.49326632170452817, -0.4280098710979067, 0.6480106840564293, 0.7706610738850316, -0.492010612101756, -1.0857582989543997, -0.5609664116936228, -0.050134701842435424, -1.155330242113667, -0.6455777229271312, 1.1904200407234131, 0.7416407218132317, -0.2752305566992904, -1.4059973209608605, 0.9811011829169289, -0.7805442691507478, -0.3877299449792184},
    {-1.398336813486129, -0.5235337641746416, -0.31263005294688606, -1.0337577894580712, 0.7445502011161712, 0.7214332417275003, -0.3396735262697585, -0.4039059395936134, 0.47415534633690326, -0.6541135736095668, 0.07254294770083862, -0.3689096489627609, -1.2830644063683612, -0.7040171522600097, 0.6911042367945399, 0.8402739242713999, -1.202199977024085, -1.2527948467752306, -1.427252309433027, 0.03641659159229888, -0.2152817942211106, 0.5393798806397432, 0.4345372520043765, -1.134117543802632, -0.44220227937488354, 0.7811121950359131, -0.22786552050472028, 0.9925825746034694, -0.019313575365870184, 0.32557730534796997, -0.990064416966376, 0.5395628273669734, 0.050152560223709654, -1.1981634844006663, -0.3459308927095364, -0.7291225135510936, -0.1943214706532512, -0.3205588286139148, -0.6132131022125499, 0.322295469387916, -0.8583722028924765, 0.8254880782973251, 0.8451474737882162, -0.7746645331184503, -0.226540404649587, 0.14241488810626146, -0.34689870274449497, -0.06135424580636597, -0.9853026060856287, -0.9364666260096097, -0.11725079344451549, 0.7433153789117755, -0.409217324741936, 0.6057452642528052, 0.5454003840030588, -1.236806752431212, -1.3010916179458676, 0.5507179400552134, -1.1629127157421706, 0.1947080571652438, 0.19859744004482058, 1.0107015677346805, 0.36890467196452914, 0.9872594331819883},
    {0.29484268990772955, 1.1607820159765994, 0.5380413943759129, -1.381835487520514, 0.6799211853810271, 0.19553651224824228, -1.1613359786306814, -0.07968827688850963, 0.07576529969547129, -1.1744079291275937, -0.7844736433862364, -0.3495196331946843, 0.8167118446349422, 0.4250250520130075, -0.5164555831577029, -0.6273220530541455, -0.8356028032627609, -0.5932581154412361, -1.571655221411281, -0.7507200495083225, 0.851422785894924, 0.5024389571511169, 0.6555683226666232, 0.9016163937319454, -0.4031750368354289, -1.3796282350355513, -0.46624128795996655, -0.8725172823683506, 0.6955761659793387, 1.1834898503838083, 0.020993122460928805, -0.9752174347340533, -1.1252438072354025, -1.4578581609210812, -0.12456794950219867, -0.9337378488243792, -0.5451537165978994, 0.028336551187759757, 0.739166851445349, 0.8760517743508138, -0.6003052305806125, -0.5465381980071398, 0.008092391757160804, -0.6834951083109047, 0.4497876446214346, -1.3776923286967109, 1.0360298246978625, 0.01809995955369829, -0.7521378860142743, 0.5187086450464633, -0.8636043467970329, -1.117728773464821, 0.5370731266471317, -0.9561524945949506, -0.724631952772766, -0.2344591825769905, -0.05011652199786905, -0.3189647771803289, -0.37965062637750074, -0.34641353561831295, -0.15667659850263602, 0.7325684064195912, 0.8652800002630407, 1.0299500637668138},
    {-0.7765999279230436, 0.053644163484730306, 0.2924773980418595, 0.037583122587863615, 0.030955641604221155, -0.8135059526943189, -1.1929119578399825, -0.38191857109354455, 0.17871121687167812, -1.6296918761716928, -0.1139394648202335, -0.08264830838105383, -0.05372900250932253, 0.4031178095147472, 1.0852673262225, -1.0114971652006455, 0.7188753090992772, -0.0016957790634063899, -1.4810602385007212, 0.23334884021087243, 0.8550845204740567, -0.3991525310181442, 0.5520890348322263, -1.1094769797270643, -0.8844790560704469, 0.7303685259312143, -0.2669160713539253, 0.33757377934188454, -0.20921158424774586, 0.4284905807814142, -0.9559534988290109, -0.8565099279609457, -0.08264656828702881, -1.090455590860255, -0.7309774347840357, 0.6278145015360622, 0.03998443151794516, -0.32739180608051266, -0.9674668515124644, -0.8740969598647661, 0.3633265810464589, 1.0320762491853337, -0.5689607358159702, 0.6877502169227879, 0.3337205623191977, -1.4232886522643586, -1.3650170673168627, 0.6408886728592117, 0.8168135180085729, -0.4824782337560023, -0.5635569406458218, 0.6449299508832405, 0.6344662221419215, 0.6481545799436358, 0.6327841659122924, 0.09512349603489545, 0.41154184097747415, -0.5654225117186822, -0.11692770593415629, 0.9650869109723487, 0.23152519529589355, -1.1453657811783, -0.01823431438503209, -1.0897929085451044},
    {-1.0178871389278632, -0.6517366366748307, -0.2378437498892539, -0.8034477734155909, -0.34387021008434643, 1.014223617625105, -0.3024805384632365, 0.17766024625238075, 0.9104215114551861, -0.6587666298272141, -0.21174876191094208, -0.2145292469349861, -0.9128524133480835, -0.8157204789639947, 0.23052024145576155, 0.9845931008911037, 0.027959163823321767, 0.3382132013959421, -0.14945496706153472, -0.15802771560659443, 1.3152014496502464, -1.0816762683355896, 1.2376590270791854, -0.1134677569099049, 0.04162670984604213, 0.46498818933106445, -0.23316623694381897, 1.0263333814628803, 0.9943425685724444, 1.0684566452224038, 0.26210971030061253, -0.4318347229551542, 0.6661578067715841, 0.9637262805333773, -1.085415974081249, -0.24942328499816455, 0.34919392960240453, 0.37828347507828064, -0.5724418984721021, 0.2271811875929405, 0.8046836242881975, 0.7526156623545384, -0.43571898037180234, -1.1153589175947627, -0.4237853807317446, -0.192363600425518, -0.13155497840561012, 0.8456246364327732, 0.48823929964160634, 0.511793361214795, -0.36926579303606877, -0.6486822009238725, -0.8934862225761864, 0.38706637046169773, 1.1423693605765808, -0.9431057967298129, 0.574146266633476, 1.013689827359205, 0.34614115603854684, -0.07418083043987392, -1.1528103195974362, -0.3703541888324248, -0.46529861741335155, 0.10067818103654821},
    {-0.7960655603200816, 0.35590147064509625, -0.4976207424080513, -0.9183593498724019, 0.9852251805423369, -0.9399624002688903, -0.346968976673408, 0.015311097795805969, 1.2832241848612786, 0.05076474765523392, 0.01389270660896651, -0.8060264254426718, 0.4593180877468182, -0.5447516139531259, 0.5364995372306988, 0.40271148788883915, -0.5162713624845758, 0.0015359021510698396, -0.9521519472048705, -0.38738823826659774, 1.2373931350322334, -0.7888532572158381, 0.6612529304732665, 0.982854533670407, -1.1493198450840465, 0.0513950273882757, 0.8153485100134966, 1.1089343793077955, -1.3672583683269297, 0.9013611215749574, 0.748796900837361, 0.5040299022363649, 0.5907510301434931, 0.23037433153301826, -1.3880693937098287, -1.0386958247037485, 0.6065921906374233, 0.1613190117569064, -0.4993561914596312, 0.5576608800505005, -0.0807968716396432, -1.196778393013703, -1.0368647758188867, 1.1389555546059442, -1.167625212614396, -1.193353255234775, -0.8751583270885116, 0.6772977724406457, 0.8983954205904819, -1.364141156690029, 0.28519030202227036, 0.563497283006091, 0.5407428255128609, 0.514604278831959, -0.14079199397562417, -0.9081805805388797, -0.05856662620041073, -0.435076473825155, 0.07522789908572255, 0.5583102936152721, -0.8319643243470083, -1.134890309082778, 0.7732834199996053, 0.43392376802664195},
    {-0.6348068023234018, -0.1128666605821988, -0.6893582666727593, -0.5701000912385591, -0.32556895438900524, -1.0179730416871289, 0.5732255436739483, -0.8358477169312292, -0.6336672662285733, 0.7178109134199155, -0.8994274943647291, 0.46352141708813593, -0.1507143817085151, 0.6738971642524955, 0.2690142928000738, -0.08537850140748358, 0.9879364974777263, 0.32287898279331656, 0.8491772046279736, 0.30307950176009685, 0.2557944231091974, -1.1056180026885596, 1.0537475375644694, -0.7336660075393262, 0.288691342646171, 0.8584463837686015, -0.5870957693586851, -0.8794350731241092, -0.260825847586426, -0.15340806888883574, 1.019253243763054, 0.35913664679669416, 1.0437726608485103, -0.44295171051266186, -1.0156124994950748, 0.3668198737338441, -0.4940304683008401, -0.5752117420743442, 0.6753119037893847, 0.8274519528908572, 0.388270857438259, 1.1057760201068858, 0.31843875583030845, 0.2613250308257295, 1.2037627192717373, 0.13120117107601556, -0.12367188932322687, -0.9864509719298038, -0.919933024183857, 1.0764907360988396, -0.29800855758080425, -0.7565061187256079, 0.5289787585281812, 1.2187113563209917, 0.6222887787796275, -0.7901896035559076, 0.6575800790332363, 0.7387078771499347, 1.3516553153599584, -0.21831990433081777, 0.20855530830069857, -0.12166861552542109, -0.4783040996764538, 1.0561335347055605},
    {0.7593946876945592, 0.12900036447465127, 1.2352843093779722, -0.18371090983823674, 0.3591661058714867, -1.1661869832715581, 0.5936832765846537, -0.8430199489174333, 0.1882230382309555, -0.5027650021056886, -1.3545330730766407, -0.3295449598414334, 0.06332516577257727, 0.013098871338092118, 0.7700301518728262, 0.4078064949246545, 0.38185030726160796, -1.1955789450797185, -0.024938617127187642, -0.2020705985960584, -0.8146244809126431, -0.3859671103179677, -1.1973675252630447, 0.8600458576570384, 1.046002016327173, -0.6766073879426161, 0.39546035956525394, 0.5530087884009103, 0.08554035785289048, 0.7573120475362435, 0.48854521751121927, -0.9566577367526434, 0.0956503081859103, -1.09413985641952, -1.121208290337074, 0.6583614966859097, -0.33915318486994855, -0.3260124076591701, 0.8348176198388105, 0.6345448152853261, -0.16543214206275933, -0.6510454320508003, -0.4572171529774643, 0.8026721239209162, -0.5136607416541579, 0.23020671293387202, 0.485024591756267, -0.01687938030130316, -0.26448588691830044, 1.0443621677415076, -0.18398943119522743, -0.09781371025923008, 0.6926830203451529, 1.0669167487836915, 1.0247814932536132, -0.11925899273541889, -0.7768713840913035, 0.268325817533471, 0.5561640475139364, -0.9140256621339036, 0.589937008865712, -1.030941496213827, -1.0589078060886212, 0.23564291493374837},
    {0.17200719479359788, 0.08873364183462516, 0.5009731691460972, 0.6076588753530059, -0.379908856541989, 1.0042622962083376, -0.3571897394277166, -0.4958740414407619, -0.19920174549527053, 0.20826555263758975, 0.4590695845427599, -0.5660966992380652, 1.083786109594556, -0.09723705321176573, 1.004191592988195, 0.43748636211367875, 0.844947805294172, 0.10237268775108749, -0.3487929404315616, -0.447776665543525, 0.8533317790974755, -1.0218071327466711, 0.2858061379319715, -1.1143475376804308, -0.32994044581876675, -1.1423902041444614, -0.19416793991391312, -0.936630906857542, 0.5587970427744401, 1.0823502687809332, -1.2501004429651337, -0.6306657389849678, -0.004861606563307501, -0.691514900836918, -0.7415364741819963, -0.32956323240400853, 0.2611226656592688, -0.1502294504156355, -0.9949320122679557, -1.12083958269784, -0.5061983915234763, -0.9034442028640168, -0.050776826706958315, -0.5408804489348269, -0.11395544021346063, -0.6946964981332482, 0.6866849036381211, 0.8674184569965785, -0.754421649892839, 0.20122884614461886, -0.38084577278208026, -0.5232164183034518, 0.6826905726615015, 1.0797206787391112, 0.0027991224106798506, -0.6377739500447354, 1.2628333652197037, 0.7340552267492432, 0.43713341227627395, -0.6501523027868424, -0.32264113616801604, -0.8922429330773308, -1.1255212807210178, -0.10665637035246964},
    {-1.1965323140520092, 1.1259213707160498, -0.5421166578936278, 0.078190261864008, -0.5430418882682335, 1.3218444295122889, -0.84087010610057, 0.0776734683510489, -0.49481817203169093, -0.8431902572219061, 1.1357478452294767, -0.5914855901055883, 0.7850034287298457, -0.3731868390233067, 0.9228609320214614, 0.6572442389158165, -0.011923504907448874, 0.9444656716781513, -0.2868220496678203, 0.19900326719630354, 0.8509589278992962, -1.1644749458966228, 0.5147820708724568, 1.0680923376457163, -0.8951062084936482, 0.9812095518279975, -0.16758141142995323, 1.065538246456924, 0.5581461211535537, 0.4921899843950601, 1.0834503832219136, 0.0802599148335666, 0.06483501745725645, 0.022531916552920313, -0.723450485908135, -0.7086271983502525, -1.2055312659178823, -0.43959250432443514, -0.8751737126279426, 0.14071459049668725, -0.5792112082002282, 1.351844393658132, -1.0156303480090716, 0.399530096548932, 0.9746582924795028, 0.49496752325763643, -0.8802563634287606, 0.7258419949243975, -0.28689826369062343, -1.287165729374482, -0.03423949184687434, -0.6796463764496544, 0.19765453610148684, -0.4553732505020403, 1.0910172864518302, 0.14452761825913474, 0.29170458716532943, 0.6768904037475609, 0.01806287745393025, 1.210750542417538, -0.637551232174872, -1.0132680852774723, -0.061125549631062814, 0.4357888838161591},
    {0.44843980543297957, -0.1251596173557991, 1.0961883633356793, 1.1227135384975595, 0.43084551815637573, -1.0786261715983205, 0.5649632390633492, 1.359749708233406, -0.7052528600582171, -0.88146379330325, 0.528297021572621, -0.9580199761432006, 0.7929466142316572, 0.9100659261830215, -0.11561165726028211, -0.6375610607879688, 1.3857862481227285, 0.1733062646815223, 1.0102321833230306, 0.6706398675429398, -0.21177956352489957, -1.0683907624612328, -0.9520281937415092, -0.8557525610918076, 0.5743949672453001, 0.623619635134375, 0.9949081782408999, 0.43213684449484885, -0.5447529047593608, 0.6494432928983951, -1.1798519062200392, -0.6865568258417195, -0.7924741641769403, 0.7849669850755292, -0.016390480216700656, -0.6864894035917399, 0.6681192408649108, 0.8302675327564621, 0.8100405177468709, -0.31607562298354114, -0.49669342814451717, 0.39897791065205507, -0.9475278442600604, -1.0680639846369433, 1.1611830541434782, -0.48153375761537365, 1.1372146762979662, 1.191952297493082, 0.530939381917323, -0.9206111505706119, 0.8827627595424642, 0.2292057255110154, 1.0250409346374225, -0.8997567682100773, -0.4047019478989109, 0.13232832923549306, 0.7092402328810374, -0.19337806518338432, -0.028239881608196897, 0.31613555842431895, -0.6484593965282404, -0.5414117345401391, -0.6456813379914752, 0.8972864245427254},
    {-1.3230035036494776, -1.1325336919222324, 0.7793984609563435, 1.002142395065474, 0.8812263807945383, -0.6149001953443973, -1.0156091633144793, 0.5059727648015458, -0.366303313173681, 0.813749372550555, 0.32916539357290975, -0.9642132806016579, 0.1201177170161811, 0.38471794250452696, -0.8825415915912402, -1.0421120056935762, -1.3159359925033052, -0.44787170092191425, 0.8633578468627111, -0.5839354354052788, -0.5179366297571969, -0.3049830172383456, -0.18669115845446613, 1.0638417829162852, -1.0229330535503731, -0.9100750401804264, 0.6344690721893899, 1.0154079835769068, -0.7795969438411455, -0.7201926274551134, -0.8429297133130376, -0.39896741189454316, 0.8746661315100451, -1.2146016639148627, 0.6880535802075404, -0.5497519403757682, 1.2098848366800132, -0.09416882777084058, 0.3558525359974018, 0.14114074400360493, 0.6976322286160968, -1.0921503595728963, -0.09242073083097414, 0.5229822707345305, 0.25685087241227145, -0.033700367650382326, 0.6425145662502785, 0.7766139323448579, 0.5181906201742312, -0.40536859376651685, -0.9459416321270298, -0.07927008874218151, -1.0876479465214228, -0.9565905820541015, 0.7481262572148065, -0.5312138930953512, -1.0890407341224242, 0.9695879967116977, 0.7289565952326746, 0.1844233234494475, 0.9296221491196524, 0.32855112550515286, -0.15786652831086284, 1.0904724262411716},
    {-0.5427555998272436, -0.6526329669203168, 1.0855399306239486, 0.6173316053820229, -0.281168710080906, -0.12653179032332162, -0.914191433983191, 0.8453273326920187, -0.7345334112000732, 0.14596160892119744, -0.816691252013505, 0.694731306040823, 0.1367181520514483, 1.0907406647950006, -0.08504819192052025, -0.36673068886756055, -0.5406725135926929, 0.6429224723775993, 1.3071373388689163, 0.8171431906260459, -0.47489856168636435, -1.0828653509964825, 0.47035058690496145, 0.7989075405879618, 0.48520308204330415, -0.4648483075045756, -0.9373044167213251, 1.111652045750167, -1.1075695808313533, 0.7245837637835566, -0.3614012444260369, -0.2578636517309581, -0.2213018843043563, -1.110539425712387, -0.20270958035344186, -0.24151075377762216, -0.43663360488208935, 0.4780225279101395, -0.21176357457601097, -1.2084034968985653, 0.6138196321304142, -1.2873892321350358, -0.2928564203962331, 0.7254496821836426, 1.1655340563706609, 0.46873591127941433, 0.7603664517269276, 0.7861816253536293, 0.45279194014813945, 0.9176693872589902, -0.9344757350901457, 0.9218716775536996, -0.36291778371085287, 0.48673316202181754, -0.2695880876389098, 0.44244077874627663, -0.10705785632583863, -0.5420971061047294, -1.1768126481434709, 0.9539100578592441, 0.3175339366758334, -1.0474657725974945, -0.5019559873425635, -0.3777768595940187},
    {-0.3526298798028672, 0.23821797425918892, 0.851673056469087, -0.6845336843160486, 0.1998127231734416, -0.1286420723844246, -0.7600106641578468, -0.4712367530526579, -0.16688818883898943, -0.9873141673286083, 0.7536242913525524, -0.700114375510606, 0.4739638301453965, 1.1220477904542643, -0.33045420418503163, 0.5985696674722044, 0.12345268179601412, 0.13473020554472728, 0.5551743631540912, -0.3677410098499964, -1.233685226903523, -0.673395495480798, -0.2799655853215358, 0.30504136076615324, 0.5222951821988032, -0.3572202745909611, -0.36259307172451366, 0.14019810545229644, 0.4952199338418344, -0.29255827242229065, -0.8064315730846204, 0.5003487645920615, 0.7838610147398397, 0.5042619862720246, -0.7074141078652001, 0.3010688271388982, -0.1340763590008509, -0.26932521274786086, -0.392582122449836, -0.5206309470722672, 0.8326541735933917, 0.02077451780764082, 1.1069752762246694, 1.4316415148914008, -0.6111962972311243, 0.00424148641730615, -0.7492613992042974, 0.5027006145057509, 0.348040734071701, -0.5817104460546748, 0.25277113643203797, -0.5762417180186847, -0.23643957550066, 0.5560777901507727, 0.9889983005353624, -0.6038768315707325, 0.8630521902045981, 0.2790789486301787, 0.8372009762781066, -1.1224398721535827, 0.9381471334376675, -0.7665007628011666, 0.0004623824880156284, -0.9622008554253252},
    {-0.05825724607265157, -0.894174580720422, 0.8043007572127683, -0.09558347136861667, -0.5134568680267556, -0.7360067256258209, 0.7993875772099882, -0.1228773916878488, -0.11544886051078083, -0.43179207588639523, -0.06667994160590614, 0.9768788497776446, -1.157853947561832, 0.5827674479540074, -0.941804804127533, 0.39115731673545395, 0.6129281363346235, -0.5866266631652276, -0.07841948209840105, 0.26824866939543107, 0.41985417660837193, 0.4837759491197769, 1.059759560881535, 0.9218514680182097, -1.103525335523494, -0.33989697695078863, -0.9747827652034147, -0.9446520620164598, -0.6920627621932524, -0.0913225464108305, -0.5496226437130439, 0.3218155120876702, -0.7993130061692887, -0.9454030397837875, 1.146644231254037, 0.006915123974639609, 0.43464607268485145, -1.137763601668937, -0.6117776229673793, -1.1478516979944753, 1.0039082562646255, 0.18565365094803132, -0.5280373162863773, -1.0889207520105393, 0.1463813446621959, 1.1470435148066433, 0.14805034609297124, -0.2928691130103431, 0.7742772283706666, -0.7776698249768612, -0.11783218787462485, 0.1630664698446172, 0.06924029107935616, -0.8173728744622997, -0.7679866703042276, -0.12087025900319595, 0.6627362827083461, 0.0644819703378207, 0.8267441431078514, 0.8873830862968469, -0.7776332181850713, -0.548620938148963, -0.11845539889124719, -0.03448813995270573},
    {0.45281889776550527, -1.0072276136008318, 0.5415420173501893, -0.21535699137261843, -0.23026532041132267, -0.7964435154647663, 0.35067185981441074, 0.06277613796405852, 0.16179358094378174, 0.1559448806405884, 0.5804229089770692, 0.8230841818884848, 0.6835123253607345, 0.030563433031041486, 0.079228007717668, 0.3795287307500399, -1.2917317202619025, -0.2798613760967153, 0.9262235137901489, 0.45995945727843573, 1.2406763469219226, -0.7119923270042177, -1.0490090950809987, 0.2787753593139453, 0.9052653755275207, -0.5794101309710208, 0.5656689523942386, -0.6708612785681409, -0.4764303691171686, 0.07001195751609132, -0.8017508338802337, 0.31469990077380205, -0.45081488249679974, -1.2008129846693767, -0.9071819323066542, 0.5340030996103551, -0.12764689980927332, 0.7925381930951318, 0.33458676477931276, 1.0688112583414906, -1.0110282272138469, -0.35080752223994843, -0.4394833311821549, 0.808054398992113, -0.06276383008419442, 1.1022090752715925, 0.5183582002030519, 0.2374894732134316, 0.552795915506568, -0.9501982083025238, 0.0917232805262619, -0.6471536958606151, 0.28502200591246074, 0.7541045363589749, -1.067695514153989, 0.5990081236764685, -0.4100717599660383, -0.2682732408677399, 0.7847061029802856, 0.5185739401561669, -0.6310880398653641, -0.7770050282936701, 1.097561670905016, -0.4874937121352116},
    {1.2672452739457556, 0.40026361082615186, -0.508355704139251, 0.0790830937029776, -0.5943085958308227, 0.8672351886636188, -1.1783293477716563, 0.7948053063852847, 0.36381408143163513, -0.19098939840727008, -0.24816402720668088, -1.0173900147074149, 0.606454162434705, -1.0781413871066516, 0.10602609822577742, -0.3059460813277607, -1.0026960796803468, -0.8286966045515528, 0.5157988898217943, 0.14093969393031336, 1.2367244480909554, 0.4545032103170214, 0.4762391898812323, -0.31076983692516624, -1.0416200250870264, 0.5831593985425831, 0.29915618638825914, 0.9732384720159003, 0.27664314617471014, -0.8039437369536765, -0.957998049450193, 0.8964431486290125, -0.7639050862206326, 0.5012353885402087, -1.1607438205364105, 0.3753377273076502, -0.42435316198081274, 0.0001851265855786662, 0.25509276653113355, -0.5728952180335335, 0.6261036718294989, -1.089960762195624, -0.38826961248756797, -0.7125827715439947, -0.36007429665403795, -0.27003490358966015, -0.08720185934852552, 1.198065884950562, -0.9362765591135281, 0.7905487939769117, 0.3581589785068083, -0.9377602535620855, -0.6240405062239591, 0.20715802310210724, -0.7321339897189719, 0.16835885359538935, 1.2405134847709516, -0.4598584362895288, 1.0147083545287248, 1.0159903074807262, -0.477024146999466, -0.08809334182490129, 1.0752013804287106, 0.7331466966631807},
    {-0.8314550691064123, 0.9369655440181084, -0.17239672361844466, 1.2479880480594296, -0.13077164216938333, 0.26721036423805505, -0.25778088337060223, -0.9431128137616227, 0.5105543762421049, 0.6963051209493069, 0.2389806847773866, 0.7480305114279617, -0.2493174786325746, 1.206080004236776, -0.5394007852238564, 0.08063218801300637, 0.4296993429566183, -0.5354523755848916, -0.4810332980280947, -0.9644268199183572, 0.8365736311919646, -1.054987549135889, 0.3814519245875878, 1.236046875963605, -1.1398931912879104, 0.7995036033804789, 0.3274714783170405, 0.7130023446173035, 0.5697962041065489, -0.40083155872608756, 0.6350182245202345, -0.6976460511387177, -1.0391553946232708, -1.3156686003907483, -0.150108755909035, -1.0475751687536667, -1.2030553453956772, 0.47095115319471526, -0.1516675795946471, -0.39376262224981723, -0.9829347024143904, -0.2893576542302767, -0.0821034466835255, 1.0552445942806363, 0.07603987148534334, 0.257357869213175, 0.9031991178532787, -0.11053208119866066, 0.5732505177816973, 0.6988225856988188, -0.26253591361464684, 1.251638444906871, -0.38344546088782316, 0.11891480094132195, 0.562534352229313, 1.2079764349439681, 0.34511183972517756, 1.0510162473594185, -1.104925733435906, -1.2341253107392771, 1.2755419232104324, -1.0722342580301742, -0.4413755642511553, -0.6142840305519663},
    {0.14856083446790552, -0.35375078397138787, 0.6936818915327594, 1.1851176846521905, 0.03486345114299608, -0.6231377649319402, 1.0581574404779224, -0.39135049851242787, 0.9963029885499568, 0.007757740886745, -0.3554596288908042, 0.7515423301499287, -0.7362140258260844, 0.05046055686209107, 1.1902869770650153, -0.5391458227227897, -0.8266146374438194, -0.06394209771555477, 1.0423541045573144, -0.08378991294643204, 0.8463209070533982, -0.6429859105407482, -0.6792313578219665, 0.8201118809235785, 0.9408650208209747, 0.7360040290117136, -1.012321433844874, -0.02437110610407876, -0.5653494054231633, 0.901975480521287, -0.20893794630986304, 0.5632588608322752, -0.46297936149491414, -0.1940158969889959, -1.2246863506120884, 0.8306777949158047, 0.28001176744681305, 0.17407054468019517, 0.9821393434965857, 0.39834547161674944, 1.069845666344021, 0.2592092419794853, -0.8913491737998943, -0.8577544710912239, 0.6312948866445312, -0.22228100257293673, 0.854112370116553, -0.4432537497210292, 0.2790277035299202, -0.3027129496372916, 0.21872765269837513, 0.4464746495930615, 0.37271372498852695, -0.04320444208871545, -0.982975420225731, 1.2624048979704672, 0.47689384865942613, 0.12725831488690126, -0.8571659552261486, 0.01655197870647483, -0.9089132293796377, -0.36272097620881705, 0.4006872463497821, -0.5766496646253613},
    {-0.8342269573081665, 0.4521370369538019, -0.6666589616854744, 0.5091451091138476, 0.3628923616320335, -0.04820524383036401, -1.0988446932908245, -0.7480863277253985, -0.28010444412081514, 0.8514353306051787, 0.8647438926983598, 0.40485275344242266, 1.2874146513301226, 1.1166552921241097, -0.8264006441239055, 0.570225111641811, 0.2819681902733555, -0.6068558922216426, -1.193379893185447, 0.38220960914404856, -0.6596406480575187, -0.9102912340311521, 1.0804230768255854, 0.38478815872149325, 1.0975108939399516, -0.7036045921097844, 0.7831097510714797, 1.1210788186310967, -0.284818073190073, -0.6478922127526593, 0.10603014575924534, -0.520862183607998, 0.6802435316822455, 0.48697132867847126, -0.46702543130564006, -1.0731379866707114, -0.13801180830836698, -0.09415590770594431, -0.8611924417919984, -0.35222471012122764, -0.45545377570719986, -0.6618690886251717, -0.6071412800111919, 1.056141788134489, 1.0422511368751992, -1.199721911523387, -0.3931191654939505, -0.8006639462694057, -1.1500694413141572, -1.1280343591930264, 0.034572139938216714, -0.6794825168566041, 0.503831529080633, 0.1978944141643318, 0.3786106321518404, 0.18457969207792574, -0.1387180706072926, -0.7812320785705319, 0.841222495825665, 0.047407279562745874, -0.025024185344108076, -0.530726126449591, 0.4390402204124, -0.01227065480967395},
    {-0.26309145761114894, -0.21051372338099267, -0.03883090709437885, -0.9726549102015889, -0.7804504356020527, 0.15776109460684007, -0.33376573649188346, 0.3742701785541211, 0.4162230962678007, 0.4925658526466129, -1.0170390255100852, 0.7356323585723284, 0.1617414027717877, -0.23080704685526232, -0.07526112031904819, -0.5825359262853984, 0.7079660602049682, -0.020754360023410454, -0.1246739825862075, 0.6412554399461061, -0.6082370895171308, -0.5573302791250593, 0.9004651945423422, -0.0945797338586017, -0.786422219896858, -1.2420319964458897, 0.6200519060884054, 0.24443472960881513, 1.1328454314578265, -0.21341205386200687, -0.4647792803073609, 0.8080365076053088, 0.9314962036337566, 0.7969559106186559, 0.2866658959661583, 0.6997179510398693, 0.892661144484626, -0.8932211401637565, 0.43317729086521334, -0.42779662757388964, 1.2258545943056407, -0.6743678936223745, -0.18014520209763615, 1.0186003033252666, -0.07875330085728964, -0.624549628529824, 0.9648529908437484, 0.2979560278503581, 0.84191598984553, -0.15074369214564534, 0.6069024588047519, -1.0107863515748252, 1.29386364884114, 0.9403105135110489, -0.9932331189836702, 0.18959999192350452, -0.26052309491518605, 0.8924060070430611, -0.5008729822686478, -1.0791788501628976, -0.1927876285295255, 0.8250951904965805, 0.39688141373024044, 0.19566876570699143},
    {-0.08577455615455325, 0.940624993770977, 0.9274329818063276, 0.2245737673647286, -0.31026258943678525, -0.964166687591905, -1.0522462630045593, 0.6859501233429303, -1.3011840787161977, -0.9299722228298395, 0.48804891918771803, -0.12018778579079818, -1.00631669906536, -0.5068018068549466, -0.8104445841039938, -0.631003163754861, -1.1537860501910469, -0.3942995080856101, 1.1054239607031018, -1.0403362394585924, 1.0389776812671254, -0.4026958577611169, -0.9782225618717256, 0.4920891914616061, 0.8500084577496405, -0.045783951515858165, 0.31785015703423736, -0.6650219760197238, 0.6040789610127546, -1.1960393994827412, 0.26282158802697503, 1.06061829750641, -0.945232167313985, 0.5046675815984056, 0.6167887781120744, -0.3636630088465, 0.3740370654632229, 0.8730640545041577, -0.7853526020003215, -1.1158228738324927, -0.5644788855797236, -1.4568322696041152, 0.43990713126000797, -0.725819056411322, -0.10492033691646789, 0.1589111572008155, 0.009982168688120189, -0.05847913375630015, 0.6175691343788229, 0.43130206484512607, 0.7501039159014061, -1.0822407236263063, 0.11188014113378197, -1.2426614432156955, 0.45527747403056146, 1.031403011085999, -0.44097012864236534, -1.6308655643827314, -0.022801173962457743, -0.23477632395363537, -0.7599973474799504, -0.5872571179342221, -0.5537437539680125, 1.0434677472680427},
    {1.0016657800327262, 1.2312248908017083, 1.1168722467302883, 0.5197075746186991, -0.9836233405667917, 0.22242133182474966, -0.9286442941654587, -1.0701648230951333, -0.5715310146661072, -1.2326693968266087, -1.1946888588348057, 0.9221577472388808, -0.05804188091380821, -1.0063339456209721, -0.37020715655092, -0.3331181815275595, -0.5310494629331676, 0.5352431728851849, -0.09882455345731647, -0.6042616903419588, 0.46117342685398205, 0.5772168959400134, -0.8700032224501848, -0.5505429997797825, 0.21023279528460806, -0.31744270608853103, -0.9186981883821943, 0.6723435942255737, -0.0562269951430139, 0.5581550769160002, -1.2991318024066967, 0.39869312681683616, 0.3914457495491539, 0.9323132149522675, -0.6383659526572527, -0.37531862649282044, -1.0623979990684764, -0.2002302542954972, -0.273645530895587, -0.1398374014067072, -0.587264589492062, -1.319788881169457, -0.1431562724891447, 0.11768446083279721, -0.5030757459771931, 0.2599704173957883, 0.706262674112008, 0.6924526905781927, -0.7482844520418694, 0.2557324031972561, -0.3210688338686883, 0.1635467495654198, 0.8684836325877, 0.3131592300772194, 0.4508672084208809, -0.8683764856885622, -0.24563454927508108, -0.30825289585487414, -0.364100943237094, -0.006722900339316262, -0.27779392557358135, -0.30803981222401494, 0.6338547301321353, -0.6820369035030344},
    {1.0532434115560452, 0.38799155105502986, -0.24780091307533364, -0.6335709288788542, -0.8789106769390294, 0.9599730866986628, 1.040207654977473, 0.8677190419250611, -0.12600745186694678, 0.08168658486440336, -0.13205865295440983, -0.8240318852662378, 0.27404674145421004, 0.4017447575948397, 0.5798249118154866, 0.9561879927489401, 0.774888532275375, 0.010521146191304604, 1.0570297229418029, 0.6266782821913803, 0.8554627904019455, 0.9641177024211857, -0.6218141030401682, -0.3173675858101521, -1.1059324852856818, -1.3217208011080477, -0.06472977040270633, 0.08756515727275502, -0.2204513624425444, -0.38851438714315323, 0.6604081204770983, 1.1263754946979412, -1.0309531698056416, 0.9236391793955883, -0.9929700066851397, -0.24728932812223348, 0.06641114573157081, 0.07924171154468203, -0.2640642266914365, 0.6195931192470222, 0.6351041029523454, -0.8240027811596222, 0.06837655522637688, 0.0455911029934133, 0.0018597241601650918, -0.8919187922249727, -0.5451547318092486, -0.10961713143288743, -1.0548046472328474, 0.8708997920794255, 0.983739298527768, -0.15426273854079364, 0.43140859763195993, -0.6359773926531305, 0.08745986930063093, -0.7893731885266013, -1.2312144301125256, 0.21653012480243738, 0.3603941738803554, -0.22276917684643222, -0.694602296634077, -0.25332219274404977, 0.3876759160608378, -0.610422771010751},
    {0.06849955563233126, -0.8104949130994507, -0.6452108199855456, -0.4219121675836007, 0.020154856001479735, 0.7316449710297168, 0.5378062145365341, 0.496827382888128, 0.8522223350542221, 0.4197547408857716, 0.5309284601225467, 0.37071031189874126, 0.2581927652188717, 0.056756795507272445, 0.8169997040215634, 0.39385298781555816, 0.7473305856828122, 0.6941502157129666, 0.05349964140641708, -0.8876318510740443, 0.5168022557447035, -0.19233218223912085, -0.5157068386877619, -1.1902537405238818, 1.0710429390436653, 0.10528209698236689, -1.2229656044375692, 0.7362566468347665, -0.46518416512246347, 0.7312941946678974, 1.0053440965282556, -0.7463030965943288, 0.0980295334941126, -0.055329820877257276, 1.055005710685372, -0.0963152702744891, 0.33767766656854487, 1.2416344215118211, 0.5210289470251743, 0.011770058928129825, 0.43457048788644215, -0.03528657902274497, 0.20000732803264384, -0.2509702890710712, -0.12526610508048786, -0.33510098768825514, 0.3325979135739377, -0.22588487843544794, -1.1990830780422892, -0.8249717392873256, -1.257437238486002, -0.1995018389965293, -0.4504054364789206, -0.8699904616336541, -0.5161287347721971, -0.4150883446311759, 0.21598408387894943, -0.5193344778308806, 1.2538263369046347, -0.17292741691089922, 0.7663294183649808, 0.9182665630582042, -0.17931343879539802, -0.12820215042771702},
    {0.3121236309286217, -0.7587488280588217, 0.20808724458905078, 1.1024473428398085, 0.660130791886166, -0.6847698791807071, -0.19508879434440662, 0.38245177531204433, 0.9061486954963643, -0.04416979520577412, 1.235220416908398, 0.7229347565258256, 0.2791271627837866, 1.0665765383385406, 0.6674156645753101, -0.5342542422635173, 0.3760291410711706, 0.7226112135282574, 0.9103570659552225, -0.6589467868664299, 0.04030628028908748, 0.2516055166803559, 0.9183796507077951, 0.16080200483488302, 0.9109636513474523, -0.28695825716550993, -1.0863305140695094, 0.7104665466380106, -0.8032432504143294, -0.074352376012769, -0.7846697141207377, -0.831709043544115, -0.045333134786769896, 0.007329152086756301, -0.28180744399036656, -0.7026705711709399, 1.265101513391982, 0.8511702576503067, 0.9292772922635502, -0.6819524624130258, 0.781860975962321, -0.07961341518079626, -0.7226263160514, 0.7052923985206119, -1.2776545089556746, -0.565833417935016, 0.4126166100874181, 0.9446067844984127, -1.1186646448010635, -1.3774961213883024, 0.9909791050276165, -0.959897610221329, -1.221015549005496, 1.3961299360329782, -0.8576023774204887, -0.828674336080338, 0.21745423945766781, 0.3131372280073776, 1.2257715449323074, 0.8714429737198567, 0.08812936794347548, -0.6197488215238668, -0.6659567700118965, -0.6146895269309296},
    {-0.8054398660322406, 1.0744102228206038, 0.9485530267437535, 0.44685871861119697, -0.9346555055786445, -0.5247474526626263, -1.102191777719955, -1.1798080388083978, 0.49336889737612255, -0.1085332901711205, 0.02988769259002561, 0.9919066733742506, 0.940832241647528, -0.0873207044201176, -0.758153500212691, 0.8174105106318884, 0.733146620076549, 0.6600206665911792, 0.7146316827524158, -0.91261420528257, -0.3648492157816933, -0.8517055875776202, 0.2538506130862487, 0.10960755532215141, -0.0534128606696458, -0.3851934150601296, -0.4522120075630741, -0.8384572963840952, -1.2068227259300308, -0.4697095234542546, -0.764425500025892, 0.62667920237178, -0.25663030638496637, 0.8246895198021792, -0.23367365550683297, 0.8561092097491108, 1.040165541650153, 0.496464170720565, 1.1524229519262754, -0.8823924996182645, -0.7884021679696472, 0.04385638080580965, -0.1764146858322537, 0.1897399601047355, 0.544772468203644, -0.6900696044867484, -0.24507985346241834, 0.3281082436553767, 0.4088999483943238, 0.45544203154012225, 0.5164594569868793, 0.4401937323033347, -0.06929154590325724, -0.725308771837524, 1.0811915754401993, 0.9558939156201082, 0.41616237461845823, 0.36283972202964265, 0.48118333742617, -0.8108168018903766, 0.22932185106656328, 0.9727771411501189, 0.898654064514494, -0.2271374697903264},
    {0.04987489110597956, 0.14182518719879653, -0.29038132277283524, 0.7816968139330047, 1.2589023116686646, 0.0803829317306376, 1.2184190994527964, -0.9738789568696193, 1.2876107012347544, -0.35465356887920924, 0.2548651148532776, 0.972706973369746, -0.7176472358055256, 0.9168875628734792, -0.5861409648185966, 0.142540033859575, -0.2314857060957275, -0.9159606209806236, -1.105918357800816, -0.1990575400196293, 0.6179236535714655, -1.1146493153390342, 0.15810095345209957, 0.003970660719544625, 0.5963880810175333, 0.7816141381693463, -0.9656583556166204, 0.011737933435022206, 1.1587910921408289, -0.14066302832771244, -1.1254911137004553, -0.4043810724200721, -1.189612432159587, -0.8565100715137021, 0.713452897787686, 0.619573838213532, -0.2845436768456359, 0.4994381225459271, -0.9298358530933325, -1.2240595589999215, 0.20103016550663955, 0.7038982066649667, -1.032094528034514, -0.15421233534164053, -0.4078843035595964, -0.22968917639496753, 0.9326010179869062, -1.0043325607127498, -0.8631423255450027, 0.913241696291307, -0.6265056577599247, 0.6624528646236454, -1.1237444850028395, 0.006768733143834715, 0.7355115749723123, -0.19203357783363775, 0.9442571218851794, 0.0016408633490000812, -0.8212387173673402, -0.7780559842943209, -0.18209584705795573, 0.364222178890739, 0.6803435038020373, 0.9707284398629944},
    {-0.2752993871411032, -0.7229910714519435, -1.265063704288304, 0.486539986402943, 0.26891757597210364, 0.12457909638342876, 0.07876936855483574, 0.34187936857514173, -0.3675109629934251, 1.0728012169952579, -0.23643051325968112, -1.1754635991469427, 0.5884232782307641, -0.8787142723540403, -0.5580119731079243, -0.5270827125212146, -0.4573111270062962, 0.7820028695510045, -0.5093121975016353, -1.0210523305193335, 0.6373801048589539, 0.9036937855609846, -0.3412098995880744, 0.49586925266095566, 0.17250815461845995, -1.0242645385615408, 0.48342799838507766, -0.3639148245674607, -0.1400630618612813, -0.18592595496825817, -1.1795594202548847, -0.49525462697426226, 1.0684217899667843, 0.41355902264217514, -0.21490345607163058, -0.9836796523190444, -1.0158443599798639, 1.1445983537467028, 0.1835312316694206, -1.0278881086034217, 0.29185800956668034, -0.69799531534223, 0.2645256668677143, 0.5878601277323734, 0.7681780016802725, -1.0050323921207558, -1.2837349234361968, -1.2836410038287116, -0.5804093697594926, 0.7722023269290907, 0.6154329672166251, 0.4245711085532943, -0.8147544701008594, 0.5166077517681803, 0.7721421698490191, -0.06380910949959145, 0.1962142272052525, -0.09670305329818497, -1.1639550318009138, 0.8230871658604169, 0.46706602220702736, -0.7908629758065092, -1.2059288911087724, 0.3252456326618648},
    {-0.2992502205495385, -0.7127036228390055, -0.24528022488266074, -1.2197812221334428, 0.30970802950147974, 0.6632625129764081, 1.002926959206376, -0.5351018979959486, -0.3511746655077669, -0.947577225535435, -0.13199661790565206, 0.5327322761988893, 0.468849474358424, 0.5228814339495913, -0.6800885141022904, 0.6454608222258678, 1.211401463012469, 0.6292950580599203, -0.6734747308557995, -0.1738471391797589, -0.8590468393709424, 0.20688823224053984, 0.9520703711990868, 0.7188820239803756, -0.5352261509956528, -0.22642471637595793, -0.3753601394988732, -0.9109648358625291, -0.8228959745382036, 0.5727334055581562, -0.047705666863942835, 0.4087995826442403, -0.14913822248848815, 0.889618154652192, 1.1129215507618033, 0.9823038047979784, 1.2676712605094025, -0.8187945093923673, -0.32465545865194445, -0.2856046507145558, 0.8721896028309671, 0.3002825380971295, 0.27613328822181255, 0.8146583956998571, 0.2384759927343533, 0.4318116198453657, 1.128766842439688, -0.7184737417099959, -0.6806973214862007, -0.09136474819881335, -0.5041160422712115, -0.04327931800446736, 0.4731753181247248, -0.9101966212396078, 0.5703198612311534, -0.5454451807126425, 0.6319591180864254, 0.8931290225712913, 1.059234728699679, 0.46451018144064155, -0.8744662386255906, -0.9022766321343805, 0.7308427224653847, -0.3876153089674515},
    {0.26002010462677677, -1.0480207891175197, 1.3589930933393395, -0.08483692812633535, 0.510083585264423, 0.650964625780589, -0.3967049203149815, -0.4989910136776261, 0.8716140847711387, 0.2561603877668941, -0.7647143764813317, 0.8111064098185096, -0.2971681856333432, 0.0077266150904822745, -0.04546444376873875, 0.3896480752313562, -0.7774428207141745, 0.9380864816191737, 0.4920822479615882, -0.3107033921145129, 0.6838645369770288, 0.8924955223518362, -1.0423845934884461, 0.8825183482392841, -0.5301177377203161, 0.8924383118808077, -0.21727353683339296, -0.30053017150433414, -0.628547833695493, 0.3730037528399788, 0.32954014802892373, 0.6682657027665757, 0.1409451114741761, 0.042884699266188854, -0.27706578494690415, 0.33385700915890315, 0.7438750070985911, 0.9742715316213441, 0.0710728465087442, -0.07718127272329149, -0.08621983812876995, -0.9944604350505556, -0.012062824864207742, 0.765329404571731, 0.7874359626128127, 0.8084279116691139, 0.12232292072670578, -0.8688478342219371, 0.7853535031242697, -0.9915307839681176, -0.7587496781024968, 0.3110731165568038, -0.5589551728808642, -0.9485815188001682, 0.768746650737367, 0.6233658710249181, -0.8419511831724629, 0.8374391157922126, -0.04470992423602192, -1.0142131716121188, -0.5372183992483851, -0.6014340647593621, 0.44863254042810047, 0.7768574299532671},
    {0.7935176598190418, -0.21215837052379488, 0.9858565602527545, 1.3224875518241774, -0.44715460158103865, -1.1670661961815456, -0.38340182255568134, -1.150647926892215, -0.19896570772460387, -0.30265859040480747, 0.39657129953115594, 0.7592217207463221, -0.8709243495616208, 0.9093412498297954, -1.1531524051270128, -0.46753690533007436, -0.5924003951635787, -0.9977914783518095, -0.9254356991566953, 0.13807209882497398, -0.590042150130083, 0.03451204685048906, 0.8112355045039817, -0.4347473431768525, -0.6789920341853851, -0.2536953845069451, 0.6089675244345627, 0.9391909251260749, 0.3578246685366523, -0.9707341410561184, -0.21742848411688964, -0.7008180957792172, 0.8140505314630425, 0.11648043505573516, 0.9891490449281383, 0.4099586805501242, 0.7293837309512866, -0.7675475198265344, 0.3926938958470763, -0.5990932229574792, -0.7755284224107503, -0.20737601166889877, -0.5081291093313606, -0.22037283458316592, -1.0214298371521566, -0.39651287208255426, -0.25295913086898747, -0.6107177753061047, -0.1848752095216323, -0.07290219713123977, 0.1813302703123016, -0.32511719130039346, -0.9973906046974065, 0.10352115081915882, 0.05016580681133301, -1.028818687568276, -0.2803701402963775, 0.7049974435178712, -0.5002653727515948, 0.36339455665831116, 0.37527006725087025, 1.05220649376512, -0.0871113383798932, 0.012958206812239319},
    {0.4309728912431709, -0.1790356975936215, 0.27938006895528555, 1.0856465478466673, -1.1609841375185126, 0.2722348769907103, 0.865830481287869, -0.9757197192398843, -0.2696222619615779, -0.7762956067424277, -0.413101516572131, 0.031809270858400684, 0.8436292270458207, 0.6583280538588965, 0.9197804996361933, -0.7891975946683812, -1.2296163337353256, -0.368244515877624, 0.23609475349849726, 0.668832295937927, 1.1396421363539677, 0.23884686118616455, 0.3359468672427915, 1.0101581357645744, 1.0073867295392087, -0.21886675164040334, 0.8792566064678341, -0.25321229069459283, -0.6673063906665425, 0.858294627762293, 1.0916371241584382, -0.8848569361105424, -0.1693227287600585, -1.2920474344026485, -0.34343896534960006, 0.3893079128468112, -0.17450564681068426, -1.0595921655106488, -0.5432363667874217, 0.3387356125649126, -0.05994990151965971, -1.0607706824173952, -0.591179475602415, 0.5318434723167097, -1.2684779671099808, -0.4576272680331383, 1.022205462771717, 1.0996497429393035, -1.0655702317866893, 0.9993700178125451, -1.2957894286833784, -0.6352118803863146, 0.16072732476651633, -1.086131095739888, -0.4210393872094517, 0.9637091549147322, -0.4569317858875426, 0.6160601027981122, 1.1037904424988478, 0.7200400347483159, -0.9162599251508127, -1.1740080019229093, 0.4384611117770654, -0.7175525232413809},
    {1.065289799183239, 1.064684252178328, -0.6563457449869987, 0.6705212856746211, 0.46495087508861116, 0.4555999294536198, 0.8479758487636123, 0.3522278445920502, -0.6141230459567462, -0.4761124324195211, -0.7655458703971367, 0.4065589179464025, -0.7820071365654966, 0.5359011765242351, -0.3300630575992572, -1.0870391302747924, -0.5734645655461904, 1.056299517941266, 1.3620284522787474, 0.38573996608700545, 0.3068185286784187, 1.2402891763524084, -1.0936648779166478, 0.9485107065146365, -0.8266753264848414, -0.12905158777338938, 0.6392053734476817, -0.004408898254533043, -0.06274764347542455, -0.2926986865140828, -0.31061142993742, -0.7797767366363723, -0.014949618743868829, -0.46236717048437825, 0.20436829250764066, -0.4461317887246168, -0.18304909433247174, -0.48430867756825696, -0.3558099628913351, -0.6536818112924864, 1.1558062928351467, 0.2584997217614784, 0.4328011685178688, -0.7102780589909301, -0.16075165634516714, 0.6552721504871929, -0.10609073651936271, 0.3845172976903877, 1.0499424198988168, -0.7388710895138849, 0.41513737179761573, -0.0036223544739061968, -0.7300973950155885, 0.12306177646389135, -0.10987720347489141, -0.6466879022532194, -0.7744839667009854, -1.2282615649976076, 0.5709943628412241, -0.025432729994812883, -0.4101303392463322, -0.970820369742981, 0.4751152763986146, 0.9734698228182744},
    {-0.16320165801386646, -0.9043569506965948, -0.08658394795605771, 0.44811047185401964, -0.3001944032165549, 0.09137156438045592, -0.4674975963623587, -0.49748177039939684, -1.0528101380886772, 0.19736868990129522, -0.6480890176597432, -0.95235827608758, 0.005599768401029142, -1.041170786469027, -0.5112510485097481, -0.5529207314401492, -0.4625154214630023, -0.4018037291140191, 0.5753537706622295, -0.8791688667342195, -0.18065941301793192, -0.10607807174368661, 0.719127294101654, -1.0552518210879978, -0.615941084583718, 1.0715412130493884, 0.887556948935963, -0.8005016645830653, 1.0380576345266497, -1.0581039411542104, -0.22758541313092462, -0.563594025327669, 0.3835419704498259, -0.03832981883885822, -1.2828122888172846, 0.6153740001462455, 0.3245371667246093, -0.07470185343912862, -0.5253851143694321, -0.7798619385214172, 0.8702619749799728, -0.31841970577718814, 0.7246232757788903, -0.7024584785809954, -0.18157889731231058, 1.1446141532943368, 1.0009868079892503, 0.7369401302412639, 1.2162185309134936, 0.8260767554796163, 0.41222126643795326, -1.039780413597897, -1.0460543702841016, -0.22999084185718252, -0.28240960166997614, 0.649504907563674, 1.0710222143484505, -0.5610792716730998, 0.14961141785633308, -0.6946570727140483, -0.019518531096852726, 0.9065212298689834, 0.45437108576935253, 0.261306994255086},
    {-0.7388340855251704, 0.5174376835864831, -0.35771919558775467, 0.3364589672881838, 0.689281124863616, -0.998113694735752, 0.4720901133798314, 0.051296615858333644, -0.7544501797691965, -0.5380676844484794, -0.8110261145006022, -1.1541543016433575, -1.0435470798882758, -1.0431969061241357, -1.23204858307965, 0.787259757089622, -0.49863720061366523, -0.6882024209042957, -0.9187392437098586, 0.36400331286085674, -1.3354686223101706, -0.032666305343599863, -0.9894404036920491, -0.2440983762651043, -0.502243696927821, 0.5823702298735125, -0.7770458201976947, -0.8116855417754745, -0.7250617317518249, -0.036783364659003795, 0.1797705064562373, 0.11302000409018136, 0.5976765451939859, 0.513621040876176, -1.260420339531045, 0.33414700178538015, -0.04143400570552523, 0.4219637351556866, -1.0190696609367, 0.5693311821551279, 0.6335583788740989, -8.341750641514565e-06, -0.7184569224834937, -0.8802111926612324, 0.5101095558095173, 0.016978348757816494, -0.14936732872634403, 0.5474475276629676, -0.5455315141613797, 0.8207647126355853, 0.11588035999431413, -0.7201767831867906, -0.3173389874332029, 0.16934387219804067, -0.7303022120300342, -0.5334333620290106, 1.0547942762930236, 0.3193027050684216, -0.7757373948806746, -1.2338149276000216, -0.30384485048438326, -0.2246133045394739, -1.3068207858697494, 0.19136240050462175},
    {-1.2188047157109692, 0.7045154020811218, 0.8094994297906921, 0.1670688212379955, -0.7308350440302713, 0.4150553966999652, 0.10728049141227287, -0.5649380210394381, -0.2552716260118908, -0.39329302693817575, -0.48548177529725284, -0.4508151477972016, 0.832437607775453, -0.7522225307246454, 0.7013810293204346, 1.026547433437916, -1.0929837407685867, 0.5364048006147312, -0.36272763790718515, 1.0348464140120868, 0.935997618043752, 0.8243981230948528, 0.6045513192863432, 0.19272312223697907, 0.8440522059227497, 0.7583988357909608, -0.1613087443790396, -0.5319338012024938, 0.24986208963615647, 0.6731329180230855, -1.239096076068339, 0.40508863625322966, -0.8261487118085088, 0.9962733661338881, -0.3896299444088955, -0.281037210016373, -0.7670753644211142, -0.23062727184667176, -1.202502997291305, -0.33528302907589885, 0.8733981296660644, -0.13566491979904566, 0.42828706739161815, -0.6854609211709722, 1.0012627376968057, 0.03078841980128704, 0.7759034557364038, -0.9844000543339115, 0.4210619397614468, 0.9713884209544688, 0.5852559672272445, 0.7084778474255977, 0.796153340499034, 0.5457175716023606, 0.23644876028113176, 0.3460131650678764, -1.2043064905182324, -0.426509778273902, 0.3506180852534929, -0.7334089243509057, -0.43414563290186675, -0.5117890228269849, 0.09477699830173719, -0.395276562957589},
    {0.5970332677449243, -0.36913547263372837, 0.09254579119867617, 0.3526999281690604, 0.3857025237685501, 0.6230730899086776, 0.9451434038467444, -0.06850314219833833, 0.49758079070115424, 0.18096673792399762, 0.33978362537525725, 0.42741058189765635, 1.3000300077223743, 1.0368855280628337, 0.20197964040620708, 0.45475761478848475, -0.22027902608667838, 0.4872304696084659, -1.1415020460190433, 0.47683738377081464, 0.0824346733242006, 0.9673834226192287, -0.9843192730960239, 0.556212115535727, 0.570128742058085, 0.05554230013100953, 0.7030892050689708, -0.6419583121664151, -0.6657114108843223, -0.060097423316683427, -0.21981953044410052, -0.5713204633964092, -1.0151139825212738, 0.9954443994045062, 1.0498237856381136, 0.7949310375033725, 0.5416358907634561, -0.11063722416601823, -1.2091258059846812, -0.8128365547778016, -1.1724552429515112, -0.5641279603452363, 0.8890875016414849, 1.1576528505742851, -0.5791101325858042, -0.07338434363714512, 0.45507969702632656, 1.0117125972367156, 0.176703502395947, -0.8873147584314408, -0.6763626061258112, -1.0362177601812066, 0.26802645760422195, 0.7488928195291785, 0.003164607550239114, 0.5935582577653391, -0.2846527641378365, -0.6714228668783203, 0.8435767216447005, -0.4481191068455542, 0.9714175017467561, -0.5055419624830345, -0.9861720222242838, 0.4329461448063265},
    {-0.8000482191947029, 0.6080330843894955, 0.6791650186163244, 0.2497071127050185, 0.40302770700297225, -0.2861813464131339, -0.24648965824557512, 0.6469249773753412, 0.9137244308134364, -0.5976187959638066, -1.0070058268557058, -0.41296328256232506, 0.37271967995486227, 0.7002567233682764, 0.18784964261240877, -0.8057868059069384, 0.8719915541010709, 0.0551697783007138, -0.16146400317347054, 0.5653567780047538, 0.583455785214595, -1.161377856444913, -1.008079075806659, -0.6119387690036473, 0.7443592785282442, -0.6548346541992938, -0.14146737915838162, -0.6911304392312998, -0.03783482256136698, 0.41480393259683634, 0.7793287809783095, -0.2599496744806916, -0.25101263383526057, -0.8721045502859288, 0.799693887755887, 0.2735913889793234, -0.31711809029429716, 0.5803085167163778, -0.7847931163664953, -0.39574552896986, -1.0267835654021906, -0.8492540716308782, -0.7638503735392244, -0.2331157551995765, 0.07612129156972912, -1.1713712193145434, -0.5278284320674789, 1.1974548079402787, 0.48129514158563674, 0.6221686013399913, -0.05825662253008003, -0.8310898712647607, -0.8674466062100669, -0.9892919437063211, 1.1019199849963404, 0.7009836079205938, 0.2742215788145748, -0.44153248580035115, 1.0979218058474711, 1.111193822459752, 0.2833356255265659, 0.9486215490698735, -0.9061375578205771, 0.32825849818118563},
    {0.04451912329896727, 0.8528302893479444, 1.0661424914876698, 1.0402521999186498, 0.30039275143488, 0.5378897779398053, 1.1273306630019029, 1.120806618934978, 0.6794428839480579, -0.6579040223917061, 0.32492586456954986, 0.0289318856472236, 0.1600111229358498, 0.40494271279904387, -0.9577676823232947, -1.236662605153625, 0.6799672498601351, 0.8551702261908185, -0.23007151797999983, 0.22760567628570072, -0.7441537442986031, 1.1747538262677473, -0.6427426120722095, -0.08533277521274055, -0.4579522135461169, -0.12539640010462294, 0.68658107985311, -0.3992251686243199, 0.6910709425099626, 0.04705224332265836, -0.583613422294567, 0.15093675694887262, -0.4406376255883921, -0.8173738752795743, 0.597451464157714, -0.14846875303632814, 0.33063030846468683, 0.4376208907352011, -0.4238847274415583, -0.17045727896216162, -0.2719710070893343, 1.0036512020743202, -0.970619060284083, 0.35234546018114227, 0.8669918528175352, -0.5291876347192921, -0.017909754920510005, -0.0431617766551843, -0.47956710502098654, 0.4836215690118004, 0.5746961061984304, 1.150188352905547, 0.7026889459735155, 0.2358360163797213, -0.10333008007503759, -0.746767548684286, -0.0475299856168302, -0.06097765965864344, -0.6286098130532757, -0.20011020528744114, -0.9290294305582152, 1.1158441130221202, 1.0382315747810411, 0.4265115788100634},
    {-0.8987087696795688, -0.5190250419823139, 0.37948404092207294, -0.41871767847062896, 0.024338936655383555, -1.1753673297261602, 1.1681615113144703, 0.005636305537053211, 0.4794096309101837, 0.2963609149475683, -0.681835084085834, -0.390193550591886, -0.3711007184089897, -0.1275998342471771, 0.4085848204218779, -0.04685804015544331, 0.09601245406452254, 1.2570986036611411, 1.0186398634496034, 0.7026602506023639, -0.3624432246358951, 1.0107982025363393, -0.5964258505289023, 0.563955752739325, 0.66286640636135, -0.10711492323901048, 0.5867476669506533, -0.7958048117519632, -0.7040241584320998, -0.8490570721784206, -0.34662825853557655, -0.26198649392537054, 1.0220683312595635, 1.0800333951397765, -1.0744101499603689, 0.44317488097356816, -0.011597132991351209, 0.08200208739438233, -0.5488380495291513, 1.0051310928082173, 0.7939633855425082, -0.8105979630368667, 0.7163942254196034, -0.502128378303675, -0.8828225313992312, -0.8748174496801323, 1.1409339135192782, 1.0137192889895141, 0.8071511047498157, 0.011188592686066917, -0.2407835131075734, 0.16032304021258348, 0.8594207010934424, -0.75628195060794, -0.20301297967354653, -1.096679824716319, 0.7664247315602671, -0.4485578633298363, 0.9650521295366059, -0.5045331283151139, -1.0767016572674064, -0.8037476725111005, 1.4149646473657134, 0.7560924100923757},
    {0.9688741720098221, 0.8607698199504332, 0.7614563571557171, -0.9465450168862644, -1.270626624620433, -0.34092934796365926, -0.13423060037907436, -0.2509839485430049, 0.9214814513597139, 0.8245770640498732, -0.21991533011420705, 0.40493622328109646, -0.5943221298523834, 1.06817551954701, -0.4397964343163614, 0.3660464255516379, 0.20080314510797678, -0.2598683163793436, -0.16112265597587264, -1.0033914982206271, 0.40193143270729564, 0.27614365929454326, -1.0133980521694799, -0.2389598666162296, -0.6983920061949241, 0.1713013721591736, -0.9540610916844426, -0.451102185533477, -0.8086280073769304, -0.48263869075630234, 1.1174107841595018, -0.3240263086372198, -0.21315889787039669, 0.44289513614775194, 0.13145913797775294, -0.9306313704592851, -0.9896897727334655, 0.7704610107450157, -0.6071264532174891, -0.9065247616382839, -0.12432753821091387, -0.2833597492052512, 0.5387955999903501, -1.142440852801652, -0.5531253312207344, 0.4951673400022027, -0.34766004301472325, -0.01560619993206802, 0.11626952409405464, -0.8471234758438905, 0.4758317273159998, -0.4685036645566387, -0.1779740728249502, 0.8923475463371415, 0.6602623414310878, -0.1609354920844679, 1.1573179285915622, 1.0413587557934154, 0.7257868820623987, -0.35229286450326847, 0.7562665652928954, -0.2021432807981019, 0.3704074176695452, -1.0154615506967153},
    {1.177721649323023, -0.5018695408419057, -1.3900627078916115, 0.3065587233544369, 0.20564388612797635, 0.5633495606992391, -0.5637946516892294, -0.020869588203280772, -0.42886501382002484, 1.1817287405493604, -0.5533539090153042, -0.6231902554133644, -0.8015227203293388, 0.5631123510422809, -0.1569272029230548, -0.9717657317456614, -0.5814182116516277, -1.1372604791061514, -0.10886413078126139, -0.6648643501232622, 0.6680018843127216, 0.5728314169095607, 0.15209274814497994, -0.8782457455374373, -0.9714449063988337, 0.951124974020014, -0.15715600982666628, 0.8322065728360051, 0.2613807018087867, 0.2163220401318737, -1.0927003260805408, -0.39270740843638113, 1.1470867929170228, -0.16937676861363077, 1.0533836913764218, 0.4370853438666572, 0.48388377087144685, 0.6344129136073678, -0.5430621975324221, 0.06023367875250533, -0.5045695802463592, 0.4859264359439992, 0.2236383004223551, -0.3328789672871468, 0.7693497586461364, -0.594729306740476, -0.25513582119608474, 0.7443368661541859, -0.9783849511086031, -0.9010021469130448, 0.8297141093753109, -0.4820838931494186, 0.07015614269495568, -0.5121686482984894, 0.8457557625632475, -1.20890016502611, 0.6679045932347267, -0.2671120617815544, -0.3302477848730619, 0.9675789537903744, -0.3573692778919214, -1.205873267807068, 0.6871729838363609, 0.9910221123062366},
    {0.039748608505086894, -1.2139291101916139, -0.9374966869810318, -0.3250565294385626, -0.6054730178941681, -0.4775391356132397, 0.15488088858540872, 0.8573181960147546, -0.04902417952915479, 0.9890515557036714, 1.1190334956972074, -0.14664469547177283, -0.7076027460159428, 1.0792736302726844, 1.0070921541816547, -0.786392290794041, -0.25047114490282, -0.41386037120887226, 1.0357953228860965, -0.8607715337071851, 0.21987771476866752, -0.246230132638007, 0.9143116258573307, 0.9868082965880773, -0.9170955910342516, 0.7226568504037121, 0.6852922075883581, 0.9763832323802416, -1.0092845583512626, -0.7933101115483001, 0.9211950992019934, 0.056344457116153226, 0.6186681525262968, -0.45257628971064884, -0.18256436776636167, -0.7635268149323622, 0.8340694117195008, 0.8646438577432938, -0.10941794836913825, 1.0561803877794158, -0.02689262335896762, -0.20951688197521592, -0.8481280995321331, 0.013711506342241818, 0.02494180808564055, 0.8206495262592913, 0.4545457499884496, 0.8416188107035519, 0.4039414492814247, -1.0554959875028493, -1.2028506305369095, 0.9587991270803858, -1.0534257924031085, -0.1673288622481737, -1.0561759359042042, -0.9690308214856385, 0.6531870623711247, -0.9007876521845813, -0.38633202557943325, -0.3349086664391661, 0.6817492123437618, 0.5374463047668259, -1.051667605128749, -0.7169571452646575},
    {0.8594838298703926, -0.43217337208103324, -0.06714804448920103, 0.5313502196355192, -0.30449035254540746, 0.6969166386577536, -1.0503772298623515, -0.8104115583118678, -1.0501630680039533, 0.10717615504428886, 0.9781585451928737, -1.211726973885362, -0.42068771526899285, -0.6443443756954405, -0.07028876825918766, 1.1281688922594773, -1.0027476038139442, 0.07485422847805961, 0.8245069682854064, -0.6366365693857459, 0.7603838177887929, -0.1953289625383453, 1.1265791279834547, -1.1864969431680286, 0.09240337414357641, -0.7126177351970275, 0.09796378977414692, -0.16615099557253948, -0.09414817066751634, -0.10528930496374371, -0.3274949373666826, 0.7658642543170793, -1.0871133655630183, -0.7211812301665504, 0.4925345448095381, -0.1533646297345599, -0.6245759844691541, -0.030353206562430547, 1.0818357233582838, -0.9894459490034907, 0.9561705199251855, 1.0386813030679996, -0.6300207955136179, -1.0335546579744412, -0.68488460098584, -0.9954740851897598, -0.4727020097698393, -0.850418088869134, -1.2502912401935644, 0.8986844849316532, -0.7145315223571965, 0.620278806322947, -0.23660356071365346, 0.13550136098555457, -1.1993391614609694, 0.7084401085857853, -0.5187735050587422, 0.620067213804824, -0.7357118878284972, -1.2409018463048127, 0.5915412085603244, 0.5731124257464053, -0.6716231056048151, 0.18185769874386135},
    {-0.4218336370920819, -1.027350187777892, -0.6598915452142142, 0.8710724373092009, -1.2035678317286511, 0.5531974669313908, -0.6488516099550019, -1.2677975339884788, 1.1134979375613447, 0.03594294204896854, -0.4834968714348326, -1.1355873021348062, 0.5121265302347219, -0.2960684830507416, 0.7408677862561285, 0.5785442265086588, -0.011827386450672555, -0.8502271828946906, 1.1624074133147002, -0.08463455318127427, -0.5010388921501122, 0.6808680888951307, 1.1767986122608498, -0.12555789900474265, 0.9137263157360397, 0.6074416020952444, -0.8341338453811177, 0.23598436877583795, 0.34494864483350945, -1.3939997539479376, 0.03214089686124621, 0.91457673642341, 0.6492872617981844, 0.5630687636960625, 0.752494436361312, 0.000257363226483685, -0.06229781457764927, 0.5780041991102151, 0.05806925558168137, 0.019404523213505637, -0.9238229471951942, -0.7216121715853336, 0.4194491075545781, -0.2271945571335491, 0.832395673452787, 0.5502921569530733, 0.420971677330527, 0.762196705676092, -0.428787444730294, -0.5852249038930277, 1.0567153626509387, -0.04432608022214815, 0.8835663753934268, 0.9530237166337531, -0.4003377343545528, 0.7787038545687318, -1.1006229626648407, 0.8886723534321584, -1.09985097643783, -0.3117498686102351, -0.7419849153371956, 0.8331871272918555, -0.3916391869194152, -0.19526513204760837},
    {-0.42515147596973174, 0.06594969535137256, 0.5239158242339131, 1.0719033412988028, 0.88550505952858, -0.23311839385853006, 0.09435712987875983, 1.30794530461602, -0.477549978962391, 1.3370164549048313, -0.03810182432641409, -0.9871905151822852, 0.15845776160162345, -1.0972034022083947, -0.601754620029116, -0.9187692096208496, 0.4891322831938415, -1.0606503120474655, 0.8245315492220778, -0.1357468384773296, -0.71290598308751, -0.5407762148361596, 0.20407840419659018, 1.0867428428310983, 1.012447237064869, -0.5333685800738033, -0.7689189104222238, 0.7015439110471444, 1.090879467475324, 0.006641516432000397, 0.2885556962918837, -0.17642959201400354, 1.0679743641389319, 1.2843477064804933, -0.974085626392218, 0.5107713639143759, -0.8268643637598301, -0.4362089805433897, 0.9958243372561321, -0.1691752935704115, 0.4739962230527432, -0.596041954177169, 0.34764844861983313, -0.11268726244783094, -0.4048271113196072, -0.6812047417719085, -0.6500642624591251, -0.42082248965057584, 0.556227746729985, 0.5286367402471107, -0.6825854704640508, 0.623066488678629, 0.9019340952238731, 1.2331974288363228, -0.12327538736869958, 0.7288497976638694, 0.2650266135050963, 0.7661161154899181, 0.447831755944633, 1.0870357262603656, -0.5929698627615811, -0.9548497502030214, 0.13164348515448226, 0.2953677925932352},
    {0.1817291165820655, 0.4909619159113559, -0.36931449668971217, -0.11949143847358648, 0.11701225582176517, 0.6975463047748862, -1.050551137658417, -0.5415873282555855, -0.771684201641451, -0.27925029726042455, -0.39435504426462326, 0.8237758491204331, 0.8089988619634351, 0.2884400592796913, -0.779963542690795, -1.1178082743398026, -0.5215891206917882, 1.064463623244648, -1.2016935099184969, -0.33353513785406297, 0.002322073116261624, 0.5270524573834483, -1.0385790916284732, -1.1252405589708543, -0.3194461478421576, 0.9217115310281933, 0.9313513382303412, -0.784918538695286, -0.3759055189489311, 0.2649561532299997, -0.18125524879894991, -0.6947708458318648, 0.8700975110459416, -0.3651134927303097, 0.3392670132837087, 1.2436642120589405, -0.1617954982197136, -0.44104664918445297, 0.809825163053324, 0.9270092739809549, 0.9178678203904991, -0.5102035671129826, -0.915173422475652, -1.0705297538124663, 0.6914273454658154, -0.3236922517258116, 0.6764482921167397, -0.6994119485233636, 1.2454897109296932, -1.052253332138801, -0.7832760181813141, -1.052281398973112, 0.034591722226634855, 0.9252669848839299, -0.53298747620462, 0.6597954208656863, -0.3853277663563607, 1.291755326993392, -0.7696781121317214, 0.631296039623569, -0.42279076567192747, 0.14767334673349325, -1.2265004024034585, 1.0722731436325514},
    {1.1866530387599037, -0.6963908259665018, -1.0728898591558067, -0.1748151371200699, 0.06430521312648307, -0.40373406807443885, -0.1484493307870766, -0.9689145433518199, 0.9001668486155611, -1.0731648805762204, 0.4257626984857418, 0.35534775099423804, -0.9031201685083484, 0.20075983236001413, 1.0919052557962572, 1.2487200341534037, 0.025933226261963413, -0.1341951444063365, -0.3063113206937297, 0.42753379713062706, -0.5258713239698007, 0.2862181471382936, -0.7904112604802582, -0.38766871530779073, 0.30218104478145014, -0.5878572795523191, -0.6835404508162595, -0.6685501576249165, 0.80782399228715, 1.1229672607162433, -0.1317490417223244, 0.5542865551096634, -0.06737049388887995, -0.3423421665394259, 1.2331645735381858, 1.055226432618213, 0.9827673684435355, -0.9051789186054741, 0.8258421191253157, 0.5730015904374375, -0.39392580614251504, 0.6960597838728075, 1.0011346116804007, 0.3008065765987993, 0.5381648016980507, 0.8479400162390794, 0.0014109083949613856, 0.1933202815718387, 0.3271473132991883, 0.7583418467153784, -0.88495515562951, -0.4639282337632711, 0.7866352262280338, -0.632355306349997, -0.13307605875884704, -0.5842748302166807, 0.9969263027516403, 0.568264957953735, 0.6877665098592822, -0.6946365908138427, 1.2122221650496035, -0.5099619522776458, -1.0591397741883022, 0.2547460653120069},
    {-0.7249420794628872, -0.6956685371068887, -0.7871477852321893, -0.7500433894130332, -0.34092365582281214, 0.22391067236098386, 0.06194668436404082, -0.8501552580527327, 0.738514344849306, 0.3299337160134404, -0.8493291581230867, 0.39651603590126566, -0.5459876364297968, -1.0151903381131944, -0.5116507503063785, 0.22638330884276295, -0.4997296605254455, -0.9951985073670208, -0.3248074427519181, -1.16133445309742, -0.5973695817169198, -0.31704564985831535, -1.3691950070233372, -0.06869031346151798, 0.521122917702997, -1.1431768651141778, 0.03293106441931884, 1.0268203326391963, -1.121262119936503, 1.0319825431934693, 1.0386793477130638, -0.31238222775958646, 0.37694127260464616, 0.24969196100614094, 0.5573185308610493, -1.2078745054864513, -1.0418999348092388, 0.8255693009099587, -0.35453763425086743, -0.8250851781680844, 1.0010863277892257, 0.014800527646495644, -0.25372452673602724, -0.6928948201460835, 0.09571022908946983, 1.1775062210474583, 1.0425498739874965, -1.1962197162836674, -1.1430735957606302, 0.9709598236271196, 0.5905241979581005, -0.17210954775910667, 0.3087450474675239, -1.1053800301472403, 0.5753938023116094, 0.8709983058853857, -0.16485058047615742, -0.6871255128270753, -0.1073379507333936, 0.3535825445683928, 0.17990530647964753, -0.3532499089151164, 1.0254553175819199, -0.17305728024479808},
    {-0.9162590278385394, -0.9228215602173404, -0.14358702330288087, 0.8299117150220894, 0.4755568158131251, -0.7318660341096638, -0.01537838947413262, 1.023472234980135, 0.6939963258467703, 1.138201227938811, 0.42893697768494765, 1.3109433340399335, -0.9467007476802254, 1.295846497304704, 0.29178362177158573, -0.19044405414263108, 0.8005968945809981, -0.7512402526510684, -0.8559324059448169, 0.25384727764163234, 0.8837348201668819, -0.17608109175611764, -0.9323136311102951, 0.3109846109881527, 0.589353836728722, 1.1029742711030952, 1.0972954964454738, -0.9305077587614379, -0.6259470587031956, 0.15334538505626105, 0.9017590840772696, -0.88251515761793, -0.4506014486597024, -0.6413188926484198, 0.31112549085903624, -0.7288441502055788, 0.4490211339177702, -0.2605689084358036, 0.4384636513310652, -0.11565088105563352, -0.29691261668582364, -0.005586999058425784, -0.12457844272205776, -0.7937919765796976, -1.0224996837816793, 0.7557493714882794, 0.4280185837061312, 0.13587371116538888, 0.711436242448284, 0.6399555531301131, -0.6239309906790674, -0.15416049271901874, -0.8708168047631384, 1.1329918888763417, -0.2248285540142948, 0.7463208482572543, 0.243840622004546, -0.25939894396129853, -0.9976660767187557, -0.10480778694060426, 1.24708437679243, 0.7084371219923247, 0.3762304475982139, 0.28012480387918887},
    {-0.427115781290645, 0.6785861769735838, 0.11028930245548677, 1.045546418512758, -0.298189041374817, -0.7228951889664138, 0.734812171239295, 0.05842740993922011, -0.36840622719731314, 0.4078231655868347, 0.3675904984582046, -0.32481194114825634, -0.9440157461705689, 0.497936682102361, -1.1622056672139867, 1.0384196618235282, 0.10837544515338438, 0.3232958202575255, 0.08787030046641059, -0.96831118125863, -0.32787932189937363, -0.39192320039303397, 0.6958580919439986, 0.3256467868729349, -0.18340158821938063, 0.8944625215707575, 0.008228642220267963, 0.9788454103376277, -0.1270528862539055, 0.44824762986336614, -0.21821058304795055, -0.9054226434152167, -0.39437374066158565, 0.23665923226777774, -0.7620273785579083, 1.1284997741414353, 0.6700855032437893, -0.030608033477861712, 0.16680352208409213, -1.0161949464688802, -0.2301513285139764, -0.2759518197042644, 0.24675996158144928, -1.2601094854746504, -0.9365326044816585, -0.6547083428462955, 0.2883575660141784, -0.10177024605150976, -1.1012891484258616, 1.140455054231129, -0.014279201993010459, 0.8679480423494415, 0.2525055001319923, -0.7281159878027167, -0.0443582221923612, 0.8937841351292698, -0.11834463511499801, -0.6650413523006774, 0.440946755204541, 0.7870292438496702, 0.7696986288304273, 0.08879161045617517, 1.1721365138390762, -1.1227490989593976},
    {-1.0698159047577516, 0.7190137637302048, -0.16322331267001064, 1.018136774707606, -0.47567879665719964, -0.8151968340332223, 0.07946369880495456, -0.7956818384531668, -1.0681575260198288, -0.059980074821971686, -0.05551586533346901, -0.1252401643418035, 0.7459496752847868, -0.9479420933204196, -0.2777046848185189, -0.49041342343340916, -0.11534508980536876, -0.2480080062495178, -0.4399949463363739, 0.840465964319037, -1.1375119981841668, 0.6369153506796423, 0.8203924554077997, -1.010621966100829, 0.5310556465873405, 0.09753490864751135, -1.25318943420595, -0.6409392029602299, -0.8612503406145521, -1.0593411179384564, -0.3789564112108432, 0.004878085868409332, -0.02460258855462102, -0.7424436760468853, -0.23935059439265152, 0.8071848715199652, 0.2765486343087586, -0.9575481750463566, -1.1337139977596606, -0.8651220462200991, -0.01891748054217414, -0.062241956595723465, -0.9974788300563011, 0.4776404966459929, 0.7651250986917228, -1.0898653717046936, 0.8279106943243758, 0.533423835314992, -0.1342826985481028, 0.27240418249891973, -0.9925015318451578, 1.2562054142904893, 0.7877503738965991, -1.0741080718762779, 0.9179213968474789, 0.9583289115883321, -0.781569739471001, 0.43206115459554395, -0.05791490218422953, 0.3204735136785673, 0.5841413848720528, 0.8065118174576492, 0.43066230996572796, -0.35132905722811897},
    {0.5285133427419755, 0.03983793032649901, -0.5810519230579266, -1.2039195182193263, 0.4971255602426676, 1.0953278289126933, 0.7680343173439937, -1.1422062071318249, 0.6591636054545591, -0.11989150301055199, -1.2656650302181798, -0.4295015974199579, 0.7987343017678437, 0.21155360314196886, 0.7726059502189255, -0.4282590345775714, -0.12397160258655886, -0.49434735668272034, 0.07687225849333888, -0.3536628278216794, 0.23454665817863574, 0.38834515918616447, -0.8460675704074382, -0.5208279677894923, -0.664211011497691, -0.738531659951376, -0.17843467554714998, 0.7705303059150446, 0.5428441326790266, -1.209420605329414, 0.8522532619379106, -0.750486282324946, 0.7289355888790973, 0.8978933194416074, 0.8188491755943055, -0.9700371424082957, -0.011069800436333013, 0.28542515325981344, 0.697109239719215, -0.24738848256380247, -1.0345013930421039, 0.9936408381449073, 0.0403964655864566, -0.5742653648680681, 0.3683932449342204, -0.1639925648234917, 0.2529062540999989, 0.6621454880478558, -0.5921923242718269, -0.13133716921049626, 0.5695753411827341, 0.538651315182188, 0.15586642229790446, 0.9208477563662342, 0.6605423322693168, 0.24624022943275803, 0.08506355478467259, -0.09468897917915987, -0.6640623530354269, 0.488705852393127, -0.6689451690648089, -0.004623348471979551, -1.0576662831168273, -0.5807393456096366},
    {0.3191627497762909, -0.30535294588346956, 0.15013723616860122, 1.1183412276204385, 0.16711249348302204, -0.01641666094097142, -0.5275441295026767, -0.1370965559490302, -0.2729628761214762, -1.1657556908802706, 0.5686745685566863, -0.8828067624979892, 1.162785566291494, -0.9220847122312108, 0.7310253967275233, 0.6405784407129468, 0.2382499942706626, 0.8362620598878979, 0.9878923538177177, 0.49080414742325557, -0.578916871371116, -0.031089953017088338, -0.27170872373100846, -0.11248992764995491, -0.8690542984963169, 0.8995347807355718, 0.7674211058913774, -0.4961619616427209, -0.24310807416378816, 0.45019368723068076, 0.5028030623249292, -0.4246266187871258, 0.6655239241745997, 0.0659884961762896, 0.4412934650147606, -1.0020537984307687, -0.5695211504951531, -1.1532623694354605, -0.7104451367753705, -0.7689495333645994, 0.22691194752155872, 0.8464221151461795, -1.236705923535103, -0.2158797053054031, -1.218353779455618, -0.49389781392849574, -0.23000509563413446, 0.3194216980401396, -0.8224216323917877, -0.8690956878028565, -0.7994045155582035, 0.850795768766135, -0.644227441701059, -0.30848200829142497, -0.012700481851931296, -0.012840895927569472, -0.032190007961816244, -0.780081464348594, -0.23068073788505628, -0.6039860664990374, 0.2245222160583322, 0.3943526140924296, 1.0783573162982536, -0.1833399626830814},
    {0.14893431603592386, 0.5221230609211622, -0.14497226918527745, -0.18875119495342998, 1.2056112079087788, -0.1567948437150419, 0.45025097418193366, 1.0753780493837901, -0.08170264836959494, -0.4257058572969312, 0.38804936163174003, 1.0970823366720943, 0.02708918036643445, 0.8645915830199237, -0.1260195441407511, -0.9295915964997964, 0.7358742871464778, 0.5018809074360505, 0.8948231273485572, -0.6602664895748676, 0.07757807652427699, 0.6550645952893928, -0.9411010655487165, -0.6504335445826114, -0.7395311377931499, -0.23400317227793496, -0.8017623803663801, -0.8317790875046794, -0.3711025692040184, -0.525255265165682, 0.6953846565489368, -0.367107403300439, 1.025386087917228, 0.654343408575369, 1.0733359687212263, -0.39920597706888244, 1.2596183620738564, -1.2900251398761629, 0.7154175789291266, -0.6940807361735148, 0.8864726480128986, 0.1851306122320806, 0.26777140627998786, -0.5906150140886288, -0.13631947373078582, 0.18397493736715478, 1.0504630020790546, -4.305242341501254e-05, 0.9931218245450784, 0.3918432242131916, 0.6933171754038161, -0.5613919773672322, 0.9905288435049602, 0.5213001270391925, -0.1867312578502022, 0.20408006044372318, -0.2204037368204786, -0.5893218633568701, -0.3729845462506717, -0.06877005219182919, -0.35754501173556114, -0.20317835466584044, -0.2983781851409696, 0.19191455043082187},
    {-0.9851811793647899, -1.0590889644267047, -0.2696259530445801, -0.7334911855587712, -1.1955590152146431, 1.1467279203734808, 0.9788165173241736, -0.4937326400509811, 0.5174437351912587, -0.7818222391503387, -0.5104538846276105, -0.09437539002125238, -0.01339341252603975, 0.028108778612073084, -0.8775443564334467, -0.3304616387533494, 0.7466043609096539, 0.1891696751235231, 1.0097696734053976, -0.7730165036955053, -0.6098173858055108, -0.4026411463578725, -0.16246278589767277, -0.44619039483991013, -1.1706559708040893, -0.290455155537981, -0.9456105962477004, -0.4000937291731466, -0.7433462784548953, -1.0919490744727542, 0.17720845121105736, 0.9251591051398884, -1.124067700885078, 0.585283914754193, 0.7094539195157499, -0.5433742418152329, -0.8226099232765293, -0.9037752894689898, 0.7632109150315616, -1.0431189490870378, -0.9783413305022403, -0.33108520396633967, 0.05439296315174927, 1.177762889983448, 0.9660901359091719, 1.0291647387940315, 0.44698103365452574, 0.5081960771130675, -0.6984560503877696, 0.09389650047250231, 0.07706441585335722, 0.5886204926883829, -0.8757787988708956, -0.3296577646275641, 0.8547414268474128, -1.0998777252017127, 0.059778361204430995, -0.7739903307274065, -0.9535931657190321, -0.5846559821464852, -0.07533361599597861, -0.36979909819606127, 0.472161790501473, 0.7870954380398336},
    {0.12301501434491441, -0.7290245291414335, -0.2524203250337161, -0.9804154878739557, -0.33996455526540664, 0.2579514911822097, 0.9645344717782819, 0.644195053868145, 1.2152800338845997, -0.10781359570556175, -0.19066368715834503, 0.4071491954507387, -1.0437983781766857, 0.5268067087053173, -0.7184792440519799, 0.34822348856608226, 0.763969170442668, -0.6443464312470721, 0.7470729207240222, -0.41352671117829337, 0.534680447614273, 0.47302714546173297, -0.8316657096245195, 0.5707566151091121, -0.030101279060059855, -0.14464383682019508, -1.0647993230546204, 0.3264122375788477, -0.2881526613258218, 1.1260553305037553, -0.35675949462334866, 1.111157503135416, -0.7506010727590597, 0.9398517868523732, -0.8960997772688305, 0.9705202346515726, 0.7754383557639518, 1.0299621873671772, -0.6635248191368786, 1.1179463422807345, 0.8817821197400587, -0.7660901505889738, -0.9558582157021323, 0.38642195617382225, -0.7531584960037282, -1.2562146609313296, -0.9322537863597979, -0.15015680480627144, -0.9214729941531534, 0.20792646294389805, 0.186150083087821, -0.9613934864961123, 0.7050498546422489, 0.8924694110079218, -1.161389253371839, -0.7883652064794553, 0.24485574465959134, -0.13669475067697753, -0.702868558281337, 0.6150478188895623, 0.7688109839633471, -1.199799032634725, -1.0479900712509653, -0.21340529919621679},
    {0.036761186132685975, -0.3612286951067529, -0.4264227479914436, -1.158349609593788, -0.25942035778987366, 1.0399012352602839, -0.6338644922227851, 0.22579960991618947, 0.48482545856974435, -0.19078758451406613, -0.26899984025490853, -1.5360114375094243, 0.3603164609949105, -0.21786148463651892, 0.4370160751557256, -0.2280095378602123, 0.16885330115344918, -0.9876561973658221, -0.1641307518899034, -0.9573444567240308, -0.08564147939730485, 0.9741070488765039, 0.9820793564881241, -1.2882189730627112, -0.6061227547183541, 0.5259430010350189, 0.4361950829270315, -0.4358887707620171, -0.5616352803546552, -1.1382041088620758, 0.006570997654509596, 0.7531122300838662, -0.7858223613138305, 0.16109303932832109, -8.144423537287076e-05, -1.5035163784711887, 0.771460193986415, -0.8191746478159517, -0.568094787816024, 0.05904474025919736, -0.11279636833849892, -0.6515059748544987, -0.34594832722410707, -0.2790217566660329, 0.5826821959165789, -1.2537712871947089, 0.4948130474269936, 0.5254297512359418, 0.0329632778185448, -1.6451622775537176, 0.07907867194465801, 0.33053191514527624, -0.8778582027700763, 0.8648510227589041, 0.5545104668665031, -1.4781165957688944, -0.6938687908616556, -0.543995574686202, 0.15568251890858184, -0.5498392485169648, 0.6091388916204081, 0.38777858996660114, 0.5234934840967616, -0.9206126414426715},
    {-0.8698208274907389, 0.29513966624367505, -0.017908561953345926, -0.7748518877635552, -1.2027472083485569, 1.1431485971359678, -0.17562557783343075, -0.03376173613341215, 0.6764225579882873, 0.1897222691614712, -1.1781874986569492, -1.545778837343706, 0.7179181941311152, -1.6016151414853483, 1.0565366318641303, 0.1190865146253964, 0.3799367375202878, -1.2489966017331287, 0.4124298546460805, -0.5737952038343739, 0.08173472353393907, 0.6644776928924433, 0.6717649211587671, -0.5890394126380256, -0.47195080952502844, -0.2882328758232761, -0.42053123042116697, -0.10118833076156547, -1.3978770322314453, -0.7940020897152001, 0.581026911030454, 0.6718345048425037, -1.0514634141609094, -0.920508934522673, 0.6485096474044295, -1.2222495763726546, 0.06935700022602626, -0.09830030569959058, -0.777942039516933, 1.041724356139561, -1.2061166767632596, -0.4361134901324509, -0.3113297401991191, 0.6807419927953632, -0.7395661431065458, -1.589839754621835, 0.8351561172766929, -1.1359559135970814, -1.2487930574751105, -1.3483301997504777, -1.0694771092627597, 0.42839468233145506, 0.1546192606044257, -0.6422691095256134, 0.9978662275634854, -1.7374409747546737, -1.113936848949983, 0.12446651704917518, 0.38662516535702685, 0.4837560184126395, 0.8378707843057952, -1.0013139815129453, 0.19387301025668585, -0.8807196553402943},
    {-0.8092383991812863, -0.7290800150617766, 0.1563562253355622, -1.0245774367716065, 0.9227770370400956, 1.3053234069881343, -0.2679305219029003, -0.5633991452188567, 0.8807570459937726, -0.36197756825877986, -0.3124122148866629, -0.4406711792867539, -0.19805631612572433, -0.7692351345216049, 1.0722118884902108, -0.665357670096407, -0.1181136430916845, -0.9080550140857587, -1.3847172396050456, -0.04078885791167542, 1.3327780538788148, 0.7466098161325839, 0.36680748538977176, 0.13582055492500966, -0.28299908768799026, 0.015113563467466617, 0.8110215168105166, -0.8113469960909184, -0.7462093461200164, 1.134641575325587, 0.7226244772161791, -0.571348147684076, -0.7737344771980972, 0.7840390184703984, -0.8578704936295937, 0.4394611995410715, 0.4180703533159045, -0.5424490785083, 0.6276662901667918, 0.029694341351455548, 0.5348778583831652, 0.7585476679513082, -0.32992901218898607, 0.1335789037366274, 0.16813999374800925, -0.11078083052604744, -1.3506761873129802, 0.7338461106561055, -0.2268950418538161, 0.3369280934571109, 0.499525983410266, -0.9367074511254494, 0.6777647501331349, 0.32759320178996265, -0.061318448928937855, 0.6470253842762189, -0.8286742178311904, 0.5412727406711079, 0.6021046574704438, -0.0005949230734036551, -0.20908887329031933, -0.9417987525209067, 0.5719723966754889, 0.8065567491003993},
    {-0.9853249593250687, -1.2742588154652996, -0.03892477352634684, -0.9639513753107636, -0.7332453487316235, -0.548776107454523, 1.1124352392943548, -0.6308044364607049, -0.8220268821135078, 0.21953074268266234, -1.1495634616538366, -0.23635003370737812, -0.985828938575256, 0.8856546826133521, 0.5676259175965577, -0.5821584156472087, -0.9562349331381448, -1.0513692706463125, -0.3293074920471887, 0.3242968690566438, 1.1239879595828723, 0.11246523365107694, -0.2453445933758651, -0.44998403176437113, 0.24639789136748266, 0.3385115600108714, -1.1213979012789264, 1.3019963059013027, 0.31500788325275336, -0.9343565636386968, -1.0403189562551147, -0.1660340561482542, -0.5335285454793587, 0.04771181759328338, -0.028519021203785574, -0.9133990581350824, 0.6606313343474107, -0.7038896315411983, -0.11190686004463136, -0.02940119177327519, -1.1837154741359586, 1.0024215229187596, 0.07893690627395462, -0.9136898184223595, 0.037938485154510815, -1.2174771288765345, 0.5932758305545689, -0.43423651538118796, -1.1457249516962174, 0.326847091457043, -0.8607460704975676, -1.0442212047719681, 0.8088698408935223, -0.3318051779807118, -0.41445065520492624, 0.9934857459446691, -0.006947959775242778, -0.6058908582370173, -0.8906042060207034, 0.4667934386443746, -0.8417205450611821, 0.9068182028864122, 0.646729002319659, -0.6374230381302166},
    {-0.9294205168977082, 1.2406154413510322, 1.093642536476346, -1.3183800364404321, -0.43357792497559516, -0.9248253695123321, -0.420129057756798, 1.156729797988164, 0.2560035461534311, -0.8188758402283095, 0.7347420516835487, 0.8601408171024522, -0.4621243727368515, -1.2039694458030512, -0.4797322651578502, 0.3493538691203642, -0.7732928010111987, -0.8931840312840549, -1.280233551694265, 0.8413651330262252, 0.4488687772608878, -0.5334987638918415, -0.462063293961338, 0.665581974247353, -0.20704520251399172, -0.8078102850811867, -0.5883161201066828, 0.9117504748604588, 0.702832445632671, -0.5342869917614069, -0.8899693862263218, -0.4037817266364219, -0.14459173431860067, -1.3176734758245676, -0.42507289258920766, -0.21692049904961333, 0.7446987842448833, -0.7144914263796506, -0.8782987754255819, 0.06385386123266604, -0.4254466834020167, 0.27515096704746134, 0.9151221046254616, -0.5625381299736433, -0.04484172319512711, -0.38501351101783393, 1.2038715622941447, -0.0035198020586426184, -0.6744052878227343, -0.8446310763771316, -1.121374107819314, -0.17533231103620192, -1.029568223814201, -1.17209079704334, 0.9957058914705598, -0.3246711758137662, -0.9901049663662823, 0.5370537157137594, -0.6048361586985894, 0.0609018836625852, -0.22739902537278064, 0.5786994629974033, 0.7751392657677028, 0.583357887043178},
    {-0.20066546837199384, -0.9441467495243807, 0.7898813848391764, 0.6480221851429488, 0.07784492856461392, 0.9539398424779312, -0.21944951400984147, 0.6523082350020846, 0.6129558981405099, -1.1563321024074809, -0.2622630892444764, 0.14790565756302984, 1.0499427609841956, -1.338751953765435, -0.8667906791530393, -0.9981044709200306, -0.9019089488476906, -0.1983919161863673, -0.4495855276444488, -1.0359722743215651, -0.7919094076747246, 0.9073181308509168, 1.0988026383735747, -1.4337015968567213, -1.3103081872723379, 0.9235503133550484, -1.0709419298881255, -0.9139614487682645, -0.73688344337461, 0.6244468331995225, 0.20314130321189686, -0.5148034245723608, 0.8074034988760129, -0.020647976595941774, -0.967692245959745, 0.024279757242437337, -0.665126672286967, 0.6495417206015773, -0.8731642705087952, -0.5037383008010557, -0.06809042130597576, -0.2152892372136446, 0.9837147701275379, -0.30101684375136806, -0.4188857258142611, 0.4931768002710874, -0.8767621773691273, -0.45722433117979433, 0.3887956522344139, 0.8638740619452085, 0.2923449066792606, -0.7806358855515008, 0.3002948833167426, -0.5178847615124414, 0.7931313430470267, 0.3026769306788643, -1.2033142401637427, -0.2270789731681681, 0.9794359240064437, 0.8358925617224309, 0.7920453359216802, -0.199471196860347, -0.4773343749944749, -1.0616437178943916},
    {0.5653837126734599, 0.061335663378102326, -0.41523636115469864, -1.1053889377976547, -0.5558678188326719, -0.8079857781356197, 0.09144538413817058, 0.13271999431297637, -0.4158911550359195, 0.25296747806247516, 0.7920901490164006, 0.2775307899357417, 0.00441264008164942, -1.305250787989076, -1.0224113013178286, -0.4822572732657179, 0.7943222451293828, 0.5152343301521999, -0.49708920106263876, -1.2245711945379028, 1.104821025990725, -0.3776854739262717, 1.2373671449450363, -0.607250834916721, 0.003965038562479008, -0.008047139572438088, -0.3078215649237192, -0.32671728349335466, 0.12236748560333592, -0.44912985339912465, 0.19407437235029998, -0.07811708053907154, 0.14470447087824823, 0.7642156737398491, -0.6849146337443499, -1.0072484943387756, 0.12508565754623896, 0.4505581135860424, 1.0354586142774687, -0.06770374908273043, -0.9399085005665627, 1.0771318630694373, -1.0113257535023774, -0.05107916826300011, 0.2761941029685903, 0.5005190397196297, -0.12405362517123548, 0.7497650473609511, 1.0036461623141617, -1.0498054837577298, 0.699971215302938, -0.4191574337617159, 0.7783883913900709, -0.7270113075573272, 0.7398406290184453, -1.0341907501236045, 0.1066253527109431, -0.9198472557637397, 0.1579264865953676, 0.3802944513360657, 0.4787253123444866, 0.039325452725844534, 0.29623398727670447, -0.7793976132530661},
    {-1.295369934393998, 0.4897469115895307, -0.920346832544265, -1.0460243800478994, 0.37047765478015193, 0.4348438068393865, -1.126370391637103, -1.1704145995257864, 0.5999250738902175, -0.8484060176713313, 0.09688288508940884, -0.7829466758216517, 0.6626814661603317, 0.6066896486821293, 0.7083463322282971, 0.18716700872990488, 0.4127790920663846, -0.4587479553463627, -0.8818116615536831, -0.9535510944202021, 0.9102936897635542, 0.29020435269004363, 0.14701557659791, 0.271165112682695, -0.6718740467735399, -0.5084109162610935, 0.6885162687452047, 0.08815966425286886, -0.8632762018110186, 0.7989044053797622, 0.3558018400751936, -0.1512627111807363, 0.5719949616113649, -0.2274389557541659, -0.12530840063264875, -0.22729293519900703, 0.04503872062115672, -0.5663786462780369, 0.9216790598195552, -0.22460182592714137, -0.09289078789625321, -0.8807230720903682, 0.7421510297411057, 1.1451415862124072, -0.10974945235837541, -0.6255876191964672, -0.13754924875383504, 0.7815560857152964, 0.8991336070481211, -0.8895736781338527, -0.06875588112814161, 0.725337713899054, -0.8830531319100611, -1.1209215544586488, -0.16553857876212427, -0.2731464525214563, -0.13971131910468818, 0.7180758135580132, 0.07643254738409344, 0.7934810196279679, -0.21289845421633216, -0.6522724894050046, 0.8190499569572075, -0.6891371771068173},
    {0.5054586935186922, -0.8759062438991377, -0.7524650519759121, 0.25586803331402586, -0.25045939923333443, 0.11563641989114626, -0.5447088570479387, -0.7410486089053411, -0.34465879843164116, -0.009323454879244377, 0.8635938811061075, -0.9299242735404967, 0.11607733083945551, -0.4735550975658926, -0.7191542713766048, 0.7637507962529235, -0.8425995896240922, -0.206481750702712, -1.1349901228880852, -1.2139755294669186, -1.1080221418979768, 0.7029674377579197, 0.020592159035884516, -1.2643447325404342, 1.0648070159075367, 0.46925951647734765, -0.7812300789861278, -0.3172793321018063, -0.981800474906611, -1.12739574218675, 0.9551284034160215, 0.5796438937617745, 0.6643559492213323, 0.7700743332514487, -0.6148815960877761, 0.026683020441221623, -0.08127835355317752, 0.6522354983383507, -0.051881009499490115, 1.1702616774186465, -0.5147961190321535, -0.38545566861737096, -0.7520393904391951, 0.8614722144974294, 1.0196880348483848, -0.5130102004872836, 0.120224338074796, 0.8238503115043603, -0.9741098331568879, 0.956190091538949, 0.1885743662759063, -0.3995106773437867, -0.9140416767899923, 0.8874097027802257, 0.3855696632903371, -1.211534148256976, 1.1328615433758988, 0.4319268992664721, 0.7180669468842619, -1.1422633415652867, 0.7302044036489614, -1.214061618990601, 0.18610760663921183, 1.1883629193426621},
    {0.4195893335088975, 0.9716655470605013, 1.2473789544786003, -0.9069905923508522, 0.4883231412632622, -0.5151631851121705, -0.999176633124165, -1.3036235010161195, -0.904093845204545, -0.30809016454374943, -0.5411064649887715, -0.08205842058288047, -0.7473030478069996, -0.9973133790504656, 0.46373252788146757, -1.2229167812416397, 0.7151572064852755, -0.8454688511159039, -0.19031853972882326, 0.6241413055341368, -0.6625005829368696, 0.5736117296363284, -0.6753271878631391, -0.21703789230817572, -0.7623829452420596, -0.560510808913941, -0.6883010598668998, 0.8387617248653835, 0.20222904116731383, 0.01148298080010218, -1.0772832023738999, -0.40676484462687323, -1.049546417813582, -0.49476171408539116, 0.8702331306242199, 1.0686762173800037, 1.191957744907273, -0.46310553658414527, -0.2567610394989929, -0.4247896668801888, 1.0133970824202563, -1.279761500533661, 0.5214926402943748, 1.2994167884289436, -0.8100353002821636, -0.7792842741181243, -0.9948306571956701, 0.042330374578756706, 0.712627140295879, 0.6138522179615532, -0.883094276392999, 0.27097652368382075, 0.2697718203913704, 1.0195507354488038, 1.1092339142990257, -0.08416837525639503, 0.043797431091641886, -1.1057332680445995, -1.0461331921837753, 0.9900355210886738, 1.2277656198164346, 0.10346200042073603, 0.30921041982491665, 0.9324801418640604},
    {-0.7772250712765929, 0.8544845447406019, 1.4032059298853934, -0.3241801820749287, -0.5886660688547275, 1.3391994830821619, -1.068080088991717, -1.0802855729470833, 1.037308123782847, 0.43697614034701693, -0.3064224952504779, -1.222787578865005, 0.08985397668001228, 0.44055443295750546, 0.4658559225265289, -0.45385481350164075, -0.935112508066016, -0.10200152728877716, -1.1247996630367025, -0.9063616614834101, -0.828735819668769, -0.3057206923332145, 0.2777220064673558, 0.23083085401742928, 0.3238734678920759, -1.1255879274885805, -0.19029409151259186, 0.08727084081466718, 1.1105786853729442, 0.17389071758607214, -0.3864721781473132, -0.34828213349473963, -0.10823059872832597, 1.0436930157424589, -0.4487350992119183, -0.6106690799577139, -1.1806515457116842, -0.11822425035892377, -1.302406991607139, -0.6990939174026466, -0.7792757384943929, -0.7349862505304051, -0.9111245015283422, 0.6438242611045103, 0.000302028085802929, -1.0130978984908876, 0.600699323801012, 0.07574819477103256, -0.6940299982899171, -0.06234489828956688, -0.6082793717529172, 0.5574982987784499, 1.1014317202038215, 0.42021076256814494, -0.222394178249485, -0.8749972747171197, 1.262932934301702, 0.058621849809602875, -0.8030307226926076, 0.5802440177374718, -0.4630376469341547, 0.8961177541513361, 0.16847993306376388, 1.0876295320624638},
    {-0.4341864496807421, -0.36164991509115463, 0.48709744545269507, -0.9132228052442626, -0.8603328424114037, 0.5489175314227249, -0.6344466467465937, 0.5194267688899302, -0.16122958544677557, -0.7287226625069188, 1.3024955924433936, 0.6674071457793925, 1.2415713734974807, -1.1372814751751015, 0.9899926569552943, 0.3643869465455928, 0.39288797439074463, 0.7214168656647877, -0.1473926587824271, 0.5263460078796014, 0.23493319998166678, 0.3684825271819106, 0.7169820929787112, 0.537704087783901, 0.6456407393388695, -0.18081351979007645, 0.5406659964550288, 0.35788146649115943, -0.7700304095727963, -0.5960794066499084, -0.4385109506110472, 0.35784607023044973, -0.11721025775892625, -0.7061086870589616, -1.0075101438035132, 0.42469244276761603, -0.6852369562539203, -0.8064874108832641, -1.009853397599561, 1.0687608454531277, -1.1080079812519943, 1.02618220920216, -0.6922316162165684, -0.9879774135189624, -0.792180310527271, -0.6483885096804962, 0.1516212090387117, 1.103155754192544, -0.9707072887654159, -0.6529489752282869, 0.6840932975773657, 0.3521662580765814, -0.5150928414175965, -0.9086071749196418, -0.6581009471503344, 0.6803598584908052, -0.40081593321062714, -0.3204925375362943, 0.5345600665158841, 0.6681026475916275, 0.439567224487451, 0.31701801175588346, -0.17128781586349817, -0.15120867905333166},
    {0.4209485019881542, 0.39534305395351654, -0.38793178422677355, 1.0011385467103806, -0.5494169811532963, -0.1370647161019628, -0.29052183933622067, 0.6846303891197528, 0.9237884047237009, -1.3214807276056593, -0.6898724508557841, -0.031297072064334436, -1.093766371982479, -0.20311478765414706, 0.7843245952114333, -0.7748612492745167, 0.4958089357592115, -1.26493432174978, -0.05146596242244414, 0.88714962229995, -0.7393793150448787, -1.2819563790917197, -0.8237718724474332, 0.5762985711627197, 0.23189990478889042, -0.654983951808236, -0.5015226223140696, 1.370792282588055, 0.393048559168397, -0.19802815474557034, -0.9923976886934257, 0.15540173877079547, 0.2159710204780183, -0.8905289458212011, -0.9406947512978818, -1.1678875948693572, 0.16658626331023885, 1.3397515636360582, -0.3200611181261661, -1.1230863065855408, 0.41388378029011774, 0.3689078064897286, 0.613785641086071, 0.5427332954150997, -0.929805119324987, 0.570794749257745, 1.0413804295228115, 1.0975382556542044, 0.3885015873361673, 0.9258583004389896, -1.1102899654333582, 0.43514093934436265, 0.7131247071089524, -1.045560450047569, 0.8494841529320075, -0.2191305870324931, 0.3227382927399565, -0.9062314556915718, -0.12113927975469159, -0.6821041512665389, 0.4322050648487048, 0.22606168365386967, 0.8522079791428966, -0.07176896917963049},
    {-1.213773460589038, -0.5212561555956731, -0.0795432409872525, 0.24784389390692052, 0.15771513866445563, 0.13931587371154494, -0.9048162599581606, -1.1353025656941282, 0.7454576506378884, 0.13084080307998838, 0.8152361334477702, 0.19967251498178476, -1.1125234559717463, 0.5162464952938451, -0.7121839812042429, -0.08538919369296458, -1.2172221398191454, 0.792921759451052, -0.3571085612011692, 1.0280599032786077, 0.8143189723324066, -0.12354034600959678, 0.8450433999872647, -0.6646111850347454, -0.7615584172520161, -0.418923659210003, -0.6441715948384521, -0.626604322722669, -0.7908867634552016, -1.2934181754129574, 0.6605801627648062, 1.168361675067788, -0.9559651413918646, -1.045644261439534, 0.3102406099489706, 0.9159515530324589, 0.8071634235938018, 0.37062353966010436, -0.5867109654604781, -0.5956598091275196, -0.41956111155418563, -0.5163173622876385, -0.810117889565996, 0.46533567093280404, 1.1470510451951306, -0.24475784882486804, 1.1560063237870866, -0.46233523176438335, 0.30989604542931715, -0.9798692189452185, -0.06750067376478182, -1.229267929310608, -1.1741460416626632, 1.020570494835774, -0.9923391333727877, 0.7721687682553172, -0.11891371038888855, -1.024670867273823, -0.25412910805687794, -0.9579817526336383, 1.090929864294376, -0.455282692524842, 1.041659595175858, 1.040848881167858},
    {-0.5206698297261623, 0.8532603213915136, -1.0315843521768355, 0.9004163489407595, -0.31601949861358747, 0.35331282086507343, -0.5381137922935448, -0.578045965064708, 0.5527568667229852, 0.09816410514187222, -1.2995744380505025, 0.05446169549003794, -1.101661455897969, 0.9034977733719518, -0.5521178333691007, 0.04515067474002958, -0.17996361821926646, 1.2233353290326314, 1.1218711829040708, -1.1384634017211088, -0.17018154320935322, -0.1273050291632707, 0.4562069878506237, -1.1130217066434396, -0.98776970772538, -0.4115132730505752, -0.5265722094264155, -0.11330842931759479, -0.23565984658135003, -1.1268576149437415, -0.9627400992289024, -0.42094362370980387, 0.433441666579108, 0.055208590339839575, -1.21499100681799, 0.2651765388621064, -0.9652478662402283, 1.00347521307677, 0.42560306773452444, 0.30963332311746117, 0.8956248225864745, -1.2759202900210007, 1.1217115157684399, 0.3078204538161396, -0.06252164859422751, -0.7648423472012496, 0.6200553248607293, -0.7713145945886526, 0.3775495701641692, -0.3974760401098289, 0.7817344320597167, 0.5283770365138613, -0.211528848410272, 0.26656476264865075, 0.1405539266531907, 1.039539896996777, 0.5400523392599604, 0.6002598225679707, -0.7031735853015674, 1.2265787492056845, 1.1356993641807454, -0.18444544904399185, 0.9419554326717836, 0.15271767855121765},
    {0.9425850645400171, 0.9510112960137773, -0.517440660206999, 0.39995031463021624, -0.3630440002138939, 1.1338951204174637, 0.610228933617826, 0.4645145216237898, 0.08637401813694927, -0.9782761034894042, -1.001068119035925, -0.12232130522126129, -0.344288734522554, 1.032870032189872, -0.7490297942601174, -0.22538802591266086, 0.0931901011982527, -1.199424746669427, -0.1809815534417087, -1.2701317663383385, -0.6771015643356358, 0.4802773336225939, 0.8484623010627108, -1.0692584927774438, -0.3966091307543942, -0.4903186726288654, 1.072656479979918, -0.4958166628915451, 0.5502277571363521, -0.5615015880266983, 0.14869394390897542, -0.6811267175603307, -0.42751909121993303, -0.4904592925152499, 1.093340382173532, -0.23019400510372834, -1.106714848060756, 0.8947836034512205, -0.6064655712493717, 0.19566486267941025, 0.16337347611578715, -1.0626394082569468, 0.8627838621803925, 1.0682292511407534, -0.9395855967687939, -0.7263852847410851, -0.2634472957717651, 0.008070808130026445, 0.36524063173617594, 0.5347221007459834, -0.09588274241837479, -1.1584867474259013, -1.3262998253922065, -1.1482638043788695, -0.2517888600693449, -0.12119187975087745, 0.1421033955134099, 1.1411299669014863, -0.8618679059911846, -0.8083548312314991, -0.7357016404209233, -0.7733602401623779, 0.4907019007852122, -0.3985659756209163},
    {1.1122386882956263, 0.5655914920700938, -0.24664678428340384, -0.4020643593493118, 0.2913422428297912, -0.25664769606833027, -0.1189233157479856, -0.5454109054303979, -1.0058813601144332, -0.25013270328393683, -0.4149866549981961, 0.7883863755048417, -0.7174948689198477, 0.9179617748004761, -0.6861686450863425, 1.0696476295756994, 0.4587256014370954, -1.2109495489742543, -0.4330147521631376, -1.1440071227818773, -0.21466435028248457, -0.66518075280171, -0.34753573685955214, -0.5370611101442964, -1.286027628121281, -0.515326449268877, -0.045078994171722134, -0.8259323561071942, -0.33341911487331494, -0.24201291731855754, 0.509078119084709, 0.5424286259238089, -1.032004589938176, 0.06250406243874083, 0.6426362695686562, 0.901361437581365, -0.5443136252075381, -1.2028059970661529, -1.0882586698839682, -0.28090852835024743, -0.41721563513357773, 0.6592718882132772, 0.5565916395471905, 0.534040937178723, 0.9854577867304062, 0.6811412843457937, -0.2005475148278427, 0.9923371071156433, -0.9496546856481681, 1.0382611107077802, -0.7012017634310316, -0.5194080851839162, 0.44786816102733207, 0.9785131462629627, 0.8460214218946472, -0.05837265858186684, -0.4070253340415844, -0.6175938305299243, -0.50445049916202, -0.588263905985084, -1.0608318136791477, 0.007610532598781374, 1.0792468669494644, -0.83067276681728},
    {-1.0092528867232429, -0.8041500186569553, 0.16848193249148155, -0.12375989066888105, -0.8123063434560689, 1.1672938280330163, -0.5006398061428181, -0.7450324789195141, -0.7751819136766649, -0.9161864928456074, 0.08185166166850376, 0.8549202408938458, 0.7018332330566442, -0.583354148389624, 1.023193494885806, -0.09877713862266708, -1.2373295841304437, 0.9035060855775865, 0.013543695313416097, -1.0768838636778477, 1.0580978101555245, -1.140702893865551, -0.08292474298990692, 0.015473002894733466, 0.9891625743895025, 0.4650412786202789, -0.49935907070976043, -0.3130026509741067, -0.8243665650961965, 0.5441858772412341, 0.7423183614245519, 0.6159420060510197, -0.8515252282425334, -0.9506997493224678, 0.49037379701115463, -0.31892199353519374, -0.9013274648633748, -0.9957148960145425, 0.5863920194213949, 0.2109105689395226, -1.075654692763877, -0.9173773907195174, 0.08697360814588155, -0.5597382765357122, 1.0286390953442583, 0.20098734832626594, 0.14094392679852025, -0.8795975070109501, -1.1118408162436768, 0.7662471559167146, -0.6245879636047682, 0.16166510534511142, -0.3643428342061566, 0.6521384514640961, 0.9141039058281331, -0.37981393600383584, -0.7876299661207934, 0.7690984258041259, 0.3458577855597079, 0.0400447530838753, -0.685424848766139, -0.8213426707545911, -0.3440901168008825, -0.5550665772676052},
    {1.2258290759131174, 0.24626531317917397, -0.05735792220258287, -1.0822928079839391, 0.6576951382020526, 0.394929037563174, -1.047923448715373, 0.08368278609647686, 0.9105665659730848, 0.11851710331940774, 0.5476074012177379, 0.3017202483493188, -0.8361691055901548, -0.12573554808681126, -0.8674850002491896, -0.7320845115316471, 0.41340727820107703, -0.790393121430526, -0.9979197497359915, -0.6020116758739694, -0.41585684743026546, -0.17935680762821965, -0.6288484970450458, 0.7995415263650633, -0.5034591567867451, 0.7127958510572158, 0.18965675087263606, -0.4348099142903488, 0.05221563442467773, -0.9797438187289722, -0.09766186589126025, -1.0241987897660836, 0.5730538058273251, -0.4066819794039798, -1.187973842089903, -1.0764643534645981, -0.36238143186550886, -0.4279155480518975, -0.3279964624691, 0.07633460094750522, 0.4246248218886154, 0.2736902733642183, -0.6618923896703459, 0.7527827334270766, -1.0614728232518889, 0.8877589887938422, 0.511003788504284, 1.0551608986968055, -0.5512379558566214, 1.1483730568202497, -0.5559352966908211, 0.011284844989620898, -0.2596436105683812, -0.9764843181885459, -0.08696463164193434, -1.1395948418690165, 0.5571823021575527, -0.659049808622074, 1.0772906541153568, -0.7762968232654529, 0.7139350105002904, 0.0149489176381665, -0.00851650108922411, 0.3508743453785014},
    {-1.1884275475893729, -0.8468804003060948, 0.7510012640067357, 1.2360760252878558, -0.47283287262820567, -0.6318821912319361, 0.3821722221843123, 0.71484458303045, -0.3938735622779053, -0.4651914988522998, 0.5787205879532575, 1.0006136897909985, 1.0017218053015862, 0.21629237847206484, -0.21905542351503127, 0.2841333924048743, -1.029283827450467, -0.6507824738828416, -0.08012652568109462, 0.8284440947508971, -0.8310242597264377, -0.9033342532874983, -1.0809610965036744, 0.021909488985565394, -0.07481077819884374, -0.5047334151122516, -1.119936677792612, 1.2024778418877358, -1.0693413540035022, -0.33113200013420785, 0.4348075399899799, -1.0833137720027908, -1.0641196951800547, -0.5731697472496253, 0.6514577720975416, -1.1651865760096474, 0.4388965856095858, 0.11970419738522523, 0.2661006119326749, -0.9456032471526378, -0.6413335299553292, 0.1326916805572935, 1.032759642785968, 1.2690337187414595, 0.5394409710266814, -0.5341288393702601, 1.0045304639865258, -0.05930138860749467, 0.2524415913426789, 0.09277523229936376, -1.1836135012063134, 0.11157740322790446, 0.13434793189573518, -0.442226696302574, 0.4757256881798454, 0.4875272291747197, 0.5914599369798973, 0.3908254256019154, 0.0855947168537672, -1.272881771010469, 0.12757269818542408, -1.0678410810653087, 0.9910636716728874, -0.6202367044207834},
    {-0.47325248359934935, 0.49632215842627675, -0.13718738335164848, -0.16638898981216116, -0.09954878706096593, 0.790443176288659, 0.6888654851934483, -0.5456532095502035, 1.2501509478148278, -0.7027312635172882, 0.8490625301580511, -0.3890375934192466, 1.1330781849462022, -0.9206836926801917, 0.24388733199940946, -0.9678581446321312, -0.8180205003166741, -0.4426788129110727, -0.6388362710290024, 0.8433086469847568, -0.14681139345812727, -0.46449524190356184, 0.5335648235023763, -1.0898400051781887, -0.02101187764209941, 1.2429204426392888, 0.19992450188394736, 0.5748808892185083, -0.17167208851023225, -1.1365580113658744, -0.20641068031884233, -0.5470089550414958, -0.5697778321769956, 0.7959885522208738, 0.22913795056581376, 0.6935699192818701, -1.2987111209088738, -0.16948214053094235, -0.5943563367216964, 0.47080485301729535, 0.38257867799659956, -0.9085498182139503, -1.1420997862369295, -0.582336000551751, -0.4858410028864652, 0.5975059184193886, -0.1101417438906335, -0.5260302054590956, -0.74095441017884, 0.4408521894941803, 1.0056501017401296, 0.0702740829348096, -0.5568146514328742, 0.12384801461035003, -1.1327610615357895, 0.053576915472634754, 1.1704898411009004, 1.0256002203891215, 0.6972597074042818, -0.2011322155208751, 0.6876401216760397, -1.0616685356213813, -0.6813223035040642, -1.3040665299975234},
    {0.11980324930029498, -0.1269428639949545, -0.21568937658039034, -0.2715304388715695, 1.1612887190532792, 0.33661722755718415, 0.08349826590208209, -1.2927792731768295, 0.3977970047077592, 0.7994393548776613, 0.4751928116639579, 0.6301826994850618, 1.2381466054134613, -0.15164592497464238, -0.38617674832554083, -0.7779770387705282, 1.2770655475912371, -0.9534638992528107, 0.5191597901895784, 0.5101927582083248, 0.5439044208969388, -0.4455515394608202, 0.9619729832974927, 1.0946951079645997, 0.2952649210945572, 0.781355174450927, -0.34112675917509394, 0.7374843852839537, 0.1482515105544576, 0.5122108182497269, 1.211104611189069, 0.037904245982279955, 0.4997442764416097, 0.47221050901501244, -0.9452773770763244, 0.3345902619668283, -1.2215493602213332, 0.16174415184822216, 0.5174904374678798, -0.025564410269259572, -0.19955021268048892, -0.40580934717173694, -0.7116749389353307, -0.4100009538366044, -0.28205310367630054, -1.208010315097986, -0.8611880716474547, 0.8996456662929413, -0.6531997956599079, -0.8221405326389585, -0.2583082477418333, -0.9829556677485778, 0.3459513200057704, 0.03037010855070581, 0.7017167347544929, -0.07949674195262312, -0.5065280789894472, -0.6388832403088492, -0.21880157893865412, -0.5117791160983499, -0.5842963013147052, -0.2566982235813804, 0.8997248054573258, -0.31782420248578247},
    {-1.0281057784892038, 1.1367248087718411, -0.7551703598287032, 0.6468633204146569, 0.11407031586411044, 0.6119498876059242, 0.24605657896376795, 0.43728836801312915, -0.906299237300042, 0.942377630200808, 0.5513194395061635, -0.8630234749682402, -0.57631761660152, -0.12169764147417166, -0.46308049982343574, 0.9628405055002895, 0.07174374722742437, 0.010727404155712621, -0.48123096883287964, 0.48467698063300363, 0.8990844397458602, 1.1224701294307209, -0.3269088353493083, -1.2307133102647836, -1.0078683722003567, -0.7285505302528985, -0.3213900375252472, 0.9098085096866902, 0.838319022301223, -0.1174159181867629, -0.7403824881425688, 0.47759781246925065, 0.6604168833287087, -0.13042636983351277, 1.141609047002625, -0.09678023770723594, -0.6133321139732095, -0.6499945812982546, -1.207531344171867, 0.21019724940316964, 1.011175310209723, -0.9291585423489865, 0.6704223665056487, -1.2537517002288499, 0.7993948339767277, 0.5749108817318319, 0.14492982540828114, -0.08390459589844645, -0.9313762485194617, -0.036027181277122455, 0.41943591475536335, 0.9535883281134698, 1.1547669101383662, -0.5474295692700942, 0.31114418966651414, 1.0528174903405463, -0.666608056874818, 0.5195766420775083, -0.14700418797113893, -0.4642180346953463, 0.8918385865183243, 0.15372342798134664, 1.2030165753212412, -0.9324921694266886},
    {-0.2985888719373953, 0.7327961313183742, -0.3731870167612507, -0.7131616403397644, -0.5733790112066723, 0.43919704137692506, 0.928250296530687, 1.02315808277348, -1.3926972892462075, 0.777881077117781, 0.155079882408092, 0.09133307478061366, 0.7029682324097539, -0.5881180070593208, 0.9246919437455496, 0.3032192696756572, 0.38583313938852154, -1.1764455628952664, 1.083534270041865, -0.18776217779910961, 0.05574296248096649, -0.6888700081517829, 0.7732442024947414, -0.48476945130326216, 0.45778707543076763, -0.8135593924832913, -0.4976438639482082, 0.040919731090482546, 1.0632474017801143, 0.46884660370305203, 0.23682550249223405, 0.9963885660432527, -0.0441760803693689, 0.9598217667350724, -0.2338509864272534, 0.3369730443374715, 0.35500757103832775, 0.17032604826702966, -0.5882098142227342, -0.14874656172850503, -0.8251960308743513, -0.9207691188602013, -0.4378369576820931, 0.4273267602297037, -0.7440277719515442, 0.22528676861434113, -0.6584114223320835, -1.0103740699574046, -0.17171604746117997, -0.4630615860751621, -0.645073117784792, -1.0495583184085147, -0.5000121874842595, -1.226188142253502, 0.8523797968196044, -0.016683079631841975, -0.2813603583135221, -0.838573540449844, -0.7557845684308904, -0.2894512777287861, -0.20040311209862055, -0.04140723600545204, -0.8238019415278511, 0.301675784685168},
    {0.6394384748763128, 1.179597320030477, 0.6482335268797906, 0.12467881206480051, -0.6716483170740575, -0.42223344412897784, 0.29001215021549626, -0.3899052722225734, -0.08526145615792068, -1.0079337623821056, 0.0783016196089023, 1.054907440313859, -0.24753978008598074, -0.2564262356518571, 0.09503102895463258, -0.7518260576296306, -0.26500824886060126, -0.410005853925883, -0.7570244603972166, -1.2572942614552027, -0.826567415770501, 0.7082357209559754, 0.17672932089631524, -1.2687823879855726, 0.9610927903106546, 0.012151351679005886, -1.0353539285969173, -0.6694223494414531, 0.8507387396838383, 0.8271688892288347, -0.8081972635776484, 0.3117955267757683, 0.8179681835768824, -0.6270927849647223, 0.26300546813910197, 0.4640348936922151, 0.8106947058716288, 0.8482595021151592, -1.0866825454562734, 0.3661719332739238, -0.9376254225854, -1.3289145373836997, -0.5552962757630439, 0.6735136699502123, 0.955166709713353, -0.13814927714155006, 0.7722341040725238, -0.25306556185918017, -1.3584799668589909, 0.18488442776731331, 0.1853815850655454, -0.4733418655053646, -0.48504625691001807, -1.3127890511206677, 0.3933122699624144, -0.6563117717791059, 0.06395357479492156, -1.305668177180669, 1.1273226727086396, 0.5376048660852555, -1.0527173876123939, -0.3256979299520495, -1.0985325638460504, -0.6290268791325598},
    {0.7882369718120195, -0.9011313579806652, 1.094774026296294, -0.7013138122561029, 0.883150639927611, -0.6672847337613844, -0.220206277992365, 0.3880085836418679, -1.0720009018258512, -0.9171413738412363, -0.6530614201495153, 0.4842531113672732, 0.7560050471808285, -0.7524248563855076, 0.9159873376646834, 0.5304325449702637, -0.6606067098617581, 0.9180940029017842, -0.003013545266218561, -1.1698848969360975, 1.2505019399163024, 0.20391028749049936, 0.9860951089935133, 0.9689111815022428, 0.1948603992777913, -0.3408743401181824, 0.10357514103389708, -0.014602134022809287, -1.0884083377576668, 0.25429489213270173, 1.139119849477484, -0.0071178368234967124, -1.1227549978702414, 0.14050249219691774, 0.9461866910764954, -0.27395676129400615, -1.2713672611433324, 1.0376708790361135, -0.9541056795173551, -0.7916477457403092, -0.8299396539533385, -1.2101065785524614, -1.0506708522542327, 0.5686664763158743, -0.2933093053713567, 0.04030141189890302, -0.8331630336379895, -0.21796074484294062, -0.6194401042897423, -0.7784996587943993, 0.7657136121334961, 0.007272684438224675, 0.40213536556367724, -1.2708287540975542, -1.0302350541175886, -1.2581806074100061, -1.0889482696690185, 0.2335825409217665, 0.07688287993398395, -1.227129772094287, -1.365487477466382, 1.0260668033454174, -0.01846030771706311, 0.020959191571689146},
    {0.6889847183188067, 0.2562389767836858, 0.48891434834915876, 0.2800116078412205, -0.3928382986355164, 0.8761812554053259, -0.5385169492345288, -1.017930516539494, 0.8783218513905929, 0.7005470236466155, 0.25507119452293364, 0.9365078338668698, -0.6473022151326611, 0.5629056514384218, -0.6122566071167876, -1.0582794425369437, 1.1945298414940495, 0.790840265693572, -0.2075368803642947, 0.5597084955459953, -0.33786303796679146, -0.8928020081352297, -0.5017968873100978, -1.360581371267315, 1.130513557592118, -0.23986303373568402, -0.21030438334317014, 0.8521817347064354, -0.15038899098768815, -0.7949244886771061, -1.0213752768393194, -0.7865059243464612, 0.5065172279706509, -0.19540956847985386, 0.8987436293849542, -1.1815011990042554, 0.5409877511993773, 0.9925255898758116, 0.315623671712676, -0.49207900064944543, -0.6437267355798596, 0.5296509718779467, 0.3961294535355923, -1.0069062994575477, 0.07072174957140226, 0.7197210796871103, -0.14043009682281996, -0.4725434871902123, -0.9001600684873, 0.285800092200458, -0.368563384538678, 0.6494834372636092, -1.2206232423904857, -0.386495618447694, 0.8618391539524926, -1.3854562973317714, 1.0968488337654938, 0.7119779892718018, 1.2392872902454244, 0.42052839319671764, -0.1543682530971444, 0.992702455142727, -0.381659520883306, -0.06493235563414967},
    {-0.6220411920594104, -0.1725359745825574, 1.062828300304632, 1.0261726905190727, 0.6871147739474608, 0.36559441267879444, 0.754954441884283, -1.1882706973351893, -0.6039642993091957, 0.27294565542547017, 1.1716849675035044, 0.46786852629277, 0.2936408318242747, -0.3601736756039627, 0.19570242423695589, -1.1411247729035265, 0.4346431712930783, -0.05423574290304357, -1.0290756106513157, -0.16194235986738564, -0.1969635125931301, -0.42917262529049366, -0.19004326538166808, 0.16676650004982957, -0.1929009517910063, 0.38175526404864046, -0.43537415345468833, 0.20032374161226998, -1.1875541307995023, -0.8445590432421138, 0.46021054696915953, 0.6536114652905526, 0.8185272260992801, -0.6397425244837469, -0.7148838095879433, -0.5901184592133961, 1.1132050804739926, -0.3860609045136453, 0.1938554036901866, -0.10002293319627871, 0.48073797871896284, 0.024028398904684018, 0.3734777460888636, 1.0660410333850598, -0.795732842659053, 0.585530856316988, 0.9813071818853333, 0.6885054805406722, 0.6626205079732603, -1.4666529339203906, 0.5614080144149641, -0.15700953055532096, -0.6038221885413103, -0.7208296637700768, 0.1342255911601034, 0.6551079981777331, 0.630503580450586, 1.1387685571155421, 0.7375123360682403, -0.7902407012692988, 0.12922185397843586, -1.191356349364783, -0.4791488008676772, 0.09544799275669863},
    {-0.986452217627264, 0.3654697889443228, -1.178446519624996, 0.3814266999420581, -1.4062103475573986, 0.7201624474553994, -0.6222597657828258, 0.7117209768777728, 1.0115679398741348, -1.2553444840455235, 0.6786159489801352, 0.05884796544737799, 0.4965354025396737, 0.6097782862303909, -0.05035861648358314, -0.7463288094785724, 0.5941800928949976, -0.9141191910450773, 0.4556464058711707, -1.2711821218884014, 1.0025191164222418, -1.1287078182689918, -0.27115393562016665, -0.7058745199652349, -0.6436194604949766, -1.0840757526758387, -0.7327543912783756, 0.6030922041742586, -0.19705104347827673, 0.4915901607873256, 0.27298390829010466, -0.4581022020665107, -0.5875647970059087, -0.5828075260398768, -0.3310860279440377, 0.9475586625464877, 1.1636861464987849, -0.9546692050037343, 0.24092319909951743, -1.276173722866919, 0.256015981894534, -0.6521455830141469, -0.673821447197921, -0.751450920790332, 0.28172837871719014, -0.7392885764205064, -1.1056725438299781, -0.5814166050747905, 0.2511330856965653, 0.6259869860543865, -1.1719977944485291, 0.12732282292921263, 1.0524215102118781, -0.787983261910597, 0.7722959773982828, 0.6904307936089583, 0.9599398686871502, 0.06709266807620935, 0.7480958590512844, 0.02260274492974462, 0.5066601200197426, 0.7555272774354084, 0.4585330873053517, 0.8488368835397725},
    {0.5895677968737011, -0.02715172548145807, -0.7458110524478554, -0.1708005030352616, 0.5754273549359484, 0.17440748463286646, -0.25100715671175716, -0.5741428106093196, 0.8304726283584594, -0.3118647696182452, 1.0107406473675324, -0.10585324419040064, -1.11061123109752, -0.9211813164552333, -0.3139514764796416, 0.5209217534398093, -1.4465775940075325, -0.39957994924628476, -1.1306162165451958, 0.273085728762655, 0.8424868587442645, 1.0507640463774226, 0.5210137765231588, -0.3155806781629143, 0.7055471893809228, 0.8445167997002622, -0.7252654427801011, -1.1233474089806308, 0.6483804320603097, 1.1444541981339618, -0.9177109345729002, 1.0930506894807022, 0.5360295440057469, 0.7978659210026512, -0.8160754219133697, 1.0010741294927183, 0.6334889936608326, 0.7882380853125245, 1.0900894026597197, 0.18870021959931849, 1.1100499207422194, 0.772584323386978, -0.9820929000739801, 0.30839829356239146, -0.7308663335989718, -0.7016306666452713, -0.4492129110616155, 0.02108288031473901, 0.0009579255864165251, 0.37317844597836486, -0.8442785292487129, -0.5770839563891076, -0.8601226702843796, 0.714005299223142, 0.07203040410538336, -0.9165604876583526, -0.9173764791453435, -0.2606624337574721, 0.145134053687387, -0.9782429164494456, 0.8092550744682556, 0.6084102072844373, -1.1169393281099025, 0.47409119567350383}
};

static const float b1[64] = {1.6123758238313646, 1.334221197433246, 1.4348497423042659, 1.4601423314018211, 1.0399095968031684, 1.484945865534298, 1.2262110293919641, 1.5565993988354638, 1.5334997076140044, 1.4698064382017095, 1.557794297228196, 1.561699943942039, 1.4881360101526293, 1.506612917756393, 1.5348772562883173, 1.560577406866669, 1.5123213923143604, 1.4833318164848257, 1.5563329918352131, 1.1774893660936445, 1.4563945644054042, 1.4142669099138259, 1.428411564713077, 1.3129435484035041, 1.2780275853038932, 1.6068556215435463, 1.0076937975801095, 1.6107516479953399, 1.0690644545679449, 1.5581365089375718, 1.514552653685795, 1.4598313092959772, 1.1274605728924008, 1.3025949096468463, 1.4027366380803665, 1.548846900381669, 1.4437008783818843, 1.415916712188058, 1.4382887067578374, 1.4293662281083483, 1.1408139247032172, 1.4932274866436612, 1.0833626940892576, 1.5903104244405184, 1.2718998841045344, 1.4197301047875497, 1.379098405929787, 1.320061583369821, 1.5631386710100792, 1.3904682020597288, 1.207389998263632, 1.391323790819357, 1.5672672261759963, 1.4872911970856766, 1.2363869221036285, 1.5633423496460197, 1.383026874681539, 1.544512936537679, 1.083749876594424, 1.3576302790980113, 1.482859115267292, 1.1957415538156113, 1.4908620744204208, 0.996556093093215};

static const float w2[64][32] = {
    {1.2532190026347618, 0.09156728031479251, 0.4167579570970065, 1.7567237011624475, 1.6187905342261182, 1.0553881801081906, 1.790343088975714, 1.3460895139736422, -0.7519000054468399, 1.4633886828592022, 0.6845098564273603, 0.8108718467054543, 0.5993557577398356, -0.1901638292375116, 2.089195330107338, 1.9533705699481378, 1.908471356222342, 1.3601712656083522, 0.9155320975918735, 1.1737260331405848, 1.8804189160885225, 0.9069975888460332, 1.408725862092947, 1.355495666242072, -1.0200516745218184, 1.396752864738183, -0.9132565192599243, -0.822821317127213, -0.22540926498498565, 1.2713094528999023, 0.46289396924348086, 1.8400673844265663},
    {0.6993269531609968, -0.4916656247580623, 0.9263088008711883, 1.3588492360345121, 0.5239299538754245, 0.47316566306763874, 1.9868457586192823, 1.3306475911448674, 0.7079806984256357, 1.1425592166983063, 0.26906097656049377, -0.5280451207923472, 0.5096719088093572, -0.23947422719275122, 0.39694948829023585, 1.6384804118765928, 0.9136432096064693, 1.449786249277624, 0.597315202237347, 0.7951211110797995, 0.42715570649166906, 0.3012324144642068, 1.3729763380134885, 0.8233866657990766, -0.5952940933008231, 0.7317288320626604, 0.7502832166869887, -0.17243197611078345, -0.36902195288039996, 1.78196813270308, 1.683187417186815, 0.6456721853724366},
    {0.7834443299136762, 0.7654549124591188, 1.6025380491489503, 1.8818644868307708, 0.7861969517747925, 1.8029050206493762, 0.8642337089155923, 1.1936951427669813, 0.15618441543173853, 1.52576191671243, 1.5981912803012088, 0.22510928690275644, 1.9199231779522639, -1.0168924111308455, 0.6983696499088025, 1.8544597583304747, 1.4769810442077975, 1.8563681977671396, 1.0345343331422012, 0.24167035354571131, 1.3640088329210172, 0.7089257499431814, 1.1901071753428478, 1.6339229544194094, -0.7834727093488679, 0.058998532657188484, -0.8856435589765622, 0.3141719764913385, -0.9422093050223137, 1.1381170164411065, 1.4999231657081904, 0.5935783624392935},
    {1.7184483866464328, -0.11115283302940987, -0.07314133758659858, 1.9530373117144821, 1.4745611916562384, 1.6953619208085375, 1.1320161565270008, 0.42630560243483284, 0.5130188941881981, 1.990949508980607, 1.9544106147949074, -0.2122743520393774, 2.0519193869202836, -0.5233085487981343, 0.5916379823677146, 1.127596472975915, 0.32797993892756705, 0.5777411392125841, 0.6566030823400553, 0.6542558302746857, 1.8536310168416532, 1.978899821324809, 1.2561267406240089, 0.618882159378047, 0.46005979754305715, 1.0544398214461703, 0.44667848021480333, -0.7826539020002276, 0.5516135181461944, 1.7035595077956296, 1.799459542511097, 1.0612220118044993},
    {1.0586085383538806, -0.46670156166062404, 0.9069980352797863, 0.6981202440377039, 0.6839910390528348, 0.1696512980091789, 0.18990158140085917, 0.3964696153895714, 0.5032582783922894, 1.1382655691882346, 1.2846287770540685, 0.4938395702721585, 0.8086496337813018, 0.715705139497007, 0.61546605662196, 1.7574891781787076, 1.422472369334987, 1.9544892079627059, 0.18826105652016906, 1.4366589237793386, 1.9592861533607575, 1.0648441288656607, 0.09924084650421214, 1.3271439914060037, 0.1639002516745086, 1.3855721508378251, -0.7399178001473555, 0.5138395158464114, -1.0369336103051099, 0.15347825664183848, 0.666532403116985, 0.766165076696411},
    {0.7542485492212341, -0.23188697173962422, 1.555426529971002, 1.5754535217883727, 1.6496808858527423, 0.5115580603215159, 0.32170147988257436, 1.580932370812021, -1.0112325708248393, 0.44061643769112396, 1.5024041453954824, -0.7212701415898899, 0.7750790341198155, 0.49202627081401934, 0.4460796154873851, 1.2486892616942793, 1.7112743223577875, 0.12506683420577397, 0.5811277658083756, 1.5985840061034284, 1.8687586723952738, 0.269983092805155, 1.0661241687828549, 0.8860650338883784, -0.007550356161029157, 0.41251077900811833, -0.36766794447325657, -0.4400374921537343, -0.6960676846267712, 1.3407584039016456, 1.231276942564301, 0.43815799706200026},
    {1.8584407958070936, 0.3707863327139912, 0.2726134873893433, 0.2532789044075841, 1.4194780456886547, 1.5943366649539046, 1.094351493034509, 0.8647541767147523, 0.4848919213187048, 1.1545967820813154, 1.0820282567825503, -0.08868954871618666, 2.0062551022266115, 0.2250647521171455, 0.26476330241180934, 1.523601552626694, 0.6431981414363438, 1.990078369334347, 0.9532040755734781, 1.6641549668409006, 1.4170052068147887, 1.1932965163746754, 0.5200596238215279, 1.2137790213886548, 0.46554584385104536, 0.19128191904744968, -0.6751143769375186, -0.6214500877372963, 0.40075450792055484, 0.30347182184672944, 1.56784084957642, 1.670905594740038},
    {0.3562622604756273, -1.008082149237197, 0.21916668727510635, 1.0793468496831082, 1.4656657313632977, 1.3571893135576738, 0.207314362093294, 1.8692435002419472, -0.22125992348090706, 1.5528590203698995, 1.6794853850995919, -0.2415442303346736, 1.8513476537352294, -1.0235273524645567, 0.7960145914584348, 1.0056635594180676, 1.650803650600865, 0.26112538602418417, 0.5592547289995714, 1.6547918917502125, 1.9408546180808126, 0.49842068127733263, 1.0350491865098619, 0.7142104424969894, -1.0392796683979733, 0.8367321740492037, -0.4326285627438504, -0.9257933782157015, 0.32649285895481567, 0.7743707779192547, 1.3798691644989802, 0.21185079821547742},
    {1.5472852039545515, 0.34267666594501983, 0.8848156298547396, 1.5435708663762104, 1.0361777734542574, 0.7422943520934077, 0.5251236771664914, 1.7748690115772554, -0.7099814032831494, 1.8790326919588585, 1.6022825881856242, -0.9579445991324989, 2.100407956404039, -0.94812442881107, 1.9063709310471484, 1.0498920424543259, 1.1439718365808291, 0.2211873444396925, 1.2280018862568387, 0.6368802043028579, 2.081143720629079, 1.018533039658681, 0.4987487782109076, 0.9393857983332712, -0.7445165631261641, 1.2626580176040287, 0.11090420025393044, -0.4255536749720637, -1.0203094421609136, 0.49894774551292415, 0.9476264854387134, 1.87680568704845},
    {1.126213917445085, -0.36582892230449954, 0.5603067911736845, 1.3148745521574727, 1.7045381203727212, 1.513507024928953, 1.070291295851138, 1.9086695301067305, -0.9859236305515667, 1.3817954501611824, 1.8414632941698603, -0.7032121305385444, 0.8723942863317261, -1.0796762585689443, 0.5197720388825239, 0.33504022321165877, 2.0188971968807925, 0.5412878366848352, 0.589588743651653, 0.7419841750044592, 0.5690430730355552, 1.1247119209464032, 2.0166960285585662, 1.100236021615928, 0.5304278668726952, 1.7169296221270485, 0.19040476187312402, 0.12175338563855796, -1.1744703627892625, 2.03562770384226, 0.6382006901512466, 0.7281216009303829},
    {0.9763942640916531, 0.5655101634792501, 1.839684051035751, 0.3929703259141189, 1.8671433507085553, 1.7100182153869297, 1.841206896018672, 2.123695295423073, -0.9774283683392511, 1.4374236460257896, 0.16468789214235455, 0.7567192231020498, 1.1570010113836724, 0.6427504465755465, 1.7498245383919795, 1.5990667948625261, 1.9207408414353793, 0.6409816713115498, 0.8132967615974066, 0.8236604465253001, 1.3575090270511816, 1.9123754275123304, 1.65132529600007, -0.24115565430534278, -0.829764284301743, 0.9482816858769393, 0.18548902562691072, 0.5407721244451388, 0.045135833091932205, 1.2760063259693595, 0.12725556676814112, 0.09947691318515377},
    {0.8515876880566701, -0.014495046383332112, 0.7778314605684705, 1.1825404407387001, 1.712359103675039, 1.0599973342627564, 1.772008106170323, 1.5140832969785387, -0.8361018674403385, 2.133845819653637, 1.1360315830816259, 0.729439495763372, 1.133189481848598, 0.17232517584373805, 1.4476730945801966, 0.20251461480683705, 1.1935432347021362, 0.9459801335254173, 0.6920185333473567, 0.8209198356912708, 1.1079412684760643, 1.7051910183539403, 1.5448723876057033, 1.3084789544607625, 0.5946346101369429, 0.2577056590353962, 0.4299988959053392, -0.37947397055245363, -0.43502857812891477, 1.008118454048501, 0.8632831275459533, 1.9417993213604057},
    {1.0581224934247768, -0.39922731951590673, 0.13547538040403198, 0.6566015385436221, 0.2969716564274435, 1.070927124641844, 1.9936352747999617, 0.6330420804782225, -0.9946231854041977, 2.0761495875638722, 0.6800134920077013, -0.2986981138101089, 2.056642636911018, -0.20747109935650299, 0.8715809517529047, 0.31574626001352196, 1.9977446171211921, 0.0873378439640088, 0.5494498020288713, 1.0026787826499874, 0.4716819587548928, 1.19067025961509, 0.822133868077279, 0.4798538690675359, 0.08579286127212857, 1.7449434550673266, -0.7233419267206266, -0.034160965713337856, -1.074680917273397, 0.35912657268886145, 0.2530115761574153, -0.02211850670386859},
    {0.3630396588879284, -0.5620802635140776, 1.7637905612750668, 0.6978198708658364, 1.8869130499345599, 0.6505981028845251, 0.5363681086351755, 1.3683643314333256, 0.6795816425877501, 1.18926107561373, 0.5012051783763324, -0.7856531817800908, 1.681581907300315, -0.4696864441353668, 1.220126170129714, 1.4222852051821264, 1.3502850170344411, 1.5321076529308433, 1.4414197592566336, 1.2588837660108292, 1.4338442119121815, 1.726279270751271, 0.6315438100262779, 1.0928098626950487, -0.1551089519921875, 0.08394651718765955, -0.030910055341777196, -1.026416987635664, 0.40819391688987916, 1.1061668760549832, 1.6214521611795487, 0.4859476914340153},
    {0.7119443786072679, 0.3667687247661221, 1.2279589060946907, 1.1190092800748228, 2.11327260668823, 0.7224799042871626, 1.1561063792560413, 1.540314423672398, 0.3059291884101864, 0.7130140648524522, 0.7981323367165044, 0.4145608852503859, 1.5526980345450339, -0.7607471310724149, 0.6840076247579596, 1.3663474562993256, 1.3813170393823666, 0.6101047229709333, 1.6240911396782158, 0.39756226500972947, 1.513041244947256, 0.33464652038748843, 1.7164296570202668, 0.7429017882616336, -1.0847912939508297, 0.5782098241782593, 0.5899825039652025, -0.9975414579715501, -0.27597717348315576, 0.8846144371244057, 1.047021928966812, 0.055916824780250084},
    {1.3958702750791325, 0.05543097474812418, 1.525636790095872, 1.8269452695664916, 0.8132964356527999, 0.9856955638843125, 1.8400462780782252, 1.5119207596709276, 0.5843974926451508, 1.8114905779185515, 0.21532485216931088, -0.4012438514773741, 1.5633167631166298, -0.8374890713888022, 1.0624234942928512, 0.8621187720918031, 0.9321246885726777, 1.6236241030924432, 1.0351779321228227, 0.26758727320590037, 0.5036104036010431, 0.8902132322414249, 0.30067552849366985, 0.20254397719206685, -0.09430564689089839, 0.3913695861847886, -0.26890750666209723, -0.3113351956785738, -0.12761691798605063, 2.0359341131372934, 0.8824800455344199, 0.16051543583654615},
    {1.6753274351650724, 0.5052703539746258, 0.26217067931658894, 0.33113840074819123, 1.920799351015482, 1.6446728040378018, 1.3882091328757054, 1.1432393367018698, -0.7318987737087723, 2.0875219053784346, 1.0647562798251224, -0.268057456105717, 1.3224477895578997, 0.3125809973962522, 1.0039784859167196, 1.6265281687732893, 0.24471792118529953, 1.0061060918468356, 0.3854238004273872, 0.9557649344278671, 1.3986139745961261, 0.6015082364533925, 0.9310970718484329, 0.8892616074071306, 0.04655092010523714, 0.9891582445286502, 0.04049780813643353, -0.8048903952346238, -0.7545561981930345, 2.004648594868597, 1.058958679371311, 1.5548859141585003},
    {1.8323532288278008, -0.3332940199698473, 0.0015197877354037465, 0.955738899066148, 1.7207598831644393, 1.1760916037515234, 1.73942997594899, 2.099877797622865, 0.1981779099735901, 1.095866105102508, 1.503756424463915, 0.12382751529581922, 1.9544798422832521, -0.6439186072364184, 1.650652439148768, 0.7845625893488875, 0.861516387943902, 0.5485611719797863, 1.677898095931732, 1.9538367336266416, 0.25451335779492457, 1.0165432645339385, 1.5319158310045695, 0.18357312230602396, -0.6426727925332744, 1.473209316895043, -0.5773463456898206, 0.7262738948159688, 0.2981053702997904, 1.491809055734751, 0.6412804464765296, 0.7578408343404803},
    {0.4554474384982275, -0.02718405452897927, 0.6285930943850984, 1.5955351640523385, 0.41539525803984295, 1.3076052483565308, 2.152931700159334, 2.1748761764286813, 0.6162452920883702, 2.133148224364832, 1.6373319289592483, 0.9270668339913528, 0.532868911809491, -0.5562858316186655, 0.2960880977241977, 0.8949437929523015, 0.6089579597321143, 1.7746889598452191, 0.036781498786388055, 1.8500986179053278, 0.5326068304743486, 0.6399176940984962, 1.0225204970647466, 1.6558017931135598, 0.7804536155207997, 1.0462631693130366, 0.038430854132699074, 0.03580350550378672, -0.6508632805031939, 0.932547458423282, 1.6639350553767391, 1.196552827017567},
    {0.819454547684506, -0.1119291452896771, 0.6320116585264861, 0.4598823911347324, 1.3391502192043636, 2.0145771925658997, 0.1582167514664991, 0.6569241833799332, -0.796075915138006, 1.1010166489201978, 0.7859189294507937, -0.11615317422675692, 1.8958066371932263, -1.0681111811737107, 1.509629700317441, 0.7050273618698203, 0.5700201012073585, 1.7016535129997672, 1.8221891408915194, 1.0540239387340398, 0.3882431999945493, 0.21425081320140077, 1.8275199300470077, 0.7441727003470888, 0.44179748664855173, 0.877656555573424, 0.1576884869790638, 0.23379634171564018, -0.5421555348365309, 0.7384678930830536, 1.9183076335249918, 0.4556344395258369},
    {1.502639148686792, 0.2348088994556031, 0.9445938152868382, 0.35894701129244777, 1.7680961302640668, 1.0557580591911926, 0.8293280621935475, 2.054834374162588, 0.056708945549955946, 0.8328288846697193, -0.016508467299824477, 0.8888377348190372, 1.810734269569958, -0.7784085028253629, 0.21928447270775833, 1.0228970772334558, 1.4343052652289545, 0.17807307730006308, 0.27473574648243754, 1.1970036459380775, 0.3846944705770845, 0.8583281027099388, 0.5382526261465609, 0.7748357762957028, -0.5848097487253153, 0.6179000597046367, 0.19313822962140065, -0.9831069742682216, 0.25611993679412537, 1.2405778798037819, 1.6237424932646187, 1.6923412755468221},
    {0.8142415823757089, -0.27603336074551765, 0.281871989225567, 0.3111321543333071, 0.7839740090514049, 0.19173684919013662, 0.21400911451389582, 1.4119692389463154, 0.6839731974490765, 1.349997627374881, 1.5500188282093135, -0.196820793720842, 1.8836417089420057, 0.5416693929223093, 0.631424668558487, 0.36267795639539446, 1.049593082350333, 0.9160567199930812, 0.6500850169421858, 1.5769864083031169, 0.8655633462327001, 1.4694475410167127, 1.09882266516429, 0.9170058600784319, 0.21320632645418813, 0.744439824521983, -0.5130057861126295, 0.5713557507986103, -1.0791094234594272, 1.4255598593542589, 1.851135060715556, 1.3455446551582864},
    {1.5495821400091805, 0.40840879769878485, 0.17601975198075742, 1.7974303849200968, 2.065556116067607, 1.250975879746394, 1.3156250588159457, 1.4740991074898435, 0.5069718494671698, 1.0450104613008717, 1.8229936339571988, -0.6243320227314486, 1.935737071055123, -0.24829380601223888, 1.8696016016555133, 1.3876137749207396, 1.0737457610546453, 0.2188973848539069, 1.391871999652597, 0.18872162376539553, 1.021828535962361, 0.8647891125609738, 0.6876120625916641, 0.35489658423705805, -0.9601318499689451, 0.4162343469033122, 0.42381128110718236, -0.5631648839408177, 0.2219935327154074, 0.6134736380764266, 1.6602396686718286, 0.7490155236237828},
    {1.4054701043167013, 0.6885044564900489, 0.9490802267899646, 0.5065212905471017, 1.151670029950195, 0.6058148945518396, 1.92820986845518, 0.6921312399929384, 0.7527192816115991, 0.8277141120109678, 1.1038195135057032, -0.0151413796612695, 1.535552798771612, -0.9442175635502199, 1.4911114517981057, 1.334602475588577, 1.635311094357996, 0.44601986932767335, 1.1798134215083602, 1.13893114519557, 1.43192193797863, 1.9442560390539376, 1.6518603759408357, 0.7967965487799265, -1.1043880391343794, 0.6815668072308831, -0.20402621046737998, -0.23814400563459473, 0.7908114939012951, 1.2919263930779066, 0.666902985942708, 1.6348124103690946},
    {0.3367139955528208, 0.8484566177910711, 1.3491798047733061, 1.4180078435793366, 1.223849610818059, 1.7593062352493851, 1.2525841837439944, 1.2422885669110206, 0.695253785833153, 0.9211411306617401, 1.961796129284865, -0.9896243446568247, 0.32706075380618976, -0.4325102183820838, 0.8885924777919572, 0.49290728736348827, 0.9873172477445535, 1.5403529306615185, 1.1199237489417917, 1.2867324584393383, 0.937690975786802, 0.8361600201294125, 1.4489932445103626, 1.1040488915025646, -0.40127754778050734, 0.11349594279054283, -0.5741099758567684, 0.4496363577332385, -0.7202848930785145, 0.819034306834367, 1.7310085077875237, 0.7348025557499621},
    {0.7827144861486431, -0.3987518668056839, 0.43051421937491374, 0.2983403881327166, 0.910573123783884, 2.0140878209256683, 1.311832217107155, 0.9205521310529255, -0.8021936760376099, 1.6708420078479658, 0.2847223282016703, -0.7740661318184413, 1.3459956750024298, -0.8676217143111485, 1.7797994746445707, 0.8884312765627105, 0.7656416749991984, 1.8712398798012995, 0.02231556141190809, 0.7931739598183333, 0.5965065120981848, 1.43575713745752, 0.8213190869277834, 1.0378491181194234, -1.0211927866458173, 0.1768548786831612, -0.8155010261220147, 0.4077929892940865, -1.1013698038433268, 1.884701092490197, 0.774114692672604, 1.348117377987092},
    {1.3355140135148644, -0.24252157132895613, 0.19623972016221022, 0.5455833684664185, 0.26902148381910007, 0.5802476492349876, 1.2872008330665152, 0.677469193414316, -0.8261254226299013, 1.2282639404890272, 1.8098045886165175, -0.34828541999092527, 1.6477518057698526, 0.5545531827136437, 1.5126888793824913, 0.11713902511583912, 0.6308889861790361, 0.6208368384115392, 0.6325833174483734, 0.7143528047881909, 0.24364384855559995, 0.7897932694451156, 1.1354073680846861, 0.20094876665794753, -0.8557128641482682, 0.8349183521011994, -0.22484027670312318, -0.5333600035340217, -0.4301821352631962, 0.1715162112291297, 0.4798757914738514, 1.3508225132034413},
    {1.4162222085235932, -0.31561777150364845, 1.0734767216546544, 0.9244435002534066, 1.5004724354833752, 0.2687223978057971, 1.7069533643405483, 1.2452165971027962, -0.6530779450962698, 2.0973567363285768, 1.3058462892098175, 0.8637560946872216, 1.976333475390265, -0.3802519136610028, 0.32888047365941964, 0.6904473850691507, 1.5082052821030434, 0.9537495801938085, 0.6503050528741294, 0.6285283520637668, 1.6377977943947373, 1.7080731549968766, 1.3720459858749245, -0.18891844410467803, 0.6606524275031355, 0.2655412635923229, -0.17920882747691982, -0.2052368978986165, -0.20409382076715535, 1.8692150466893207, 1.8358175253910833, 1.9007064020337727},
    {1.3693671558106661, 0.21206125331457804, -0.12889611930274442, 0.3709719367712513, 0.8487177949620166, 0.12084883345971711, 0.3298143174420129, 1.0357710496721868, 0.7685327112603447, 0.9152739302453918, 1.4206279090059644, -0.11634506633803146, 0.2956711480603683, 0.8160227143220471, 1.1697575247369032, 1.7551525005097348, 1.5150207149893804, 0.7318096880683631, 1.7768144910189592, 0.6406059115276225, 1.0162537226335318, 1.7008944773084014, 1.7879753895143338, 0.5801139351428632, -0.5369382941690916, 0.8339517563950968, 0.20623218702313073, 0.09775420593095668, 0.4071576339595079, 0.8843558928117873, 1.7300985156238022, 0.47577605879818075},
    {0.4965280510888991, 0.8207272002671364, 0.2667307350297912, 1.8225365167935208, 1.7836137644493775, 1.8578130496234178, 1.9273711371148237, 1.0109199101827888, -0.6565424588919515, 2.0278575646242967, 0.8417295990883473, -0.0917702952737196, 0.21163715453084903, -0.027012697860463186, 1.3710320177584823, 1.0950788323220126, 1.881703556109991, 0.9871033750657892, 1.313717928178337, 1.264264441055984, 0.5174159176012073, 0.44358473378805896, 0.610833025206257, 0.8924317854110131, -0.9811485172390726, 0.5415020217904044, -0.1966406322742762, -0.0926323182765603, -0.6733346781518638, 1.498752605682497, 0.3210034458861765, 0.5442085190195906},
    {0.8722313489664226, -0.15491028546500515, 0.0007771011671851516, 1.8325978927159294, 0.6682463513148308, 0.49499672776042525, 0.9074937573698758, 2.0879338006756987, 0.0828754872280365, 0.5571892534319849, 1.682919985146092, -1.015450116007818, 0.2867579647627009, -0.5159438471855928, 0.743007961404171, 1.5104528269422863, 2.1180021115577663, 0.15325907893109114, -0.11613497694101849, 0.2535275772726952, 0.786761816919274, 1.368172527879372, 0.13262555329537545, 0.9662357358320521, -1.1109201433620677, -0.004704376228636176, -0.940862775801039, -0.3927981485065514, 0.11706948291811224, 1.083717105206442, 1.4832122010210262, 0.9410924503103886},
    {0.0481023952683062, 0.28979756195029943, 0.40292009902252773, 1.6164286865060993, 1.3944359549894703, 1.8364095137952483, 1.2033860802973715, 0.8767851901412331, -0.6010696310934689, 1.3553733337412748, 0.6418292120955164, -0.5953946091832949, 1.9954076310593043, -1.0369906436488683, 1.119421181726793, 1.6513468240040363, 1.3248076867274627, 0.9208717895819472, 0.27801005099616977, 1.5870002976113637, 1.6961687819407312, 0.6602622135765088, 0.1518994803649151, 1.7298696284919983, -1.0408251910061763, 1.8489527807862185, 0.041774033505297264, -1.1379878783405655, 0.23022353018820865, 0.2842879603768627, 1.0384935616920346, 0.8532458625110461},
    {0.2255197329921031, -0.7729607896172337, 0.13549449454304255, 1.8954645308818119, 0.514329092500835, 0.14931977282229086, 0.9184668079102198, 1.0231925035220997, -0.9765462865279827, 0.38202969248044943, 0.6810995154592082, 0.8846340544368478, 1.1044754577767328, 0.34697284567475367, 1.2780113075758257, 1.9150512354016822, 1.9573126177347449, 1.6540230665008402, 0.6598600083948664, 0.0912349627674093, 1.612611253681832, 0.24032581122188282, 1.2676261381438936, 1.566408027138436, 0.20502901707286714, 1.0126323987963128, -0.1707698683025749, 0.2294872369400962, 0.5866486454083768, 0.41166956816880224, 0.6014111928713805, 1.5949102685144436},
    {0.6587266497473157, 0.1561459720479441, 0.508175349397493, 0.17331658011079204, 1.1606674568122892, 0.294916168762727, 0.999447833711888, 0.5555804196972287, 0.3239770879142761, 1.987843021269273, 1.9866454777323672, 0.21115112133461064, 0.43484620779520994, -1.0245474302330346, 0.5036842998796343, 1.1731317270042214, 0.6492991024160213, 1.8450505200407095, 0.9868258061935273, 0.8107598411208307, 1.3791571339614728, 0.37800453830633945, 1.5157356702192668, 0.16807762299547327, -0.6052605610666649, 0.6044008010594726, 0.513963681436036, 0.697992455905454, 0.7788822699997046, 0.5221822389107253, 1.5170656161528582, 0.8224612970165631},
    {0.2212576882122835, 0.6438672065150558, 0.7123030905364763, 0.32053449111562676, 1.9850635112107986, 1.5730262899744334, 1.6527521672864254, 1.4880211753180956, -0.24340706950797658, 0.48593613928546836, 0.38673721406339173, -0.6620503965552486, 0.7387578399189011, -0.8253731955216321, 1.5668534120945377, 1.9048888011699245, 1.4806211622569354, 1.8871275751754626, 0.45802957027450814, 1.0397522765392715, 1.1660256121451449, 1.7262891190727228, 1.4133234634002527, 0.3228320665351448, 0.2859514881975231, 0.4485715856120839, -0.8332490086570012, -0.20272223627453523, -0.9171456798911436, 0.21610148753643546, 1.7556254040889592, 1.4339956372142015},
    {1.1940096641064142, -0.2675732717606241, 1.5271595631678125, 0.5069807242874429, 1.9860498957795092, 1.2706010145762208, 0.960686104903933, 1.9173233135740146, -0.5958840704999042, 0.7911388916787139, 1.4532796035006341, -0.767662819965913, 0.6666102957453517, 0.0071115914579571796, 1.6607220931293551, 0.7394272560478818, 0.8575441075204647, 1.640807964352814, 0.589733447462421, 1.8739078695845957, 1.2357268926640692, 0.45224113802166993, 1.0369782379775843, 0.6903671298363124, -0.056619597340153364, 1.336645485133685, -0.8639380953464936, -0.5201930209349878, -0.8642226165952496, 1.898820463243853, 0.24897354979316974, 0.2078312798532182},
    {0.9250530388170234, 0.0019598189671857186, 1.5619141724909462, 1.3664891961594154, 0.9799348210725517, 1.6865388156857868, 0.20648595516217538, 1.5706491135531295, -0.9120869458392686, 1.8641519078076476, 1.6687637066070975, -0.34430390511511044, 1.9598969448235763, 0.3337836202770052, 0.745074003149425, 0.08785935029311706, 0.21627970155173673, 1.5797565501225495, 1.3323861529862149, 1.5766064078203776, 1.2998816536550637, 1.5872226304741592, 1.902789612403391, 1.1721958497912814, -1.1624833152667726, 0.9482827629683772, -0.14493322388605495, 0.7118313950145406, -0.5118832750994258, 1.7418481002585515, 1.5095283518781726, 1.4138135112544643},
    {0.46810955367913043, -0.9545349649765941, 0.6095176908980354, 0.724283628919925, 1.2661759631522442, 0.7635819187628629, 1.2089116549515841, 0.488773509816144, 0.10320271731343918, 0.8047430644684817, 1.494769786061429, 0.252034174376177, 1.764875302340345, -0.20534039100732715, 0.8195493516268088, 1.9109836422322704, 1.127289782582558, 1.6582210472566643, 0.51224280981696, 1.0460100985045668, 2.1016807145259824, 2.010615118258218, 1.0626147286530172, 1.3548531737021516, -1.0843552706469568, 1.5394032345195983, -1.0919163712521964, 0.7710119163783528, 0.41157776600280566, 0.6946034215262431, 0.8292797512200941, 1.2949132503605296},
    {1.757684432561333, 0.2192697264574728, 1.853178259135432, 0.8840701898201482, 0.4238043617511168, 1.9613684086224463, 1.4885133409808822, 1.122513540652016, 0.5184862115814571, 1.4136458274349128, 1.0851792456018587, 0.5131452662550975, 0.6873242529587185, 0.6400052208322925, 0.9296384802861651, 1.8247758383153907, 1.424286548184434, 0.1608281310409031, 1.2042578613513368, 0.8452747856691863, 1.4675486258562493, 0.3841519657385922, 0.566423046845321, 1.1745051103273842, 0.7408752435319468, 1.1556743382681731, -1.0298971158302852, -0.6731733205936776, 0.21337558777291113, 1.4356234995148205, 1.0958361690095222, 1.4445213965681287},
    {1.569214061322524, 0.7738355057412993, 1.269733192664499, 1.4607835299176655, 1.8141191843066085, 0.9282816595517909, 1.9874364258971788, 1.2104507807804956, -0.2434189499073734, 1.916949662820427, 0.5169621392744458, -0.301042905401702, 1.9642250099926357, 0.17265499199938797, 1.842904665954214, 1.082067919153774, 1.2274406494068508, 1.8475762363711714, 1.570444453927875, 1.7723688791317684, 1.4610231790102388, 1.6911622788259848, 1.150851074764051, 0.7049511187963976, -0.07881883679673422, 1.4862965900146976, 0.7914641988951653, -0.7608242921895972, 0.7331060887550055, 1.7724716010575423, 1.6513657709296377, 0.17031063949259106},
    {1.1297442652893877, 0.19998067528082614, 0.2835707197701848, 0.6390076254487638, 0.6045206164920135, 1.8771173007022504, 1.8642498846254445, 0.23499084844887758, 0.35241917739210954, 0.5937210148943216, 1.3891842973905904, -0.5901833136177858, 0.5786414095168917, 0.7376582856867782, 0.5872455747507448, 0.7471581982516879, 0.689064918927294, 0.8744965276596695, 0.08872885537248679, 0.8112622236113016, 0.541423761767422, 0.7317855688576553, 1.6952820451494943, 0.3247658345377458, 0.6941411599444288, 0.7852973358213023, 0.13719533499535105, -0.848650874326252, -0.9521474096073391, 1.8529124336112035, 0.13990371287989206, -0.008516536959275912},
    {1.0676379795248245, 0.23804031496818323, 1.787414495816534, 0.18686789942782717, 1.021084938224657, 1.6493092170546628, 0.2871774458915777, 0.7348364884896362, -0.10064224461313366, 1.8608136693659405, 0.16457970872629882, -0.5840915835543774, 1.8110421712543379, 0.10995003501169842, 1.5074765938072254, 1.034571519830174, 1.0246196515331185, 1.1884938597532086, 0.2069013469101298, 1.3494648409485024, 0.39390415756156033, 0.2370953184825473, 0.19674524177980104, 0.39988327913891253, -0.743941965629051, 0.9102219406674428, 0.278249208976958, 0.07686505503564339, 0.2935696049519262, 1.6959195040540418, 1.8535064780470516, 1.3741877951367274},
    {0.015481645399499278, -0.0644767667772949, 0.5523329777178662, 0.6477749140265986, 0.7277120942564673, 1.8842387678374202, 1.806420288175462, 0.992603278060756, 0.675994965524528, 0.37684598126611074, 0.03347168061479583, 0.14239218002735682, 0.4529070557369373, 0.31383931151060274, 1.6189801403960173, 1.895447749287186, 1.4526233254445877, 0.5317614899591349, 0.007762186402563263, 0.23961444337453228, 1.2838788543319244, 1.4867512883441087, 1.4578574094436192, 1.360870562314437, -0.5259292835238895, 0.09832476112494214, -0.2980993299373416, 0.4924063026820082, 0.3602142347281269, 0.7617520735356816, 0.5056120503780064, -0.013819605752853176},
    {0.5369223194723846, -0.537109709243762, 0.4221404140674881, 1.3118588004780607, 1.4004003021230953, 0.6043680942419964, 1.5595697405628355, 1.5733782379230048, -0.13905703927633617, 2.1762956268307203, 1.1283894609756775, -0.8203092820357987, 1.4481931452051637, 0.7743630402119365, 1.7742012194922765, 1.4671333290814395, 0.7605929450064292, 0.794603275460627, 0.14285675257417743, 1.959281298678353, 1.2956196551083483, 0.14033054119114918, 0.9381695862501652, 0.9505153114044194, 0.5949485838058299, 0.8533493877114688, 0.32142780437551044, 0.43072898241841606, -1.138728200946051, 0.46903898874282274, 1.1375963869124175, 0.7790889858010845},
    {1.3297204840988874, 0.781529530798647, 0.08472370601077321, 1.7558451317380197, 1.3731634538611082, 1.9275647189763094, 1.8039823037302283, 1.4026239497281325, 0.22525114783174938, 0.43923073030154697, 1.3251733678045683, 0.23520872617645958, 1.889437679633784, 0.218836784758056, 1.974368989111854, 0.9288350495654266, 0.2937618106020874, 1.5149728219103216, 1.052833500343961, 0.12250645762224194, 1.3755832848380138, 1.6266990677599233, 0.6334016642824231, 0.11606043964714617, -0.9884302484983838, 1.6304213162921553, 0.2546425796515724, -1.0210941789749184, 0.2834147838278374, 0.2063232700944787, 0.6749374621648137, 1.2215058593120114},
    {0.8747904417910486, -0.7459285337414379, 0.28010456202536016, 2.0920274450175342, 0.5487329474849681, 1.439436181484935, 0.6627051678915479, 0.6057325053471018, -0.3369747572242951, 1.5085720765235635, 1.8521439450362085, -0.9661505177637351, 1.1271624121768637, -0.2082621299521442, 1.3863099892400468, 0.5034526609520981, 1.709083904182471, 0.555153069138374, 1.675082713094576, 0.4563006975975003, 0.8431535487899654, 1.5330692793425729, 1.2366810539299706, 0.8116789024543797, -0.6182199388207157, 1.3418423755899265, 0.7360714190220627, 0.5028680516846584, 0.04596747357241455, 1.3351619049664603, 1.4562438129361435, 0.033895428136977476},
    {0.18198119260125087, 0.32681532768684074, 0.29040978412676555, 0.91080582958419, 0.3566381645508211, 1.2059803582955249, 1.2935814795181713, 0.28992484202323127, -0.8757287595951109, 1.9419021337189557, 1.3927125324001735, 0.5148955165521035, 1.4577193103988655, 0.02417549297429768, 1.9740604009371159, 1.9849042942928807, 0.5245301083631035, 0.9764589476844094, 0.2742389460131576, 1.0907221376863978, 1.1087122319765845, 1.365183570894991, 0.3269194796915092, 1.339724869724759, -0.10881293231893367, 0.7696115562142125, 0.4885365123037436, -0.8347871159164584, 0.7403430814122064, 0.824371670287096, 0.39875937852455257, 0.011371592789536011},
    {0.5484496205404792, 0.3683965476352642, 0.22150874939451082, 0.4068281189173224, 2.0253689635402097, 0.1467139776449529, 1.2625604440307139, 1.0588114583208303, -0.8167159997745481, 0.527945461070154, 1.898033518848085, 0.24031582075823948, 0.2097296476901139, 0.19135988838336843, 0.7597802307796695, 0.5356362866255592, 1.21013695882716, 1.5732975987264752, 1.0661746657640516, 0.8506449926142684, 0.6206363882409514, 0.9834380255497659, 0.14906955940024336, -0.23337386268619972, 0.5753870960790017, 1.3411635620008329, -0.18191060050859054, 0.6198725015676549, -0.018800348333616886, 1.87489643615499, 0.7766258899223439, -0.0588489874208928},
    {0.17997160179284794, -0.02177838942218058, 0.8707975368404549, 1.3673677469523557, 1.7413512729754226, 0.36776830260370647, 1.0254187302820077, 1.1451454847810698, -1.010072595271622, 1.0338237168733566, 0.17082896112023682, -0.6911996368377971, 1.9820452676253362, -0.8168930099717214, 0.6102969591190871, 1.6648674454685009, 1.4416638874496612, 0.7921355876678879, -0.02464420210841195, 0.6707271173118142, 0.2755495741024449, 1.6349301958027724, 0.39226673715683863, 1.1295648618847811, -0.18855707353878212, 0.06020113103443369, -0.6966814661767732, -0.6944203631599779, -0.5878090603015248, 1.9086429021761313, 1.2051967930100036, 0.08221574254171414},
    {0.3517747625626564, 0.5151545262785527, 0.8832055276501828, 0.7797581068084865, 1.0049447473686643, 0.30344079953464737, 0.20618656792586923, 0.5126240578231473, -0.5460299671105944, 1.751696089209267, 1.641063668209356, -0.2850901917818611, 1.3812113444485563, -0.4799406362815093, 1.047037723974677, 1.1281523564700429, 1.3027068483344366, 0.9317604892532614, 0.9262469212917194, 0.7298742782008549, 0.9325942546498925, 0.9939141047575636, 0.724749169654192, -0.0075636061595336914, -0.03434573243470067, 1.6968154294236617, -0.33350676173624855, 0.6711453831705279, -0.37294192482251276, 0.46244815752852897, 0.8067197500620419, 1.66091061118168},
    {0.3573600856242843, 0.16593712923902637, 0.8239125990631398, 1.062426749572768, 0.7100376557676193, 0.1708021751708551, 2.005736715804501, 1.789115169029956, 0.3613147726556136, 1.1811479967796155, 0.4584819294206291, -0.07383830457613201, 0.4323133744802306, 0.5253841693404148, 1.7590479466742504, 1.3558807142282987, 0.6256174457066316, 0.46504109529368604, -0.07243821502768076, 0.8962144447176748, 0.30160460867797767, 0.5835121610324477, 0.8673404732668744, 1.0551291302712487, -0.9770140702636361, 1.5786436581363947, -0.9073588560933223, 0.39215701455506036, -0.24988183960277086, 1.4095587414062822, 0.2514780314873505, 1.8247310293689227},
    {1.3005160147099484, 0.08773785906545015, 1.3575514810504201, 0.6988997625894767, 0.352513289256952, 0.8042428574847539, 1.6342537423408876, 0.48312506683286494, 0.23756114168478984, 1.2256498834749192, 1.7038141236799667, -0.9424837460585996, 0.9096591757106874, -0.6111574344909688, 1.6582065597985998, 0.9229894987396258, 1.1504113314884652, 0.2512209181010989, 1.2882414348831626, 1.3771851836139857, 0.8882947409532767, 1.3208329527322373, 0.5952508129625724, 0.5218392168184233, 0.25268913889996847, 1.6685251607905156, -1.098425951967445, -0.8638482497194909, 0.24558460937096194, 1.3800859042463618, 1.4493167031017011, 1.9864619611196097},
    {1.2536195290764718, -1.02195947388306, 0.5483930655342248, 1.9484304127051624, 1.272993453621393, 1.1955275330099822, 1.3802087803479273, 1.0016768975557384, 0.7843356464094494, 1.2679793157782662, 1.1615974157735047, 0.8969106729394924, 2.1468232700001852, -0.6906480026845174, 1.5922072590761243, 1.566096568213476, 1.210324127979573, 1.5940638341031899, 0.0849131059936429, 1.8923772655881734, 0.24300854519492116, 1.90141482997198, 0.07256283962270614, 1.5478268219502669, 0.36842346414434163, 0.9699407239688896, -0.9656649958580344, -0.7691998172101695, -1.082795494301153, 1.4504188699868077, 0.2160233668312001, 0.1765493017708575},
    {1.1409161752584829, 0.09459811811627482, 0.7344589338551555, 2.067692446519865, 1.3378462578356458, 1.3138039095725345, 1.8747897462898617, 1.7359672094608718, -0.8740052011788794, 1.4837831014086278, 1.4504850892048962, 0.9157987455327169, 0.3051303161160508, -0.057054112292806845, 1.1798527656270827, 1.2138610867071513, 0.2355820293677596, 1.5854518081194124, 1.0137373312378606, 1.2214433507432951, 0.5265102400791909, 0.6141853986512282, 0.5701475611799812, 0.22507171388705147, -0.9240594057564325, 1.6573578885468894, -0.34108742399242203, -0.9363581172659996, 0.5052222337566751, 1.5526156060943823, 1.081625394968919, 1.894971656791122},
    {1.8965019284179572, 0.3614097709080895, 1.6078854372041071, 0.29601350740735494, 1.082422154153608, 1.4926245572773973, 1.0358844597116141, 0.5681465170234336, -0.9088527970351268, 1.1922868466565366, 1.5512635218060908, -0.26816356073999037, 0.70500363156185, 0.6184733779354377, 0.5827578548126917, 1.312859471144983, 0.41480116897260544, 0.133732321941953, 1.0045534544738592, 0.5061148717777008, 0.5724648619652345, 0.9340131123487863, 0.7181561220396818, -0.2566175206502897, 0.50065018362181, 1.7747545162029288, 0.03174354890073534, -0.7581984864143728, 0.2748867015051667, 1.7674643688468494, 1.5313228223453847, 0.18873369815984362},
    {1.8723384863229051, -0.10105900277698436, 0.650489073980122, 1.496734943076608, 2.086452862718043, 0.60779440662936, 0.7552138769038267, 1.1114297251028, -0.6696201152479032, 1.9486944330014413, 1.429265058105227, -0.7910208469260334, 0.6044070268291324, -0.3808037183890032, 1.8172439890587369, 1.8927131969721873, 1.7488665182896685, 1.6284787863536987, 1.0187161399157785, 0.8215645687356898, 0.597863181681806, 0.5529634351623441, 0.1587682262562195, 0.6392146142077749, -0.3694564299546538, 0.5031416988043353, 0.5447637321787406, 0.24841115852322612, 0.587020650252261, 1.7939915319062965, 1.318281482012126, 0.7758255191684167},
    {0.8939414578856418, -0.6276733844177104, 0.7808640752837697, 0.8566902956968968, 2.047560168074695, 1.061399240872753, 0.9361630192358309, 1.9470305955073164, 0.760587289856352, 0.6700891035336095, 1.001614111453158, 0.14001413647239772, 1.7787698476752645, -0.45932465607227674, 1.0377328772396384, 1.6446295991694857, 0.2479623444818329, 1.0613256114674827, 0.26755689309368513, 0.828169736948068, 0.36749631894811574, 0.13158577841538563, 1.9248567956800156, 1.2327385339014527, 0.7609452686493504, 1.373062688398865, -0.9629777948964617, 0.06828470923720525, -0.4243467934826898, 0.7222860094338656, 1.8511520841430618, 1.1340889725973688},
    {1.2353619424784428, -0.6972272973948411, 1.478800036820745, 0.5089522843766561, 1.1073129709715765, 1.5089041685318871, 0.14496056054668566, 0.5749732268916395, 0.42759485741962217, 2.1611806724944005, 1.2084237296970228, -0.8022984902318756, 0.29494079566345827, -0.3170474801748713, 1.1980775326014235, 0.9674162661563542, 1.195066107454949, 1.1606924626691915, 0.9617459790422882, 0.3526668334780149, 0.09994649405638344, 0.6555036283015624, 0.33069941647565165, 0.2980312518188164, -0.580883101439602, 1.7942778043667196, 0.469744889337971, 0.017529819914737014, 0.5236123467960252, 1.7366028941806801, 0.4228805596007124, 1.0557113299603884},
    {1.1645373887241244, -0.21045285180191636, 1.5034703806526533, 1.461260475963208, 0.3787722057691616, 1.2277835740981697, 1.368586409811426, 1.722133020380788, 0.6360693297994969, 1.0531587362765822, 1.4788276347584177, 0.6810136555163432, 0.2553213906253155, -0.939688655948051, 0.984904133768125, 1.415609885684224, 0.2520431221386112, 0.03846467621909828, 1.0111760066797757, 1.8778971266842328, 1.7214278483672718, 1.869172260969464, 0.40294456639340787, 1.4943144270747555, 0.7400038062228729, 1.5501508757640448, 0.6504271526798888, 0.5914746569542672, -0.5335185166314795, 0.2879662603318268, 1.401323727227911, 0.2404690053899921},
    {1.4181588760351387, 0.47172549026178145, 0.6491062125933402, 1.0810293134227544, 0.2491881132554844, 0.7303413584318789, 0.946947885062772, 1.899285790175002, -0.5909533021338922, 1.397510716924977, 1.9412215959337005, -0.3556014473679812, 1.943506579170866, -1.0766236046660866, 0.16752371496322582, 1.2122778978380673, 0.7201490217196611, 0.3362531927120339, 1.270789897294311, 0.4343407293359147, 0.20943235536388172, 0.9571516433027114, 1.3813697687914557, 1.0756182762495368, 0.44300552286749034, 1.127749857244271, -0.4308798533833194, 0.5002731085989883, 0.19766400540528015, 0.7623653450742411, 1.0273853190358975, 0.9096268868013069},
    {1.4396657678560907, 0.39360553114212193, 1.0146122403568372, 1.3758271501176533, 2.104308989399934, 1.7486193524276545, 1.2199147217399309, 0.7048115135328987, -0.35233105921326535, 0.9615428369642253, 1.6792601173398247, 0.9048573691930832, 0.9152882769294337, -0.21405732210666445, 1.6395311191083477, 0.6410667709130533, 1.8090861646318261, 0.11889801844509211, 0.9380849644085059, 1.0463608555905288, 0.8399578478262756, 0.8785839427926118, 1.7969942925151583, 0.2553548159461286, -0.7495299452549563, 0.8065515774603861, 0.5161416912362863, 0.42833573622684895, -0.3979413786482392, 1.8246694658797087, 0.5244563588786222, -0.012380861343946802},
    {0.6041032726742551, 0.4261371916133708, 1.5178336721037289, 0.20773184380825513, 0.9697793404044561, 0.8105337179671863, 0.18991810684899557, 0.8370922092927149, -0.9101068884406481, 0.5074880608908039, 1.8520981125041691, -0.9001077477308275, 0.7317381755593927, -0.8702001888997747, 1.8889330633343306, 0.5105157754917656, 1.6894108981367684, 1.0315055755276579, 0.5003909010100833, 0.4826208468486566, 1.1649186758907737, 0.12159145397043453, 1.8940210316677837, 1.0529530594914607, -0.049984331723780334, 0.3827091049245129, 0.6609041302261076, -0.4811753908110409, 0.539031063597952, 1.677621877621059, 0.17517499486460236, 0.11335675952183097},
    {0.7606652125365282, -1.030588265808998, 0.6806966890662534, 1.4659433722783586, 1.2356666327284314, 0.2865327575493961, 0.6271295717409607, 1.2250752960294695, -0.4333376756314879, 0.5589209007186254, 1.3881817406437245, 0.4857899496052619, 1.4964344194106423, -1.1190191080402185, 1.7434069985953502, 1.1851359705681885, 1.7488217315669765, 1.0166176482643505, 1.733274846532634, 1.4508955040207718, 0.616678110776979, 0.23104299962488647, 0.6060568735173868, 0.10677980551625142, -0.6160257035355389, 0.6892675769375519, -0.699507302464548, -0.34526919685678314, 0.7285699237955471, 1.4808906727084516, 1.11021443853003, 0.15836588023735393},
    {1.0914969100670813, -0.5888070986438918, 0.38575190218933164, 0.4394528005521813, 0.6632472546246994, 0.15046996319034409, 0.7465708761187546, 0.6787914507759754, 0.6558649376642007, 0.9398498959023078, 1.890469988074601, -0.43206389628996533, 1.2929646379735966, -0.46581560533963023, 1.7079624910782074, 0.27248055382363096, 0.3488820701832075, -0.00914302231852803, 1.32118121601483, 0.5480795822509842, 1.816729350967574, 0.8151699998729381, 1.5867677506740523, 0.8533424713624886, -0.40790730768362854, -0.019367575971917225, -0.9148139289348373, 0.21215799088800064, 0.47815450897351514, 0.6264371142595507, 1.5186230273955172, 0.6032928703095244}
};

static const float b2[32] = {1.1082064110246204, -0.13936057689271267, 1.1034018405747088, 1.4327230250590974, 1.462837779221447, 1.312034448190966, 1.360208833482287, 1.478383579680575, -0.2419011598814386, 1.4854645728083937, 1.2320124150726226, -0.021827566820313782, 1.4291940283585762, -0.2586259258485172, 1.4237650811968112, 1.3140089178188938, 1.3892947028761988, 1.271480054184185, 1.1235159473447036, 1.2052016989164778, 1.4149324393905423, 1.2164209283662444, 1.263120647793085, 0.863502171192238, -0.28389528964072275, 1.1878123350739862, -0.26540272849054003, -0.22519368082230193, -0.23616140121616086, 1.4193664582461631, 1.2203188225261437, 1.2591955373640695};

static const float w3[32][16] = {
    {0.29880527749489344, 0.338388229268042, 2.203852047681874, -0.49361925420626607, 0.8498051679715133, 1.7647030100716234, 1.263105705712464, 0.7537955908174258, 1.5433843099665603, 0.9686771891597764, 0.7491298389859987, 0.8595686137521438, 1.2792624062188784, 1.17116080286429, 0.30621591553490674, 2.36959664640542},
    {-0.5205888873699213, 0.03791466342263983, 0.93280071290231, -0.7327375882361565, 0.8433131085672372, 0.030221234878307933, 0.6500340847655626, 0.3828901197682089, -0.5457337034983571, 0.6928067626776813, 0.3583841440001507, 0.8418937437640096, 0.2769655731149721, -0.33780015888688514, -0.017983100517958813, 0.09031668325116085},
    {0.20107510818516305, -0.3481617855761807, 2.0957995280580093, 0.2389203575677988, -0.8414794917263057, 0.4799961945322357, 1.7726236410196168, 0.8145506116305289, 0.5963796464694887, 1.9425720609132766, -0.7867445076290223, -0.8295282839641678, 1.8084774851273038, 0.4096977699085308, -0.862040532793017, 1.1464118069763654},
    {-0.6316495479010321, 0.2899699505169842, 1.3986180827306418, 0.48700914453379995, -0.9286942243124309, 1.0929379627468139, 0.32651049674347504, -0.006795520909538566, 1.6789259241166832, 0.7040790680744219, -0.4920751986883381, -0.06425111563376036, 2.427516094382471, 1.2232008317737055, -1.0290014871754456, 1.9866626573911652},
    {-0.44538763021333727, -0.8114067518867973, 1.0574455226244255, 0.3825655469512446, 0.6899256731453005, 1.76131051649783, 1.7662885612503487, -0.9626389216835861, 2.0073436874138504, 1.0701890465737582, -0.3335003206794819, -1.0060719262043616, 0.5686610103119631, 2.480412195646445, 0.125866776165709, 1.7565081105344245},
    {0.3342331472501571, 0.6902947057512425, 1.9594750310525118, 0.11476660555083387, 0.2692156397545173, 0.29118579572550474, 1.109923243411975, 0.848245184386087, 1.501294477865345, 1.5817217837394324, 0.01115378711605297, 0.49465559592794983, 1.437272863269966, 2.3596313424975714, 0.7001611925869309, 1.4319868877615944},
    {-0.9840575579949904, -0.34530425063441406, 2.1477367224096575, 0.04102343453713644, 0.39556153386981635, 0.5335162527982767, 1.8548831509521015, -0.8430020092325583, 1.358013647858987, 1.3920498989355332, 0.8389362074938365, -1.0193811542270752, 1.5719799465720172, 1.3726662227429143, -0.6571640867132142, 2.083800630636361},
    {0.6532748503894505, -0.6684160117217167, 0.7364753109150428, -0.6001747999157826, 0.664160432330622, 1.283761723787453, 1.3053993783084967, 0.7146436161126125, 1.6289325234047423, 1.5943822612170089, -0.9269422614771975, 0.051663761092928244, 1.978626954328703, 2.017993699188408, -0.319490992736105, 1.6427300797468771},
    {-0.19969361899287155, -0.3105348142864652, -0.416294791543387, 0.48121748027018224, 0.2853119500512008, -0.6804139674771478, -0.6563166647605435, -0.2881278690944106, -0.0421813974720199, -0.37165956502194036, 0.6352727676474125, -0.30498314658617964, -0.1981264479045847, 0.8256018934130053, 0.11797699762926639, -0.2295413668911137},
    {-0.7207973514062719, -0.600139083601651, 1.7541068552557049, -0.24055150527823396, -0.21264377206621163, 0.39710791980255683, 1.3614938006032102, -0.9245453335944311, 1.6080583496627066, 0.635635106369643, -0.1695911318864422, -0.4171669614634904, 2.3282321391599523, 2.398162529826728, -0.20150613433177944, 1.4328762716530021},
    {0.5065487464301168, -0.9747792671402447, 1.6998308174602337, -0.6146289624564053, 0.8193861046594477, 1.3699409598141887, 1.8646029191909166, -0.0071143473645694415, 1.9752742322378884, 1.2812140856736878, -0.8843993948575593, -0.04524756715925151, 0.7846024034099501, 2.0626264781864845, 0.7095113332778074, 2.129636491978567},
    {0.9957723911182136, -0.2394617064619569, 0.27809559212731094, 0.48759396177039127, -0.14294345806996026, -0.7481676373837424, 0.20389725360823152, 0.6653568442926903, 0.3595340000966983, -0.5406996070815376, 0.6562384306129159, -0.4419080594800931, 0.01863589500046395, 0.4978261127171216, 0.5901055116941348, 0.23018951465463117},
    {-0.4007169732199805, 0.3543942784079002, 0.6952208523972866, 0.2264242384820735, -0.5199467565356308, 1.3070327115122458, 1.3128223899554952, -0.044292478540357345, 1.1025728395426455, 1.1377490783469755, -0.4058223690228008, -0.060547633397418456, 1.782481735342734, 2.1398338758894004, 0.6852485261697061, 1.2843443431700443},
    {0.7086830571565015, -0.9188608221971392, 0.40182078467393595, 0.5524992903836148, -0.1576010082848819, 0.05023424937667015, 0.14639892153910955, -0.8167008607751213, 0.08619289917188261, -0.19671837965693825, 0.23028137481359698, -0.448456508393416, -0.6437622971351857, -0.48909614896793896, -0.24448564937445671, -0.16616565309429854},
    {-0.21777648680822695, 0.7749261329018375, 1.1323750042702676, -0.9144326288899363, 0.3868566753552346, 0.44760866416970574, 1.0416177306535064, 0.503408987162107, 1.5032750273178361, 1.7406612899431058, 0.6380719245191546, -0.4024765976931163, 1.1795357113276286, 1.2952981388765965, -0.8477038202427671, 1.9715164403636936},
    {-0.663200160271179, -0.5943170639014705, 1.8279648127214017, -0.7770829089443522, -0.9935273277714126, 0.17251929690587078, 0.8940686538034532, -0.9434735852173531, 0.47944957923782217, 1.5921400262211631, -0.7475893240771784, -0.9140670070829325, 0.6447819434081045, 1.4804975396711133, -0.7648699681694938, 1.6599028459322607},
    {0.8825183835940236, -0.8372563898969893, 1.4636083944198237, 0.8566778016415629, -0.8666696919282276, 1.3154824337136435, 1.5861284237916513, 0.7755971321938485, 1.510570081806961, 2.0733800927258845, 0.10065708160181004, -0.16310560966276946, 1.4731772187657122, 2.589858032723343, 0.5321268676415661, 1.8659162447712072},
    {-1.007370112651329, 0.04193895677388733, 1.9604871799116046, 0.9534673718423581, 0.6124104247998262, 0.4148741148538594, 1.6127437629422636, -0.7419934610838884, 1.050774259939505, 1.836746950242697, 0.23163482037282998, -0.8227979142805796, 2.4128816555096586, 1.6177469941613163, 0.28139876166163985, 2.3312516719853265},
    {-0.38563521724725597, 0.235934176638256, 0.8156975598591573, 0.10266318866942996, -0.8543919585211458, 1.7048796080208144, 1.0583214640947285, 0.8176655087646654, 1.7398576914901394, 1.691407299461972, -0.8810719874013941, -0.5603342689594994, 1.6939326210066419, 0.6954607681389674, -1.0417730894835946, 1.3407927500998043},
    {0.5141066809555723, -0.30072919429036366, 0.8429755227740658, 0.007708222533839005, -0.6240930877079947, 0.6210725922914144, 0.8502150042459813, -0.18338447580570552, 1.1789187328812758, 2.1206960910812995, -0.353342832070752, 0.9378593323847135, 1.0010269984535531, 1.4103735558469321, -0.3321828609413131, 1.7566236189440132},
    {0.4165305179623199, 0.2436982203615922, 0.6243736965860703, -0.6253537017208859, -0.5959463496069828, 1.106147216840027, 0.9959363763246095, -0.4698583716489237, 1.6751899888259183, 2.1627809755351004, 0.09994488490537119, 0.36303646177762494, 1.6437046928846326, 2.0382451074035606, -0.3052866815689603, 1.8586097338743746},
    {0.27262240422130635, 0.36867324875679675, 1.8866120549779546, 0.4841715705359277, -0.03067937118391575, 0.9884574894045501, 1.5415537318745254, -1.0200313006101562, 1.8599487187689132, 2.1702913574132396, 0.8610923772721198, 0.2629319657837237, 2.322961442542219, 0.8269188835923945, 0.09062328347217793, 1.8833879463550989},
    {0.7481927420643598, -1.020077196847103, 1.0585748215305786, -0.8199633560373653, -0.527056849926114, 1.1984485290703502, 1.8438236485477801, 0.7321493615746175, 0.6430917492622675, 1.163454599607893, -0.5260571869499704, 0.31197137663303354, 1.1114310426811107, 1.8126739123026245, 0.22261626858940645, 1.4591155565545608},
    {0.2287843227090999, -0.26604578656306566, 1.8695743262615299, -0.22018199561315735, -0.8398505077033226, 0.15819421684196613, 2.0115354627788777, -0.5405854036792602, 1.121921060126793, 1.670450167177332, 0.47654932093468844, 0.06541389990995898, 0.732367935330812, 0.5698561725687403, 0.142610148792777, 1.3586059923839737},
    {-0.4341670330706649, 0.7308660721779868, -0.6207771220945796, -0.4235007547193479, 0.5465270814796921, 0.037340892764186756, -0.4044970333913808, 0.6532683848336949, -0.5074059343603842, -0.26713750913323747, 0.0517906900514168, 0.01817388944266326, -0.4880264569707561, -0.5877999731819041, -0.08343871447604947, -0.5139456189110722},
    {-0.899817786280758, -0.22899053063074193, 2.1000945528375365, 0.8541735652223045, 0.1637709121745614, 0.7022100360478691, 0.7478283692129961, 0.9006750935723902, 1.210009939195647, 2.2252092988579695, -0.5326609186433755, -0.6076466600632283, 2.265227075958223, 0.8042983967025107, 0.3011198176055848, 1.5153594739924388},
    {-0.10933950744148636, 0.33004272679272645, 0.26516466523634497, -0.49774398285473614, -0.29034960586702935, 0.9188168437400493, -0.3584649523451635, -0.42241289546337335, -0.850211733715595, -0.5576327477851916, 0.9317465646424726, -0.0700417241351103, 0.30115687507405686, 0.18571588062153627, 0.8551591686366476, -0.8230223523834044},
    {0.23276777970556548, -0.04355422098571944, -0.6481534589115019, 0.7375677891896006, -0.19875371163148517, 0.44184320108278413, -0.1855560042820801, -0.7634893469879602, 0.5856256059069643, -0.7913502788892994, -0.17190633331578864, -0.1673729684981364, -0.3658726128438727, 0.04728739119053414, -0.49694151456601077, -0.5282999941388663},
    {0.6853772173989561, 0.7093949340736946, -0.48648116331466185, -0.21187128786356182, 0.541882111760588, -0.5283315849657446, -0.3300310317511993, -0.5103708838738991, 0.6172603950407529, 0.15444787022576165, -0.9228837051813703, 0.624448842944841, 0.8292131741442531, -0.4733374544878469, 0.6795889382373136, 0.1706252084191074},
    {-0.7058062527536845, -0.5330619014383158, 0.3956043763623505, -0.2150314250403768, -1.042856741355994, 0.6697960293184585, 1.1062637800168846, -0.4931745925970399, 1.2262481788893929, 1.8432731238351783, 0.44104736126911676, 0.10051881220969017, 2.3866987635670975, 1.8246901379060378, 0.21503134365500548, 2.0157051453801467},
    {-0.9361064749980601, -0.1737907654993648, 1.5863629032438167, -0.7585486354136903, -0.6543984442549861, 0.48566773002637414, 1.6469095732402612, -0.49520931037813753, 1.7119222000514867, 1.19238504314694, 0.6386679967610253, 0.08064218411216649, 1.4657998193349773, 0.8727498006573972, -0.08596009775841923, 1.8211281147942133},
    {0.4699436174833058, 0.868224522673657, 0.8068712874475653, -0.4170472431222316, -0.5737007546796874, 1.9094007683902547, 1.491707788284525, 0.6528867139067086, 0.9134402113873612, 1.2534384668542695, -0.8259855047415292, -0.6757012877191918, 0.5266874846677095, 1.796200410116257, -0.2408208931366436, 1.7816104913141289}
};

static const float b3[16] = {-0.07841022167231729, -0.08216979040590262, 0.7521987566414398, -0.11574027380899837, -0.11564769790928689, 0.553690042573169, 0.9056787805346822, -0.08177707596028717, 0.8335252919888438, 0.8230746342099358, -0.1054479385192703, -0.0683373056440535, 1.1419615207635885, 1.1233616259525376, -0.17210258697056513, 0.9110833088652803};

static const float w4[16][12] = {
    {-0.1703636291707313, -0.4229330337342624, 0.6100944768687976, 0.3088494781015346, -0.2603897218233691, 0.6953955538190969, 0.878967062928823, 0.6511405989633223, -0.7567487680166965, -0.5463794981321142, -0.9337837019336842, -0.5369297573264284},
    {-0.6019797573339277, -0.165450547966985, -0.46012490430088226, -0.7626140936689824, 0.9654771771983546, 0.8414895548498308, 0.29707589468830825, -0.31793231988582654, 0.37571341802952907, 0.36575022216478886, -0.09389532892539441, -0.15317326482811375},
    {-1.401651805800165, -0.25341603032204685, -0.9578128819237216, -1.635731752411973, -1.3425314602218557, -0.21655674441052938, -1.9701017630362903, -1.8537627250570936, -1.2883600482684707, -1.2522062658562856, -1.5261887935448424, -0.6885298036569507},
    {0.3387993080761664, 0.548367121706244, -0.12480112038459307, 0.35946456888258727, -0.9304682787052827, -0.7947365683571942, 0.3920611841320356, 0.9272085182804756, 0.7157113986570746, 0.34471890246728376, 0.2991816583991745, -0.8409179486606247},
    {0.4385160631424939, 0.8281085607288682, 0.809443735621364, 0.5185357023748863, -0.3906818430930344, 0.7669504762630948, -0.7595788408887925, 0.688590565391962, -0.6415373233944097, -0.1251907148613476, 0.1072099545935444, -0.11878069655342532},
    {-1.3111264776447114, -0.21330276613770743, -1.1455093303985175, -0.8069973182668755, -0.5402583163183877, -0.835071932188255, -0.8219793863668481, -0.7802365495331893, -0.3673539809378651, -0.8584337457588596, -1.4403624038174232, -1.2868628673381048},
    {-0.9686522976495668, -0.9442549495907059, -0.08321222247320487, -0.6468868791847541, -1.7163513018127017, -1.5660245637217167, -1.0951818464801297, -0.951334294843869, -0.8415768286415732, -0.9870466488339074, -0.1779345839246435, -0.6309714881465052},
    {-0.7446430557897344, 0.6212609702321368, 0.5403105181873348, -0.5753570401338598, 0.5260678623311049, -0.1786041915514812, -0.15429633016671485, 0.009332444711524437, 0.4232406391970428, -0.43999259365837456, -0.7880598931394645, -0.23586012010580468},
    {-1.8898222727981608, -0.7939935975412078, -1.8678570129035958, -1.4818500129840242, -0.5319338073558034, -1.7801662493147445, -0.35342385180322244, -1.4672229071638727, -1.5249925586515576, -0.38342388620896317, -1.3965870947834047, -0.10827374547953178},
    {-1.1191090778229447, -1.1912330990647944, -1.554630123777534, -1.6233273578196643, -0.5750390341111788, -0.4014668861440797, -0.8173414181430967, -0.007352701403028091, -1.318555846011645, -1.292978158274463, -1.2214953944331977, -1.8039852562497316},
    {0.5143620622469671, 0.06483426907228032, -0.23021489429406933, -0.03615222571182632, -0.8148372988802637, -0.35358332974573226, -1.031707507704664, -0.3183413400425082, 0.4683521672721922, 0.1400042644685057, -0.7472926669983694, -0.8086401781078569},
    {0.5534244325811392, -0.5224829050499353, 0.9182020869537959, 0.0628938442193653, 0.7864460829577475, 0.8011217769397299, 0.6096362603722242, 0.9050547242277751, 0.33263883365639957, -0.06506523157219737, -0.829181155647836, 0.7029887535260915},
    {-0.255605192291083, -1.8459780444085194, -0.9666625420727325, -1.650922379007639, -0.8379645096784427, -2.037644302146203, -1.2049856435006387, -1.5924538471995109, -0.819669250621431, -1.981977153151838, -0.8329632263139316, -0.6088140388289922},
    {-0.7549535840855236, -1.7497768164310377, -1.0851864559623303, -0.7357399692941773, -1.035834996300702, -0.790753048383296, -1.167130664042104, -1.6275111230253891, -2.2120122183344146, -1.7855718200525403, -1.205158844863538, -1.7427125830406303},
    {0.029815318550293967, 0.19424149351151582, -0.7999320910297264, -1.11062996012541, -0.6994264096146133, 0.40508312996091805, -0.30612056423286743, 0.04363565479201993, 0.013188395339512412, 0.6628489332280375, 0.14647937491712804, 0.08891564153363984},
    {-1.3795266011989302, -1.4945817880098013, -1.2931075269336594, -0.44271090628382104, -2.11229833366309, -1.3053036131509994, -1.4244911031500407, -0.7104575793691678, -0.4357423238663134, -0.37003079597323374, -1.2924123912904952, -1.8800971308629781}
};

static const float b4[12] = {-0.4914432995648182, -0.5414654045870222, -0.5619257933721995, -0.4371297781181123, -0.6120773711107674, -0.4564092274341559, -0.5576897601542339, -0.4813412068165352, -0.5600829714887904, -0.44912513477579685, -0.46919123297047016, -0.5901295512491451};

    // Input Layer 
    float z1[64];
    for (int i = 0; i < 64; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[32];
    for (int i = 0; i < 32; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 64; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Hidden Layers 
    float z3[16];
    for (int i = 0; i < 16; i++)
    {
        z3[i] = b3[i];
        for (int j = 0; j < 32; j++)
        {
            z3[i] += z2[j] * w3[j][i];
        }
        z3[i] = relu(z3[i]);
    }

    // Output Layer
    float z4[12];
    for (int k = 0; k < 12; k++)
    {
        z4[k] = b4[k];
        for (int j = 0; j < 16; j++)
        {
            z4[k] += z3[j] * w4[j][k];
        }
    }
    softmax(z4, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
