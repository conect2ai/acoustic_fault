#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][64] = {
    {1.3982882528005947, -1.098164611422797, -2.3659091101142646, -0.33569845787710856, -3.6715610335886346, -0.5255935217907314, -1.3984546173178618, -0.7761912575046439, 0.06298307400016241, -1.904845213979503, 0.958078691323945, -0.028324945232457637, -1.752619901200372, -1.2744141241622404, -1.4469061279095392, 0.2784595859411568, -0.9916386418940174, 0.2548700107195874, -0.480236913782849, 1.7832049788593431, 2.8184662504000824, -0.18397898097590898, -1.5369533144245588, 1.3410330198543998, -0.7509280820342278, -1.7735386114135767, -0.12523701761586786, 0.6145248202614584, -1.3195775768508289, -1.7411914920572902, -0.05643283323295652, -1.118360237328592, -0.2668270267283477, 1.4433575888653112, 0.5188117809403838, -0.5361946673278731, 1.2181806010820142, 1.419341736477796, -0.6586012389480338, 0.582906567489202, -2.3577163969447215, -0.5989882929914788, 0.4350249383250832, -0.07289520483675431, 0.2507297408622869, 0.6274783043691106, 0.08175220325642309, -1.8299021044362738, 2.735802368384523, -0.4548155893803543, -1.5566760097546046, 1.1083492186501283, -0.21072806224141177, -0.524763980963611, 1.2473930503786317, 0.684981306313906, 1.5203901758911338, -0.9505553216043621, -2.3766358188030106, 0.6021018489123428, 0.23718339514364353, 0.7101259349204727, -1.1645656551969663, 0.8227292926587704},
    {0.5203652877956085, -1.3782169842875356, 1.1912691708927015, 0.4277858624582391, -0.8373772773611914, 2.5104755390110634, -0.038206369529842146, -0.32773871585926884, -2.593418609996504, 0.5478481333279337, -1.0738700023436323, 1.2436410059630671, 0.22794429319054718, -1.6095029666519782, -1.107910239611662, 0.9166840197599911, 2.413213034757899, 0.8446561575775291, 0.6122637670300599, -1.2890880607313386, -1.9281404138645584, -2.22038173192577, 1.7909022075798897, 0.19533935670118963, -1.3232898915498288, 0.8137350478629142, -0.6990018278741644, 1.2733950921658246, 1.8507945808629902, 0.527539760122241, -2.5369632851241986, -0.1479931441682569, 2.682386980094767, -0.4508358766035507, -0.5346082740794265, 0.3429691295972904, 1.305369204310326, 0.36598468116112626, 0.7925507532449857, 1.7268251289308778, 0.2912082099824511, -0.9752514257492428, -0.039508605321900606, 0.28508983287025785, 0.17419243432619813, -0.20767831545303095, 2.3377325150000754, 0.4781838009010603, 0.20572514478488654, 1.3320143638842445, -0.19400921257024245, 0.39886095902767527, -0.3443161608731428, -0.23162380192877108, 1.0460808151627126, -0.6777655936915865, 2.1366701673381527, 0.9865005751159426, 0.8750118514345884, -0.30223092059942336, 1.6882902903490666, -0.6387662816843078, -2.019489036330392, 0.5008141943415569},
    {-0.1443409909458457, 1.4335675487940036, -0.0031445851325407957, -0.42934659079560344, -0.2637523474568253, 0.19273422714282687, -0.5078853415192861, -0.7697206875467656, -2.0039838590213206, 0.031203065567509163, -1.4691653711843113, 1.3764695969310006, 0.629069451318957, 1.328293656868172, 0.3241860780594128, 0.748174478194209, 0.6971342756081198, -0.08142801153577366, -0.566092788295169, -0.6442699473487911, 1.0138520858700735, -0.011769428967619051, -0.5649880758244484, 1.0070649623697734, 0.4491948256962454, -0.4301635542605317, 0.9913213899693205, -1.060292540194561, 0.6047027694362056, -1.3828821942901588, 2.0785065370038134, 0.5829527877597273, -1.815693650354567, 0.35441063089882946, -0.3869490556549899, 1.8452414223894464, -0.10403110533910156, -1.6165612848281232, 0.28707896576024006, 0.1099024666208499, -0.4743520556195263, -0.5912006781506237, 0.8668527955638148, 1.9633813227928671, 1.990350339345921, -2.311574455831333, -0.396008144950881, -0.7940395893852943, -0.5535474192807519, -2.9050604228770562, 0.709328091492668, 2.245382689299454, 0.8838717270035878, -0.8713325071406635, 0.3428348309218319, 1.072269057212586, 2.2772961317790754, -1.4925250317355034, -0.09711674945873366, 1.978847922634988, -0.438309893162196, 0.6645864958789666, -1.008663994838075, 0.5452455374764377},
    {1.9511810819171977, 1.001710406330764, -0.18966288934362951, 1.165785234405422, -1.0669313485131997, 0.9513738910796193, -1.1138927033062975, 2.4762702930493194, 0.3592379507366318, -0.1959487013084041, -0.7744577168575357, 0.8991082500865454, -1.9636494359033865, 2.52929644799293, 2.044870318765344, 0.5733288989276619, 0.5519407593089375, -1.0168102576874576, -0.40980241891759434, 0.15461136830842218, 0.22907506501684818, -0.7851798882051019, 0.7373468059922651, -1.7413356185688562, -0.5081142745304251, 0.7297155287946857, 0.7802354256035573, 0.8808123568616296, -0.8752629318601146, 1.3956253395381495, -1.5242472024115075, 0.8902765978263444, -1.7792425572406858, 1.597058933035906, 0.482028825008924, 0.6554902789710777, 2.3307797939932526, 2.7169034069074987, 0.8013246327358756, 0.7457743341470308, 1.1983008118363248, 0.7848333584440578, 1.4208177763185392, 0.860275158864291, -0.4238388611478317, -0.9437588032778318, -2.2715232141484223, -1.0613542882521587, 0.6656003198939682, -0.021592221300781457, 0.6239679462174378, -0.08435465425164497, 0.40833227394284916, -0.5494023772763604, 1.281872632379889, 0.08396640902960635, 0.9706456504195412, 0.10210193118416012, -0.299106994028212, -0.17538314272063152, -1.4453363511653103, 0.5678992578718223, 0.7612697432699124, -0.23415833770044414},
    {0.15670121675361004, 0.9962156900971416, -0.944197743587633, 1.6562651153827492, -0.694075395190987, -0.6086668521819337, 1.7860818139003416, 0.31387045152123, 0.09060715517741262, -0.619406758706451, 0.5620670594635182, 0.5737325612490214, 1.0999532212252459, 2.623110617733102, 0.09046010144141599, 1.6261275961870536, 1.580432032052168, 0.37304528063028014, -0.06877939369485059, -0.6296562885867922, -1.328388995256595, -0.26449741750493244, -0.3247473071049733, 0.17227909006601724, -0.7067448805415045, -0.330054394630965, 0.21700479505867562, -0.13954328876266064, -1.1332641202774338, 1.0186119082062834, -0.32691589107175834, -2.417461163726625, 0.09950901015400583, -0.5571080597375857, -0.2440582009306603, 0.7624987446700869, 1.5915497882192333, -0.7569102630250563, -3.577935109736519, 0.5087593670774385, 1.4042800542017881, -0.7293294223054873, -1.3419109461980379, -0.7864737899973544, 0.6772526807073028, 0.17808181976281126, 0.31986336847971875, -0.549826158565151, -0.9033677109995386, 0.1986969750063357, 0.6672260498022383, 1.0820889691628937, -1.07902301418376, 1.227379422795775, -0.028022600133374462, 0.8769592497270297, 1.5319209043529771, -0.7307767463575207, -1.186016047447455, -0.03084848528022969, -0.6264749904238642, 0.3830522494854062, 0.8049900652544328, 0.5174146368766397},
    {-0.3797189373853858, 1.7235653435742275, 0.17352815484236575, -0.4207604069669784, -1.216025693572944, 0.5883739954786115, 1.4773094396060011, -0.3385951457399173, -0.7594906038435608, -2.522100560583457, 0.06903798723369066, 0.1708257285606104, 0.43307611047309214, -0.030405175167608826, -0.7245999044474101, 3.222504368413872, 1.134444526501143, -1.103943537212685, 0.9088695145309375, 2.011960332992747, -0.957664698282631, -0.5696787020600966, 0.579951265723004, 0.9300149658058858, 2.4504795405680104, -2.4611760909035167, 2.1628110455377882, -0.9654360009097191, -0.3068682106179309, 0.4496368190307637, 0.7718061776573703, 0.223088486888666, -0.23218513791066472, 1.3417698505289433, 1.1899443254608268, -0.33770373581201546, 1.1076698220404495, 0.08395151176872978, 1.2220688077289343, -1.5573145150176435, 2.58496765645127, 1.1197291501803768, -0.4878284242166582, -0.8837108311199958, 2.8429897400109367, 1.7059193802979975, -0.9899217005089942, -0.5675855938071729, -1.30080393638905, 0.9801397419308338, 1.1974110541006973, -0.4599609728149139, -0.6833242779630178, 0.3098079878715649, 0.7084564043762887, 1.3447412078965935, 0.5475733262445533, 1.010233465353547, -0.45156278759361457, 1.1470283814810958, -0.7298893685075138, 0.541996276861456, 0.7035348840258238, 0.21427953317536316},
    {-0.14523203486231187, -0.7156046393361871, 0.1413095792621684, 0.7882469040850555, -0.49082588342501743, -0.8114480515554667, 0.5922205578498101, -2.5629208286250704, -0.9776327781196046, -1.7836580272765747, 1.2953122209465375, 0.276549515243405, -0.35310228989443293, 1.3455201414856255, -0.14889877906686838, 1.4544850390629842, 1.0383545749105694, 0.30394040993195415, 2.143255385221122, -1.6663240726910022, 0.09172705431635102, -0.9413632572955889, 1.7257390609871848, -0.16428430072309744, 1.4364136768893776, -0.11702779805060563, 1.4741668096848033, 0.40663898689181066, -0.5924249993665035, 0.4812239842163599, -0.1302247531856041, 1.83096435875439, 0.6421226338505499, 0.27001703080318784, 0.425453466675655, 0.399410221165115, 1.2645157184749716, 0.25363537804361, -0.35164467098011354, 1.1721952206794957, -0.7535019602361899, 1.1467262172544483, 0.6670957722351254, -0.6157393683743695, 0.992167513292909, -0.7428062877568882, -0.5336630811302094, 1.3537326773278089, -0.939701152938707, 1.066308018060006, 0.9758741339297218, -0.18764546604859017, 0.9317009995676973, -1.0710976391029412, -0.06355368175645025, 0.9942169562645473, -2.3679167094556464, 1.576509252463183, -0.24132162242994362, 0.8946426866417156, -2.424225672717282, 1.1400769462817308, 0.6565574233867294, 0.49812183412459105},
    {-0.33978202732852464, -0.9622221963095888, -0.0003100684883287721, -0.8937159540347127, 0.40709546901129706, -0.9986607683685697, -0.33388603505705955, -0.5955463725244021, -0.0018864748473423707, 0.06057734388016447, -1.1224479819068154, 0.3102416559583252, -0.8260360912907785, -0.19303936012605372, 1.6585754919227482, -1.6301473832307531, -0.37610929627856904, 0.35489538353331895, -0.48073618447066163, -0.2178072498057127, -2.567814427534915, 0.7155043189514256, -0.2827082759205727, 0.9626475764280589, -3.519489966301913, 0.44214187017826045, 0.7919630750882046, -0.3088758311665901, -0.5445733863664098, -0.2280190633863349, 0.42821202329175, -0.871402118829047, 0.38555607469707254, -0.8835554728465586, -0.4659476719198466, 0.22178922526114997, 1.3974710441121296, 0.3010180583150908, 0.48113271288253007, 1.3829404489055963, 0.5912783917692486, -1.2739165572644942, -0.6219173410901182, -1.1955524968199358, -0.6645163709695154, -0.09200507420480072, 0.6540113977547418, -0.06720062463585022, 0.5393698809971542, 1.3013285676288495, -1.0885111842100885, -0.6817395172533883, -1.534533342059614, -1.1602285799673897, -1.5373897680242254, 0.5829881174841038, -0.8646774844402478, 1.2903878669617599, -0.0858124304034155, 1.1965256721816777, -0.3742004359406541, -0.5032631688284608, 0.7661514328383113, -0.08192362788969859},
    {0.6657527980685165, 0.7629073744969886, 0.6960225446256956, -0.40350313778621655, 0.6592384265161982, 1.2206357449306309, -0.8145315076768573, 1.2500631613587667, 0.8592661035114456, 2.093324327036282, 1.463760099603302, 1.2082945694124438, -0.23165132512893577, 1.0110639257396756, 1.4428782605148907, 1.5315611074477629, -0.9484084326980976, -0.1360993518427608, 3.0582503561741134, -2.8998043410975254, 0.8467252129380785, -1.0955492360028796, 1.4417239636894341, 0.04714697457708415, 0.6010735329111201, -0.7143605850732506, 1.1785620046953202, 0.8792939199450028, 0.4861311435508568, 0.3500387141094951, -0.07570317820962853, 0.18418930554323054, 0.632923823618988, -1.077163100875211, -0.3274199536167344, 1.4908314528059654, -0.9362934351932174, 0.7827319205605345, 0.8793603737832959, 1.1046067050358404, -1.250289258778971, 0.49081133171746605, 1.8890983935970345, 3.066908128621537, 1.0319608246598506, -1.095616330555026, -1.7846184829759626, 0.7579492690727161, -1.110371749913703, 0.35931801073349257, 0.5309410349638446, 2.094279140862043, -1.8704626733660743, 0.24580693113209356, -0.8318913801709196, 0.3763995946590959, -0.9456865910091874, -0.0299874564221993, 0.8676747558196342, -1.8008159267365613, -0.21652214460560593, -1.573622161579445, 1.8429493414996778, 0.12232139847783009},
    {-0.0029361047941790586, -0.6367736848890412, 1.384469350720008, 0.6971617667484772, -0.06704435120388386, 0.6942495356254772, 1.5994037500001907, 2.04682801101446, 0.26612575308738046, -0.49197363158439505, -1.4308317509187285, -1.1997242762106393, 2.033062097771122, -1.302205558970461, -1.9471352385709868, 0.8521030699105803, 0.9290710067504766, -0.5532153063994222, 0.21636564675472203, -1.3829936365556685, 1.3413245175533872, 0.6405471663427059, 1.175968560946537, -0.1350691454395127, 0.4306457073026996, 0.8200832261088061, 0.6226104431033929, 1.1387881013157541, 2.4974005949434868, -1.2228452085446468, -0.08144105158774345, -0.9735916593423528, 0.21553123626083698, -0.7629907061819472, -0.807419550154653, -0.19724552823666866, 0.023212257857436476, -0.8616030819689964, 1.3898579171082126, -0.03366218181132597, -0.8903260613160751, 0.7107048394666015, 1.1551590427212812, 0.1446774224850143, 0.38823067049955184, -0.994001032746068, -0.8736172325417141, -0.3795487174704587, 0.0973120393876961, -0.5899052726533255, 0.6103332186065301, -1.3872484284982052, -0.9790675260724422, 0.26531672689317753, 0.07903906116846969, -0.8905423126234142, 0.4332740114968403, 1.9912735704582594, 1.0139654404643481, -0.37641367202839565, 0.09129585995043817, -0.9047361374680114, -0.72371525459601, 0.2795871028948543},
    {0.8846450913976299, 1.0483370469856, -0.6869261460550533, -1.1250998418981109, -2.1550355621797275, -1.3193321848732065, 2.477455124999254, 0.5993201505742051, -0.10372554522700583, -1.2423271912974625, 0.19709375703859436, 1.2219431742445281, 1.7483385845518291, -0.5800821345118291, 2.5328153397255955, 2.341376373167527, -0.8574357763542589, 1.0842914675070086, -0.6459232655392715, -1.3050563430284625, -0.8742890770691156, 0.6343073251450752, 0.51832441741074, -0.4762240791092288, 0.9876466037143938, -1.3669219998336215, 0.6467505826335816, -0.7946954503259581, 0.5162337536058829, 0.5843856351434137, -1.1144507781676325, -0.8406479736113621, -0.9472876318395129, 1.2954279930799681, 0.7228474078884529, -1.8058293900755895, 0.13580787294881744, -0.7069190090146353, -0.8297324284313105, 0.9167779741358056, 0.03070597652398368, 0.9331990157955858, 0.2682576646525732, -0.8013804482077401, 1.0354317685178862, -0.629650989053141, -0.4579109978407386, 2.0599213097479923, -1.8269397751718945, -0.5343338094553766, 2.3658039490502523, -0.3610463879332823, 1.579268008368839, -0.3823075622910293, -0.5339117362891644, -1.3499271557797212, -0.5407790184702163, 1.5569657406551622, 1.65570003195215, 0.17068133189765547, -0.11334209029761302, -0.9229826265694515, 0.10595828937386907, 1.4722192979105644},
    {0.7072150797663171, 0.2682115527450933, -1.1165028195437134, -1.3242356758014406, 0.6322126951290147, 0.11992300358239365, 0.42303474339288166, 0.23363045460157555, -0.27925190261730165, -1.241651646245628, 1.3551576239568381, 0.07241511510445499, -0.25028493575410354, -1.2659309753880204, -0.5034655600569029, -0.9074562169484822, 0.7760802736382022, 1.3492912546779745, 0.057394688699293935, -2.0575247418072236, 0.7338850721049482, 1.9084320685414509, 0.16260712093478769, -2.040201990276705, 0.7011920085637927, 0.16984701418244785, 1.4050157153160803, 0.25105147629884983, -0.24204980651455812, 0.4281591495385745, -0.3441448600862643, 1.362434005000677, 0.6830628692680906, 1.2079098387486553, -0.882023739662561, 1.597540727392361, 0.24278235723981564, -0.461394138157259, 0.6331860516856426, 0.5146295360853722, -2.0457719419747424, -0.1251323880020698, 1.7891531995472723, -0.5398105570814059, -1.8675880066050428, 0.49092718938062846, 0.04504808767734674, 0.5547175017903488, -0.05579185060707782, 0.3615233222277711, 1.7662912423586048, 0.7378188032095941, -0.1925747271600191, -1.317539908592821, -0.5372329386344247, -1.2415290007850066, 1.5437421585717765, -1.2901705737621645, 2.1916570113105074, 2.0801353037342207, -0.049307516961472474, 1.8381199429715869, -0.4079362153832291, 0.764296781405311},
    {-1.1087850903037144, 1.1233001962684388, 0.6615087961844902, -1.7691299940417702, 1.1340228683450635, 0.10305514402293424, 0.8771054665714391, -0.8250932140775282, 0.614152395852663, -0.36063501449436913, -0.8077601397036678, 0.29017052584650155, -0.14174013294049856, -1.6062950623417185, 1.0589542894779618, -0.1615307066075528, 0.8859587741962184, -0.10573877062814185, -0.2809840737862429, -0.3908967600320345, -0.3172979198832325, 0.22057379396004761, -0.21508442901683864, 1.3751922216626424, 0.3657829552303787, -0.380919003617332, 0.6111461302838465, -0.757135358194389, 1.3119734759530286, -0.6140923304979541, 0.5530671278612226, -1.1007341824192074, -0.504593649372308, 1.0288953930049742, 1.261161711143509, -1.2517827121009957, -1.1802303274233903, -0.15524467875232514, -0.784153157712253, 1.0517451428130262, 1.358016834039332, -1.245735873324454, -1.8613272381820742, -0.8975916458312927, 0.005997707616711478, 0.2912805637293348, -0.6151372286687389, -0.4974429956271138, -1.0049925394143688, -0.42987035140933305, 0.33290906250677826, -1.1444835600473642, -0.13067883567900768, -0.36689466740534415, -2.4623760324018713, -2.2655453894834117, -0.959126364979285, 0.41924287009298006, -0.29142651239402584, 0.6383009167768969, -0.06502819695428338, 1.135669315709327, 0.21819021505402167, 1.615985142301227},
    {1.2327369018013172, 0.8888154385923236, 0.3800876703829037, -0.998735629744905, 0.13965246444860144, 0.2913187011679363, -1.252060992374736, -0.2197389265385806, -0.17838424268269745, -0.4594151460110767, -0.9009478611978939, -0.7493988837786716, 0.09994824647826468, -1.0454188337046437, 1.40172499349988, 0.090960623014379, 1.011087411963968, -0.17340373569960232, -0.1937044913293757, -0.494064253382075, -1.8482858123352957, -0.9047985768728299, 2.5314731314833683, -1.328462390187955, 0.2765258043086672, -0.5404563674753579, 0.392315839580071, 1.2575652162491122, 1.0287320358256529, 1.0911971279884993, -1.0462050468790458, 3.735083234608493, -1.2159516847237475, 0.5686869772091943, -2.7331858787040395, -0.9153112374667844, 2.498395744419681, 0.5161749013917987, 1.7392417997737546, 0.7604666917861227, 0.24065395831455125, 0.06106939358662177, -1.6915909688097646, -0.8457031572389354, 1.9151489774725332, 2.0359447958229175, 0.7317720394257766, -1.3319577121520165, 0.3941878759107843, -0.751208133842269, -0.634938469946362, -1.6995234521582927, 1.195185639376098, -0.6576758180151037, 2.974210293401349, -0.6036712410092292, 1.1241862654841506, -1.500246660987317, -1.4047086684874703, -0.34174209969347824, 0.16611982043428425, 1.3899259632718608, 1.8499352554797865, -0.2289081856589461},
    {-1.7166765237680852, 1.4818205284280415, 0.7890832904610151, 1.0089923835866321, -1.6582051346170539, -0.48485942494413037, -0.3798058551985267, 0.397430796053522, 0.8901794852871434, -1.0602271730254125, -0.31864283180435665, -0.40243205294568063, -0.7476281313341211, -2.9115377867231946, -0.9215206422520414, -1.0544312692948465, 1.5956048340824889, -0.2901299546470953, -0.35589686015247296, 0.9608926757837452, 1.2133692901754733, -0.3766022253925775, -0.672751768470255, -1.0321008070628157, 0.6604306657861865, 0.629822146648094, 0.34984135522423526, 1.6823828917696604, -2.103509558813151, 1.9620316598645353, -1.005255530755633, 1.5040386072772747, -0.9768855879587893, 0.0571919558148112, -1.1770014998195595, -0.14023329256844339, 0.9583639580848068, -1.2941737629479433, -1.2987936854979125, -0.9006637921944715, -2.6390652865675097, -0.12242834688391942, -0.3809971249362045, 0.38229647773362563, 1.4675821459026392, -1.2167229200338732, -0.9540199160445747, -1.6972238987430348, -0.6375496921277739, 0.40944927894420136, 1.953065296298517, -1.3984187386290778, 0.3901483262823703, 0.4796634010853302, 1.7042198678938665, 0.7995205207961973, 0.25302765556040324, -0.7624378388345315, 0.5409690723185528, -0.006909148980217733, -0.558797249455688, 0.9064238216274669, -0.6799818152820355, -0.8901055449930111},
    {-1.1250357821440147, 1.4004531021003632, -1.0197758618464137, -0.5916365350126979, 0.31809170980874013, -0.2782859002609502, -0.13646355354263784, 0.020423542898722728, -2.1363059288822286, 0.7417458757383253, 0.8862211473784503, 0.8343165197176956, -1.3962140503080789, -1.3889759569849593, 0.10360232484897534, 0.8473739237520318, 0.6326753347090586, 0.11396959130941522, -1.2104889908278738, -1.293430260305006, -0.8912379564413196, -0.5701902450217191, 0.3429472396012118, -0.4131905434763201, -0.5779027810310344, -0.3267752778608149, 2.113986108917772, 1.3760982039437806, 1.0811460929281629, -0.21781322347142312, -0.4631309510587988, 0.6286091662379228, 0.29727024743395475, 2.3656717670675205, -0.41792270408528726, -1.2946218955147404, -0.17913293125910576, 0.5735750791323372, 3.942570378222851, 2.1177510525611654, -0.8690735206548098, 0.8055890609951368, 0.8847898494317744, -0.6300361390752287, -0.794866502653787, -0.7449990880728518, 2.1302558987887545, -0.20901168651124383, 0.19735214065562093, -1.8306358118587591, -1.0614148448254694, 1.2345698065445225, -1.580902865662729, -2.812646045530329, 0.258406004362529, 1.1896291538119776, 0.5273170029979821, 0.09524535235366642, -0.8039310108517862, 1.1959484218880538, -0.25238375591994205, -0.9410102133549545, 0.6123698375310968, -0.8435994364006721},
    {-1.211698253822234, -0.473379509460186, 0.15705347968620653, -1.302257778348784, 0.8497452444783385, 1.7281510038156274, 0.5321387829048223, -1.2620550983511967, -0.13583122795716776, 0.4217534757023224, 0.5362088081975794, -0.5320525608194507, -1.8603341833392442, -0.29017407778091675, 0.10689850465801481, -0.41706759205080485, 0.5213382627223805, 1.9571219673664986, 0.40706958710322744, 1.7003446848354908, -2.552826192309117, 0.07992725420980096, 1.4937249657565734, -0.41740103589086064, 0.34985862928325595, 0.9910647816592469, 0.6330899467362235, 0.3149446715078092, 0.3176023131962445, -0.10234254686522361, -0.5362345541988552, -0.005637396331430343, -0.39577980382529765, -0.5973437148674158, -0.5137552512950532, 0.8280201590992194, 1.230611653794527, -1.6876190938558886, 0.49056757453032196, 0.16946598494227402, -0.9506620265174596, -1.034755558859865, 1.8870487993101612, 0.6152895339873443, 0.21348390953231555, 1.950913410616344, 0.18027144081806648, -0.7783893493127749, 1.8361486834902772, 1.7132506441366817, -0.40652037403062685, 0.3984486325002911, 1.9284134464524105, 0.28520307884435325, 1.1252003170910176, 2.939803600276968, -0.5655914928806859, 0.7233401512716435, -1.931954858839065, -0.5876029586916522, -0.6524007734151289, 0.3673152924170471, 2.4467466383924017, 0.32609888423881805},
    {0.2744315061573921, 1.328185328908175, 0.442645137000384, 0.1343957335919841, 0.10256605388633355, 0.5424515868568703, 0.5450197547046397, 0.08726180468217862, -1.632627275055432, -1.1098312985139458, 3.4904452393823986, 0.24613005896446433, -1.1808745868343353, 0.5700994576956554, -0.6606753740873291, -0.10974005880160724, 0.2650256893750146, 0.9444485852756469, 1.5938067929479645, 0.37139625551178646, -1.1187047231229996, -1.3999252608309813, 2.8237130383252196, 0.9467488969569008, 1.004788404954744, -1.0087424739764, 0.502373189746228, -1.3321591507053465, -0.23885771952578297, 1.3969448914276692, 0.21098903426279497, -0.6877516222472927, -0.14454172432189394, -0.1155369997803275, -0.5191066791924157, -0.5375583516799519, 0.14299084014985788, 1.6365262688020517, -0.2165603263951775, 1.1965339648686326, 0.22556638017607802, -0.344263465381611, -0.0728929249811699, 0.8680409030426366, -0.32250354335249587, 0.602733598908238, 2.2374425886832396, -1.287891044988402, -0.26429876244389056, -0.540363406582645, -0.9839867708992361, 0.5114013075181859, -1.4334213955900033, -1.3386656577359066, 1.8698725186236842, 0.6974488517959392, -0.28927812331498354, 0.870659932212695, 1.6378549106306806, -0.6409873546548974, 1.4045652343242336, 1.3154007319643346, -0.396352920552769, -0.9178602493039735},
    {-0.659124040661527, 0.5263945065866175, 0.48031360058946276, -0.4488070402464464, 0.019645906978722115, 1.5991494088966485, -0.32448780848986863, -1.2393916253696737, 0.03645537073466219, 0.17897141728221047, 1.2278906950607875, -0.251497421204153, -0.9761197460951426, 0.685803515134951, 0.3753983978614985, -1.0325552946746823, -0.84953113515281, 1.1960509411565872, 0.4693440993075748, 2.086603357445103, -2.175567847129542, -0.21662322459627054, 1.0088813678343806, -0.43469907925332296, 1.1773846622595507, -0.234865324209636, -1.0320895888697332, 1.1571281119431494, -0.6330558350049917, -0.46139490128488614, 0.9738795171053674, 0.7102095582474378, -1.3432942464957554, 1.1340196307432313, -0.0065791449527583265, 0.7118012966106022, -1.2712073614722492, -0.6417230312216265, 0.9136899736927456, 1.1333462673547796, -0.7388984600113803, -0.9838651311636196, 0.8020233934804223, -0.23177150069940658, -2.044067759299592, 0.6948383373244531, 1.6526758142362228, -1.1478895724062166, 0.10855938892272536, -0.6025187070427865, -0.9622375029181711, -1.10423731428663, 2.38495297707989, 0.306438802469392, 0.14789011091608517, -0.9076473981498753, 1.182666188132336, -0.35178968273256034, 0.37279732000804877, 0.0004826755875270099, 1.3021887249538326, 0.2897595761208243, 1.2031496567378899, 0.003740306487937696},
    {0.6671569827268987, -0.8270203456436204, -2.4302287093552204, 1.3914276976127082, 0.6749784394615209, 0.19212636796607796, -1.4057088867010372, -1.2755608761096546, 0.036450339411880917, 1.582063954233946, 0.20352573536921129, -1.9626889017838265, -0.21223331223243314, 2.4988188463981866, 0.23012529539779045, 0.5731955464379463, -1.8267240003959175, 0.47541586505683725, -0.19102286607913432, -0.2972679222943706, 2.3433609936538797, -2.4635695978742183, 0.8545932360296754, -0.23759921224359432, 1.4613074777242645, 0.7244479116908248, 0.894523172341924, 0.22220163047941452, 1.1372097954691467, -1.4860275229105333, -0.4212327821490269, -1.249913952149004, 0.8849485191657782, -2.17205896057017, 0.142653809555959, -1.148711717537284, 0.3654985737516861, 1.686226765448664, 0.35064776948963067, 1.1111140854907595, -1.0659394728598957, 0.03217060901765347, -0.26748779733665184, 0.7579132863759328, -0.9817500046081146, -1.170697663131691, 0.4674814233270346, 3.663606880027801, -0.4947402694456312, 1.187430263461748, 0.2542540846460034, -0.690574258994889, 0.4957948827109265, -0.2701460614575051, 1.8720830337988208, -0.41653891974425084, -1.9245998760768905, -0.8901189004313085, -0.7810238188693731, 0.8278359167997998, 0.9718919189254069, -0.04728814517290378, -0.8895868663962962, 0.7776952500077431},
    {1.005322652724072, -0.19688981048389176, 0.13154017690497127, 1.7951326841105708, -0.38089448154749417, 0.5164123579392144, -1.826024457242224, 1.3034494202023588, -0.12423121584631272, 0.3285706762092018, 1.1481485845744204, -1.1477828718956156, -0.04299027553872585, -1.4086354493040605, -0.43762678137928784, -0.013476073192958229, -0.3281561362544899, -0.00828180794655996, 0.767462664145371, -0.9862390707034379, 1.1901802834941002, 0.9267257915360368, -0.5042315570754999, 1.211230239047108, -0.004503699661858363, 1.4208907580503038, 1.3416283189511338, 0.9162560745168273, 0.8937068480654864, 0.5957687641771727, -1.2424388727526663, 0.3107683730568317, -1.338189331773285, -1.4945344821337585, -1.504537912594703, 0.05184947139950561, 1.252310901578425, -1.4142972096036723, 0.15406898159683297, -1.1011113792532534, -0.48511981649089647, 1.1919941379745946, -0.08571103628226477, -0.21571222242808305, -0.7333430322453319, 1.7021753676916729, -0.17410319922858303, -1.5644542854388706, -0.36437740844108896, 0.19764771657369848, 1.5334977701385377, 0.2219893902962271, 1.0270578661838616, -0.7013967380699393, 0.4785232914617255, -0.364958277253937, -0.7733587395056404, -0.52992370948609, -0.7539350897053014, 1.4178782588853014, -0.18161258632408922, -0.13391511050756955, 0.4552879581195159, -2.1495077323971077},
    {0.03458485129762002, 0.7101076376009203, -1.60005760872185, 1.98373135945167, -0.18104387040645342, -0.6422111622781939, 1.485545713469055, 0.047464259564317754, -1.2135015251479875, -0.7657964658120839, -3.622328322980961, -1.1189173335690443, 1.472381213409332, -0.1062197465328404, 0.1685616423215364, 0.054678732289123316, -1.5126577912583383, 1.565040317415766, -2.376718853465344, 0.2807490121849032, -0.15742816598112122, -1.807670806923219, -1.1296611042270257, 1.2825395612442612, 1.4792728826078736, -2.7525618758652053, -1.65868546088997, -0.1964307123730338, 0.5118409023506333, 0.7227819921806673, -0.6035734499883054, 0.40412031756336897, -0.07272722879615186, -0.4539768328870497, -1.3501683610119017, -0.4418133217385426, 2.3514738974443015, 0.25632792360800066, -1.624465115597319, 1.6281803611174828, 0.6851264779853137, -1.6868647130988876, -0.2787879787143902, -0.8760466002644893, -1.3763304783012875, 0.023070841316607093, -0.1966830129453698, -2.1337172239355358, -0.8565035297377884, -1.8618936161941666, 0.04496065745850958, -2.200479719293305, 0.9890120047780973, 0.17919267089228416, 1.8758587684935426, -0.06893727443597089, 0.386197843235633, -1.3754670819924075, -0.46011169684123304, 0.47587473182459306, 1.3421050821350071, 0.5241495962614013, 0.26008437842321047, -0.25058660932908045},
    {-1.6849056922962713, -0.09299873494734688, -0.742884342390097, 0.6018006844408296, -0.7909198017372444, 0.6481470991037984, -0.7646864130479732, 0.08912888564164088, 1.329842504147488, 0.4227059395572594, -1.2770292218721822, 2.769619100731032, -0.9297593254411219, -0.5357920271146948, 1.5787060215846611, -2.251364657209132, -2.7693523138053973, -1.2210021819974028, 0.04586594820667879, -1.3537614960877062, -0.26320450815435537, -0.6599240703905117, 0.42885256194760735, -1.5361102744659785, -0.10056819791410669, -1.1941606035044503, -1.3003080324821894, -0.11502501665303895, -0.14104421992693333, 1.995098433462972, -0.9940781031388473, 1.1413182383618496, 0.053701199476481894, -2.127902792328605, 0.25047070097534435, -1.1317277128357528, -1.2491381934096675, -1.0494200197210526, -1.0807631271035272, -0.13931593694070007, 0.8171714407451596, 0.42553382891120584, -0.4200740805386688, -1.2549677174130494, 1.2822961657568008, 0.06613028028684532, -0.46619164777776273, -0.7862694518426792, 1.4837158049791244, -0.42207368433360193, -0.3853123246923969, -1.7658401675902315, -0.379300233333158, 0.7390716500589697, 1.9735746810677313, -1.2763430970388672, -0.3880696855370924, 0.17705928346540714, -0.1048368681507368, -0.5039389978941813, 2.0769748773575394, 0.3956045758088776, -0.8730007455007589, -1.4737188404972943},
    {-0.19813750980670977, -0.9991167796517685, -0.029763746872605096, -0.1812001606725501, 1.4119465996452218, 0.5159885304807134, -1.689570361191336, -0.046669030179528434, -0.05578398428704273, 0.2574765221959001, -0.7597474598612873, -0.13745580947402616, 1.2703953981150355, -0.4238963186480252, -1.409352379300147, -0.20077132864832195, -0.2240699870528238, 0.3226986544857208, -0.22860231338147666, -0.23168680188000776, 0.35395077038352213, 0.7220804640103481, 1.7499488605149476, -0.35215137300649746, 0.7836024750371899, 0.08185950861264286, -1.413551841056498, 1.8898397836933674, 0.4292672532072696, 0.7655336951867069, 0.2732864501961164, 0.5363300018869855, 0.9002966701268812, -2.4321397996903884, 0.29823163534599506, 0.634671060428429, 1.430412425707886, -1.0084244514050338, -0.0174524416480766, 0.39052800424744927, -0.9862845682005525, 0.5168541046470946, -1.2331510051007446, 2.128095979789118, 0.382727797974217, -1.0331110944277202, -0.25590372989599425, -2.2228681850498972, -0.7776491532963237, 0.006462679753016714, -3.069415773940669, -1.8190177669155931, -1.1203665962491085, 0.13977734907729736, -0.5144385160341542, -0.520151304666949, 1.8571744561618249, -0.6658505964025393, 2.3085985673270017, 0.6272222182132524, -0.5966052231653676, -0.23236646404177358, 0.00043943964195398516, 1.2852479417454061},
    {-0.5955507418108725, 0.5925735934072651, 0.18138283936168778, 0.45094238490022986, 0.44073192608091216, 0.287915956106166, -0.15798224005070777, 1.6332851117125826, 1.6906240963712384, 0.8538884980945134, -0.1189537088210741, 0.4676478671472428, 1.122419649708159, -0.7197962788641092, 1.1564404491616496, -0.1380968557624836, 0.998999448361554, -1.7136294808430872, -0.1887945362797489, 0.77018586640446, 2.589598248653435, -0.2058888053374895, -2.240837721462826, 0.7618566876743624, -2.291304543511542, -0.45720942635137346, -0.7438032990674966, 0.7757612391705203, 0.48858456735917766, 0.5350593518122305, 0.5008033238395146, -0.21013242906712787, 0.2220211287764561, -0.1729485411943355, 0.01062943281344703, 2.4802834355905743, 1.8777301642421589, -0.038277987889418004, -0.506410718016735, -0.3774280539468653, -1.8398364108327065, 1.5551497193715336, 0.7051602346267604, -1.7603523866718709, -0.1802788670215135, -0.42556816299151384, -1.6194358549128387, -0.9463106669482884, 2.062505371668214, 0.5140332977433801, -1.0369666687801098, -0.6899405903500697, 0.6416256226400181, 0.017136922045451065, 2.4265784202478367, -0.3565838166768953, 0.1268584631036483, 0.8114679707406882, -0.055854601274995974, -0.5417447846270272, -0.5752248945746324, 0.38428123812743603, 0.794500779733211, -2.395571342546911},
    {0.7500798562132113, -1.208484128937047, -0.5454434624805039, -0.7175360249932655, -0.19070807856789784, -0.8246123593841026, -1.5535895797924208, 0.32339253329002643, -1.7306454167617578, -0.46858963174333895, -1.2738898861970793, -1.5093519189131337, -0.8475790604907363, -0.641744272562798, 1.3564419839891828, -1.7091660590748512, -0.3442232123026432, 0.7792528995677082, -1.133819257989098, 0.5814365679780503, 1.3393440354493154, 1.156831592294043, -0.16452495373885323, 1.5406530439851143, 0.16598759854009193, 0.6566787413618205, -0.46044832711265987, 2.2896817620815915, 0.21800560419091794, -0.20729122879955758, -1.4402240497354482, 0.13771007802152577, -0.5806303570706802, -0.8138609876539296, -2.2456089603249083, 3.1184283930539562, -1.3958472103554176, 1.9728447070735964, -1.1244960968339521, -0.3796079476171243, 0.338139645212106, 1.775087775613747, -0.7759110899245449, 1.6324928605513378, -1.9190940396645195, 0.5047440427730556, -0.5346068325972428, 0.7500092136451839, 1.312426752257855, -0.5279428952647317, 0.3862153099559845, 1.8078994606548864, 1.1834223878346113, 0.0971006470486214, 0.25614611959904665, 2.3589808895206166, 0.7895822580045767, -1.79367598838586, -0.3660505394838842, 1.1095195350605076, -1.665737641320871, 0.27317483209655646, 2.609305178985405, -0.7455553176118218},
    {0.46148800197514867, 0.08447081314039097, 0.17176866395514537, 0.9602502775189119, -0.6521679330019922, 0.015002402405392117, 1.4920025124944312, -1.1027370185555807, -1.3787605221781691, -0.01712499796347209, 0.5214162930045867, -2.0537014067497137, 0.5109202585133145, 0.49777522574471456, 0.5046429598700951, -1.8302239216877823, -0.7486820545167859, 0.4738564761617538, 0.7770052719522667, 0.19220652300883995, 0.8303145459382306, 0.3251941260173189, -0.4757758047458387, -0.8891244792094314, -1.0298616252952475, 0.7244206497086597, 0.41129222788925535, 1.2320577810278366, 0.3062935810537712, 1.0122502855517543, -1.1068056137801134, -0.6009127590630138, -0.3492141600834234, 1.1832232892754986, -2.3554562785970443, 1.1152023791401247, 0.5755624869964628, -0.3936432059477219, -1.6576237820959319, -0.8634833606650144, 1.1245429123846988, 0.47218004068069835, -0.948718322430833, -0.8430958779715904, -1.7384909430115665, -1.3405006164108302, -1.5172467942183798, -1.8337299917707666, 0.17248279374747114, 0.974165205249776, 0.2787906314452198, -0.2644964488856711, -0.8488246640123185, -1.6810468121571132, 1.1262459440445594, -0.6571596364976797, -0.44748040074333967, 0.8038411785422721, -1.8916373585869597, 0.5687257136630801, 0.19612910898290833, 1.44197305686709, 2.404126298235884, -0.2813829473958264},
    {-0.02919476652292582, 0.9755291887803409, 0.4844399609361221, 0.8919645303707038, -2.3746524565512837, -0.21466121806142094, -1.0178283813016813, -0.011505011898279809, -1.3987010715909212, 0.7037922100651192, -0.7428003388881425, -1.7638040034492888, -0.13093360438531007, -0.5768983043522834, 0.41625015736690746, -1.4879174194772984, 0.5539373324676294, 0.05954021117469659, 0.04355648741811477, 0.669912146362042, 0.25211593001470484, -0.29670307694703174, 1.3716506929105934, -0.2091425306076573, 0.6532463707282521, -0.5763733768284401, 0.9214646282885363, 1.3488611163487172, 0.9825546202558909, -1.4319343505998736, 0.709761636748722, -0.6919920804854028, -0.3896730982359001, -0.10169993275406512, 0.7553537847708999, 0.055818275913653743, 1.9330459051006168, 0.21971508256478425, -2.281832545149353, 0.09237210114742839, 1.6839706685899782, -0.08600326827443548, -0.47058560601915783, 1.3644538711493905, 1.0790443604654552, -1.342854117480065, -0.813647198848444, -0.7713513507893603, 2.052854154721574, 1.353355698862077, -2.125425067827693, -0.8239709462424327, 1.1598398089987776, 0.33692759237730635, 1.5340430478066667, -0.9343402882609431, 1.002763264060307, 1.4926343842203331, -1.3880778339828113, -0.9536145635856388, -0.7756198805047615, 1.1681740905259888, -0.02379920775720542, 1.0713544728080389},
    {0.11218685596941726, 0.38317610620892123, -0.0529669425554339, -0.7228325543071581, -1.7782042791092003, -0.021605690024015353, -0.7252713789416015, 0.451173056752452, -2.1527307670535536, 0.09140156219604338, -0.7001559693103038, 0.5824598471347548, 0.06720780212783144, 0.8599788673878285, -0.9223137948942429, -0.815631191157534, 0.4237022576358074, 0.3426735865994952, -2.6164998409765983, 2.3573647593473956, 0.37699213409855303, 0.04518038464584706, -0.3929264368913846, 0.639205844675239, 1.0363649419076661, -0.21753193880961927, 0.27424333313238075, 1.8001273352134572, -1.4054113960088894, 1.751316269150689, -0.3575082550866432, 0.003946140250093913, 0.582517856869019, -0.15396400601042137, 0.9460198437571881, 0.8427028711394974, 0.28998911191839355, -2.0342825460949046, -0.9560769306960368, 0.13610219408043026, -2.2926048635476186, 1.09573352877419, -1.2971997101080928, 0.11502427888906995, 0.6133419745148623, 0.6596389152095782, -1.1096264484156926, -0.16072552569213733, 1.8894668784381101, 0.9281945931773975, 0.28840866832801443, 0.7216875549300622, 0.818767041885884, -1.9868821863877928, 0.3267036785774599, 2.1531865263289314, 0.8729524058570481, 0.06420484727460339, 0.3141412371969984, 2.6939820553897693, 0.055524113800109944, 1.7520921822313287, -0.4760868134726107, -0.6001043101487676},
    {-0.019623916413286698, 1.263240896971832, 0.27775490658834245, -0.6011810460184283, 0.16559574482396877, -1.247764130624991, 0.194793157723463, -1.2716080290347864, -2.3686146681505136, 0.1166006963463923, -0.9550585318686404, -1.481871573076699, 0.4519222005039477, -0.14699529438936598, 0.8527719692317647, 0.09167399634717024, -1.1031893753877065, -0.4847478242759849, 1.7184807785949305, 0.09057998405350173, 1.112040441626612, 0.023434925320864615, -0.5406257434219826, 0.3578659441116387, 1.3407852517743433, 0.759905971930484, -0.23035553015880747, 0.1453331224769311, 0.08298347791239313, -0.7871672770438486, -0.12784347436065843, -0.08961119372490965, 0.11926161990901224, 0.27282875877002294, -0.34266200853637796, 2.492101254351145, -0.8524146296979808, -1.2476401365982275, -1.837058624293907, 0.9017241026128386, 0.5568199877543837, 1.2283600600681297, -1.4163177677478314, -0.0038305946597831783, 1.9564349994593033, 3.1537386143027892, -0.9569554689062187, -0.6142419711337269, -0.16884592556671515, 0.8870746955032695, 2.776945187110778, -1.0793089144420889, 0.9467747787179999, -0.008610125340329487, -0.3218860486537746, 0.06751937806037418, -0.8627758540284458, 0.566334652989751, 2.516979266029171, 0.9755274077992679, 0.06364153802448319, 1.4235901809138316, 0.6869639759313421, 1.6956204422331562},
    {1.4465367163816114, 0.3464339705447768, 0.46484570394434144, -0.0384897708953515, -1.8958749088329117, 0.10269874393901907, -1.404925059086452, -0.3043497889292144, 0.2688669143984319, -1.3428670419376418, -0.0305656636628115, -1.3239292522733652, 1.627264831151875, -0.8939399469319061, -1.7900798920100742, -2.4021022060316106, -0.19927059850295978, 1.1085095511603704, -3.209215198916116, 0.3517078098379886, 0.3274981147972276, 0.8248192945502999, -2.0914135313939384, -2.4034695268841606, 0.00899014195106269, -2.277710311548356, -1.047531270078166, 1.3453553207092122, 0.7653865836898512, -1.8422445266069758, -2.300566730710908, -0.22840550504668847, -0.7874067178435374, -3.1568780646250514, -0.5090393266896028, 0.2557318578840572, -0.8531521996052621, -1.3816826698654763, 1.2822557629796814, -0.0626361555282157, -0.34932655744882285, 0.04977301334770879, -1.2684196581741443, 0.2938064142372186, -2.0904932108605037, 1.0999525017376246, 0.2583079629102646, -0.9694519938780831, 1.0034916862460022, -1.6866602040564866, -1.1943190685775653, -0.5844387883569819, 0.870058658027255, 0.48794940166054873, 1.0814892560427127, -0.28931866929847355, -0.028453901262806863, -0.6759754702952158, -0.5276729021779322, 0.9177884883780397, -0.5553868717483155, -0.2477706139704047, 0.6265146624411484, -1.0996265576991935},
    {0.4742441887287194, -0.6021772532494094, -0.9475446006967295, -1.0052661131624632, -2.110515470708923, -2.717251366384613, -0.007750358890035882, -0.21649596345687616, -0.1848785610411324, -1.3961002825002893, 0.0032594875396174524, -0.7236806792977964, 0.38906869547961537, 1.1140939944311476, -1.0188493251709043, 0.11224986718793489, -1.5344611510448198, -0.07035629995619866, -1.9063335151839897, 1.8194443554388666, 0.8975985336076263, -0.3301168159053892, -1.4255790546367964, -2.675031123987076, -0.9571593036175187, -1.0328825666128767, -0.1088944168516724, 0.36588964432199633, 1.6152701783796282, 0.4221676991743727, -0.4578509546894489, 1.9213589962845845, 0.7814517716891853, 0.9630118317697975, 0.9397969220487902, 1.2919634004225073, -0.25307313664599873, -0.9181255758570347, -1.2756414905448765, -0.5741908934963192, -0.38608034328805646, -2.3400820443114627, -0.6463298654396072, -0.10644176470087784, -1.759506254115588, -0.43829829183228797, 1.2016707993333733, 0.022891520921484675, -0.060739394782633474, -2.507629333306926, 0.13343978518838442, -1.305371433877398, 0.9070273309351724, -0.9911194087892173, -1.2054512192193956, 0.8435132289309594, -0.07523049706827649, -0.44219869693734537, -0.5046370762137405, 1.921512944114566, -1.3174656112934735, 2.2437071989896364, -0.6258813989491763, 0.7319087949828694},
    {-1.6987023822708476, -0.8546211731725134, -0.417820942987488, 0.35351313089554176, -0.7531459975232843, 0.24755734161434392, 0.046916562906488574, 0.243732340227893, 1.001138247678397, -1.4633173031226372, -1.4260117234743896, 0.4137932718910119, 1.26992406481905, 0.38370516775979746, 1.030009388810749, -1.0167927082271182, -0.5107115323402482, -1.8082559630551194, -2.388024118914986, 0.32526204133317327, -1.2364314801301288, 0.3793972210430627, -0.05662436882254848, 0.9378024542477891, -0.21938543910827613, -2.596505913643873, -0.19689015604474944, 1.656162363377091, -0.7614098535878722, -1.2940135990972197, 0.2490767646940145, -0.32633636748492445, -0.6354962602109885, -0.1344188162760807, 0.6493639223148981, 1.4420923700896342, 0.2276574698002618, 1.6258963587007054, 0.10578112630600338, -0.42104099389778, -1.3773988776333967, -0.5696089877495026, -0.3149247329634232, 1.5619511620176163, -1.7158022287508543, 0.15548577968120408, 1.2544963816854529, 1.1858490802120998, 0.3181035019889422, 2.1427253847029326, -0.5557057301636833, -0.0605461558631471, -0.24641838805396166, -0.5013355178188847, 0.15658226803914158, 1.784458998094606, 0.08200757153880293, 2.4211455101599713, -0.37537827968654275, -0.4024512032689742, -0.3445788472206025, 0.07478607648105882, -3.5461267675938797, -2.1497404673585554},
    {-1.3285824265379338, 0.45673521401376965, 1.3276204445453053, -1.9022381877355385, -1.4489835438700798, -1.198004653912859, -2.0604513649661813, -1.413402048785122, -0.12921170471384122, 0.00783668844460848, 0.61472673008169, 0.9986048415484785, -1.6324433960252684, -0.6610567448443798, -1.9212943030940324, 0.8661154548103014, 0.4283775668718686, -0.8848355350306726, -0.8323775374287609, 0.7300100363068531, -1.8206731393597086, -1.1168322939133486, 0.952097604817924, -1.3765449175123847, 0.6119869400638638, -0.0885168779341579, 0.054795895000368924, 0.5796002435414068, -0.37976725011943646, -0.161983249148274, 1.2456237524505342, 1.6216240398252249, 0.2567779097989591, -1.9258403041501633, -0.16201307071390778, -0.036592033252163626, -0.4772367562347978, -1.927430598381218, 0.4207314455418122, -0.2934715150513169, -0.9606992347556339, -2.6256303031500847, -3.0185285702172835, 0.3606350928704418, -1.267650409325041, -0.8567423770937197, 0.4310332281288573, 0.43442191287906795, -0.9571883895463132, -0.3021977956967744, 2.70143399311503, -0.5515178594013823, 0.6824990428550873, 2.354887089107738, -0.1598708739180267, 1.693114231471247, -1.7761677324379885, -0.5060117375347529, 0.3990830236738594, -0.3779872047725487, 0.3275432189500929, 1.4296657907801984, -0.41114686961823416, -2.4349208722826394},
    {1.17743477401779, 2.0760763428717044, 0.8820930871251281, 0.8001519319583033, -0.3501815128397854, -0.8176678761450246, 0.13603723579586893, -1.3325813254142473, 1.5435365814725186, -0.691427149989563, 2.7786059765049744, 3.51004743838821, -0.9027884591458862, -1.3125518926329922, -0.16473040978301673, 0.3125051920572962, 1.086101509327564, -0.002311868029245881, -0.5469838978804309, -0.4127868195536807, 0.9598321687602805, 1.3732553616290826, 0.7038910899064275, -0.1244371579399068, -0.5515229002484616, -1.4682167140101814, -1.7323123810957526, 1.110721868546404, 0.4827594631160138, 1.4622514293076976, 0.03332373666414861, -1.5705917805122662, -0.29697897333649337, -1.4750257583097592, 0.9988260225670118, 0.5846730004410992, 0.432726745058147, -0.4285856157350341, 0.08963043402827119, -0.7552838940025338, -0.8109685734120023, -0.07225187160265391, -2.2332467012416597, -0.0974095103429875, 0.22244400135359588, 0.19874691511724085, 2.6955326024538784, -0.7996486708696491, 0.44876960864194837, 1.2198010209606, -0.14280617892908543, 0.23212912502049218, -1.5692650132353452, 0.6652127315042147, -0.7595213867808647, -0.24938928915046016, 1.3728250672543978, 0.9530025985115911, 0.909959396248268, -0.9140671224467217, 0.5101975058395383, 0.03154626839972861, 1.2343084053346132, -1.0772173316166198},
    {1.0583169619361628, 2.5871104696485707, -0.801571162429816, -0.9046163261316552, -1.8880216921472093, 0.5359693451582094, 1.30066144272845, -0.8369736141164106, 0.11525809363138803, -0.07232712321587924, -0.7910119359764194, -3.207038328907183, -0.46415072852620526, -0.7154849996529788, -0.5534053508739949, -1.1604578532367762, -1.4951697075620138, 2.0686203560746037, -0.34351357919380826, 0.7397086093180447, -0.42651840708127736, -0.6413748651835582, 0.9254135258430048, -0.013249566103961604, -1.5168563126626027, -0.38498227934387325, -0.5921895341064985, -1.3373024525577257, -0.48403127886007286, -0.683671833526122, -1.7540550095210206, -0.04116018760277485, 0.12075903804505608, 0.03897768198020259, 0.11123560100405414, 0.6624037083790434, 0.4072791408942396, -1.903223164207145, 1.1533544932928288, 0.29469071065414515, -0.811417463817087, 0.9334195241616331, 1.2701131868578044, -1.1391659486521029, -0.06368791883776585, -1.4999102570343414, -0.3377979161420839, 0.09696988276596806, -0.254399953366762, 2.4024628742805603, 2.0790597404072044, -0.8836415571228902, 0.34244446684188673, -1.1898037243319792, 0.9816538583031058, -1.3734894401947086, 0.33876738412721974, 1.09416296740533, 1.6378124805018768, -1.5645271015162234, -0.07493115327847788, -0.02111805418867941, -3.188552483866345, -1.4845857624960546},
    {-0.04090813388152041, 1.444356073494759, 0.7816248908813734, 1.2309387366734568, -0.37215842628962825, 1.6100114576782232, -0.3299489528288326, -0.22235897083001543, 1.982135888555279, -1.1237002459890617, -0.5298491423310058, -0.8259837074396879, -0.24490207339928705, 0.8734166267462502, 1.7925919669239434, -0.50697657465029, 1.0195252418413354, -0.3778744318284888, -0.24521733166682302, 0.4187550898260552, -0.48423459758506476, 0.5465439302622701, -0.48248260057028675, -0.5122276041564551, 0.8289437255122474, 0.354124553874484, 0.024534295933395775, -0.7806421411605723, 2.6773161759665367, -1.7201071767524272, -1.8850901632723167, -2.6600810155836507, 1.0235266497842228, -1.9273040415837055, -1.7875017475345918, -0.2922081294043652, 1.2045471514699897, -0.7270072072877438, 1.321184483958177, -2.074855080320183, -1.5289322679794566, 0.3095883003556787, -1.642158976426316, 0.8667808854206717, 0.9007400517925136, -0.42101029593933054, 0.7338490693577562, -0.04816637729524118, -0.504285290877302, -0.6936707205530224, -0.4613280087449161, -0.8579140090632226, 0.2084275539111384, 0.5578973951383689, 0.32119827851748134, -0.08647300442870436, -1.0824581622383598, 0.9041061532969328, 0.8810426023382275, -1.6808336994138962, 0.37804604340996867, -0.32954524993651757, -0.32623062652922696, -0.504061366940403},
    {-0.3305542549046231, 1.184766159454008, 0.5357163449966605, -0.005848664156042081, -0.9726349204471604, 1.3103620470270483, -0.5571528298993155, -0.62589521207385, -0.6498715226017763, 3.0451282903831474, -0.7273595998152426, -0.33244816412276246, 1.4509394026977087, 0.21229490474726517, -2.3699172300773985, 0.8897062402371634, -2.2427124972725547, 0.18683035886778135, -1.6372957998197222, -0.29544030069591615, 0.29204636076527496, 0.1508129725791046, 1.7672715371170595, -0.05615206147374014, 1.0234077614750179, -0.40762662837249347, -0.6650955802418262, -0.4507706574436723, 0.9582990594727306, -1.3488981577703207, 0.1782627280022714, -0.1534218784752608, -0.9939104123756431, -0.5222996596616092, 2.0073788240839137, 0.08822453282674364, 0.05680485296971101, 0.43090008622870063, 1.5681260261358911, -0.20769231452878326, 0.7696473400871153, -2.092532784322627, -0.41320994285201895, -0.6274942758800285, 1.2181536936028532, -0.16935366841915683, -0.2973573684774762, 1.6646014776679572, -0.24568355176690726, -0.9603048542989943, 1.5514508648700631, -0.21541685287452259, -0.41848714060479786, -0.7233443486478034, -0.4827809864731927, -2.116012938044173, -0.19708464348491495, -0.3077495424655058, -0.9619822729761454, 0.36015158544653275, 0.6283534910140289, 0.5760790580202372, -0.25049514979369764, -0.5667391308454203},
    {0.5471162680445173, 0.14505963492988416, -0.5276277908741397, -1.9374604252117362, 0.14166127098810483, -1.1853204130244732, -1.5041673758828265, -0.0214533221657922, -0.9467572236743137, 0.35181995575308, -0.39099471387885426, -1.564797824227985, -0.959781649571251, -0.8517939443629741, -1.277375717248451, -2.5000055065140057, -2.7813623639898695, -1.1936424904338883, -0.9448314407650851, -3.428383091099798, -0.5480345460268631, -1.5504393481671006, 1.0211428262293374, -2.5077850372948394, -0.8809866770863909, -1.3715125089204179, 1.9898246766605536, 0.3546644666499161, -0.20102563665528297, 0.593966356333128, 1.2655121545017136, -0.9087207421477574, -1.1957230756370327, -1.0809214050996792, -1.5415651578658829, 0.47362876434412937, -0.7699312808322717, 0.3759265508583803, 0.1449337520318963, 0.27307616583035416, -2.282519817815916, 0.0877073129620488, 0.11242207462331845, -1.3379549508764719, 0.6540533956189807, 0.5215161531773651, 1.827661194103321, -0.2888035606823557, -1.0234476823008096, 0.3333551424296184, 0.1654282006474788, 1.5007965086701383, 0.049301136591293655, 0.8671472518252461, 2.2919119605652396, -0.5043360425314406, 0.6192969431341625, 2.051262232535397, 0.6432144654115346, 1.911116726659393, -0.781940841755987, 0.6184277612067799, 1.2085045458160686, -1.3701805220765781},
    {-0.2770010571699746, 0.16372164772702158, -1.4214689263224687, -1.1897495900754687, -0.3659278432667914, -1.1138633018558175, -0.2230170429786265, 1.3991906268818017, 0.22211661275240033, -0.31555815349785676, 0.16980930306802303, 0.2619032063789726, 1.5060885982781276, -0.3282347726121961, -0.2113150872783298, -0.47865247987846976, -0.7462367185616259, 0.19596243732311863, -1.6436595612077927, -2.0891507674612706, -1.1211214827097944, 0.14301387538736657, 2.5994794237856405, -0.8983867869879104, -1.0232682758592238, -0.22102243807653021, -0.7118480129031536, 0.960576417137499, -0.7025878571134156, 0.28694849399864225, 1.9850611786314312, 0.9511301449985498, 0.6637583979664042, -1.60101652667492, 2.877601256213123, -1.948813662633869, 1.0069024596563285, 0.19627055289981163, -1.7583607005456023, 0.46661922713517795, 0.7014898167800332, 2.349056266131957, -0.9266130816058402, 0.523303809898654, -1.8234410048026255, 1.000295402686359, -1.860339500668714, 1.0230599595451038, 0.4143902311256914, -0.41939530226252686, -0.12061494645252527, 0.2595818472829, 0.5901296600576325, -0.09257490336065131, -0.5755293623649075, 0.6195190095610208, 0.7801556867438463, -1.294894281907814, 0.5336239842030814, 0.6081065813745012, -0.35894430264493377, -0.057044298905669255, -0.7383125537816047, 0.840542974873803},
    {0.7454639653292346, -0.22738697757435275, -2.4667681792900127, 0.49682498766840005, 0.8305147298951249, -1.5130605289377381, -2.241676134452274, -0.8530984664181354, -0.05291401033101068, 0.8416661273786366, -1.2204991743951934, 0.18622664056555796, -0.5794419225860429, -0.6035963035049353, 0.665571382531482, -0.7847640308461744, 0.9193890450631398, 0.40718640081578994, 0.8611093525244942, -0.9444764680359969, -0.32188277497201784, 0.8597233740464357, -1.076432031538328, -1.613825498645535, 0.9838194435193216, 0.261566807904969, -0.4462646948377655, 0.265085631877956, -0.6171811935444137, -0.4593571220407374, 0.47313171916188074, 0.8733596867914345, 0.9411643367681605, -0.41043756944883947, -0.8690736281674534, -0.6238883036104583, 0.5072548449240554, -0.9112314118203221, 0.8470493650070938, -0.08477351794584431, 2.1328216060441365, -1.2831245901054893, 0.0015170716240883507, -1.1142277315800508, -0.03249550020859536, 0.7245003283793469, 0.6828754183148957, -1.0438474745562771, 0.34289577231609847, -2.1716316763161476, 0.045942635143399524, -2.0052882490866764, 0.741819896352038, 1.2896761253442528, 0.5639829795191691, 0.3880996285156994, -0.04043744734481974, 1.2698006191609406, -0.7710483801586271, 0.2986954195135643, 0.2404970351910662, 0.16065700581889966, -0.2689149772904135, -0.3089302233458464},
    {0.13950389358520696, 1.1818142526104773, 0.4235305722512001, 0.34223048373345893, 1.8431364587590968, -0.13287079229145699, -0.35737046892286894, 0.19523555967051875, 2.513682133215054, 1.6311757244542922, -0.7073096665665793, 0.338510802658905, 2.423220792363857, -0.760236158317477, -0.7937540870855563, -1.2689902830393134, 1.6044161678575195, 1.2127251564495594, 0.009546289422280155, -3.164573528417528, 1.562364446803247, 0.666793429116235, -0.9188883025506174, 2.4733197853279343, -1.1079923418181221, -0.6468586380044303, 0.6735342343900106, 0.8550857213936479, 1.617456329994843, 0.7550132736746746, 1.4276340978634618, -0.6451914105602607, 0.27380740234003137, -0.7025796085315563, 1.171241641881021, -0.383130196464742, 0.08698331966973552, 0.2060479341433944, 0.8865869678474481, -0.4314362475993843, 1.7246109008770476, 0.16225693647317171, -1.4801910074372622, -2.1409842114987936, 0.12944579316010282, 1.377391242540978, -0.6183163130512024, -1.171232400504996, -0.717065878637859, 1.163226252349724, 0.48611674639259245, 1.7262042348182491, 2.171399523581539, 0.24949441757136043, -0.88888666870835, 0.0799385719507553, 0.7259208492806712, -0.5551038168612075, 0.5293018532879837, 1.1630777028460486, -0.7621625467835732, 1.4602734205112644, 1.2062131222230883, -1.168076157341905},
    {1.5824472182027163, 1.5904121023948468, 0.9043435737368928, -1.429641738476748, -2.1321155890269305, -2.557138035837623, 1.6090341654523368, -1.330774292482789, 0.5633117159930301, -0.2891697988136308, 1.4653524622704979, 0.08345223011050353, -2.303896219044553, -1.7113656209083732, 0.6307843740967783, 0.620613031734687, 0.6116359207514803, -1.1042660064536023, -0.19100811181268607, 0.7761096040176, 0.05179053457910787, 1.255277705469439, 0.1638226000936022, 2.699727347671611, 1.523607093786603, 1.4241570160787802, -2.0117715590473977, 0.7214002311759797, -1.7238736160135981, -0.5100556242064512, -0.7164067329297166, 0.4143884678732469, -0.3514157500702149, 0.6312893502163238, 0.43300621316029264, -0.647383299160296, 0.14990308841411606, 1.8137386233878408, -0.2738450950202121, 0.6179626055872118, 0.27820356006958863, 2.549805905092031, 1.0065327471368544, -1.698588999090496, -0.9410714131157712, 1.4429257501679649, -0.16288370552866266, 0.7549883905820143, 0.6788117012390527, 0.4987044331274489, -0.806970914475056, -0.779721311934714, -0.3695667072867588, -1.5051253550346935, 0.5440687964399297, 1.6717334580586194, 0.34654546219977284, -0.471299760283878, -1.7549386809093075, 0.5388256015742499, -1.2695962946639219, 0.2136906469722236, -0.34485634383333547, -0.19825438528359796},
    {0.8405797684501292, 1.671643707261863, -0.6909716597521117, 1.4793833295047687, -0.7254076385774395, 2.142934820377059, 0.523450212336523, -0.45452349187125246, -0.8689058090995666, 2.269429782249012, -0.4991569932419161, -0.5505060039946663, -1.1885370146579688, 0.23244064431064856, -0.33130770175114344, -0.881891761337915, 0.48302888054756304, 0.9521681990630325, 1.0666352850909642, 2.324423222344744, -0.08496406747042504, 0.34441103980839927, 0.3844329079895084, -1.0413436250830481, -0.7331916048121595, 1.5585942914068778, 0.2533115827092753, 0.8157164090610743, -0.21494894198874928, -0.7801997902035129, -1.4971610380070535, 0.15853412645608422, -0.309655290999511, -1.7475528738687711, 0.02521921622407957, 0.18927141421077526, 0.24154275856696844, -0.17229227492433097, -1.6387554251959398, -3.186200004893437, -0.4593549817972485, -1.0181744681659988, 0.7655439600894152, -0.968958237811033, 1.9296244592220262, 0.3997689864826125, -1.0913558177306468, -0.36869913477803906, -1.0180443275158673, 0.9753642356437184, -0.09901806457814835, -1.4416988936309332, -0.8340372216099647, 2.150860731132071, 0.6803653447200234, -1.371126802306919, -0.35787821554759186, 0.8462293978072918, 1.5223950360115832, -1.649218804634201, -0.05895015884072097, 0.2582599776985881, -0.08645750310696042, -2.2012355864333983},
    {-0.8435706355184228, 0.6294505614707243, 0.7284441177773062, -0.90683832259328, -0.8114861108564573, 1.4190144053910898, 0.6255530455310991, 1.643310702830957, 0.7600128894973285, -0.5894353994536577, -0.5514695329950992, 1.9049235911282096, -0.9132837054031532, 1.3131037938778234, 1.4031908254162369, 0.8837468533902806, 1.508230917980362, -2.180876183471146, -1.404559360802747, -2.3978595199500896, -0.6406103795232658, -0.5417721593891331, 1.5485347336085513, 0.6985209105714782, -1.6932534415229235, -1.3571883876892559, 0.11021574207280717, 0.7093607670139851, 0.32262509756491214, -0.10138541469253882, 0.6840172727630253, -1.5456817577476403, 0.47521666140108515, -0.8533625040028535, 3.164564500945425, 1.885913513981988, 1.0170107037549607, -2.0067324620814535, -0.08162302207305748, -0.36279417934503716, 1.1494297869156036, -0.41204400081392567, 0.9742015352952397, 0.23448921014333424, -1.5116398096930568, -0.3658789891759331, -0.2816094098672065, 1.9846985746185648, -0.49380962926029603, -1.4497168284068416, -0.9231917274284897, 0.29286686547573365, 1.2102205308140692, 0.8303341228378694, 0.9281774212652777, 1.869634142068056, 1.8578311027825851, -0.08525815283962093, -1.229885654276626, -1.5275601860078714, -1.9553801142326852, -0.18801852665202035, 0.0575760986179529, 0.804991617755348},
    {1.4951982754692934, 0.08517411052926277, -1.810538087457995, -0.29943566904933516, -1.27496053337259, 1.459670017115448, -0.8739725682500189, -2.0153219888158587, -0.5889412874018751, -1.109287107643917, 0.3413456002037599, 1.0922504650216907, 0.41776656398308154, 1.9747040330806742, 0.44787381515179053, -1.6029954033043041, 1.775833833145402, -1.6101311405565868, -0.18548201072619083, 0.18635702193289713, 1.7928727197030048, -1.4744295550131705, -1.1620833679849558, -0.37406939469373135, 3.244186270208847, 0.08588367400380974, 0.8601460062788012, 0.0011497560936844242, -0.6791092993274979, 1.021021774070453, -0.0691677614531376, -1.5131740902727542, -0.7697440085886558, 1.4078123387840784, -0.8693979034241677, -0.6911501655304286, -0.8000608538373073, 1.416705528433992, -0.2204247934053191, -1.2738986120879163, 1.1773673997666725, -1.320972943501441, 1.3060814234670806, -0.19365435347992258, -0.18731138407829392, 1.6387545467987275, -0.6427753742104787, -0.38676068497634025, 0.3593964905117004, -1.0315672990480365, -0.7345095057978975, 0.46442734705898386, 0.8088174459218778, -0.1973067637372227, 0.6531093663317223, 1.0079372811619738, -0.6055746907281804, -1.4833589827259288, -1.2448202319496602, 0.5560906052225854, -0.07039443801584112, 0.94230191700812, -0.2049319070354038, 0.10945849840475043},
    {-1.1972396761608137, -0.7058924399241641, -0.3436405453347852, -0.06558988134956996, -0.040427185520627865, 0.924365983799357, -1.0474752606710567, 1.1721885312337368, 0.04572393888712495, -0.2189926593270479, -0.432625783799996, 0.8731098112870405, -2.530009749278887, 0.14487746474056956, 1.1428171080737375, 0.622994890167583, 1.0972643987499482, -0.30118060824825754, -0.840479446873429, 0.2360070876960318, -1.0674916562354684, -2.0758943394043134, 0.1376043688669155, 0.369680904359466, -0.3363187320001639, 0.6545850040557459, 2.029464865758045, 0.3331166283653679, -1.3659456771021052, 0.9946746228599543, -1.2922772429246414, 0.8585411049240739, 0.43089202249264996, -0.9460613151022295, -0.26771752584720293, 2.4863429398223538, -0.770635877050406, -1.74228826116247, 2.4082036551351886, 1.0270812304536943, 2.6972575685460938, -0.8975959583095542, 0.3831391056074041, -0.2257357520733495, -1.0000520862605657, -0.5942383080834256, -1.6752225590170684, 0.07727104100475381, 0.32154264117643344, 0.7434756764103232, -0.7759046684137945, 1.095709873054923, 0.5965141172607779, 1.488285046544639, -0.8928251231879597, -1.141651865512772, -0.4123900548454784, -0.3981766520059824, -0.9480442282766247, -0.827396474637756, -0.10844548794127994, 0.2705030037305837, -0.7222993549204968, 0.8529935285739461},
    {-0.7105525990203119, 2.0142855140796696, 0.5287394753430945, -0.9445596799174665, 0.4145242284129937, -1.57145807041925, -1.0667542079744234, 1.2699653634700936, -0.18898002968852895, -1.4234135515753668, 0.7777082558516117, 0.9505231509735552, -0.6403671433125564, -0.15004684286385087, 0.9154844714922796, -1.5532361900990521, -0.764846109122473, 0.6875370006228593, -3.4119748344723524, 0.31857770969920624, -1.0189592893951531, -0.5822643506591934, -0.4908427750329783, 0.10100909579614756, -0.26717101031154783, 1.3217753862556916, 0.015710019751166197, -1.0556526621668227, -0.30637967141109196, 1.1101950008453232, 1.8661696202564866, -0.21174229029163621, 0.035863885676005604, 1.0312939210590089, -0.47111996690465363, 2.8529833810238063, 0.8969289225836898, 0.058295207297878675, -1.2971846714350803, -0.32818080295651186, 0.526760346536786, -1.3534350761711866, 0.9807680708411355, -1.1162897715864175, -0.00826485488167808, -1.2145783727551742, 0.9944749278720442, 0.05054937076339675, 1.3003800043570233, 1.0570624275124498, -0.8110143488377919, -0.49566806443396777, 0.2492229311190513, 0.552748176311332, 2.66536920144234, 1.3605248412002933, -2.543981627429766, 1.5771421664392373, 1.4330405807839601, -1.7139794692273649, -0.6831612628432377, 1.2206393739706904, -0.31825263271963466, -0.5442054459808017},
    {-0.39706744957941476, 1.7233772973185248, -1.1731621625375062, -0.3509052979699216, 0.4055560049659926, -0.26282522065255337, -1.4632234286061447, -1.4885259187019655, 0.4128207320306959, -0.36416314224057905, 1.4012833943238225, 0.3279611282414528, -0.6939261960984422, -0.9831768770251431, 0.5253516921194193, -0.1154826253803257, -1.336346538241987, 1.1310562042136545, 1.6137523794571487, 0.5858731308164178, -0.3032599219412335, -0.17072280592904499, 1.2007802425709002, 0.47524795524034197, -1.5543978573390551, 1.1431129997163438, 0.751786475350176, -0.33393313716243367, -0.33038077335755944, -1.2488839155128963, -1.7443512682213296, -0.7568036048577383, 0.7004619322136296, -1.3036930147273742, 0.49305291301947735, 0.04155000247472317, 2.1661351488807217, 1.5761491024904428, -0.11383574058195307, 0.27168491153612356, 0.08761957042123224, -0.5824492325092715, 0.9893489192216535, 1.5174613681669826, 0.7601820294026365, -1.6211327498139816, 0.07375178992412111, -0.32853025573783506, -0.9030834704724338, -1.0375711705929158, -0.872403605495272, -1.2730708332089777, 2.4994576106923616, 0.5717116378719377, 0.8409731610905055, 0.035214680001384877, 0.010476392229465894, 0.8338314701876457, -0.17170818582960437, 0.04498522672433581, 1.0306914106783491, -1.239005277783509, -1.1968840246847745, -0.7780419255831134},
    {0.7172713921518733, -0.18077038879110696, -0.5852823523575322, 0.29750548243621605, 3.3366907344652175, 0.9185183476197827, -2.262707787996421, 1.3481914129323473, -0.5919610943523043, -0.8476957728288721, 0.49723334728053137, -0.7838604702530684, 0.03336638398087309, 0.15800757250740102, 1.0217801694795654, 1.7277370935770924, -2.3572465176998443, 1.4986104036130652, -0.004106872293211425, -0.70244283568572, -0.706831032492952, -0.00606708578101843, 0.09021992835298992, -0.06963653153871831, -1.3929379690269794, 0.355317936256341, 1.010993286316926, 0.3231728077605585, 0.7728747508886831, -1.187983986191869, 0.9102351763188286, 1.7423599744891731, 0.955688070651906, -0.38215617848531364, -0.00023404465799601259, -0.9148880073151245, -1.3300207263676327, -0.3343350166224509, -0.20533723588638, -2.3237079692614917, -0.2732240257852321, 0.08989068275658538, 2.292247922919541, -1.0319154673007653, 0.33151144687172596, -2.0814087759865387, -2.126794949971611, 0.924304786945538, -2.26647815684625, -1.341647277977119, -0.4489236076319071, -1.0558538954474783, 0.8652485926888789, -1.0376888319127626, 0.2924477951135393, 1.3322286580159315, 1.183590868814616, 0.0693326228135922, 0.2231624380136782, 0.2300798048040917, 2.3746935170048564, 2.1345012635108067, -1.9488441815813025, 0.024660381311527972},
    {-0.9899883634438277, -0.6024647962638285, 0.07018768917452171, -0.3178308413358086, 0.6382833917350251, 0.5628973977863856, 0.22487665027024809, 0.44960228791802015, -0.7246976908385744, 0.2115068481203411, 0.6221651295566853, -0.5677033997781981, 3.1603732482758424, -0.43226181038994765, -0.05959153513962719, -0.6843359234845863, -2.6381228440640196, 0.018408640150457158, -0.21329883263324512, 1.5464635645123348, -0.37131654816775983, 0.7819808589726482, -0.3192998934164981, -0.050152164901828514, -2.9873332241469712, -0.7642143537282942, -0.22849209608614598, -0.21239734382239814, -0.8026956858747822, 0.9885645307934492, 0.5648507223246529, 3.323449395719304, -1.2655993596628274, -2.114279258975622, 1.0184566128959132, 0.7435611205585152, -0.5571001500645755, -0.731689399081104, -1.011681116324965, 2.3704838251148086, -0.866543326021368, -0.964295448663932, 0.5469329178080732, -1.043367262114394, -0.5493672127225988, -0.18462084962426448, -0.814232947048665, 0.08316480300778362, 0.808626152347211, -0.40752135270845424, 0.7854713217069876, -0.3134187080799256, 0.8617716977011243, 0.20236584544288896, -0.6881435285537701, 1.3215419598316467, 1.3721371585385131, -1.7068877344936515, 0.1674216746757982, -1.6244928595024088, 0.5523644155486169, 0.621041396119421, -2.6478434036014753, -0.09332653534851373},
    {-1.3001486111823335, 2.0406980459358954, 0.41174911581482665, -0.5245021712986202, -0.4040872742166583, 1.4466304364552698, 0.3810295057131179, -1.2972276304362225, 1.1358226769205702, 0.7458411162870076, 0.064551991376658, -1.2059771478881045, -0.07379091831699794, 1.2020774143452106, -1.3540048070416026, 0.9074493421089097, -1.2598727728362378, -0.161124079532008, 0.22214803273723055, 1.353366628019532, 0.6648871220176034, -1.628255522747047, 0.45835356953749007, -2.188423966111651, 0.2846514350747099, 0.7127177435154136, 3.2026056757607475, -1.3248438917075824, 1.4292606666492174, -0.6362375553554968, -0.24841376017401648, 0.47896049668075547, -1.1355947011810321, 0.39674405991395295, 2.2855728223807428, 1.6511203768107305, 0.30964942294295056, 2.426865624959428, -0.28372188378383534, 0.6745663916787743, -0.016276036391549346, 1.4135460650914196, -0.09762460014111468, 0.5226703187609545, 0.8961656790089982, 2.478774330449104, 2.253043056868124, 0.21224104013057327, 0.3162376740510186, -0.8686265637482942, -0.9224946171586126, -0.2886756635496719, 0.2700083457744619, 2.0533321330101435, 1.2224979009418215, -0.3215431499359449, -0.496603977965226, 0.6359871819539881, 0.45654220187735534, -0.2864030357475568, -0.930499409025041, 0.5113656178006377, -0.28725418837130284, 0.685917631438095},
    {-1.1688421532538091, -0.662376841360466, 0.6895934888746469, -1.3943439804993112, 1.5594474824685958, -0.08722579830823038, -0.6573760644041544, -1.6649605296368422, -3.073644020539736, -1.5148204141205384, 0.22421624410214808, 1.7208111674679172, 1.2968708932733877, -1.574548430582084, 4.262246810367211, -0.8070632541115028, 0.8430463563166266, 0.7188972251383883, -0.6775515730756693, -0.541177356051888, -0.8047811690514508, -0.2925182098568377, 0.33895506014091764, -0.5649537863831063, -0.27691655618881894, 0.49384874444697713, -0.8465021143436328, -0.7940836827610541, -1.6342628428848802, -1.263646816676918, 1.6425726427887961, 0.7391765377965401, 2.1284584320188302, -0.5247329583188453, -1.1443309006897633, 0.38612741227087466, 1.2708208778747825, -1.8798701993612301, 1.1442754823294385, 1.7323064803652417, -0.7068929000006229, -0.1848712040574087, 0.8462939220889822, 2.4049177771739196, 0.17036299614805892, -0.8722241534210775, 0.5776064381980478, -0.4791116344337373, -1.1173255006307283, -1.1307659385408095, 0.15382233966261813, 1.6161510288530279, 0.731811147989333, 0.8887308756899899, 1.0927199048784648, 2.767181849349542, -1.001709162154875, -0.6883264493508557, 0.5454694280526512, 0.04456085588177405, 0.054067816940225895, 2.1933235151067714, -0.8778762907849832, -0.7817138784748072},
    {-0.3798773538605145, -0.8571922912064192, 3.1438365850230103, 1.0455217103243777, -1.1274011477779033, 0.4317212484948938, 0.9195854381737653, -2.0752194370078354, -0.4085692300433336, 1.5018702130604336, 0.007170261355745884, 0.6526658606274495, 0.7370863323542645, -0.4955650312903761, 0.21991604687080532, 0.394426766183966, -0.23235370368157854, -1.5173506666496406, 0.5591779130526903, 0.6635065481005515, -1.5636124191955738, -0.6838641236636723, 1.4221402709266793, 0.8344160926665459, -0.989484062610895, 0.6773151770180245, 1.0686737624461409, -1.5075478212828741, -0.9623640941927993, 1.8590085591616503, 0.6860432977557123, -1.8944735993276602, -0.4043808825550725, -1.9340359929671072, -1.9730762814635774, 0.3356105787530332, -0.386827960378819, -0.6795554263424571, -1.1723125823886211, 0.39742191237713087, 1.3197961601269337, -0.1281879896925673, 1.4012140185322122, -0.8949129776767777, -1.7090481281990133, 1.8740898292082322, -0.4146375232138248, -1.230382850290123, -1.0807102290198147, -1.2990854159010539, -1.9126894921487108, -0.48837330221913744, 1.1687767523361527, 2.4824244946210845, -0.0362699261732449, 1.0226902442140273, -1.3076907327994816, -0.35353658158513224, -1.8084959962131193, -0.45368860091522517, -0.8809630938995882, 1.555974130238171, 0.38102340915889255, -0.05900370505071793},
    {2.3943832604127557, 0.6943741277237935, -0.8289190786253553, -1.1712615782276201, -0.8859736806628483, -1.035315144065356, -1.3477592707977448, -0.563697907145168, 0.8667411522208193, -1.207074289184693, 0.3218943972061616, -1.1953498057464043, 0.12812636852025847, -0.45398058056005597, 0.2792072609390515, -0.4170247311730645, 1.3769662269446687, 1.7545162362338385, -0.13417695574411714, 1.7636157379256205, 1.2160620711290178, 0.6381249809250876, -0.5470038142817297, -0.1060293940281235, -0.2814477022481476, 0.5761810097599559, -1.55265549870254, -0.10222846828108567, 0.2697746090492212, 0.021981470975577892, -1.0831337824448304, 0.29775628757557066, -0.4066330079736293, -0.5268962820777975, 0.27754430001211844, 0.48233103037962144, 0.280627752440257, -1.2637738265736447, -1.4829415679573326, -0.9935130754900087, 0.9527329816401683, 1.2304611058057728, 1.507356927038095, 1.5278143617829865, -0.22470247575982272, -1.550230105612417, -1.2260796462451997, -1.9942902035302732, -1.1923143107220437, 0.3744681973259893, 0.20939491403774613, 1.2316563968946805, -1.6606084895346662, -0.6267445659986463, 0.9025796326914923, -0.030431264654367206, -1.547466086037613, -1.758193806319109, -0.337068757905886, -1.2502229642743758, -0.14660164018443295, -1.479137006236783, 1.3063474458007645, 1.3907038758529058},
    {-1.471213690697385, 1.1375539607941263, 0.015868663993706053, 1.5131858535226297, 2.0401052235795176, -0.9673913030177794, 0.7751148789375092, -0.802994272257415, 0.38517697973476867, 0.568482673833597, -0.3683957855276846, -0.3711430247771338, -1.729292910219472, 1.0491934471858153, 1.236646747039171, 0.8998929738300122, 0.03605076915822636, 0.15558848679274992, -1.1682891419229742, -2.0220047642493624, -0.2877456187227027, -0.7306700446472378, 1.423242096984624, 1.579213862465788, 0.6480058698182705, 0.5136671564513028, -0.5108010960761725, 0.839938291521387, 1.3706661329104581, -1.0234187371225922, 1.724667105304895, 0.9010088944046535, 0.34610481449285707, 0.9718913333835545, 0.41394393284228137, 0.6216790192622775, 0.14534040590515604, 2.6550469370597667, -0.7578029881502293, 0.9111630062212293, -1.0684962811504188, 0.044306444202037366, 0.7890372096615732, 0.30216581271356313, -0.5863171917165655, -1.4386461305295632, 1.2078589891675091, -0.03043570968110414, -1.3560237169174967, -0.865521973793208, -0.1382238473068742, -2.230894488351626, -0.1685111510714046, -0.7826441550389399, 1.3841539333829855, 0.8847790746636388, 0.9136781964082669, -0.6454931974259066, 0.05951678573931184, 0.4204495826379639, -0.6992736910067686, 0.2693920656059349, 0.2217848501457701, 0.143772757957856},
    {-0.2737707406951941, -1.3843026781638268, 0.24318409989087586, 0.39239364862358833, -1.064617650786149, 0.7480661991967256, 1.1654099079051559, 0.06592925599639327, -0.2577078382728252, 0.028885009700677745, -0.3546437415622955, 2.479663197570034, -0.16268915346566515, 0.11371578196755702, 0.1716831930624713, -0.32813065403206565, -1.7776258587202851, -0.34327409612991827, -0.805506253927149, 0.6094951144148332, 0.1236501888962849, 0.15448143161762162, 1.9128976101859756, 0.8929263010296402, -0.229488743531268, 0.12669615941043963, -0.16043472620822155, -0.0825712865748451, -1.6338957818133288, 3.093859728161818, 1.1735682047482316, -0.297279423110995, -0.2698305647433858, 0.529046934979054, -1.4239965572313023, 0.7160167038232852, -1.2623396769981563, 0.42155393881092634, -0.4699845207927574, -0.39827282917977963, -2.145471669722322, -0.22778913095835507, -0.5588408562063866, -0.931714688669979, -0.21529233869165657, 0.6347522596924856, 0.4182314946731145, -1.1198528403456576, 1.8458026589569132, 3.120016805247025, -0.3656104613409735, -1.0883076503209284, 0.46240348853411983, -2.6250060374834736, 1.5715014825167923, -1.8312796848761734, 0.5422824085394253, 2.1461223305714543, 1.4052877601051648, 1.364260850918499, -1.647945230620594, 1.6386312043706623, 0.42935649229339645, -1.1082433458699996},
    {-0.049062702724752244, 0.3024841043174174, -0.49860774169256544, -0.8375826224713707, 0.5299228510064058, 0.1003817747555133, -0.9041362984326375, 1.2779279461756357, 1.3046171512303308, 0.035130982590352314, 3.0416732327145266, -1.0492035461099594, 0.41585561462513426, 1.030839244685012, 0.31639539847230674, -0.03179083642262799, -2.5347101667279306, 0.13350433047198382, 2.7463884881841447, -2.19531138411336, 2.755648539581465, -1.3553456667297876, -1.2516951164720655, -1.1935118107462845, 2.8805438084413915, -0.41063183704937917, 3.463736887613825, 0.5551381029554141, -0.1771605427280781, 0.3778246865788345, -1.2798935476943472, 0.6929268890738307, -0.7839026796526755, -2.2655814711974944, -0.9459799450248406, -0.3351386661149654, -1.3620535727133334, -0.32161582133948025, 1.1431959049276792, 1.5973753880821653, -1.064801203400362, 3.083269805143331, 1.9955480938496812, -0.11361280459794652, 0.14600380282982287, -0.5022833382963262, 1.4116588741584972, -1.4281184279880919, 0.43269460062960113, 0.9022099395792403, 1.374660334271078, -2.213079785802192, -0.019106717339886135, 0.2024397482352214, -0.6374885662081611, 1.3534955615748099, 0.9500197953423959, 0.06124625143779672, 0.2420056291380142, -1.2960474347779916, -0.22344160208157432, 0.22581285717081015, -0.42892331626857977, -0.6085414898564858},
    {0.5407575901682113, 0.7718040975699915, -0.4514859145321436, -1.3972534988958534, -0.40701878536771585, 1.5108917294365518, 0.7575861802074573, 1.273753419333593, -0.16045129153437557, 0.6647598849724791, -0.2818728633698986, -0.4090965092696052, 0.06147454667270483, 0.3870904298787987, -1.047176012324406, 0.41648136461148005, 0.5834558616368422, 2.363059034981277, -0.841456111516971, -0.6334113323633773, -0.3071286839697701, -0.2892246090249135, -1.2509412546391934, 1.8262723535199805, -0.7282949148056077, 1.0471845518573595, 0.007351158717925152, 0.4764470780336941, -1.5838590762913498, 0.5077689481970203, -1.6151980012639884, -0.03902528693288651, 1.2009596818241683, -0.4388417649528807, -0.7338242954223635, 0.3988606095820738, -1.3092557078090907, -0.37744665037046715, 0.8825592750521577, 1.119777594139066, 0.6297049964732605, 1.2185585027083141, -1.2279848860426157, -2.886962870578229, 0.22723850566951498, -0.34566065747674285, -0.2902974217646183, 0.5885072807235504, 0.01644805648789664, 0.8457009536376893, -1.1526806295265808, 0.4848044143194345, 2.386463575072906, 1.9826811274890823, -0.5520053762330147, -0.6473050898550632, -0.9568921657962184, -2.2418428422531744, -0.13337878217048185, 0.855729308886969, 1.6786080665652372, -0.3529209450838285, -0.4191458040678966, 1.398463907984799},
    {0.07637629500406956, 1.8764648910135395, -1.3033137923487594, -0.7582569335933632, 2.414351188058808, -0.33062920065088536, -1.5978735925147007, -0.5078668718377541, 1.2420776181333832, 1.2227891019000547, -1.4091020105882117, -0.3809801060128542, -0.45686656400747694, 0.7493082603166272, -0.38695916345057924, -0.006116871085457704, -0.32725036483832515, 0.2468597783050384, -0.838913546124103, -2.350968906410798, 4.240945814229782, 0.48387873062555853, 0.3903720985971974, -0.9961503559767095, -1.6559050870532046, 0.24859235864417623, 0.9160961285898783, 0.07177686074928787, -1.09057619784247, 1.8923152836374468, 0.17468231875742168, -0.910324577705529, -0.4975437691988583, 1.1399710447350206, -0.45226403507263846, 0.8409267773326387, 0.2010945018175919, 0.8418163009993072, -0.5231920956665125, -1.5665336845160163, 0.09966887072610717, -0.7590227387145295, 0.9627253760487645, -0.7294108251546225, -0.4530453313121543, -3.3431942145664997, 0.6646935120366375, -0.37280581911986294, 1.526562156298241, 0.9793038040238101, -2.9692524398383724, -2.072438623036753, 0.17073194012218057, -1.2782677183983473, 0.6749974383006105, -0.7908013002566191, 0.8688765805837679, 0.06192051949153743, 0.45055674176423194, 1.4722268057725256, 0.7581862757498115, 0.9095120253161733, 2.3775991570723334, -0.4733741110072475},
    {-0.6874092413963475, 0.3859674884442191, 1.4476229245647798, -0.19707638558313087, 0.7276882843575566, -0.011200315862200256, 0.3015659810222922, -3.4870473230079093, -0.5397863442572637, -0.85543833564062, -0.8483009153970762, 2.2133053848892352, 0.27547788074423835, 1.1739082043987015, -0.12279018346334021, -0.7651228200772152, -0.5179803923976806, 0.13868497691520126, 0.025932995460274427, 0.7352805925537332, 0.04461746251537807, 1.6492968956114935, 1.3381955217860693, 0.4556350760514644, -0.5794351453791051, 2.0295307999674645, 0.3493163891003602, -0.8703924333940253, -0.04593862643374052, -0.03987638863824629, -2.3335871650318483, -0.3103723459918126, -1.6997310825750922, 1.7010972277180527, 0.031153106463761442, 0.3026061420245048, 1.1073086530746177, -1.503548298224009, -0.1186332147321704, 1.316264475590575, 0.1059237507615828, -1.063666153592837, 1.497241499093489, 0.2981622684849539, -0.18090326250095257, -1.551222202378177, 0.6770299365379286, 0.6800858477567462, -1.393058742380054, -0.818000002153425, 0.9820080060600032, -3.2285589206563894, -0.20386912525827056, -0.7769382899807443, -1.46072681628148, 1.2654129049503406, 1.6498585576710052, -1.1710347353962383, 1.7032153404823653, -1.2303400014955814, 1.2367911823615254, 0.7161345260037832, 0.14593914676661182, 1.3216929691593247},
    {-0.8178707539379952, 0.08575934502265939, -0.0866349999060714, -0.23614635424911953, -0.08263958746433174, 0.02478807749860731, 0.516566889489168, -0.010260196546635113, 0.03225474453453575, -0.44627119747781563, -0.1392573548126418, -1.2311770611858712, 0.04552070239805155, -0.8159021834620948, 0.46608929171191554, -0.0388279002812224, 0.06260730164729722, 1.0786684750971598, 0.20126548200732447, -1.8885010344523898, 0.007271896083241698, 0.4555109756670959, 1.1721063358410757, 1.740176589721538, -0.8023470221343393, 1.182554184718431, -0.5604910918333431, -1.719165302463218, -0.6321691737239648, -1.0498684753088399, 2.1367828984373856, 0.9954398930488613, 0.7634092383645891, 0.04149271929597043, 1.716298038518999, -0.37858217677675043, -0.22984011549159292, 1.0381392881697353, 0.7003417419373426, -1.567850120551164, -0.378077644843568, -0.2934036277048974, -0.3069578616492847, 2.14732940873087, 0.183291850106298, 0.29125247008639343, 2.3323902032495134, 0.9046261067823455, 2.134605355057198, 0.3577558721316997, 0.931615616634012, -1.0791974587916664, -0.051105809429598074, -2.3333582134956248, 0.9491634441737014, 0.6830290087068216, -1.4538195810863836, -1.022076590020586, -0.14658548218015166, -0.9643614205023664, 0.8275987097575668, -0.31733285763239427, -1.9110001840647075, -0.6469829887840464},
    {0.7568211444791727, -0.8399760645993986, 1.0413358030930353, 0.6950589078207691, 1.880779718472802, -0.5649618663359044, -0.8033015387631529, 3.330872702222673, 1.4260083463501514, 0.9239817215962002, -0.45015566165285426, -0.7485345327242515, -1.0002587974349264, -0.8688026246368504, 0.7499162580320005, 0.9953858616322312, 0.8206073352105916, -0.43938225754957677, 2.0555552696158683, -0.8467653321951593, 2.4778774836417656, -0.10726405406606263, 1.659900844915004, -0.8764944833752777, 0.528821817828026, -2.169471179557085, 0.3799622723664646, 2.6727612999403334, -0.1370615726253767, 1.5327460957175665, 0.8483277573702479, 1.6181091151458615, -0.0035575510577088004, 0.6723447443357462, 1.0486885786506401, 2.185132061275474, -1.7835213502673146, 0.6854620754937549, -1.1269254469412642, 0.3072836828567169, 1.4003049765815434, -1.0999262728690977, -0.05273698860407875, 1.4282986941737439, -2.389641688896236, -0.7079154592565389, 1.9468775286433415, -0.25256447253536235, -1.0413412757541396, 0.058447291261906155, -1.1469569634884629, -2.1184457001314834, 0.44082018858498945, -0.4389788017189704, 0.6962028122564059, 1.0717617365012069, 1.1814567268049752, 1.4317137258770527, -0.017203014330331952, -1.7642981141745715, 0.9234006672321254, 0.23167138372178778, 1.2177729873969843, -1.178192862658195},
    {1.5031444302097001, -0.308868727121029, 0.2690172235709628, 0.991892822937164, 1.5899667483440822, 0.6698453720931373, -0.7623040193321731, 0.9309673132774171, -1.8629215773471537, -1.373959379787474, 0.37849530232995365, -1.4483187482104356, 0.6186581331328418, -1.0404784812487688, -1.2265597332635847, -0.38361776731328145, -0.12071575297723687, 0.8008576178877775, 1.2994307550876298, 0.06485041073361449, 0.5902689203997332, -1.044692143313116, -2.0750783762060845, 2.4890251318743197, 1.4094297307164405, 1.0065643166647975, -0.21419813258791948, -0.9149336562540219, -0.8547986587351926, 1.0459490509462777, -1.8657110140636146, 0.596195065365083, -0.32025219827254026, -0.3404859887170224, 0.14168066104092425, -0.7347005528718578, 0.5579194408789991, -0.49917875643177306, -0.3660108300531698, -0.10009161152906455, 0.37188120565538774, 0.3924392456299097, -0.009795299456985975, 0.6557318769636916, 2.204194681913277, 0.11021147948017987, -2.0360249010243243, 0.5470881627233973, -0.16301735742114726, 0.6480823911681222, -1.6175775041537348, -0.7075901128893876, -0.7676386833990421, 0.8977594103073884, 0.20569092370506634, -0.2928845313113155, 0.3729816263480474, 0.8761220673055004, -0.10304070184442221, 0.05869705379070667, 1.973762060507252, -0.9003363454164428, 0.48163489082786604, -1.796129881003577},
    {-1.0874631522702236, -1.0707457027190368, 0.3005130340988581, -0.41679455167099433, -0.9334567137888456, 0.4958967168931685, 0.7349296952077919, -0.8651576165304267, 0.6845953032025518, 0.3364366431893815, -0.18207990218544087, -0.7669780936871302, 0.14766206011563263, -1.4691592792216668, -1.3327262400474276, -0.7306281181877107, -0.8939348556258117, -0.8329260688568745, 2.5425997497732133, 0.35718120331461345, 0.1312699409634334, 1.1729799221420225, 0.373998804913577, -0.16979846459153863, 0.5822387367614669, -0.12955733261258873, 0.1570072986233785, -0.7693443603004128, -0.15870812754601107, -2.452401675161694, 0.06410472718964838, 0.06495415113841885, 1.9541352615587317, -1.4833387990407263, -1.9661761459771, 1.6966742612433205, -0.15540105315107428, 0.5870148993911315, 1.0043564732219392, -0.9526590237606487, 1.7077973022497799, -0.8142571900793919, 0.1269756292171411, -0.15934872403104808, -1.0067784515493519, 2.9828138707212224, 0.9431416414254647, -0.568080670596211, 3.20979438382887, 0.4450374286011279, 1.4044677091698703, 0.2541832065286308, -1.5502785951320828, -0.5369985366391568, 1.2271947384705226, -0.4341150845429479, 0.39907102630864244, 0.4148820663836655, -2.9726454182689297, 1.661597465038521, 0.3704459382538804, -0.28929090641872385, -1.3598573540651118, -0.8038576740050675},
    {-1.1492862161638586, 1.0350616385568405, -0.2646123674564418, 0.5622698141765664, -0.5690900157937112, -0.027017332302152676, 0.7215601016842992, 1.5417990118029183, 0.14914993630582862, 0.2652441855058823, 2.729784696993327, -1.4535656516692528, 0.4935757630563802, -0.6213537956052612, 1.6837566672859903, -0.9436931359122724, -1.4200818977152323, -0.6302103533026836, 1.8286317612781455, 0.3163336069363038, 1.4024770449021349, 0.08162552875341293, -1.5900930815788807, 1.1208323120693937, 1.2838140106278026, 0.9419532183649308, 0.01790234295767425, 0.5023311301211602, -1.031698916537559, -0.8989169950730069, -0.32368976003915906, -0.7059427560536141, -0.5023654158075571, 0.8174060670306154, 0.12686327516603899, 0.340992173981349, -0.28234271942048333, 1.263744272279003, 0.9055931336532917, 0.05865412603960671, 0.6985284503878215, -0.927449158606915, -0.9671714340917358, -1.4164236537671657, -0.9344293895781122, -0.8256141618602378, -0.11168250740996895, 0.2764566042688799, -0.5244639609217353, 0.7227558960144671, -0.044476802879790084, 0.09076547191706126, 2.2666074354164185, -1.485357923941303, -1.446360137995063, -0.19416065170113167, -0.9521139621432977, -1.0401948466485698, -0.40666818676008537, -0.23506306851696232, -0.10918576711564501, -0.9746592781992321, -0.07474765832406172, 0.06190179314625879},
    {-1.0702115506968217, 1.0759954233235567, -0.038381151096332305, 0.19514780680345503, 0.8223493812227782, 0.735593230102819, 0.46874486854588077, 0.8152923811652704, -0.48778609869735756, 0.533694726271622, 1.117988510635347, -0.00021389213819765344, 0.4208558350552976, -0.7957733648584642, 0.19273922770513982, 0.03816965366704391, -0.9596970247223864, 0.6037048112872463, 1.0515617286941468, 0.43556008335844937, -0.5667855847607407, -0.25030427920560977, -0.326158006936051, -0.5741916549972363, 0.029302055500779585, 0.5178211264233763, -0.36517131401667674, 0.8963903561144361, 0.633646453914277, 0.9885494401168987, -0.9271873446542145, -1.263443334519495, 1.6775473477395422, -0.08930200413966609, -0.08811786643544048, -2.779535500428903, -1.1838024142514314, 0.6932347823088396, 0.6495944515636741, 0.1271807367714086, 0.6645595335493646, -0.988196293069441, 0.8659681512623735, -0.26220352578333933, -1.6406719653682116, 0.9071177547339239, -1.1200648145628236, 0.8199654615728675, 0.1963311451119654, -0.08326477544648331, 0.8525584503983101, -0.7205776794447292, -0.6328304934599847, -0.22208615954532793, -0.9911401019623979, -1.0583757674010301, -0.26249496298585473, -0.5492470689729593, -1.137063201022688, 0.16601360308391264, 1.0967443064932725, -1.0478310531565882, -0.6094420618585772, 2.191826285526326},
    {-1.4510419017445266, -0.6976464386616318, 1.0935353782853376, -1.7433213732951958, 0.4186794130677527, 1.0666043567094992, 0.7408004626658513, 0.06379551041122189, -1.7425673677880709, 0.8881326587367856, 1.9542306092617006, 1.119367089814588, 0.818604480784949, 0.19431454500186512, 0.6644536209784474, -0.2664322033825902, -0.6629080020088453, 3.1355368518842743, 0.34851272909783526, 2.1807203730833757, 1.479055780294296, 0.36544906833154667, -1.815219369414127, 1.9034087281256507, 0.7022883407664419, 1.004743086498626, 0.3171042461270624, -1.1515098202921552, 0.8936487218676417, 1.1406180947862115, 0.21955233023346402, -2.9932608573930617, -0.5692324222276295, -0.3545277494991016, 0.6644054176216413, -1.106097079431468, -2.4470948982552585, -0.5658448113101918, -1.568071587429281, -1.4282718336966518, -0.5025356909105941, 0.2640207263229384, 0.32952706298833256, 1.1079151373986318, 0.7922763895702903, 0.2774535094313282, 0.915751865047925, 0.7688790415429042, 0.8963332212921828, -0.16769463233514928, 1.3791677625989625, 1.7510386059569294, 1.5941333128345345, 0.5286078196116031, 1.0301814433424523, 0.042671835831376105, 0.142226218175545, -2.5444239618813946, 0.4153376873806579, -0.045245950445746176, -0.7374022118619595, -0.6048681017983348, 0.8554323389580434, -1.377427818022174},
    {-0.4432979746717566, -0.5413113866140664, 0.4144660815781264, -0.2284765828569856, 0.3432189207233701, 0.586145844441489, -0.2374403061536487, 1.204695097384731, -0.34609307328944744, -0.01863019849705634, 1.042565342009546, -0.14852348075739602, -0.906542685689743, 1.1945090903690776, 1.1994884303801916, 1.7923415864955137, -1.0969297012155395, -0.8361567655560124, 2.02635795774331, -0.15573517442112303, -0.19274072576819645, -1.0323717442463969, 0.38892254045347585, 1.3022077658929785, -0.8509852535359825, -0.0632578217094174, 0.18586934726247129, -0.16531778227592994, 0.9034461818453631, -0.2155707831585183, -0.3564659028996831, 0.2287801219833892, -0.1947596486687242, -0.05540912802203004, -0.3927014153654772, 1.3396461704246478, -0.9171164677941239, 1.1525506697881827, -0.3394295654317184, -1.1576100070393538, 2.384051027591871, 1.134881133284545, 2.088359319539411, -0.9471445194478719, -0.7377481803064376, -0.7689067867836392, -0.7494791219947846, 0.41373655575860274, -0.4717841984386519, -0.6149919536387518, -0.2012542378746373, -0.4217874805092421, -1.2082010846386328, 0.38763945534068167, 0.4450613222813879, 0.3680799911938724, -0.6578411870530892, 1.2083491347939006, 1.6635309433037748, 0.9691894286096334, -1.194569953913371, -1.4681886371490918, -0.0722332732230399, 1.4312342566229892},
    {1.0450976182163667, 0.11163567891861027, 1.6836139006426543, -0.749070711669974, 0.031263528815464604, 0.0970636330740123, 0.2013608958413975, 1.2300230267585637, 0.808419556332987, 0.4875770906823076, 0.5948948460708519, 0.5711392057666456, -0.8420102692071524, 0.3573496069271765, -0.9876305246223712, 1.2079615276094888, 0.7589526170452194, 1.5810559267340196, -0.9609802342176925, -0.7543885146808272, -0.38351554474408417, -1.024130831660249, 0.4178847410884418, -0.3463070120357598, -1.1404566549843713, 2.9697583694041114, 0.15019440996850755, -0.9902272494085214, 2.02055821548898, -1.513644299120455, 0.1388026198140974, 1.9832762891089109, 0.9484768610096392, 0.937685345127124, -1.7100674153467126, 1.9013280022292036, -0.9311165719143213, 0.07982325498431057, 0.719019800161073, -1.180834559882018, 0.07236963456803025, -1.2665736149832199, -3.3420717111359166, -2.004580824423442, -0.8378825552560364, 0.5380020842039639, 0.1572284058078717, 0.3930693340247919, 0.7835671483819915, -0.64892496173225, -0.8908811348242838, -0.39214013052086816, -0.240894611661232, 1.4625225537494948, -0.5069437421654732, 1.7537389451397773, -1.2902870550331036, 1.1355334638704877, -0.5010037507371614, -2.6719587627008656, -1.1741514443320011, 0.627644124381819, 0.34069073398641536, 0.9078452299847919},
    {-1.467487726400623, 0.5195591250849767, 1.238570467816055, -0.8566954470311011, -1.7086653876111595, 0.025937758072534102, 0.5436043107119346, -0.9595249448909517, 0.2703589324497099, 0.25454788952981705, -0.24594715284253676, -0.9903770451816859, 1.9880359960656901, -0.6805374306882731, -2.7458656600471048, -0.778956125958982, -0.061749305326179484, 1.5215480572140887, -0.8676783292354711, -0.3853159219475338, 2.6358276801952187, 0.627563067776967, 0.6714656574154646, -0.0956553407155743, 0.6429244614197621, 1.0518354123840186, 0.5571706578240903, 1.1082307432180134, -0.3716661158064729, 0.9222030716559267, 1.4257239284589027, 1.1548073092275435, -1.8331788202448032, 2.1079433591194694, 0.06374094808517743, -1.6655381022469575, -0.8822215975744299, -0.7564362530531806, -1.2262479644175854, 1.0256523980795544, 0.6540528578416912, 3.714260036909023, -0.48852793540077727, -0.6939509682641369, 0.8400345090665079, 0.539534390958641, -0.40738721684684714, 0.9063660199171205, -0.3335881554726015, 1.350717239591003, 1.981976164232176, 0.09926202336823706, -1.226076188313274, 0.5160338145565131, -1.0500819849032155, 0.4994065564336015, -1.9126766091684964, -1.322769937783455, -0.9311817001844355, -0.0965830576984033, 0.37782903375296023, -1.0100608669719713, -0.10720124172154778, 0.49982311468068524},
    {1.9160776541373252, 1.77096813343937, -0.886178399508784, 0.2747851074056693, 0.22598786366776244, 0.7407445748692206, -0.6414130824743209, -1.7101256365659523, -1.2356178594118647, -0.5420555488980217, -0.35591692302563516, 0.03793668183911905, 2.593349812345876, 0.6991183754473604, -1.4127753987330038, -0.2119144010602451, -0.3629924488701051, 2.3866965566286993, 0.03418439168410441, -1.2201339857003968, 2.742264050094808, -0.8822689161117836, 1.3299803822273675, -2.4683063886825685, 0.4654596824064921, 0.9102326671742754, 1.0512016477761894, 0.5004840913065095, 0.015311517967380969, 1.1125716868735316, 0.009188367062182907, 0.8030262785676062, -0.883673868894408, -0.45609391923571263, 0.1482511023607735, 0.9077275054312647, 0.31427381014688943, -1.6261380200017685, 1.8751122849514628, -0.21736992906604743, -0.6780982694613481, -0.30852156996155317, -0.09492077942616337, -1.4989133170560405, -0.40429989908843383, -2.092630921151772, -0.32832061909705745, -0.3734664291433773, 0.703685894675224, 0.2716143913907359, 0.34916942193359535, 1.6651289453567053, 1.0961349066976875, 1.1756927783461653, -1.322017346305156, -0.9561790357463785, 0.6393051604355378, 0.7481210260120151, -0.6421621823708716, -0.02888200257931742, 0.1769400602558538, -0.28174343928384665, -1.1972502012562054, 0.5933995143187146},
    {-0.8322183084427198, 0.8423904294855252, 0.9851286247073555, 2.442213774924406, -0.2533689914047892, 1.627801068475744, -1.9656820876528602, 2.2821980492606886, -0.885885276202665, -0.43729832023415427, 0.004619794130898232, -1.1186445835851142, 0.3160566380621033, -0.1925794447774046, -0.47659668183396353, -1.4549741255103648, 0.08292037695405213, -1.5111947470928244, 1.9017569783770236, 1.3022816096990162, -0.43424754257901016, 0.19770116726960288, 0.266531151291405, -2.0601922002598996, 1.0024718095106278, -1.359957417576447, -0.1620645641634261, -1.614080077206825, 0.5740677339767638, 0.4021237572086034, -0.3595270669696356, -1.550746983185149, 0.33634897837411126, -1.3923617323317958, -1.551880538903251, -0.34055452215528614, 0.1686793615480921, 2.1825489064976513, 0.4362692465908745, -0.20318848312738108, -0.18319423185091108, -1.0196532544429968, -0.33179895631580675, 1.6847525170966442, 0.7399355026170622, 1.105170163663466, 1.5113165917313633, -1.6650822040276496, -0.7245380904325277, -0.7752446335097414, -0.33603254502134644, 0.350258238170752, -0.9580909405869857, 0.9583754778823136, 0.7648485209025122, -2.3680094611393545, 0.01948471001527659, 1.5562346259217024, -0.8418302595523368, 1.0052777300264575, -0.7249205334248471, 2.3766192531886956, 1.5615739893220026, 0.33688523569763834},
    {-0.8555843475457025, 2.1129835249854, -0.7260895541198048, -0.4885736543915634, -1.369341315781416, 1.9476493160716117, 1.652975927481955, -0.3028744234707586, -0.7449384919457256, -0.8318779103474392, 1.0389138903291006, 0.24436659996794816, -2.3271348292706255, -1.0540751201420973, -1.757844905598704, -0.7245055498735243, -0.9587580142366473, 1.892741329149785, 2.3034206903362002, 0.04817209299348401, 0.4570741365217098, 1.5061760875088324, 0.8282723876285627, 0.06389006947396701, -1.5258111833149446, -0.15009266546378694, -0.0738232175766557, 0.8005681721939573, 0.7942840968482758, -2.0430341582395144, -1.343947504767881, 0.8745617768211534, -0.12427335046282448, -1.3816424837434043, 0.302413610150215, -1.364362044537541, -0.6915674628745628, -0.44496396507157815, -0.4184014277384992, -0.3053524481279394, -1.1990700633181095, -2.214765243516592, 0.09665444291969752, 1.1601784731854259, 2.541559476832139, 1.3691101448318481, -0.4987701788479534, 0.38237585451054895, 0.9970120163600581, -1.4148283694482315, -0.5005382922270512, -1.0965177185997879, 0.05168783724666637, -0.7828199381783629, 1.022578287663271, -1.3124612240029319, 1.1811592116123057, -0.6199786784132648, 0.5835983025376095, -0.41006102605475114, -0.2795680239833218, -0.17225521161927632, 0.3515510597341555, -2.0556997630225458},
    {-0.0761793214811255, 1.1457994788254118, 0.516399647855635, -0.6922770650533985, 1.498812874450376, 1.3524641576013665, 0.7814532355558772, -2.5867804835122166, 1.15718283596631, 1.0143029420318994, 0.7669766919263663, -1.2840025771009, 0.05151095701947024, 0.549902784875349, 0.7213479673793564, -1.0610433505811987, -1.2155540983351176, -0.8495188209048377, -0.01799121618631158, -0.5607099453980438, 1.730723961746035, 0.7835055756715267, -1.5365069621828706, -0.4433516829454801, -0.6596342225456353, -3.791506990556362, 0.7425471265645156, -0.7826416327080534, -1.3253092895713217, 0.1337611726365814, -0.8656719719128744, 0.08962475951577362, -0.507826458119269, -0.08438672922209586, -0.03957454610644359, 0.41599858289057895, 1.4804303875206368, 1.5041933432259333, -1.558269376532041, -0.1050255648628167, -0.19731035226946209, 1.0028030052406807, -1.2060874904815586, 0.5189787132322687, 1.508394273399794, 0.4586315273046287, -0.9499847710346186, -0.38711169881650587, 0.42050774777660155, 1.7628219489356418, -0.15815027847792204, 0.10427587800523938, -0.015105636248219598, -0.4021554799770816, -1.4158002123088598, 1.8874719003443396, 1.8721851037849147, -1.912074516348417, 0.4336196546339912, -0.917161943973347, -1.277658618484066, 2.2222828739365235, -0.026728139162329623, 0.35806066690565114},
    {-0.9574075430656408, -0.9922107589129603, 1.651874075421575, -0.3621845318526876, 0.7345200591184132, -1.4723706707673463, 2.1618269622698425, 0.6353675933912606, 1.350702338543526, -0.6920816062096782, 1.023062091247288, 1.4077838661483917, 0.030430624318743604, -2.5859750800619916, -0.9049866238129205, -1.307601345561804, 0.3119350660367502, -0.2073959610712772, 0.3148696866984788, -1.3893703826573043, -0.15330254556711165, -1.2464642797416567, -0.7358699435644935, 0.40225148347936046, -0.05205242036182944, -0.23082281058374496, 0.014910013703782147, -1.6154372414599125, 0.4711517787058664, -0.11318001770962569, 0.34471926000909825, -0.8548216914661766, 0.208087440940543, -0.17180559277211224, 0.6703978294386647, 0.12957772169621812, 2.120250590059098, 0.31615368670678634, 0.606087017585122, 0.1735244120808418, 0.03960808156768251, -0.4540810705713421, -1.9523084635755927, 0.9177151968677619, -2.6208271920203834, -2.001502047455937, 0.8247051525869832, -0.6206295561131879, 0.9258954100240901, 0.3403517887954917, 0.5060358661608632, 0.746065355276062, -0.13376584346281192, 0.3507588527088866, -0.943429322642675, 1.8867855355413385, 0.32167676513556936, 1.9941872157460065, -1.330094377285617, -0.2599294458887797, -2.1365702629900385, -0.3902433471060489, -0.9052673642622324, 0.24342989887580896},
    {-0.12580019113547758, -1.2574326340231516, -1.5248443110061838, -0.031085380578559196, 0.5341304359921483, 1.0900565659370816, -0.2424987633527081, 1.2290363474777148, 0.5757874171630062, 0.6787769777900696, 1.2191157573414242, -0.011664054413326881, -0.5642026453642788, -1.474943847767642, -0.40329982178660356, 0.24596042403428212, -0.49147001302962795, -1.1143139862044968, 0.44524406639791253, -1.6074137957638073, -0.3320501084137092, 0.006458184900590898, 0.28929693941068035, -0.3129314102697854, 2.107745629494051, 1.9964847719964103, 0.4186390908378518, 1.1413821619543847, -0.8708520502795846, -1.490280147962059, 0.6376873999351216, 2.185881742603018, -1.1844914004386093, -0.328675591972216, 0.4614895496906973, -1.067325119932044, -1.0192567024695243, -2.3586885818862737, 0.6478527995724082, 0.23180753623534306, 2.629984746307345, -3.3303930254913254, -0.9282923365439852, -0.8666873744659553, -1.8542281883456735, -1.7128045470799713, -0.11955215472995785, 0.48364652889353715, -1.7880583036988593, 0.35950497794001174, 1.1720819894793149, -0.385420051560253, -1.0054448931768236, -0.7205771306370431, 0.08541261170862059, -0.4160427137125667, -0.9758468601696072, 0.8147399118659182, -1.4749546723190232, 1.141279586583065, 0.10444806226912326, -0.08836964785502562, 0.5528529603482139, 0.2145630953930385},
    {0.1201136940348787, 0.9958144999984854, -0.20339297023983186, -0.07809582248336368, -2.287317256448506, -0.01972469760819253, -0.12051292213713771, 1.5473266707185287, 0.012751724880506063, -0.48355280993386596, -2.239801569835834, 0.20910983424757631, 2.071584419002621, -1.6844948813672413, 1.2982523338606757, 0.12220303050222649, 0.21458810527081792, -0.560816577540603, 1.6024313170687594, -1.206063594236033, -0.5204332939525311, -1.4440412115999886, -0.07973521620220916, 1.8694846451885423, -0.48576883994212844, -2.0661456591709837, -0.33829622664910014, 0.5783824267151869, -0.1350785660351302, -2.470152351917455, 0.01292785327490975, -1.172792660529289, -0.40942116984694926, 0.7236904438809486, -0.9468126215003803, 1.4206743267237072, -1.2606458886758902, -0.6321930176011794, -1.470968113488642, -0.43440218372658773, -1.1608955605452793, -0.040072818380566665, -2.3617861275070156, -0.868942002452472, -0.0654865118337996, -1.3178786451607423, -0.2633120164555737, -0.8025756226437668, 0.29173361769955886, -0.5893019680728413, -2.0770187610150597, 0.7639351138007702, -0.031899152344698416, -0.20141233336738748, 0.15169478892838079, 3.555640052234879, 0.5969356401146436, 1.2335318561845552, 0.04900450135429266, -0.04978214697977162, 0.30743978091765123, 0.11241260328010359, 0.5451335034942713, 0.3363048153205345},
    {-2.0639361733134503, -0.13529809799031456, -1.1110865617382446, 0.5394702022387201, 0.24499414967805822, -1.0122314083094393, 0.14061324393588542, 1.1925337937723839, -1.6613069407981933, 0.8700959376755629, -1.380737003507983, 1.3455691316116638, 0.4948783718769668, 0.33503318176937147, 0.3253013293352837, 1.4180453658080734, 0.8076710000829499, 0.8905497723603524, -1.2971487747881727, 0.8230917354830825, 1.9291385703214674, -0.7057266557401383, 0.7368280971342023, -0.5428683930495863, -1.30642004587286, 1.3122761488591468, 1.7360637985306133, 0.5185442161833229, -2.2248418483060757, 0.37888166009512625, -0.06362075815594424, -0.5932920062381146, 0.2778197870315883, -0.3343079664073918, -1.7306611377133263, -1.6668843413125052, 0.20899550207886802, -1.7666223468396736, 0.13516648997091463, -0.8471894463425473, 0.8186186093699999, -0.3591460532282046, 0.18747050863667442, 0.10992811807138671, -1.8025599730122395, -2.6751075121563046, -1.6210323988854751, 0.8621070076397876, -1.542535898458408, 0.6615423911049976, 0.09054072080326883, 1.1420228594830255, 0.48854461605509597, 0.7028158854947096, 0.720141510038165, 0.5861819630383206, 0.9981713766612345, 1.1706543998204346, 0.35715997733356053, -1.6927359292869697, -1.5420098523892176, 0.13447731438557006, -2.871125716585893, -0.9783562698206306},
    {0.8644331876145036, -0.45840318803078073, -0.8900943314936399, 0.30243029576895025, 0.38901206092975543, -1.0991846660879678, 0.17203001083457514, 1.4239623763859184, 0.11010648195609422, 1.4768523366776274, -0.04022226890635854, 1.0663588683960532, -0.6784813114396353, 2.679163315611124, -0.5720380357142015, -0.7671076525606882, -0.44369138819774206, -1.3927500376373774, -0.46795743765521974, -0.55504180718942, -0.4516365312997804, -0.18439867914625024, -0.9799573231233092, 0.20387203243617058, 1.5175752420938222, 2.077836839011493, 1.562044368664951, 0.14644377898962682, 1.667200568980021, 1.2758677728964674, -0.8644108186404291, -0.5913158126222298, 0.06898988624239676, 1.1884854055964524, 0.6215423200572261, 0.7795669679761063, 1.671122541576142, 1.1753765752685619, 0.8739536194477683, -0.4140740732483542, -1.2111383772486577, 0.6029318559468955, -0.36914194104684356, -0.6252899286609545, -1.379415871149349, 0.7712782342676892, -0.9515636470836297, 1.6697062282189985, -2.15039478683891, 0.05414716050952123, -1.6776962870154417, -0.8524493323904329, 0.7249507480176342, 0.8902724413904488, -0.01578919019308809, -2.2131928780135497, -0.539939964191026, 0.2963769760367752, -2.328937952616256, 0.44022420413405355, 1.3962053328974033, -0.1042001967681631, -2.375645784639345, 0.9195337706033423},
    {1.187954893922285, 0.29055223418030257, 0.13069437928370561, 0.19169234122713927, 1.023372779713241, 1.3406320984436582, 0.715863164235078, -1.4713261766176637, -1.7772891381563354, -1.7423931493216944, 1.8787706466903438, 2.506588107617994, -0.13394805154520534, 1.9990752471784756, 1.0452489987731874, -1.4655440384348266, -0.04614992756007941, -1.3073011038571618, -1.166103635331092, 0.35945993750666516, -0.12795952341580474, -0.18418100898357215, 0.8260421775826912, 0.8449525630768306, 1.695542370569626, -0.8476553883884989, -1.8040507381861188, -0.5657771962041023, 1.3807276833145512, 1.3164858568912294, -0.36744454072425825, -1.2630483928810807, 0.5039469283608154, 0.3217065835656105, 0.5892003130302572, 0.04474489141861259, 0.34710376236030216, 0.5499534507839592, -1.25028730283621, -3.2789855841698867, -0.6980100001398082, 0.41178424057356516, 0.1188482911109662, 0.09712079721053812, -0.4308654586814616, 1.4744472649227658, -0.05678121154656459, -0.4421510220067095, -1.3159045074111018, 0.7305992284392018, -0.9286224446431459, -1.228763762852128, -0.40589660069815764, -1.1775056785434361, -2.202038969623777, -2.680539920222033, -1.3228119349527843, 1.6793343689639253, -2.1577935960251065, 0.9807634442180297, -0.7248427169994293, 0.5172898003358444, 0.012853983261406052, 0.07499543783019781},
    {-1.1998127677565136, 0.7697171777486029, 2.2498421571551437, -0.754941188713727, -1.1931995946726979, 0.19406140600833136, -1.450934421236343, 1.695215805705779, -0.4680576931667546, -0.5491865361999274, -0.923139185204597, -0.11953543658919454, -0.17569847587852727, 1.8270972395771863, -0.5564304922307564, -1.3968247153706383, -0.9586584309063376, 0.2733368682025816, -1.031792540613985, 0.5458982744198977, -0.3741630494934962, -1.4656514692683602, -0.35995055501872414, 0.2730459669757693, -1.2222568690057554, 0.6865741645497768, -1.5252833954400722, 0.27086773736771047, -0.5447878002109068, -0.40760664220249937, -0.6381463825281379, -0.00046135480207989754, 1.6116607207853382, -2.5402036811695172, 0.8988338541384236, -0.3286710200063083, 0.3974308679225069, -0.5033492479145917, 1.0136445254753659, -0.22241335342507096, -0.7005645932088159, -1.7666049649758158, 2.37975580384407, -1.6080845889493873, 0.3412837315198603, 0.39433224868726485, -0.7555067529378173, -0.10098638526172377, 0.887651636387809, 1.6354391856311998, 0.10882718092461709, 0.8252676476190018, 1.5673548196317255, 1.7391600058287449, 1.444650815668939, 0.3478693777189884, 0.03158620863364596, 0.29938118311132694, -0.22230981782234582, -1.4170302167277828, -1.137744898896259, 0.0002620859557151631, -1.071888356680572, -1.3420068981786522},
    {1.6885271633365837, 0.16884566810754975, -1.319969498818335, -0.5171426323059194, 0.5926980111072819, 1.0343897954664483, 0.2461104104000995, 0.8203885443752947, -0.6662612517017382, 0.7689468747158518, 1.6436814296285007, -0.045971923093636825, -1.593314318263797, -0.5973219861999219, -1.2085398359859743, 0.05895824949047837, -0.44130631077827226, 0.7745556069649498, 1.8262437268446665, -0.5730027269028545, 0.7530691306181079, -0.25445089347402916, 0.7040261968409601, 0.024970521974854956, 3.0039001887188204, 0.023580748915607002, 1.343671000089469, 0.5249408396357063, -0.6443550913411414, -2.3548420486731088, -0.07874063007668074, -0.20331416196057275, -1.4571784655422952, -0.19714125867458565, 0.5347864434772618, -0.19447867776563768, -2.1942939146201157, -0.37786917880154236, -2.138393915446072, -0.5135013256061248, -1.7706843238822307, 2.226788211073787, 0.4482792591229877, -0.9892808543788236, 0.8767340429447517, 0.6039580596307327, 1.6370300050644053, -0.12056088053854215, -1.5893282465119885, -0.023306057962906274, -1.6928803113094844, -0.1083092559774568, -0.8960088151437382, 2.23615717780943, -2.3811125544986416, 0.3819572018398069, 1.40357383362798, -0.39894164181629654, 1.3144964137628203, 0.6633810656768083, -1.4250944642683407, 0.38551145198227604, 0.03966692372025997, -0.058232253005854856},
    {-0.1434214242561319, 0.6088743223547863, -0.8414687904068199, 0.036232070807495916, 1.9116535007395483, 2.1357435777008322, -1.774489510217841, -0.6862276363240204, 0.13677480652504978, -0.14451685587007895, 0.5678828042263213, -0.6565756483825129, -2.5502385358112067, 0.24036370358601375, 2.245779300243517, -0.8315533074748946, -2.117039780004418, 1.120290266276405, 1.3407420223907134, 0.2126986291743385, -0.25989925353358434, 0.5094986178922971, 0.422252195469728, -0.9358521737666652, 0.3809957298042338, 0.7162363371159174, -0.5918678080307836, 3.0879200701013314, 0.8556229848262333, -0.1790548567751761, 0.18071518970674733, -0.030598934213680574, 0.4273834391459744, -0.39449225564552354, -0.7409245031979049, -1.3460991040907422, 1.4447372755576264, -0.12461100336875071, -0.36305366949110107, 0.8280507873038239, -0.48791798037743145, -0.3911569007620583, 0.06912319757715436, -0.48818751645774183, 1.4084216498653503, 0.2709740148239294, 0.5430138419970827, -0.353186878094528, -0.09565217097363973, 2.414068031248863, -1.5872664293675414, 1.6027296470058239, 0.0978551522161676, 0.9608465982381454, 0.08105852775332138, 1.4299522781024683, -0.827406877007128, -1.0940611208228013, 0.3604267504173923, 1.7921107625496147, 0.10859639493107152, 1.2108215832970428, -0.5608143376051878, -1.675828759308003},
    {-1.625001651794883, 1.3051151216098913, -0.20293308323003406, 0.833426901760188, -0.1413423970830915, -0.19682161595792982, 0.6692586841039552, -1.734130933863504, 2.601550043734795, -1.5477644070078844, -1.299142977698845, 0.28203325948733365, 1.230498843225074, 0.6428331731361674, -1.1276512970207855, 1.3896272702859365, 0.830420362942219, -0.316739136305351, 1.194768826544497, 0.16580176558985546, 0.7824109297344983, -0.8765579793653095, -0.6871040219251224, -0.7325469973718659, -1.855321539420172, 1.3361469256807466, -0.3276201153966119, 0.568158546214724, -1.3436118692151209, 1.9625179289136274, 0.5456634494963158, -0.47396835881554567, 1.3782453341861896, 1.327234297604511, 2.045711704476379, -0.2929784222685465, 0.8942674404804057, -0.031097937756658606, 0.16523680116532627, 0.16749310051625088, -0.07711444994677726, 0.21903275017872706, -0.6200675805590413, 1.2375806807837977, 1.687825002150749, -0.635010806928466, 1.3724596632409516, 0.3785265145328289, 0.21367181140298802, -0.5808872359786367, 0.9121997029789392, 0.23484407776885707, 1.5903735863645994, -0.00039388517269614847, -0.07468928911135381, -0.13801328179774588, 0.12953031564384476, 0.3977203434037991, 2.1025401676868247, -0.48946230749268, 1.0990898294973206, -0.45395106867565227, 0.8230360452118346, 0.5259327939009847},
    {0.16794819755569168, -1.4330271500546408, -0.8808062895207966, -1.3112426352134072, 0.44145474673147644, 1.288932796125521, 2.105340813923393, -0.08793325203723788, -1.21064895467124, 0.16797122860241226, -0.10287924941622084, -0.7015582866426646, -0.3992065027740643, 0.7380365777677558, -0.22765357679420437, 0.22307316426826487, -0.32604282321066436, -0.9501478655324379, 0.17925925123160372, 1.01759339462412, -1.648255057478859, -1.8576054057579727, 2.0236225327920114, 0.3281806200678764, -3.0416542876255743, 0.7488437979172863, 1.4702555396578638, -0.5871417417542673, 0.31200144326350193, 1.953015162890208, 1.293406379550481, -0.17030833336898937, -1.2343879319506692, -0.8485727420978322, 1.4639641189060182, -0.0456439247168735, 0.7310318975137488, -0.5180732614236577, 1.525084900329432, 1.3142427284318259, 0.1896693494949575, -0.1433342552931986, 1.2966369625909484, -0.9445419222141458, 0.5425197623360363, 0.7061841117465769, 2.170458310416709, 0.7416868523203659, -1.406538849823363, -1.6638811734921433, 2.0860099425910077, 1.3125616451637085, 0.41058039515834355, -0.9530240621818846, 0.4629877437401244, -0.2610929130971581, 0.40698417745795745, 0.5142564999101775, 1.375150850545243, -0.8142276176689399, 0.830188964251155, -2.004225128693049, 0.26532974855627145, 2.5767112528996967},
    {2.542155817378877, -0.45630351814266384, -0.673129183831537, 1.3918498668551107, 0.5966631257231754, 0.8264762590063368, 0.39188630771202676, 3.4521709969426624, -2.0143395151435066, 1.152915931663851, -3.0055114424152114, 0.2369077463991872, 0.1798718417279979, 0.6626716917268688, 0.34510037870271465, 0.5853396730401943, 1.668648261038284, 0.3423069294515946, 0.8390703648684055, -0.3505002362361101, -1.3678064079204773, 0.04575308110618148, 0.24926899143553122, 1.4008382197829985, -0.08622896637582969, -1.1031235986172303, -0.822111533931101, 0.09208616981342899, -2.677660369617095, 0.6195023788372079, -0.3699072254105293, 0.6438117340991919, 1.5259327125616413, 2.929438733933872, -0.6177038146592861, -0.004736295768594321, -1.739199960652025, 1.5894511478808135, 0.7599812116586898, 0.22066358223646157, -0.7857432388943346, 0.4032535249616645, -0.3411589786272961, 0.504711793195327, 1.1868403425695042, -0.08164413733779201, -0.6077297844897206, -3.1269698310143363, 0.04457887734405241, -1.5129409126781377, -0.9988305296121609, 1.2979784164418129, 0.6331944103868176, 0.8010380430556674, 0.4753723520753699, -1.5541291965997905, -0.889135428184372, -0.4318467633470455, 1.2643639687363968, -0.02638371580652573, -0.16691276880754374, 0.016298182592571594, -1.6616337502620646, 1.7946862172409253},
    {0.8505980092283362, 1.4708803361056786, 0.41408325003109364, 1.4580669792969552, -0.2859459254797458, -1.370152123437973, -0.5778179435646811, -0.18887160486287105, -0.7255764567299744, -2.2951506708393734, 0.3621135535320698, 1.6483360439577468, 0.5410293558851068, -0.7138150441051029, -0.983447595496333, 1.9349959199845876, 0.6125350902413093, 0.10312606672797849, 2.7017886703622334, -0.28376892800863673, 0.5636423323193247, -0.2915689852920535, -0.310242696384027, -1.531174157482416, 0.2361062307657351, 0.3949148531096425, 0.15470065376341985, 0.8167963373476214, 0.4547340558015656, -1.9379116890719958, -1.0348334297562585, -0.9677675872744739, -1.3714675743331608, -1.3084504828959562, -1.0331165578580719, -1.0535765060271824, 2.085811915907093, -0.5688646450109227, -0.8674984809599278, 1.2559786871980194, 0.3319610094785799, 0.7715835542158686, -1.0447261841764102, 0.5066580004500267, -0.13407275151236633, 1.2685276114082036, 0.8686172772747878, 1.4739395288098995, 2.210754170167635, -1.0238233519175746, -0.4409111685154451, -1.703248692043868, -0.2650626590563799, 0.49951548857818434, 0.7819089131556431, -0.9241921424986983, 0.9816096757884901, 1.607784982626589, 1.5436566651638228, 0.1903561183052322, -2.474103956676793, -1.171180196465795, 0.09536609213930826, -1.0638150357539091},
    {0.7329615543923564, 1.4837826130578031, 1.417970677834952, 0.056750426030567694, 1.925702764915202, -0.731362110366376, 0.08906416184174977, 0.6998670548087478, 1.053548088585724, -0.5202745471775104, -0.31743262841900527, 0.448303866175685, -0.6731025877663946, 1.6843346663114178, 0.7907312411235454, 0.497885776657072, 1.422394457088156, -1.9100872910129527, -0.8400930365003378, 2.5677797658708674, 1.0950697563350231, -1.2326821768882537, -0.5272800617340342, 1.4299059446250872, 0.5959854543959863, -1.552815498652694, 1.7491054968042083, -0.5669727527043831, 0.020665737776067238, -1.8288495517842078, -0.895993188476138, 1.5024961609145158, -0.3822593761558552, 1.4693175919760106, -0.8982699383230192, 1.086684154143267, -2.2844349556442296, -2.2155026185962043, -0.5645581847579294, 1.592789013209267, 0.02377553539219493, 0.787508480712492, 0.29769199985564254, 0.06991125807744317, -0.9549397502324378, 0.9378476140181262, -0.023418148872722585, 0.24853549819788567, -0.25911268520546316, -1.583644636296575, 0.3647413145232059, 1.9651631344196683, -0.9962631564864589, 1.0026666596664553, -0.4120152416900945, 0.2045922232701141, 0.6657066144233569, 0.4309862414148299, -0.9225282518870311, -1.3179604889985053, -0.12120527300005127, -1.448048634536428, -1.1560854614190297, -0.19827572501095517},
    {-0.013878059699113439, 0.25099313008335616, -0.6941889194329324, -0.10101748297151224, 1.2585397347085954, -1.6419945837909375, -0.9419243518853471, -2.3969926633558587, -0.6502661394436634, 0.8324772566631969, 1.077598698685902, 1.189916507095234, 0.2976318052479628, 1.9139648094264838, -1.0108483933510497, 0.12143126806585264, 1.4841887813670105, -0.688831921492634, 1.2081424002369225, 0.8985495565633405, 1.6797645586614203, -1.5468328786047658, 2.128734890995869, 1.4660093658415476, 1.0107994411254262, 2.1397866019679177, 0.30540116131276557, -0.2566759712899121, -0.38625272469380234, 0.7369955425279271, -0.37245217937286135, -2.6092474874209737, 0.894727846681283, 0.8752642939963619, -0.03605853036984192, -0.6297000498390891, -0.49708922521902305, 1.3593419153946873, -0.06401658063980867, 0.16237498836090158, -2.42172800939548, -0.5365938354930134, 1.2042353944428201, -1.5111660107252476, -2.069754362354863, 1.6588082745962038, -0.7080446570056048, 0.26680087575991984, 0.1839123839970329, 2.090810766152161, -0.11014397468254392, -0.20421382606672717, -0.045689745477734994, 0.10176536278351278, 1.7012888535536639, -0.7751370606192315, 0.6663363822309124, -1.6722447242969372, 1.090754831232273, 2.7157643675910204, -2.025010391598709, 1.5458755062163196, 0.16382330853274624, -0.617573823920687},
    {0.3033104115505569, 0.49839211516392723, -0.6708281891578389, 0.8786963164195746, -0.24260219328862118, -0.7795431830794689, -0.33500106012173614, -1.9638828664966732, -1.0283729932697179, -0.4474672491431318, 1.3463004021908949, -0.14452275911541443, 0.41603534841265055, 0.03325063977651969, -1.8825820310911934, -0.21671561876575113, 0.9571216729337796, 1.0906106093938257, -0.38629927657868113, -2.435769832290139, 0.6655187098442285, -0.6102056878924536, 0.5315761069477696, -4.332484305799775, 0.2751376933764921, -0.8709467128950727, 2.1776389757045935, 0.004823662565862976, 1.248346554455417, 1.0822787843522141, 1.0807090297931528, 0.6657535722169551, -0.3993511251579447, -0.1517334872557251, -0.361784333824385, 0.21948204118744769, 0.38125085733717595, -0.5979372699540525, 0.040344900757841085, 1.4592653269418592, -0.6446091225903772, 0.43496857687683055, -1.0127962971937485, -0.7572883765590742, -2.8186923464611287, 1.3485285674744232, -0.11200897324499434, 0.40458722167045996, -0.9772514965677954, 0.5988091368860273, -1.0030239033207824, -1.212080121109444, 0.7854894226458542, -1.399851038982134, -3.0705440982895045, -0.37617130319853687, 0.8921156305278841, 1.0753983355092938, 0.29347511542928073, 0.43246857907689484, -1.8559144489571753, -0.3886662790165849, 0.8926921914898295, 0.7185256286062169},
    {-0.6888044977380329, -0.6076161801524639, 0.15467006158319685, 0.38619578706879637, 1.50494094112499, -1.7786751807651924, -2.151621349295137, 0.43687255228921107, 1.4699714876441852, 1.3231054251312075, 0.20680317875581347, 1.1297124143840134, 0.8048020748183713, 0.6042725108953663, -0.6151013581268666, 0.16995515132203542, 0.4869910861049945, 1.3066679253163773, -1.6804315224052986, 0.0922613755126716, -1.5641711254454727, -1.1450014802646051, -0.03747510816625398, -2.444714640106745, 0.20221199337978113, 0.904290579180644, -0.2739741056523509, 0.7057863001930564, -0.6204894230196796, -1.5395791665077356, 2.8243303828456208, 0.933778207728253, 1.2161402016456662, -1.0345843017525223, 0.01861441897776917, 1.3024211179537855, 1.3554936638528385, 0.1573596391015208, -0.8774702221549984, -1.0076818905040577, -0.7508770345839298, -0.4169543025675341, -1.5727164167817278, -1.2077158221225461, -1.1471726255785772, -1.2584751099753932, -0.1357514659384181, -0.8747029055802751, -1.0460999532879625, 0.4645319113355925, -1.9734553778476842, -0.4974408082282236, 2.25275707187529, -0.844623906213946, -0.9500086987187222, -1.193160294976915, 2.213519126277993, 2.1405565172471586, -2.6333838727147185, 1.184510748202189, 1.1664078626640837, 0.758894936767582, 0.009464995435770783, 0.42692881338633226},
    {0.12192975813221692, -0.7567412019706945, 0.6437142041653429, -0.30630301791168457, -1.1839163536357364, 1.8921925162472812, -2.298952484394608, -0.0469946748184819, 0.401431775771525, 0.7304670432784155, -0.06635090910617873, 1.238040006749278, 0.6461285350982782, -1.349625959841775, 0.8753957766518272, -0.4343347725311055, -0.005746673319637001, 1.1127550941252486, -1.7591538762723455, -2.920247184788239, 0.8814084380098183, -0.24533601277817263, 1.9208517591371241, 0.8159068438779287, -0.8753191102618566, 0.2473933491213387, 0.36157781491744145, 0.23933154721035818, 0.7268372666489434, -0.9670942986107365, 1.0881874749419054, 1.0572294512713105, -0.5639681065247252, 1.1744037985071176, 0.34698187585271156, -0.1594754841892551, -0.12275826053500927, 0.8623261609475651, 0.6857860641118374, -1.404393341928703, 1.0549892916687595, -2.533504009093821, -1.001610251308184, 1.246362519433707, -2.061424614805804, 0.6582364352849608, -0.3440279404776662, 0.11659611630392452, -1.715490663733878, -1.4934823432501183, -0.623407804837412, 0.9044430096815745, 2.7439079211931054, 1.40842191594023, -1.2408370209115926, 0.2110873519337177, 0.6971551132470026, 0.5047630249826498, -1.3404918325157276, 1.126581443550117, 0.8196254964020205, -0.5946461658401193, 1.0132375094454493, -0.24381928694189384},
    {-0.6587730890776171, 0.18683261496914152, -1.5773777575159513, 0.38094874304819676, -1.04959768408383, -1.2351564528904695, 0.04135042313553292, 1.3049827753038195, 0.8757217892292228, -3.4290363246158293, 0.6388030756843057, 9.124438192100844e-06, 0.27186725584841476, 0.5353763064337657, 0.032680467678891795, 0.21836521697457262, -0.2222641918772136, -1.6669822834490158, -0.29045770758322337, -1.8910932819502306, -0.4991913236149873, 0.9916736092529757, -0.9887889159005473, -1.9154921750315654, -0.7180381224066938, -2.8887729167068046, 1.138798313464741, -0.11496545559405034, 0.8433473905190343, -0.04023439714967731, -0.36520726091827477, 1.9722551107975643, -0.5500272860855191, -0.9939561827024624, 0.41133238466236566, -0.4089172624641248, 0.8256799748297629, -0.41677902468810935, -0.9159116378473763, -1.740619315020377, 0.18113899407409056, -0.7505761109786767, -1.1760392990520407, 0.632518937450476, -0.41957884081630564, 1.8113133111930797, 0.716319464495223, -0.7109041512491753, -1.2267449449743655, 0.1823841481756363, -0.6449677572544115, -0.23253155003752665, -0.7812083536383078, -0.5600677606049491, -2.285638056064924, 1.423882148907626, 0.7608602620051068, -0.3848526636678649, 0.4260010578546487, -0.7954517839564579, -0.2923542070011505, -1.0106907216935705, -1.5780497374117082, 0.5247135389670571},
    {1.1436753030557474, -0.0930632120889699, 0.505254624813754, -0.642117172038644, -0.2124792666618129, -1.2541353175548746, -3.462573782542109, -0.2671768530660864, -1.9752606561627468, 0.9523438869285212, -1.6859370129640707, 1.273042582173988, 1.1642239089537716, 1.6078059779311478, 1.2555205329114716, -0.540132542506944, -0.5673932301960405, 1.2860252558531904, -1.7689771402193177, -0.5129037740042187, -1.5496001119144274, 0.8002132162170666, -0.5824237633741898, -0.7527029423677444, -0.057745795415491935, -0.13401585143633862, -0.7382661504706842, -0.07941261381088405, 0.09515514336636186, 0.3999828073147524, 0.40360534231253536, 1.5047906223368246, 1.3870209814153656, -0.829570637449185, 0.44322577691264, -0.7587869690015127, -1.325277245341605, -2.2344993087142675, -1.9688275377229714, 0.019375778562566243, -1.2606708376330988, -1.1116466153990476, -2.039866370216874, -0.5322258156484588, -1.0767221167656542, 0.8169990311775733, 0.588310248881442, 0.36424057110752783, -0.16829810032637763, 0.9860578510596205, -1.483344802259214, 0.19923917493247734, -0.6818110463357983, 1.1445382095100325, 0.30399265147522025, -0.7058149234840203, -0.0401523895298192, 0.23588209469982918, 0.2813306218106404, 0.594143785027247, -1.1442516660198128, 1.3168115825335065, -0.5906711137291604, -0.535127730904622},
    {1.6965038030238044, 1.1835264589276906, 1.198542441797623, -1.2310002630775418, -1.3856641077476637, 1.856208326650044, 0.24890428922431415, -0.9890805174186711, -0.9174350448981548, 2.0568288108147352, -1.621950196504908, 1.6879886354186655, -0.6961749084172189, -0.5782738777316033, 0.20991318325890598, 1.0796590773086845, -0.5581459798497297, -0.7495640361218855, 2.1620894789423297, 0.6862571273356239, -0.6778388476040377, 1.0748743978822433, 0.4476743356636194, -1.4669222170547316, -0.7837851233052907, -0.8422465772321901, 0.7544304001944795, 1.1924662309185927, -1.1586271557135328, -0.5631062304933722, -1.2515482908552793, 1.3356691931848703, -1.7144667593763812, -0.6609306580308769, -0.5646666279148601, 2.9825175459972377, 1.3113595171465955, -1.1639069369327402, -0.6708538940564692, 1.2663661502926462, -0.03712780278069515, 0.4630338879476182, 2.612432309443527, 0.05301400704154479, -2.8267792985616977, -0.16723692924697028, -0.17908748359663965, 1.1062155944419632, 0.6923623306756372, -0.8463062249803617, 0.5116717657941278, -1.8522863128992628, -0.04786768130570288, 0.5996780960462474, 0.030652479799222834, -1.3943910637679433, -0.31990855943002344, -1.2904279592528434, -0.7702850394339452, 0.1398157122405003, -1.4562754699713607, -0.9875098408932731, 0.401490768754576, -0.33280519303434225},
    {-0.22528493916090173, -1.4352173206797516, -0.41063612936510524, 1.3501505694771623, -2.683025038167906, 1.107918173638758, 0.6355498501856806, -0.31056263923521166, 1.5554033543286574, -1.5532020673107723, -1.7065543121499298, 0.7349028131066042, -0.5054995935851212, -0.9631968495859028, -0.7450227497321648, 0.6675732677357115, 0.8778922461258168, -0.8119042530090169, -0.8374360015798088, 0.522985406496554, 2.6173723604158594, -0.1221320620863356, -0.3238656632164229, -0.6228363173037771, -1.454323390547604, -0.24779177982645287, 0.9142322632551642, -1.321718188197683, 1.3807856945929984, -1.2798069395216225, -0.15004482969928964, -0.8858780419837322, 0.12963893109338276, 1.733405449393121, -0.6136739990088373, 0.21257077417821174, -0.11075280282634566, 0.69400359124234, 0.4728901272527247, 2.378053773162831, 0.7250546295181994, -0.47452655184437764, -2.121747734692527, -0.3078757284582125, -0.37915265351050886, 1.6507166887262927, -1.3733367765230189, 2.1955660832736132, 0.9367200088948263, 1.3075248533741375, -0.8957346946040258, 0.1524928530078823, 0.13219786342722145, 1.7718174072181372, -0.8411181912270224, -0.44615490055164403, 0.9521055781112487, 0.9752916898895894, 0.8525852266020618, -0.4883375832027839, 0.26260368456933536, 1.592813903701837, -1.8890485218571273, -0.42330498214301543},
    {0.6179230956187969, 1.2832133972269038, -0.15350447289911648, -1.6876458528032283, -0.5541324061693147, 0.04186782935426459, 2.1631800340177425, 1.4071845074477416, -0.7496858140375567, 1.2264695263100225, 0.5604418230895892, 0.8300536416950656, -0.29023104845074454, 0.4874227979407653, -2.379823646095423, -1.0154059444021246, 1.1413869756711283, 0.9683458854682665, -2.8716378063400136, 1.4858617089412482, 1.2642672443909235, -1.1832734930651516, -0.555673730544639, -1.2101268446517202, -1.4615180352024792, -2.4554559387046173, -0.062125403497070915, -1.7225247584977974, 0.5712506634004304, 0.10649847950579243, -0.8390413760629691, 1.6969522943219137, -1.0147568593506648, -1.7095237721909995, -0.0603085801691411, -0.03255618185678044, 0.03925813437264528, -0.1633973427505464, -0.695090429202356, 1.1677967864004852, -0.4443012127321376, -2.6703078580808284, -1.12450425363883, 1.377570162328701, -2.2522455687176595, -1.9403919481773872, 1.0492464914729405, -0.769374421744014, 0.2467094256376228, -1.038747630738557, -0.36021245998443485, 1.3951877244063549, -0.021820260194804982, 0.35770097888561764, -0.4699162517506732, 0.661243234569794, -0.3568037965419931, -1.0161895921600548, 1.6051753016613675, 1.290853053599767, -0.5191177104337322, -1.1708519749440243, -0.48515386118415943, -0.9442447688395156},
    {0.2799535889702505, -0.15789374246536642, -0.8817634112764651, 0.3818716837054088, 0.6011439592895129, 2.0028824038861064, -0.032924127530404496, -0.24660298040266884, -0.6407066374913212, 0.3564885499720889, -0.9813399219551304, -0.250763609125309, 1.0112277274220665, 0.4831366931594391, -2.1657077413827213, -1.098671474215092, 0.9805838757904826, -1.8295028010946537, 0.5436602492626246, -0.9822813933586522, -0.8443416966792499, -0.1063089287334626, 2.1991040671799276, -1.3057919791577164, -0.23524228511010134, 0.6701707894582777, 1.0396364128315536, 1.2970360889248986, -0.677207023041926, -0.5148239859981688, -1.2740293703131864, -1.2684310337235636, 0.22579866044210845, -0.921858220284036, -1.1862863700190733, -0.8577106604035037, -0.6213717936858069, 0.35587668986730747, -1.155425739426525, 0.5279809814044671, -1.9762929794092134, 0.47836536965882503, 0.5391433570681089, -0.562849616960129, -0.6866429111436196, -0.3110028236199399, 0.9298416194908137, -2.099842699361311, -0.7111482579733354, -0.3442971213879765, -1.3467123581642384, 1.2415502342504106, 0.03199639208624014, 1.1180711180450302, 2.1068697860734047, 0.07763238494830704, 0.22789023250312856, 1.1786594227115703, 0.21066528532970216, 0.48125415977877645, -1.040624997722185, 0.8016186231685677, -0.8313392017787085, -0.21478224517602593},
    {-1.3621481006811138, 0.06227951493960314, -2.1663697179688546, -0.374166767315057, 2.1312213799325193, -1.8061335679274875, -0.21352619225233926, 0.6386861464048222, -0.3211534169679379, 1.846719397755704, 1.9643284094737445, 1.7570655194176443, 0.14171390675011555, 1.5464928709280668, 1.0516017824592419, -0.19599807987319787, 0.9929627253696123, 1.3015810254188942, -0.5463776297765128, -0.29715221971373335, 1.1665407241186456, 0.8425850538080348, -1.0083588315556933, -0.7240020236459401, 0.4258599746186785, -0.7408123647409695, -0.7804010503190486, 1.0655256204431791, -1.414809024397029, -0.6456655212843689, -0.45767877394253087, 1.6339386974653045, 0.8738967262975144, 1.228777275483893, 0.7789638305884754, -0.13332675912725186, 0.263451875058548, -0.3492757752691024, -2.7113888365555403, -0.10099263811782344, 2.9604805828039633, 0.23768961205637834, -1.2804988393344898, -0.6520231737183961, -0.745869638690125, 1.4351711779099576, -1.4994286883921553, 0.654025444256811, 0.6269855552592708, -1.5705328166235477, -1.0949696121300567, -0.6472284885682724, -0.5065075121854269, 0.1972350729561389, -2.327677558044638, -0.862184067364018, 0.794281034799666, 1.1522271526336885, 0.8059568800253816, 1.839329237426663, 1.3571436671865018, 0.5852916029585394, -1.0833159740008922, -0.39562208487834344},
    {-0.09423464905974879, -0.15462816808960764, 1.916733564485159, 0.1329359236961584, 0.2636863053672363, -1.5192540755869333, -1.8247256669185494, -0.5902913940264951, 1.3815886714223524, 0.6027260130505423, 1.2540606445336655, -0.636091784077064, 0.31361013189181997, -0.004840668280444054, -1.2799266341378148, 0.12188422334102941, 0.909552000134972, 0.004893548075201452, -0.44928080247276225, 1.246267494729748, -1.5193542577507628, 0.5256564418771813, -0.5996465323747319, 0.847622174961831, 1.0636510452277754, 0.5884239910853201, 0.9390849321301241, 0.44323895189008755, -1.0372220846494395, -0.7797132404354926, 0.3866889845800469, 1.2914965229660673, -0.8088769980122505, 1.6927481741870678, 0.2423609053731, 0.38057392113945343, 0.5677550013126154, 1.2050137672408903, -0.8188453891764347, 0.45020435768343914, -0.5435946182087731, -0.7585134267859079, 0.7732067686230214, 0.3265897366284089, -0.5797988058124202, -0.6774750659323785, -0.8908476105042186, -1.5533037182035212, 1.234507473735513, 1.7579523961550645, 1.5630955858443065, 0.6828617889715878, 0.704095391026991, -0.6828870723665645, -0.23160627983526386, -0.7093071323606099, -1.8974529259107484, 0.49419769604046565, 0.03844584838304135, -0.7153420598209846, -2.2477905191061924, 1.5669838630999082, 2.2386593219010993, -0.5298645273351962},
    {0.03252539952947479, 3.1997573095063245, 1.2449842377867075, 1.144042118293787, 1.623662580600909, 1.8028159540971984, 0.15776998691737626, 1.1646951447731104, 0.9537584608752913, 1.6246627864067784, 0.16081144295701463, 0.7162037064011268, -1.7573904810059668, 1.8573308573817167, -2.4029946617013938, 1.2012956336738891, 2.052586034073602, 1.544778339114928, -0.03710015915789132, 0.6684901545891828, 0.4612652000881548, -0.6464433576643519, -0.5601927165363867, 0.8607574009770722, -1.5694696571330295, 0.8805057630678433, 0.42476767223192674, 1.2000579037037067, -0.7503014556144297, 0.5525022014113231, 2.1840689564297784, -1.009066959613227, 0.19863916579162993, 0.7510306855192387, 0.6801475246532948, 0.5625322597200167, 0.025378119093063367, -0.470081508626156, -0.47561719929915397, -0.5736942473715908, 1.6366155645124363, 0.04564207921296011, -1.414235891075132, -1.4447906577993743, 1.4503115117247798, -0.47760223723765866, -1.2709135115214247, -0.5186906593135973, 0.6825830993657656, 0.09320649163561696, -0.3502338847611457, -0.2380053414231489, 0.11003704134784995, -0.5511168394951506, -0.34569662484080843, -0.7832745261238955, -0.30110819721271714, -0.7819757808217875, -0.2979886677654603, -0.37664735421983464, -1.5721214421015781, 0.46813642302811914, 0.31538313857548017, 2.5307196303003137},
    {-0.4512384374726565, 2.052919742496823, 0.5401749120069917, 0.2806011596646707, -0.011194946254795753, -0.29726521444208187, -0.5605028473396402, -1.087880173531266, 0.7930279496496421, 0.0435367245593827, -2.000292443467373, -0.6240341688134626, 1.843905269032751, -0.18380510849680667, 2.4785145464529865, -1.0355816609915436, -0.264339540294795, -0.27909294666779566, -2.689060963477598, 0.3587311777597959, 4.027569508795557, -0.633148649609025, 0.6523263381595124, -1.0978136240679839, 0.7040912035200997, -1.064533313035938, -0.2469118998692045, 1.1532896461445377, -1.5672910604178845, -0.9945196159299895, 0.6467576817721538, -0.19715898391281111, 0.6430410306148003, 1.0080363647729054, 1.2879117752621227, -0.5411794256246909, 0.30422523719339156, 0.021928713379814845, 1.0305333607151306, 1.9108045892728767, 0.8688144174253934, 0.28912365765226916, -0.5889140225706627, -2.863652577032774, -0.20747302488290623, 0.845229518676322, 0.21948173033551502, 0.1421108524974143, 0.28585475913262753, 0.07665979633678228, 1.9254111597871366, -1.6612599990433754, -2.0038352277748688, 0.2310158781556887, 0.6669665556161127, -0.7229091089799222, 0.3893215125240361, -1.132482557827785, -0.20066783841760685, -1.4448854926492352, -0.9894811232274515, 1.5142594734127264, 2.0117233623979227, -0.942135622254963},
    {-0.8411004493639332, -0.3764823163482647, -0.27244333300812823, -0.5567507783516615, -1.3090165474345556, -0.985445307299673, -1.8538057054706767, -0.20794435258212682, -1.469902806539329, 1.4070060980733, -0.7373528378350902, 0.4713883759459951, -0.4391597763743805, -0.2685359808906939, 0.7659731705123375, -0.16229024556329222, -1.0270932535627437, -0.22379395204101793, -1.3661658711266795, -1.285721448535605, -0.48803564063682, 0.24905240086065328, -0.9878089810067653, -1.5141241281409334, -0.13238592854013023, 0.2442824331303359, 0.8088376016892808, 1.2043392404346285, -2.6517441427005344, -0.877481994695374, 0.5776613630291586, 0.0830778266551992, 1.145398107624319, 0.4651453697973338, -1.3145590646281564, 0.10640197210522434, -2.3184526846209725, -0.09510705725956861, -0.2199652077963037, -2.2664498631108114, 1.0352628216142628, -1.1368072981940105, 0.6524968911377672, 0.14483476366203268, 0.23481942764035482, 0.3720059340548513, 1.4979376675001594, 1.0187297512179392, -1.0289908902498148, 2.0810875255211583, -0.2880805218400911, 1.0993244797463224, 0.06933457732631865, 0.733738975173676, 0.6098031130506704, -1.0595071795447877, 0.22684805728104937, 1.5581280852380333, -0.4472523826769908, -1.5556476493750133, -1.5521635915342962, -1.3578996018584228, -0.9302596746859475, -1.369068115858801},
    {-0.9560812124581759, -0.47142919205099887, -0.4010959459619809, 0.5092897863868349, -2.005144742835284, 0.018478679121477156, 0.3294194925879927, 0.787216445794149, 0.32355201860865435, -0.691526757281223, 0.40544062392430047, -1.9662804010062644, -0.9329251210347819, 0.922209187711835, -1.5131212901000057, -1.448930805001992, 0.2492378892757927, -2.819048906263834, -1.6968606178038965, -0.6458511598433473, -1.953868977997229, -0.40087584225430334, 1.0223735690193652, 0.09700789655968388, -0.7331421712088106, -0.45362916417475546, -1.4854172638230456, -1.1405658117677528, -0.06040177366867964, -1.4460396397173125, -0.4264275699643048, 1.6848353243161491, 2.0346723952841197, 2.4225919399914577, 1.6230236533552067, 0.6439667574370209, 0.5693004365060255, 0.07860294342597318, 0.8302338854380984, 1.3782016015180927, 0.32736201307061363, 0.3469437624224715, -0.5947861177865243, -0.3581297291584848, 0.572420181275241, 0.10078058986769409, -0.7261571484152647, 0.5825573295185973, -1.9369733471533381, -0.5941059182992596, -0.9278181706280677, 1.6955400308851436, -0.8550017658591431, 0.04633305661664826, 1.0199269410910339, -0.9899795720289551, 0.09481618640412007, 0.6566796646256424, -0.981261457662564, -0.5691082641970784, 0.46251315025199397, 1.7433723389739404, 1.156445069392663, -0.6915734718067462},
    {-1.7358695346710094, -0.48839980399860217, -0.9770566121036443, -0.5220277286310631, -0.7396405910051588, -0.3824902916053699, 1.382055638292962, -1.4430749870854405, -2.586895154060733, 0.1916660009948827, 0.44156868845378844, 0.5213114545073968, -1.0714862753975105, -0.5115052592520811, -0.4757268620055705, -0.9700233773035364, 2.009199273761177, 1.10576236417374, -1.354792166396976, -1.7852200369458926, 1.4265417956710087, -0.5952549135762578, -1.0919295373254385, -1.1799805808147088, 0.5391307293228971, 0.26646337992380353, -0.699249086810318, 0.9602509257025893, 0.6062697408390277, -1.4407055702238025, 0.47524034281552197, 0.9697722002142886, 0.8029545141687187, -1.3435478032472217, -0.15213059700066145, -1.146532537416604, -0.32086707956589416, -0.6693814589838929, -0.26990968167702806, 1.5085623726393114, -0.7339149919061785, 1.703288527118308, 0.019570597717399087, -0.3629948907472984, -0.8926755631839668, -0.39481834399604576, -0.7200606064225316, 2.2471625518863445, 0.23167369281345884, 1.6890550044115167, -1.6513307106654171, 1.625932666638488, -0.015291290271666163, -0.6859006658743214, 0.5506956910467065, 0.7801440699956053, 0.7847039766316681, -2.9488692150046867, -0.5439811723220709, 1.7858604813626289, -0.6338283934515043, -0.41907062085428004, -1.2159183757879246, -1.0167999258848948},
    {0.6355048315636029, -1.660620383369787, 0.07105150557348898, -0.4225028161683543, 2.536966354161879, -1.1810129803574814, -1.4008988101252378, -1.800661778290519, 0.7304912425229485, 1.214516863633545, -0.47843086261398, 1.6210099409435583, 0.5054181073298839, 0.8617817093267309, 3.0204470928548375, -1.4121841522640273, 0.09417898108901686, 0.006693771725104632, -0.2489770234779311, -0.35148633742467483, 1.3934451586297438, -0.4110201617066515, 0.8656826503173252, 0.4093754916217184, -2.101909563695471, -1.069344020849259, 1.7410120317521387, -1.9241094529478606, 1.4403977139796742, -0.41118517255833653, -0.3527605163603168, 0.7514706320619703, 2.5280547017094888, -1.5727535829671369, -0.5367286278762999, 0.3194056340400193, 1.3361150856071922, 0.27339978043962315, 0.5680264314545449, -1.1471882258502037, -0.4273550074102939, -0.5415280598580275, 1.2225094400644774, 0.6485225248850649, -0.31625945986185705, -1.689779889705433, -2.489314296560325, 0.5373510713640145, 0.6512278643204175, -0.8236137877254552, -1.1122045452295881, -0.3742447954394286, 1.1193931786904987, -1.1842392278572977, -0.7050873226882508, 0.657450533418619, -0.3493079929435857, 0.2220168927368521, 0.14542494097566455, 0.6758550744283737, 1.4448296553579236, -0.1235475670340645, -0.1755187454376236, 0.6625244070971584},
    {-0.9819465260315288, 0.6776626695722788, 2.252950311471682, 1.0564870269181519, 1.3227361738492778, -0.3063819328494543, -1.2532946973305767, -0.9012089031633829, 2.434876970232315, 0.2860311244029225, -1.2825955413745136, -1.027794201682133, 0.8698832573829266, -0.8196708205900304, 2.5245051331293613, -1.959777879934187, 0.6015181392818697, -0.5817846190002293, -1.6307340259979937, 0.0034690845636316868, -0.47625275955571383, 0.3342427808430427, -1.6340769628562872, -1.6219936501092573, 0.1530017539465765, -0.47181020141104746, 0.2223629608859793, 0.15122301039411945, 1.4581789163021885, -1.0256183444058435, 1.1450065339809221, -1.6740274564968727, -1.113867259695551, 0.2153588235641188, -0.6971302946216242, -0.4549981304067809, 0.4214237363188876, 0.9590957089733405, 0.4124183559386962, -0.5069144125784738, 0.28312043740981785, -1.145979283724107, -1.0777946325083425, 0.6059482313663971, -1.3454228814887046, -1.4611131711981555, -0.8007196814048361, -0.6574817413084793, -1.367365880814012, 0.4856882328018931, -1.3924969040963198, -1.2759443092675995, -1.2984095845353318, 0.2983919727243953, 1.2290352158008901, 2.1846763891538616, -1.038567708556948, 1.2773952119194891, 0.5193085725417219, -0.6880740546070926, 1.4776927915650218, 0.023509373190734605, -2.340785772069375, -2.4902836806647723},
    {-2.961056577661212, -0.4573414693339246, 0.592237415758512, -2.0575606949295415, -1.0988535750851618, -0.6993519476529682, 0.29582954956629676, -0.5535693802061605, -0.22289572342199385, -1.1989311254801063, -0.30191960906187076, -0.9098549154360664, 1.038921863958842, 0.638679123800536, 0.2840906560002481, 0.8264643116578734, 1.8135943382791326, 0.8874870698907793, -0.00710419341004837, 1.4759176013544077, 0.8226545847305508, -0.6757210595768461, -1.6171810227436323, 0.5287674949997845, -0.14492349076201097, -0.5638697572991928, 2.417723727251326, -1.2577068697888079, -1.467488608373191, -0.6804746691370236, 0.5193910068368597, 0.27283313191740605, -1.8407944058262824, 0.7203468808278575, 0.10252489553204913, -0.1918466600296455, -0.6119604360063978, -0.2438955248397427, 0.3847856994381561, 0.7804311228786404, -1.02119558811694, -1.1145076624801726, 0.07612284611385632, 0.7263008381122802, -0.1878070136019837, -0.5055349401985213, -1.8395709967598246, 1.789568119676293, -0.2913698182691125, -0.3944019843900032, -1.1263598726548845, 0.27647429796164974, -0.7723663323958937, -0.25951341214186496, 1.68982405283985, 0.5171953561906727, 0.3108548105289552, 1.2686917035197964, 0.02220794682388894, -1.7661859547091583, -0.19155026034024178, 1.0099862991551234, 0.5375557958360114, -1.0813674130003423},
    {1.953088007189544, -0.1608132844086338, -0.7724872712263946, -0.44173486253937533, 2.578535142355877, 0.881927664801506, -1.3532813400480794, -0.46219363868806607, 0.6259514433951837, -0.3217227874123311, -0.40010815871289235, -0.2964883240272092, 0.1285849874435222, 0.11913900990619354, 0.6529127490498089, -1.6873263194945538, -2.7222343624733534, 1.4829142824954171, 2.3872787514263574, -0.9970886711038988, 0.07061292086363591, 0.8290618371933821, 0.5718454189756359, -0.2348153532916351, 0.05940282113873088, 2.5808824549339953, 1.2181726297452224, 2.3513694526484183, 0.968404265664823, 1.1087770758025206, 0.18390786991424504, 0.22795220702963567, 2.2915469216462885, -1.21933179889586, 0.5249297051430004, 0.5928538573686024, 0.8892049955090099, -0.8160205823625212, -0.14045022463123358, -1.721557389085965, 0.15689417277703605, 0.5463419168492892, -1.960493107592631, -0.09729437949471172, -1.05308621928299, -1.5603002689443624, 0.22322097475319966, -1.1524531109656992, -0.5599491971122793, 1.2608883054195428, 0.502659323670748, -1.415899127403563, 2.258128449751982, 0.2875997883084161, 1.121608640656182, -1.4065624242560655, -0.5286171943752886, 0.3165371383711008, -2.703488383663527, -0.6269040989174205, -0.07495139557478805, -2.9544709765213737, -0.49125115042160816, -0.8773370591784612},
    {0.8782309868869863, 0.15361078977579418, 0.48744418089830466, -0.12346473140807517, -0.6224845620597409, -0.6923269316033719, 0.03059000565404307, -0.4787131294456777, 1.0079767491511042, 0.18002208522144864, 0.7486236054399995, -0.14696874623235828, 1.673788031673376, 0.65145982518113, 1.632529452924952, -0.043026013557025095, 0.3169060769833452, -0.33027841137483865, -0.019616524313958165, -0.8259270024136012, -1.2913859770847407, 1.1398663414480688, 1.0505685671328584, 1.3297800475712773, 0.22975696322277883, 2.865055346103314, 0.2999416988411581, 0.14637773260265358, -0.9841484951499997, 2.334864459518207, 2.1483384722248204, 1.068225146849854, -0.4873584320656061, 0.3322160568297227, 0.20204696932025912, -0.18925325700516546, 0.4688307538362237, -0.1562732000407981, -0.0877111078657724, -0.2190743745211937, 1.7621217862780425, 0.1864646452655894, 1.1004716590148251, -0.9488177395469668, 0.45670746753239955, -1.181131080152398, -0.46534903971883257, 0.5327782891504387, 1.3845776772370035, -0.5795380924331254, -0.9404836539608877, 0.5590294058488364, -0.27567163763139324, 1.58768591076469, -0.00011875989176658961, -0.7574614465542157, 0.08144948757600647, -0.12741239416295208, 0.18382844078730437, 1.8022314726982631, -0.13027451470736656, -0.27543253345836927, 0.40729207993878463, -2.0699870840458403},
    {-0.739933191080724, 0.7982914799959112, 0.39530477112003565, -0.7751152845590227, 1.0285578620534561, 0.24279710311269184, -0.5997159133114544, -0.23125908352357244, 1.7208162548589954, -0.4038950781822463, 1.4825098128975975, 0.39511305969542837, 0.29045913976764237, -1.246175079866635, -2.4855851426902715, -0.4811621529159489, 1.7064094090259356, 0.43831204074435387, -0.13960308087493795, -0.1393222439730394, 0.7978243459739096, 0.6286535164205124, -0.5405983180498496, 1.8305927275090563, -0.8127394654202288, 2.982056147629587, 0.652504055099729, 0.2463302969179585, -0.4978977691197704, 0.26842292462727096, -0.27069284105672514, -0.8334941979457022, -2.827044306953429, -0.2734346615790348, 0.38215815053196994, 0.11071287379995452, -2.331802247399689, -0.4563353402213803, -1.001033682476814, 2.9933178266107916, 0.6740904026447223, 0.9477692638165779, -0.5470932394897489, 0.28413117934662546, 0.017948703566428453, 1.9314475366245727, -1.5896870797037677, -1.1768775760683694, -1.2636403165845773, 1.1364573031122225, -0.34738679268592604, 0.5573304853334035, -1.2514861524643295, 2.1390736914091817, 1.1860898075542177, 0.15911430539820076, 1.1565044032790808, 1.0382689504387295, 0.5499498758834223, 0.42264853146584747, -0.7661735807694904, 0.18360634418500818, -0.5449348658304569, -0.8266250472977468},
    {-0.4552100939355684, 0.06364306724959828, 0.6486430618889899, 2.4701687244718036, 0.07951406890269803, -1.8725476435588804, -2.925678563728503, 0.3863550517976086, -0.40312696616061217, 0.1353567943356974, -0.2181870766525746, -0.4312996032012738, -1.217348520109447, -1.6772147251477925, 0.4655837399792303, 0.24478832194232172, 0.8051128675121242, 0.22427667453915837, 0.3896322359296463, -1.2206143233349318, 2.9635943710017147, 0.3184330373939674, -1.9765859457587618, -0.011357592348783087, -2.099619053709822, 0.8776663139728873, 2.0172769137684257, 0.20101085056358614, -3.1002973595257606, -1.9086952153356973, 0.4803717279117005, -1.3522358054118593, -0.08844836065096155, 0.45442091259528133, 0.8602661961297813, -0.9968431254438181, 0.4905786715856915, 1.5354495953989442, 0.4217186356903161, -0.42875158281828324, -1.2296752303274185, 0.3037101090228736, 1.0046311891095052, 2.0821103740281415, -1.8841138051551056, -0.1008471071278575, -1.8148830392921245, -0.7206375617579316, -0.5320327229548611, 0.26077926103655746, 1.0402603200315563, 0.582839115829311, 0.6239651151731145, 0.5856207756213865, 0.28313060421816894, 1.3740328084471514, 0.042641897583891315, 1.0187365442443983, -1.8001880063632916, -1.1389317417163902, 0.48286642772632304, -1.8185203140954815, -0.064254253483218, -1.0014683255179166},
    {0.8463449066892546, -2.3432095804010697, 1.620611632361996, -1.590054773611187, 1.5666361106938302, -0.07320499659278727, 1.7036208603566683, 0.8092458980382707, 2.2821567102106015, 0.9555163518664795, 1.3933138296237189, -2.844722783427256, -0.5760669864309413, -1.6612768661034951, 1.6542989957235832, -0.3108919263735691, 1.816245519411631, 0.3268637733084021, -2.1515459781842012, 1.523921762152406, 0.38987362431367567, 1.1498849146258372, 0.9585349692557875, 0.5460019672373081, -0.30708655658551953, 1.7580974189755363, 2.17368221882007, 0.7744179437731805, 0.5324164850295051, 0.33983687756180575, -1.9061998265105071, -0.13122538041624568, 1.1878849209391948, 0.1617252018333901, -0.5447415864660942, 0.8870559311584194, 0.3009903703264865, 0.8550362301137068, 0.510006622171152, 0.3068499873680009, 0.012165952269110086, -1.6426947745460057, -0.7325422259811832, 1.5818335428987802, -1.2218396004713283, -0.32214778320960863, -1.589237140852665, 0.43055880004874264, -0.6001803536811362, -1.488627578572284, -1.435122815459527, 0.779441872155976, -0.034845404938692794, 0.784584521128107, 2.922746316043164, -1.726455899907993, -1.5733012532230486, 0.9096312345776748, 0.06375376367832206, -0.13485374505301212, -0.12128805733716687, 1.5739351853713488, -0.5458895674510663, 2.4061400173038163},
    {1.1362068529455094, 1.0497008485841446, 0.9973088393438647, -3.030082879088392, -0.14716910669942326, -1.4525629359900425, 0.6411392960976178, 0.6333260739119778, 1.0732413521443795, 1.1543112639077615, -1.499641025294355, -0.924683076204179, -1.2769157121379004, -1.0836165406371168, -1.027821242045829, 0.9949368784149933, 0.09319580428057135, -1.903891787345019, -0.1102290420627005, -1.4503633154064621, 1.9903562495880212, 0.09603828904421369, 0.322207793015918, -1.2394350930616325, -1.5212730707382245, 0.06643357824871568, 1.4338964761381454, 0.2786334950059463, -0.7287106136425877, 0.5979752485045071, 0.14223698107317187, 0.23304073889143337, 0.2734370084722799, 0.5668575862501211, 0.7798931815529241, -0.6945042713834406, 1.6853588181691843, -1.2707122963571018, 0.13948397842880503, -1.2150888972468985, -0.6581675778326099, 1.4098904015365474, 1.477670164212002, 0.5721017158709957, 1.4885647365556025, -0.5432357388631486, -0.6220848734818895, 0.30494912544151825, -0.37990053814675967, -1.8088563855313153, 0.5073185445484725, -0.9498875376485513, 0.9350094323010929, 2.273341510466809, 0.5722918279952875, -2.1209545149987754, 0.19398025214450226, -1.7892869974505736, -0.4945171684035967, -1.1145174808698257, -1.0499028228813783, -1.3248865559548029, 0.9992067134334215, -0.19937637335357603},
    {-0.020942566580901066, 0.5088520337809125, 1.3390424824188327, -0.25935156906238027, -1.9016417654073434, -0.007016875041971654, 2.9810285210192244, 0.7666761031025175, 2.5358859266726625, -1.4860810172881345, 0.006621510940815898, 0.9092743914905822, 1.268062646567263, 0.4554541937017161, -1.1356957081067964, -0.2041139261573719, -0.30612368184782407, -1.5881328541308675, -0.674970360401747, -0.3065363477493641, 0.5360365491547728, 1.4950137146344866, 1.7076950161084588, 1.214617042865096, 0.7984512729284415, 0.9294463986864063, -0.7757490315865774, -0.6570235029203085, 0.8140835708077431, 0.11073610250311655, -0.5918722045201613, 0.9237775506434865, 0.7959272141259975, -0.5623378459968146, 0.20563043467655362, 0.8271079846957471, 0.8335280419986714, 1.6073080558474233, -1.4371268714193786, -0.9576450291125714, 0.5682050251227041, -1.1293652496507882, 0.7624825424880436, 1.6907669678685044, -1.1546506200387188, -2.6749910107103605, -0.04879509901369622, 1.248389470592389, -0.019711263981057835, 0.2811045538896111, 0.82990131471193, 2.734010005902108, -0.437543852030414, -1.2916508819335997, 0.13639515582922876, 0.2966679975432383, -0.6224530708152864, -0.14675457629840252, 0.9263924761718423, 1.0580079210687834, 0.7441315809971955, 0.8577202871456835, -0.19947491630586306, 0.9216381071590553},
    {0.16149563557950047, 0.12533504354695874, 0.37419795601493977, -0.7835889266967895, -1.3430539100257533, 1.3424329797995098, -0.019908931856805156, -2.250277565713042, -0.25665617942235, 0.6692979775733262, 1.0654143702702739, 0.9420150378915763, 1.2576803449913652, 0.8564881057825534, 0.5362174108778329, -1.3057170920549106, 0.28261949358260163, 1.7629108323994216, -2.31128649762868, -0.10954834311718396, 0.06656289740552818, -1.1323848147475803, 2.2397950955209307, -0.5174883831465975, 0.5220371954507652, 0.3070639377579059, 2.1734018277806695, 0.64771954322533, -1.225857747339739, 0.8422849918755125, 1.205795340903936, -1.5604020295674883, -0.1827478311772556, 1.7540932246932925, 0.16030539130933322, 0.6408612208581019, -0.817346643723423, 0.6011673094873452, -1.655950348179852, 0.8026976274569668, 0.9921518698269601, 1.0510928103344737, 1.296827981597562, 1.3385569753888866, -1.0715860843101261, -0.16115418018572564, -0.5249044701235582, 1.1367009969176327, 2.0468651508217275, 0.47487170289009817, -0.8216700745370858, -1.0111705976659338, 0.28214948730279404, 1.0597617417123069, -1.0992846228011754, -0.24272409370376785, 0.6506338708586227, -1.0513497267746903, 0.14232596725770275, 0.5720391320524345, -0.21219909288645986, 0.2727817881703797, 0.7849240207955048, -1.7126435581603165},
    {2.0308401157773806, -0.056064400389247704, -2.888813599864999, -0.08613958137863101, 0.21366082841425899, 1.2819437727718441, 0.24191528361418177, 0.876603420204945, 0.36264971032512705, 1.5206515706604347, 0.2269728657767416, -2.1654397920579203, 0.7642885423725683, -0.37595184020369854, 0.1066701663837157, 0.474633183029417, -2.3932940623365098, -0.618822762817435, -1.5147322244745562, 1.004639660858541, 0.00557938955831853, 0.30280262614494025, 0.7797429251752638, -0.14371207048778786, 0.05232261555875596, -0.35660446014796454, -0.7811195080738634, -0.93315310951928, -0.786232306130314, -0.03774312043897871, 1.4740884454683225, 0.7767144848815075, -2.863682447401927, -1.745201433445179, 3.2605808428189453, -2.0776595108733686, 0.45035485066610625, -0.8703428207762112, -0.04845898263271608, 3.0774146239821936, -2.093659642134145, -0.10490860389352656, -0.8265950042017292, 1.4775161965636612, 0.5152430723951931, -0.35612921153466065, 1.889739353523665, 2.624686109634421, 0.7110490053266774, -0.19113563365048647, 1.1297412235031115, 0.9936267778439648, -0.1280522603137717, -0.8426507309199478, 1.6776167750437876, -3.5361196527804553, 0.30112288808201154, 1.238927296590098, -1.4111651404015229, -1.033493067910392, 1.0018034591952036, 0.5880451432005888, -1.6042415657087532, 0.824436553556133},
    {1.3312245129653297, 0.39329442353206645, -0.25588345179451694, -1.131463531788778, -0.10216509180413615, 1.5636107921525344, 0.11150696946016718, -1.569827640290085, -0.027649699050154165, -0.7043009390015174, 2.3295020804870203, 0.7231607524269381, 0.6418136339783399, -0.8682521799430905, 2.2323194913632043, -0.7851586127692982, 0.06256465608661022, -2.7956978874272287, -0.7332327174293003, 2.9547012157838055, 0.13030179609239234, 2.5101227937316644, -2.1385217310809495, 0.08313745207988166, -0.17223310624957125, 1.9135556704156693, 0.6019032981203503, -0.3643066238099437, 0.568062402393101, 1.3240212860557454, -0.6549939214751374, 0.7110766178192587, -0.15038069475536794, 0.4153723525040086, 0.4211206900142001, 1.4009835352849669, 1.080928106466183, 0.06462207611003483, -0.9251459596485254, 0.6493921039837812, 0.024029612606254816, 0.22149170846031885, 0.816428835763702, 0.17578690535653282, 0.19881894965720007, 0.7901443784258599, 1.060494178242798, -2.8997113442217386, 0.2947433894697327, 0.500940600132312, -0.9624595423928153, -0.8387500307128498, -0.6843298171839162, 0.3939826083322952, 1.0606753725374836, -1.9975642311844772, 0.43538745221056085, -1.5308313931222828, -0.5053814973395536, -1.4531983608402868, 1.1479636438353285, -2.677263601375128, 0.6571315754179996, -1.6488339162093928},
    {-1.95650823077196, -1.608348605018299, 1.3123254576735788, 2.0864067743842014, 0.37369736604274445, 0.9465842024614648, 0.07148258165485546, 0.6287139682349682, -0.9557777387921347, 3.0348281421949417, 0.33759070058934965, -1.6171061144177634, -0.25737577369010406, -0.5238251767243827, -0.1817557726928708, -1.7788973710117821, 0.13140480035438984, 1.0525066632925324, -0.4842242114139656, -1.2006467251881063, 1.9277046783208391, -0.6793186396361827, -0.42329873302371906, -0.4438960431343099, 0.4583168061545884, 2.582756522207617, 1.50694188824355, -0.47889408557302793, 0.16423071718847068, 2.015475015422167, 0.43695553567629863, -1.8659526202018106, 1.460497864269639, -0.7229988337742694, -2.4528280988065196, -1.4231972932251675, -1.383560067309446, 0.38930713707732506, 0.9177115282438784, -1.2706850906109932, -2.81370713297538, 1.255113628763672, -0.4302190872679113, 0.2527798020675609, -0.11104431135014436, 0.018956588549342016, 0.6481286435539783, -1.410961701016248, -0.6787244950443934, 0.33273806046573107, 0.13265173282012022, -1.4389570608586664, -0.9188532205165515, -1.8158041723099634, 1.85619027531787, 0.39861887856351413, 1.661363615545698, -1.3387229436267232, 0.09065705192580255, -0.027163614943904537, 1.2247590708905927, 0.10271441064481539, 1.8488490875932164, 0.31555626831896494}
};

static const float b1[64] = {1.7283170613263719, 1.817214223688156, 1.2375515288085674, 0.47567770774201124, 2.472960779840052, 0.42262343389411666, 2.186906471221011, 2.0562231990014777, 2.060038787144445, 1.7065915946301378, 2.074780577986211, 1.324149813515077, 1.399527217996697, 1.7664764158711785, 2.3727926445579803, 2.2302821453758583, 2.0323946500914207, 2.141177139270408, 2.2031409702616838, 2.181110102242904, 2.2488984707752935, 0.6746562227694585, 1.6822392134059276, 2.1737591781029946, 1.7073950362606298, 2.2058856928434314, 2.0999480125001386, 1.3877911597784023, 1.8434279180792799, 2.058447376567673, 1.2392318873872958, 2.0441217124346935, 0.9517103561486211, 2.047807282544156, 2.1957787307299585, 1.7414965768426567, 1.8422666408726127, 1.81654570438877, 1.5036287237083072, 2.0767332295771466, 2.285750189317108, 2.0799422854672116, 2.028225508127534, 2.013662085843377, 2.192082875135575, 1.7154477258238485, 1.8391203530076656, 2.0187809806467167, 1.8189508662753877, 1.4171778990846138, 1.6438609780357636, 2.032455003633293, 2.085223191692189, 1.5714684752604107, 2.1640768104752808, 2.1089445912405997, 1.4607769338641279, 1.9465887260204657, 1.569930552465466, 0.7309523991841929, 0.7384869643654046, 2.2373577731143985, 1.9792560945955608, 1.9177410169397884};

static const float w2[64][32] = {
    {-1.8574459436155761, 0.5979698984402027, 1.9228943397076486, 0.5247940540598766, 1.3665422988715317, 1.3444869153356869, 1.8540732404334466, -0.6375566277541727, -2.378942350832696, 0.956667988732774, 0.7984975267251667, -2.1162207886742226, 1.9110803045812106, 1.8770463056810456, -0.3160810557632442, 1.864272194233136, 1.2762690705765536, 1.9786006252718047, 0.9535426367530557, 1.7796976551016472, -0.16003016507994755, 1.090080131788319, -1.4873524258316682, -1.9404143591363852, -0.43197210040130635, 2.4445832604540283, 2.7293819346880897, 0.6821768194978198, 0.2994907340964937, 1.4372096891536275, -0.6222974556218503, 0.6814294578495699},
    {1.0514822018600039, 1.3845197323803327, 2.2108279997660727, -0.2754358076617705, 2.6725864944357958, 2.5045850300414925, 0.3748396338652952, 0.8407497294316966, -1.6247868106195178, 1.1965182929885039, 1.1211109430596122, 1.286416650194283, 2.37990048315188, 1.8203672334759686, -1.1122569034660144, 0.6402618134202539, 0.8311879031771824, 2.1073176828359275, 1.46071548833322, 2.0764576010266205, -0.009396908072166548, 0.9483679611260658, 1.7729320123416308, -0.5789328352132934, -3.093217271820223e-05, 2.8483208245124723, 1.7017014780785147, 1.1721837905786414, 1.3212966122955432, 2.2789904156466196, 0.7533221243684243, 0.817910846562666},
    {-0.6494164350249979, 0.0041472848588505855, -0.15730866586564315, 1.412416958013491, 2.6793810627967254, 2.3755879920057685, 2.6190149457039995, -0.38879898490512327, -0.30783532582362644, 0.24928883347832642, 2.5514979089151484, 0.5263055274772485, 0.5205981100215609, 0.7656700089420886, -1.122804093007459, 0.8325594130300726, -1.1301593612874523, 2.0662281258033786, 0.6325323639064059, 1.7904639410345193, 0.4705960554410615, 2.228841413351571, 0.1297902289787494, 0.47237260849976487, 0.4248498598343982, 0.5193494009052704, 0.644670170304232, 0.7289620274492623, 1.874363545237948, 0.9413949647660327, 0.2483329147220707, -0.13561833372618187},
    {-0.12159047378156111, -0.5981781516996517, 0.8407890312901034, -2.381110075866513, 1.396074744267921, 0.9679683256122252, 0.9252090976818007, 0.21665135819997802, 0.7289178058675824, 0.3494229862821539, 0.5913646657865087, -0.6260883054530274, 0.32395481765384826, 1.6234030412152032, 0.40353199643089394, 0.5382843692150759, -0.5903940747866244, 0.37781835533018293, 1.11515498863452, 1.0403883934454874, -1.7526647757872544, 0.1660846684872624, -0.9064435614645276, 0.7395373098359743, 0.421544292142899, 0.5984610608321814, 0.47665561592511524, 1.6131313581150004, -0.16675656682539136, 1.1467142948500073, 1.353394358626882, 0.20981055472556742},
    {-1.55653674756147, 2.227249679301814, 1.827825373696508, -0.13378841383249795, 0.25864918461935754, 2.7147831523125565, 0.23780174731346465, 0.6512152625546986, 1.590576740936976, 2.2657378652852174, 2.4366287865983756, -0.626919359489552, 2.0994921456926567, 2.608487962171757, -0.2119122020237225, 0.0923093518705642, -1.8582192127827626, 1.1210885651701945, 1.0885142655763842, 0.6542901666815636, -2.0661019133789273, 1.7387939443776026, -0.9134981200459512, -0.4703396807064941, 0.21848941499793553, 2.7978244997911905, 2.474067920865511, 2.53114275420478, 1.8139522935873056, 1.1658117268608803, 1.1688139665461688, 1.0144249182033218},
    {-1.400546110297992, 1.196295521350207, 1.6153772223231444, 0.9959295556763446, 0.8535569753846652, -0.10091161100600629, -0.3705389931136466, -0.2232903190713353, -1.515477303865315, 0.33472649247662883, -0.7069422213197339, -1.1469778916957303, 2.487815593680819, -0.4428023692767125, -1.8257985503778538, 1.7174312819608377, -1.7590362443877765, 2.096161189202245, 0.12598861243568257, 1.6371593057740488, -1.2973934655786685, 0.14816482493571045, 0.15898893583101942, 0.29961309611346604, 1.4767088731113858, 1.8549640906796876, 0.9273686451180847, 1.8749597215091272, 0.9357432304184898, 0.7519367278654358, 1.4021383308456892, 0.2572962298230555},
    {0.9451666873400743, 2.406183729208058, 2.3017675145219343, 0.9217030468073866, 2.0342628322287646, 2.552736079446914, 2.771800188493882, -1.4723858867734807, 0.6248220258781775, 0.9473014784294456, 1.8942649181695743, 0.8792136951699068, 3.9777446443693276, 0.7624123480202883, -0.7918795630667729, 1.0679880175757896, 0.22304518587431968, 0.29769330077789175, -0.8554424469377722, 1.2430422228364817, 0.6464171626541584, 0.8758254224808565, -0.9815526291766424, 0.2871175057188792, 0.853045107569782, 0.8126053821470632, 1.0691665597134095, 2.0651228113879636, -1.0646684542622047, 2.1536437963144044, 1.2354053820074593, 0.6948268691705888},
    {-1.2107812050901745, 1.043357062399456, 2.0414247843339237, -0.5898902883878683, 3.689380306702106, 2.880595627247971, 2.0886929157456366, -1.0565628035640755, -0.523311528372726, 3.9623427851252906, 0.3748993931294737, -1.2036148360261267, 2.136351864023066, 2.792489687767882, -0.8720599619497902, 0.056640598829963466, -0.5347251878970264, 0.4966189058990545, 0.10151614457598859, 0.5703273295753303, 0.4092003547204921, 1.4171809970899951, -0.3991763194420448, 0.07169224414102761, 2.7124397523653645, 2.5803240368437566, 2.5202116993318113, 3.2661447648159743, -0.6138332727133159, 1.4409014686296457, -0.45804343277995824, -0.03472175697780844},
    {0.07881997310411705, 1.9198322680550433, 1.0764327819497208, 0.4991922519435961, -0.17826973241417962, 2.780437929574411, 0.8441670081569442, 0.022674092449801043, -0.3627930812384832, 1.800511131723192, 2.470064293923724, -0.18993122128106274, 0.397378111586755, 1.4839058856549394, 1.5255665555952622, -0.07623653356934565, 0.8296572025146596, 0.9634046872325733, 1.9447341879921993, -0.40836372423733314, -0.6559291397013356, 0.753062973953673, -1.3214892296388616, 0.20877120146786374, 1.6567104951292393, 2.557565860135363, 2.464874793767321, 1.6732679348610162, 1.7801380764264776, 1.7876222815560336, 2.8247404403715164, 0.7194192759413262},
    {-0.583443689272591, 2.9617143277534828, -0.5939266818788688, 1.2292513598850818, 0.0933758407738608, 1.3553176621378054, 0.5870986284956718, -0.33977634968866216, 1.1026696852738782, 1.4954854794829933, 2.5180252803514938, -1.2532575348901343, 0.9254293798746709, 1.7855234146516945, 1.4114633589180667, 1.9791901587144096, -1.031316543830783, 1.568467578596199, 0.6714015031683399, -0.29421227302373154, -0.8904336876712581, -0.06260569120349462, -0.1678920886317554, 1.0878975805970506, -0.46929371736451825, 1.4000189664017682, 0.3131333220439303, 1.358381880005579, 1.658970922012961, 1.2491939734083999, 1.5585418802004936, -0.7499703515301097},
    {0.7191872669487079, 3.7555813623157297, -0.08165593451335011, 0.6088277528355088, 2.3000516107243443, 1.3809414159130584, 0.9998133398869277, 0.450883359204181, 0.785615152931672, 2.137291101942164, 1.865114288362113, -0.42358578884747333, 2.078576835417318, 1.842684898668515, -0.2908685056439491, 1.5958782153263946, -0.40485073233253405, 1.3189353164952626, 0.12483444739504301, 1.7191891520828, -0.48871206617153845, 2.0691544045620534, -1.3949916221499479, -2.3364630510176, -0.1235007181448109, -0.05064336296777406, 1.433862140239351, 1.744597471545812, 0.3534839355862614, 1.1469992996729408, 1.8077035784085798, 0.2842117162132375},
    {1.467170669136446, 1.5655719230038814, -0.020028219416561202, 0.8463815054552001, 2.3843622187431333, 0.39308620380954706, 2.142247129277435, 0.11314127400776805, 0.6365861360331636, 1.917410179584863, 1.6101499992311445, 0.5168533232056226, 0.0987618206266873, 1.1402822712096525, -0.4829800850092266, 1.5709033613512784, 1.0104845424613362, -0.34587814287682, 1.2327158057683152, 1.8955968930992346, -0.6263242990842067, 0.4073576360645217, -1.5731397432993584, -0.317893338807436, 1.4698188030916262, 1.8486842247507302, 0.46538891291542717, 1.079824914676774, 3.151935348183426, 1.4412833138362653, 1.2712257656482184, -1.4729412312104444},
    {-0.9086137088750785, 1.9349424496316263, 1.3517420557119342, 0.7934888699379511, 1.6114623483712611, 2.7618312374440244, 1.71923465177728, -1.3228502250294167, -0.5449865144428067, 2.2160045467229423, 1.1631441851792703, -0.865489347913467, 1.2874909060550588, 2.651312645339074, 0.8110684709249032, 1.8663347173303992, -2.209098990392774, -0.1025259508097779, 0.5717952469768317, 0.3479233872811038, -0.4102030330353799, 0.5004339297063246, -1.212370424404619, 1.9418674248713237, 1.8686537012590163, 1.0851207847060522, -0.1825697806845526, 0.27837470152233296, 0.4983683499913568, -0.45221699934795984, 2.2725431477765956, -0.15118643080045965},
    {0.08004009099019913, 1.6027413548529503, 0.6932214718363985, -0.3575644281299715, 0.43384517918678484, 2.842392069897709, 0.44535040753309946, 0.7449718263048282, 0.0410307137885781, 0.9476912626142994, 1.5664401081771187, -1.0361515278494604, 2.014593141686974, -0.5913573403953958, -0.4995519596921274, 0.32433105914554816, 0.8403799276544038, 0.9997536099380573, -0.7785756551129609, 1.0274313808815694, -0.8616014885904627, 1.344513570788362, 0.22853222268047294, 1.0913729912347723, 1.5079927388197643, 0.6924291824081065, 0.16806793270458406, 1.1899082180941654, 2.197133773974845, 2.441455048542662, -1.8721914764002496, -0.7075363708125401},
    {0.35038941281311625, 2.405703072660934, -0.7437722682410544, -0.45927135662736535, 0.5201080718981953, 1.975895651277302, 2.0563618599198166, 0.25322657892462297, -1.1203289378862973, 2.646819043603496, 1.7655274828464567, -0.30982024095062144, 1.251179794128567, 2.598449493117886, 0.03687925529180967, 2.563737426889992, 1.4722642741349552, 0.8083800877623193, 1.5059986416234425, 0.21093330370229224, -1.1605944023404522, 0.9421129287153455, -0.4410614280165637, -2.070074918219369, 2.4351261875324277, 2.6314652174495667, 2.6408955564733643, 2.7248327822992056, 0.5742574563731263, 0.8629201011809348, 1.1096367504409725, 0.1960038816403569},
    {-1.1548329245664393, 1.6009369612216258, -0.2899478112554307, -0.050181332195915945, 0.1942750688381022, 4.161514998544678, 1.6787092112718107, -0.13335662104303034, -0.3592599725725703, 1.128795218409658, 1.1513862494098943, 1.5911651494510994, 1.0136512109483715, 2.9607488502272523, 0.6486894980861041, 3.0861344073191845, -1.2434090260457915, 1.736072954868606, 0.7260132360242658, 1.1389372337301509, 0.18768813432072493, 1.8802224604879885, -0.4803971353049667, -0.0071171439732842815, 0.6333797088172199, 2.1045961787987326, 1.146594197944325, 2.211211927404261, 0.2704391738942971, 2.0364995621365236, 3.5653176275453617, 1.7625114848377534},
    {-1.0248579536461977, 1.8983124511854006, 0.7409882948289278, 1.0325632593394998, 1.1940114644290902, 2.4145581250741373, 2.2421707466443177, 0.7173673184426035, -0.8891150528407452, 0.9562995841712768, 2.0449360067760054, -2.566425521647532, 1.8208041967693287, 1.864294242252032, 0.41769241846754823, 0.6183546052520131, 0.6037405398685666, -0.17409724949307245, 2.63776462625612, -0.587661097050247, -1.5464932158431208, 3.1479558349394545, 0.5431430431525139, -0.9472852858155131, 1.3430923029790438, 2.9610099475339924, 1.5448186202184007, 2.3584291492456715, -0.5478974143487718, 1.5273430332754447, -0.19959962161619937, 0.03682726469851587},
    {0.6794520059348949, 4.084259945292371, 0.8465637734452344, -0.5343093531848532, 0.48350989943874967, 0.5071841310723977, 3.312665366764052, -0.004302170841244538, 0.9303043402052795, 2.6953137598168304, 1.6290707890910106, -0.6926813406122421, 0.639677995574303, 2.71043471915237, -0.3030078403461954, 2.0971797823040688, 1.0965455880066737, -0.11283548001104593, 2.814242016733843, 1.1465701855587702, 0.9805016533293572, 2.2752384088346083, -0.2836222548780042, 0.25488887214521977, 0.21538551068334966, 2.0585790533338257, 1.4327423468417428, 2.2383602653112735, -0.33818840269207384, 3.5868770822000036, 1.4673095506026899, -0.9849277940350168},
    {-1.0261204564106132, 2.299905434310191, 1.8193997412282275, -1.33384174822584, 1.8843221693542083, 2.332022450632973, -0.21305398660388214, -0.21456545274276884, 0.8210517234226461, 2.482025637483555, 2.231530704296245, -0.07965353675105127, -0.3183922477042954, 2.6846570272602026, -0.22041456934337658, 1.0481740348026372, 0.6989026544934739, 1.8287413201888938, 0.9301850203110819, 1.1098743061472136, -1.3474374849193598, 2.47504083030481, -0.7820903206039853, -0.4533161718034904, 1.2995702299991072, 0.5096726681083913, 2.206917702106383, 1.9710632843930238, 0.18360404180253792, 1.3346837623880443, -0.5515257465060451, 0.9323062595512618},
    {-1.4107239508979834, 2.1024921250567257, 2.6529752173417833, -0.10076917275537742, 0.6488106812559323, 2.274239836909304, 1.1083347029145687, -0.5446607729378568, 1.1149773320081993, 1.9461134153170012, 1.2751682740623, -0.2101181878030947, 3.993484043460804, 3.1402754080153805, 0.2646620568977426, 1.229681344367586, -0.2674700826260714, 1.2575153546281834, 2.153046326490049, 0.7067124262722626, 0.9383267249694632, 0.3973137455905894, -1.1365044364614987, 0.8301389273972248, -1.811696258880093, 1.4849301711904108, 0.8096424925705012, -0.11100019482712155, -0.46848224929494636, 1.3489023270619536, 1.0263039516088874, 0.8359455583250487},
    {-1.704228175905134, 1.9546256364600871, 1.8861745305161262, -1.2203407117148226, 2.9199237892689207, 1.7637159480318663, 2.424406999539125, -1.1873711289916722, 0.6955782324336733, 1.549638929610701, 2.2346824492934787, -0.016114210152127564, 2.351309974462359, 0.5433306551731605, 0.5899948090531135, 2.5443092044067717, -0.5059132697352681, 0.00401834116469568, 2.044562871504878, 0.05151747413592198, -0.6050406075936945, 2.2036129203280677, -2.1765608775042553, -0.15034948810954038, 0.7812816395313095, -0.43921438606708874, 1.6735162765365308, 3.5440376528236546, 1.6467131188012607, 2.9373436959706596, 1.1394058546981831, 1.525360775839981},
    {-0.6782968263192243, 0.7258939004866032, 0.04825817240886171, 1.2858371483383046, 1.0713052393070985, 0.7616470411192656, 1.5209917819794978, 0.1514299844133052, -1.2982387670135678, 0.17845468580872237, 0.9936538652202144, 0.5075045239048859, 3.2205702896413015, 0.297070151365599, 0.8813966110077496, 1.7107217801092613, 0.8548713548213843, 1.6086331898503599, -0.6543690666575165, 0.8381454016412104, -0.3709806907183769, 3.222280163219519, -0.822801655439633, 1.2321992251656924, -0.15122798246867522, 1.6069250490711635, 0.8690991713118577, 0.42049571911486244, -0.703876963833732, 0.38124070763369583, 1.4463363871165125, 0.2826602565732506},
    {0.38291506251471663, 1.5397279638506003, 1.6823609330459535, 0.7351121243748714, 0.19565620754624155, 2.01137387680105, 1.0226047544362133, -0.3870916228728496, 1.011941881264767, 0.4163792567688269, 2.7492245823874994, -0.5368778923166163, 1.6191557612470402, 0.6986485639292037, -0.12786481405854014, 1.6130692064975614, -0.5120382476825609, 2.072429603784218, 1.0375614810273908, 0.8405460063827879, 1.4678307426944663, 1.0530568835085206, -0.8553504508224754, 0.33252006788424887, -0.07755045103497268, -0.411466056928839, 1.7452510370971537, 1.1000477231522259, 0.2860584816205247, 1.8199832400881337, 1.775836115420439, 1.161782129860318},
    {1.629663380127073, 1.9135738120905417, 2.533578546772915, -0.28716027094947083, 0.9491689214945023, 3.4297929898827366, 1.7960876653811777, 0.4974280059642232, 1.8223488238604617, -0.5752806160200168, 4.055605245895086, -0.7523019360471532, 1.71705538458088, 0.08715277817021462, -1.0813797504033966, 0.26765001018980644, 1.4522283985373903, 0.7807350894495135, 0.2508199881756337, 0.5455334191243308, -0.34500302930435783, 2.541847964658288, -1.349489524430642, 0.014899940252849188, 1.7455782010020788, -0.43255226335462066, 2.033538265044666, 0.7557133688048067, 1.0182747404943988, 1.556373274817289, 1.0484562050712205, 0.864894417502614},
    {0.9501641414020199, 0.976375815168659, 2.951688564670792, -1.7039580358986177, 1.3877657853060164, 2.1163986058085325, -0.7844611800313542, 0.22294467938720103, 0.43322933794215296, 1.3771191330111339, 0.8293178751134817, -1.2041137358496525, 2.602811510485671, 0.4639065449607563, -0.5904019458194544, 2.7857834981315217, -1.3852705863218526, 0.8834228117761603, -0.18540376707737058, -1.7204020949083092, 0.5958824393228902, -0.14340049794072557, -1.0009399649966784, -1.7169008701813415, 0.31748114972994307, 1.9490378679692708, 3.492606679566801, 1.2715451870211927, -0.20909791902603397, -0.7189403963986634, 0.5513050817458207, -1.140174918578185},
    {-0.5291782837777183, 1.8962177110702922, -0.07250747412353391, -0.4531607458330561, 2.540684564105976, 2.2036736507850425, -0.3046752645404277, 0.1831547042364905, -0.11740405103131753, 2.954792134612207, 0.2872480809298408, 0.09381705828332441, 2.731904907422607, 2.15499895873683, 1.1564610043357617, 1.310922406586285, -0.6840128743554197, 1.1575235898801626, 1.3725997880944734, 1.5029016689780792, 0.31032641198407257, 1.1445881539709726, -1.5777947846429086, -0.8899793908514644, -0.5462455015012565, 0.8973112890870972, 0.5807849377121095, 2.325770443048055, 1.6366734006759003, 1.107052079073635, 0.9241263296301293, 0.07251074941800373},
    {-0.4369732944623051, 2.5720715174134607, 1.7817817249045234, 1.8372251190937348, 1.3617449661678136, 2.0647993556810094, -0.6252223006330545, 0.08513174008203671, -0.7261120144290272, 2.8145679434168795, 1.561466584996062, 0.8234991435725532, 0.4061783833278151, 1.1645881606704689, -0.06749964304120959, 1.3224344156897394, -2.1895716002173176, 0.9930787449010992, 2.339004295969954, 1.4226812612066149, 0.05060978669992958, 0.03143786408220859, -1.7984169975820814, -0.2174784854058362, 0.12142441633726227, 1.9491048626199978, 2.9381835029022922, 3.192846171259663, 1.6437162590510725, 2.249646272178485, -0.7818096054757698, -1.649898034757902},
    {0.21532769205513297, 1.259781265881406, 1.339984744595133, -0.01282050907973219, 2.401017686478314, 1.541698990500597, 3.010256058434974, -0.04093734273029303, -0.5145959077038418, 2.1839190049808885, 0.6392648258954889, 1.2847810618072264, 1.0897149394685957, 2.129472181753923, 0.36368470721441054, 1.5022086679858517, 0.39593479346236854, -0.9539863538992068, 0.6904029924444753, 0.08373817835986357, -0.207418962920609, 0.9903940143956624, 0.03519352888465795, 0.6639471779344217, 0.6835378269878093, 0.2517184291919842, 0.7653336380210776, 1.0595934435745562, 1.0109918301948777, 1.1463171803020102, 0.3994830637603749, -0.5851778825349538},
    {-0.32925704643765946, 0.3814043759370436, -0.6205310601302102, -0.3834151219068998, -0.5100991073127165, -0.20894872230699857, 2.6927977006701385, 1.5192146813782006, -1.0291834161470623, 1.8042419745047833, 2.0464514639294773, -1.387395792032718, 1.2117605959954145, 2.4072827357990976, 0.1716874449898322, -0.4505389121604861, 0.30601092535197993, 0.041076675976642475, 0.8054122719796973, 0.6242601639328654, -1.2267690986457287, 2.087131822123863, 1.1173254690194996, -1.4547416620393672, 0.4604240236100575, 1.983138424817129, 0.23881890606589556, 2.3747191064099744, 1.6084730013791306, 2.1288046778091556, 1.2180146716999456, -0.8721234837819962},
    {0.7537957060629343, 1.8489427674329852, 0.20375853850197836, -1.0939399042634277, 1.405265361822447, 2.9199376967399213, 1.8472179720404307, 0.6078289878450379, 2.124741783785017, 1.508009793938948, 1.6738797126639922, 0.4755676239222099, 2.4897454478096748, 1.148709853021575, -2.3434942687938025, 0.1457186259503134, 0.253802598388752, 2.6010999124414544, 1.634799086873766, -0.7910547068397601, -0.6625587148202622, 0.8549675570860199, 0.9004863541965918, 1.8822450215785294, 0.27896845867410297, -1.1132460116018734, 2.6800793420871534, 2.1037448284693347, 0.11403456601458911, 2.8087315791454226, 1.342792595222791, 0.23087265490544845},
    {-1.5082370120745314, 1.5738120285243873, 0.7069643571499368, 2.1297293131889434, 1.4240138333884764, 0.9434053944270119, 0.20644927431803098, -0.13794721416023836, 0.4466726702901777, 3.1580187002978373, 0.4055032400819139, 0.540455925487792, 1.0916471424529794, -0.07855360419469806, 0.14911111902562266, -0.16802927446099272, -1.6349539425947155, 1.3651493903588476, -0.35617871858836075, 2.1806325507647286, 0.4140484323752131, 2.3393580367408484, -0.18553264995282445, 0.381502989456028, 0.22600731151637019, 1.9858509911157325, 2.235861303208617, 1.0523477215673585, 1.3324311379540281, 0.705857331160525, 2.0794500436345347, 0.3824068560680682},
    {-0.6518105346790479, -0.00555331655243391, 0.9508925842841738, 1.9735003163568887, 0.8475601783327421, 2.1378508501964584, -0.7265198691593373, -0.8444782652178461, 0.6150432564630646, 3.5411402808556236, 2.406246283792456, 0.06193366932815772, 1.9705775335281486, 0.40736098054462416, -0.18346440125507366, 1.0807843081361157, 0.8480765880091711, 0.6329392491035598, 1.8070761684426806, 0.08843868554576924, -0.39695696143590886, 0.7862698705378219, 0.6087972734073155, -1.5940171712678781, 1.1857661751660848, 2.4037125712101823, -0.3848362344645067, 2.926000715592937, 0.7173070851895769, 2.308199054445457, 3.078241900771987, 0.8503889000969269},
    {-0.12057358443880102, 1.569989515329479, 0.8628788105880254, 0.24008447546304584, 0.9504992230034991, 1.049078360312087, 0.721988227237689, 0.8273093449493584, 1.2669871928003538, 0.31224499639317943, 2.12707640640849, 0.0021690285962150434, 0.9807330478484113, 2.3415175945919167, 0.762211193081994, 0.3306342965572404, -0.5647695153791258, -0.05764833444008835, 1.987243371744728, 1.356440382091529, -0.09108909928763559, 0.035616238654236486, 1.7301559695591013, 0.7317737602224246, 1.0261430760107386, 2.1032927878564034, 0.7557341049849695, 0.009945998479989813, -0.33571859704429746, 0.3755421906215325, 2.1845903061397185, -0.3115055991827584},
    {-0.3584400724456395, 1.7005036443136512, 1.0334165491176839, -0.541130072939495, 0.8982874596491899, 2.5558233673167625, 0.4921308896701937, 0.5133955791780801, -1.4728279450889743, -2.2050178670942553, 1.5491582878877688, -1.378478341726335, 1.6479992148930644, 2.8925978789825395, -0.07593646693325753, 1.4241619850917795, -0.3193870036079556, 1.85272053977945, -1.1181806910939915, 1.3563113520122947, -0.3352927383611563, -0.05530730795675977, 0.24311503298529294, -0.9496378986362282, -0.3205558305343397, 1.1185436360696195, 0.7639234267025696, 1.9984375617121897, -0.8846209605437991, 1.4488075290325888, 1.4656157744136338, -1.063097423851436},
    {-2.0909658956078605, 1.3255248049079305, 3.3946381710759765, -1.3417797221393006, 1.3660577799832074, 1.7142501068234761, 1.841101576317622, 1.455957596245652, 0.6531987150150096, 3.6509056944095954, 3.5413484318699666, 0.4002675612182921, 1.8112411007228895, 2.2872986065431515, -0.8344067371552019, 0.6550884393294659, -0.8252503554760866, 1.6337024086388332, 2.0554708396568877, 1.6834688651440235, 0.1453499775126831, 1.6980768419160581, 0.6250912644723362, -0.8265005274690774, 3.8989390533434887, 1.0434061320325363, 1.5392306594646854, 1.3418226827004829, -1.1021383523958292, 3.117293165570601, 2.359351394785913, 0.7532123237341346},
    {-0.7063713892286612, 2.120151089391048, 1.2402035599258496, 0.25472471967103394, 2.0864477802971835, 1.3848756988187745, 3.50526453601588, 1.3608376709556447, 0.7108708077507757, -0.12387803884990531, 1.6031508756697561, -1.4536877645094555, -0.37092520296657205, 1.708770074506365, -1.1443493734855428, 3.5004732735667137, 0.4350632639683124, 2.0443316874224347, 0.45328426265259675, -0.36824823733300216, 0.5640018732048517, 1.181434991279022, -0.389072890382245, 0.6889149009557548, 1.475460780471773, -0.4466320807266881, 3.0576398116541723, 0.9574355926945665, 0.2889363001763687, 3.522475104754874, 1.5148288608633915, -0.07838688876090459},
    {-1.390616425906455, 0.7934693328162407, 1.5935345036077972, -0.9540547179920613, 3.3576027890305142, 2.08696719138121, 3.3607506707233665, 1.5000360117355482, 0.612097332415192, 2.3656640920892618, 2.1018799677125113, 0.4762107887846463, 1.3751235746416104, -0.4502663242035032, -1.4255029312365646, 0.8724051965049953, -0.12142223040132707, 1.767329387688628, 1.237048512503546, 2.03212689618381, -0.6401916101281296, 0.3258180450841096, 0.5280686043541534, 0.6926398987453493, 1.1480362481717372, 2.9166217241150476, 1.9848087411673174, 0.6579827001397325, -0.08587012585288105, 0.7996742819306222, 0.7761884478462481, 0.9669343056664882},
    {-0.009969900381636473, 1.631683335688066, 1.1124978050871293, -0.23225977617132232, 1.8639198699432358, 2.6247799930534224, 1.9331433476191884, -0.2549562904845124, -0.16344162940521217, 0.7129884133033627, 1.2823807429032894, 0.897826492830174, 0.8103387544137304, -1.137057371230991, 0.38887350985542707, 1.4168732187850903, -1.01503089964098, -0.883887842908407, 1.2859728446324399, 0.05871339106058702, 0.30325293096059663, 0.4355635769810814, 0.09002090633680455, 0.35594478970269894, 1.496482806368436, 2.2852427129908035, 0.966171866485673, 1.6481081976591507, -0.6438350794616423, 1.0400384221555108, -0.8336366065041394, -1.0804935250570953},
    {1.1831633746243289, 2.353579280268528, 0.6352931584097674, 1.9325864486289055, 0.3614843380772857, 1.1057819148428552, 0.03105697902552332, -1.5805549605693192, 0.13605160780586525, 2.05145057186502, 1.713169836765774, 0.4477754010380797, 3.3073188782967216, 2.3490359469545417, -0.07509004971758636, -0.29247843117589845, -0.7193940130181639, 0.9546953636459755, 1.5867586339207627, -0.5457440439698452, 0.9843280422535835, 2.1310263012753823, 0.39581810893796476, 0.629335830685514, 0.47241451007700147, 1.0485969521430694, 2.789861456627912, 1.670920783728792, 1.2443708451319953, -0.5045326135547342, 1.5219376748941347, 2.132789144949861},
    {0.05324745261833794, 2.1135411965576147, 1.2541583925443318, -0.3284754872897022, 1.992580870808215, 2.655967317497778, 2.210131421084669, -0.7374801227212349, 0.3676768688547267, 3.144865879915999, -0.3360295654301595, -0.9775687958237562, 1.9454339767574709, 2.0552316728894446, -0.6110039007367747, 1.8077721472838761, 0.15778371345149564, 2.6159104770940846, 1.689266609823508, 0.5651275984403489, -0.9923554405130514, 0.8794918242460238, 0.31614496356940663, -0.1078093332687474, 1.0446255144266023, 2.2767014349880643, 2.7917062322768316, 2.752985683331614, -0.0031141098956825202, 0.3910594384513943, -0.042799497143765235, -1.433052623600302},
    {-0.8690915255988085, 2.4129150563395285, 2.2167091449285263, 0.3184274938413633, 2.1284231500182567, 2.8255598571930687, 1.798008624938792, 0.4433858960525678, 1.7747169293308995, 1.256416130576966, 3.3189350159076745, 0.6687667362630781, 3.0490930915244516, 1.0453980479121603, -2.1523304620378942, -1.6682398446509132, 2.331008818541342, 1.8934858867922697, 0.8131232347698533, 0.032666218683078174, -0.9880916690809438, 0.4568370626803015, -0.3212075453833719, -0.17554055008130873, -0.3184761584397852, -0.8896488809351198, 1.0539466800038775, 1.1975944788296757, -0.21587702911684117, 1.5810767994030983, 2.0914982745614763, -1.1430648288985237},
    {-1.1883225053833806, 1.2016955359071526, 0.2295473289301803, 0.7725412627120863, 1.3827402665256925, 2.4094568526703357, 0.12282429790227546, -1.4934308496253925, 0.2948470685422065, 2.4127952623642788, 1.8219763463254086, 0.864873351595752, 1.0106456730248963, 2.219631355473929, 0.7359880190492892, 1.930990931726491, -0.3994788825126193, 1.4433616890136836, 0.12290982938939782, 0.3631356529168704, -1.4127843674994638, 1.5481670548707347, 1.149048915277768, 0.33524508406853515, 1.9772541584453052, 2.822314203525057, 0.7223263672645718, 2.9205109474504325, 2.7535682804660766, 3.12694035073122, 0.8225804079572355, -0.16632261470880613},
    {0.3483498331723203, 1.4422105247140877, 1.294885642181513, 1.3760017633806554, 1.3131288872399511, 3.240711309633294, 1.8776465593633913, 0.647779479247764, 0.8368156501837254, 0.14133058858129818, 0.6696001165840546, 0.44126330980941275, 2.131670953452612, 1.7926758135150538, -1.8981139500619293, 1.3843291083912723, 0.315919256736775, 2.783208877129064, 2.145376248352789, -0.5960334067183903, -0.11970359483875426, 2.483959199175892, 0.7253498370233185, 0.022546943196446786, -0.2922965539838617, 1.2208472373354016, 1.0410170836145576, 1.905849812109386, -0.9237677872671726, 2.389672723278574, 2.191384790546805, -0.9199187062794919},
    {-1.7798682609772418, 0.40852917329837374, 1.5706291614216765, 0.5544555362068897, 0.32079124682927446, 2.6548810312238964, 0.16892871826008454, -0.30319677818384677, 1.8963967343080508, 0.7421227408111369, 1.1952870994422686, -1.531914563254495, 1.3026695822107874, -0.26576855627397206, 1.908616882084896, 1.0803632617710537, -0.7912307392103816, 1.2616920927654742, -1.7150301004645805, 1.127727100356115, -0.1857474674726785, -0.6748713521346185, -0.5967053867092946, -0.834874991566904, -0.09594160501237048, 2.828029016827709, 1.1823921387397414, 2.850482852095722, 1.0771857921110304, 2.225586125259579, -1.101209069043661, -2.076725795285909},
    {-0.7316936610735549, 1.132042513025375, -0.3768888361165666, -0.4848070130741337, 0.618209261679118, 1.0389418102604928, 1.0871695010742242, -1.7006645271316168, 2.1971114056858565, -0.17242954042357875, 1.9968538279641364, -1.2896211441572736, 2.0963567261564804, 1.6560823825920976, 0.9058288388525987, 1.2883663168301769, 0.01587341870016849, 0.8184739189892944, 2.6915218875731064, 0.10580337381716787, -0.20213624379963305, 1.121766145844893, -1.5450242326885142, -0.5848063945469125, -1.2672628934169314, 3.0919107740542486, 2.832577497120067, 2.381335498791897, 2.996883497239532, 1.0892146499909063, -0.4769426655320021, -0.39244746940675884},
    {-0.5227315863048216, 0.9105075571698733, 0.8929559018836409, 0.7776754733046048, 0.021302268858714304, 1.283570976883271, 0.5674988584411675, -0.9227372674923162, -1.052472536584378, 1.011185009624172, 1.5734839457841134, -1.311870497306511, 2.0275656065691843, 2.7713571380403015, 0.20199860047047222, 2.7228415649511923, -2.84827430861358, 1.222294143717261, -0.8930616882401705, 1.113616376143199, -0.032618572902941685, 0.0975269876187962, -0.8315701915286192, -1.1407074120956828, -0.2592781752770523, -0.6389520599557897, -0.19139610225760095, 0.8110439015329352, 1.4277057035212941, 2.93319220126592, 0.5737874236970815, -0.6582108639217906},
    {-0.6966327713516427, 1.029028523869475, 0.5914298628833253, 0.0021210814346022864, 2.8718276277326877, 0.6401512546157251, 0.0537110362986648, 0.4194501940703791, 0.2976538295545238, 2.561815489689386, 1.1077326238930927, -0.4624412977279108, 2.44704217099393, 0.7697750091846509, -1.9585123048062993, 1.4488977281578872, -0.8368139150929643, 1.5389944434367875, 0.971321532157423, 1.807260673875703, 0.266135538256101, 0.06685922368076982, 0.5989901000733163, -1.7769988100198169, 0.45736688676393705, 1.3365015045632291, 1.985805267326132, 1.6501307576308184, 2.340083185233681, 1.2714755253663483, 1.8346810090978312, 1.6581680085488462},
    {1.6905864238174515, 1.6493160891654957, 1.242963915810307, -0.723789983120381, 0.12025994028643752, 0.5661947005739819, 1.0430607104093519, 0.08373637284867706, 0.8897112522689441, 3.2695683706224825, 3.5967566240706366, -0.19358177648600672, 2.133967790994037, -0.07043411792800895, -0.4553984614440096, 0.9408321148005102, -1.3303762178525065, 1.4611629069335608, -0.17596665380868456, 0.8815497429741633, -0.9741683455480709, 0.24434552014525904, -0.8133754319899564, -0.7849315091237443, 1.5879298070165635, 0.7697851605339106, 1.541983592479224, 2.727294304583523, 2.6354339786929, 2.607935616297227, 1.749157244710412, 1.537651002715996},
    {0.4473529834882921, 3.1796901555623367, 0.8628089990847809, -0.2151748515981061, 1.454170712137978, -0.27294884527407914, -0.934832259760926, -0.21684223539006633, -1.5105171751384123, -0.13742026657967502, 0.638511513369005, -0.7482655342122101, 1.868413801170759, 1.4565228084866582, -0.9028538409012458, 2.077795515339409, -3.700931045922177, 0.3057054572033453, 2.181100422188148, 1.5385833444065284, -0.7323098368228411, -0.6737541714287796, 0.47401394395913665, -0.12101304982754327, 0.36063496472902373, -0.19631500307678657, 1.4355786446524401, 3.718325252305252, 1.77614788626685, -0.3915566007059995, -0.9893746153616976, 0.48457222204644984},
    {-1.3804526547833311, 0.14299875593464328, -0.987866479933944, 1.7266648221244079, -0.07084841181736602, 0.7991065117393399, 1.300941539049803, -0.46658561748667504, -0.15471005915425423, 1.1667321564704778, 1.06611813456047, -2.6704925349251494, 2.4636099548540327, 1.4104784652371003, -1.7894148981843152, 0.9687119357562841, -1.6026037347816315, -1.390694736905432, 2.2450225402876782, 0.876296851901716, -0.7976203089268683, 0.9803910190243913, -0.9643732586586053, 0.8799005689776344, -1.2089560950884601, -1.311068010291482, 1.9617608237509672, 2.017205742908404, 0.44464076088250015, 1.6957284428477661, 2.016045518069887, -0.9527166874141563},
    {0.7856343765474578, -0.8208419076502275, 0.9265494352208848, -1.62360010417992, 1.8288903796775193, 2.8029881994658563, 1.6791546916193958, 0.8631085076813916, 1.512014805325495, 1.4630442240215036, -0.044863441826260765, -0.3958109081408161, -0.23206725393996605, 1.9303927561746255, -1.5960560563503075, 0.7976444855535743, 0.24226175507626738, 1.9067995724033975, 1.8493348818643434, 1.628144300973634, 0.3259085228805935, 0.5086394911403297, 0.764339927802835, 0.2632531128236248, 1.185199185072321, 1.1778649496127716, 0.9601703567607793, 2.614280744055046, 0.8027247993857503, 1.6869715969996415, 2.932486471773141, -0.16245558882314737},
    {-0.053216546192377374, 1.2141857250278694, 1.126260399891233, -0.7300889589727142, 2.846641933753631, 2.271540798194651, 0.04398238788009841, -0.020947196742390675, 1.6253804144346338, 1.1356897569461777, 3.404366012678415, -1.3517589025774837, 2.1095493075326957, 1.2187347635230807, -0.8490507900866576, 1.685523875907885, -1.2911583466789078, 2.042791620810718, -1.0599128004883602, 0.28102100579809486, -0.9584587106717627, 2.34870947426805, 2.140900748057526, -0.8843406684213347, 1.7179372592765527, 2.465295531500761, 2.427074249716626, 2.1620434793928287, 2.063563787569584, 1.0091398489390273, 0.5708664073090577, -0.8728167989263255},
    {-1.1963013185483995, 0.27662169950444876, 1.6354238864325488, 0.04772966366918727, 1.8282690295895712, 2.178614304042814, 1.6119911464439844, 0.4713442188655765, -1.0960684765171622, 1.229003889246909, 0.6122688320631547, 0.07936334683632285, 1.9287946211673828, 2.282964179102917, -1.3206572740727867, 1.0552910047929756, -0.9939660490574713, -0.38333342049959596, 1.2885442209084714, 2.3515081201267427, 0.9287940112851769, -0.055907247375353186, -0.8934234730666772, 0.35671964650212173, 1.0930113532774075, 2.6349093314175884, 1.4444092327510618, 1.7444368715726526, -0.021297591945173132, 1.3834454728981345, 0.3141828330976636, 1.461113467386363},
    {-0.16213670905253524, 1.1189644663811513, 0.9610949702735146, -0.6023112187390003, 1.6948179236445773, 0.7093289843571924, 1.1438406823940392, -0.4787537561627237, 2.0323131847005027, 1.5199320425053917, 1.700069025899906, -1.4204332642008641, 1.842628259990418, 2.088308661836249, -0.47918993080051514, -0.7932832363975, -0.8531804509242185, 1.0072965997945715, 1.9020827792870703, 0.9112206484348173, 2.023879638484139, 1.3327344439886282, -0.7499495985644159, 0.12680204593290773, 2.5811528688153067, 1.3308271517350723, 0.8033425666234917, 0.498979897324215, 1.7342476292801081, 0.6032930699924582, 0.09380602537040736, -1.2218837198174684},
    {0.46250815260797656, 3.342276360721761, 2.551746404256347, 1.9740801133960642, 1.2623989731945653, 1.370633630089181, 0.9088416357683368, 0.6516048446199069, 0.45469528916601754, 0.4664475353210363, 2.578634355318392, 2.722791176262163, 0.06420381586650176, 2.937644748060681, -0.46007058050402316, 4.631000065839794, -0.22190636635156932, 2.224415064059398, 1.793078439977858, 1.1280199001988214, -0.648020355033395, 0.30204616266398304, -1.675141979869652, -2.1024303642139825, 0.32114042080950633, 1.8549453323259604, 1.3251471381116793, 3.4432843676891918, 1.4093925067104274, 3.7630989660549483, 0.5890187037254436, 0.034181342218877545},
    {-1.2408983070760313, 2.2052002351844098, 0.3263183424962452, -1.6733054624384318, 0.9102761818747269, 0.6613947502646914, 1.2524605180991761, 2.4075860988169975, 0.6229755819765082, 2.1787190558177567, 1.5195985053510077, 0.9205250721496606, 1.0653610109751614, 2.172437022348709, -0.15804996853847175, 0.06868252496736522, -1.7193231664211284, 2.960953207260867, 1.170451476019012, 1.4580089716437128, 0.18439232281899737, -0.8310871772890617, 0.09524508779046029, -0.38583049922836554, -0.6037366415496165, 3.9932642666355966, 1.7490963888516362, 3.3061216556158515, 1.3730011594388538, 0.4262545035447156, 0.44694465060404276, 0.11618942254812353},
    {-2.650267528662968, 1.2865221752915212, 1.8620490949296689, 0.23964406061292565, 1.2710437434856101, 1.7053440155687716, 2.3234501375706156, 0.8336793835264945, 0.5201926853584776, 2.345206773778964, 0.47986584882652217, -1.8295455125646538, 2.7460920184621966, 0.5745194439918742, 0.8572176348423275, 1.5405453585440967, 0.6351236312768387, 0.9883470408489928, 0.9107531464252338, 2.3883281303967037, 0.8803823404533431, 2.9167748042925705, -1.9715574796798643, -0.4652717364358689, 0.5726275254156147, -0.5119213456344761, 1.4325526530752242, 0.05591352832356555, 0.7769646179866729, 1.6559370767243928, 0.7827977474014346, 0.6537782754423476},
    {-0.697744167233716, 1.9818967938716405, 0.021146823226719666, 0.13726641492490885, 0.435884763384097, 1.2002205105260568, 0.859300054019943, 0.6978020658942725, -0.9122683927306274, 2.1890700628561746, 1.7541227258359275, -1.4848131092895298, 1.2673044030061957, 2.070405421169942, -0.9978816534611159, 0.2327909247173014, 0.9984722971810694, 1.0741302728960926, 0.7581939610303424, 1.4530128769849078, -0.05557475294929486, 1.9780400788089492, 0.7901765038972645, 0.5979769974465602, 1.3225377421013065, 1.647448911760703, -0.0622345433157573, 1.2458019968943512, 2.7630909834141413, 2.792561353938368, 1.961419332447146, 1.4870056884354834},
    {-0.5239782636302195, -0.38872903939342734, 2.503656237553899, -1.6747993944433206, 2.3852767510541044, 2.10051311765792, 1.4663674302293, -0.9257879629725384, 0.42876321584456056, 1.8311470853374783, 0.3570042759221185, -0.28029551135753505, 1.5243728232506826, 2.210073576914748, -1.0327091446151937, 1.3296591976618168, 0.6412973728910216, -0.2336380896747266, 0.8380447085689162, 0.7666073786311336, 0.10125857909266774, 1.0643361328085816, -1.5769475314609667, -0.8819434384898615, -0.9731800990901066, 1.4731570338593585, 2.3084892472798098, -0.322833120200101, 1.0202464685199575, 1.9801150229371276, 1.351381743702672, 0.21456019933542828},
    {-0.8735773543183757, 0.5798061876045028, 0.843965449054867, -0.9942563890953465, 0.45471440276637853, -0.2376977552306099, 1.7304997258753056, -0.645593562777914, 0.4109097015268463, 2.6704644152793833, 1.7600230731128557, -1.819602134284388, 0.021977380972095867, -0.8916764221558847, 0.7989848744253222, 0.9785395341706635, -0.5052167608185569, 0.44274987269460986, 0.3136028642146078, -1.4642502527179497, -0.6436583103777775, 1.7182271798527893, 0.15726230582551914, 0.6637585856426181, -1.4397171893743552, 0.4021069201456996, 0.7065084571174395, 2.731447367327806, 0.7035695059534984, -0.0474470945863034, 1.3105534917275716, -0.5722089207920372},
    {-0.6961305723199243, -0.08386487045910836, -0.8902084351420866, -1.2300682556166205, -0.6896619752657858, 0.9132674218110134, 0.7730210031143508, -0.9301721983629332, 0.05741361989168524, -1.7846470567618475, 1.1799530263809632, -0.8391027825505518, 1.314596436378043, 1.6927309376453574, -1.0161755851538015, 2.850800658344128, -0.788156183459412, 1.7726118044893067, 1.566767547608379, 0.7719058543200606, -1.441020806036019, 0.23071480986816748, -0.8661895040688032, -1.5576435994216316, -1.0838373052798882, 0.6020196464302888, 2.3866135244851403, 0.7500416951822035, 0.6024842443904871, 1.368630736301271, 0.622175527555841, 0.7956219152521584},
    {1.118956292214104, 4.250649860770351, 0.2990638873216944, -0.036913493495369105, 2.1406701366716767, 1.9182195915275715, 0.373558480432712, 0.4105454260458974, -0.3959049221998352, 1.063186476180324, 2.3607925323541337, -0.06579696084233809, 1.6160225426629988, 2.460258311338313, -1.9494274565758725, 1.0654328847673427, 0.3785005244980407, 1.214513126943268, -0.41259717243110977, 1.820361257041404, -0.25843045987239555, 2.331024639123709, -2.1076007839270927, 0.09244539934448684, 2.184518606868716, 2.257320338914659, 0.34506211483895705, 4.096527165771169, 0.000316744783658316, 1.2877342238478293, 0.23116287938568517, 1.0785696340028688},
    {-0.07325047604514053, 1.2612083247754262, 0.9689031221149401, 0.12157083665350236, 1.441194031933987, 2.7498171864420207, 0.7714438604955717, 0.15989980517694158, 1.387191753345788, 4.415598836622632, 2.964915973191248, -1.260159801115731, 0.7932933865894095, 0.8786733287455223, 0.8532394827435493, 2.0256931800096383, 1.2831091777519879, 1.2157138279990354, 1.6477903796130293, 0.1514340590010278, -1.4589544269148704, -0.052752279169986815, -0.13947978800443944, 0.9476111234835966, -1.1846657142243138, 0.646925935513447, 1.0023343424307545, 0.7027235394550757, 2.304683032411525, 3.3491937470683375, 2.4607943519323867, 1.7960896307182375},
    {-0.5630645921966126, 1.802452553657119, 3.6919452665905528, 0.9521531332522993, 2.7602256762592696, 2.17212322727924, 1.815985646239117, -0.6832037964501814, 3.719667992404363, 2.785565186423976, 2.389933302558673, -2.0485178249378753, 2.778248524717288, 0.20815393921607733, 0.46533130272506684, 1.1794046402494542, 0.5006883917729346, -0.10757042279410885, 0.622426780581308, 0.8055022181362523, -0.84656550366776, -0.26771166362028587, -0.05205805927244121, 0.7113917214083761, -0.6227254829131232, 1.699778424582456, 1.1759604971538218, 1.13646370434103, -0.13854947646025295, 1.6594540302965481, -0.5810160629459433, 0.46878991782895874}
};

static const float b2[32] = {-0.49413185418913635, 2.3885971032011057, 1.6401679047879296, -0.25697397845160336, 1.7144301945972753, 2.6432727657827697, 1.8603196093027572, 0.2752100918977854, 0.689077357231533, 2.1396879822842707, 2.521880192691065, -0.29060692318054737, 2.6371006752747292, 2.2339445310953554, -0.5736201433089307, 2.1070366945037153, -0.5135331373137871, 1.531237872414352, 1.5380642587975004, 1.3011976901457862, -0.1887952131046513, 1.7695386204024968, -0.41414007186872587, -0.44641608619308115, 0.9762163463374455, 2.2860565282157745, 2.0652059820900255, 2.636505504807699, 1.450854035172051, 2.2245169346689733, 1.4009632479938143, 0.4512577686436151};

static const float w3[32][16] = {
    {1.786992933619758, -0.03577135465728353, 1.5018458769921745, -0.1807906206261443, -0.28267834301449585, -0.6813137592231382, -2.131802097281759, 0.34080590259346644, -0.8552647925391832, -0.19597135270730007, -0.9982274930168428, -0.6502168754755638, -0.06259850975316196, 1.2092652303969178, 1.1391075022874955, 1.2056365581215547},
    {1.499312751464881, 2.520446912120751, 0.683539753518069, 3.6418188403972467, 3.363075945066463, -1.6468471263065885, 3.502677480041927, 0.09241451475874171, 0.4112209315737551, 2.548787318413976, 1.8389095919051346, -0.43893478285423115, 0.1923250910728591, -1.7680240102565665, 0.5836798894454753, -0.0841804108160977},
    {-0.39959004709500134, 0.429592331409504, -0.40741842544954027, 1.9941280556362513, 2.204033209820835, 0.04613917105902771, 3.7237081467638995, 0.0004116614022789482, 1.7546929796286421, 1.481633076461986, 0.9998387259545204, 0.3099762400643092, 1.1628016189006254, 0.5793524530510907, -2.670093421027575, -1.8742511821144496},
    {-0.4418914546367045, -0.03356181020411377, -0.4842650601811013, -0.9522144680379709, 1.4500032846583621, 0.7868500689615547, -0.7486070330217097, -0.12454447327358364, 1.5434290352117708, 3.3596876931835356, 0.01785276031620772, 2.4703755131217404, -0.12418545040938216, -1.2582693260690587, -0.040923637380010904, 0.2489621538036236},
    {-0.44830994974306293, 2.109708485546979, -0.5956805659536777, 1.4902167456503568, 1.738139165416223, 0.5001387064732981, 2.614152960721158, 1.264202698627042, 0.2593654325227474, 1.5955684721332501, 3.1964897880505454, -0.6113708836129571, 2.59407795956478, -0.3281561206308478, -1.102073783575645, -1.0957685333608187},
    {0.14097334986519627, 0.815628235566719, -1.0888453420724002, 2.8969739369068273, 2.7900110298682406, 0.35607641964555536, 2.521858006821863, -0.9314002188508073, 0.36976511278537544, 0.6124827468677413, 3.655981742330542, 0.23322366846273032, -1.0940736279760632, 0.3076874760409416, -0.6361163340773284, -2.9175088810868584},
    {-0.875576831507867, 1.4850155025737268, 0.3139612057102748, 1.8789055406760404, 1.8843942229253425, -1.0293902770666201, 2.5489442821975903, 1.0437333796305708, -0.01420203888204521, 1.6853985368461806, 1.8010980793570477, -1.7229291063226635, 0.03534391710722215, -1.795289698161476, 0.699981983017754, -0.34887969192451124},
    {0.6197327501825545, -1.6102504807111018, -0.5267395622979765, 0.618554264359309, 0.04407489144997852, -0.7557788482697451, 1.1666500945577414, 1.3405329208008703, -0.8324399511613316, 1.1880036594936056, 0.44731062555905915, -0.21631131205261545, -0.6395367144828643, 0.37340952691671375, 0.8788667056653382, 0.16785300302268188},
    {-0.9545380146780492, 1.023477030211478, 0.1906685553397902, -0.038969019891159445, 1.6772091099802535, -2.02941302401275, 1.902315987711997, 0.09906188276452306, -0.6078276139267387, 0.7470897833209521, 0.0889327938460171, -0.8256439126436405, -1.347725048900166, -1.6053972547105992, 1.3669802794019146, -0.38934276116590744},
    {-0.1536588452827508, 0.6810743174791524, -0.5603859251583315, 2.7713254400213745, 1.7045591638001352, 1.2451194518089648, 2.0983012040778104, 0.6251624047649725, 0.4591557097468924, 3.1357324425450384, 3.05473159468007, 0.5194287054894543, 0.5492593246556845, 0.28246697944558136, 0.5862200848064307, -0.4416003978179088},
    {-2.4281669290135612, 0.8111698217977283, 0.07438039141987043, 4.092285891919436, 3.489635078099381, -1.243621440738474, 0.6973838006255125, 0.9668283140665909, -2.1893581688257564, 3.883271291603809, 1.3195570029821488, 0.004480344936297385, 0.006574665945893196, 0.31963699787549044, -0.8877927705636892, 0.11030992661365663},
    {1.3962922104892899, -0.3087396176927765, -0.7837845257268137, -1.1634095858685727, 1.3231650159169144, -0.1928104792755674, 0.3044679212578515, -1.2441798455741633, 0.4106667683568031, 0.3815863253338913, -0.5898655917521761, 0.8044044094147237, -0.011261923580238918, -1.1547560564364152, 0.6016895480945365, 0.20962259072588824},
    {-0.8793820687903958, 1.524529525615675, -0.5553531428289816, 2.9272488989422887, 2.9497108247036894, -1.4388455335964971, 1.9133876682018363, -0.49383946749788304, -1.9560825598777276, 1.8499877523580088, 0.929375500680456, -0.6667518398842807, -1.6050333647667874, -0.12691200168500208, -0.04182298591335679, 0.1586339213002871},
    {0.22111695493638425, 2.1092747293914864, 0.7910641271969014, 2.3697802056863586, 3.2316785015224854, 1.3361897543013925, 2.2822522596662886, 0.9319490621036796, -0.24204427974173218, 2.460394865672665, 2.098391420723803, 0.46586721737010534, -1.384746913990545, -1.3122787275424308, 1.2207579090690952, -2.0644311839474057},
    {-0.6369040043674992, 0.7758399149221115, 0.3770014052258692, -1.2283960085757555, -0.40345429975457664, 1.1092601191187414, 0.8454598821395394, -0.38817004538276184, -0.26786958762600865, 0.40655804490846864, -1.1224676089163195, 1.2651811878003876, -2.458679720332019, -1.0950661446315186, -0.38279553002361627, 0.8221823698576322},
    {-1.1092119296686185, 0.7641010208086902, -0.8523379951080005, 2.15554193188783, 1.7256151920127911, -0.4759066773269055, 1.870074135895273, 0.24416638079292596, 0.3757491829568818, 1.27187213914521, 2.33530137739823, -0.6642700170969582, 0.44058703333466037, -0.4337009027025711, -0.4043902568290103, 0.5296574474627092},
    {-0.49724627729484105, 0.8211129427624498, -0.2664138272623511, 0.14374061697092974, 0.6330299268231335, 0.031265844881683574, 0.3839795984073176, -2.357134777285266, 0.7313436289843838, -1.5750383770309628, -0.9488817009742992, -1.2329307157028928, -0.09418197733351966, -0.6528469107490493, 0.04604225686409797, -0.8841198316932534},
    {1.9015522827916829, 1.5358632503241, -0.22197582071310615, 2.705774253512161, 0.3374926891680788, -0.44644421431088255, 1.8638030342149103, 0.43863360061072293, -0.8514471635550345, 2.979040013666544, 2.1130106554072556, -0.2606531155513195, -0.05194824475687517, 0.23861847045017884, -2.2992713231074493, -0.8546760964343756},
    {-0.9958091893400047, -1.338513257071129, -1.6602145938046033, 1.7856730347854635, 2.6488669462969505, -0.47775883818283227, 2.2638585804051887, 0.6349013058878636, 0.09762662356834319, 2.008482272784014, 0.29738157770394547, -0.6765620404519125, -1.078571516350399, -0.2815374762654656, -2.21007590860861, 1.4275383304138547},
    {-0.8305436088572046, 2.5970268502553213, 2.155284807654411, 1.621042823109253, 2.354733035433003, 0.5108009391025147, 1.0996012763497534, 0.7888561137156964, -1.2705931700358855, 1.2448556017002783, 0.9547942964707568, -0.15122269404107064, 1.0305885262255179, -1.1308927051306126, 1.4789161039719572, -0.213112852697378},
    {0.7978480300056617, -0.7606521290429651, -1.2285426240536221, 0.005315454568951491, -1.3138368075456397, 1.0318980157305822, -1.3201635421193532, -0.5521240183978218, 0.6014206604327454, 0.9742464139092191, 0.023967006975049724, 0.5599318520681956, -0.035006840317472095, -1.4371939614048301, 1.1234131884903713, -2.2080375912621055},
    {-1.0435565720888147, 1.4697448771377901, 0.4607841634669129, 1.6298370932731503, 3.9386507990588955, -1.6809404621617463, 2.2886763039740723, -1.0203728267453522, -0.4222652669772774, 1.0184755939271342, 2.1982812768145896, 0.031217775870695234, 0.6962779860731447, -1.37333384689131, -0.789065277931277, -0.5087002852346161},
    {-0.8336037610459464, 1.0191752429460643, -1.699702543108812, -0.8385754539255138, -1.606140632089041, 1.3553874036807956, -1.1072122140910146, 1.1977120294487762, 0.7996321398177209, -1.0854452644104584, -1.7147227566902896, 1.1577453546031995, -0.03846668810073792, 1.6873972083191315, 0.7517313517408303, -0.5188606301799447},
    {-0.6962855639933548, 0.8057722368511467, 0.012766435822754559, -0.5803394806627054, -1.42442150946714, 0.9348681033008107, 0.09738740884042575, -0.3137752099269037, 0.3252639761869309, 0.9273741699443601, 1.2905339092319161, -0.3886740080012486, -1.1468342612134217, 0.86516912568632, 0.632991883180408, -0.0007181962504596663},
    {0.6870443361639462, 0.8993580116267089, -0.2791537743902262, 0.27558682040203797, 2.155505074938294, 1.9321637431226366, 0.9068343369434709, 0.4678944601273073, -0.255015625319741, 1.6311962245855136, 0.9746494431935876, -1.1865855517065584, 1.2905384852959838, 0.5207851202933826, 0.8591776971330689, 0.07801248073429715},
    {-0.15514791770361863, 1.0128646008618833, 0.7419691277331498, 3.62659753991328, 2.968378779171932, 0.11939154170122587, 2.5849863603683043, -0.005020576934267589, 0.4199999175506798, 1.77259879174393, 1.3326713194007924, 1.1000876234559827, -0.21060955790821756, 0.764825179773656, -1.3728400220544579, -0.8668490880361794},
    {1.5073556735935072, 2.0963018124416926, -3.665237003636615, 2.939203020920331, 2.2196450959149265, -1.8777500285465514, 1.4514078133005959, 0.4859763177644836, -0.21214602535915042, 2.441838066156326, 1.84414429954547, 0.2293826868262979, 0.5706331148160486, -1.2919699348232512, -0.46803805460547077, 0.6466084814688534},
    {-2.393480958063392, 1.9824541500388606, 1.2304903933990796, 3.477605512094793, 3.8480677591903185, 0.48270719457124667, 2.415926715287602, 0.030883023064770865, 0.11609553287677596, 2.7415824952519525, 2.2580222053632575, -0.9064214764791833, -0.8510664286487337, 1.8070592079766432, -0.04755595764998586, 0.2795505123377829},
    {-0.40697482823712194, 0.8404114681482335, -0.09439140590904527, 1.5828558147824274, 1.0236272659765058, 1.258193165749772, 1.0114700008255688, 1.4923530098928262, 0.3707122782787926, 1.6155696163288995, 2.5267657478348187, -0.48742937870064507, -0.6237419813614691, -0.12924620009608706, 0.23283245430637128, -0.1378085542347677},
    {2.116004138350497, 1.3058713305626606, -0.9434320437262049, 4.418626760216471, 2.503238896398641, -1.8574407649073843, 1.988953422191301, 0.7514593270443131, -0.4661753822623544, 2.9763689925447854, 2.0739086803691755, -1.5758985883678578, -0.01879046042273569, -1.0235390970090925, -0.06898332471426905, -0.025896846401682997},
    {-1.2743513681802798, 1.9411742271356156, 0.6174521263739422, 1.3575265137321042, 1.9262652015428232, -0.7575208212557498, 1.7935607152716357, 0.6070783391180419, 0.8507191604462628, 1.585959927283264, 1.3609191761311321, 0.9385863161707659, -1.0163361022471542, -0.051413688686543495, 0.1905764484792099, 0.5642944729041177},
    {-1.490479637979593, 1.4252231450768877, 0.8010424910278583, 1.621200302819285, -0.7472263040713163, 0.3765990416115464, 0.41601410518744425, 0.5206229000965121, -0.5088748310920149, 0.6717383559471748, 0.5282816886053274, -1.389959450267724, -1.0366766387645532, -0.20807113154813625, -0.5766468496964738, 0.5099759651663527}
};

static const float b3[16] = {-0.2341651865939955, 0.6793923188129958, -0.41882099219152813, 1.5863968060778533, 1.727181126085624, -0.02836557818502301, 1.3018721224840393, 0.11111020696644591, -0.2495738467437104, 1.6809623872920896, 1.727933327874038, -0.18606731526579318, -0.2420137672210487, -0.14764048442843955, -0.22859015455395704, -0.13427555503772937};

static const float w4[16][12] = {
    {1.078891974689343, 0.7604527781505641, 0.2949131313686227, -0.7435505725643815, -0.35961286135225246, -0.561880155373328, 0.3357940150705369, 0.553356195794002, -1.528141546718363, 0.14514043936756696, -1.000867591595827, 0.23540306123797147},
    {-2.485822706005407, -2.1708196489267855, -1.4234513361893544, -0.813617843931131, -1.8709951129929325, -0.9071457740195658, -1.0579310532944346, 1.3573610724612757, -0.7367505473925166, -2.3015853473152235, -1.1962761399507245, 0.08477769624525194},
    {0.5282183022339585, -0.856587318830157, 0.7565638015384446, 0.2569831150633254, 0.07466336452367495, 0.5951327755982347, 0.4724097760526845, 0.13287986502844354, -0.18115445104387817, 0.5589294104786744, -2.5048890697499515, -0.7928550309252032},
    {0.014499231921625678, -1.601357957548272, -1.384045161950509, -3.1524154091237016, -3.286663487930393, -0.5225164854430202, -3.22370727826417, -1.0962503999845725, -2.6200915666270377, -1.4997019102468223, -1.1490970341113498, -2.1133924050279282},
    {-2.520556927792095, -1.4535207498746718, -2.1631347893076427, -0.40899748553505383, -0.23685216104117585, -2.4424439223085113, -0.747453161548252, -1.4504651952176948, -1.1492155669519637, -2.3714597067840324, -2.4905315233425633, -1.781174757645446},
    {-2.136048115136774, -0.9284123413447021, -0.44566185184379636, 0.5077406587553945, -1.9201697259719872, 0.0599487796906972, 0.027697942111684068, 0.8328967558039347, 0.7488829773398663, 0.43805031938759026, 0.47240592662821973, 0.3266885268268055},
    {-2.1191414229936565, -1.050707582053486, -0.8107115661651886, -1.405768073602674, -0.6695363422023297, -1.2873553192407148, -0.7406256921994598, -2.348159030355647, -1.0930728784568124, -1.3413275517463037, -2.130035241162238, -0.9362056606882988},
    {-1.3810162013834268, -2.9253237847124796, -0.353417164276214, -1.155690705823191, -0.42959576989365095, 0.08014555699119996, -2.517241969949701, -1.6667422310366933, -0.8697644025927832, 0.5954333437383866, -2.2940460909907707, 1.8969217920678636},
    {-0.6745934015667872, -1.8624151708479226, -0.45615365132841257, 0.7205876061585881, 0.012472877877626755, 0.7633703404332541, -0.25812691426063833, 0.18277381661342593, 0.7358123964701674, -1.321940872656447, -2.0302911392666023, -0.7262405435452565},
    {-0.9042716464901658, -1.3894751620396395, -1.6656399079739954, -2.483167482139212, -1.0347165019389102, -1.4440317404620542, -1.345018100258693, -1.8165225634188709, -0.648355373386525, -2.1685144494103543, -0.6124842515073506, -2.1233598621156666},
    {-1.5280965385817527, -1.3832466484811825, -1.6673826281461028, -0.23997801125024767, -2.0193913759558244, -2.5617041617183314, -1.2389847132485616, -2.796984709361735, -2.402172447402614, 0.3830700113556581, -0.9950943038282145, -1.7902015368754558},
    {-0.5379375914460591, 0.7583796206235273, 0.3609995780920225, -0.7402012700218429, -0.8198132575728467, 2.7808588332504236, -1.879034940557454, 2.6574596483758866, -1.2158927931487213, -1.6943228832667774, -1.2211845814385172, -0.9052876204303109},
    {2.0209951686328256, -0.006050685468457227, 0.6537478641850817, -1.1059196878789408, 1.2692322803452147, -0.6726707665610493, 2.1612611651547455, 0.35275546551201703, -0.8104516121751476, -0.6403257333263702, -0.056388280532124406, -0.8701093815241189},
    {0.1179701698835894, 0.6254035822216497, -1.2097509989056048, 0.820350324127964, 0.10010007339698859, 0.029681707076649164, 0.22883831256072143, -1.106207418650501, -0.45469090786498356, -1.0353457897017833, 0.21402794035329065, 1.1905975166247968},
    {1.1109297121732218, -1.6296747011705237, -0.6537516797452776, 0.6271787497487463, 1.1609998792385285, -0.21091140127191152, -1.8606884396979457, -0.8677594422762424, -0.8130833917204502, -0.6341824112434639, 0.6837253131765081, -0.8079676451222464},
    {-0.006082117530922538, 0.0756391164494998, 0.9515374443649534, -1.4565874297320789, -0.34997370955960533, -0.6918991225675497, -0.21003692532249987, 0.32959452412845686, -0.9581588845205681, -1.919721626026812, 1.0824277546952399, -0.4119301662395734}
};

static const float b4[12] = {-1.217844586806628, -0.3542752836126007, -1.3455872039309187, -0.968752686674693, -1.3003900430929578, -1.094530058507054, -0.958627176354758, -1.0051280733619241, -1.2463471145104188, -1.108282308987961, -0.9865172127772677, -0.9879809286536867};

    // Input Layer 
    float z1[64];
    for (int i = 0; i < 64; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[32];
    for (int i = 0; i < 32; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 64; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Hidden Layers 
    float z3[16];
    for (int i = 0; i < 16; i++)
    {
        z3[i] = b3[i];
        for (int j = 0; j < 32; j++)
        {
            z3[i] += z2[j] * w3[j][i];
        }
        z3[i] = relu(z3[i]);
    }

    // Output Layer
    float z4[12];
    for (int k = 0; k < 12; k++)
    {
        z4[k] = b4[k];
        for (int j = 0; j < 16; j++)
        {
            z4[k] += z3[j] * w4[j][k];
        }
    }
    softmax(z4, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
