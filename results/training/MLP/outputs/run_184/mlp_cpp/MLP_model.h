#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][16] = {
    {2.9950219346636318, -0.2977981676219848, 0.4057928569551155, -3.392620239370836, -0.998726807574436, -2.331731733847822, -2.5221467125575505, -3.301987264680216, 3.744134942596942, -1.4716443794110472, -2.0858291779303246, -3.7538036476920382, -3.73901115649465, -5.558926660065267, 1.5425430578285446, -0.45334636463304634},
    {4.291334320053503, -2.4594717606377245, -0.14280375694791933, -2.750357701128539, -5.324226136393386, -3.114971136903482, -1.546845180912393, -5.145263786872371, 1.0023291705528268, -4.401721596168827, -4.159640456266421, -1.27406088717635, -4.216964461984602, -5.662953889425837, -0.9202709425043294, -1.0511165135279483},
    {3.769850213890203, -5.233874071533371, -2.259971134339616, -4.219758964183339, -4.344341223312472, -4.345364385755153, -0.9960148424313906, -5.652227944494848, 3.1945936169204705, -6.331507860242841, -5.609292872044937, -3.18885671427982, -3.6721185321169023, -6.427150863610946, -2.906823756515023, -0.3201314572912893},
    {1.6960532463255977, -3.763780812245683, -2.6888711114145485, -3.7455000968235432, -3.3937887188998452, -4.6102436108659495, -2.5476051445595074, -6.086690257370891, 3.7893565006631844, -5.299538519903314, -6.096401194139797, -4.891422525012515, -6.444197002692161, -6.621445749788807, -3.3976858483435652, -2.28700348139144},
    {2.83441191211663, -3.131821767209467, -3.201879856209891, -8.491601158777884, -5.553191326709204, -4.465747664162253, -1.7249467244044359, -4.150311161549895, 1.538445829710264, -2.0012676606644977, -4.528697741765028, -5.398824525018552, -5.200122974156153, -5.419200733603682, -3.908571731481122, -0.8156307515207273},
    {1.1072017120415354, -4.185854658530485, -1.700467339638035, -5.782266040572813, -4.935769927788966, -5.029748197058863, -2.7448111844466534, -2.9289630076359496, 0.9701603936451583, -3.7336484259760025, -5.881025233550316, -5.6445862333059935, -6.056338733633491, -5.254622564265068, -3.7023092493480396, -0.7587336971015122},
    {1.647678616850345, -4.779440902138085, -1.6684195354949596, -3.614612898679171, -4.590662373943759, -5.311725975258972, -3.192583728779838, -3.9891815434652114, -2.4193706322918396, -2.8745932298047236, -5.285390696939918, -5.335495023475507, -4.560828161214214, -7.657206138352809, -4.079038207820816, -2.5862827550045995},
    {3.060889518558417, -5.582637624246329, -1.5019123209424847, -3.533826830678783, -4.061889609493866, -4.6224970054205246, -1.0584657323706885, -4.1117531618326995, -0.24843868036118288, -5.451417183932179, -4.247660891842631, -4.814499626411656, -4.937338871454185, -4.332128510026163, -2.085316689788522, -1.9536674098038158},
    {1.0180121461200895, -5.151361992025074, -3.0301388509668596, -6.672663107874715, -4.2612208844646595, -6.745993262050324, -2.627444520415009, -5.6210836729833344, 1.4009036279486835, -4.2578311981293355, -6.071380667030879, -5.714557375281672, -5.182390696663165, -5.352613833776557, -4.068256083799052, -2.8578385421067547},
    {3.77454793099771, -5.503773732131669, -1.8729128931107784, -7.465661080470742, -4.8097860158958845, -4.805783607173322, -2.031983108712099, -5.770703062572902, 2.618283606978378, -2.5565636562412304, -5.219348180326997, -5.06711477103597, -6.394027308999056, -4.41864206895621, -3.4366257662425355, -1.493595831165453},
    {4.814033205751346, -3.4888115330423375, -0.5345521154828773, -6.5065002273221415, -4.5825923375403, -5.427631107159102, -1.4068090405667018, -5.496387557898159, 2.130524833529169, -2.4314925329213555, -5.54801118020852, -5.476601494278026, -3.5588290206911384, -5.637666534845753, -2.9401643456246607, -2.1828881338259807},
    {3.8015754972557545, -6.415329052388147, -2.3776575612574664, -4.618813959544758, -5.33352847807637, -4.8838626139856425, -1.9183992952442765, -6.359749448185281, 2.4545267460931814, -2.6326423685507816, -4.6032133271912645, -4.6857507692731595, -5.845478882902619, -4.397955427810839, -3.2632688558724507, -2.4986983276453274},
    {4.720462028710128, -3.811356180702887, -1.9747908949474633, -4.879431133329175, -3.055015006793637, -3.680177736845748, -0.4380930366979093, -5.426360491193607, 2.6084387635397115, -4.291256849028133, -6.12964509871037, -2.606657232451016, -6.922158542974147, -3.8069805055326924, -3.250116868171134, -0.029501121263596365},
    {2.4337838744276166, -6.383043818751269, -1.294003457055376, -5.475270082693715, -5.965095632716079, -3.861296601174987, 0.32351458233975416, -5.920670786148673, 3.9156223026723715, -3.480967965539854, -3.3829161809640858, -5.029833945131399, -6.57234576916692, -3.9967629405218124, -4.951902115466499, -2.2677854885273687},
    {3.937217037852023, -4.956499869242561, -2.7061723094501873, -6.3552453175974986, -4.2834485632539545, -6.595262958645997, -2.2151748937398885, -4.388916607915912, 2.4612983583857155, -5.198787637771323, -5.705870866549249, -5.5682759870451655, -6.242124442678312, -6.270677842933304, -3.2339864807180607, -1.7949217195686664},
    {2.900782083570175, -6.532696466887411, -2.6002641920281144, -5.247231489943425, -4.419116575546889, -5.2266325258751625, -2.483382898765159, -4.7227372742569775, 2.3780176361283023, -5.136693680273956, -6.084660102990293, -6.470942510414558, -5.605482275402416, -7.008664169316443, -2.997523705913367, -0.8316290538102424},
    {3.8813814281441688, -4.787199429658933, -2.4768730028165953, -6.512510044289283, -5.782208398660287, -3.6024031601846023, -1.9667534191329197, -5.244677867126238, 2.9710492695633817, -3.3662659264643864, -6.819030540208954, -3.7336353357085628, -6.136064946149126, -5.580303623988147, -1.6220525396314003, -3.125929448390103},
    {4.625517470760149, -6.6925405854289854, -2.6085120574495275, -3.7686316368081036, -4.849589273072394, -4.339855816554189, -2.0051176589465904, -5.73014138607718, 4.795308489475996, -2.9851071904021045, -5.721339428385078, -2.433899158627653, -4.44526209655445, -2.4743665817308504, -2.4252319935495574, -3.4397437034628617},
    {4.57794485610682, -6.741551309145845, -3.834305730190412, -6.5874479958883665, -4.838370412855383, -4.835328158784711, -1.446659763756733, -6.211356359221332, 5.370049976838206, -3.1244750907036325, -6.776198165661756, -5.200203518409421, -4.793802597155865, -4.681051338173092, -4.3135728068455474, -2.1420992739725135},
    {3.4145263861386237, -6.260775481586537, -2.520940957032355, -6.743057940168154, -6.362377729307179, -7.368747564040523, -1.3136068662219478, -6.44211984307985, 4.759069401159125, -4.474676513001419, -5.0821911804733855, -5.706750882189501, -5.738027368314855, -4.600716125477823, -4.4484304432175925, 0.1560559431918617},
    {3.8493810455915844, -6.055322080719956, -2.714917308590697, -6.486660800338728, -5.239178637460622, -5.410790389716795, -3.0871666079265068, -4.885563854712447, 5.615445257415306, -3.384469889978491, -7.725387274456801, -5.446228736003102, -4.694772629405441, -4.049308005059745, -2.081688578055907, -4.612285768252743},
    {5.951667407266144, -6.122136122648602, -1.398150486510531, -6.500690272683041, -5.210781882402367, -5.3623620914811765, -2.2028401738202352, -5.489537274524614, 6.52808902860937, -3.578516509195948, -6.011377773445293, -2.8917302020695277, -6.161291140930145, -5.1212427766278035, -3.2220090234402368, -3.2239784667850855},
    {5.441840702535337, -4.260565370258449, -1.6855841098574087, -4.623390146146713, -4.318598701102303, -4.086499139868308, -2.2558837012685355, -4.202850817860143, 6.285717894006866, -2.4411243046385773, -3.4979296303240353, -4.9621217263336375, -3.735703913204063, -5.114093881708049, -2.105466070406345, -1.4059298157580642},
    {4.7938524728239775, -3.9403975332697865, -0.9027206998717847, -5.88939583732049, -5.791645896388579, -5.218540351636172, -2.7236587713914244, -4.107429350238844, 4.66288317537777, -2.1270762663333977, -4.3333282500816335, -4.13998651261376, -4.293120876936161, -3.037718327696783, -2.7271273966683487, -2.6731132153565778},
    {3.024898026289352, -6.454368195851082, 0.13121723398032661, -6.898732264946942, -6.92545315527033, -5.762153432558341, -2.53549705144801, -5.543527480951453, 4.2611063345363105, -4.758297279442332, -5.687983721460988, -3.388009201053159, -5.808206883134395, -4.745580673043184, -1.7187184984237807, -2.0590953827650793},
    {3.686642291756879, -6.333502536224812, -2.067222514767886, -5.076288342149072, -5.875852642047576, -5.770864007305569, -0.08761732281266918, -5.395087289241367, 5.201298562199299, -3.628000392600865, -4.999392286701528, -3.354128309111898, -6.002072586318721, -6.042838852652836, -2.666110522650367, -0.8731773136775316},
    {3.121596697284693, -5.684778554477692, -2.91028080250467, -5.193190955222285, -6.948119713801476, -4.5652796857780755, -1.9280712443567032, -3.6127202200061044, 4.986126040896877, -5.467109239260702, -5.099724239812948, -4.66280450400021, -5.390945646726051, -6.143113971225169, -3.6323654132710756, -2.7539660399934287},
    {5.216046397558721, -4.575887980626082, -2.706615989914663, -5.425872345227535, -4.162409740155271, -7.478945502430506, -1.064387675758995, -5.097629296585556, 3.9884527655364694, -1.5663203274817215, -6.75198714145529, -2.642336753443925, -6.110293572957768, -4.068428078208242, -2.6381566029876784, -4.003122365300359},
    {3.0965818228148367, -4.155500538096979, -1.1948139913706877, -6.642720601584653, -5.3523111648711, -3.247990404891702, -3.8108699890155653, -4.882632081617493, 5.867851085464263, -2.7693276322619935, -6.3296745096387905, -2.212933040018938, -4.0558603196058565, -3.066172417656073, -1.5393671539529554, -2.087956545930413},
    {4.328010074757326, -6.488480059275837, -1.1120682448501504, -6.8569048592167805, -4.746687343220582, -5.524714757243499, -2.210260939288744, -7.191996161446306, 5.4423491476988, -3.1692896137781013, -6.124072152228221, -1.992868345708587, -4.001537970455748, -4.220928376167453, -3.8965362850116607, -3.812385290229138},
    {-0.561687478606785, -2.262909106613939, 0.1547275411042629, -1.9425967636056571, -3.9906771726837555, -4.727796533547784, -2.3922381405092707, -2.0387271211063482, -1.7931647838739893, 1.5210302463703234, -3.463163826914638, 0.6754228281031608, 0.8934911434465699, -0.7665152004552606, -2.4401354511875595, -1.2278623870050875},
    {1.5477594573223938, -1.5231786419403526, -0.4810165545923404, -4.347865491115809, -3.4873460605453657, -2.8415761074545327, -1.6528699762035777, -2.42668485807117, -0.8918323643713766, -4.016960472200913, -3.2459581255286563, -1.3807686844708247, -1.8301132040905614, -3.6265332804383195, -2.1341504682746937, -1.8970060912932258},
    {0.17725561435367304, 0.18238856186404154, -1.7977304973553399, -2.0764147631469787, -0.6612802570465787, 2.13118553261511, -0.6565817763908336, -0.01747276070740113, -0.40619303312865557, 0.2398777774147394, -3.388159097490172, -0.9438226975950776, -0.1000809183960786, -1.6243941971375546, -1.4655856464988177, 0.27644158902747346},
    {1.9345762271374063, -3.2166550664361226, -1.2384717006815513, -2.0889957195658777, -1.027194187681697, -1.1189662690095272, -1.4649139855947688, -0.7693679204439827, -0.43883723132961433, -0.2459308528273813, -3.4230667984509875, -2.8761166947412566, -3.4245046294152894, -2.8164124880119803, -1.203715481851818, -1.366484081256388},
    {1.7748799383485667, -3.620902705226154, -1.818755127244315, -1.3813552440844887, -2.7589932910024784, -3.3254915538698255, -1.4018399828611927, -2.6884554547708803, -1.4352294042959455, -0.7019587322300059, -4.415515437051829, -1.9631090578347092, -2.2175093130107935, -3.021108319200344, -2.0264980107580097, -1.605396400480216},
    {-0.4535517047372751, -0.04886575456447103, -1.878297212379609, -1.4627517817123643, -4.09691287511528, -2.543008867024466, -2.8167706315902925, -2.6758682852260565, -1.8535762544191334, 1.1208738671078484, -2.6397189647662618, -3.9088833240942793, 0.08713641833629816, -2.7912739821888968, -0.0252131746897586, 0.7406869797297244},
    {1.819725968878962, -3.1214165244704817, -0.8642535456616474, -1.5450681816667158, -2.526330356069064, -3.6280981568439974, -1.536683287625189, -4.014079946183835, -0.25464476100101613, -2.0159996514471064, -2.902950521166217, -2.76116726168567, -2.5991811911292495, -2.931185051826521, -2.460553407151642, -0.560916949254732},
    {-0.6439523177107352, -3.7947804529573816, -1.4167783191105061, -3.4271392041269495, -2.7268263264121266, -2.6519855651941646, -1.9543002229975621, -2.4412447143852036, 0.6532530283618355, -1.552941489942568, -2.7469379695870746, -1.7771633186396034, -1.5970764013391803, -3.4856198006962145, -0.946305920210848, -1.2525756692056533},
    {0.9481444898708282, -3.2279435218192067, -1.6964879237599357, -3.1559547811373854, -2.718794293969474, -3.153965767740636, -2.4795440523875008, -2.911910248497221, -0.727598233099034, 0.1703133449246347, -3.4601312783942264, -3.433112742988908, -2.594892018598879, -3.9268461411873057, -2.0321295129309873, -1.4690349402302603},
    {0.35007749013965267, -4.968985344147087, -1.009724522544682, -3.8918526722315536, -4.9721752398311665, -2.517182291727196, -2.4261881698648895, -5.289065094770764, -0.38080848868536304, -1.57904313116928, -5.201754075535038, -3.966913751772342, -4.133963998213543, -2.890191951497867, -0.6749532934310621, -2.4212712885738843},
    {0.335731452577768, -3.089582981649468, -0.05020354000062498, -3.0227824908360823, -3.171718339336493, -3.6943750552961885, -1.4389587937858854, -1.180908247479483, -0.7234482421345403, 0.056930851772031534, -2.051645203052052, -1.31845523973428, -2.8055474627584736, -2.5745035355838835, -1.6272555166015241, -0.4169719483333123},
    {-0.526872181746048, -2.8271995706363326, 0.8262564936692941, -2.5039324158455187, -1.925882019296906, -1.9664288341401166, -1.5557285844737647, -1.9683910860375073, 0.29040686416994865, 0.08022379448613852, -1.868855012937142, -1.5847130067836115, -4.810780480350383, -2.300375337398162, -0.5521035496242811, -1.4920290738060622},
    {0.2890032810365151, -3.0413386624870853, -0.11227595961747647, -3.712402592725182, -2.916991339617303, -2.783299812974742, -1.7017073371849665, -3.057472703995293, -1.0826484822372657, 0.9671680468778491, -4.612565145469061, -2.833289327037371, -2.817171645559387, -2.9131769597115054, 1.0350204230297302, 0.2667800831737628},
    {0.3564140752277409, -4.444999503421989, -0.9025722725809544, -3.9586433897952618, -3.2273842493223213, -4.308547078045014, -1.4125006430733558, -4.825555178978945, 1.6475305514992062, -1.9077178018652936, -3.8499661408592503, -3.636350893619746, -2.9521371036846076, -3.832177482174246, -1.0619796036692417, -0.0032146764169613904},
    {-0.38000568577421456, -1.13289788023156, -1.8013530707229433, -3.2392398677193315, -2.2952222811518044, -1.805992873056256, -0.986700871177211, -3.562310362290451, -0.20930818586596747, -0.874320673729368, -3.1980215705622177, -3.787188384566079, -3.3874775387737075, -4.419741240328437, -2.306911864068618, -3.1768877040506402},
    {0.6660355191932747, -2.2584783667684674, -1.8016264056716125, -3.4698238118407296, -5.791077064577265, -3.8489346112461904, -2.3889465993369305, -3.7109720965033492, 0.028570548409111142, -1.796340563496872, -4.244433840851358, -4.428437849921343, -3.1737595402346233, -6.039110577534092, -3.399909308173652, -1.5941934260685724},
    {-0.13137851986686366, -3.370461134286715, -0.5242135712530954, -3.2369662457690285, -2.92218179251284, -1.6851326606345218, -3.125365423572031, -3.710677715905514, 2.152456849555248, -0.8293063504641192, -3.705302845312245, -5.177365610937505, -5.311177805115641, -4.6933226734254365, -0.06460766157001774, 0.6040709569774704},
    {0.14020515120770666, 0.1899586714643711, 0.06575398705228555, -2.0655866489161925, -2.8230536572273928, -2.393411315595345, -1.2538838266337273, -3.1473892719162935, 0.20756582489676018, -0.5693903724581029, -3.54883041987117, -4.011302427291244, -5.135382252742292, -3.4115324324386322, -1.9809884910974318, -0.3284489902177462},
    {-1.5032617286100416, -2.3153743328507024, 0.43951287840046654, -1.080857689219199, -1.863475574706838, -1.7568133480644943, -2.1258653322193495, -2.9345887520665843, 1.1290879296809113, -1.1115790446115372, -2.909410695152875, -3.8821355301194553, -1.412949728131587, -3.6435739610629394, -1.499331085855617, -1.4626892999263146},
    {-1.1450810875174813, -4.410039807360796, -1.012944839438169, -4.304617615519854, -3.943883516410671, -4.389325609476764, -2.9644935627843805, -3.9290500127315338, -2.7108999278226125, -1.9409972571263774, -2.5148054715385926, -5.423299690003231, -3.006920914776294, -6.131348230899817, -1.9062170801974836, -2.6638489481246648},
    {1.962300130051701, -5.141020043271702, -1.984758860498276, -4.946116297933645, -5.649014968487895, -3.0565907276569417, -2.6859025262186007, -4.559344912007293, 0.2110645149460936, -1.969757896711946, -5.796398049583044, -5.42610061445465, -4.016083044714659, -4.281733638470918, -3.240683743695882, -1.6097137779531836},
    {-1.0090512003926737, -4.081428707924371, -2.7946717560656475, -4.27734875445673, -4.806469345312944, -6.246612129932992, -3.318312073283047, -4.775582501832686, -0.7870913805706323, -2.687028120157449, -5.861731121347428, -4.982054203159405, -5.154114322228021, -4.271471614295254, -3.747142408529014, -1.703692686109301},
    {1.214427460898397, -0.5187627116863952, -1.5879136802675848, -2.1379721281298547, -4.2343837945574325, -0.6730789033375816, -2.9923347911943945, -3.876746754898047, 0.9419038015957807, -1.3302178488193952, -2.890954349825083, -5.530563060159185, -3.571718713812971, -3.313858132890811, -3.214169106709634, -0.05774274714918272},
    {0.6498899069300866, -2.5805256995541264, -0.6216240164323712, -4.640424217617573, -5.041619844622881, -2.206221257457266, -1.3170688507508184, -2.4093248530137537, 0.4468975089068531, -0.7414446186715794, -2.980019021056917, -3.5942665421847937, -2.503452965743923, -5.299076245452816, -1.8857279866016499, -0.4946600174437653},
    {0.876087160551842, -2.8679774960254574, -2.9470963898918527, -5.024304175901308, -6.2975201857643555, -3.2312236717776655, -2.2187047285127717, -3.2145894860447766, -1.3976356425937235, -0.8908727893826942, -4.98990743832518, -4.918247675975539, -3.692030361719694, -6.506865921422065, -2.57778508881383, 0.41729475732904353},
    {1.2428791850891523, -0.7383044307333541, -3.1014118117568836, -3.428154257258552, -1.650332995373627, -1.2562273642369484, -0.06511547789404051, -1.3367691693408665, 0.18897697477670491, 0.26157772681801256, -3.1013838188798, -3.163035214255328, -0.08543644914119021, -1.6428361202607902, -1.4711384670608554, -0.5246479154237477},
    {1.1357898483842943, -2.803719224262571, -2.74077212787611, -6.413919499539251, -3.653636801250888, 0.09645886527005276, -3.1885249932114625, -2.726058030603253, 0.5231370158045145, -2.25257625320001, -4.852885949382941, -4.167699414306174, -2.761426825052808, -3.837528753910925, -1.4332399013544161, 0.301012240440866},
    {1.196681152146959, -2.6160449086763347, -2.10882685994171, -3.743865883350084, -3.2654542263949224, -2.693806923866629, -2.498719398558507, -2.2478736300935513, 0.3095049047323821, -1.0049500752093576, -6.4667930120537305, -3.1018166816756363, -3.1772155062295946, -5.511260708961024, -4.152983682459389, -0.6499161295797297},
    {-0.4586440037133146, -1.9852708782740476, -1.6191909322920055, -2.4955251216925465, -4.047148850043711, -0.4527660576689217, -2.2868625818136574, -2.4531655654833426, 0.5130634422001982, 0.1354019965022059, -6.305039679358137, -3.510288904815952, -2.045434319824417, -1.905157571688285, -3.4628619841032005, -2.1768259959412464},
    {-1.328616186004129, -2.160865062667229, -1.7772084073322962, -4.254237733468111, -4.049755378374691, -1.8966515255417904, -3.5558772704592734, -2.5307151609317367, 1.372823950919721, -1.8837559973044515, -4.5134708117388, -4.525530251204573, -2.4440774017050444, -2.7552442251194837, -4.031940822631498, -3.1545417619704623},
    {0.41981629624373473, 2.0871181444980342, 2.151461529306404, 1.9275446790186284, 3.429459667651386, 3.702050254912375, 0.9299554973500326, 1.1339995176004072, -0.6755776980427765, 2.982285765897868, 0.346465626983659, 0.24939040411338004, -0.7303273469100555, 1.0769048196926854, -2.4537044610069505, -0.14380316359904194},
    {-0.6748800288374988, 0.0007304399866323907, 2.4531953404016003, -0.529376989762716, 0.21712944832611777, 0.07400739237806463, 0.5757391093540761, 0.5946323742043995, -1.0642402877180603, 2.0983940162039447, 0.3874994059192659, -0.12933025147772556, -1.7412993950178441, -0.7262127406076148, -2.0090933975629324, -0.878260745390327},
    {-0.028322740723785406, -0.249112036396764, 0.2737164483507938, -1.6247062550941225, 0.20660564148015503, -0.4352452131669545, -0.032093402753581024, 0.5632854548091231, 0.46583730669121826, 2.967847313946265, -2.554543840137421, 1.2046867185321601, -2.1673875453473213, 2.090679504350211, -3.567539075454875, 0.2655837392636076},
    {-0.08681919290314367, 1.1939462800299958, 0.2118584509501936, -1.4993634432155136, 0.5811886586041731, 2.08409968763124, 1.4928973517264392, 1.0418287899411482, 0.23127647949118596, 3.1645618722512325, 0.5587278873563923, 1.8331634727607145, 0.16256247405843655, 1.382866913611677, -2.3837128996599435, 0.41494523997251664},
    {1.2093604147734454, 0.9318745019410739, 0.5471695237837881, -0.40404979977031025, -0.7279592085502182, 0.48974374777624663, 0.9485489560516841, 1.6199959540258426, 0.43143655749133974, 0.4081516993462629, 1.3371818966444793, 1.8683174618794076, -1.8162049275141847, 1.4996866985936508, -2.5065732385663915, -2.953352882263417},
    {-1.3357218990391695, 1.7801031765952524, 0.2721546648222928, -0.37446084274249103, -2.093666115185905, 0.03708614203154127, 0.6749441720381589, 0.22779101789978967, -1.0758461574379998, 2.653851870488726, 1.5489100213372198, 2.197304415892895, -0.0164162424977127, 1.2494857235848098, -4.4722140013995, -2.52148212633412},
    {-1.9060689969847058, 3.5144447870676156, 1.5946730119577817, -0.9442258844743289, 4.0086150392723745, 1.7550769214491253, 0.13534532897928667, 0.24774337564739454, -0.3790449763911521, 3.618932889018963, -0.34853252943735774, 1.4687380061567918, -4.328657899479052, 3.289036751552414, -4.499568138637792, -3.0154958464114},
    {0.3405938114557533, -0.9808840917785809, 1.782593845050489, 1.378060457427829, 3.967616669197306, 1.6561087770042047, 2.3964276466806, 2.1794699301448337, -1.5248001600619951, 2.3200666551657108, 0.6281500480260092, 2.958118958790745, -1.5694028289437192, 3.053895127583482, -4.728249033337894, -1.7408137289604184},
    {-1.7226454622745913, 1.944128686783309, 1.0622367128813872, 1.881214740181395, 3.9720772072630903, 3.9881728649464496, 1.5741144074561408, 2.0646749966229785, -1.7862643022714446, 2.781168864684416, 0.36210115011469873, 3.0737455034582606, -0.263184093396187, 2.7196856777844967, -2.5548650684327865, -0.849259684344033},
    {-1.7734541136251842, 3.824828858128721, 2.776758127721416, 0.03748602861225127, 1.445431143902733, 2.4388425469285515, 0.018406996616623112, 1.2840012347302512, -2.3613550818495717, 3.202629572480301, -0.14271275038970252, 0.2136405304544177, 0.015802799544506474, 0.9276217145007616, -4.414001009579936, -1.9694080973378711},
    {1.4659884489887978, 0.08157843684297314, 0.0444214302732025, -1.7383500600087816, 0.8933079874447241, 1.548104222873288, 0.5168164567968803, -0.6872921728682532, -0.16952593872436705, 2.145484232629344, -0.487168868477705, 0.008668577463068516, -2.7732257316375177, 1.9162031657637095, -2.6743704902240446, -2.3897402486846593},
    {-1.6253799772100699, -1.024568936842551, 0.7298590402233427, -2.360589386654243, 1.2713884637751012, 1.4981139247765658, -0.32593094657582533, 0.40089473331540093, -1.0305302272500543, 4.153253765679601, -0.9835212537462087, 0.35045126265874643, -2.223643370984592, 0.8167727773703738, -3.4845831491664754, -0.6821298302701105},
    {-2.5029948696589623, 2.1539466806546765, 2.23607259652137, -0.33610887960519514, 2.4151633792246967, 1.3614962393420758, 1.6173048043669493, 2.5487681691435924, -2.527887125749725, 4.364544793010719, 0.659264184793179, 1.8369098651601947, 0.9179400297533216, 1.3689777035404944, -1.6571017044324907, -2.2847591234441778},
    {-0.9471226109709241, 1.5560900135464333, 1.4122004243739756, -0.3215847866302487, 1.8798873801659395, 2.8412784100778925, 0.6915424413939464, 2.1290338832626228, -2.412959598278686, 3.4463630452131877, 1.1098263566724915, 2.8434291328925188, -1.1588858550795702, 2.6299161852608113, -2.5889642245409275, -2.6327256278228646},
    {-0.07631334473283448, 2.812647910738978, 0.7593081053488283, -1.7785971350761411, 1.9263253120036583, 1.5710605018431358, 0.9260538805230922, 1.1715412890395387, -0.8631038310925002, 3.4216218874211184, 0.21370326450530244, 1.1989852349896082, -1.3526659170929787, 1.2574959784769117, -4.251137806214722, -1.2794755684243089},
    {-2.279282885227223, 0.9466682332246336, 1.874997011158705, 0.558917697939029, 1.5060053697170737, 1.1194990680884898, 1.6329093041164089, 1.9566646954202955, -1.8858570378084145, 1.449479071933882, -0.8490525072296778, 1.8165115029003915, -3.7479549125159917, 0.6846917593081844, -3.4930246792346153, -1.0657109795812574},
    {-1.0833940540034874, 1.5384760175782703, 1.867970840867676, -0.5372512895189503, 4.234887371776718, 0.7428817065850299, 1.0189996748168095, 1.4221573168187924, -1.5621500110609914, 3.343141162633033, 0.5129126550436226, 1.7301438122485617, -1.6704926633894153, 0.6453693726785922, -3.4438834375973446, -2.5711714833032353},
    {-2.5283302282940197, 1.8059388449490819, 1.3120336018026837, 0.8555943483805037, 1.1623071428357026, 2.247077217037355, 0.05738741437894256, 1.813491520422051, -1.1043677053017218, 4.018972998277407, -1.545543729163878, 1.1828951725458015, -2.461551365343723, 1.1288499973045918, -4.528166854476667, -0.8205074321699692},
    {-0.4531929246946211, 2.362370053042618, 2.583172021809882, -0.7231829029412431, 1.4608489338282382, 2.0978912806020595, 0.8514301193769053, 1.5152615986117821, -1.6914854793155252, 3.1159819082308284, 0.9908275002136091, 1.5447425211365267, -0.6424700806261046, 1.499622078795663, -3.1448166116624745, -2.709783297636886},
    {-0.9641856748134581, 0.5135234345429577, 1.2053297366423217, 0.09288703440126601, 1.655071805272977, 1.8722839218445324, 1.176911193856086, 2.347279154044242, -0.34574011333458476, 3.084185484805664, 1.4051256047622802, 2.3384233293768433, -0.47451766442042964, 2.7022073483482068, -3.610433738211836, -0.4394348324394291},
    {-1.6624596878530147, 2.8792555693940307, 2.033942726732669, 0.37775045164918003, 3.215349083449303, 3.9615949219928672, 0.816496874714046, 2.4561876230269646, -2.593155965854958, 3.4011829254711157, 1.9197165198578394, 3.8777595262305296, -0.9705281116783327, 1.0054043858915436, -5.524916363683616, -3.9422057899625536},
    {-2.354138682537763, 1.1250039958083846, 2.30371315633257, -0.00405748317916197, 4.410223983194829, 4.100880718835252, 1.4236250853538293, 1.0022469472517552, -2.2699367391459124, 3.4577771537760498, 0.34628976170160025, 0.6821132446047677, -0.29460360479926995, 2.7305123368803517, -4.919468286326549, -2.896859366217874},
    {-2.9738253117380444, 2.2396580197439198, 2.8731619109363264, -0.5854686689534204, 2.5833069574810748, 2.7422624190469223, 2.6003853585732393, 1.5316526484286928, -4.106084618869489, 3.668154551287405, 2.4088224313888835, 1.188791445838467, -4.0555110298768, 1.84508332309159, -1.467501018785658, 0.21518575176990773},
    {-0.20293897596034147, 0.801828802038713, 2.0244532009333582, -0.7329427428253027, 2.217904444966171, 1.2231368740277702, 0.5948156084629774, 1.2701496585157181, -1.0633692221993138, 4.058231014266206, 0.49491574788537157, 0.9337968475303581, -3.0791627043947263, 2.3244181882623356, -4.707556928900185, -1.08697172538501},
    {-1.5488927060331286, 1.2467589390686906, 1.3154886623555484, -0.6459831934344109, 2.9808413846724853, 1.4284125935549243, 1.8377325654218006, -0.4224688996681317, -2.93676472935817, 4.0146742062389205, -0.7031794941674738, 2.153376015276636, -1.3661645210832907, 1.2715058058030726, -2.826348257952122, -2.818324119785879},
    {-1.10164749304937, 1.415762383182336, 1.0101353244301898, -1.4014415988493851, 0.4291307695087757, 1.481550563715414, 1.7297083376142859, 1.8100163479409763, -1.1124017030725062, 3.3333109819098525, -0.23991639654869973, 2.1007300183423054, -3.067257766458882, 1.0243867651073109, -1.6369707982757604, -2.2540718254294627},
    {-1.449142044128625, 2.4223128476712907, 1.09315894123608, -0.4873056080101893, 1.0942899838322286, 2.5732153363247194, 1.6144990194250708, 3.548801207005969, -1.5490773406193388, 1.4191693515843136, -1.107709664080539, 1.5342280996965418, -1.3892179977678794, 0.027035133493634973, -4.809528731822879, -1.0836480348172524},
    {-3.0007665998906488, 0.41928536614288126, 2.6814377154151474, -0.7218436351345051, 3.0870832054934456, 1.0277363010045737, 1.7848094251136326, 0.7282692265855992, -1.6873674517702668, 2.35190752241635, -0.7324110184153035, 0.8066664604283357, -2.3375596396311726, 2.500280879733573, -3.641961048867799, -2.8665515205410332},
    {-1.9120493370886622, 1.321782847249414, 3.5098569380362874, -1.8401766661681591, 2.187409656450399, 1.5879605813058182, 2.175822217621915, 2.2015954005156537, -2.4477753524060297, 4.271541035354541, 1.4170803962798713, 3.941739693982024, -2.330502862063877, 2.344964798330008, -4.691086945130947, -1.9809624069951062},
    {-1.1935221254021329, 0.6035001850294691, 0.2923932265843805, -0.7683916921356229, 4.185720670833159, 3.0341907418985565, 2.5030067958484414, 2.405942472244848, -3.5714496117514245, 5.479211779917541, 0.6973773717775391, 2.8305163375873885, -1.275697534394791, 1.9672898176031604, -5.059956903322479, -3.3086921565309204},
    {0.3446819441063481, -2.4972956355203197, -2.1088167508783693, -0.3823596527729625, -5.579671727298455, -1.2275060162595255, 0.22102326860926208, 0.14818424530284316, -1.4709659563031556, 1.4069523027901185, -1.0032405281704813, -1.9785144142869124, -1.0147878572586566, -1.1543588938892733, -1.553526938129321, -0.5627785575220953},
    {2.7320666495775074, 1.1403918255341159, -0.6451508637624462, 1.5760027168205708, 2.113002366922568, 3.267826639645147, -0.5139297071892397, -0.20555094000955026, -0.0507733568839623, 3.2192164046024785, 0.6841539462451859, -0.16564855833892186, -0.17824418308552775, 0.8828933441519367, -0.7511721033875871, 1.93433900514239},
    {-1.4284653509496223, -1.1693634759259157, -0.934575883772666, -1.6539520335368916, -0.5755732272000582, -1.4954245618173858, -0.06766916903832246, -0.737850547191704, 1.9329302775596195, 0.2096446974563861, -2.3715648216456064, -1.6673208507367818, -1.4822253032905666, -2.313056197773734, 0.4996753116895972, -0.6360964323956583},
    {-1.1799664922882591, 0.12153046835093154, -0.09742114811866684, -3.0470331615135193, -1.7973305145110334, -0.8089814671628531, -0.5637728939436534, 0.12301617609682687, 0.31442115355906786, -0.3596574264018473, -1.743145203490744, -2.211777387834153, -2.709784674493323, -4.351586207788794, -0.41943306407798586, -0.05316210148824837},
    {-0.36349563648319577, -2.8992841377914242, -1.2442788082952392, -1.7706810103297643, -3.187945567703273, -1.111399690303232, -2.333377186359801, 0.14621018282043485, -0.3038981972866039, 0.22001038184220267, -2.4574557924905127, -2.9021702812519825, -2.113770353329071, -3.5924085501481455, -1.8907358168539856, -0.9533613019901964},
    {0.15357127165420714, -0.9728817703747501, 0.8199674220727495, -1.1415381589178246, -4.643748624480298, -1.2641195063556765, -0.7420164523370424, 0.6494398257373594, -1.0181279251108888, -0.3209287299945925, -2.4821457248404903, -3.2986663284026165, -1.0268730133885706, -3.464668810713077, -1.16424940912427, 0.921122208765263},
    {1.3954792163110512, -1.2386108189496094, -0.33874466269780096, -1.2270351960666668, -1.768876665048302, -2.0352987690959754, -1.3025374320476346, -2.5420717688954846, 0.3684950432459293, -1.0609000619701543, -2.0610444676317536, -1.9249834062071733, -0.8260726532826038, -1.0691255670000928, 0.38792533118855355, -1.2510773589106332},
    {1.027452951829639, -2.66799726628776, -0.2353572806432915, -2.7958376951300736, -2.3523509781076086, -0.6375153880715134, -0.5234230224296285, -3.2012248226452433, 1.1275552522225802, 1.1134926198694581, -2.3818487928327157, -3.3620725843075707, -1.1485010613366453, -2.725834590654289, -0.39398881195040053, -0.0793728133702641},
    {0.129414628328005, -3.2530036404809026, 0.6437227650078899, -2.93969439860298, -3.8474438591464066, -2.7392994110259, -0.9396810544191556, -3.017193724998737, -0.6314942488043894, 0.4373530685374716, -1.0306707798869221, -3.087024204441367, -1.5691119508175801, -0.7222211649156877, -1.251976734983684, 1.5506247524606598},
    {0.5177665296204201, -2.2930247230104492, -2.077169359525985, -2.463612501599978, -3.367078585100731, -1.7826394820472493, -2.128118465366512, -3.9228016408055635, 0.012893029362690838, -0.2884593007947837, -2.8540709922356675, -4.000092334074121, -2.199020535725083, -2.1316818971788623, -2.3404299306817875, -0.7511440631106927},
    {-1.4452681754614998, 0.3403692592695626, -0.12000999145517946, -1.1401679217456369, -0.641832535413615, -1.351965155487049, -0.25025477628251636, -0.8340590201784237, -2.31667104685227, 1.6770350178886861, -1.9706979017641697, -2.712227057470874, 0.4093782541823597, -1.5923373234499238, -1.0209394845971929, -0.39701473902069934},
    {0.10990095835541408, -1.3773682877449658, -0.9207996084050021, -3.5101248139669727, -2.7329477791239385, -0.9064609025763403, -2.1058403044227667, -0.8051227670669449, -0.13327200952643284, -1.4037326031253192, -3.4731099445967804, -3.037974524906577, -0.9583072930099177, -2.710941826446888, -1.8552759045403022, 1.4861218787919703},
    {-0.829168723148539, -1.250110694763415, 0.36657360717314447, -3.7426844580681666, -2.2701423170306345, -1.594072626442569, -1.6387417694281667, -2.920794974190935, 1.8777107266738777, -0.869777213877626, -0.5804252794356165, -4.18153834175868, -1.8427468370466618, -2.847058661561318, -0.5140978247328907, -1.2399803862672951},
    {0.8763446696416181, -1.5157435521409848, -0.8567350588293409, -0.9751272527967227, -4.389585514641728, -2.089573197687853, -1.0785255446562416, -1.6914330861277147, 1.4548811560057775, -1.2426367712058526, -1.0907094632821228, -2.771317355455035, -2.5217648275777584, -2.3501183534160512, -0.8363626140284529, 0.057594807271293784},
    {0.4622693813713644, -1.481443130993614, -0.19374992938521737, 0.18361901118500903, -2.7902528693796578, -1.778354069548828, -1.0572311324761803, -0.10498071986893225, 0.9816027108308615, -1.2072475264754512, -0.8753929248579898, -2.5284320791073824, -0.9767418427805987, -3.0065447211324905, -1.1990397952607754, 0.708300830885021},
    {-1.5185859300786622, -1.0833182021340637, -1.0098984088629672, -2.6277988114078084, -2.5535971974208054, -0.650421492318092, -1.0750107475559674, -0.517174412661001, 1.0172220787884405, 0.5617240731284254, -2.0769158051517964, -3.2853195488476663, -2.0549813994570245, -3.1989664303060006, -0.2158072151410859, 0.6221464567347421},
    {1.0783593961395959, -2.9864020273250804, -1.4265175524970428, -1.626841272031101, -1.7698828125940085, -1.4626455152454518, -2.416843996720438, -1.3655061461209972, -0.021286117368191027, -0.16877305209048954, -1.976855686707346, -3.8204644220214243, 0.09650920710407411, -2.2120656213054, 0.2724669498558839, 1.4898374395931442},
    {0.28236008972417675, 0.003192671262814827, -0.9715952974768358, -2.808527748862541, -2.9766991927369655, -0.9031866628361604, -1.3361846044587322, -2.4998606517946085, -0.24149670930961414, 0.2172988374478239, -0.3949612059628255, -1.9632707901066013, -1.9301882015404557, -1.5903551249526375, -2.2759671713085745, 0.06614992473911514},
    {0.29803260903884965, -0.32721481959500587, -2.128832430033312, -1.7407935150543565, -1.0930215534266865, -0.6832549228715729, 0.8542801909790287, 0.8927143329281336, -1.4480312325203986, -0.49118226548968913, -1.5320781936679764, -1.2025527488732248, -1.0903448270254734, -0.8710852323396334, -1.1280800763881733, -0.22775655526067162},
    {-2.024317804787714, -2.095850960531523, -0.6373123726052675, -1.898717997684839, -1.8282922123781973, -0.6334767002479375, -0.3116399166011014, -2.186652282019381, -1.2643197746346382, 0.5114439313366185, -4.055524165176702, -2.9156434184485254, -2.997119383716698, -4.380788866516008, -1.2556444406307528, -0.7204753440239285},
    {-1.3333099807641735, -1.3304677752337797, -1.2500816819086125, -0.7115777713196384, -2.562930398930108, -2.844246361924846, -1.738049707882045, -2.583310859006481, -1.39403740209437, -0.5416559047320836, -1.305865688616776, -3.9168259480001115, -2.2789597573076694, -2.799744102401871, -1.5892235129137497, -1.984286429225775},
    {-2.920163183693192, -0.31042353771516534, -1.7780890688689748, -4.284037999341765, -3.056472417384304, -0.15532819038653825, -1.7731586662457601, 0.25683760277189355, -0.35842708966238834, 2.193116253731822, -3.8449520817620377, -2.4245417277053707, -4.164212801070821, -2.8257243179861, -3.5406285084574196, 1.1485400678339022},
    {-0.5315287948590917, 2.083028877027541, -1.0861571274290878, -1.1036555005380213, -0.12773313298513883, -0.2652184187227029, -1.7569895113624168, -0.9277821687350667, 0.5997827838624386, 2.418465448771769, -1.1310494863760376, -4.171426347738355, -4.254377640741566, -1.6381366710408827, -2.468546634009043, 1.623857477453123},
    {-0.03805037667466491, -0.0312582025285056, -1.212200307782066, 0.035074602699831495, -0.6907802597392876, 1.4837882819346762, -0.43473145950191633, 0.38302321968080805, 0.8225355107864255, 0.5167867827032127, -2.404222114726582, -3.8535600944753376, -3.201297178990139, -3.9978851821279444, -2.5343220042408543, 1.577374553648967},
    {0.5885606332556715, -1.092245897763444, -1.6347161736020377, -2.761302480499023, -3.841053583439002, -1.8818042270389883, -2.74073608726875, 0.1477772599379023, -1.2412169256576242, -0.20149670268697864, -2.8373042599573877, -4.809461905719448, -3.4792137438794035, -4.094998513167971, -1.9140317159052616, -0.5628797822866923},
    {-1.0803216382421197, -0.19515675055749812, -2.3684171878312053, -0.9876292298983845, -2.568888690418919, 0.03125380692726909, -0.5352973050003262, -0.03562641225347511, -1.0244059289348937, 1.91981934701351, -3.0491217481280986, -2.6894589728586027, -1.789270019357015, -1.129262662566268, -1.2862107312631008, 2.3826612451849454},
    {-0.7356376187202597, -1.4131748296414752, -1.3072755614829117, -1.6959443634662132, -2.310716017562226, -2.192410192028026, -4.417336056722214, -0.1292721838743499, 0.8962274277857217, -0.18315949337001117, -3.1363467938710623, -7.08050810137362, -0.9501846344036894, -1.699062850317568, -0.4562806926024054, 1.0206939813458356},
    {-1.4804500707954045, -1.9630960348363142, -2.1071746469002237, -3.2375391099972726, -3.4830462862347638, -0.8603618638872645, -1.6644030365978737, -0.3215022618557709, -0.10837404381606267, -0.160026363802675, -2.94275510928742, -2.585749725744586, -1.8005624578364694, -3.4998545681389466, -3.18551269619952, 0.30189102874507895},
    {-1.3106707105336017, 0.19220983087785506, -1.809648561160667, -3.37293807902846, -1.6620950408650228, 0.08608080190179301, -2.5951270675474336, -0.751118204308504, 2.3542888142144807, 0.34473653548160527, -1.9944527864780017, -4.5793717438615715, -3.417042011993126, -2.3333489422027025, -0.5271270958188203, 1.103522583845521},
    {-0.36390270417586384, 1.1668856487703299, -2.0125171187757513, -2.4292875104338325, -4.0662199300922035, -2.453759846201473, -2.4066997079993846, 0.0994785383996643, 0.8965023682412769, 0.8449330915374196, -2.3375610618772398, -2.2235605315313327, -3.689012605671066, -2.98201135154398, -0.42430230211800773, -0.24507088569784846}
};

static const float b1[16] = {6.815063011823659, 6.8745737287712485, 3.4970624539342676, 7.066065160718381, 7.358515770104287, 6.370160867277346, 3.311943461619947, 6.531600415352881, 7.268404552229942, 6.194636320749749, 7.252521765058935, 7.09943350751755, 7.4897982599332265, 7.082310062455314, 7.019548648353751, 5.252505862821626};

static const float w2[16][12] = {
    {-2.601674725090578, -3.467697755318185, -3.418531111658304, -3.273736944750725, -3.9904415531678263, -3.7278682134832906, -3.7530000710579112, -2.983381485611268, -4.026943841934329, -3.358245172669829, -4.145936378567229, -2.150901843016421},
    {-4.615253779512876, -4.258801391789082, -4.2356962899880095, -4.906265775854471, -3.932042045860338, -3.1197512225025723, -3.6939417875274674, -3.6731650407252863, -3.4607581215641585, -5.372241888412894, -3.8834741157272683, -2.3849174173100067},
    {-3.4717881779665984, -2.697993591071445, -2.797129376273489, -3.3935455969791266, -2.283245166989922, -2.4360460312768057, -0.4911662789057338, -1.851570241697219, -4.143318647950899, -1.418209618304751, -2.5966283680913027, -1.1427479194165784},
    {-3.621394081834286, -4.2522006110903865, -3.887689897874818, -3.5497433129049303, -3.232834219423953, -3.477898310546724, -3.8429813900568948, -3.831068088643548, -3.1320626858755833, -4.924262377905695, -3.4555456555759334, -4.319461475853103},
    {-3.604251234395616, -3.709198252560415, -4.302838165378303, -2.1617740175987126, -4.64522709853242, -4.321710241514049, -4.874332774724452, -4.273193093070536, -4.250513863486845, -4.4038919316131535, -4.865633909073883, -3.685528420896494},
    {-3.838825696884924, -3.803650484673648, -2.1854845278896526, -4.092449955569731, -3.747422467339955, -3.715259083137363, -2.4915341457893874, -3.604562796187121, -3.516933733426773, -4.215814224448896, -4.627213669761909, -3.990771113907668},
    {-2.601017612705261, -3.801706754095312, -1.71891812882405, -4.051980589321749, -2.308259809216926, -4.302792447754444, -3.5857213623985267, -0.8653104270294614, -0.919913987898389, -3.2446350719354013, -1.616248935514987, -3.006940276273145},
    {-2.710634746021612, -4.119743381406214, -4.508466219284608, -3.7590095798547916, -4.359956581993825, -2.8403807950399327, -4.042914628608247, -2.89620646259243, -4.608625533357139, -2.8828778192520996, -3.1044719012545507, -4.390792191582361},
    {-4.294041356766065, -3.51995314468449, -3.257856687621643, -4.241323367214212, -4.654042530142729, -3.6128622487890207, -2.9397967844867283, -3.618096636354037, -2.7261849842826957, -3.4097776180080897, -3.0290364311642257, -4.683321377405075},
    {-3.3953519585064638, -2.9517187557544666, -3.8710735545121606, -3.4450595775681108, -3.0191027017569505, -3.838718058562153, -3.90050469686866, -4.7581227605097265, -2.385382759505976, -2.761224371864781, -2.516575700104861, -3.7982864847658844},
    {-2.9737708131345175, -2.8854093737221262, -4.673894413054359, -3.9205064619227756, -3.5866248894310253, -4.191653871961823, -4.382942108833689, -4.730269028276132, -5.051033895649289, -3.738535617913483, -5.199635871538934, -4.672537219639684},
    {-5.23283928027756, -3.1042750803416035, -4.005036701140387, -3.065084497692575, -2.9683909575873657, -3.6745658495843307, -2.7506771023187806, -4.751830723731344, -4.141243211560255, -3.0766890289545112, -4.689003958734516, -3.683909384642916},
    {-4.444633229287829, -3.510332863974211, -3.4424736605162614, -3.9054844623032867, -4.417292060026206, -5.547574978715429, -4.335762936112292, -3.933685668861668, -4.1945004310309635, -2.7889826985530166, -3.1882724342381032, -3.2983328097373135},
    {-3.30609285677245, -4.720534658434128, -3.313929257447091, -4.35369144997042, -4.539968462856257, -3.3281591915000885, -4.83857945277874, -3.2815315221176364, -3.8689460608488635, -4.0740391873540895, -2.794038414145213, -4.438893266493189},
    {-3.7345732418354616, -5.108531544703605, -4.292283735761962, -4.847479432867695, -4.0800532995749235, -3.0506968477834673, -3.835536262480106, -4.404217708758976, -4.676940097949336, -3.820158064332915, -4.090112739178819, -4.096676201681277},
    {-4.027986800635427, -1.6993419139378185, -2.894697428833467, -1.693953008546514, -2.536551553405236, -3.3263780600743726, -3.344612897367687, -3.045262340335063, -1.996697803685038, -4.239584458553841, -3.446073191403122, -2.972558467232888}
};

static const float b2[12] = {-4.637170004967447, -3.692523344879176, -4.056588351055257, -4.141628172575577, -4.205799900039626, -3.562402883244178, -3.807539691643416, -4.291085955615732, -3.555401875940027, -4.32837961298853, -3.5703819986300975, -3.8787827316720005};

    // Input Layer 
    float z1[16];
    for (int i = 0; i < 16; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Output Layer
    float z2[12];
    for (int k = 0; k < 12; k++)
    {
        z2[k] = b2[k];
        for (int j = 0; j < 16; j++)
        {
            z2[k] += z1[j] * w2[j][k];
        }
    }
    softmax(z2, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
