#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][16] = {
    {1.452202727090902, 0.07843726903239258, 0.231749592942503, -0.5791869105682109, 1.6119681191738102, -0.08284339302375372, -0.32721106053999627, 1.605917797000561, 1.3449195259925357, 1.2024412519309027, 2.214151047944785, 0.9960893949982439, 0.21803121255486804, -3.447447657118007, 1.774268026560927, 0.8194669590764595},
    {-4.1579268114229, 1.179665280243036, 2.8743543145447332, 3.5085306833639995, -2.0033509185262646, -1.4662731360609698, 2.895139166929591, 2.286081184239327, 2.2246527442734565, 1.9983654221982043, 1.611452498586949, -1.1727663704069256, 2.4625989120456087, 4.829680085354398, -0.15871137221561352, 4.65905551995134},
    {2.372121954822922, 1.8346228498116384, 1.4667371245471652, 1.4683107590738085, -0.566055190884278, -0.9256218068321702, 3.737481418315103, 1.3700998123653876, 1.3320027587252745, -0.36880408106309, 1.706480485585454, -2.1735587787855497, 2.585399747696098, 2.3588468755769068, 1.3924212149530906, 1.3334630377418606},
    {3.921523916875102, -1.6353838653861492, -2.069553200306757, -4.2195619959445425, 0.852158485865244, -2.959601112436906, -1.772706806193722, -2.5527273691817483, -3.6667806600928805, -3.937115253329047, -3.4299362497955435, -1.083669421200429, -0.4658219252501672, -1.947238159540455, 1.2007636729579856, -2.906759950186186},
    {2.949682200562904, 1.0429912750684227, 1.846749842857717, -2.0521221220239667, -0.7585326571531814, 1.254965467172979, 0.032073675057962776, -2.4197458731463826, -0.47846561286700634, -1.6435483866273044, -2.206349313036233, -1.6897350589439406, -0.11018047039814347, 0.2601111736178126, -2.9477662717571986, -2.11633453004482},
    {1.2631602942383713, 1.1583036676221583, -0.6456806752007468, -1.8344017146863958, -1.7511959141436897, 1.739926597660578, 0.3373900627505606, 0.26896905670517074, -0.563546563975107, 0.163670933686385, -0.9583903497452053, 0.05653061837377205, 1.4664135884109148, 3.3514842480730196, -1.980088267608982, -1.2562699932190802},
    {2.8477868768374424, -0.812977680617912, 0.2681676570079637, -0.5911059775299639, -2.580325984811109, 0.7257494127603523, 0.33154014016574207, -0.16257429386430788, -2.0989424925648743, -1.884355627260901, -0.7118150877888529, 1.13553707683515, 0.8649968130905255, 1.9431010404870706, -0.6614287922602066, -1.1175597429776145},
    {-2.2515690968972017, -1.1257139064402042, -0.5117099771408358, 0.30834748309003723, -2.8802150152648087, -1.3959416352785674, 0.22358507568215558, -1.576629605459001, -0.31292248716316756, -0.19121773523579272, -0.06635993675154647, 0.2146539901493307, 1.1283408112567042, 0.25071244822625516, -2.8540325387175636, 1.6395133133535633},
    {2.506827007706823, 1.0857148204012084, 2.47113807599951, 2.5040336771579903, -0.6884480008959939, 1.6242285210387941, 0.11883305434118495, 0.6356660516534662, 1.2737049902091173, 1.4127713530730646, 3.0439607651592206, 1.9115795759515242, 3.8711555174987122, 2.668105975854093, 1.2428391128549603, 2.8882906027606547},
    {-5.210437663937115, -2.5047552398193864, -0.08434952456818083, 0.9349335878593005, -1.1546925282297806, -1.5191971189522493, -3.323786718788566, -1.71185539169186, -0.11063733483365816, -2.3975806604851706, -2.9510336839443396, -0.02608447974230258, 0.9953348933924661, -1.2075463486159526, -3.004595831341452, -1.1710584907889794},
    {-2.4191500915520443, -4.416580265628849, -1.0526967478464107, -3.0693574335955933, -2.314989184125655, -1.541595782138213, -3.2907488281537556, -1.8918595203355586, -3.0435127166295852, -3.0941515569995075, -4.973183193091864, -1.464129536528371, -0.749210672361591, 0.02445807150104633, -2.9849285743521894, -2.3690824653669487},
    {1.1371040556137255, 0.14489213689743313, -0.6105665507110609, -0.023266351347941087, 3.315829246695121, 0.36581400030373923, -1.4083126662691112, 2.5046373005259466, 0.5975736703037808, 1.016700205375858, 1.461534735428598, 0.32069689304637133, -0.46534127388784924, -1.5116664489711396, 3.341490067454158, 0.7017167251800935},
    {-4.151953938071584, 2.4699016093016817, 3.4743967175537067, 3.7166503732800034, -3.6843610763698162, 0.2944666086453157, 3.206106741794577, 4.445607316392797, 2.4981672695649726, 3.080315150347666, 4.590968541574821, -2.6974265082108664, 0.3044527778027034, 2.9702809956896252, -2.511459576572746, 1.7436167899619928},
    {1.613577310433207, -4.274798132182499, -4.1938000352753635, -2.676316600990516, 0.9101786760314481, -1.7719903248857978, -4.526943535055681, -1.4022211031168226, -2.9979393190857735, -2.2642336163011025, -2.691127358003606, 1.6896465243470467, -4.030485071916834, -3.4524403510562465, 3.0530215109883794, -4.315807917552977},
    {4.4691349071324575, -0.137580498731985, -2.5716062533498745, -2.706277025568556, 1.370826927252531, 1.765798284137666, -1.366959490208494, 1.031745483463371, -2.8767942736238483, -1.590968155679503, -0.5066308566656939, 2.785932695565695, -2.491655601946073, -1.3908338589022395, 2.248008907196303, -1.405065115501217},
    {2.1397473244738667, 1.7209427732608213, -0.7440726535830272, 3.6654674357820416, -1.3577833351900033, 4.112906267460514, 1.7033790123321397, 2.81188796449907, 2.1840347970455944, 1.6526464470850661, 3.470152169910652, 1.4063222207362966, -0.5150839983891168, 2.0597603687287016, 1.1969796188103197, 2.9544786072873017},
    {3.371762341153558, -2.7845108569279526, -4.330033573492266, -3.355081338530598, 1.606091465337689, 0.11106369749000565, -4.629508730086302, -2.551410578116013, -4.743721897148856, -3.089686122381032, -4.339395067603876, 3.774317297038573, -1.5541511576694, -0.6889192370381075, 1.362683915300142, -2.728842603709945},
    {3.5583066393850546, -2.6228156811305388, -1.8794979720933067, -1.3184966403540352, 2.0431488552801, 0.8147009240768706, -4.222376230947012, 0.05565806724304088, -1.9643048452198717, -1.0124178980964367, -1.7034923976719065, 3.0357509795968767, -0.5295081569583138, -1.87346753253412, 2.655966926140509, -3.285824743162477},
    {2.234744653022252, -0.810875877110486, -0.3318206407772363, -0.7480355460799929, 2.026839378333873, -1.9280254944842996, 0.660146141051254, -0.2948903530358859, -2.312739332092685, -1.586508841469901, 1.5904167871589814, 1.519270458197286, 0.5632776335852497, -1.6023754153691276, 3.7651997970945326, -1.3475896221751555},
    {-0.3285964918079654, -2.496096095668946, -3.486912092469078, -3.6974323128824302, -0.4039019206898767, -2.283651302192684, -3.1734338757366642, -4.1780819014796196, -3.1851131718641845, -3.703734174556742, -2.595043104115564, -1.6663873135559935, -1.559752557273782, -2.6103676515269125, 1.7732774786276275, -3.769227812349983},
    {4.4017388671216935, -2.0862654993255987, -1.9138685478905177, -3.0564390952385967, 1.4531652128013752, -1.1540774134502658, -0.7802410691089728, -2.796247628232712, -2.837806726016612, -1.1576599249529425, -2.049613443578765, -0.16160792022802836, -1.3688209529063062, -1.6427760748350573, 2.033503310729721, -1.709683352885163},
    {1.9405815884957827, -5.6646089436843114, -4.893132348345118, -4.050637875201949, 0.5865108870473507, -2.2518692868666976, -4.640014870802911, -4.610417873033105, -4.689211589057441, -5.50995276846673, -4.742932818002933, 0.9673534778269502, -5.878518353438103, -3.981936570182809, 1.3442365385606303, -5.71320146215368},
    {2.3963804564230333, 0.138268645007165, -3.717936031375368, -2.47383144949141, 3.2903499463010353, -2.5645119118131796, 0.3764869739482537, -2.327165442309631, -2.3127662031042573, -1.4414770466005469, -2.013165402058997, 1.19875841890718, -3.329880717266052, -2.6091637612579817, 4.279982273483005, -1.0477911219191796},
    {-1.6509534294683186, -3.8292237349927722, -3.1402943762454716, -3.668170871182817, 1.2239353375871544, -4.10164260432977, -2.8414637191179297, -5.794878073394836, -4.856317237348883, -4.23545056667601, -4.734593709183903, -1.2635470658234211, -4.834393479133826, -3.4483037862945034, 0.17824529882291668, -4.054106713256063},
    {1.213321277049999, -2.7120665986316683, -4.484364930964136, -5.3112656217898255, 3.136588869041449, -3.278088497184234, -2.0028943501304637, -4.38907210613372, -3.4616703079300564, -4.98197209746027, -2.696530787854285, 0.9627780775077043, -3.306443315870978, -3.726937909074803, 4.1305268115896965, -4.564860813394374},
    {0.34658221214671064, -2.0761426002504937, -3.597939180861236, -3.939490400289772, 3.3333408525765313, -3.794571211358319, -1.1554224006516702, -4.263660706866536, -2.175561080113725, -4.155278332627807, -2.205417915510589, 0.5964161915350858, -3.5926563417001, -5.477462884361318, 1.4967034027717652, -4.3898616029508},
    {-0.16544891643525866, -2.2652494714145677, -5.086273732863773, -3.3351195194680274, 3.2879415475779044, -1.1001363755319815, -4.337669294634745, -4.436982125114462, -3.006021044244287, -2.5066802600292655, -4.3161733030417535, 1.1804827061208458, -3.92736557839169, -4.714338081435217, 0.8629920281507323, -3.395583445072516},
    {0.126919033885283, 0.531708243491261, -0.10847452321846963, -2.635742249504999, 0.2024894368793632, -2.9003587830449664, 1.8171385683177002, -2.437143671366998, -1.9034816070601248, -3.2374272139085605, -0.11647350809609414, -1.8064521102201383, -2.4600080263854815, -1.5636297199002505, 1.0361977756759553, -2.2895171415381714},
    {1.425386957160227, -4.664979489433807, -3.541971316242783, -4.469222192147719, 3.319317990994609, -2.3587179814087436, -4.782529502341672, -3.171147855808621, -4.728090764725391, -4.529173854699875, -5.54628674668207, -1.122951042491539, -3.356109646934594, -4.768994923989243, 1.583252850087753, -5.909204234873608},
    {3.2487470716916373, -0.20897473820130325, -2.67839839223433, -2.3370602796306303, 2.2912685414453375, -0.4515363577127665, -1.6450800538534283, -1.0364828970327469, -3.853951200827727, -1.7200185533520511, -0.9482855648889855, -0.34015005899539075, -2.5477434435488004, -2.955327141977028, 1.1923938681062756, -3.5663830403756274},
    {-0.8917141580982326, -6.100566209436841, -4.418826473197735, -4.102476395114679, 1.7181518076150186, -0.2130359549092244, -2.0700383385255594, -2.1507072142298296, -5.41335599501946, -3.4535486957054995, -1.2591816517031547, 1.901664582582441, -0.2263451245827752, -6.318383783529161, 2.346665076416976, -6.353418836957006},
    {2.5158679711205316, -4.689217830711276, -3.7249505261902676, -4.021082873236973, 1.4371927854343365, -0.49113530486470575, -0.5815096501115243, -3.0399453103951846, -3.653935207504547, -5.209113329288616, -1.1514691423966952, -0.6241167310112212, -0.25155745792100936, -4.5174531495385555, 2.6752945745665713, -4.492977234821908},
    {0.07459571095761475, -1.0630753026560251, -2.0112355680178253, -2.2656978415985356, 1.555775393573563, 1.3825071064977434, -2.0522586849110045, 0.5759948492936806, -0.4261734778746992, -2.106696006247645, 0.3799871275565389, 1.4401459055459718, 1.4940468695394102, -3.033826362083213, 2.1302098413124004, -2.4682747432505527},
    {-1.5362057520198462, -3.032465366219043, -1.8269047971715222, -0.8492239994333006, 2.4973443661049637, 0.738420589978094, 0.06713020950909364, -0.3660342693823445, -0.44703658298905236, -1.9286100411509501, 0.07019518638934313, 1.7642333652076787, 1.218593251118289, -4.334466331834229, 1.3324494908915332, -1.2939177984635954},
    {-1.5006230058363608, -2.7382545023015448, -3.035294207234095, -3.615925257005756, 2.1169675050452597, -0.06989699580645331, -2.1573183991399016, -0.6611766413033373, -0.7718100286566733, -0.8734498988332293, -0.18483293169369652, 2.000382210247941, -0.3486673244382907, -2.8862983611998323, 0.6496076382344053, -1.268658380726955},
    {0.9172409680242902, -1.1564390152769854, -1.733211107917259, -2.366627107285032, 1.7722050561060965, 0.832438292997619, -1.6663795147621019, -0.6342240665435035, -1.7463958375716666, -0.2093214823853434, -1.2020698905909886, 2.088508873556945, -1.586165425495812, -3.93280436950048, 2.0719919058374785, -1.4986346112942508},
    {0.8230657962056558, -1.0376694267737527, -1.1103302289647299, -1.4020255695268817, 2.6919038143942076, 0.496370462615706, 0.04270542263317864, 0.9830758072417682, -0.2881903779265946, -0.4407901848876599, -0.04925177879812087, 0.49827381004075055, 1.3883635628870927, -2.758989384844656, 0.6888595815216704, -1.5794109301565313},
    {0.12663020976039543, 0.13919449694330635, -0.5019703546849195, -1.7784327218018408, 2.4220039269214326, -2.2161384879723527, -0.2188179106169316, 0.31972772106755337, -0.4787250492928351, -0.917422679146968, -0.5603992995933843, 1.7600297493716497, -1.9290155738596988, -2.29885288887881, 2.7146424984684354, -0.08902292847529175},
    {-0.9053102287780581, 0.5391494652182448, -0.8122023363154627, -0.8504929697261935, -1.2035621884712242, 0.1934513302737403, -1.1671988415630457, -2.8786855522568082, -2.462715739869598, -0.6932268055139235, 1.441647711736828, -1.8509774133318517, -2.8356533993112056, -2.198445624819936, -1.4730257922647225, -1.1343778809393785},
    {0.7040135940682276, 0.34793156551434284, -1.3857535526634577, -0.14203451228382774, -0.24573156893775278, -0.9926121650105246, -0.1301049259589759, -2.154557061491484, -0.9894442829436272, -0.8817792018593535, 0.40144241023894905, -1.4557077437299717, -1.2721927732369125, -1.6041736706675929, 0.3275973664942545, -2.868501499388443},
    {-0.3599649283579875, -0.780629360002092, -0.18489365444336278, 0.7412021895798938, 2.4838543667077486, 0.20411569210471933, -0.5862263862992771, 0.16942016328246462, 0.8273209267165129, 1.6610294826661474, -0.5752507759182584, 0.8670961135485605, 0.32677101286449356, 0.36046374638066186, 1.6427192161675048, 1.8005624653337755},
    {-3.6772981506470424, -2.1160108180585993, -1.8165907587679846, -2.990288593452867, -0.36432498731490387, -1.6390870903586907, 1.4504957000470153, -1.1450968759896538, 0.2747858837152636, -0.0017211800160658408, 0.252367996626626, -0.19273928731365705, 0.9678647162474021, 1.627364987026168, 0.24757236670262264, 0.39064504038029585},
    {-0.04849383187457821, -0.6254132296924209, -0.0881583113054295, -1.245161384853882, 0.16998160480456623, -1.8643060941329326, 0.23619478993707704, -0.012762220229021197, -0.7463986983917614, -3.0950960239216805, -1.456452793366262, -0.45035087017993647, -0.6514407209658529, -0.36768443341685964, -0.8187757123594607, -0.7238375904770109},
    {-0.6364772796860904, 1.1171921304602492, 1.3379952692549852, 1.2974741088195358, 0.7913372875878847, -0.9786412255952668, 2.02776697019273, 0.7000591733768551, -0.7752742092120142, 1.5144286238813096, 2.1853807014649322, 0.0937554793147248, -0.6914071730361894, 0.5186675133737946, 0.2002043640654172, 0.9374341910262333},
    {-0.3165864047050564, -2.4774783144600203, 2.4276902904116096, 1.258710925937016, 1.971299669502838, -2.542205317710775, -0.08087123622419805, -0.6156782302717048, -1.0924720120897948, -0.5668131654381706, -1.5557448094144848, 1.2741215127712389, 1.0957202683991576, 0.5640405717398922, 0.8639556468456223, -0.9177288473725698},
    {1.3465710636234232, -0.32994393636434977, -0.44358767303588087, -0.5496199327830481, 2.633954694150617, -1.1187697028345367, -2.380897647527366, -2.574741892380212, -1.3250243952569152, -2.3198690953898353, 0.7868231286160394, 2.132987527930866, -0.2985463481475055, -1.80162872102058, 1.9488292844479822, -0.10764591673645942},
    {-0.8637455708118112, 1.665714198480787, -1.0766281635906823, -0.43665290798337253, 1.8064008052460807, -0.1562972119128947, -1.6123893459029577, -1.1268729808316593, 0.9439860906321609, 0.8118166253261417, 1.4280252714703892, 2.5845715350673943, 0.5759662590927852, -1.2720710388264451, 0.5304290953833408, 2.1955587623493282},
    {-1.696016845493789, 0.7407676095172447, -0.30550083811350304, -1.7676232977023232, 1.476632506594374, -2.4074462490768047, -1.3863742213992831, -1.9137468472781833, 0.10944951107379597, -2.243786094297609, -0.2237380993921086, 2.025071121776181, -0.16799773611165822, -3.623180629410575, 2.9426937385877623, -0.3524835574475083},
    {-1.7552491114720523, -1.201301747464599, -0.22897254242516202, -0.4607836087713018, 0.143100841770088, -2.581724524979944, 1.4770583699249868, -1.8155873890696514, -1.7151546225772194, -2.0574745228374427, 0.6504114865970526, 0.5397710824054921, -0.7155411118250604, -0.1255368000867084, 1.5635275522940608, -1.3144919886275288},
    {-0.33316707058432754, 1.809314900788756, 2.294324670366546, 0.04890186840317272, -1.0497740352000322, -1.7206725325440335, -0.42709152935141287, 1.004827191350184, -0.5060886463883345, -1.1260544551549547, 1.0487224001121922, -2.5000824948739324, 1.8716810262291848, 0.21894212900295842, 1.163947352872363, -0.4912420079994206},
    {0.7038757297844843, 0.6067101879654925, 0.5038746573093983, 0.4816600453932382, -1.8363686596830084, -0.8449726959019206, 1.1774489917793254, 0.26310157459357997, 0.4088866910448055, -0.7146026365233922, 1.3904767882731122, -0.7269826144935736, 1.2781686716074607, 0.19090671238804496, 0.7656545482079493, 1.796171022989267},
    {0.3067519872472087, 1.2466583267945646, 1.34124777321876, -0.09322850130190091, -0.8269319687037984, 2.0939487596945763, 2.4828059214890263, 0.9440145895253336, 1.057034105611422, -0.8315587545736651, 0.541880621250988, -1.0331989967037534, 1.2563886675656348, 3.251110363643068, 0.5234773926793678, 0.69403304930047},
    {-1.6340471509118928, -1.6663641267028142, 0.7653892996710195, -0.3669674854164136, 0.1219423012899563, 0.5325137940355519, -0.7023514130669515, -1.3230310431325856, 0.8841115381224476, -1.9731943258907794, -0.06733129390487654, 1.4763888060561376, 0.9703665068844899, -0.8747442777418215, -1.1427833406269017, 0.9669245981983139},
    {0.9842866023410229, 0.5221568865938448, 0.5762343165756031, -0.04032252945552502, 1.974387510317979, -1.0139505985711652, -1.2665637000254304, 1.138404759920563, -1.8484196388554965, 0.6263482304575225, -1.015706998718339, 2.1949279456983235, -1.1448092785866244, -0.6644693308801687, 2.2230582520596194, -1.7439401893264972},
    {2.574151558198115, -0.1109256743627713, -0.624982281532266, 1.3301324449257417, 0.1492970065288078, -0.4983815391654914, -0.8448393114731584, 0.8993298638149504, -0.16829704378770863, 1.15704030001241, -0.40505748983811435, 0.7839247115341996, -1.5487128404963026, -2.74981243708281, 1.7209408414451022, -1.7140355309497857},
    {-0.06505526355268493, -1.7868004418373111, -1.2409781912357523, -1.491209030548518, -1.5821773511830088, -1.7673405506363091, 0.34501092951719686, -2.145436455938887, -2.080349977831595, -1.2480651671472167, -3.0311947943068067, -1.2376438415981865, -1.4507773931136596, -0.36411571737895365, -0.0426902814035695, -1.9520599023871559},
    {1.1510474616390856, -0.5927351798439013, -2.1080582283056857, -1.988496202297422, 0.9852365899715722, -0.18920510611117228, -2.7778100673322976, 0.9823552880206939, 0.859099327253081, -0.46889470939530437, 0.13548816124347482, 0.14026549750905334, 0.6832840871403487, -1.7262343419151678, 0.07998833686821391, 0.33872670948848066},
    {-0.1527179588424038, 1.205651068265421, -0.9411061891976048, -0.6444754250779882, 0.4610743027233391, 0.45925082961736496, -0.5334454142804307, -0.26744362551972256, -0.34869728231737, 0.4630913792042233, -1.0608409409514359, 0.0705368595583871, -1.2978581607189392, 0.01869841537734144, 1.992749503324221, 0.6792266711484433},
    {0.28931654808750484, -0.45970143990685797, 1.0991458646662595, -0.46843202527364497, 4.153667024104954, -1.2912437369604244, -1.5290468911243755, 0.6086729285632803, -0.4857950123803056, 0.996792552748519, -0.47137477724245835, 3.2816616429324417, -0.9463404043689195, -2.0396664489852117, 3.009929346681155, 1.2476967746293772},
    {0.8515359956303785, -0.7881671939910146, -0.23197102053616175, -0.5538808290572325, 1.8736267099243025, -0.19384375293381237, -1.3398065919158786, 0.9545718978124975, 1.1107071253378182, 1.556586437230226, 0.3354051566292505, -1.1940741950409073, 0.6266689933179547, 0.4112470855209213, 0.7971134443253555, 1.2930254905305667},
    {1.594390546886148, 1.4993796408271485, -1.1591239342372233, 1.5103054293023872, 0.11453005401615199, 0.6363999232696418, 0.32841250912466946, 1.3103498745822348, 1.920599674516457, 2.651447030631666, -1.2810119193853235, 0.9527884752267851, 1.5839521734244064, 1.6040610891251361, -0.20730728288602765, 1.1785819175627348},
    {-0.31621137535616506, -0.06930571103199962, -0.825549454675031, 1.005616905951217, -2.975814107729556, 0.7578797464119615, 1.038455433721029, -0.08174333419881383, -0.12886212461597285, -0.4724883553895043, -1.0283778592305006, -2.087726484963283, -1.8962473292058146, -1.3579965396124443, -2.861047100549284, -0.6390325864712381},
    {-1.770311529214023, -2.1140314017863586, -1.775001437270261, 0.4602834153197656, -1.8222478945345084, 1.0499339693633425, 0.08334088307023907, -1.051825680188257, -0.15062334579887413, 0.6431313385761819, 0.9016735467437739, -1.7476059839743232, -1.0398511827279007, -1.4515783843151138, -1.2234379216622107, -0.15998272393594745},
    {-0.6222112139974254, -1.404846233268095, 0.7951009408469621, -0.026718388902705, 1.3532504278862376, 0.42565325988554487, 1.0636102632002913, -1.3029026788281077, -0.4346327963736124, -1.8237171061397652, -0.41309284532987967, 1.2479536125967, -0.20516406576423035, -0.8341779746723644, 1.078355335270527, -0.582834362952191},
    {-0.43789597486388865, 0.36050468831375615, 1.3941597085654716, -0.055673837933709655, -1.3015511205388004, -1.3898731954991854, -0.5723850341893728, -0.3962633025985346, -1.2870957091333721, -1.7970805959133644, 1.413438308199718, -0.6703192747253384, 0.4556165390710272, -0.464792798299028, -0.4511571598064749, -1.1583501767411042},
    {2.323636799448962, 1.5524553200808395, 1.6743132684164785, 1.0024811233172575, 0.4632042318814966, -0.05227701841688961, -1.019675758595493, 0.5654520668583212, -0.09611921741497322, -0.009903632628855122, 1.5059129749591564, -1.4167978603236755, 0.8882153584025858, 0.24588771876770596, 1.2358720308565976, -0.4599195903663964},
    {1.305605269596068, 1.0126211817725341, 1.161274360991603, -0.05151848994798622, 1.8659142014432828, -1.154217882180371, 1.1998364582559864, -0.15147208149576571, -0.2914323625235102, -0.8837102376809093, -0.055089673529589434, 1.4818448152343748, 0.8098825256999463, 0.21022960006131972, 2.628503545022031, -0.03125204871143945},
    {-1.1308144263631281, 0.4217989891199761, -1.1302885187739387, -1.043386232402512, 0.9169362023964093, -2.393074192667836, 0.1928168405335549, -0.9680263393786503, -0.9867577557741146, -0.6393797222600915, 1.0288022829936028, 0.7633462842785831, 0.6594472951324989, 0.37315000865415676, -0.5359553725089613, 0.7868068309150769},
    {1.5986793809690876, 1.3151512106454353, 2.661520541330514, 1.3230959733953864, 0.6749013366303027, 0.5424169364303574, 0.001697920148243238, -1.0426260105831755, -0.35572939909682494, -1.5777890267646282, -0.21973402246381082, 1.803338386224103, -0.42233355380266935, 1.351446663653864, -0.42727804420002224, 1.2652760287675415},
    {-0.023273973110305952, -0.5271817957157627, 2.0248556816407284, -0.2664497477633469, 0.6715750834396557, -0.133104145769512, -0.7089980309627065, 1.387660407908612, -1.015408117910285, -1.3555680369851226, 1.0120045009884204, 0.7918271945707197, 0.40193015401733684, 0.5676276173162953, 0.20600855941963872, -1.250008471722893},
    {-0.26425638612624475, 0.3239006754097183, -1.5311219282874098, -0.1601555002155598, -1.4437689883021725, 2.0267314997950665, 0.38190037957380785, -0.41960388335188786, -0.17547810666585287, 0.018040164868253224, 0.16922641530140956, -0.7830811147727094, 1.7044508154398612, 0.48719679396314386, -1.0208073886750737, -0.026501627968467122},
    {1.4662628181971524, -0.00942672454613703, -0.8954895532390975, 0.265208731949433, -1.078060640893779, -0.30959452173811025, 0.6569786553898468, -0.20728549651091227, 0.9283107745384866, 0.17023197148005542, 1.328279855260872, -1.8604429351052325, 0.5672978574107417, -0.7766517156785833, -0.6612190075992893, 0.3968457027530132},
    {0.09936095312674958, 1.1492884146925693, 1.1398538515075136, -1.225895229883545, -0.9121903301286846, 1.4218303166611785, 0.868282293295585, 1.2162033168914521, -1.1089409181915024, -0.6131068315486768, 0.13662919896833625, -1.0991834777719904, -0.535622371516243, 0.047456526596181596, -0.9414774345050868, -0.19933166140419392},
    {-0.8445217221241788, -0.5530035014118282, 0.8113761582881037, -1.2840935789592416, 0.03802205665280679, 1.349836731589058, -1.3233923862572525, 1.1253447478650722, -0.11262285684168023, -0.27844150733256484, 2.0026751521400645, -0.31318002311784887, 1.4900168954152424, 1.3600625123229002, -1.2656317580746885, -0.5706931579031065},
    {0.33017357404646425, 0.6200547388437615, 0.1770680366153729, 1.4053463728952909, 0.054668096550048326, 0.640108845680737, -0.26156417947627386, 1.3078666086127642, 1.8178198429981718, 2.001745670342968, 1.5197255572186825, -0.910728253832512, 0.3920933325512439, 0.24327182358292757, 0.2513368221220445, 1.5989873699206734},
    {-1.6600199630445651, -0.3224855736674789, 0.8204208593883972, 0.28217594016130315, -1.5879330111585495, 0.3223259249992831, 1.9460493789063642, 0.01686271164777927, 0.39942547495434455, 0.5608962332542182, -1.159752433414777, 0.6446332638979392, -2.45970396161619, 0.8120344998008506, -2.321247088259101, 1.317531990775498},
    {-1.3390571124473514, 0.4426451096687738, 0.6670848881903285, -1.3088704928963828, -2.0192093039616896, -0.7605626014410325, 1.3879909522388598, -0.7580767327144531, -1.8588398266926773, -0.8642801266707518, -2.160257881041214, -1.5184057568274338, -0.722836128372664, 1.4705704011699956, -0.26243569890072677, -2.2939231220932768},
    {0.05948231307245403, -2.06379049524522, -1.3790079492374923, 0.7982527788293008, -1.1958333570905846, 1.8071747120907884, -1.9123522552503058, 0.9705549000843192, -1.7538343127286886, -0.4032879934018082, -1.6258091199426394, 1.1591497604682262, -0.9375723799223894, -0.9965348045327538, -1.4020943621274227, -2.9493159132486486},
    {1.3277748568667271, 1.3392516952057218, 0.06995619294968781, 0.6350359552808926, 0.6620662699307541, 0.14125521701666388, -0.24447134763779468, -0.8984077420055242, 0.3443015393306739, 0.8805267841319769, 0.68573788452307, 0.6883373810456445, -1.104493772108051, -2.0375007580505344, -0.12598065330955274, 0.15230435716829802},
    {0.40894608164366636, 1.5312724126490431, 0.20224767846483382, -1.6282191657992806, 0.778436029464884, -2.062879251674453, -1.484262808729158, -0.31451315493881804, 0.8391629291375768, -1.2616133100821012, 1.7557983661360426, 0.6727246682938586, 0.6297334445309534, -2.2798015237386666, 1.1395317160895577, 0.26854333154715954},
    {-1.530302439736869, -0.27720608119661205, -0.8214461115942251, -0.4098310315136377, -1.0842473280256995, -0.0514310420453232, 1.9393506110847316, -0.07358993897919863, 0.3201219579690342, 0.6028723617786599, 0.07583945896637871, -2.311988441616203, -1.7569353551225104, -0.3324161231509208, -1.6072360854696774, -0.07133814883464451},
    {-0.26739379328608803, -0.5161231589761384, -1.232628585931184, -1.446452424827379, -0.8710169725659682, -1.8275833119058225, -0.6625308310527845, -0.9043184929719383, 0.03869317510880503, -1.2803115579641515, -1.7017376063939929, 0.40773531807245916, 1.1803390241847669, 0.9765845885753839, -0.9157198818155687, 0.7658062925978549},
    {0.8722935437135452, 1.6085695963891302, 0.3795319454406839, -0.6812700322261285, 0.09426020921028717, 1.6444072837169639, -0.5558451175553044, 0.1182704132902288, 0.9594023514741531, 0.6133680288040073, 1.1377875626636134, -1.5211122454729904, -0.2377224084140256, 0.5023414872382361, 0.41595182093172434, -0.9773880439204231},
    {2.376392878591038, 0.4569377801193217, 0.5957860322448212, 1.759097884380614, 2.054720625255437, 0.5274901792221133, -0.5230476813806941, 0.8691169345462685, 1.618475961726159, 1.374130238922144, 0.24697710965248423, -0.9453507215562491, 1.4948834829240023, -0.04725470674019945, 2.156059705640944, -0.33002324409205974},
    {-1.5326659814304495, 0.3881103837907552, 0.5128635693340436, -0.8901448433032906, -0.6631079191702031, 0.7628539836915971, 0.4582168789230833, 2.2090708617481343, -1.1016328377117837, 1.1078647258069143, 1.035488873907645, -0.5261656921232581, -1.0723716207223628, 0.9440248095029241, -1.5523209465765406, -0.18619252817909926},
    {0.20172139859827456, -0.9665989024275307, -1.33380198274775, -0.9159429605508657, -0.7031133862955834, -1.704390936731106, 0.15005535426431682, 0.44254037504311367, 0.07374917927744508, -1.2983795538513443, -0.7512907874625596, -1.730425179511201, -0.5006671464023781, -1.3464155014964971, 0.43799997280548353, -1.54541623019606},
    {0.48529296152328527, -1.9042774913927107, 0.008870798590439244, -1.7060049350272752, 1.7923676266697148, -0.9399706720634784, -2.138279967652458, -0.20225011773205212, -0.5153423201610946, -1.535057989905645, -2.6143779610229068, 1.304553792313958, -0.030330395844318937, -2.1214749861632503, -0.3001361760641462, -1.4377290402893397},
    {-1.456968570644403, -0.657802893492573, 1.0564157801906158, -0.22298460554002417, -0.2557442698875193, -0.7677169157001867, -1.0996256969103697, -0.7254417701721021, -0.9464662270062848, 0.8705670542582095, 1.1320861067242511, 0.21585572175875395, 0.27558358506335956, -0.32082736258441, -1.6298998234868645, -0.7417871087749753},
    {-0.9376871619176749, -0.2460067617375993, -0.07985449759470552, -0.538673368549225, -1.5162857531925273, 0.8786015655280073, -0.5824338018747445, -1.1145557880514751, -0.6950505827188785, 0.21462796217159602, -1.2493380236215423, -0.7897962384097088, -1.6479955524916936, 0.6876304200483053, -0.6429416644282216, -0.7486555793997289},
    {-0.463167839356176, -0.8388409762107654, 0.45664604044331925, 0.418797553159372, -1.5056139265680097, 1.5100890179828306, 1.5357939847016586, -0.7749313236029707, -0.4844418772255988, 0.6630220174984097, 0.988849067181645, -0.9937346050556017, 0.7385011869008222, 1.623724984902041, -1.7489879345775243, -0.5487855826298426},
    {-0.6633017037864795, -4.840447703013603, -4.876243738795068, -4.061470811571648, 2.3825494101572535, 1.682523184735299, -2.75815463457557, -1.6963473147087915, -5.513075281331935, -4.271747447930826, -2.022571946493606, 2.0364271249389474, 0.754876039188023, -4.59866866719622, 1.569943490324693, -4.64813978659176},
    {0.5429926875641087, -3.9574943114926264, -3.8873390954971705, -5.3225193283678705, 2.771171867756044, 0.8710023241948123, -2.8402145882297076, -3.987422548966064, -5.633104168766894, -5.841889683266989, -3.731988466603687, 1.2785862763368874, -0.9236843022898773, -5.238228693741061, 1.4209576600277654, -6.242923732385269},
    {-1.5499391822269666, -2.521411649936305, -1.7489958390793865, -1.5775028811880674, 0.8550432858541679, 0.9351197254750281, -1.9352554481106299, -0.8245368372120684, -1.9202955024003543, -2.962986510179019, 0.6683574122503987, 0.6817314414381778, 0.6612601303399455, -4.725303560821842, 0.8520241920557736, -2.3603652128955646},
    {-0.015409702759343905, -2.1842158107649055, 0.853874733150207, -0.23388949636438366, 0.22978360913299287, 0.09195508220254618, -1.709673268651388, -0.34605055845374344, -0.007742614400002991, -1.7507879946256681, 0.6127518657091946, 0.45309671407692936, 0.4237622693589625, -2.0165803630318178, -0.272745839946429, -1.2173599982439038},
    {-1.230559340786687, -1.4750012829517978, -2.791567863273095, -2.835925978026943, 2.393709456277127, 0.3407338561418418, -0.8615593456999798, 0.33478262556220817, -0.14718433794461944, -0.3753029723112118, 1.7022352187567373, 1.89326054998344, 1.7239344726988763, -2.9724290765166503, 2.5131405137864564, -0.7643963956305224},
    {0.6737258495899422, -1.5861510324409354, -0.6876819572533154, -0.30721392587650437, 1.979122784477145, 0.32925504150817747, -1.8318678027674824, -1.4840211353980246, -0.2166248376455905, -0.17908794977159134, -1.8620958476691059, 3.726413703065745, 1.1140629335868257, -1.994649124964405, 1.5845298385187299, 0.23234193279355864},
    {-0.22064014768884072, 0.6756034980279945, -0.8171372567682312, -0.44002466392185224, 2.1361049746462664, 2.360614874602138, 0.6663708753486618, -0.6596083708921768, -1.8168007030424085, -1.7106871930209908, 1.7395709226797758, 1.4816957876366794, -0.40716066031524095, -2.2650745302086186, 0.4057779951534393, -0.9849005652661786},
    {1.1086122501447098, 0.5036918204638013, -1.0011015974606308, -0.6332631450034881, 2.7902560528032128, -2.3641822311779266, -3.0567221496952164, -1.6398562186150092, -1.4857628989657017, -0.2159347605755625, -2.1566775332173105, 1.7913563065955165, 0.007958317808201432, -2.0393969405557906, 2.83606598069701, -1.6894200212385577},
    {1.0043927499526788, 0.48614866851853794, -1.1507906141414959, -0.2687350594646573, -1.2240116684510653, -0.4463018174866975, 0.06361717662390834, -0.9434036258982351, -2.2650998908538407, -2.7835500050879314, 0.6900917439475796, -0.0924225527808198, -1.647138833676403, -3.200738572532812, -0.5180710395190575, -0.8489215874636439},
    {0.9775873377000601, -0.15263436951233603, -0.7262088871822201, 0.5822850551480301, -1.498973993883166, 0.8672993774943617, -1.2418621885080874, -2.3256434839070708, -1.5082064505385324, -1.4553577634260713, -0.23808198126774127, -0.5916392506515005, -0.9011577865264153, -0.6415875537480951, 0.3634744248714608, -1.9837946022683415},
    {1.0203361730888052, -0.07015289891140114, -1.7960289478737603, 0.37923847902469, 0.011661565177257253, 0.6655040353708275, -0.1508615265069612, -1.8622730510104986, 1.5838245021975241, -0.24063277060323285, 0.22690044395505318, -0.5204354873380446, 0.48130351111501085, -0.5032937287040316, -0.2120223375632637, 1.1079133146473872},
    {-2.074867436897268, -1.756782007144705, -0.14732840921627888, -2.295965806073417, 1.780142399443994, -1.0786097187728483, 0.6159612972238279, -0.6971869856287247, -0.31103876116059265, -0.9781042708469577, 0.2906763287301599, 1.0886093848057181, 0.4750411434978565, 1.867508641215913, -0.9512166466887834, 1.0611482461729767},
    {2.082417928654759, 0.5526995200882101, -0.1986124641191848, -1.2048675836174383, -0.6081033350452072, -0.9499847475510834, -1.0023461372643396, 0.4465338621433546, -1.947802381672587, -2.3156715109078196, -1.295343887107328, -0.6467909154052176, 1.3473733620164667, -1.393467797218123, 1.6766606778841593, -2.236016742813252},
    {-0.15362585544272697, 0.08373564654589491, -0.7978732887482868, 0.2369001589077983, -0.10307004929079501, 0.6455871929029283, 1.5955826086329372, -0.13966545783275747, -0.06427883308006409, -0.9230319837924076, 0.5731324718740619, -1.5064346013994558, 0.012230706083759165, -1.452914217027929, 0.08327373917404894, -1.577357765002879},
    {-0.9920006786733929, -2.897673102467792, 0.17977141787777073, 0.16063848022656912, 0.8686967980714951, -3.159184323225849, -3.0512621078957616, -0.8874958011641148, -1.133434979531668, -0.5263127213291322, -3.2236066740077893, 1.226794897148154, 0.3263348214019548, 0.7805796926725322, -0.8503070157382591, -0.3975114399600271},
    {1.5685267957198583, -1.9646988349505388, -0.7116195220202413, -1.326254243458828, 2.3989628226987856, 1.2911415098726697, -3.4734585078645646, -2.1361014228240456, -0.516932280948132, -0.07478675877071715, -0.22622692031649547, 2.8296260361892855, 0.5419092230148433, -3.5427287077445553, 0.23757113084841328, -0.7554745377235702},
    {-0.9061748502125527, 0.37690989745342046, -0.3706684434215022, -0.2678584285884061, -0.4000455276221186, -2.030569220998665, -1.5823571620793029, -0.8145347410505486, 0.5313963687307565, -1.2133301174376245, -0.7682800859710558, 1.423025988911904, 0.43681366837663743, -1.3539876310250245, 0.9437325928652777, 1.3467191896865134},
    {-1.704165057366935, 1.4223724768138555, 0.6763940129550532, -0.740922812295842, 1.681238408459802, -2.2417916783335343, -0.9198146437629349, -0.5277373042668743, -1.0088710142730037, -0.2864908221740351, 0.3604984509467252, 0.3639448199992522, -1.7033174364119206, -3.286817455462876, 2.5871804499502202, -0.3509263180048795},
    {0.5903298611456724, -1.7835924313681877, -1.6432039785854018, -1.0316240449085246, 2.02957846714833, -1.6329977609883997, 0.8225780899225181, -0.18959926220592394, -1.0518721903326593, -1.2727905551576522, -0.09099046433569773, 2.3011632973420006, -1.8830227329108697, -2.4887656778013385, 1.0217818697485792, -1.4996554655216232},
    {-2.747425596937252, -1.456758124707509, 0.01805260941255123, -0.9871674518210043, -1.2620209983936093, -2.171170491436697, 0.8443374489104343, -1.1303096211231143, -1.4577816716972354, -0.11148415713786644, -1.5536281395260128, -1.7406555166825761, -0.14071398593955306, -1.1067586229863393, 0.030016733381933166, -0.10367698142830123},
    {0.9137180691212617, 1.2450308098827243, -0.19856769538200744, -0.17381652742317028, -1.067541381817296, 0.07884154432745533, 2.141716362251242, -0.8091705788845914, 0.7292340897195109, -1.7854522119847978, 1.7739363783616795, -0.8900581500296478, 1.2959118771651668, 0.5087911867315239, -0.31960110729114766, -0.20187236233482278},
    {0.9731899865778852, -1.205027303161663, 0.309372443559362, 0.025278685576518963, -0.6362422608306321, 0.7019132001238098, 1.5833639837844706, -0.6705237477456509, 0.6661939307202079, -1.7388737542274846, -0.5802663930446227, -1.7379070990444727, 0.9556383899242338, 0.5352834735987759, 1.3549771403434663, -1.4269955558998495},
    {-0.8709914710588029, -2.085385095381919, -0.11977403360165917, -0.09596684916469739, 0.4303987281955603, -1.9412724189981039, -1.3676775729732507, -0.443395691258219, -0.02622783379411129, -0.7906268436069557, -1.7511337506229945, 1.8052728372781246, -0.022203171627697194, -1.0740765273312398, 0.2763303401370103, 0.6976777310400292},
    {0.7458175476916479, 0.06286197213673285, 0.41410774100043213, -0.3835459362772222, 1.3715462874295357, 0.27328303062429, -1.5938714586936287, 1.1540348818831414, -2.1387360340073234, -1.1577821427024304, 1.1551588436689677, -0.16246115533536817, -1.1809799950739994, 0.5919755181612664, 0.7677325509837332, -2.5317929785399578},
    {-1.148409439911577, -2.47568598990618, -1.3236588297348362, 0.8909848448215152, 1.7303280540096804, -1.0254908561996685, -1.4149700515285386, 0.5265167038456828, -2.441641573844312, 0.27138482180551815, -2.242268891364506, 2.1030779178750136, -2.3360979812732086, -3.37455495876135, 0.954647372111773, -2.3984232216836783},
    {-1.1393204399972283, -2.029093215144447, -0.00047348512436075027, -0.5692351126303586, -0.10008827323804281, -0.2488775566970796, 0.46375436081647864, -1.4915920223310062, -0.0006987046209911197, -0.34142924258161317, -3.5596122101388907, -1.549020897911981, -0.9853201257270319, 1.2257593507628903, -1.276685641345154, -2.0181924912583913},
    {-0.7682291091592998, -0.7667344919709078, -0.7921442187758067, -2.058518871077744, 0.06270850130048755, 1.2405806527009666, -1.4516378139895811, -0.38471262486317653, -0.8990455503463738, -1.6325343051372025, -0.7804917656299105, 2.192665655537639, 0.9187150480571254, -1.4019834055775786, -0.23777064584283877, -0.8377271347079348},
    {-1.7221838909022356, 0.4695700224823341, 0.6993927840802632, -0.6805184503512995, -0.6638741383159008, 0.06240256873616065, -0.8263283722378372, -0.8746859028842083, 0.3358663935743334, -1.6088479198148562, -0.4802534181019978, -0.9953275793276537, -1.9934372342820863, -1.094944554108019, -0.0591059408356142, 0.5915017233557572},
    {0.703158851107585, 0.33220904222490516, -1.1824490974763031, -0.7669725181050221, 2.9768273597463843, -0.9484383027350909, -1.4808193093446862, -2.009272494078363, -0.8707954274184834, -0.41364563106708563, -2.0300949400734827, 2.181325828552398, -0.5161343191285026, -2.8553823100356945, 1.8260095495630326, 0.9537146496806957},
    {0.19530988905286045, -0.9927560966933868, -0.37027728197473453, -0.6447170121480822, -0.031932048332770545, 0.7068330322363251, -0.6084223346796509, 1.0316987352922016, -0.14787167218031147, -0.5378793254002936, -0.2607099746185661, 0.6110297886215504, 1.8807193709812358, -1.1345785348348247, -1.0857796320762791, 0.42908366464028286}
};

static const float b1[16] = {7.163587047431949, 7.435226835977741, 6.952338096647817, 6.960638292298235, 7.456681262007203, 6.7696504171512855, 7.475145640372556, 7.06430954673408, 6.496589524340942, 6.833550169465734, 7.645868063530126, 6.399209301416491, 7.639962450558663, 7.426421632805064, 7.536230217629318, 7.5015784759072925};

static const float w2[16][12] = {
    {-4.268234784906015, -3.8108464813019145, -3.348991870385434, -3.856146800711782, -3.640164901292595, -3.962723905172414, -2.9012324976876505, -3.7883433428281195, -3.8197493902503625, -3.4854641825707646, -4.306967859029951, -4.087010168904803},
    {-3.745348921916476, -5.3430835732684265, -4.131523060301632, -4.367889457681534, -3.6634343387159864, -4.446386559007999, -4.649612175453923, -4.31684073790832, -4.530054310194445, -3.9189298634057836, -3.7069089607930654, -4.282330617750508},
    {-5.138753391164392, -3.4579773218744063, -4.482505147866461, -3.9713834041959237, -4.214243018392647, -4.498947252403688, -3.6498138553834094, -4.246513400870991, -4.702445842324905, -4.251464749261558, -3.6513034738483743, -3.9865299100676586},
    {-3.0276035220776865, -4.46030565452174, -4.00030405439362, -3.002800287089561, -3.817312787367023, -3.542382057647148, -4.548654787084931, -3.87100361888463, -3.405399640774624, -4.792915172158951, -4.483496532719689, -3.421149267267885},
    {-3.7716339908521013, -4.202102159719515, -3.093761045610342, -3.2506853194687446, -4.05788530915511, -3.640007905243445, -4.478179264800098, -3.492628502855158, -3.3736684598207103, -3.6324060798338587, -3.053229683963077, -3.6352570234007278},
    {-3.658002506380808, -2.4767966734333227, -3.694769067466091, -4.012144475091738, -4.136225146432702, -3.4951959765520013, -4.1705362264995065, -3.677618029767169, -3.3205313592281462, -3.389216504168292, -3.0582920353364402, -3.5170679671443366},
    {-4.819848318725564, -4.836337680044881, -4.213962767960615, -4.250477649787731, -3.8376952255778667, -4.259639273975979, -3.7972888247242227, -4.16161351667087, -3.7221775336421525, -3.827498304292122, -3.767562878563559, -4.10621319600437},
    {-3.569397545398306, -4.570550252085441, -3.5789808906765197, -4.657397864249897, -4.161534646327124, -3.5096816039584735, -4.051613992259763, -3.811579986196788, -3.954236736034657, -3.0172858978125965, -4.721995501727982, -3.560412813579744},
    {-3.4672007183381295, -4.223479070740336, -4.568561114182685, -2.9000078561417224, -4.710928329895255, -4.907621561517511, -3.5993355975522707, -3.3471958467485456, -4.551484356833723, -3.389888924769827, -3.1862025017776823, -3.838246436006314},
    {-4.872612544418022, -3.710117289656662, -4.15504103299417, -4.521255888348732, -3.3768412054260004, -4.096036548236022, -3.4774464957217863, -3.950160600760916, -3.8811389360865114, -4.522121353909032, -3.4205401948029133, -4.866486471044738},
    {-4.37837490802312, -4.0610308707775165, -4.813631441695816, -3.7342294910204457, -4.808155025739113, -4.201529581561085, -4.077705688338199, -4.120847697128959, -4.910564813459224, -4.3601259031659785, -4.971134586108315, -4.693362009796545},
    {-2.6746004553419542, -2.6876338679115257, -3.7611236671937274, -3.267614153874294, -3.3134810254278424, -3.2705615420849408, -2.8933094416337073, -3.248295642671181, -3.894502796503058, -3.5014381539924595, -3.2308745771387337, -3.7622873984659315},
    {-4.497875182544933, -5.124556105694693, -4.847268110882186, -4.69857394311666, -3.724574616355073, -3.6566735032922497, -4.0925134930774085, -4.472363203732936, -4.279740504901623, -4.820675597581512, -3.8960876796955253, -3.709999823114668},
    {-3.5754808237860836, -4.030479996059305, -4.1930046819278655, -4.227360130250917, -4.5475924295653884, -4.256229883417594, -4.6760284964861984, -4.418184198143502, -4.753868221235228, -4.3259828875931365, -4.5557148870640045, -4.965274223721394},
    {-4.03872945958841, -3.441018992087454, -4.134802087972492, -4.582409005907503, -3.8813040626891704, -3.932842642180725, -4.3135763932942615, -3.899427708544038, -3.3178130236169774, -4.2250594053064745, -4.364062611441371, -3.1959751189789976},
    {-4.375884956444461, -3.7592761126136964, -3.342156034730965, -4.687203964917923, -3.774290980975546, -3.697501167417739, -4.268108646891881, -4.1406078900921, -3.4728084319596193, -4.112193417457219, -5.147397273375654, -3.6588553400058754}
};

static const float b2[12] = {-3.8022150019064926, -3.8831593817595733, -4.633003337644564, -4.428243984198905, -4.553988283109117, -4.30348192613729, -4.054499377273605, -4.985415925757513, -4.403697494377267, -4.52354024601273, -1.9785336618629947, -4.285437899370021};

    // Input Layer 
    float z1[16];
    for (int i = 0; i < 16; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Output Layer
    float z2[12];
    for (int k = 0; k < 12; k++)
    {
        z2[k] = b2[k];
        for (int j = 0; j < 16; j++)
        {
            z2[k] += z1[j] * w2[j][k];
        }
    }
    softmax(z2, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
