#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][64] = {
    {-0.00048731095980568547, -0.12245111986909012, 0.23262557590148394, 0.12820458680262597, 0.2912598839637917, 0.4463755832548609, 0.3979037939688884, 0.06102802927671755, -0.05582728472523793, 0.34533937415909305, 0.20214514633336533, 0.32958308557538646, -0.4489675664806954, 0.6152324762024124, -0.2694730389890778, 0.5966592108943827, 0.43525755331629024, 0.5871452867484014, 0.30838732038233846, -0.1904045806375032, 0.21507038692506192, 0.3250968536326468, 0.21811438818373272, 0.45864036803315106, -0.04979427119391023, 0.014154193608282533, 0.5898070008061344, 0.12168944984686088, 0.5244180245717538, -0.037044687997486454, 0.20739206446968494, 0.10299220461411358, 0.18810123381632463, -0.07733395805952246, 0.42562814478803007, 0.4782068143973855, 0.4044839071892335, 0.7082956240241812, 0.4801134626107116, 0.48150198467136457, 0.6644215352818373, -0.41314690695809514, 0.5147416623619606, 0.3885257410060446, -0.10015201743738122, 0.43369005459361554, 0.23048845919137298, -0.2818202209260003, -0.05810072826176436, -0.02086680276544157, 0.4749090084519494, 0.4552317130027041, 0.3586639537745259, 0.0579922078379957, 0.08507570425001362, 0.6793141656499717, 0.24200898162057752, 0.27419855503982504, 0.1678442571455472, 0.3844018134010585, 0.5064765469706421, 0.5785154591149471, 0.38597384087111014, 0.35305741346548924},
    {-0.30921401977712043, -0.4452211273575216, 0.4487399036991288, -0.011494176985984199, 0.13800130112354433, 0.3602695750216197, 0.5756195525331786, -0.3814228948541926, -0.1763001287932516, 0.42468824570357677, -0.4429550058349345, 0.1499320978958304, -0.6340693356910947, 0.4421679720759497, -0.11926431036801623, 0.5760865471814166, 0.5333618847671024, 0.3587862720142284, -0.10322761180400174, -0.4294834600481777, -0.07466710802933246, 0.43030052676597863, -0.20012178078467435, 0.36601109642843577, -0.5255106765251366, -0.3832536113200211, 0.5316956758133409, -0.501401955605912, 0.7235207935588668, -0.32976831981302446, -0.1746542703963335, -0.3870853607867028, -0.047581049774012965, -0.49403502452783893, 0.6766920430993344, 0.47176296400169104, -0.2342847930208293, 0.4260884617207799, 0.3459765240035699, 0.3103026094871493, 0.41009693127167685, -0.4760914539272925, 0.3766143912886547, 0.676336244117774, -0.38805698119032267, 0.31533868543962434, 0.39017529582769883, -0.34828522638848664, -0.3382435389291532, -0.49599584928562307, 0.3362709275390149, 0.44006978351611686, -0.30726524139304506, -0.43827673647696946, -0.4153632082579508, 0.5327797654878637, 0.30647107263055595, 0.3497349868364166, -0.35598815652008275, 0.5505528569985311, 0.47478592266168107, 0.7037232795406826, 0.06486764955396014, 0.6115726135376212},
    {-0.4637615535786547, -0.38040232971664334, 0.30430407600562287, -0.2108375307508728, -0.014359193461528147, 0.4444813483439103, 0.35812506946061756, -0.47826483995203534, -0.37971658586568346, 0.5240428875720475, -0.5593560065643236, 0.328260654710238, -0.7865987271488801, 0.6644609404163101, -0.20035321404412437, 0.5487620902182074, 0.5554373532541823, 0.5777363382982078, -0.10653759567232592, -0.2400996204510354, -0.030742512211063364, 0.019709449534384943, -0.06300424132991506, 0.6942912883352041, -0.631986615756303, -0.5320757572751713, 0.49537389204342375, -0.24797931207475835, 0.4867960187326665, -0.6602967760570468, -0.6268596412638032, -0.29885956812672404, -0.20634836918422672, -0.6400917273719046, 0.5471952242617816, 0.4560880741809089, -0.40164582626891016, 0.7421219275080437, 0.25160069089204806, 0.7315858713004199, 0.3604754982229143, -0.6555679941247966, 0.5899284959804544, 0.5735532171897979, -0.3253442678451078, 0.6291010212035754, 0.49086323747364824, -0.616421794005291, -0.6143126876662711, -0.4506022500941819, 0.6519151714970346, 0.7217268393165398, -0.15322601666946056, -0.6014806852617898, -0.42288143359914293, 0.5123820626426423, 0.2523344457317631, 0.552550390019024, -0.24014071625848374, 0.7278445944155906, 0.3570915047142811, 0.4304460224930699, 0.24960614611353663, 0.7046316833905452},
    {-0.5266100428365784, -0.6495795573198023, 0.37350390173324405, -0.6302198349445784, -0.3558429642311478, 0.4178769182537463, 0.40125507195542975, -0.4202270366489742, -0.7426238673807236, 0.41183448045673354, -0.6579194399143381, 0.2164894500255463, -0.7911693042228631, 0.5855907184708318, -0.6969060240523617, 0.4460965225467947, 0.5870854620432115, 0.6288106153725543, -0.522039452802184, -0.7082413228864282, 0.09908971810476687, 0.16984419180435364, 0.1836148646567542, 0.46985256897843436, -0.4223883312578784, -0.4989140471824015, 0.6420248367516035, -0.47913212927772936, 0.6471997857289692, -0.36945215829388456, -0.615425109416288, -0.6072550103544777, -0.15272063209648934, -0.6489776943986524, 0.4662683292333864, 0.1388761608194525, -0.3474039623003398, 0.6841157533908232, 0.18261953036246326, 0.5889546082832214, 0.3774297208742538, -0.7577393271834603, 0.4523535523853486, 0.6861633195121104, -0.4985418823437422, 0.7558607105929636, 0.5313677678641576, -0.4712468618929949, -0.6248789811230376, -0.5731103063397303, 0.4768850579340371, 0.7382853081272992, -0.5653652520944081, -0.4566743075975915, -0.6746550258909914, 0.7288446088335772, 0.5457683495010034, 0.14791828036023807, -0.3012490677751131, 0.39839067452469, 0.6313022758488473, 0.6177788312037191, 0.024235005622640443, 0.5172836610853891},
    {-0.5391879313167497, -0.615202805533487, -0.11274307528687931, -0.7514867741374706, -0.35645065979853874, -0.2003019448715685, 0.2343233334642452, -0.34966149304101246, -0.47291256857607145, 0.6031139661473385, -0.5827709401305486, 0.020238200998823962, -0.5123242172103628, 0.5760145736514188, -0.6486928046311822, 0.03186998653789034, 0.2418133341245525, 0.6499501507505062, -0.3468921738997516, -0.6874854458401561, -0.562594593292672, -0.26835605619419495, 0.22138266404148177, 0.16092709310442396, -0.6277970435027332, -0.7106855601639904, 0.501045350396905, -0.4875743567442439, 0.36885966849101837, -0.6142883152732487, -0.7267945178580743, -0.6034138101325107, -0.5453590792679657, -0.49011662935247086, 0.3900508326941511, -0.03756615989833971, -0.6747496867471899, 0.34868408121151423, -0.15020483611549926, 0.515434237367432, 0.1745294428009795, -0.6003242967734219, 0.180743482083642, 0.3471321744722814, -0.6967956024393028, 0.5255746884269227, 0.3857885143509913, -0.7407679093278832, -0.4386016509724452, -0.5542818863404354, 0.34388916878543396, 0.5844774140561197, -0.38243953078156967, -0.5249232630964314, -0.5083605556716693, 0.17666094367157822, 0.3001458212195078, 0.33790693759660695, -0.5347518624266772, 0.3920505236558574, 0.3836951814134427, 0.5187421082101952, -0.41844117023629457, 0.613195151196374},
    {-0.6330742285890137, -0.7304469719069467, -0.1320764508069017, -0.7789104303268557, -0.3033264715610192, -0.18460041381407663, 0.292945004773509, -0.3371601491249087, -0.6276961028441423, 0.3011211751417847, -0.5953105912896373, 0.05756378723301136, -0.4334060170120111, 0.012453388485604662, -0.36895845924227116, -0.2076634673743501, 0.04969461127177079, 0.2654238254993787, -0.5160389304993482, -0.5021321171898241, -0.3743580529658798, -0.36155147542792865, 0.14408740078492646, 0.21902578196307415, -0.7172288740869776, -0.6963940481674735, 0.34430096649514924, -0.3704057379899721, 0.36035796324299374, -0.5896003401805354, -0.548746032711478, -0.5170511871107065, -0.5097414159704965, -0.7083546108894557, 0.1803391366721598, -0.13077331921273624, -0.40130729328813175, 0.23116234524843593, -0.2119373493761776, 0.4765114471997884, 0.07221123504772528, -0.6095403699533772, -0.01402302383911211, -0.019074758335942323, -0.44188877766152984, 0.2940016535445672, 0.22891042284479302, -0.742177240449835, -0.6283120465700355, -0.7322987123667617, -0.010300911939171589, 0.5030502336133138, -0.7528909105390618, -0.5106388278717208, -0.5516348337971468, -0.07412020832960818, -0.04918385866662645, 0.15764737628068703, -0.4304713196366725, 0.16692880736792143, 0.13671164918383652, 0.22755792327174637, -0.5562951403378033, 0.10695729227030759},
    {-0.5007296451464103, -0.46286459234868105, -0.28631523086912214, -0.7082793315158972, -0.5921225092877073, -0.3416511891909106, 0.27030508436109113, -0.5016610342306096, -0.6129020332160869, 0.451581294561633, -0.7933222352218678, -0.0009421361602384295, -0.5056976879273161, 0.020815989488523562, -0.3705743028716378, -0.244504147279189, 0.23087218479694374, 0.3186101466750161, -0.4773155761273969, -0.4983668952871334, -0.312751072740447, -0.5441041765034198, -0.08231021013128145, 0.331126504082308, -0.5333738724918836, -0.7447611600622567, 0.20456511939578048, -0.42019760675892365, 0.3194064126612226, -0.5225252003959399, -0.8314290433377035, -0.6786119197640371, -0.41305525178300995, -0.6990204009858145, 0.020564330229062195, 0.14912077826755885, -0.4808589530062768, -0.041209899010168714, -0.5087417176789247, 0.41060869648016635, 0.2057240536540226, -0.6354520935227422, -0.28173216117981253, 0.22200222755738955, -0.7577052276088173, -0.062457198458008824, 0.2791274316850465, -0.5946727048802987, -0.6522802298789315, -0.5802312921390014, -0.2607295476967422, 0.33057655661947244, -0.5726978920667718, -0.7569477231497833, -0.5540236019831649, -0.10588092678695449, 0.026936071640571164, 0.2462075292377185, -0.5721731390836216, 0.1851872312089245, 0.24498548663883407, 0.1921527494346389, -0.6388815163166701, 0.021321387890922038},
    {-0.7606032272507319, -0.48232901734757716, -0.026026397124996725, -0.5640779743533081, -0.5177499071072853, -0.08219430304663133, 0.033711207105029, -0.5075329291822694, -0.5000852075451949, 0.3081709841140581, -0.5183790702184969, -0.039596840679903024, -0.5750171787768306, 0.23284239579748578, -0.4058693329922664, -0.059753881066024216, 0.30305696155255646, 0.3549313076771505, -0.6344983180066559, -0.781091910773083, -0.43315549038504664, -0.3611385306715204, 0.09080662548278617, 0.35104294109860573, -0.6817903746591877, -0.6148551173153761, 0.12212832777290616, -0.5943403209996369, 0.44018057735034516, -0.7341715482464156, -0.8260073623271073, -0.5040477714179994, -0.45147192373777456, -0.6645089735701881, 0.21606392769382474, 0.1438520104150818, -0.5873376028655763, 0.19401140363855301, -0.08859361067482147, 0.4423525254916609, 0.18402669232339045, -0.5344655449769451, -0.13353202737679798, 0.0405041374883708, -0.707181026961563, 0.06548494899828178, 0.09876562403740485, -0.5640335063046275, -0.4342095987583365, -0.7656581029035696, -0.18096247180796216, 0.20975537914359418, -0.5679108256740062, -0.574186303340878, -0.46322721367440806, 0.31714248189719396, 0.11234193612094895, 0.22262258648967465, -0.6272256120240353, 0.3124904765571367, 0.32097570349654464, 0.27867892865311356, -0.35452401583726134, 0.388551779020877},
    {-0.7224636349974808, -0.7429706615426663, 0.18860181236586915, -0.6601670180416367, -0.6415928219829423, -0.13288723533850372, 0.3924430728234568, -0.2758729033562988, -0.5754184838747471, 0.43176228999386906, -0.7922722677567898, 0.3349880758534434, -0.5853300484284067, 0.22595689545397854, -0.6905244431123518, 0.08949328118262953, 0.20844069921705227, 0.4313868010727547, -0.5877991970449796, -0.7064511617590054, -0.508880062214179, -0.29899302072477235, -0.06510413594318724, 0.34152795142802544, -0.40582847360856844, -0.7240071120359833, 0.30437181505061556, -0.34629037711082455, 0.4976939351305978, -0.5892753030268509, -0.7856771480190419, -0.6285400256044208, -0.5586267878603063, -0.576669170535448, 0.42119269704287954, 0.1317566670384963, -0.3596474180693284, 0.47629729425727024, 0.16573610455702129, 0.3522441860726877, 0.43912440722698126, -0.44832057731198005, 0.19278588338262354, 0.4066155020896654, -0.4364220013685582, 0.19646552731441858, 0.4096426370581362, -0.6673888590764214, -0.3751043960277514, -0.5462358599280287, 0.20974064379862933, 0.4741194598459257, -0.6124734083432891, -0.47473512626791275, -0.48945573817674615, 0.47607640243758687, 0.23383057037400048, 0.07486574354454911, -0.4395197008813869, 0.48726223421804354, 0.42070111529189724, 0.42019143312697554, -0.19880288840381347, 0.4635188034459467},
    {-0.7499498388716764, -0.6508595851398271, 0.05679932497296941, -0.5590118945265176, -0.3143381191908585, 0.02205561231063208, 0.28577850295239143, -0.39517843527266966, -0.7182252625715541, 0.4446003265760621, -0.6575025962872082, 0.21858237226026328, -0.7247523869697792, 0.39201129299889204, -0.6035230362917993, 0.14429594331049275, 0.6323718182022475, 0.5125072160559115, -0.43321478783871964, -0.7200345251044308, -0.29350566197972927, 0.019450668290082785, 0.0896078692946851, 0.46346690145324193, -0.483048691356524, -0.49209541950302127, 0.5976612181744704, -0.36271077150804204, 0.6099558018486202, -0.4891343571059373, -0.7158950160261082, -0.6507355134394409, -0.43358675593942747, -0.7110036304881628, 0.4287053358779852, 0.2734312971664467, -0.3192315474185575, 0.36430426501426233, 0.09811326949817022, 0.5357025400704271, 0.5838302002325434, -0.5282871027657905, 0.23644419784947657, 0.3533317428193747, -0.6085455089754042, 0.40656873132210286, 0.46183542424974805, -0.809912299116177, -0.6088213408972845, -0.5032084977803094, 0.27746861690972663, 0.31205306246523595, -0.5464146116196869, -0.7950231378544562, -0.37583996022648913, 0.45419955457517636, 0.46181814574960867, 0.3203963043662124, -0.36679666757286594, 0.570421387737281, 0.616153447463136, 0.2772439085205766, 0.014830487010641545, 0.49301689966459816},
    {-0.6332554484028946, -0.39697657751275117, 0.23006116134115648, -0.5517450377101469, -0.37080499695158126, -0.12883011508239736, 0.5389929036739303, -0.3345957218417266, -0.7089087544924161, 0.41949827629796843, -0.6886539629819823, -0.039912962865800365, -0.5522832334788108, 0.3922047491510773, -0.37289939881027645, 0.2273067209948883, 0.3598943174577986, 0.40076312263437686, -0.5499281701928391, -0.4568745026198614, -0.38205109864662157, -0.00887319686376143, -0.07326865294740494, 0.17406159218721093, -0.7514466168102479, -0.7980580834032419, 0.5338674257309926, -0.4089655045981087, 0.45367153142479044, -0.7725376834105459, -0.8230691067508421, -0.44021063687913975, -0.4303167010413011, -0.47486827720799263, 0.47146899836150336, 0.06262056546834702, -0.4859564412890697, 0.13525469213170646, 0.06249363499395653, 0.5682381203076775, 0.24064379443752423, -0.6189524987211056, 0.059110649151477145, 0.4731654555703947, -0.7657477002132307, 0.2786614187611332, 0.3821423084903237, -0.6082700281266576, -0.6849517838456718, -0.8009773002964802, 0.04827691226112533, 0.4313807748784848, -0.5548092551049728, -0.6366994840890592, -0.7141429790180336, 0.13685975294999073, 0.09524254387700634, 0.07633514412963166, -0.6006820245418335, 0.3620293923672294, 0.51477780945507, 0.20537676030981802, -0.10154601305072122, 0.5486322896591742},
    {-0.7865219581856493, -0.70454177586063, 0.2545390569705232, -0.3569729399704262, -0.4009410135209963, 0.0770247404860645, 0.24201821728657816, -0.4355992106423756, -0.4506687362745994, 0.12020893352327518, -0.58226091340985, 0.3242356882124245, -0.6070734908313542, 0.30366730190430263, -0.3726627057021835, -0.008898824275484407, 0.24762386848380458, 0.21532912217542088, -0.4556221574568466, -0.6790008470851567, -0.3674826307995982, 0.03853220242304294, 0.08823799216576457, 0.2749794028571063, -0.35545224054899516, -0.694275590983116, 0.32438017937504326, -0.4812423427946531, 0.4140213882159092, -0.5572602906366435, -0.7674745058178513, -0.4110720615062966, -0.26683188826841947, -0.7442468086974948, 0.25562019473856523, 0.0424192918675751, -0.24926200065856402, 0.3881594982226314, -0.1071710165016801, 0.49970689540994245, 0.25500598392537754, -0.48176801068300795, 0.15414609788193506, 0.3613867998015752, -0.6378447472049524, 0.14136874782043293, 0.5264865635108656, -0.7787030281761379, -0.6602244293511474, -0.5199866626767928, 0.13398512073355331, 0.1303172751408923, -0.45189274179885486, -0.5218352027854066, -0.4902042908413123, 0.17304906166492373, 0.33677535544658055, 0.04218169667765725, -0.6747174745654051, 0.3590173909136226, 0.3816328171649988, 0.446935414898965, -0.1507477831699772, 0.5339379239457697},
    {-0.6744671738119318, -0.39383126135757374, 0.1652508671111155, -0.2765133181947165, -0.33460394699250967, 0.13023928282081054, 0.26816626224209594, -0.630666124641495, -0.4742353600038141, 0.2798639874190083, -0.7805158811373234, 0.3889588232760342, -0.5549222786500588, 0.37582958886465745, -0.33038216660465125, 0.15371027147066346, 0.5293119852420864, 0.48744061597273824, -0.6717854421615216, -0.34300799112020663, -0.1022386537725943, 0.06597734815778789, 0.014195216782862896, 0.19469983272369523, -0.5296032634026047, -0.7551490079179347, 0.2708297127636973, -0.5386945585928358, 0.6055463604161939, -0.46972096163474264, -0.75072497032994, -0.6180808861692844, -0.02291102347883938, -0.650427869161224, 0.2819713309930778, 0.1603676498176038, -0.5653638776109605, 0.22023254969955525, 0.16082740655132122, 0.37850812100487263, 0.5549214491445146, -0.5076837415186441, 0.40744468043784404, 0.45005585308047125, -0.7726910547581108, 0.24878749615683432, 0.6299774672507379, -0.6936386930166049, -0.4096579819708761, -0.5327765914581568, 0.10855445264298534, 0.38767635271768747, -0.4618140328141445, -0.7469742878053497, -0.35319627544577203, 0.2267857540798214, 0.4061838108818191, 0.05275586993498013, -0.5476355302213309, 0.5379572985411925, 0.3175772869523191, 0.3505271599752067, 0.027167271560788214, 0.5780871254920018},
    {-0.6969117989999667, -0.46071182758262297, -0.01380775093491903, -0.643373875581217, -0.3337849837823767, 0.015467134566169211, 0.4163636853533722, -0.3920787481020702, -0.5389046767313482, 0.21592483982930505, -0.6334987482854533, 0.2567973105078293, -0.5363490804905967, 0.3790477506795855, -0.5241039953785523, 0.023892489470797914, 0.6704366421254682, 0.5618071488918374, -0.7391779767108728, -0.46244857861562116, -0.16451615833909164, 0.135139583762183, 0.07427800373146697, 0.3645606553034208, -0.5517918119807358, -0.6014045473614694, 0.5725162617851478, -0.671088820108659, 0.45473045952269026, -0.5864479260339028, -0.51951611869598, -0.7462380406221621, -0.21989708961903348, -0.7370559630646256, 0.46543605899880947, 0.1322836240808901, -0.3247181078442368, 0.5289313716348514, -0.01295866077512809, 0.5354026228827704, 0.5852987257905949, -0.8247824970971622, 0.3854453475526369, 0.34050969834297956, -0.7076169689326013, 0.5882978014053182, 0.5545959448517983, -0.6484459578480309, -0.6018888731491789, -0.5272422963404915, 0.2116793147794413, 0.21494835223083097, -0.4347172891750991, -0.7276045969144033, -0.6869255135037411, 0.35984540234823886, 0.1590407424729125, 0.13406919302487771, -0.5204248752417638, 0.49853533721062143, 0.35185493741360546, 0.5517682527042017, -0.1589766590316015, 0.3395531857854035},
    {-0.6411346018644828, -0.40236562691956534, 0.3554743983817927, -0.46890650609123863, -0.42223374128880303, 0.2072028800841192, 0.40871591957946507, -0.597724173689542, -0.5304001445161401, 0.5070641602339712, -0.7704875244738437, 0.4540152568334538, -0.6674176114958672, 0.3748632500574694, -0.2905649970248981, 0.19405600030340536, 0.6931964601011378, 0.6027335827559182, -0.4603299290567475, -0.6589316726859296, -0.2937699308980555, 0.07902484870155402, 0.18052248992653389, 0.23947986108750674, -0.5962640801067677, -0.5096971550631414, 0.5818594406263136, -0.4169237141193089, 0.5363690517958106, -0.5822750785817778, -0.7400993004638154, -0.6580542029206821, -0.32211103634068805, -0.4933623467709873, 0.40417741706518456, 0.22836529764677924, -0.6202929124617733, 0.47205864571147516, -0.036169248188683056, 0.4357329664949155, 0.6419034912740107, -0.7867467301456734, 0.19971323411265346, 0.42291644285752994, -0.7617466673035725, 0.5936959739616444, 0.6591594742279534, -0.6125382652884876, -0.767884656968718, -0.618472075325816, 0.17300326040005387, 0.5138975253678346, -0.4450760068093059, -0.5950019892583842, -0.5991846840937383, 0.4762804210305731, 0.24991266866475179, 0.2895042082017906, -0.5121842340381614, 0.3934912866812175, 0.45788563315323705, 0.4554008515444436, 0.13467005469036922, 0.3304841378936176},
    {-0.7626184517680673, -0.6333900661917687, 0.0922868330223938, -0.4162892228432495, -0.5392495615918357, 0.19910922429525058, 0.4474738885054972, -0.5189175614997162, -0.5793314629248054, 0.20959235652605998, -0.47309723086536865, 0.43880288788194094, -0.6630431185526364, 0.30308687973707504, -0.534041605662357, 0.2848333286084776, 0.6789258554240916, 0.6009779652956266, -0.45922970927452367, -0.669656786661123, -0.0832244455532936, -0.03222033160128411, 0.13511561224687976, 0.16497777677532263, -0.7515068451642485, -0.6686215193124716, 0.36254249834603114, -0.6914202287059035, 0.5883051604890629, -0.7842193853960843, -0.7788103314138826, -0.6856423807583775, -0.30249354246286103, -0.8213923857956698, 0.30382811177457575, 0.24786310975361098, -0.6140613209691483, 0.4568473253846704, 0.26654379246889415, 0.3557896774803648, 0.5895250405281605, -0.819692700464694, 0.41316156717745744, 0.5638493789744882, -0.45671562241141017, 0.5908644878722924, 0.5863669119809868, -0.6286857663972186, -0.45875807766190185, -0.8047600604672961, 0.41139256983853767, 0.5417400270714198, -0.6506231555288268, -0.4914984424470544, -0.49610502410476043, 0.4062164556335802, 0.2319682867218744, 0.22190759515630623, -0.5098084192932393, 0.6764804285444911, 0.5427697967162788, 0.49459952439504146, 0.035405933984357395, 0.3646327685629799},
    {-0.5615617841564958, -0.44461860585611274, 0.40624772698091277, -0.6879119205049008, -0.2756636197681916, 0.2395415989734697, 0.48525775632555207, -0.5121310943937548, -0.7419602034818097, 0.33893750989248755, -0.6032573020652373, 0.3666033203309078, -0.7933054863559217, 0.6555094215131166, -0.7331473128287788, 0.39606348995188295, 0.556865989360543, 0.7571041397264938, -0.5822278685728673, -0.6326981434612595, -0.12886451017560496, 0.13445381086895858, 0.29266103201219057, 0.27956290628675057, -0.7425496468559332, -0.7816036552436488, 0.6259686543687788, -0.32815166644933313, 0.442287958933231, -0.6935683420113015, -0.6746989751798711, -0.7002075265427689, 0.022023968370350196, -0.7886382946044077, 0.4278721978479272, 0.13578324278817352, -0.4713624516757604, 0.7353524256074387, 0.2148986580678458, 0.5120007743449734, 0.6999800658991957, -0.8310419961423589, 0.5053911662044075, 0.46675423666453353, -0.6866180310435941, 0.4945167242657084, 0.7183160425545883, -0.7589385054086799, -0.5344850685545894, -0.7193607298657446, 0.4750127495347373, 0.4174368512494303, -0.5678160057407645, -0.5235678021606176, -0.5680290777190574, 0.6980978812683177, 0.36962885336169415, 0.2773069113653518, -0.6954497171429163, 0.3872275730607018, 0.3713690598209734, 0.4595354877660139, 0.09460177064789907, 0.4206970384001283},
    {-0.5644893244215511, -0.3055515342863335, 0.23852126809316682, -0.05122771838380318, 0.052748959099639406, 0.3595479456353281, 0.6152966281332547, -0.3114049141502847, -0.5019951901912786, 0.41675279027162554, -0.3995878906515355, 0.5489742553281356, -0.7647020508340592, 0.6572452686424093, -0.4688768756952801, 0.6466833323722468, 0.6263976944676712, 0.7666915038175777, -0.38633330336627053, -0.3982545164947267, -0.07530796252856364, 0.45145092973209033, 0.23461399277528155, 0.46273212865919977, -0.563410574720101, -0.6268310639518124, 0.7163981959859174, -0.367112595286103, 0.4703689798840768, -0.42048268268270095, -0.585699009231372, -0.5426927139959126, 0.28044713061527493, -0.7306700613331724, 0.40632912124753673, 0.244157675730298, -0.09524020352211306, 0.732229965162552, 0.4109430125379235, 0.6190473517218478, 0.7335186644458015, -0.7676582374082239, 0.3115831771100248, 0.6161389556925886, -0.5323876708177203, 0.6841378840625293, 0.6708447093814618, -0.7190487805161988, -0.6638321781629869, -0.5848509929525411, 0.6646069915769631, 0.5065473377104024, -0.33905559874205404, -0.3936100856691915, -0.6276366555247531, 0.7595208014762895, 0.48903475547699987, 0.5734923024691599, -0.24845261329290935, 0.4884935518391996, 0.3795997827250767, 0.5398067081117065, 0.18230464088298678, 0.47582214988264565},
    {-0.4802879855950961, -0.22885250431951223, 0.2729350203684022, -0.4117742973101542, -0.07610010695397476, 0.1444090108125463, 0.5597523816617462, -0.23897652978755038, -0.5019139850016631, 0.4628586745522945, -0.5594927722976862, 0.5959777173391005, -0.6567878005312351, 0.7489899197112858, -0.4602350680636765, 0.33881467603307786, 0.7196914400735299, 0.7176703372696409, -0.34959361726394367, -0.5441236219074197, -0.09974681372122511, 0.3968900277389378, 0.130560273817258, 0.380415885344396, -0.49236341829050795, -0.647096894095726, 0.5254613875110942, -0.4765493959815095, 0.44989888195258587, -0.3747175600543519, -0.570262406009568, -0.34867711065802454, 0.214112670405659, -0.47985101961524335, 0.6547354078674081, 0.3631863499084722, -0.22327559331844213, 0.7400197271438413, 0.25671257377488055, 0.5243512772750277, 0.6774123119939436, -0.7576753812555117, 0.23579393256230907, 0.38046912392894044, -0.4545059335278283, 0.657414306899583, 0.48821212738095215, -0.44179054538409035, -0.719270903991306, -0.7713287519384587, 0.6007040721103348, 0.6803986520671063, -0.37180040526784786, -0.40224401742955834, -0.46754975252453584, 0.6532672483819754, 0.5925452461889046, 0.33226297515722425, -0.5119041854211823, 0.5249724824713571, 0.6737383303859724, 0.5384824775998945, 0.04792705486494309, 0.7256220875616096},
    {-0.39859981039068226, -0.6037405649396606, 0.28045092602194477, -0.29671992516971474, -0.1929665897347403, 0.2649134264793136, 0.5858520655972915, -0.5797928371908094, -0.6016259895825333, 0.27430413120455494, -0.4460938402192514, 0.2274796528907787, -0.6218310460081549, 0.5315407136243888, -0.6331996524564575, 0.3009218516849884, 0.567860674110989, 0.5535687658201934, -0.5239769674762765, -0.4956398530122732, 0.08536987857252347, 0.1559608641794146, 0.18243922103970842, 0.31515202529127107, -0.5009138463735475, -0.6307831921159408, 0.3554303585526695, -0.34246035700341193, 0.5985073252119083, -0.473145210056219, -0.7721148012706456, -0.47396863820186286, 0.12006101810519888, -0.6788332583084714, 0.6673060343001902, -0.005827229632526783, -0.22283394040743956, 0.4723361228150576, 0.28293506283148867, 0.5678742645791186, 0.6263889510827195, -0.8102725413619634, 0.48750360685434196, 0.306795412080291, -0.7616030173280457, 0.6901642551299941, 0.5338361415006898, -0.47686819389440505, -0.4640670063559081, -0.8263966663381066, 0.5084372992993236, 0.5359442165921245, -0.4649072083529823, -0.6177415627473801, -0.6741799671063298, 0.5504097848783517, 0.5731951272821633, 0.5455134652130535, -0.4949701547863572, 0.6918762088474344, 0.3914788630961275, 0.5284008964337912, 0.19308224989230593, 0.480102338599521},
    {-0.60086993770204, -0.5469825268094289, 0.17672555637426846, -0.48124948612484636, -0.04148056117615104, 0.4062393723934538, 0.3905565608962363, -0.5095335448066418, -0.6846441854314983, 0.6080065764956427, -0.6187790918106802, 0.4191351479750691, -0.5228404854412843, 0.5760882349416795, -0.5557149409177822, 0.27847080164669674, 0.5194992489750181, 0.45013422762086513, -0.2264109476445229, -0.4304133600132478, -0.11667451915835743, 0.12172926265953304, -0.04522451260683027, 0.38300364337482123, -0.5535435149866883, -0.7706387913201199, 0.47358408605718083, -0.34718956275789675, 0.689800012922549, -0.6028046250421129, -0.5222358496422307, -0.44398883136918166, 0.11825150789167277, -0.615362233680262, 0.6859337424781187, -0.010298735329375213, -0.4018389913149906, 0.5713462517327657, 0.35417402829023215, 0.6870534659687799, 0.5699927624062409, -0.7339185412728694, 0.30016694355637263, 0.4564863308033744, -0.7786673192063794, 0.5062223009141821, 0.5253795185287585, -0.6931547051119736, -0.5437681372849807, -0.7433430281471269, 0.43578209193515133, 0.45867749717717043, -0.5277711637767386, -0.7498982886956811, -0.5928967384195214, 0.5102198004343352, 0.2775117716023941, 0.34949355880652233, -0.42578929909576, 0.6346836533674377, 0.659244244229371, 0.573266342725908, 0.24370369817127394, 0.7641725138301433},
    {-0.21481317193520794, -0.29446193169458224, 0.18162745231155958, 0.07775759191883128, -0.0549397146679871, 0.2769846092291766, 0.5969122999417267, -0.32567364470416765, -0.33518463180933644, 0.5635170146111288, -0.634851917531733, 0.39167274333894797, -0.5224259708489258, 0.7028290647771934, -0.5938265256708243, 0.4795517066703234, 0.615080137039113, 0.7463674260103224, -0.2146075241546592, -0.3607921192924591, 0.2912209532115631, 0.45396954237205706, 0.12262849726348996, 0.5862062453671542, -0.5838633583028936, -0.4731141732527544, 0.4641598603573745, -0.5343497739565182, 0.6137642887950364, -0.3121943446928158, -0.2614462636562756, -0.4562571101682326, 0.14029005591384092, -0.5781026039742809, 0.7282847132867356, 0.5722734120765013, -0.05942996583246672, 0.6481746192670605, 0.36682416288983977, 0.4993855408468951, 0.8013118756723446, -0.5519193062885988, 0.457557432567731, 0.4580374688500172, -0.5037643253345695, 0.6833843673876199, 0.5974133438249202, -0.7121967682946545, -0.46761378396712555, -0.5131639551867734, 0.49209508562290843, 0.6015034022839402, -9.983473645279606e-05, -0.5011159621100407, -0.538394956346035, 0.5096269821937305, 0.6688648753265138, 0.5370516006929044, -0.1581337197466395, 0.48890787221513027, 0.6482485475945613, 0.6427772323050176, 0.23328586562384868, 0.6021211405029637},
    {-0.17767181210986063, -0.050439231853450596, 0.5092288087960313, -0.003414788340586843, 0.17090691557735282, 0.5143226977317594, 0.6044140094147823, -0.31416804547259497, -0.24219747962126092, 0.627029812865277, -0.2297647450981051, 0.3407230197149171, -0.6914269202387994, 0.7752980992248515, -0.48317591851167596, 0.6629523573741727, 0.4967200901753765, 0.8044713895516806, 0.1013321050395653, -0.08303855618661823, 0.1065680804751811, 0.5709094021125316, 0.4228587603472437, 0.43313961707426235, -0.505061122779028, -0.4728875171840786, 0.6215923450297504, -0.11444451417218356, 0.6869950455718736, -0.10357929457968258, -0.25806521919517506, -0.07618030097434189, 0.16082425513723408, -0.36442846677989593, 0.6746230271920723, 0.64845268475576, -0.06588695857961395, 0.5641635765532865, 0.29785601987286403, 0.44820494303385644, 0.7473066720247399, -0.7281239172384779, 0.6197851031291006, 0.5637468804331307, -0.4006144954083065, 0.7762641833064172, 0.5033529817483564, -0.45657891882699403, -0.5852730479967414, -0.43570802730334374, 0.510890484417979, 0.5519451971832724, -0.20123512113371914, -0.2905665513211368, -0.2671482149424372, 0.6217321651198031, 0.5897588901036277, 0.5632548724974895, -0.1101802525967649, 0.5111920909856227, 0.5479033019018176, 0.5375338931854686, 0.40461854452234153, 0.4838717130635246},
    {-0.3402262810223346, -0.46632715357649973, 0.28896861221668246, -0.17235846298638302, 0.15911901441282267, 0.3931332233214535, 0.6081657986049099, -0.3658320021428694, -0.5588597007497796, 0.5271004446147624, -0.4549867193996503, 0.25147987760298457, -0.7968216038674475, 0.486302256619975, -0.45626191925103093, 0.5982045826315183, 0.737148622716086, 0.8039803671379606, -0.08409723672757456, -0.3810168831570614, 0.1964960141460493, 0.506236448338076, 0.1757538965752867, 0.3266318752044274, -0.43099069834446785, -0.37262343919474, 0.7101888492913458, -0.24388592273447013, 0.7204300358362048, -0.19908588360856866, -0.3571447314947251, -0.5291814298562624, 0.34224592902220263, -0.6964577062874319, 0.7527324473492941, 0.39716137213752506, -0.13970420560187677, 0.5059055750520981, 0.23253984257230434, 0.5253849430108344, 0.7406749953144183, -0.7657432826583177, 0.35056687223963284, 0.5295059406607752, -0.6426899040928334, 0.6748344014065691, 0.5294913109213132, -0.40242146547060786, -0.4165611717939973, -0.7558937132955694, 0.5693296658668495, 0.6642380601567377, -0.21377562440961734, -0.6049679615465536, -0.4371086136915747, 0.699559680837731, 0.5432907902261863, 0.5000623495990075, -0.31324837788999904, 0.4550140629720153, 0.47446803005699634, 0.5298567037396252, 0.32759157975253644, 0.5148081114356111},
    {-0.43944002126035575, -0.32373300609725936, 0.24632465243680762, -0.41498516567242005, -0.05398202434202516, 0.25767973522779564, 0.6137060805369098, -0.3379474271506961, -0.6728380535697283, 0.3928367388477461, -0.5829683538032939, 0.39538342732132786, -0.8416015709019454, 0.718477327099617, -0.3665374961272664, 0.5282741733991839, 0.5822969314875707, 0.6852172515225218, -0.4204496944353232, -0.6131838149886985, -0.004381634333137962, 0.43460205014649483, -0.04548524482724336, 0.3360343987759718, -0.7571873420563027, -0.5211514113087039, 0.506573672901693, -0.5135685792193975, 0.5695993623412424, -0.54357441901616, -0.7173892064409597, -0.6433809199612628, 0.1967345784258483, -0.609306192639722, 0.5400675774667839, 0.05838483284185509, -0.3315375585752377, 0.6443655079123107, 0.22126010283191663, 0.47904437884244355, 0.6407751331607586, -0.729241836683227, 0.5978211852426033, 0.5041331289736354, -0.4620955903733094, 0.5886775970629444, 0.6333917283285746, -0.5413538399563528, -0.7089242684433584, -0.7271567416814343, 0.3761028453206749, 0.7100405532871168, -0.22567553037560822, -0.5609628563661444, -0.53190041046436, 0.5273374670580716, 0.43999962602316617, 0.3751699694857311, -0.3926515432268408, 0.48947437655049986, 0.48112054711453334, 0.6318604516065802, 0.17124113620505615, 0.582720743539258},
    {-0.6182828561088896, -0.457829525132317, 0.11228633826198378, -0.25579672347618576, -0.1489406907001003, 0.4509052487177069, 0.4233142408801756, -0.4103292329530724, -0.5935641726285413, 0.3662919226467403, -0.5127840881669395, 0.25799888407915056, -0.7306617871227229, 0.6502824726250949, -0.6530100110620785, 0.5564899620245369, 0.4170907005814262, 0.43881584068843454, -0.4280141666767776, -0.4270847989429059, 0.11988300109017119, 0.25633671065824537, 0.1296081125059193, 0.5612636296822594, -0.32948533545394754, -0.624477030660761, 0.4209954650583611, -0.5436798986293667, 0.735059664068741, -0.500284531226971, -0.4582540661648091, -0.5953973205505638, 0.07290534643711007, -0.4041643150927884, 0.47831702645581364, 0.3518110119108243, -0.029102549175182423, 0.43564853628576394, 0.37965851373902954, 0.7094246789001387, 0.7084663492600604, -0.7049933308467295, 0.44040500683531497, 0.4913652630253976, -0.4601911426664118, 0.6348510638353189, 0.46458348309495645, -0.6185409565005829, -0.7315753859055554, -0.5273905777816715, 0.4173100283612804, 0.40058553154023724, -0.1372481257467852, -0.6427591054592959, -0.5936031601672013, 0.45911353937414034, 0.2540045129122404, 0.6274839858336744, -0.5328161329292173, 0.5604890153018378, 0.5430414704346509, 0.4298086010156869, -0.006289601298634874, 0.6700170862039087},
    {-0.484147906107235, -0.4352332368952178, 0.13560430792106484, -0.2885787245360133, 0.1537933791206471, 0.34615539642742627, 0.4682035643404233, -0.507452917265024, -0.5945353027534709, 0.326379927644486, -0.5823630136070195, 0.34497529584244785, -0.5139063269761158, 0.5081918877799277, -0.6065225185610359, 0.6804093976918119, 0.6744231742486144, 0.6558083800646869, -0.25496166447353824, -0.4970345536707754, 0.20229465369121638, 0.46429316085242417, 0.31100384444011664, 0.43191990757126675, -0.5775682738905407, -0.3815800064562579, 0.5602844303766522, -0.3575103030098962, 0.6551232962399458, -0.6490800080950773, -0.4743687314420358, -0.48973459884874804, 0.2806651615536684, -0.40873939450182944, 0.4685397506239391, 0.4282921309506062, -0.2734687258887694, 0.6417663161557751, 0.4494808460916239, 0.48885194982634184, 0.42938366827545627, -0.7153152790643496, 0.6016168110322853, 0.35946837057727316, -0.3791158893292342, 0.5179737493624561, 0.5899329920286344, -0.5798463318066394, -0.7102669391339064, -0.7694779902819101, 0.6200665688027149, 0.6409215853569015, -0.1452432191653412, -0.6830887425642399, -0.378831964089922, 0.646485678643698, 0.49452173873989413, 0.47077983598491985, -0.31814480644949183, 0.7566949584397322, 0.674474548044069, 0.5638404988706887, 0.07238677650726481, 0.46288375920526204},
    {-0.48046825985425795, -0.42191130100326507, 0.41405395641864784, -0.30931678036980775, -0.05149648947135255, 0.28467382735570357, 0.7367342726155833, -0.6038693615220065, -0.5502885560785635, 0.3557673672938573, -0.39357654099119477, 0.5332068845580207, -0.8486165991180002, 0.7004592776384375, -0.6047825066270753, 0.5826326828240411, 0.505840511790981, 0.6229639920327841, -0.2620583920062119, -0.2839929040711047, 0.2629051867879442, 0.13243650698533901, -0.03956520202005233, 0.6259204128061318, -0.397693006236935, -0.47401643549225964, 0.6710552837685334, -0.3934909288167623, 0.6567407445281751, -0.49797051128584763, -0.4535053347675374, -0.5523059871570336, 0.12746944619564754, -0.5375530522388895, 0.5305962135875646, 0.2827498617460275, -0.29929044967683704, 0.7351271586206701, 0.2024479228236547, 0.6042363414721157, 0.577260791932106, -0.574270831357296, 0.3731033600488025, 0.5904399230749668, -0.381059685101965, 0.52809918618195, 0.7369850122072821, -0.7005853299708852, -0.7280249094731058, -0.7192382240342402, 0.38072083201345913, 0.7060913383862503, -0.2832896160554355, -0.5141152938403636, -0.6566027733806038, 0.6421563085500184, 0.37379369850049715, 0.5467377355327991, -0.6095935649573687, 0.6798453211782882, 0.6944696992070787, 0.5379806869759961, 0.28752015616622734, 0.6111689718240199},
    {-0.48694163373191834, -0.6143324160886213, 0.11987245462994879, -0.0323879334544157, 0.021368747316737734, 0.30588507819078975, 0.5159401781967716, -0.4073355313479255, -0.43627551640347917, 0.4986823522457661, -0.6778139300627714, 0.2183386148727652, -0.524344870478482, 0.736818906521383, -0.5700915241502409, 0.41177708100734706, 0.6437187643161606, 0.4949643139482003, -0.3233261122824681, -0.26433879298669444, 0.025828900510068975, 0.30246185507244694, 0.05905128745610951, 0.46968637594360496, -0.58799811440292, -0.7115817931607444, 0.6871265145486097, -0.5914613990801025, 0.6255920953871866, -0.563070697106967, -0.33447179891574447, -0.6449795571846936, 0.1561490510047126, -0.5464875296846552, 0.4715649853090869, 0.128547510270405, -0.4403884388366873, 0.6670730961297141, 0.19869262736317733, 0.48439698951497123, 0.5672122767703013, -0.7332777411435758, 0.4404924928567447, 0.6486876547760536, -0.6783678882525765, 0.6817557790356137, 0.5515454966046066, -0.6416120765693177, -0.5410968627215587, -0.6692879666974625, 0.6133573147101838, 0.41879990699509023, -0.4721755950411876, -0.6580470514305777, -0.7404004612489113, 0.6285997257204868, 0.4384632540295091, 0.42854208449481446, -0.5659359851634481, 0.6887375179359229, 0.5690668198129927, 0.7533808676313088, 0.18842982216606555, 0.7320865951226232},
    {-0.3526688320462127, -0.21430265534258483, 0.15923744805993292, -0.08521261421538685, 0.05133701623299622, 0.2698906927202217, 0.6052526297181245, -0.33625604253388264, -0.26513365986633325, 0.3002902952245008, -0.6670789471469475, 0.21062974292949024, -0.8088073415363327, 0.743357032755537, -0.6037444787048654, 0.6036398584905802, 0.442250475300713, 0.643011289735732, -0.05438492314647473, -0.3830720516936574, 0.018646860251996994, 0.463936753079508, -0.09654469530541882, 0.3819556006262047, -0.6334319236180833, -0.5164797199480515, 0.5412313676300657, -0.6138863075311077, 0.7027637222251691, -0.3039147203116152, -0.2645737267870494, -0.35649869260307, 0.18397506606063868, -0.7280006563292541, 0.5772857855121125, 0.06959285572546894, 0.003649820260130934, 0.737690634426901, 0.38911662151260595, 0.7012174491192472, 0.4597270108499903, -0.8580967951352433, 0.48637196571777513, 0.5732198491364765, -0.6304849649776119, 0.7690803498995223, 0.5226949041836343, -0.4850889278156677, -0.723794516212755, -0.5610550586844519, 0.3057293599297215, 0.5249814391239073, -0.07456901596560396, -0.41028599596086374, -0.734485702548373, 0.6802074480307534, 0.2556397673408507, 0.5796795629531697, -0.3189165740963662, 0.6410633796985575, 0.6261036627578882, 0.7355974961531894, 0.3821791490112125, 0.6636700328745169},
    {-0.28157767080614177, 0.28668149565844386, -0.17183701268293217, 0.3065297267350573, 0.35308599202948826, -0.32468280010114775, -0.4330856479846577, 0.064334657642505, 0.2088430968037394, -0.3008945984288062, -0.17726595598619926, 0.30618197965763355, 0.3470791780327012, -0.10967361899241898, 0.12491670587238357, -0.3164798992737486, -0.23917720172212956, -0.5686173088589378, 0.1886234029249035, -0.03841665710086846, -0.4727552403821563, -0.09387217939922002, -0.13703971617422378, 0.304438413867694, 0.23952179375170157, 0.10747451045081023, -0.3275593975980371, -0.10436318423142538, -0.2664642485700983, -0.4408547830722521, -0.19534018507779, -0.13688898190925383, -0.24781077537026372, 0.08325608776429118, -0.30991397406689647, -0.06034318879021536, 0.29186701507166957, -0.30559715738422033, -0.5285189657068456, -0.07785389037018975, -0.2774856324099675, 0.4385742534917968, -0.5467013608910803, -0.4811182628492178, -0.01700037179373388, -0.282319302238352, 0.11167940827616706, 0.24560011293915077, -0.05762696675720877, 0.147548290094569, -0.1409549266519188, -0.3929933434754922, 0.25317565863060193, 0.3107889793018344, 0.062280381946152145, -0.42542073606805225, -0.182478770287785, -0.06428818349182357, 0.09682843884423241, -0.3434422370127635, -0.49497918527773593, -0.10639467368073457, -0.06352176142666976, -0.4834026240944941},
    {-0.3547532207903347, -0.24949217391391448, 0.12330242923185795, 0.1869353428856874, 0.14148290363659208, -0.016777674413991705, 0.405516934141988, -0.4858368925178416, -0.036108195529303604, 0.4447165901194095, -0.33960400305823674, -0.011538575825728481, -0.5372532529803784, 0.11895104571025863, -0.329820130879225, -0.0012560306737871207, 0.3374738638584327, 0.25415272569004427, -0.004844298489896658, -0.3150913979196083, 0.062286789846686924, -0.2807289435663843, -0.264771898725191, -0.07648224080713288, -0.5961054496009595, -0.40367543952557694, 0.4409353378830677, -0.4701372424379374, 0.19912368395324134, -0.17999299859225612, -0.23694404064402927, -0.16699940469179844, -0.3284253432270755, -0.43003369764786514, 0.07140079145598845, 0.4006363437504419, -0.39059873998121314, 0.41318399102548636, 0.3010667025634646, 0.39835668324145357, 0.34203626083626026, -0.41215212890835884, 0.28807599574047327, 0.04812704530485187, -0.1967070616292905, 0.04840133844441065, -0.026169983117159984, -0.6166645716298155, -0.5239695902051164, -0.22170557991118942, 0.11560271753775346, 0.42302878148133305, -0.30704620037242836, -0.45969184911186556, -0.10022757212607189, 0.10998896912988944, 0.11765472163216424, -0.08810784777694387, -0.3944149694289418, 0.3325277330452692, -0.03318798303313355, 0.20238512876838508, -0.08813519506366178, 0.4474171196491436},
    {-0.24250553982332657, -0.3348810685189192, -0.3223651767565869, -0.4996082902484868, -0.43729876062683837, -0.5255912018776198, -0.4954700973380816, 0.3246420551104937, -0.31844732400722153, 0.09488178959270845, -0.36872354380257344, -0.30597051145202886, -0.08235004227405937, -0.5982330865771456, -0.3314249792956031, -0.4030069371499828, -0.4883280104276576, -0.5442402792638544, -0.1907865291195445, -0.5325566231627292, -0.38308498730494694, -0.37920197400704453, 0.4278854360305048, -0.37083261675984003, 0.2920637349181477, -0.09867142597669079, -0.4155277037236739, -0.02539507166611966, -0.6233848695318717, -0.5353164516013519, -0.2507390419653603, -0.2390081377261371, -0.5520887692448472, -0.053271899534869806, -0.5681358181214703, 0.18328957668101997, -0.1987933546498099, -0.23729567308119567, -0.4030064940813151, -0.4248218846057766, -0.4431148457569558, 0.06085025925052257, -0.6140547390112544, -0.6888840302882262, -0.3204947183889873, -0.1986966919066243, -0.33628400431250727, -0.22363920672969542, -0.19843887250120884, -0.11400387026629126, -0.5548098568379607, -0.2144447050886897, -0.2673241469389271, -0.2843257318541218, 0.14954521943237542, -0.4628459225641568, -0.41621707479204995, -0.07812215774965868, 0.05144344585935, -0.23827318158675528, -0.4785028984042359, -0.44894411968502135, -0.6540106881231326, -0.5381133868201605},
    {0.054311003543444925, -0.3395547149745935, -0.1853433342312475, -0.15943261582465879, -0.23187625652636698, -0.2473357452884784, -0.3471538610073419, -0.24947928286860033, -0.24519001268393734, -0.08878224931637776, -0.14678419668641365, -0.1914000917011836, 0.11700075607522704, -0.4347091541509778, -0.4361876836501694, -0.25470777752235074, -0.3291902545503455, -0.05098143794578757, -0.025992617439383782, -0.5129019531262581, -0.1825884672148837, -0.05250781573983968, 0.018165964596828954, -0.30681174170086445, 0.11922054109575561, -0.03182810754603212, -0.1225799265256904, -0.05804278661447097, -0.128994061607487, -0.006680292267371455, 0.06088315868978148, -0.4670079792988655, -0.3382122585621058, 0.09483390602869912, -0.11015139179564319, -0.1524910075136919, -0.08952667631182201, -0.1295095481373624, -0.4472540487804173, -0.2794350393701281, -0.2852938775775932, -0.004972512614268509, -0.4411821466834321, -0.3231084204680272, -0.40111521153421303, -0.26471734179500783, -0.40746223541294724, -0.17639359065289228, -0.044515830548642395, -0.2318395838366173, -0.5210763016240451, -0.2283099893641455, -0.32577361685048595, -0.1690632517380783, -0.018260094310608363, -0.21225245141984567, -0.08126256544176728, -0.34582132706605384, -0.039317176684653475, -0.22339649733366962, -0.4727444854278058, -0.47365900700668767, -0.41557933306090816, -0.1627103897868736},
    {-0.6511973512601349, -0.4491572550712551, -0.27462003658796463, -0.21193368143552763, -0.5659110066726908, -0.17132081182298506, -0.27019936697545643, -0.20750057658007842, -0.3766983337734242, 0.2028788318976186, -0.5868206255423545, -0.37834974281631356, -0.4920789973434833, -0.21837496823375308, -0.514036544788843, -0.06111194787829662, 0.08859888739787301, -0.14673029595190998, -0.6009325666322368, -0.4982335260994557, -0.41548955754464906, -0.43689027054649554, 0.029775862773459002, -0.2612203363358642, -0.36891015274415256, -0.28637858695334445, 0.070282001923037, 0.0675696180697029, -0.1947904718726219, -0.693393034767872, -0.5201118079402178, -0.35387317389603246, -0.46858525839662474, -0.24735050894828298, -0.23879115715813826, -0.18005161465110275, -0.2711841128768141, -0.17875067547066523, -0.30549609794383864, -0.18699724994887343, -0.21904803604789896, -0.5506291299609498, -0.10333401859370948, -0.12975167044876407, -0.28460002263748696, 0.1280428105173821, -0.43146110328199266, -0.6889098712667648, -0.21480693483094737, -0.4445856217594273, -0.035579054400000254, -0.19550127729556094, -0.3674799106996477, -0.641322792759801, -0.20423997610911548, -0.26724556956757817, -0.1530860494062518, 0.08293503067434044, -0.5141210054934948, 0.10765464572337959, -0.22865984378470883, -0.15666185990063183, -0.3411986892961521, -0.26766856562942193},
    {-0.43586355243269553, -0.40377510903616476, -0.3349655909631803, -0.5123977991357122, -0.23132985100959472, -0.2047398099687787, -0.23555766932514333, -0.26304965985995815, -0.2707643154918599, 0.03176214919604412, -0.3213252426329791, -0.14407732708112603, -0.44597187207145184, -0.17527203728689114, -0.2742875231408459, -0.030728311670313094, -0.05082339689612815, -0.4005762021178835, -0.5119097366864036, -0.5028672920492543, -0.28610320445982473, -0.561620027199882, 0.034400118205675095, 0.004294277050062652, 0.09268900996481734, -0.186051936270271, -0.3109771480876929, 0.005479195120600446, -0.024947011767691117, -0.6800174830222836, -0.21239091215411335, -0.4187302967906152, -0.38182334119765476, -0.2697617954650072, -0.11384829485699362, 0.04982378563607156, -0.08243867019240833, -0.2940868227428824, -0.24923562641026353, -0.130606683029607, -0.1373450390496694, -0.47454367317085094, -0.517673723994553, -0.28859712483659206, -0.1616578003829148, -0.08410162763325818, -0.3779568193097509, -0.4196452123454001, 0.006671132888784642, -0.6603495821728148, -0.07852865578147115, -0.046991244143436514, -0.28970074061001255, -0.5935051905549091, -0.2192147370483779, -0.1035490470797195, -0.24931280789469046, -0.395427549012224, -0.3802363597161073, -0.27448444801022676, -0.16033718164075014, -0.21436725178882107, -0.2094988220891008, -0.24165224719359743},
    {-0.4159999204913257, -0.5036714444746165, -0.18257868997228968, -0.5873574440285811, -0.6077492843255581, -0.5564543477797529, -0.27144130968874614, -0.21466849812018016, -0.3616567160336807, 0.07614479294819236, -0.5126848595629698, -0.35960271850489944, -0.20683837123178234, -0.06912255401487376, -0.278121287643611, -0.023151670824840907, 0.07263857116218488, -0.20525400054989787, -0.21493733658210304, -0.5290442200392131, -0.3742252722331803, -0.5497362585333032, -0.12074699144284945, -0.16760037470181302, 0.05385824871901749, -0.45516171410532386, -0.3438707489758916, -0.17250922612618938, -0.046516061849123616, -0.3231477100926838, -0.26976509585466935, -0.5455142432908974, -0.4757781729991257, -0.1327700353256947, -0.17088450988298842, 0.13485697012964687, -0.22544330126609569, -0.08296069812267509, -0.40083852531753345, 0.011286361077978084, -0.1797909052481911, -0.3449605532263119, -0.5329278628122482, -0.18797217031076663, -0.47474022506222846, -0.04226298977870098, -0.4213447929888364, -0.32917016906408136, -0.3712040119609263, -0.5357953346620058, -0.2726992285153541, -0.2798129177672365, -0.4979822759768814, -0.533485468395396, -0.42801845068245503, -0.04328248851240535, -0.35699997010312295, -0.4254704663621488, -0.16083766473407773, -0.2940997218574411, -0.34250718520083273, -0.24295121198674852, -0.36943764097854215, -0.13641488542166527},
    {-0.12659498334730512, -0.11036709487256964, -0.2604371803682787, -0.25672735489505216, -0.3888981112547839, -0.20896165356372629, 0.031905467685828574, -0.15548088712320102, -0.3398905073590739, 0.3151628371628807, -0.48675072933371577, -0.20198836763740777, -0.23392676735515291, -0.21438477534801031, -0.23564971052375847, 0.013362662341137149, -0.01948901251601845, -0.14030978831986587, -0.43835857017723, -0.17427127354369254, -0.49340976307706114, -0.2661616000370865, -0.2481057371882309, 0.00417772386867475, -0.2297723507901739, -0.15428402988085183, -0.3037802955746295, -0.05225309722090508, -0.09687626689224167, -0.17253830419534827, -0.3189824015029851, -0.3154214108972258, -0.6038650343870828, -0.01526373442154654, -0.3050742951033611, 0.05837877042995477, -0.4158453442524587, -0.010270108416229036, -0.21025838445769235, -0.054898468288872404, -0.3658882450608688, -0.11818672865308924, -0.46205600585311046, -0.44069319119254186, -0.5111213310555782, -0.23496248498448777, -0.14025312819799723, -0.18416233278386956, -0.07663898589692193, -0.26456740968074716, -0.09956890106976472, -0.1750227646466423, -0.24955735202699023, -0.41002476144455924, -0.15744894515559246, -0.25296493865571684, -0.12804501628044326, -0.11963074266352512, -0.2507916149120113, -0.3893656386871238, -0.26827408045409357, -0.5262970154831784, -0.26610386473530134, -0.24977370373999702},
    {-0.5415492418545043, -0.4762479105752009, -0.5910512094740036, -0.22556675686178412, -0.5617664120832602, -0.41960232399516095, 0.005982819528985405, -0.13517685531251822, -0.3891589193772007, 0.3619026201935725, -0.6449935712752058, -0.2473232447929202, -0.48322262243109015, -0.24466080575058885, -0.4513141175006885, -0.17556886577417222, -0.22382491520905473, -0.33548389196995543, -0.4919420272331309, -0.6052799368332012, -0.23349435473542093, -0.34639632848393104, 0.10687512364924122, -0.007586045137660582, -0.3681197060436146, -0.2560772758682514, -0.1867546601426888, 0.04130433292256609, -0.26280201524312874, -0.35637991303350863, -0.5293454306918366, -0.30173302528071433, -0.4237677530866627, -0.04397231238562786, -0.15210229456520577, 0.2732365460883822, -0.2909885110093889, -0.31913020466218955, -0.23298207700784074, -0.3841709452059863, -0.21476896443526813, -0.2932131347354569, -0.38527549969529823, -0.5647811259528785, -0.5335997517884771, -0.002259399316047655, -0.4244638644591423, -0.553193053143645, 0.015196225064192577, -0.6400073736180917, -0.42747953076419, -0.3107361206775889, -0.4670235613783648, -0.521702168468765, -0.08047493481121748, -0.38746795926034555, -0.22354505759277393, -0.37341024079388213, -0.38541104607201576, -0.18778227198925812, -0.3225225363518083, -0.4080285239033219, -0.5714958226080149, -0.38713161553319814},
    {-0.5475959457155415, -0.4022533561625685, -0.15947459189372712, -0.3995098960658393, -0.5957628566797292, -0.38875850891632946, 0.12637391556314712, -0.22168145594809702, -0.3770770946372154, 0.31322896186260113, -0.5890640334576989, -0.12135438985236802, -0.3279538105340687, 0.0024103916556209018, -0.40686423955737583, -0.13332967932965845, -0.3571346494385985, -0.06872538355760727, -0.4631300632517893, -0.6503372216411007, -0.24662713810495335, -0.4556679557262364, 0.07299214334249281, -0.005832893984102104, -0.49037411526427893, -0.3139848494691874, -0.03319183536187791, -0.295555970876424, 0.048206695574484135, -0.5459912520138449, -0.4477942866897692, -0.38301768560212796, -0.5456214044699158, 0.007985201023612975, 0.011058702379814852, 0.12535833700465468, -0.3166970101643742, -0.3792112163024309, -0.29836214123808025, -0.22604619555644678, 0.01883162276486174, -0.42960943208187724, -0.27156701248151216, -0.23287008315544416, -0.3974794772435678, -0.005673429017739668, -0.3709992475241722, -0.5750880529148905, -0.13099541671501594, -0.4017806071556899, -0.1666970180257201, 0.09611933775566012, -0.3838558785827762, -0.20178388545234643, -0.04525694781335014, -0.035676432038935585, -0.23125828159905742, -0.27077747555627907, -0.4195261816043284, -0.29450556893846586, -0.3588554242922814, -0.016046886424588878, -0.49654156035918406, -0.21644427416073783},
    {-0.25779609193280645, -0.6051647941724578, -0.33749318831480185, -0.43336390765446503, -0.6281166606383215, -0.6556781619628351, -0.19309726698547616, 0.06275834340718416, -0.1800025124934848, 0.22315799771217126, -0.648245280141874, -0.24547220034327058, -0.42349346248019337, -0.11244084788221995, -0.3371264156367937, -0.2724615593453127, -0.22931526965339563, -0.38225855054049823, -0.4755025537723195, -0.6351167919775209, -0.46839019287975353, -0.561820144602707, 0.035113512983776365, 0.0985332168290808, -0.09147048648759301, -0.5721301562802847, -0.31399498794928493, -0.1528983339550916, -0.14311323722488595, -0.5554065277487892, -0.2734595280649519, -0.6439628245835489, -0.2719685327734564, 0.0006011516979625678, -0.3951801992253648, -0.2212453685538447, -0.20560406259251937, -0.42984819701266735, -0.30136389988300455, 0.0003320888570089592, -0.14242100701006427, -0.45461313845702356, -0.4757887799227018, -0.10113785004775781, -0.40517282934414023, -0.30152575108494917, -0.3972830095719036, -0.20562131657092736, -0.3335341559306911, -0.4469159547481091, -0.2455560792276959, -0.0029526415237912627, -0.3929129792362387, -0.5193973053061823, -0.16610222244608563, -0.26351141004304873, -0.23344631191835194, -0.12075118534070697, -0.22818487307918858, -0.04675740156375148, -0.4292068831340117, -0.3351472055718339, -0.5737886955493496, -0.417568206711411},
    {-0.27742504696091325, -0.4968994513569161, -0.5910522780815679, -0.37226014440490207, -0.5247659666259148, -0.4256246190313589, 0.007478643478596402, -0.1865659124386585, -0.3659525033728135, 0.24558291059046902, -0.3678598627362384, -0.5008372455211052, -0.2385054727609905, -0.30363624579013226, -0.058160034551620714, -0.15852226415448245, -0.17137059707150146, -0.11843689703810416, -0.1498882225651777, -0.3274969713746153, -0.26633479731628895, -0.34719114856520117, 0.19686010915631894, 0.19938406029791575, -0.21874787813286975, -0.12679101723333863, -0.3207990642332496, 0.14684527958664492, -0.09435120296580489, -0.5798824587762493, -0.27239858786027293, -0.38493712699511423, -0.5615052641856547, 0.1188861159010797, -0.20674340061375113, -0.1843627255118925, 0.05642894717499357, -0.4471150615527681, -0.4538457788767431, -0.09297851072105291, -0.3443688581601456, -0.07630194566253672, -0.525712966440425, -0.3550754539827236, -0.31862983470829565, -0.3265560161898826, -0.41809254446267335, -0.4683151145073385, -0.30530670738762766, -0.6662986098804774, -0.45043178606756173, -0.1553948011804086, -0.4618119212215709, -0.5938182505757919, 0.028097111951848948, -0.08825051718933004, -0.5193084439298172, -0.042716035152432705, -0.19188805714362867, -0.23859569958232726, -0.2633593849712669, -0.37360488811162285, -0.5012118900844711, -0.05579491201630962},
    {-0.6376912224106963, -0.52829131112626, -0.5686071341619744, -0.432105806863147, -0.44550971448956045, -0.4973783688853388, 0.0033561185503215756, -0.2131422682601609, -0.3367753322915507, 0.20489522001417126, -0.4386053061764097, -0.3008564137548129, -0.270778834913621, -0.24902801899365962, -0.40711450782019387, -0.09028799973669936, -0.14988277894316934, -0.08103005101932123, -0.3042872023155511, -0.603555706122812, -0.5654731628347756, -0.4047204770632122, 0.16417792009855514, 0.040161401290221534, -0.23604737100613912, -0.3021340460124513, -0.4446986226415298, 0.07957854583461288, -0.22968813422854792, -0.3426894842915675, -0.49167865985742426, -0.6102792598210898, -0.46341463126619586, -0.049675840142054534, -0.11856472531035332, -0.2678413221489341, -0.10723917663729053, -0.31839700131319987, -0.3723974880175135, -0.2906114651916427, -0.13100972961715454, -0.29603980212887204, -0.4760335642363269, -0.5619704342432555, -0.5967954184255969, -0.3288028451079837, -0.37007361331505967, -0.45622939882144753, -0.2548001344049463, -0.48351578897631065, -0.46307329416247217, -0.009120751547415795, -0.39110365815799863, -0.5746878891488107, -0.048372599876380276, -0.3157607686271605, -0.3953934411724265, -0.31556847763099777, -0.12648684960605125, -0.38262194271474437, -0.2890755609359935, -0.2659572901444484, -0.46080290291229486, -0.32181923256623013},
    {-0.34461408967715396, -0.5683261007204025, -0.41667041202942173, -0.5921445168361384, -0.3897515849197336, -0.5278197804551109, -0.11545023115041017, -0.09425682259106709, -0.324018926766204, 0.2862801530820186, -0.6699665021026454, -0.6288717601543505, -0.32310511074891807, -0.08727602222483374, -0.28128590112489454, -0.1755116199047113, -0.17017654166964352, -0.29782392829803167, -0.3360691432894694, -0.467998011203079, -0.6628160517157246, -0.5344942235260051, 0.14490728533356054, -0.1707593965367917, -0.2956163870972718, -0.41242690363958345, -0.3419529619279918, -0.3406434895119745, -0.326770044996021, -0.5650891409864988, -0.34629737954539147, -0.4395196006002168, -0.48867573065526687, -0.17315311968276892, -0.04274238273992866, -0.24025802148848624, -0.19020497113801074, -0.2863784516337357, -0.6088320043768153, -0.34311453993699675, -0.46251597506364023, -0.5458200624071299, -0.5656610390585194, -0.26678662641227746, -0.397290549734581, -0.46621051026014804, -0.44678451640791295, -0.351408229732244, -0.11887929573483424, -0.4307621905220147, -0.4909053215474584, -0.06164990854612192, -0.2541014089713131, -0.5902454691968927, -0.03302520955175149, -0.4559967486232102, -0.3431011616888668, -0.05456074540611695, -0.11649685172909513, -0.34849184438765496, -0.21590234928427324, -0.3518967448616112, -0.5245111631416807, -0.4321882297302865},
    {-0.3654545855863095, -0.6383456737060411, -0.5036702186171049, -0.3812431905222596, -0.4084448432680304, -0.5759177660490321, -0.054729284800754785, -0.23110599423424572, -0.5339188201822315, 0.05110507358656353, -0.3474133579242491, -0.24150734714874808, -0.5160886254861274, -0.20877653696387677, -0.36003176586075936, -0.34889509936594953, -0.1399480607760806, -0.19286856356248536, -0.3224956309886724, -0.4810184285546264, -0.35246941430541484, -0.5234594562560818, -0.08327755122769477, 0.017882526900260865, -0.28152463518236137, -0.6634153244130327, -0.3946642342554037, -0.17766561293211797, -0.18762309354342663, -0.5580084236475864, -0.472379225178132, -0.305361203266085, -0.4548780769401001, -0.3909029301284205, -0.13776645625665293, 0.14867858274898443, -0.455730799342272, -0.2054088453951174, -0.5161262949962574, -0.06430049116689704, -0.5108958152915222, -0.33039019228471816, -0.5325640330015224, -0.2769218221260836, -0.5020824392453003, -0.2326081978198656, -0.5505210745150125, -0.39351475297950295, -0.28894613166206, -0.5446501911306652, -0.5340046962850141, -0.07625024028660579, -0.47694129061633694, -0.5803966334825292, -0.10146218001941963, -0.5172955281594469, -0.31774210160174954, 0.20780363968919924, -0.27641901034713656, -0.2790244715865231, -0.1923230612379335, -0.4172299842680863, -0.5035556011032197, -0.40993616873079675},
    {-0.2454988005697772, -0.6972720798618682, -0.4477694648499611, -0.5666756252129012, -0.40569309108860474, -0.33273404295047043, -0.2593511357342064, 0.04939670855041723, -0.4728388682744158, 0.252663262549303, -0.4587961994918554, -0.2512222441574306, -0.26965493417674025, -0.4555021904436907, -0.394015252533103, 0.049574333419132074, -0.3503874035091565, -0.30915137687948824, -0.15097464192397148, -0.38786036802375307, -0.4996438856417526, -0.6441664294796884, 0.3167378100535119, -0.20678300283624523, -0.2442212367272128, -0.5613579994437858, -0.3295511812770163, 0.17804229347188402, -0.5361714889744191, -0.5928468809086745, -0.6031134780599033, -0.3441194529517977, -0.49858099877077316, 0.04381772544430388, -0.3071528138858976, -0.006845450189592997, -0.1436736920160279, -0.18622999454621386, -0.3978281494595725, -0.4140026306420072, -0.5645205399540516, -0.3674838326078653, -0.46035910100837607, -0.3493739423608691, -0.29118734009137004, -0.5317620221098533, -0.3648615005710884, -0.33786650978933847, -0.21054955508314913, -0.32202855115185036, -0.3083012133420079, -0.39252335614594236, -0.629573637882659, -0.32850215207460814, -0.02091342437338082, -0.412207943154815, -0.3777040700337566, 0.0894430441370736, -0.29437557313185303, -0.4407982704898202, -0.24542326769318012, -0.42323725332581696, -0.4013496203495168, -0.2516329969295035},
    {-0.09994878987925528, -0.22472924409330788, -0.47164901019728933, -0.556786929290384, -0.35251020435083674, -0.1032576786490515, -0.06108696888778092, -0.09710424529059468, -0.22601718447922345, 0.04929470665329255, -0.3686056029671962, -0.10676038706201081, -0.27182220910411914, -0.06187387884939329, -0.08347947601671617, 0.08388936045750653, -0.27667550504783317, -0.19355004275876317, -0.21764065075674863, -0.6683642038160422, -0.2731609109405133, -0.49308541196199346, 0.392719697871034, -0.12538140873237344, 0.20178143281996286, -0.09085070529191226, -0.25327641867513057, 0.19904451119391367, -0.2863997205067561, -0.43743122218660846, -0.34421770999251144, -0.16568374104045946, -0.28575560970516434, 0.05526102241786241, -0.015239107202187718, 0.27268564261976286, -0.3099563177622025, -0.05560517070529679, -0.24761950439592692, -0.26439030369948313, -0.17237154396340315, -0.4008304007563058, -0.5382470790834788, -0.21495555051469484, -0.4596211341056222, -0.2829514270267293, -0.4354147125764275, -0.27370667434643153, -0.20883408303619977, -0.281748346975085, -0.31010460296993186, 0.014469530731490494, -0.2703966915404158, -0.5385786623085684, 0.2066445768040211, -0.0793226636125666, -0.24235319368118965, -0.00868874277752697, 0.04880176604008125, -0.14957625422060322, -0.31047669600514327, -0.21841102014823383, -0.24127043974669726, -0.09724077026406526},
    {-0.046728773889668486, -0.2209111237940198, -0.16629993810191004, -0.4211378552657549, -0.19345138710803075, -0.17087729261988485, 0.024376252759006664, 0.09215275922037935, -0.29006389453756753, 0.02476128598667712, -0.1349143560508417, -0.18739809275566008, -0.4819202756569625, -0.08174918505760101, -0.07084079228015448, 0.3269025912367971, 0.12873725810633466, 0.08553927645344558, -0.20326501340266875, -0.46976077992377124, -0.15804387891018418, -0.2655086477504893, 0.1491716399620628, 0.29594366955238116, 0.2551022555768249, -0.33304608295718313, -0.19502227693832017, 0.08242048550655288, -0.11565065818907103, -0.045318596301262164, -0.026134824092410622, -0.13999308803205618, -0.12402695676059686, 0.0796327519273352, -0.18845090521970367, 0.42549924540898115, 0.15374795905130823, -0.06942387260405287, -0.259425611862194, -0.1676221672535446, 0.07513271586049988, -0.16782381573126673, -0.07093743578528813, -0.31541803797515994, -0.17027438231455577, 0.13336022624831595, -0.321843263256613, -0.21710998865208234, 0.14270143697590598, -0.10213222692228512, -0.1375355842496026, -0.004367901982342546, -0.3720563812951181, -0.28664709023632506, 0.26980777954651336, 0.25733836029959356, -0.22580604155995432, 0.3507480844504034, 0.15027631637055816, 0.03146498920786646, -0.15982295600455823, -0.3089650060018998, -0.06429869155791144, -0.1455607352296315},
    {-0.29816566072323764, -0.4416461890569967, -0.4978700066898149, -0.3078800268811067, -0.3410856800418078, -0.5645275892258294, -0.18835852491774335, 0.15299731359881832, -0.39190291114137216, 0.06265552073253482, -0.4346396764744125, -0.243244050227666, -0.18477489841246383, -0.48751965131048414, -0.1731933563669626, -0.2142926879451795, -0.19989044416465881, -0.17819645725340577, -0.3827328333551938, -0.6611236466432666, -0.6648617717992495, -0.5526871263697112, 0.14853596039683523, -0.1690037859661457, 0.018572123542465464, -0.12644573147292298, -0.5455637900051974, 0.07858963256512441, -0.32010965587292045, -0.688630540887249, -0.42354065365303717, -0.47541457421004124, -0.4561477426426124, 0.10241124720626446, -0.5340760395621331, -0.14324931032523702, -0.06287856280618025, -0.45781063044546255, -0.6234163075093219, -0.3624787506690868, -0.270050173000765, -0.23154926725490957, -0.44432904332923917, -0.27991616637200806, -0.24867457305308494, -0.16166552223920233, -0.5164484999706712, -0.378526161514238, -0.2928478674987081, -0.3940525598264227, -0.42087875332567876, -0.17311603029854625, -0.5526094077690028, -0.4007152046674759, 0.08909785894575961, -0.17468252336515414, -0.6315356077547254, -0.2974144582548071, 0.0633797266687314, -0.15946745163087334, -0.39650911552726537, -0.5101726938581738, -0.3617980619709111, -0.4785950118676382},
    {-0.3922572622050085, -0.3804105188560682, -0.3617964628307446, -0.31448739589357866, -0.29490659425145577, -0.5951525174750173, -0.3088704216571519, -0.09049144700175647, -0.5485661289306021, 0.050701170383934, -0.3969774713312091, -0.2521428152657053, -0.40472036883380486, -0.49441567780343754, -0.189762577506637, -0.10979890269646231, -0.11773802219033953, -0.3948525859948121, -0.4725653908603885, -0.5597274323016859, -0.5504257594987949, -0.42967000461930094, 0.11398314238558205, -0.2330663129467291, -0.25234904558965787, -0.34805144799177234, -0.4689148805140948, 0.06939562442340841, -0.3478645942086718, -0.7423969292239686, -0.4192300428645441, -0.4101419878432047, -0.3921299306882301, -0.28521769330763963, -0.46471548941724583, 0.03459212639907218, -0.053756524986266624, -0.516182796235791, -0.5369657763970278, -0.24888129845539633, -0.3152589767030234, -0.46049120558776996, -0.5215615580475991, -0.35170854373016636, -0.3134076344363963, -0.46270168960762853, -0.6079928982534676, -0.4348896051349263, -0.1653657415380717, -0.6791425133992283, -0.6071188590139656, -0.05967008942193873, -0.41684706197411076, -0.6029588447541289, 0.07654941740077441, -0.393156702146888, -0.46214787153901915, -0.04028960219454929, -0.023390899795385157, -0.21035802060070974, -0.2213469261341422, -0.6364769981328959, -0.4211588757114787, -0.3144226318832699},
    {-0.5626317892439717, -0.6887416018658641, -0.41058344431670324, -0.45926620394918083, -0.40285202256216357, -0.4632029069317783, -0.05800241951021721, 0.02309920207776772, -0.4418316760233429, 0.11439690270210752, -0.3884119404903016, -0.5239117719611162, -0.6103526691014617, -0.3900387287975886, -0.17253363384547657, -0.38478556518687695, -0.300383754291044, -0.16563486950424655, -0.6331662218409961, -0.5615250309248883, -0.5358122288959657, -0.47095790682399175, -0.08941012945341566, -0.025738918885891443, -0.00758495543492159, -0.32409955534982277, -0.4225585029756963, 0.12009549082566699, -0.14346172165965437, -0.47430579940608714, -0.5024192873707377, -0.660910032847712, -0.7123411145408488, -0.08029488538693229, -0.3578114715798147, 0.16400055840698238, -0.38228505882797553, -0.09988019713736188, -0.7019145885147923, -0.2661768542240488, -0.06304757908144963, -0.22384225840685137, -0.4212982112461579, -0.2602280683218977, -0.30938367920730314, -0.12797978280057928, -0.5761572545809027, -0.6718706737078913, -0.48828026597843643, -0.3311364058430639, -0.42802231914452604, -0.2732003417023417, -0.2879468597636812, -0.6186791995957136, -0.15366933976901603, -0.41225067646784735, -0.39444946192608416, 0.10111998303555113, -0.22809629172289664, -0.027438280473615042, -0.10400828740598353, -0.5501870084787506, -0.6840374120181534, -0.40055783295836145},
    {-0.31814446135187086, -0.5761639447204779, -0.30220396453602577, -0.5758953376523466, -0.4242702117193821, -0.22686992773554845, -0.004780197259332938, 0.22217850558636143, -0.23754110821490684, 0.484436531231357, -0.04893311747801981, -0.2679784245443045, -0.3969813619769054, 0.20863840877296272, -0.36167220240948744, 0.22515995816616066, -0.1282843555243802, 0.04401232535183714, -0.08011054203245943, -0.6989322554866906, -0.4752528632822895, -0.6058369224750275, 0.5216015077937257, 0.17039545382385965, -0.21445674497348852, -0.516601081775031, 0.031663447968587645, 0.13818611739235864, 0.022773156574358258, -0.6298073636775279, -0.26377670916051965, -0.24765559905610038, -0.5673106790695537, 0.04868081755685039, -0.1276224752975735, 0.4957808463775145, -0.10190618658993783, 0.0045111193011997276, -0.5702277367423199, 0.2589046396986345, 0.06490365203151871, -0.17568141261827333, -0.23389981001100218, -0.24155440462897906, -0.30147296778719035, 0.16021483547143078, -0.3965222108406453, -0.4873828411393093, -0.3067913406668129, -0.20270023141421975, -0.4428899821051339, 0.15101397986387768, -0.1338045491899996, -0.19796478925576608, 0.11079145516939799, 0.021642947774789284, -0.3841029151202583, 0.46365870029570516, 0.1656586382143446, 0.17333302241831156, -0.30059079017940193, -0.044667714558139275, -0.4112368821160274, 0.04583869646441294},
    {-0.04625529951759384, -0.16328377714069237, -0.5425594999644059, -0.2710193590911702, 0.14666349832673284, -0.39357983190519363, -0.342069265384239, 0.1700270483754616, 0.02345946570585797, 0.1642219286145892, 0.18206558824486713, -0.06386463084477711, 0.3306067836616931, -0.027463563369856576, -0.08642435199902565, 0.2524885501781025, -0.15741340288048164, -0.1995755008626259, 0.2304685223628045, -0.44107371280569996, -0.2908621160895109, -0.30756862653527817, 0.7278222064905386, 0.13720082771011258, 0.36830824842187004, 0.06444585842411056, -0.27837693055511786, 0.2331932631340762, -0.268216799372977, -0.5133732237048109, -0.09494865202209851, -0.2427621642568258, -0.6860173657192329, 0.21601376504564404, -0.22327782838847826, 0.4962647590856103, 0.3470724718807439, -0.14034726971570552, -0.6003799454475186, -0.0016657359664165173, -0.3561199910059961, 0.03379167820946213, -0.500418601985615, -0.4236567821464497, 0.032510610066220004, -0.04351126882864081, -0.5426445650138433, -0.23799034282716147, 0.21128102802578047, -0.05791684790690006, -0.49689328883093975, 0.07149637832044142, 0.08819587439327518, 0.03760725479984812, 0.2579661436027236, -0.043945451146182306, -0.41628830196354333, 0.4489024480872289, 0.39029520693286235, -0.2649727287626404, -0.3448645966051575, -0.49422116779450176, -0.4402839753478023, -0.4181961860579994},
    {-0.19776581682602973, -0.3257303952799158, -0.4725676692877203, -0.3725214242557748, -0.5280412584636841, -0.4832421054508766, -0.22180233136484415, 0.29065004428949087, -0.19361374673122392, 0.32127173449578994, -0.22320945976086626, -0.23664124168710773, -0.10417046152602694, -0.5451208813496196, -0.32848089828430055, -0.13335132187758403, -0.278635592603031, -0.5802928401377412, -0.17659868743089957, -0.5526711974227405, -0.6923294621959881, -0.7007826513765355, 0.2378702237083608, 0.23835736044642736, 0.14360946129615182, -0.44714426818530956, -0.6210252953687501, 0.15879667346250353, -0.5514518346600387, -0.4741521470942111, -0.43104032686577054, -0.5683919037657699, -0.6651536463199224, -0.041929171344815976, -0.5837479524066432, 0.4065884750040223, -0.16214765667534123, -0.22235355007125399, -0.7940892713573535, -0.4278929995597654, -0.6303902955442725, 0.1364324530494798, -0.7298075471403508, -0.5678341873185347, -0.29562443085867085, -0.23090666416531452, -0.39238018338221564, -0.37058053900399257, 0.15516946427427092, -0.48111414209692677, -0.6689158338268274, -0.19615653900850477, -0.48189571358800926, -0.4585115499664267, 0.23658728773103913, -0.42640793582607306, -0.5988758102649191, 0.3284577756246332, -0.1494259961454332, -0.5657742546075063, -0.464739848201518, -0.5225332343239211, -0.5864275490361054, -0.49816124368848985},
    {-0.5719473558297956, -0.6255555855876735, -0.6630404524641109, -0.26056669794236226, -0.626595992668575, -0.7455839181680926, -0.3594037238494402, -0.04101707840310742, -0.3643303819777351, 0.05542959628366947, -0.37673176613562565, -0.3929202856798673, -0.28690057743608177, -0.22372527537922682, -0.4698104020039081, -0.14549701477103738, -0.25784313118248614, -0.18384788584650533, -0.3017348074934241, -0.45727026705159435, -0.7303645329712634, -0.54087225718004, 0.21640381446527093, 0.03780496543278348, 0.09059579916474961, -0.6329892002372526, -0.5113001559240239, 0.020556886324303816, -0.4997817653306831, -0.45160151295253514, -0.7034783469965421, -0.4239837867956249, -0.5593534935271619, -0.05563562448779354, -0.33203580702704133, 0.060294181820835145, -0.23880912741281282, -0.5936231088778837, -0.6986323754977082, -0.5102863494260512, -0.5662159899798345, -0.2194290348297146, -0.6000681984465563, -0.42596486988546456, -0.6444203449753892, -0.510799595911344, -0.46696008369745073, -0.3377622157703058, -0.26317954784067127, -0.3770716892145143, -0.47692891052265096, -0.17116828890394636, -0.4805703902780663, -0.5628246478392548, -0.19763593279603767, -0.3677116175146709, -0.3985802890470464, 0.06612566187478, -0.03588369980815714, -0.2065521732748684, -0.313833584566437, -0.6491120053575344, -0.39765322640941003, -0.3094728718568926},
    {-0.1542356207804343, -0.39319504926000665, -0.4522993945946072, -0.2237034799628587, -0.4345274192281849, -0.6626529398429798, -0.2858045569927769, 0.18949249197472431, -0.1893289095983059, 0.24285567466394653, -0.153813888925573, -0.16163498903728396, -0.06547574737134737, -0.3373634973095336, -0.4564702478352142, -0.37087483041360003, -0.5362662530569515, -0.3813236818829323, -0.3489628096767955, -0.2687819317968002, -0.5134346190532728, -0.5715093112250842, 0.39846559692189754, 0.021286496854955223, 0.41404665848620514, -0.1588921912796514, -0.5606168014714767, 0.13037585941769236, -0.291956719243275, -0.42620383300761633, -0.5179323339533196, -0.4232950807035927, -0.5793719231105797, 0.270705388779534, -0.26059629027821174, 0.1988061280011283, 0.13868279486364002, -0.19528246263146853, -0.6802397324145774, -0.2227464808843435, -0.43479652476626945, 0.16741176413500714, -0.4877069300465235, -0.5649516694305428, -0.06385538574389607, -0.46944633694093274, -0.49111959466098465, -0.3631744332172563, 0.10559108165947537, -0.19694193593368442, -0.49319495413099895, -0.017654297873957957, -0.12450039576262571, -0.1782142002229446, 0.03729461940906665, -0.37188077115297713, -0.5132705860683812, 0.12749881568089935, 0.20183588604424424, -0.40907758248803383, -0.6356027090899683, -0.5435668009247765, -0.5000615766408771, -0.5398106721330799},
    {-0.07640600787025531, -0.44384656320251886, -0.4933362400837605, -0.28271864749996406, -0.359196869628915, -0.6881220661194518, -0.43261668880648163, 0.3149588110363042, -0.384828735451131, -0.01683485290574689, -0.09509357577149191, -0.002841468575980194, -0.03883219321448303, -0.22239539045148682, -0.3472782200252002, -0.06825241104386487, -0.3766694603012742, -0.2808920386101091, -0.16687665428438744, -0.5305958135624154, -0.4005031784350539, -0.341573874433177, 0.31078815827085254, 0.06057912767968599, 0.33747894256504296, -0.33285598762566965, -0.46769329898539286, 0.1257665261207389, -0.46756944560672997, -0.6894004936307435, -0.5876299429547223, -0.2346074028860453, -0.6923612895912248, 0.1977921783196288, -0.5597772346695221, 0.34503290997686575, -0.03570045751601533, -0.2389372388083018, -0.657310105148152, -0.39086373387092366, -0.2102739823194238, -0.1539866384257742, -0.7128441136964094, -0.5692962201557349, -0.13962219280642707, -0.25264002335232066, -0.5756269669164286, -0.4446901029762873, -0.10865099182138133, -0.29901407039430533, -0.4037596512222783, -0.18788029643184584, -0.20612976129105054, -0.11916203915821165, 0.21828792954561416, -0.1416831175993538, -0.38936981647262175, 0.1356979846411167, 0.14776423997085364, -0.4188260757130386, -0.5165127916872824, -0.22354875653145087, -0.4240760953378759, -0.46011461604195786},
    {-0.16879950158904075, -0.5678958567859232, -0.6227808593062523, -0.283633678939792, -0.1560234768607139, -0.5821381928187133, -0.22585830023608947, 0.0791548100477431, -0.4185265778456666, 0.05459192779586915, -0.2338293526830624, -0.02618892732518724, -0.3804774523113116, -0.2672656695034285, -0.1832776557292494, -0.220801551930578, -0.3203876725754963, -0.3288394585990406, -0.16816464977611426, -0.46500561943476443, -0.3500305943243763, -0.4447695082688194, 0.3787422306010507, 0.23722011245257452, -0.10856042862819257, -0.3473770455841001, -0.3169800966886923, 0.11031732036709344, -0.5339393794868463, -0.5295596125668306, -0.6140746708260765, -0.4246260115091025, -0.38942899157705235, 0.060344913456228465, -0.23028621097277047, 0.15182205769023108, -0.07891267874353361, -0.500597773201294, -0.7641317839527504, -0.46085951848177836, -0.43452210395969904, -0.3055684727719486, -0.673987882432608, -0.47154490857456044, -0.3874037083918338, -0.11607937327012371, -0.5838799276898863, -0.2023172341369278, -0.23140059571167218, -0.5815993151029086, -0.4245127256997684, -0.11977653869033798, -0.3753411258366045, -0.19666530124435153, 0.21112062561633044, -0.23094195861176067, -0.5923769133545981, 0.24198093463861753, 0.12435850657168802, -0.297164114744258, -0.4290951716564432, -0.5875335940444875, -0.4598865590515711, -0.29318264002426414},
    {-0.09832740166019455, -0.4032844095689058, -0.5063033286313933, -0.30440833449823834, -0.1100120319516196, -0.4360340904558669, -0.4792624469753271, 0.31250787162168736, -0.13594946767610844, 0.30448966165457386, -0.16080428021078713, -0.15351025217643385, -0.1377993979770912, -0.40144925451301544, -0.12515989537993225, -0.18012147313255183, -0.25902428023714374, -0.15156546327906617, -0.1753308010569941, -0.6601214209737336, -0.6497543853238041, -0.5843898710089674, 0.2681413622540996, 0.20784698210612004, -0.04845664905991446, -0.03628504650394226, -0.25440205416747413, 0.17011878575323117, -0.5189232105521867, -0.4655142493512145, -0.2847183988956357, -0.20887847518619274, -0.504386174793177, 0.25877365628043597, -0.5683302413069138, 0.25216494261847805, -0.05264718448606271, -0.3862515906646025, -0.5586255739747715, -0.2983668094388781, -0.3095213125551195, 0.029680164575042738, -0.709234146119358, -0.5900097475487457, -0.25305554453022594, -0.30940973579972314, -0.38301426461993965, -0.45253674661762894, -0.1995565519221287, -0.47771632935019887, -0.49601261193327983, 0.02549299160507612, -0.12816067622697142, -0.08783765959888948, 0.2837252238208077, -0.29290560451172915, -0.6104571425760366, 0.18876656119284116, 0.15263157696961424, -0.22828060016985358, -0.5589084214244262, -0.5310516344048145, -0.37595121541688836, -0.46064681203607694},
    {0.057309480636784586, -0.3199941435162957, -0.4148648220757601, -0.5000548891810258, 0.0862610967995541, -0.2526342981838098, -0.26225806769360094, 0.06020158946798084, -0.14196885888285474, 0.05423062349575694, 0.060438619201432196, -0.10413040782780887, -0.02198140985756282, -0.11581514681292604, -0.21796824973106968, 0.16467836783800754, -0.571247981064172, -0.06241834004775237, 0.3127124123140579, -0.44883668610212807, -0.2943161870287434, -0.48984539242201963, 0.31985412737773067, 0.3722212957872549, 0.1659327339372335, -0.19279014436673067, -0.2498408768179616, 0.15228538469363273, -0.4573730371808016, -0.5380898300227132, -0.20598842398349912, -0.3181338208240036, -0.7332881734476846, 0.19539054238895834, -0.3524912866558406, 0.5994396254259002, 0.17585530650122713, -0.40954522587322917, -0.44216391671438343, -0.33560927905410887, -0.44700254537639594, 0.20393432924705038, -0.6838276981093612, -0.602081687278516, -0.06178719752827746, -0.21505453306755526, -0.27023547930328, 0.003238442269475774, -0.09920346039915254, -0.20402518147500223, -0.5706949553979209, -0.10901581705721473, 0.03661332996674498, 0.06547972731446121, 0.07266879272732148, -0.06884383172777633, -0.3921402673310259, 0.4770965873227579, 0.21294756444766622, -0.17373856150411837, -0.28820751867742006, -0.330766457672662, -0.4797811880452513, -0.2686406899669644},
    {0.36816938021918455, -0.2744075836424424, 0.39314173195199686, -0.4314803931375715, 0.23272625535098035, 0.06214700842976108, -0.2259090239582993, -0.19340520605540293, 0.5328822988370726, -0.17809310371109524, 0.2671453483618823, 0.5883449064872159, 0.06746499829471583, -0.009595930434922675, -0.31346569509581196, 0.4111474943335495, -0.1290107589442153, 0.04377519589543788, -0.018042511196935666, -0.47917173808215385, -0.20548052224149402, -0.4811284658168044, 0.2786733706217349, -0.41115179017119824, -0.0064867831243540066, 0.45589819779856394, 0.1999166376278889, -0.11746510834260097, -0.12575284632421763, -0.1100807455124954, -0.45596352022102765, -0.535302753494036, -0.15711815851130392, 0.15930491397577226, 0.00880102874406441, 0.3383244306632754, 0.44605565599621755, -0.1672754875056721, -0.27311070495403134, 0.21691283599042502, -0.39080763458396867, -0.0029542914238746766, -0.11311912674171865, 0.35674253651250837, 0.40633261915406793, 0.08053551457863076, 0.15251016460787148, -0.09581673730617869, 0.1098871646103747, 0.0913413293240212, 0.048157060004301734, -0.033113431058874467, -0.15193119464127464, -0.5609303917415501, 0.0979107559668284, -0.3212180755245326, -0.3566303790200365, -0.5776299392311055, 0.03919460261168887, -0.20955335124611213, 0.1276520061510249, -0.06499420477439716, 0.062461994824756284, -0.06468004299953024},
    {0.36735960487637737, -0.30954551799642116, 0.3886887634788698, 0.023182341930959336, 0.6022189136769914, 0.41985703276174674, 0.15725202275148073, -0.11086556080540962, 0.6024859624758826, -0.2066178015785658, 0.2669722505610747, 0.5737150699422793, -0.23590587256738524, 0.13855055887934206, -0.021123159009676193, 0.600760638966144, -0.10127761612009889, 0.4665141310912164, 0.06061433714350605, -0.04131176419524763, -0.13402925850939665, -0.4894448545931076, 0.2334230235740939, -0.21887535809208575, -0.052492161992451034, 0.18179005423546252, 0.16793335786886082, 0.05228279511832939, 0.17714826749823756, -0.03461907364072883, -0.35532079056112525, -0.3759445318389834, 0.06231624238996819, 0.25460412081912753, -0.08282825992510452, 0.22559382258500535, 0.6494744297565945, -0.07293785045280127, -0.11754091859882086, 0.3336771343195887, -0.01775120495075822, -0.2240069694717895, 0.12091512670023526, 0.35665827223848195, 0.3206760511608928, -0.2546017094306282, 0.24595308420998235, 0.11033042214592245, 0.3198113761790696, 0.032190796030266484, 0.15181751351701123, 0.07812135606860122, -0.5683484562737147, -0.4307161693056088, 0.2725390102383285, -0.27128519831731024, -0.044709469161136654, -0.4213480525981015, 0.32452208042371933, -0.0920219405411249, -0.18704800819636735, 0.08576250369327246, 0.1275660776678662, 0.27259353006589493},
    {0.370459357572789, -0.5846213172050997, 0.46149047718391434, 0.04407526337139127, 0.6071930385390231, 0.3958206718243438, -0.2644192282667659, 0.15538035495318764, 0.6712938768516675, -0.31220613495257765, 0.35340987257280077, 0.601732368185123, -0.20647775389841275, -0.27483768631631955, -0.4370763912898783, 0.5379908219657179, -0.05487171839316266, 0.1533863181651579, 0.5226712082850313, -0.13773124330979128, -0.6280063736931043, -0.5111347077762094, 0.20313153701411732, -0.37859286134585335, 0.3563784304498749, 0.45497492621939595, 0.03423755981049251, 0.23624652586025832, -0.20371668680864785, 0.15784816422589537, -0.30876205313346383, -0.45443560805577077, -0.2374170189764908, 0.3144721620635095, -0.33386095318978065, 0.422330477829878, 0.700281150379697, -0.020980030625012438, -0.10781965422764761, 0.04774060273339829, -0.30497220107954587, -0.2008538858576501, 0.19226394064621133, 0.3450208865957037, 0.4158474379733438, -0.33231088594817476, 0.01525424314986751, 0.4143531635927566, 0.5087107287733278, -0.07361022893369855, 0.3251355041526118, 0.11669992152853263, -0.7116845465026442, -0.6416725108723564, 0.2897331579603189, -0.5271798656531019, -0.5765741440951384, -0.35872144950648693, 0.21113787131864437, 0.24295937438520063, -0.21178853168549402, -0.008996756116824222, 0.35004950157961584, 0.07954385275985422},
    {0.6004998074825052, -0.31741132478379663, 0.5199640760921953, -0.2054898882754937, 0.6624462319839953, 0.4819752681122452, -0.15488793694146055, 0.02191391923363276, 0.5994540835017272, -0.1908972265858135, 0.3281367891630084, 0.59831109791903, 0.1494566365073338, -0.09060705988147988, -0.34410836745240375, 0.3852590072361055, -0.12031678636508707, 0.3885288036036976, 0.5361405821667822, -0.16311433447676402, -0.4060041535360594, -0.5725872006188891, 0.26554902114902934, -0.45301605159283126, 0.2962454968190203, 0.22298213107455508, 0.2282451649901653, 0.3208962641438275, 0.21591485682977588, 0.3786589724975844, -0.14248142899134228, -0.5335653400924439, -0.2953257409492455, 0.23259347221053903, -0.11659309681109796, 0.6178600316948283, 0.5048385023687458, -0.3381700429641894, -0.23772064954615008, 0.32484776510757934, -0.28930184193051117, -0.08329169839731693, 0.37153704742878674, 0.5117906410477469, 0.3101567126625159, -0.04539909808384867, 0.03795169592469895, 0.09582301888094785, 0.35827412996670777, -0.2147109983401239, 0.29750443189642967, 0.26398775111957046, -0.6336321385233692, -0.4863114793107382, 0.27131067473043535, -0.3774647101809022, -0.2959229855836009, -0.49630637397053456, 0.48657674365092496, 0.2853451479057642, -0.041976971279136695, 0.17972977205650584, 0.3165942003670089, 0.14798941727534867},
    {0.43991442922480295, -0.5530815194594941, 0.3104031507083989, 0.10721148121154543, 0.5470843363915704, 0.11553600290453675, 0.12344306151411935, -0.2672832960466412, 0.2718926026518424, -0.16265138749209207, 0.4170843216819517, 0.3688257434471304, 0.19306334460298286, 0.0787856349364237, -0.45520245240177626, 0.46340300468857243, -0.085536533996137, 0.46014532848564604, 0.23467011911076135, -0.20859799676628463, -0.4522440878205562, -0.568665456229167, 0.47909885188996226, -0.5385278349261976, 0.12355443875318076, 0.2208845904944367, 0.35429297048173264, 0.10245904721584073, 0.11283881379693475, 0.2110982883917585, -0.07347036134478035, -0.3849933410009837, 0.09897272980133169, 0.1443610491671446, 0.2110225056737677, 0.5311298315484739, 0.6276141372529462, -0.13314554708591242, -0.14589506942281336, 0.29420084469082813, -0.38472755229925526, -0.3277738405735553, 0.013201627435858966, 0.3199393103540216, 0.016920716022602384, -0.24958623341287456, -0.10060183502447906, 0.3743812308800712, 0.29187719423983977, -0.3326718427102335, 0.2078396861454193, 0.3718363291184844, -0.5011767846939124, -0.43934146327792006, 0.2401484718959554, -0.2657021199919683, -0.20596547496954698, -0.3024377196739624, 0.49712473900259097, 0.02854788384531672, -0.08548577322781642, -0.07216427068591633, 0.5204118730493195, -0.04837301065468168},
    {0.5508676288976149, -0.4590398455096303, 0.31215496415341554, -0.20150707968746503, 0.3417039327095209, 0.04134760927860604, -0.01948557455104459, -0.002022092526328819, 0.37727346889258534, -0.29902380965174924, 0.391486658312925, 0.20252994888341203, -0.02970247408344756, -0.11411407123598584, -0.6039686901455622, 0.45974458220945136, -0.2238557559370853, 0.38825796636844156, 0.3135076996265615, -0.552830269590252, -0.5747616054532763, -0.5371131332207018, 0.5791550394921264, -0.5862768895093637, 0.10137279894257818, 0.29759551608045165, 0.05180957263040318, 0.33314785267943653, 0.21610480598953405, 0.14883617363528054, -0.45533259936722126, -0.5755978384230209, -0.11969674228609144, 0.14232788801546922, 0.09435894609738046, 0.22995341979151548, 0.40817494255670517, 0.04326971406107883, -0.34995249245537297, 0.13890962049185, -0.40280388168262005, -0.16363234695605564, 0.1385776053593287, 0.4973182585923346, 0.35524032763718344, -0.40556475776877043, 0.2620739483311902, 0.18106567119756978, 0.3667654675257692, 0.08967764328208568, -0.06231843801189963, 0.34496714336409157, -0.6663798578208664, -0.6816838948060419, 0.47549961617370184, -0.018578300551379122, -0.4216732159763933, -0.6419906894521608, 0.4830581807582763, 0.1858582870641172, -0.16079520128672528, -0.14138565694738794, 0.45558997493203757, 0.1080966698374839},
    {0.4973686423493284, -0.5433260817709399, 0.38874820967328205, -0.11782445112703539, 0.3927299637556785, 0.25423393254367144, -0.2780093884907459, -0.2421075814902663, 0.4913022220286894, -0.028997397798367665, 0.010991801832404348, 0.3736202117467835, 0.00018749694817131639, -0.30003148557182513, -0.5780250577571127, 0.42951950281705575, -0.1774238092138942, 0.4005128781807342, 0.47999067321371935, -0.3893837472897115, -0.49728025621310085, -0.5374278612707408, 0.20908267813620054, -0.17304434725888101, 0.2670676789735554, 0.32570729404522497, 0.2557151547656446, 0.3585564731278708, -0.025204408710263367, 0.11886328506144855, -0.34073844122395414, -0.6233904157608101, 0.03835943665543545, 0.4744358346678755, -0.11615527754546752, 0.25203432505368617, 0.40412657844526967, -0.3616105777317772, -0.10138620440478974, 0.24998516986434588, -0.427181275076349, -0.29216772409635994, 0.2786557910040189, 0.31311160112701103, 0.46621034836003084, -0.4250422567194583, -0.0322765674719241, 0.4149690657465299, 0.13791732192956135, -0.10962193807228454, 0.08305962893245676, 0.37021397711320536, -0.307223186114512, -0.6500189262395643, 0.249393341906143, -0.3039988967848315, -0.5502274922627604, -0.4709427757582632, 0.4823291065013306, -0.15050677142960328, -0.28807280459649226, -0.06142160410605356, 0.4353058230241773, 0.0986004225439297},
    {0.4571423652658798, -0.35718517187782445, 0.2789948564183678, -0.18894169307681663, 0.5426706746956292, 0.4247369603167563, -0.23967271555981848, -0.31742844098973905, 0.42217408760473435, -0.21140430513795952, 0.2568151712078465, 0.323915944343768, -0.07220578687007671, -0.33556367128500797, -0.5906954785251882, 0.380594145513907, 0.07083578978217159, -0.004400590557990038, 0.49316428756501357, -0.5482763847751504, -0.3452058585788035, -0.5327168024401199, 0.3602226806972167, -0.1445018380963748, 0.019809446058597146, 0.4034763760462143, 0.1580468846815177, 0.2396405990908142, 0.07444372515706801, -0.09127504826896408, -0.5114061404745259, -0.5617710493750937, 0.14777459268843887, 0.4016020310173561, -0.07422094695466377, 0.5358349654272424, 0.5280993551505193, -0.3603313216608953, -0.04771372978315017, 0.14793196450064028, -0.49071253104934714, -0.3631105346256703, -0.0013135332409584487, 0.36769970615182107, 0.2780267031649842, -0.4727804190406122, 0.18588787154363726, 0.4075838822671726, 0.15855963040300122, -0.06592974560247064, 0.12589467723890618, 0.34103533210642617, -0.5470352112678573, -0.39280948783843517, 0.4523499317729822, -0.08929170648779525, -0.2729516380234955, -0.5241596849600347, 0.13369718523918983, 0.03634394018996631, -0.07055684195513061, 0.03783769552449818, 0.4693259100916919, 0.20571883146086292},
    {0.40771670439259206, -0.45448044987167546, 0.5725780953919808, -0.3293792898129415, 0.5635876699465986, 0.22185735350111027, -0.013228649063987631, -0.035018257849569495, 0.39669619253834476, -0.029047674132330843, 0.18916436712893844, 0.4633402839733598, 0.35754039327923454, -0.09891501098620219, -0.5926061050669647, 0.2986545941387306, -0.09647404636432416, 0.02027753291169722, 0.3806111571678856, -0.434891389194978, -0.33289843963477805, -0.5538116070232043, 0.439840128314687, -0.33439237762807006, 0.01377080033992055, 0.3635029372046641, 0.23205943758388226, 0.3033381173908351, -0.07096445438685425, 0.20875274842232006, -0.2680480760252454, -0.5683178839402055, -0.23058549283786994, 0.2785242354073744, 0.010928463018905906, 0.28942604346783396, 0.6269668373884035, -0.010348326737491639, -0.3125817194443734, 0.014001523425715996, -0.34882161165930015, -0.29141052401375556, 0.11166606401726853, 0.3236054621738339, 0.5123603059561389, -0.271101143096428, 0.2363487583704771, 0.2583121567631445, 0.3364224446510982, -0.26685201446892637, 0.4422192200408518, 0.3562882035125369, -0.64451599307542, -0.6239907032087976, 0.5142404138788602, -0.35609218923241676, -0.39823612980722256, -0.6592901783278987, 0.37941314628112166, 0.05165471706390111, -0.18807399883907103, -0.08401975585765276, 0.38702086803090385, 0.005846630561121847},
    {0.2764377285318188, -0.18697504105347387, 0.5412814384746819, -0.4795819716612128, 0.33419845248791324, 0.20141145113941597, -0.16230728207935904, 0.07759412051535278, 0.2845660568315373, -0.1700860454533433, 0.011468066725767782, 0.7202578379001249, 0.4128061586980097, -0.026239621331730297, -0.36081401617348935, 0.49858498645774646, 0.06091818332910393, 0.36685776562894146, 0.31563336840174977, -0.45354224261747067, -0.5628299464555856, -0.551672960044904, 0.3212562781112292, -0.5084903541134157, -0.007316982662014893, 0.38754373413927296, 0.2140599039981389, 0.36704473306056057, -0.10534781328676877, 0.4827672553303988, -0.5517069559345884, -0.5568871610671785, -0.22761064564930963, 0.16092637888045236, -0.1451272238039612, 0.6101435056446932, 0.638009564509439, -0.14630805228409519, -0.38824784173151256, 0.07388633473337948, -0.23380990448449632, -0.37002187206444753, 0.34094988094190115, 0.36329129880081745, 0.32892829666648543, -0.2806584537340902, -0.12872082340691926, 0.48988986853310934, 0.3994518344571113, -0.07084923165037196, 0.24121569183598396, 0.45166501796322966, -0.6925608299169909, -0.40667641203392263, 0.32834520079688434, -0.10917855795686242, -0.3089693813199008, -0.664484207127989, 0.44885029036648905, 0.042599773610727, -0.1758800719271577, 0.14053562077245046, 0.5083389553292058, 0.2549387120319459},
    {0.26226580847487174, -0.21818696945570612, 0.17377278907791427, -0.4313716301102981, 0.21171130425292295, 0.18697625997018585, -0.051578126709658674, 0.1690448137392547, 0.32741805999868, -0.1231608835190291, 0.2703225898015907, 0.6581933612863694, 0.34075167809341783, 0.19956353629376583, -0.6265645969015254, 0.23401961242655409, -0.14313880605936155, 0.17231757034502124, 0.14848767458510626, -0.6039959939968484, -0.3767245005679678, -0.6135640128880503, 0.22578801108514815, -0.5056589906385898, -0.1285102403234783, 0.2610975384946556, 0.050890012529939875, 0.1871060809965171, 0.27663133144458996, 0.35061262914656055, -0.4119420783003757, -0.5737446557520778, -0.3087923049296299, 0.4319079531024939, -0.28160428053414327, 0.4742706269502355, 0.5040749570719472, -0.17744672560924235, -0.2773097421401791, 0.04632149592214744, -0.17112622211589437, -0.2899300985205906, 0.06462225027812786, 0.39614497659716186, 0.2815303919324387, -0.04915821182925565, -0.050755312291567115, 0.13459906741763789, 0.14378251786226126, -0.08441119471624775, 0.26087395411369996, 0.442473676165584, -0.37416542663437263, -0.6005518016172441, 0.49498162009231067, -0.13992314646814036, -0.46635293326922783, -0.2238176937089668, 0.34705535862033193, 0.3336152380983547, 0.13638443238311074, 0.039204130863966895, 0.5313806680428179, 0.04941493774786394},
    {0.5300401914828892, -0.226045972866655, 0.30720782039372724, -0.15507785339918045, 0.5335291974819724, 0.34844134716583974, 0.14520500665419117, -0.2607298278032978, 0.635332167643088, -0.10723338436321082, 0.1589182085972303, 0.5179533069924183, 0.14403931075309795, 0.1518008201122038, -0.2381164615223967, 0.6092072865459262, -0.3368047394290018, 0.26007536837620765, 0.5961266002755847, -0.29492577218922816, -0.5346247915038386, -0.5782488341693116, 0.1428520431199786, -0.5587393327525652, 0.12554081698122319, 0.35049796912168424, 0.024333648964384454, 0.1472545201553411, 0.32559430743589535, 0.17296219917570707, -0.18523012761341112, -0.6996005676433709, -0.29821994664661133, 0.21376999791928694, -0.28179849431432547, 0.39973638979489956, 0.6515270300623475, -0.12891669797009422, 0.04073570742839693, 0.05126625332158851, -0.1489936223511467, 0.0016877056435313895, 0.3497812502715781, 0.368869394838757, 0.5933415745778726, -0.14648233269447034, 0.3287873663645289, 0.13703709848583756, 0.2671323937883784, -0.3225571028780434, 0.32881195965524423, 0.3707883932200304, -0.4558300414724654, -0.5964056108663995, 0.6285119008108826, -0.46526728156965785, -0.5851894765259215, -0.4751804587455303, 0.4424344166252153, 0.11393228870259775, -0.008690634352409358, -0.11375380445998702, 0.3038723277069692, 0.09596204553416356},
    {0.44963772055346507, -0.4134912428391456, 0.4552698206978778, -0.12663739999607554, 0.6213604288471248, 0.5020566384741431, -0.15488952398782913, -0.2927785359311485, 0.4642553215558958, -0.21882350972678916, 0.057113797686418194, 0.46665358669149426, -0.021332190895123854, -0.19905310522715722, -0.20785296327277972, 0.23209020137254557, -0.34201443611540183, 0.04358016076821041, 0.43523075162215363, -0.24968087783431567, -0.6106546864006541, -0.5622653222333819, 0.16759341208741274, -0.4623402294166322, 0.04994418924767572, 0.4802650287117335, 0.23669535181793078, 0.198342790076797, 0.2578003535854765, 0.07629704171217357, -0.42898415617699653, -0.6204796293804784, -0.07734011364880734, 0.23045544515160693, -0.05456275817225405, 0.5434353965696065, 0.48199180680535086, -0.2950555173167238, -0.11721331228676761, -0.051535476204056484, -0.3789764472977741, -0.019486307648118813, 0.03377007927152914, 0.21120907811226963, 0.6185682837537082, 0.03147708085819573, 0.11991346144752967, 0.17657730807320587, 0.5038302195830019, -0.1617246130426079, -0.03056384553768822, 0.24558445081919486, -0.36934373051393804, -0.4516399362264985, 0.5505607745252038, -0.2675835863533005, -0.3178465754159325, -0.654234758340072, 0.20625945006627838, 0.32643586945827163, 0.15674646570693065, -0.16101386991879207, 0.17334239112585362, 0.11507110078409699},
    {0.5307462385732706, -0.33946261141222894, 0.2601937404915996, -0.07176121329041334, 0.7082674843293812, 0.567046553046336, -0.2030568608632011, -0.07392537774204137, 0.6451452380594208, -0.28309907204652573, 0.4047343392937794, 0.5662160755733439, 0.1068394015090911, 0.17978891744485273, -0.1301353254739901, 0.2353531012450587, -0.3566848287629356, 0.13776631694062222, 0.1607487561138914, -0.4175820803635957, -0.18907258542329647, -0.4893989169756668, 0.3259184048901234, -0.4388432324216301, 0.3778220559521042, 0.6294715479392279, 0.20029733289235824, 0.4278890598399968, 0.010081259445166456, 0.0956027064128915, -0.2616502141688716, -0.39165384397143366, -0.24265140884237577, 0.1411629480442905, -0.1026543669515357, 0.43255692120379624, 0.5152040065794553, -0.21334210485317803, 0.035691549632539496, -0.11198103609102623, -0.05600971343307005, -0.1294637605565646, 0.38254042724066806, 0.4073631340470549, 0.5598873695566311, -0.2894023971988585, -0.21112662687781963, 0.30847364367678, 0.5013693864710201, 0.15236842245905366, -0.08850277974897133, 0.2311967525227565, -0.5304420559754164, -0.4142716405510507, 0.6828037209654086, -0.31687325153010454, -0.5245220261310614, -0.37596634474873153, 0.2993247770554681, 0.0329406347947635, 0.09012471831111597, -0.1178088351393068, 0.1732922528282877, -0.059951167421867714},
    {0.5563539565406719, -0.26442380779546754, 0.06398128472431211, -0.2124292531070398, 0.6901446189821058, 0.28345813926136665, -0.12054464370167764, -0.009046521284389509, 0.5931784092406669, -0.3581674964263073, 0.2531334594425401, 0.6039786033552546, 0.26312719479167773, 0.01438915607500566, -0.4544398781720127, 0.37754836022698857, -0.401558642060949, -0.1662866523813694, 0.3885806673486045, -0.2878862268059946, -0.5432523277272601, -0.42530309567909413, 0.4500894132144445, -0.4419900988762313, 0.0140950954491684, 0.5833744032310371, -0.17169185352290042, 0.5336363777474696, -0.31040389164957766, -0.13901010247929557, -0.4360611661529064, -0.411304485762265, -0.08170189822382545, 0.21181172222913916, -0.46544473250155105, 0.6031131516469654, 0.6026226504724894, -0.38438965581131485, -0.13110580395569352, -0.012914206741437936, -0.47683361876375024, -0.29826880102975384, 0.2353499790396272, 0.2507440881474705, 0.4517508239504606, -0.4268022050230731, -0.33540964431465725, 0.3798910922166326, 0.5202731917952917, -0.07518971387231137, 0.10146886396849111, -0.08824938484124596, -0.31099195687838804, -0.49308005535779825, 0.6605253354231759, -0.40750656315146044, -0.5631071917605142, -0.3452188503993721, 0.18645719585761653, 0.19695495205911565, -0.19811348000659218, -0.06780493727314146, 0.2756491245924932, -0.18553444351179796},
    {0.2667641466768637, -0.5446574114163082, 0.04658048166389014, -0.5205371098573751, 0.5263995528574938, 0.18001269795438404, -0.12164247337861854, -0.3223510717384897, 0.4920911340152285, -0.3446752223023645, 0.3080565642933206, 0.5108627884978699, 0.19538127901319394, -0.3291949610253757, -0.6964281640980451, 0.5860414331104734, -0.14560530136385513, 0.2437957390310802, 0.4251760267438314, -0.5470538574280654, -0.6646581476333967, -0.4400697761500929, 0.30644976965244397, -0.547976791421927, -0.23861663937286934, 0.4934588152013126, -0.01402036050971183, 0.408483266731328, -0.06352557258474865, 0.16757643160966781, -0.6483708760596903, -0.6361084899348128, -0.3861603680295657, 0.5045261019999979, -0.204389073984749, 0.24827177369494702, 0.515756695383449, -0.4353269430506695, -0.47190616014571257, 0.2365887788115595, -0.524034858045317, -0.017652132580152906, 0.26823426380680826, 0.1618837722793558, 0.578183904812248, -0.0788389487018468, -0.1004476146776064, -0.03838252524835795, 0.4985193315847315, 0.008114118813621724, 0.016501369013691123, -0.16076033322107092, -0.5656317846643109, -0.6282251134537645, 0.5255426665009219, -0.19972859610323637, -0.4524387002102302, -0.2324025686039347, 0.41697830379757433, 0.3512092119491735, 0.048115936791776164, 0.21747854078937146, 0.2332972346462744, 0.08019425757747686},
    {0.5959706503838709, -0.49769372238564896, 0.3719620296740228, -0.17221511606557227, 0.6634226712816543, 0.3902485663045604, -0.17939479893151214, -0.08632983248117361, 0.6141877170615573, 0.015128640962480849, 0.20522073146467384, 0.4860634563399035, -0.0936254863666256, -0.17464344063338547, -0.4119186926447624, 0.6172055491449673, -0.16250940016281817, 0.04695658928510122, 0.6393582152029743, -0.4660405931634257, -0.4653099529292071, -0.5366911542093402, 0.5661270930640228, -0.5682142022593598, 0.034930529645543225, 0.3369899193789569, 0.09606869388897846, 0.3281652608419926, 0.07030289616614212, 0.0291901506497208, -0.4223596436664203, -0.6608193293213194, -0.1270923944823903, 0.5123674377345694, -0.19521786008781447, 0.5366031992756365, 0.4949028755864072, -0.3787060775339085, -0.042222822247139226, 0.2268770800014104, -0.5009396116554462, -0.07312497296659022, 0.2007975153637264, 0.49496759183254957, 0.3922871984301134, -0.05374981493809277, 0.115353846937064, 0.03983027009010897, 0.5688162977808499, -0.15435652107177816, 0.03622243368856086, 0.17271835853249679, -0.7572921513440628, -0.5080754245918244, 0.4729932379236296, -0.19931919864498934, -0.3585787513933518, -0.15685889651977294, 0.40744317547632575, 0.4209226194392389, 0.04337381907834245, 0.005805517902932941, 0.39858667131929776, 0.02838529998292422},
    {0.6412722390306099, -0.5906769388110821, 0.12606934659031102, -0.44826988218088987, 0.4300216441682278, 0.3182687148674577, 0.030946860867222096, -0.09186639454477116, 0.6239565489226812, -0.01704934519832302, 0.41928859360635234, 0.735198672579811, -0.04809413282205894, -0.2440142520787624, -0.6516330914410872, 0.458559689879626, -0.27939291255757337, 0.1638669845941883, 0.6943894896635554, -0.37953623690731897, -0.616896408299402, -0.6359408057124515, 0.5950517907327911, -0.3705281207444737, 0.12498325626418799, 0.38294058618179067, 0.15371031644222755, 0.5422636118560064, 0.04254932076808363, 0.178759833459596, -0.3244498685794766, -0.67592884414227, -0.24411525807787798, 0.5316925419075106, 0.027244956811274135, 0.6059922388068157, 0.7631133377659389, -0.41957318074241917, -0.29986371616587487, 0.3162573160158925, -0.4563164473046834, -0.018201523455620507, 0.3724394266130309, 0.21644916515981485, 0.37956542597970333, -0.3821679500957996, 0.12874410988322627, 0.3935005495952444, 0.4289825908771138, -0.18906524996390975, 0.38035204085483176, 0.2596932993577693, -0.45518348057984476, -0.6312460353559773, 0.2797550931014331, -0.387998589598384, -0.4416149510968178, -0.4844305952584249, 0.48502355440630907, 0.18356541620827832, 0.15633549807856673, 0.07368061062539105, 0.3187259708636732, 0.10152283291202539},
    {0.5207214704285029, -0.47588127043884887, 0.3195835530260285, -0.48018578056312455, 0.45093890112058393, 0.2768112131644019, 0.027756159787610833, -0.12869712828645222, 0.5019267469355946, -0.16871672553742084, 0.1977801924893007, 0.731929933409733, -0.020983330730471733, -0.07838587233223421, -0.561078437026953, 0.5865256165338106, -0.14392060153201947, 0.3145118765144863, 0.595216836079278, -0.6131144264220123, -0.5689037492202252, -0.6179458183477826, 0.5382387206892816, -0.5542381555223254, 0.13700494064406657, 0.5511216683543362, 0.10826908576122184, 0.5184225097315862, 0.09390105637665266, 0.044696302945056665, -0.39614251713664567, -0.4130314775706117, -0.04454138118565019, 0.49132645609094105, -0.08085472408840111, 0.37583143907008787, 0.625250154974095, -0.10812571403707981, -0.08827263461307773, 0.05416039399412143, -0.3125968770466996, -0.22896311457167656, 0.2981097086951757, 0.3447380396880439, 0.390820709142203, -0.3088589140506026, 0.26058488763791904, 0.47163090259810914, 0.5696268567993371, -0.016145467287578694, 0.0919553192914662, -0.018699862956669245, -0.6341971885175651, -0.6213415398846742, 0.43633870127926133, -0.4769738597158502, -0.4712104219536332, -0.25207079996974985, 0.39206026324728604, 0.3277493215164175, -0.02565658638387054, 0.19340825112477078, 0.3687143534530562, -0.18156010387182678},
    {0.26550502931141123, -0.30484871372681704, 0.31726098466182606, -0.34265938682334535, 0.33510634115741283, 0.5455823622540352, -0.1207098395443937, -0.22625980257575867, 0.4534041365558485, -0.23327295986546961, 0.12182621435277963, 0.5109319242322037, -0.0026443115768317173, -0.26093651560918, -0.32186704240160213, 0.49188711747092734, -0.07019968182105829, 0.12116316167275326, 0.5494898813932019, -0.6067992023731417, -0.5775632273950795, -0.4684930449516762, 0.5490176654468575, -0.61081977508427, 0.02248737370638108, 0.6420043484856797, 0.06239917508011985, 0.41499732135457285, -0.24222307609815108, 0.06976373123939439, -0.4668101713624982, -0.24340749713033422, -0.010008412665385552, 0.304651160662574, -0.06739716511748498, 0.6530976238572808, 0.6581635900894377, -0.2516993351082768, -0.368786348635522, 0.3137860069422379, -0.2974390441167145, -0.2837449128767158, 0.36523479071802584, 0.1347745493082012, 0.4944194244196605, -0.07038909555347946, -0.0985518155986277, 0.439723946169838, 0.6255836598833726, -0.3008867058415882, 0.3920055916298198, -0.025472715701708275, -0.589537230549243, -0.3707115189757492, 0.4858692476353073, -0.6008398540071381, -0.2562882486358197, -0.6535836220183934, 0.2030080355408541, -0.03158511414715811, 0.05052452739834616, 0.20452041351504888, 0.486286301063593, -0.1731663930222765},
    {0.18185216610754495, -0.3750445807367181, 0.38096527644665457, -0.023514395653960966, 0.36320231255146973, 0.2754516461140631, -0.1924149902039582, -0.32430036098382625, 0.28223020636763657, -0.2784774560403068, 0.12799720703641948, 0.4042350354372901, -0.024252051886922345, -0.1755621531888338, -0.38200271293732474, 0.4101213330945159, -0.20867653333997818, -0.005545323156331836, 0.45501560318363204, -0.4721371631000593, -0.4487943983829897, -0.5347649748681779, 0.24220335882547614, -0.4231314376327152, 0.04124461060430582, 0.5897673752643839, 0.3590315717043535, 0.04624612061164697, -0.03643627699043957, 0.2753390400119659, -0.39865820063068846, -0.26215823374244845, -0.14397516011917855, 0.09387617679398597, -0.31343149900069855, 0.5755131325060877, 0.6770613270900812, -0.0031106710929037287, -0.011165016783569305, 0.26476600986795373, -0.45672907297418464, -0.02270450318674389, 0.44329806086931794, 0.25608891272850065, 0.2901815505619697, 0.03923307051107271, -0.1060320392140999, 0.2875041172845354, 0.580287026520084, -0.041053578644597105, 0.1516174126899246, 0.12361715867739768, -0.421248888427435, -0.2689863435970967, 0.4138438769981972, -0.2868138916149763, -0.5649392849974295, -0.609339601553292, 0.26199454015524376, 0.2443198675507584, -0.21314334193155546, 0.16405463891115699, 0.393717063723311, -0.035875956847305},
    {0.269076094598311, -0.5646694625861399, 0.41370509053856486, -0.33637095415778984, 0.47907240173238114, 0.6117140574900265, 0.049647145047213875, 0.04779316725896843, 0.4349914179203962, 0.11818720236837534, 0.0193025419399344, 0.6729766497126975, 0.16957300706150974, 0.1601281643036115, -0.5076524416333104, 0.5911384559712075, -0.029261205603065502, -0.0026752101407919266, 0.22708026627706238, -0.20951701902373088, -0.28884006230200177, -0.417849738091882, 0.05874169984025831, -0.4310649131252015, -0.13184919708755438, 0.36441950640924226, 0.4368839107063456, 0.14371546873852487, -0.04487155103757851, 0.08651808396839948, -0.5204362555816552, -0.30265906084789646, -0.019830921540327305, 0.06787378087616079, 0.040278086623999475, 0.5211816429693094, 0.5133876931381323, -0.17644001622384256, -0.17841131625375578, -0.014217583298286046, -0.3100936802777591, -0.24407484730702625, 0.17635575636056575, 0.2925384471819362, 0.6273235890559525, -0.23207793616950148, -0.07946385888861776, 0.16954855296506094, 0.5235697772103481, 0.20410914350304463, 0.09651889968416566, 0.044710045612532674, -0.5334349047164397, -0.35738219936898286, 0.5743607110680153, -0.3536364090230829, -0.5492925677422225, -0.42485096653433885, 0.2788643761520471, 0.285422525834307, -2.7507544133317945e-05, 0.23654172920456482, 0.6010417580914064, 0.30918395022379447},
    {0.3125918296131558, -0.3330302127862826, 0.4439799702036276, -0.17857969492908216, 0.6736894149428501, 0.5633993514777658, 0.08293229232011123, -0.0729756416410536, 0.5977214491559355, 0.05030327075275431, 0.21533879788739124, 0.3819336202515377, 0.035249643009077194, -0.0913792568220856, -0.5263530741858123, 0.3365217102286695, -0.250126005385695, 0.016423313287124854, 0.22156863133997712, -0.41458621863071027, -0.5345680459969596, -0.5495769747752992, 0.18030375317979735, -0.5601864835088703, 0.2468081476446009, 0.26577916435208, -0.013838394554191148, 0.37795493647201495, -0.14477834977498366, 0.2098005547542247, -0.2044533375512385, -0.5304278005169609, -0.3886311574822998, 0.16683883412776926, -0.12057452994217648, 0.6299403677596815, 0.563620343822312, -0.4064019456111336, -0.4745566868325076, -0.03696824634008888, -0.26398577541786694, -0.0020467889735701775, 0.4641439800943297, 0.30490820329350526, 0.5946248684757339, -0.15424065438903053, 0.1652629764357631, 0.19764463165480645, 0.4979602184530236, -0.05707298796519721, 0.10492124501154301, -0.2172204014720224, -0.6410687421619893, -0.49718119347548356, 0.40559236956933126, -0.6337388931148938, -0.7130836661628825, -0.37347837077375406, 0.39109904110626253, 0.37171832943274585, -0.19149045089031852, 0.014566084208612535, 0.3307900901884966, 0.04920903780747846},
    {0.43791656482036667, -0.3552361491433931, 0.2270183353092648, -0.5085174135426982, 0.5173778568048576, 0.399237634706037, -0.2740700295068612, -0.16340800650004522, 0.4416382108096084, 0.08124859191428792, 0.12664396520588125, 0.565954209573287, 0.07770992879836282, -0.1884800468769719, -0.6548537591317592, 0.3391597933145469, -0.3236454464338241, -0.16279999193316733, 0.19608648415317853, -0.4108620665146878, -0.47390655045329405, -0.7249800198459886, 0.12411906028814525, -0.5246599337498528, 0.07441587693884152, 0.3873980431742023, 0.18898995345272926, 0.4263695976104735, -0.23350315429386148, 0.0026069385831000813, -0.21315586365000969, -0.5730650350049475, -0.32680790559280615, 0.1091395207662321, -0.3853298913377792, 0.5671914204775124, 0.6504457591870777, -0.13550360282512044, -0.20647440016539687, 0.07646080836431768, -0.38351326027944793, -0.22250202337986713, 0.24838769649170087, 0.24360098129210392, 0.5710654892162517, -0.17261128364373649, 0.2901939172670685, 0.1819674265076397, 0.5442845654115399, 0.15627511066674646, 0.40145733119931537, -0.1633161817589118, -0.5215743898594527, -0.3619296963522111, 0.6481543681063611, -0.38483203353955503, -0.46261661830866685, -0.33508347356428586, 0.26918071672576493, 0.07543040862543962, -0.03951482682911387, 0.34486871544943953, 0.4476974929615093, -0.0014841113516095906},
    {0.5643036762859702, -0.5101769591433335, 0.24237036287118535, -0.44140093145794984, 0.5402153047472925, 0.5026478486032018, 0.15854622772113094, -0.226050724112304, 0.6978837475144524, -0.11865732106549862, 0.3471495543550878, 0.61565645443557, 0.25778938377192967, -0.027379148750411423, -0.48051557442610315, 0.6623316417841495, -0.053439466113039215, 0.11569465238854816, 0.5016070337055237, -0.670364491620186, -0.3804245566629763, -0.5310159036380131, 0.1107544020768621, -0.48899171701502986, -0.12144871470451772, 0.5703376431172819, 0.10728347020795859, 0.4606765208322164, 0.007335766715143904, 0.10619330480953393, -0.5626032738318646, -0.556649115069383, -0.02668885122346714, 0.217685763732474, -0.25179696065752927, 0.528499866042052, 0.7104451620525296, -0.3844395012452488, -0.25004264679863597, 0.23145342456202653, -0.25146672204115983, -0.30157883968388627, 0.518575829378967, 0.4739477246668377, 0.6019612942963946, -0.2708675170855766, 0.03150706222870188, 0.43504034236268757, 0.6619849535951139, 0.14884119194016845, 0.31439326680818835, -0.07615327374208572, -0.5827733977269863, -0.7116634256163683, 0.5340974034251867, -0.2356170207383287, -0.34717768106177765, -0.555992561821004, 0.17132858288419525, 0.4244029138807508, 0.18864232530671154, 0.059859998017103455, 0.229890783662781, -0.02168461817510927},
    {0.41383086077874287, -0.5573777771273251, 0.19666269457460142, -0.46337373071332444, 0.6190517586093796, 0.6222521596584127, -0.11847520930713618, 0.0262283102913222, 0.37993823025013024, -0.2997842668285848, 0.0954474483078896, 0.6241983586048414, 0.03202100695401891, -0.14515775150530563, -0.4875624940311714, 0.31580408107295693, -0.07594699793391096, 0.3115043621075526, 0.5703268660724701, -0.6297166721813041, -0.5695199142821394, -0.47891854032631964, 0.07641976524377149, -0.6220662893079044, 0.01961889076093578, 0.37270254108005285, 0.12222577491635671, 0.4407277536598557, -0.13688211312723775, 0.10252841616107658, -0.37387006601043704, -0.5944052719712397, -0.021834444080560615, 0.38581346187075055, -0.35799505484121374, 0.5686079192533816, 0.6642535788457989, -0.19179718849656022, -0.33313040718407955, 0.33984552909161236, -0.5517598710981011, -0.22137366812415427, 0.3093455079091931, 0.5780824337910627, 0.6633102168969569, -0.28829864928305626, 0.10687370539224747, 0.3387225338755891, 0.6365691615506711, -0.011738347183034037, 0.051601423801699776, -0.06735545007171195, -0.6536397996679962, -0.5043572618281283, 0.4431708431392203, -0.47849509235543336, -0.35678394791606927, -0.4148631623612332, 0.3313814941757146, 0.222359305740536, -0.2894756364003479, 0.17847487257760605, 0.4938266981121837, -0.09000027797831925},
    {0.4054655842351754, -0.5898689250361715, 0.3692043609967505, -0.2911859411311002, 0.5460108131014436, 0.5412414863934458, -0.177496008318044, -0.18313597798236822, 0.5502000162064917, -0.3554943963976654, 0.48241707604035833, 0.6300632257342011, 0.1817485419775196, -0.007268015037762084, -0.5191526081186615, 0.35175429803129554, -0.06864620055523113, 0.024104911703212197, 0.2891927881970379, -0.4268876389036135, -0.5898336361914074, -0.5699998285401908, 0.42719345874948217, -0.5978965032745966, -0.02477034136926507, 0.5785755622972861, 0.09082911943076073, 0.18782394769211258, -0.03054803868731408, 0.2145700406055836, -0.26894038527534986, -0.6446516316377173, -0.26537084478515666, 0.4511786908730759, -0.04681281558553009, 0.48818510943915294, 0.7015631615728223, -0.43486242145888493, -0.4549743737889771, 0.3054384665927374, -0.20228288169823355, 0.11104495238875625, 0.17514097087672503, 0.5049954346373586, 0.6744022443982642, -0.08272850530429827, -0.03822886673999023, 0.0998395723839686, 0.4903223162092061, -0.17146970339696535, 0.18938042317490342, -0.2187737181997268, -0.6328113879814877, -0.640894544977336, 0.6777455329248279, -0.5756734097129331, -0.645418918535862, -0.6864745481442524, 0.2798626706965831, 0.38568200298258076, -0.33386466646269647, 0.19356666295771877, 0.4054310156080237, 0.03511035618889727},
    {0.3669154238635898, -0.6454110024670479, 0.08407068484787215, -0.5809029081506287, 0.5468513515957673, 0.2743566283171109, -0.13525914302255024, -0.26276822757322443, 0.44634294160771276, 0.012153031610188547, 0.4610073475378115, 0.449351321676328, 0.3214154756842163, 0.0024010691210974155, -0.5103773368664565, 0.46372412671496216, -0.14482235536993596, 0.15678567536576962, 0.42672747541437206, -0.5884791104808705, -0.5527778309706561, -0.46049485450686634, 0.3022046112125495, -0.516813028427845, -0.04306051182475204, 0.5924596977794255, 0.18138736315272302, 0.19052717629222551, -0.1920088481307072, 0.3676006360201692, -0.5104995690756173, -0.29578002379138923, -0.16485858549969948, 0.4302596081532623, -0.17345946612263988, 0.6571458063036114, 0.6419385896614953, -0.4757930716022163, -0.2079212403846694, 0.32536594735149804, -0.5398607558535408, -0.24417921242557403, 0.2549943955293248, 0.3027972717759276, 0.38285545013941835, -0.09643898521133333, 0.1720759756801771, 0.24914867835126783, 0.6014487233996655, -0.10800576003061345, 0.08831468777322135, -0.20828168556212592, -0.3168009982315062, -0.4972031921586722, 0.6309124539706842, -0.6008039027548914, -0.6592233432564849, -0.4928470118020327, 0.16096624996638156, 0.16791816922835198, -0.3801457392294663, 0.22764031427810302, 0.377707042569142, 0.06193287801948986},
    {0.2442856635294252, -0.3740334343703233, 0.3689484402427288, -0.3970932935281098, 0.6889369218478563, 0.421303188716915, -0.29208965539309545, -0.18599145739965442, 0.4179865160252939, -0.1461284459832056, 0.34541375708434024, 0.6550384749907187, 0.37890774307079045, -0.20709929742647576, -0.6188740579050671, 0.4458869002631893, -0.3203040283481138, 0.0047031893763213395, 0.504661887225878, -0.25812552265424227, -0.6562292047524729, -0.38231984717852474, 0.2191063109384993, -0.5229570071388143, 0.0201604383066494, 0.5591409509864649, 0.2962934937131612, 0.12441151629365736, 0.019376025317999042, 0.30232641335024424, -0.1764381881634392, -0.2942758810288926, -0.450954259592221, 0.4063400435656929, -0.14255232454440336, 0.45295853722470186, 0.5742777354666065, -0.3097590754094386, -0.23311786768387435, -0.036344029418760686, -0.3141954271985193, -0.06631481548065193, 0.38486233457311536, 0.4879260944448569, 0.39269603391329333, -0.35430900919525465, -0.017193157766250713, 0.15074395298739454, 0.6177827761715798, -0.16670410021342777, 0.28589004144832314, 0.0862334152954963, -0.5340700340267134, -0.4465123969293055, 0.6032950283353343, -0.5822252378610369, -0.3036668706546139, -0.30030646942739303, 0.22632268951195453, 0.2043899303543998, -0.08740893262244272, 0.3391825183951933, 0.49594867728765873, 0.126367159022831},
    {0.5836459495354134, -0.25471158685796663, 0.41183442521924696, -0.3803365027081122, 0.42729962920880094, 0.4562377284999784, -0.23139711576669114, -0.10277537930782395, 0.6115413903068555, -0.20503957825976818, 0.20822971223250455, 0.5341198324706558, 0.36411423761764916, 0.10206998749281598, -0.5673198309657392, 0.49805727699190766, -0.035298854852675844, -0.11882620640271163, 0.44249487947410165, -0.2652706430003951, -0.2971156238745345, -0.6708068835773584, 0.3144260258227586, -0.6010019104548526, -0.03896109370011004, 0.4725152512251297, 0.179471239131184, 0.23780281411573784, -0.02369160078742533, 0.2871114704773017, -0.4659677752441077, -0.5345698538336615, -0.04071928959629741, 0.536280631727609, -0.4519340587616416, 0.6032878713959117, 0.4837277481512126, -0.3653773929244201, -0.2906111397769607, 0.18724260420021055, -0.3559337025082095, 0.1309700193160675, 0.30212267794178527, 0.5229205556979649, 0.6712674924004252, -0.3021869085823221, 0.12670290369710813, 0.06941996374762428, 0.2928078176336647, 0.10581223301421205, 0.3409316891620784, 0.049837852617098506, -0.3966003828671765, -0.634003064737373, 0.7003663512269926, -0.614425763305983, -0.5850501171631746, -0.42182882546130424, 0.2722620571577489, 0.11919968761080933, -0.07076911099006747, 0.010534283434666855, 0.5876000964684105, 0.3052304240864461},
    {0.007953957585787987, 0.3321160032216826, -0.3470039273970748, 0.0608318888933293, 0.3696943204724711, -0.5520135100201029, -0.42670845419163805, 0.4211148087618763, 0.0032763119275200933, -0.4358062908878835, 0.25906610489158083, 0.2866529274104538, 0.4578537721334398, -0.6127593306021307, 0.358966761193328, -0.24696152416604436, -0.40931284797174833, -0.44002585250935483, 0.2603472938756026, 0.3042055378581524, -0.5080780871772279, -0.2523359414165474, 0.4098269321396901, 0.03618692216315289, 0.54289875916153, 0.41046669911977907, -0.5519234381737883, 0.24446301096571682, -0.5728279645670218, -0.14793967231298072, -0.21536826674493942, 0.09451921837919179, -0.1228925873881438, 0.5677632053571734, -0.29652351921733255, -0.10902922571533333, 0.48475366366317496, -0.431685702226634, -0.4515750753383194, -0.18914278664320858, -0.5570980308149399, 0.571073018480794, -0.3212693059372191, -0.4205647938633362, 0.10496592508985322, -0.6531014837814494, -0.12973358429452997, 0.46089541845773274, 0.27974981066503063, 0.5326027299666047, -0.22317689588141695, -0.6006512602577905, 0.07591429753979635, 0.2706680829383085, 0.3806902862316593, -0.27044664555917575, -0.3527420855942936, 0.08280411043761186, 0.1098390094290442, -0.26841191789956276, -0.48398809812811333, -0.40337402017692714, -0.4573801563979335, -0.6231957398104836},
    {-0.2126122601959889, -0.3451675236306988, -0.34329368669799276, 0.0029175165957837875, 0.06972497967272435, -0.0195212957933939, -0.22845062154677112, 0.22627402895975496, 0.1588347943331466, 0.0494871587575222, 0.19128628189810457, -0.2038864405671275, -0.14290408070097402, -0.4000004452603804, -0.012762505306110242, -0.20158042850647237, 0.03194503360826391, -0.20887063881587625, -0.13852561662215235, -0.11569837825326512, -0.47837698628637587, -0.19218225603674466, 0.17417693901939862, -0.45975510047498663, -0.08778964779725984, 0.107786407465804, -0.32956315812722226, 0.2244136644851155, -0.2313166106077011, -0.29498336025984356, -0.2760514116810206, 0.0832193536219196, -0.44685009075175286, -0.2254943979204979, -0.19482221969815705, 0.3257093108591121, -0.31361055622759876, -0.008707359711639304, -0.3662137663414285, -0.29934018409147667, -0.39976606706885126, 0.08204826743208896, -0.3652976325601003, -0.30937121786607197, -0.024900723753901614, -0.33304567930417633, -0.3330423852245634, -0.3399355189656863, -0.12525055427597778, 0.038297802744458216, -0.1424975362483563, -0.17421627893220523, -0.04769816408161681, -0.10882052244558997, 0.1966631301424418, 0.028257680919686057, -0.09871434313241574, 0.12109841333836092, -0.33220106570834035, -0.2684547006555433, -0.39846760899063915, -0.23971312579856788, -0.27669896152525575, -0.31115526688936646},
    {0.02561988662593365, -0.20391122574830578, -0.5602642941897603, -0.13133729231535274, -0.09202188332631517, -0.5050763435797655, -0.476468755085014, 0.42662136383806565, -0.12134561301034354, -0.06932928719785786, -0.2859268184769402, -0.09728264895476323, 0.1664044249906875, -0.557152719269264, -0.2616804992043456, -0.24489350231597862, -0.2445948149212061, -0.513846975757339, -0.05714290237328732, -0.34201628819171964, -0.13094486118859228, -0.2119457549215164, 0.46602469446817296, -0.06361191128170438, 0.28561872647427183, 0.04915990261643089, -0.2865844438451063, -0.024258186657798435, -0.560579330165768, -0.19540663002427466, -0.10657483863521812, -0.2969005886965743, -0.45641382262080615, 0.19176225085219495, -0.2031183379027443, -0.02236719663859749, -0.19476088856486024, -0.5410244984613991, -0.4604967457446556, -0.44954521145369675, -0.41158329343693173, 0.01996134990390004, -0.4786820263468018, -0.4780302305595966, -0.26534453190099827, -0.4375751493713608, -0.5666151239581118, -0.014963741131845591, -0.09410079368038742, -0.2934229832023989, -0.49207891181934454, -0.39195063533848046, 0.01829614912960688, -0.08963817052028124, 0.1529163066792559, -0.3490622678948766, -0.5951117642019272, 0.13858913388679378, -0.2596521385513756, -0.35840339213306466, -0.4489067711350633, -0.43064415710277315, -0.573852507810108, -0.31685448282876194},
    {0.06501870838651125, -0.2902363350925944, -0.14475201594007894, -0.28119340569372314, -0.44352761728394, -0.2839450811618954, -0.2641720888855535, 0.024197564844026163, -0.06822967566974322, 0.09524492213759506, -0.3243786681549988, -0.2452754591062707, 0.3337414669304711, -0.35585122616028153, -0.1093990085542338, -0.43997323290083373, -0.4163502476588841, -0.174958548021853, 0.17977208454849739, -0.3287100537587277, -0.05613123521434947, -0.0029095239299822178, 0.3485348310813253, -0.12228916733019325, 0.44194893299239607, 0.239077692365774, -0.20430239345296933, 0.21111940741258833, -0.3893964914238492, 0.12750484966533335, 0.00048094320789096096, -0.4072877710241726, -0.22530371976111846, 0.069287780142479, -0.2146905466335156, 0.15991589016848595, 0.019638042001685663, -0.2978710305881378, -0.47652913682945114, -0.41277680445854764, -0.1514234244768342, 0.2517536996764617, -0.2518921454949029, -0.12242245112676904, -0.20526271059096596, -0.459390369820772, -0.31651983876137163, -0.06062274406945207, -0.07994242578805119, -0.3444634920654738, -0.5032467043422569, -0.2546335886618397, 0.0027386560146434, 0.07275912945257774, 0.1977932322935211, -0.5056715471521548, -0.03704188847901601, -0.3564778525595184, 0.024508477437288245, -0.3220609803032282, -0.4458261988448463, -0.26384377915600543, -0.13880059095510336, -0.23210899285930867},
    {-0.42712357726433103, -0.539006645812446, -0.10226476727181014, -0.22347756932848295, -0.16035842253349494, -0.1701580597243138, -0.2963736934378245, -0.04249261963269723, -0.3805403339854302, 0.38646842339906584, -0.4834196898075964, -0.006784208616693629, 0.03270347298689235, -0.11503377014466978, -0.06669246961302844, -0.33330209160130814, 0.010129732126719861, -0.20842149934504248, -0.147910064067269, -0.31646031741694264, -0.25029218183925367, -0.43852754443214137, 0.32751856938713836, -0.08499131758370172, -0.21047553619835666, -0.3436733517450691, -0.3249084409005927, -0.03714179851381947, -0.23780373066950675, -0.6256888076030535, -0.43415827895836173, -0.1972132883500414, -0.41678697092962924, 0.0030747217065472073, -0.4122133273124413, 0.11226353460425649, -0.012685174487203387, -0.16784318050954858, -0.15613765180705683, -0.07506484482284331, -0.3494941615699201, -0.46471813613935614, -0.09394155427271826, -0.07819546903626226, -0.14135593191601203, 0.05131654701934813, -0.4274585888498235, -0.5245631742335537, 0.003815225554507329, -0.4787544338431288, -0.3805198895860856, -0.24185669883311364, 0.030190574532305683, -0.2531454521957616, 0.0859141604800353, -0.16158692673589894, -0.20944541417734736, 0.04738980034347203, 0.03501372712489881, -0.2952224921002406, -0.4178990918913932, -0.4386206977390488, -0.15540571653413535, -0.15842245976618574},
    {-0.14839118753690675, -0.5365473207215563, -0.1723397330986282, -0.3859697617977872, -0.4054950575424882, -0.15242423891180953, 0.024675500288312037, 0.02058957834943926, -0.3655454651700317, 0.20089063285178257, -0.38193127245734343, -0.04336254148574647, -0.1826952709653974, 0.048312700994252195, 0.14362061280487387, -0.21761448595058308, -0.11864748244314074, -0.23263064948673606, -0.36265891935112, -0.17569691895234615, -0.057177212499479615, -0.4417214307426498, 0.056463170806090444, -0.02851235479806228, 0.2281099027588016, -0.3850763462412563, -0.16920685049994222, 0.2759034144756748, -0.004173991557682841, -0.22879905197916922, -0.1594876187319043, -0.410047401954201, -0.5232926862105014, -0.09995503690339819, -0.27495108564304255, 0.16955778078978098, 0.04318983127637586, -0.09997900696199111, -0.399439980996971, 0.13385890807993073, -0.12778850591448687, -0.40714344457936075, -0.4532969045191252, -0.32138528249173176, -0.24607086021429364, 0.09243653466273624, -0.40876770891311187, -0.41999992384489854, 0.13291962835495563, -0.3958688632628959, 0.018063794185533097, -0.14826513854551734, -0.043282504065633574, -0.24686546251698607, -0.04581598061642116, -0.06519693633295733, 0.03219930402640646, -0.3502246395938068, -0.28554239122864516, -0.2560785559806109, -0.07284395365059021, -0.2706220024295574, 0.001385732639071002, -0.053834734909300686},
    {-0.4622075084462032, -0.25500833805133877, -0.055246471840692556, -0.32433834678787143, -0.47464619946027686, -0.39173997823174594, -0.07157706277739265, 0.12890303447377321, -0.2992090756426334, 0.382843605400645, -0.5522715211585565, -0.24053766429011755, 0.1910232116415714, -0.2205379963692416, -0.12756234162496258, 0.04489627770445475, 0.05280108681643775, -0.2785243650525635, -0.03491437656386971, -0.5392241923460203, -0.5483804896410567, -0.12623902521726188, 0.20891846469028905, 0.16457695161187802, -0.10708119338102837, -0.14113609444601263, -0.2651550747168101, 0.08873599779444036, -0.14351086844407937, -0.5287601977535422, -0.30724294607101965, -0.31402649727062865, -0.5499129401433768, -0.22797767576054848, -0.33064022050775166, 0.08335521987468326, -0.15683337933120034, -0.23218254076659092, -0.3847214300872992, -0.12281385567306913, -0.396020991307084, 0.1621621685508881, -0.5479762546926066, -0.05132140166183131, -0.1950141667748233, -0.23239451589867055, -0.07850799146054216, -0.2935898511923915, -0.04891116226699795, -0.5543582363526824, -0.022808538228639538, -0.3598330384989622, -0.04061188576343069, -0.3740113604196374, -0.23280667524508722, -0.1422054114410494, -0.2913970038153824, -0.28745097083899834, -0.04117201651093175, -0.16807019776038204, -0.08685787035245124, -0.36897395465861077, -0.17421460237278585, -0.17101638518015502},
    {0.06786673727827833, -0.3349808491499803, -0.3300070015939517, -0.2112224515991995, -0.30659682359586266, -0.4664247021911285, -0.18164920767616793, -0.1203809517870956, -0.3458017105848864, 0.332405271345589, -0.3462026268293977, -0.19264591513485313, -0.20321490022836058, -0.3396418482058209, 0.09067887335720776, -0.24034680809317155, 0.08639091891815953, -0.36416185040935084, -0.1138883733428475, -0.1756868827164926, -0.3483511105591023, -0.13960811163246684, -0.0857736992052855, -0.12985145785095803, -0.18501676774446227, -0.1315292166550808, -0.01763910096635611, 0.03124646898809367, -0.30153873071659704, -0.0497011708307644, -0.02181546354998023, 0.13177179766246605, -0.41317147098746043, -0.2079816704742341, -0.19047739660621205, 0.08140742491873618, -0.1724195663497366, -0.24643218727096936, -0.3059996713200491, -0.11697245022384133, -0.41388171871858837, -0.049004790531055435, -0.1995582934382896, -0.22432504422639465, -0.22489265550503482, 0.022537451597850068, -0.19725391917842688, -0.19921696137394485, -0.14738768164392935, -0.34058871970859145, -0.16588741904125018, -0.038727427460673466, -0.08633833398383552, -0.053936169206111925, 0.12157718893129014, -0.25774650085731315, -0.01757841082008322, -0.10678993470731639, -0.1904679133293474, -0.16503291277067197, -0.3638802351678684, -0.1818248004267616, -0.12364858907256089, -0.1287560636133142},
    {-0.40963808407844216, -0.44522702358196536, -0.44841329130000107, -0.14937910618166403, -0.5603260863008233, -0.26485696593696767, -0.13463210258423933, -0.006913664351259188, -0.26289686104307225, 0.04058104640169137, -0.5520566084224225, -0.38495859277138794, -0.4450461462838382, -0.3012972239323783, -0.3045299852019752, -0.2595918471712533, -0.40085353217829844, -0.34935011772285685, -0.02042970029247317, -0.16655533715114232, -0.16366221266045833, -0.4418849804782893, 0.1635701710621211, 0.06602821842942869, -0.03855340746737601, -0.34420472078630476, -0.2161566358281968, -0.05742857804489224, -0.3302537249282538, -0.2236511946186042, -0.30324649939647563, -0.06426561006348684, -0.5253871518938791, -0.1367381667095116, -0.4293582276967067, 0.24178526136353487, -0.4160811322838013, -0.19540155263158876, -0.3150765225517612, -0.30123212048968956, -0.3662552688710813, -0.2763913497596795, -0.40204351897934826, -0.3705702080697442, -0.16118882015641975, -0.13300793289273322, -0.2181369784276867, -0.36063287633661084, -0.04028896097974262, -0.589555186936945, -0.4391679361245949, -0.3416655874602761, -0.42207234014862205, -0.2908763152401817, 0.18503584939265486, -0.1964662570007487, 0.01712838865454481, -0.31151720942812045, -0.39249990586457756, -0.31113861629410655, -0.1313302916113218, -0.5006670267233612, -0.4282565248470232, -0.4046550688169094},
    {-0.2507509990394087, -0.3386890531162488, -0.3667821287328432, -0.353627192856788, -0.5212806000544045, -0.27909249983371986, 0.037629922766087905, 0.16193117067086757, -0.41719062293416537, 0.08042177829762019, -0.2668116348354192, -0.1624402109373959, -0.30696965807128374, -0.16351762553362043, -0.07712737344356926, -0.13711828544049198, -0.3284409654044774, -0.014883361767941857, -0.2327767708583926, -0.332258660532789, -0.00111158962447313, -0.1110342680514469, 0.007610601022831479, 0.1146780146630834, -0.22535203123813322, -0.33089540332996026, -0.09390754506411757, -0.19254121577183414, -0.11772297676319245, -0.42847023670636186, -0.4556058216984085, -0.40996311699930255, -0.1781388403669227, 0.21375717731791077, -0.37578817908239887, 0.2929371168877535, -0.16668374360547347, -0.09997326135466222, -0.1995327492226308, -0.140388371039896, -0.03325571924731738, -0.051242692649628656, -0.4541730711169126, -0.30408156895276744, -0.3363985820948348, 0.027904280113705663, -0.09847238774360706, -0.15437417071866116, 0.07150949430268902, -0.35461188266152976, -0.42752774272744276, -0.28782378028358097, -0.08647147315370404, -0.2979478066137186, 0.20395143752858638, -0.30978485669696704, -0.08954461491151916, 0.15813613204166663, -0.02201525331231993, -0.27276530257899406, -0.11323784721327412, -0.04286908908504728, -0.3583378644765307, -0.3903287539347014},
    {-0.3551341156404855, 0.023706559088954117, -0.17702069401931256, -0.08962090598613622, -0.44330903926091597, -0.4790832726364514, -0.38771659312949, 0.2143164640686774, -0.2017454571249075, 0.11098010885094585, -0.40584651817853984, -0.24033624567682224, -0.09557816783202161, -0.47212058824112085, 0.12844336653412927, -0.4427850861176121, -0.4030756354129519, -0.26192357085707096, -0.21701962963233729, -0.3877176000986875, -0.34189347998275293, -0.520872648679628, 0.2658980307764132, 0.31118630639921235, -0.1632002470611057, -0.2736254391967957, -0.2403055006283888, -0.08182899762182856, -0.4438902523325997, -0.5673985646587503, -0.26790920169197013, -0.4401669743100348, -0.36083660315219784, 0.27146486590015556, -0.4561144091985649, 0.08592094691334769, -0.08374018333174094, -0.5778147675071627, -0.3306605130756969, -0.28024087811140447, -0.18214070258946571, 0.1408950889532591, -0.28104368996202345, -0.13588688536297408, 0.009379745897161446, -0.3159370230906734, -0.12344354806065466, -0.1489378169627414, 0.08912596003655923, 0.011972544303119203, -0.3653265870471706, -0.14792980622540317, -0.044651075407891615, 0.05114530912523352, 0.16671719218613096, -0.12984909797445673, -0.5181293530050319, -0.11605791383237615, -0.21402561251188515, -0.33991596739362645, -0.30902777276500953, -0.31308283663860315, -0.3638514272084428, -0.21312029795432352},
    {-0.4125402529755281, -0.16710765183657686, -0.5434995461519836, -0.4198697826593363, -0.3434711116182428, -0.19686398416094297, -0.21224398016611554, 0.2542323519988534, -0.015690650121718577, 0.34147507432913504, -0.30158238393793035, -0.19806640304248277, -0.10814037056558409, -0.4537636200599576, -0.165821010083393, -0.11300577250161425, -0.25176849891514147, -0.4330656522797385, -0.05341326828541948, -0.32622990043114697, -0.37476603478003456, -0.25698975358039894, 0.07303806333429629, 0.2399717071594674, 0.10186739392983224, 0.016086130102022724, -0.19625538658470906, 0.19371778036668397, -0.41355875482284027, -0.15499959771317792, -0.31099672778014964, -0.03267714878565404, -0.4682033827613768, 0.17642448165098382, -0.14537663889766608, 0.03333543147407958, 0.14113141961305908, -0.5358708230770058, -0.43818767232212535, -0.25057402666595197, -0.17261824751907084, 0.06552991713528888, -0.21036266734298703, -0.19470679842095204, -0.09363306816308357, -0.12618766611600327, -0.14345226572886188, -0.4022621484413213, 0.04493346746009914, -0.060434669008689566, -0.3119081245858992, -0.180924527015612, -0.08036690691367632, -0.029659409454383945, 0.09414454069852858, -0.12472237772483018, -0.5563643696768087, -0.11587045353520335, -0.19177854397850985, -0.18132730112930312, -0.47271214859939864, -0.515964783153186, -0.2881119958650678, -0.18742320879861757},
    {-0.45030107756640814, -0.47352178440100007, -0.6370216350083072, -0.1955472454770758, -0.19847521708794996, -0.4782293185573398, -0.26280742832810916, 0.2111511830557986, 0.03188798724403942, 0.3305357475676611, -0.40128037452605325, -0.41708168235284765, -0.04194489782911908, -0.04422440696333002, -0.21217479144692303, -0.24026946803923444, -0.32536607399570683, -0.3269597352951013, 0.06238525323993109, -0.10485017819708056, -0.4733886235367859, -0.5199254724840915, 0.3453630420945267, 0.1421416642126187, -0.06585706254303557, 0.051152756940388726, -0.1336858344383808, 0.05424610702905619, -0.1154348603923013, -0.1468669832824888, -0.2975082961698386, -0.3751338800911596, -0.44490624874161394, 0.35475751714192394, -0.0057812469083983655, -0.11418824342287678, 0.16072977746197203, -0.40254842073473546, -0.3786693344637365, -0.017549262688650896, -0.30672753346709064, 0.14549242770950158, -0.23328354526077896, -0.34632720007815987, -0.23008587724881055, -0.36037856208264085, -0.21213084999487758, -0.21791220944800857, -0.12002050150895976, -0.3879255964387631, -0.6117905207221204, -0.11630230874182228, -0.17957390326896125, -0.21150686191917728, 0.28167219154851253, -0.30864001532442686, -0.44968422770202604, -0.015794192499044988, -0.10145752354191698, -0.1076773030879305, -0.2405268346089747, -0.3912113989420542, -0.551427355169573, -0.24121570666519038},
    {-0.3924832604457519, -0.41048803351012836, -0.5204407370719354, -0.4439762177054127, -0.3308672923382912, -0.48851038437177224, -0.029517041314434816, 0.173632295531823, -0.4053097473912066, 0.001669110363541264, -0.4958142131394632, -0.5036505224084388, 0.1294908662225305, -0.2780647805253877, -0.00918029838696601, -0.14832908407117987, -0.15593418819037758, -0.3732836773457288, 0.06848013566310501, -0.23026125752417656, -0.3683422848207799, -0.5316029721326789, 0.38987641240547183, 0.12344223624433917, 0.27143484308372345, -0.25746553648348314, -0.4585269878528587, -0.044778718042400405, -0.14301655285353357, -0.5224777558918852, -0.06087029639377706, -0.005555491597945437, -0.5938822524842076, 0.25927199903355813, -0.11896171055169856, 0.0056833448094462434, -0.176727188144646, -0.22615469570305435, -0.4389207202382246, -0.23963389313241007, -0.19140145939510386, 0.21377053086568193, -0.38403910986012985, -0.5628367405071505, -0.3785834745110064, -0.28562049649145393, -0.38274407612837574, -0.254428823942708, -0.09875693446368645, -0.3578296847247886, -0.5669831784415071, -0.2813334902210297, -0.07397480763327915, -0.09525395448281813, 0.2009922747609812, -0.07523295939450853, -0.3234796762046601, -0.20248906576932102, 0.0030964688678755876, -0.13128059914526685, -0.21243465418639568, -0.27502281000274664, -0.22010386571651339, -0.40981671905740735},
    {-0.47856734642512155, -0.27350740784926003, -0.27792812468527384, -0.2631423513412027, -0.43731429730804966, -0.3738369056808001, -0.1673288869002428, -0.038186401080707824, -0.33563924149104596, 0.029292045347676952, -0.28669299777507984, -0.3444088244964216, 0.04830003076785501, -0.3477566239950169, -0.00537443654425774, -0.08325894256187671, -0.46481009298046244, -0.3580563911841938, -0.4141648655216713, -0.30437416628830666, -0.29500480826168024, -0.5017502934039321, 0.5180242150762366, 0.027550462732807736, -0.10121895582715092, -0.20045846674966541, -0.22905825616128037, -0.11662757271245519, -0.3005641131060594, -0.33019707911583907, -0.4109430346994169, -0.15351765543858978, -0.6924853975702286, 0.22949494247988123, -0.18507070870091943, 0.0887966068309688, -0.022612185383555167, -0.48783728872850557, -0.607255308857359, -0.22960764190278568, -0.38133796284176863, 0.2525046547061451, -0.6045021828772376, -0.4989022490608842, 0.027875053103017376, -0.3449164827448075, -0.5328903679748624, -0.296915463476771, -0.06037572699038686, -0.10270294144097193, -0.22676740979313886, -0.1296404412415222, -0.338323155859542, -0.3884728341002714, -0.10799185002886062, -0.3044705848261184, -0.36937539365710403, 0.3025215470048036, 0.039824573226463836, -0.4281547534568821, -0.1738893868531047, -0.5314185089457283, -0.428771880389535, -0.12815059148421726},
    {0.05579670420178054, -0.5707885015472398, -0.5916506503560237, -0.665024708260913, -0.4115394922352919, -0.39974977219700536, -0.2982211793336887, -0.027958307167418227, 0.013686933126796615, 0.20175630699103517, 0.04483426993132604, -0.053306132279871514, -0.027228961488669212, -0.48862233456265897, -0.3932474099352603, 0.09294040500597714, -0.5358004701940147, -0.45034422730886414, -0.19191579369384534, -0.44330732738093853, -0.36625532771940383, -0.3072559611276171, 0.5285495213692362, -0.009894444968111406, 0.36622295955396883, -0.2717794156726055, -0.5678956900657913, 0.047887293656270626, -0.38213680158848634, -0.19158614261829512, -0.5172543321504927, -0.4860498059723853, -0.662303577084309, 0.1437970085026653, -0.38292885059979365, 0.23211925388564605, 0.1990932554671488, -0.33157475001550846, -0.4187773981996211, -0.3255926248840812, -0.29163785012118015, -0.07157338773227982, -0.5755065501536103, -0.43770452920262737, -0.06417055068890608, -0.22328870109187726, -0.6491529203588691, -0.06618792894005233, -0.025634581368542592, -0.39546609225296475, -0.32205098737078, -0.4314097602584408, -0.39862477467041635, -0.34820004775385255, 0.318936973851804, -0.4850932482032893, -0.46771136553395964, 0.1614490937152575, -0.10435388175625872, -0.4145828077065491, -0.4213183521200798, -0.2516779439042821, -0.4867010763844537, -0.4822334786469111},
    {0.05386841560132398, 0.030511047099413623, -0.5562156850557477, -0.648348899917758, -0.24145505087650174, -0.17934312251738546, -0.4762744399267598, 0.4228292603961616, -0.1325460626753912, 0.19088214230436273, -0.22786729866682917, -0.29692026333710775, -0.07205716167919668, -0.15441189054574303, -0.055554239014843416, 0.09513815673026718, -0.46404369476378715, -0.36339457248566104, -0.15826546053838392, -0.5942167035171941, -0.15146684761421075, -0.371546198065562, 0.3985566883217784, 0.13356007094627703, 0.40008701218994575, -0.06741118844743169, -0.35720835210937635, 0.5284038304083201, -0.2924070006286185, -0.16990063525648819, -0.3298703130539785, 0.12671302821355632, -0.5768973549587165, 0.28179889273736236, -0.43607782486271474, 0.42358715412862863, -0.23275720214106116, -0.4091451022123304, -0.3878334184187718, -0.29345481563092113, -0.5497851244012424, 0.012196916353580658, -0.4901621588764524, -0.46269911030181987, 0.060801629089984044, -0.31009520088937836, -0.5653182494943678, 0.1565468441312387, 0.35586374150596617, -0.16916134036206926, -0.6150615827337772, -0.37352263357671406, -0.0070418104396589585, -0.11206356889311893, 0.28540445907878403, -0.0519965059211391, -0.3688125544885187, 0.273527797324785, 0.28600016400273914, -0.2810145216063805, -0.22145127478713364, -0.49973323924513685, -0.2410890947308677, -0.24971429742995513},
    {0.1875482954218951, -0.24963848437015598, -0.2652283595138838, -0.5429009411896175, -0.2865078898324437, -0.198462689703206, -0.40064884625972313, 0.02440612717993795, -0.13102236093945624, -0.07098672006663334, 0.0544557833032678, -0.11967797457435032, -0.1446772843994545, -0.45610331480831745, -0.1421270100927776, 0.20903342165346084, -0.5086978257170193, -0.30861431312001636, 0.06261829432162298, -0.45772390607976593, -0.4738293780902974, -0.19589725072269032, 0.42814030700106404, 0.10060777096372459, 0.49874379844344663, 0.1172136802662244, -0.4078210731159639, 0.13040870572256585, -0.3762884154572576, -0.0494190910716455, -0.015345475562820898, -0.21680458977426195, -0.3763884675027102, 0.17239330735914032, -0.558520893422626, 0.07355769815862025, -0.004837657137022874, -0.16725137057554207, -0.5171554677947733, -0.0948243751820752, -0.3476969555362913, -0.09283479005269883, -0.6029067920236658, -0.5682586433873493, -0.062141406289599396, -0.13044447859838051, -0.6207386584095022, -0.05890473542973247, 0.19891638551734772, 0.15373850543858242, -0.4769032805687684, -0.22740805741448655, 0.10386936268059349, -0.29388173717403493, 0.2878798447779504, -0.2569066393688777, -0.48925733426852447, 0.19350271390031593, 0.32581926220819374, -0.4142869525381622, -0.3504038633822882, -0.5428323360010331, -0.5360986023695349, -0.3857178888928664},
    {-0.11931529582918872, -0.06119071330584694, -0.6416942279765508, -0.36603077137397183, -0.29295589132062827, -0.46780325159165465, -0.49534979566881016, 0.4711292930618241, -0.18179479319418185, -0.06389337412774572, 0.010801463217618072, -0.3423957598627636, 0.36775155506711554, -0.4646992388554087, -0.0575331622803585, -0.10395307720886934, -0.4004216512102217, -0.5430614300369377, 0.03370142392863998, -0.5590069986895219, -0.3885530166582517, -0.43537367769696206, 0.3562668462033961, 0.2494054125484876, 0.42863788495891453, 0.07276016857505649, -0.2952340651660055, 0.42879462023582154, -0.4271509993897872, -0.5418951360991764, 0.004957140805058299, -0.35462393241489276, -0.5344347144927758, 0.39109513582403943, -0.448232090979943, -0.07152306649827926, -0.04341496461642263, -0.6106840482071244, -0.6726200781137875, -0.277928358062564, -0.2728975960428659, 0.08546318677805706, -0.4721628320033947, -0.3639746072107639, -0.11601102365497853, -0.192920138998144, -0.6015834636125891, -0.11562145590481945, -0.05919983688257491, 0.09358321082240628, -0.44498287571906103, -0.032635115071319415, -0.379033038583664, -0.23357984947430283, 0.4027202445156958, -0.43400416128668556, -0.4753240661302882, 0.06674743296778678, 0.08752832984795306, -0.19930093807125093, -0.6160217054398022, -0.6216207721725044, -0.24675592469730048, -0.5303951589969889},
    {-0.33233799346225645, -0.12781507864855418, -0.5994062502156502, -0.5486607824086094, -0.22527303566768458, -0.5469794742550798, -0.30931100868158595, 0.3249130650619842, -0.025330094782065254, 0.25759488574634626, -0.3465283850750379, -0.4947050794422925, 0.1957920744315595, -0.3287315423952899, -0.2948041170751294, -0.4049989871389671, -0.5224297398144109, -0.27418414327393253, -0.49050803450615327, -0.5138626038587114, -0.6019176262622051, -0.5771406684921634, 0.059629812311665274, 0.14386832229627816, 0.2374567242715343, -0.11955420211878491, -0.5652241396378692, 0.015022172037017265, -0.27338506877147206, -0.2974387602359708, -0.1937548088386341, -0.1580925251479327, -0.5847556209299198, 0.3096767061541122, -0.4320666666322892, 0.08693004455514365, -0.2714346251684517, -0.2588220839510081, -0.5632716147053155, -0.2280177266749921, -0.5945729545891945, 0.1570757703987194, -0.4336786145892091, -0.4942822351459786, -0.2837636875104587, -0.5397304781565028, -0.6274339258925242, -0.47365987281665045, 0.009297476474128957, -0.23564694144772746, -0.657171041646659, -0.09507448565933567, -0.12342296447349096, -0.36020917993492374, 0.050590600450540715, -0.20215659968069022, -0.3491643020531493, -0.014299506950819493, -0.13862565789641526, -0.26750830779334805, -0.49729299321207193, -0.635073568323185, -0.4300697059248321, -0.26251072917730633},
    {-0.11771202324924998, -0.2966466497963348, -0.44682488078182814, -0.40703098027040413, -0.3194096493895988, -0.40733119712123833, -0.20636197528373082, 0.47826246648546816, -0.2521942370059387, 0.15217609602391668, 0.028673028785757237, -0.2368096053815689, 0.27793656178676235, -0.5541336749287971, -0.11460901463897327, -0.2467800422414408, -0.5414850821434302, -0.3975047755328529, -0.39479135405083304, -0.5672334040090352, -0.37998378880699224, -0.314473801916742, 0.2013865395290377, 0.05942207255296003, 0.3061475407535465, 0.05519206612134071, -0.46203718611721606, 0.44912995632643377, -0.4141706358303156, -0.22009888669538166, -0.14182058639391104, -0.09811229583638043, -0.710584166961995, 0.1490217538243222, -0.39025546866673266, 0.38267567379646383, -0.19619101371590958, -0.242814208463173, -0.7024112624992427, -0.38591260201014743, -0.49601225105423324, 0.026923651196863387, -0.5673211046062837, -0.24325111608858407, -0.05664125129003685, -0.272616249367806, -0.497810612349828, -0.34907526902674657, -0.0715872622276741, -0.008758044769838295, -0.48118315016329666, -0.3081018010659085, -0.16383959649201651, -0.2848434193043237, 0.3197769434954804, -0.26016976998743263, -0.3298446345242518, 0.29379905057899014, 0.09533975079767608, -0.30602308409901824, -0.4560974486644318, -0.41830191644663767, -0.45600659646744884, -0.25823361127305194},
    {0.2394600029825261, -0.3029468338810767, -0.5691277078578617, -0.4831373692380714, -0.2906202515654198, -0.6115507474858146, -0.6127667209066918, 0.5450110876638345, -0.16884869172406655, 0.20823653783471618, 0.3143341065415519, -0.11031813150888978, 0.3110797475360464, -0.31629827176370495, -0.06697360910156067, -0.06897946880674681, -0.47539741229720556, -0.24932358706927882, 0.17427856562660413, -0.3875623395323401, -0.4069337296779944, -0.6297384576093155, 0.6140869983482506, -0.08522080956328315, 0.3584292783849692, 0.021526489858064674, -0.4528717838340934, 0.5445400887414044, -0.7000708161302409, -0.15816621559218316, -0.2014970674502013, -0.10139926594548396, -0.6649543611537881, 0.4357805571936526, -0.4820222796503511, 0.38391973770652327, 0.27104259355691035, -0.44461819298501076, -0.7768199655167976, -0.33225535311108956, -0.5324836786941762, 0.44634818642153207, -0.6499368414476235, -0.7041417111845515, 0.024791815085338318, -0.5808099155792332, -0.6904884100205223, -0.22329744633829515, 0.26147896689785516, -0.029621356738450615, -0.7345933828371045, -0.3861469398843037, 0.04936728189524846, 0.14939620435609013, 0.4156170017156884, -0.2655676493222149, -0.48411049730244216, 0.32944804130073674, 0.13376773328148098, -0.529471056448532, -0.5356717923579158, -0.4429283620938354, -0.7212124926857573, -0.7273756239332371},
    {0.31836176918018194, -0.01020361593383421, -0.7352284133966198, -0.5095323820974639, 0.2659745446831755, -0.3282276489625806, -0.5031226542996329, 0.6566964552347113, -0.061324610920030415, 0.016970573288840406, 0.5274400466053092, 0.09115863309403378, 0.3542783559082774, -0.45535888937938174, 0.3090869739035775, -0.04761016524970199, -0.7313564289837796, -0.6096935305758487, 0.2345729248268954, 0.03213712438749114, -0.25687466013990456, -0.3422807949783586, 0.6779420739776691, 0.2279407138403944, 0.41949081474843264, 0.2804085267434126, -0.3260668248521556, 0.3469688670345002, -0.6919598517960671, -0.1893068727238269, -0.017107574776972955, 0.08546489260633622, -0.7746468949699973, 0.5860548269698982, -0.4848548374900567, 0.604691955136713, 0.3043912076776942, -0.4878005734119438, -0.8135556735802745, -0.3004746478767055, -0.5471899088122185, 0.6074845947395272, -0.7617769233769073, -0.520959161235859, 0.38787714804553025, -0.38993945444498773, -0.3760013974760479, 0.05467902907358737, 0.3844068812951276, 0.4912935805885914, -0.5659304975281099, -0.12888866858141934, 0.040280748254867944, 0.10565395276564256, 0.6024579813634211, -0.47741200017473745, -0.6201393576811848, 0.5154609324535133, 0.22347123944581315, -0.3004981998924002, -0.7169900926332248, -0.5197884149243488, -0.5441773057945348, -0.6329693369698859},
    {0.030613455277928355, -0.36038636859983386, -0.7869026845311363, -0.5227442789147883, -0.08500277346907338, -0.6685908492811908, -0.6462275969599193, 0.6080818718882741, 0.09247538480588471, -0.11423971837617528, 0.1400845516713557, -0.15933102646791641, 0.3927252441171447, -0.4204431493984236, 0.06475237303673143, -0.035832673764931856, -0.48906972379522945, -0.5370803628708544, 0.3085265058826611, -0.34787332642330393, -0.6255227082543107, -0.3106533489657622, 0.5987545828206247, 0.06589246300168092, 0.63363489353811, 0.20965798664195298, -0.6867161041070855, 0.451654566411896, -0.614723620144421, -0.13425355919792895, -0.4178984634602263, -0.23699831975478675, -0.5253373383730767, 0.3913268159248536, -0.5828239660313366, 0.4708100129994629, 0.1306299353881946, -0.4987841263558642, -0.5300498100263836, -0.3904701054728609, -0.5429086031259858, 0.28622331371542686, -0.7820201132015592, -0.7203409006460405, 0.3057993108178058, -0.3101587643657113, -0.3756141031771754, 0.19731301771095192, 0.43199485310520486, 0.17498729154420414, -0.6475354140152858, -0.2507637795591951, -0.039652775072344625, 0.15911653558594763, 0.45772514767032263, -0.21535142890976347, -0.3767529035317645, 0.3554950520216992, 0.22089270473694272, -0.5510075041033891, -0.5833909623063175, -0.6486114665387676, -0.752041797618949, -0.4666390858460551},
    {-0.1685335388301563, -0.5730478325057698, -0.646693410425786, -0.3352128683998355, -0.24247915275404025, -0.4038452354956373, -0.5096401083904321, 0.5003643676810293, -0.02862004562831004, 0.16873437254907228, -0.08253416975121572, -0.3996172161174805, 0.1731484320046097, -0.4140809300228287, -0.2500779706503563, -0.41482948281229154, -0.4959069298709517, -0.3486138295299027, -0.003658488238531489, -0.2769293963283405, -0.384895881563659, -0.7075787490045804, 0.4504238936607128, 0.14554097126190374, 0.47629465832873064, -0.3243298371374324, -0.42409304690366323, 0.4055731723269347, -0.6489167631284137, -0.41643920928320044, -0.5683535586390608, -0.3179931115105544, -0.5772810329718888, 0.09151437427121353, -0.40254963905778735, 0.2786842965401254, 0.16830536014893493, -0.5093898583852134, -0.49992873023857126, -0.5974696915972632, -0.37410994155145433, 0.4030710271466625, -0.5278313428229666, -0.5259575545718382, -0.25287393033139954, -0.32653554870084495, -0.7119885503255172, -0.104480229633424, 0.14142221448738374, -0.24905560109396754, -0.5609486213025198, -0.30479111028985667, -0.06577816188967445, -0.2050543709668818, 0.3477307462019097, -0.293491379161824, -0.71523550302243, -0.1658540942184062, 0.06134230511146524, -0.6105958188171718, -0.4280289918217906, -0.6265399076375504, -0.7123286718730242, -0.5690215276589308},
    {-0.009266268688123273, -0.37500782943179717, -0.7503499814594572, -0.39404803989206205, 0.04290937502635163, -0.6418476990707469, -0.4033449565521015, 0.25800504359439336, -0.12692271790082604, -0.16031714204946942, 0.07220006675727046, 0.12528103674197505, 0.3897133596539943, -0.5230270172260079, -0.16674611103318612, -0.10603527223661173, -0.5112105276059172, -0.3458743192983515, -0.11853767683559459, -0.47863900528501935, -0.4242234603600599, -0.5782543376687179, 0.6884760174963229, 0.2157655904973918, 0.6645878210934243, -0.041061651901342255, -0.5306983150908223, 0.37571238224414694, -0.5515392942038696, -0.393379192238301, -0.34367216467167966, 0.027285939309867967, -0.7239730282827616, 0.5148720508583806, -0.45426678133695736, 0.32123593084313284, 0.17367547195618951, -0.3068932997542003, -0.6478255090534591, -0.4254039189286885, -0.5741909222046584, 0.4364099174564353, -0.7150072310920309, -0.6649124460762219, 0.07111074501011287, -0.5764107174551083, -0.49157727692032704, 0.20705741127991575, 0.39621692952130705, 0.1271334042778991, -0.5272385145839026, -0.3737134342852965, 0.10276144110897616, 0.023817977406291557, 0.44268195623578926, -0.556174806308073, -0.7040674461298276, 0.2923210015778147, 0.17047453847949584, -0.4335775223014203, -0.6018032079659185, -0.4280867129560128, -0.6788155113593728, -0.3813012557135815},
    {0.051801220028640856, -0.27530493434712816, -0.5409161900461498, -0.46326502276025433, 0.022029379984274046, -0.7663004946657124, -0.6696845880256619, 0.46296468037680655, -0.30577282871055617, -0.12736665760644045, 0.03187894600656563, -0.03387314830088726, 0.5062149753898435, -0.44694309520633063, 0.007470578997080791, -0.1482324837390694, -0.5600288702278238, -0.548922647841659, 0.017515614589304625, -0.26515233885377365, -0.3862666221932708, -0.5388878429834348, 0.6971471721314368, 0.16085888998149603, 0.5903259584852705, -0.08222073615600313, -0.7148702725144463, 0.43965439822336394, -0.7138968437112432, -0.3970581812720867, -0.17917969056799896, 0.013378380603870452, -0.5456827854928994, 0.4996628435868368, -0.6624734253444446, 0.19520918647289906, 0.10329263755370796, -0.45984033843065175, -0.8331633971574532, -0.5922918584079601, -0.7313482527572328, 0.3292836910901379, -0.6561009380344038, -0.5947234363463202, 0.1642464241157534, -0.4471149386483056, -0.4081502439720551, 0.0924885846104177, 0.3655504931836041, -0.07133525555891468, -0.7877165242799736, -0.26835346284614653, -0.17572654721341305, -0.03563689540382801, 0.4079201647515792, -0.43538319363219813, -0.727478308273134, 0.1307319220304124, 0.17630421546742323, -0.5058424460312805, -0.6512888890045, -0.4184778744186355, -0.5160233491393891, -0.6882360520823718},
    {0.1418650918592881, -0.11700532364581631, -0.6265715174660541, -0.48305510989205447, 0.013775836511623866, -0.3981108099176084, -0.6223138977727287, 0.590375228429646, -0.2531326465571171, -0.2382756547905807, 0.02980727172381297, -0.007218177680841966, 0.5050318355738342, -0.3586106696084534, -0.16063787680146766, -0.08473663127871885, -0.6320939796881722, -0.6178542040585585, 0.2923373279957992, -0.5337911824439323, -0.6674933779321386, -0.34394132488401774, 0.6668583016609052, 0.07215599456784771, 0.5329713490566601, 0.011587602511042986, -0.49717434217374296, 0.25438657433356493, -0.46966216460630766, -0.2490380694917557, -0.27246637594377293, 0.04393399217969123, -0.6422797491243555, 0.27730522064588103, -0.7368572562189861, 0.41355407142248785, 0.10662093186673606, -0.4772915080805689, -0.5837926633612326, -0.33625054994092624, -0.7095049520208848, 0.4598060721668059, -0.76141737488754, -0.7365823745453388, 0.15147544338879013, -0.46472684021571176, -0.4493966927166067, 0.014408057820023818, 0.1348889674373919, -0.03677324508468007, -0.5722248156431231, -0.2984663880243215, -0.1223490025344169, 0.16097306887997603, 0.5247268698710733, -0.5711876466112407, -0.48510783040953676, 0.31591530250348987, 0.356131333801816, -0.41709001619370195, -0.484015873245754, -0.4907760465073807, -0.7316026734612637, -0.5257811524172318},
    {0.2998608474670177, -0.22050292311200892, -0.6819845458575361, -0.3531054218321442, 0.10410513860134518, -0.6710478576971984, -0.6809111486509363, 0.38113501056874216, 0.0962461296832743, -0.18022263709520636, 0.14325194528422097, 0.02469403440542522, 0.4372883720732806, -0.5311888272171317, -0.051103699807825045, -0.3466424943721265, -0.7000660925952996, -0.5700323092785382, 0.20089223196690714, -0.2712249594855367, -0.4984985937729177, -0.6373369962079969, 0.6116394831974697, 0.18820772136592356, 0.5440247985629089, 0.3495061418549585, -0.5968977394324156, 0.3607061084847233, -0.6810009047493571, -0.0943441824556341, -0.36133275670869724, -0.16095798725974236, -0.6372664170976672, 0.5689483510990286, -0.6063900899764852, 0.49947259402674304, 0.3167424293332993, -0.4651704052722395, -0.7379017193747108, -0.47724776122265383, -0.4073848580302272, 0.3517427669669893, -0.7630075631330429, -0.6540589942177074, 0.32772387187787466, -0.5050595037950738, -0.6291406714817317, -0.04377152851123386, 0.4272014610085586, 0.20876014317068106, -0.7060973252923128, -0.5143837984406804, 0.07372324072901815, 0.04495918420524539, 0.6171538188276402, -0.4823171631663109, -0.4763538028036942, 0.4034451915124576, 0.30808210604954817, -0.4034148988772545, -0.5678587168471277, -0.47087952079866174, -0.6405632881929774, -0.586813595853832},
    {0.29968090037114437, 0.1284171245826515, -0.6754157815544239, -0.5225886633179083, 0.12632242636214955, -0.709101494199777, -0.3660343938982325, 0.4311270682785412, -0.09739787536566738, 0.015780742946558828, 0.1281902540965203, 0.04307101881309848, 0.5573556432341555, -0.6890656697766531, 0.34632834709227295, -0.20310614481075315, -0.49518589151825526, -0.4352320859016688, 0.41194983594471646, -0.282869027015181, -0.6191990841995514, -0.48381816012021495, 0.7191982831639988, 0.23836707676910598, 0.4618157538991365, 0.3770874713037601, -0.49631126151532723, 0.3580524517024115, -0.6135902533339247, -0.2412711915167486, 0.10238480194603441, 0.1645150995042392, -0.6733226207696781, 0.5302045004336289, -0.6992133838078779, 0.5926703999525905, 0.17790793742078295, -0.6814381112533644, -0.6961739517455406, -0.5996861249056689, -0.5719079388645982, 0.5965518265267784, -0.7662468314449635, -0.5300575142598091, 0.12767629721946155, -0.3496704551477903, -0.4667435143462962, 0.331621084398348, 0.20918233215112197, 0.2391026448804355, -0.6020328437809933, -0.1869174681970212, 0.23100263943163774, 0.28512604743425835, 0.5170763766884835, -0.3633939148231602, -0.5031796499087697, 0.3124965164996025, 0.4671945308452998, -0.613757661639464, -0.7574907157570159, -0.6901449829098386, -0.6842756606816174, -0.5954337571961509}
};

static const float b1[64] = {0.6917242796880624, 0.7150912371652152, 0.7163314968886532, 0.7259710728873789, 0.6838063309602713, 0.6983373248424344, 0.5596008411833302, 0.5750452625370266, 0.7057317679506637, 0.5096191095603831, 0.7056914636503001, 0.7205165683067892, 0.736493629434146, 0.6743605562690183, 0.6765976484307934, 0.7046938195662463, 0.6416912244948171, 0.7074877814590622, 0.6653691157835315, 0.7130612648877204, 0.7319467285378126, 0.7462163050066638, 0.7003347250822087, 0.7203535216579854, 0.7552828377893338, 0.7084835894728158, 0.6275020282418128, 0.5563857966525073, 0.7004600713068505, 0.6866369691910539, 0.7328162175421897, 0.7288254862577647, 0.7112894961803939, 0.7539785190860535, 0.6355386365460732, 0.724760932310484, 0.7004261203759286, 0.7221175673656227, 0.7229254293186744, 0.5745873957586564, 0.7156746565420857, 0.7564637138906584, 0.7036410756073398, 0.6961163263029272, 0.7011366877888965, 0.709372671357754, 0.6957731480795735, 0.7085641244159042, 0.6991280274915286, 0.7204386316896216, 0.712142394778586, 0.6110286603824857, 0.7394149410813509, 0.7650343659663786, 0.7587529261760393, 0.6932488013091359, 0.7181635391920869, 0.7559053186637894, 0.5781252982845766, 0.6306313443487138, 0.6849514999144212, 0.6813143261157597, 0.6719625183379864, 0.6034445245808028};

static const float w2[64][32] = {
    {0.4278545556307709, 0.6383152287886662, 0.8126686550696701, 0.8406440296801178, 0.6175640912847122, 0.5639154744517744, 0.8407312047867695, 0.5912268387847174, 0.6719851877594529, 0.6653160120135888, 0.5593436179869143, 0.6613232233233455, 0.5089050538640558, 0.552249248640615, -0.28125727311878024, 0.822015831020379, 0.7709247223457206, 0.39168336653612557, 0.15176801753127825, 0.5537608008585985, 0.5781775884784356, 0.5639622945893977, 0.7700788563564028, 0.7713482528823042, 0.22499359965365798, 0.22817233743395962, 0.744497233660394, 0.8317015330289619, 0.16354986774639357, 0.7634972311115958, -0.14023878111408916, 0.7280393042430103},
    {0.301183174750079, 0.8380286972646626, 0.9472097373290356, 0.5464695264344773, 0.7166372076250819, 0.5949678322206176, 0.6055171815422008, 0.8502875160610841, 0.552361416754344, 0.5936400739932386, 0.5078964974598307, 0.48427819166855296, 0.5979378013948339, 0.7732777317038456, -0.0015598712661720577, 0.8635070934940098, 0.7323580113015028, 0.12889336876901014, 0.13864112158918024, 0.7197114179449848, 0.680686986068752, 0.7145878790705885, 0.6818867312849601, 0.7539002648264903, 0.14437599395843403, 0.6756569656011804, 0.930080414280469, 0.9463181442313244, -0.1868693913026258, 0.40171625380498177, 0.20137815126262437, 0.6627635728197874},
    {0.33290906163869066, 0.7310076792890536, 0.7069981820403026, 0.7393839476768974, 0.7150294407334413, 0.24403871545791583, 0.8975122615041206, 0.6997950715069328, 0.7448894637762992, 0.6708569828853992, 0.3547767650585832, 0.4774554514836539, 0.47193228483473315, 0.7943152314594827, -0.07962286328508006, 0.7584473671006424, 0.6466061157116264, 0.17918824299205477, 0.043698317162664466, 0.6239346239755001, 0.46316796631008206, 0.7805756919509604, 0.8193019210728739, 0.5622893653224262, 0.5013938893132246, 0.2843454543994458, 0.8146939925027379, 0.43201603946276773, 0.015424905043454059, 0.7774208633925913, -0.0016053187772437575, 0.566640935450188},
    {0.3683402875139401, 0.7980456490019104, 0.515818569270135, 0.8569049536995553, 0.8877197974049085, 0.5923275891239171, 0.5602985445975361, 0.6416179187542609, 0.5416690844874082, 0.5060394395773343, 0.8445325834390733, 0.8062798839085785, 0.5370599379111853, 0.8034823683659079, 0.1505920983272127, 0.9194777643907717, 0.8976057578779127, 0.3696924414214354, -0.03250132971097871, 0.701784881531299, 0.7491366822815314, 0.49088639580166327, 0.561702064762848, 0.7143866898646765, 0.46906150382198974, 0.22748898907973408, 0.7324004885748159, 0.6566466751597597, -0.22123879974449678, 0.7074545916714113, 0.07569927433658015, 0.7189389693476299},
    {0.036057617155875396, 0.8095101744228248, 0.5752096762529981, 0.8227765990533737, 0.8432059579571073, 0.3028694020378294, 0.6434576698866756, 0.881917975517503, 0.7662635266158367, 0.7745527924111733, 0.37071670395276485, 0.6130815709687522, 0.5772988405077789, 0.9029713507211659, 0.030538237169859567, 0.7930396547929276, 0.7183671952481224, 0.07715263226610597, -0.07818951882008156, 0.7054007952704379, 0.408345546853051, 0.6729501369465173, 0.827645720551411, 0.5233046108191933, 0.22105905238080467, 0.5262756956629029, 0.8423129154414909, 0.6506439696257176, -0.15035107572714576, 0.4614574135223223, -0.019427827224281657, 0.7399743856762125},
    {0.16914322765599069, 0.6813478383491667, 0.5847401445179097, 0.7580074127480485, 0.48039842469206395, 0.3874723874156096, 0.6969678521904562, 0.6861384998781956, 0.5926795184790188, 0.7266063838135685, 0.6181850177779088, 0.49093062874357846, 0.5721698963145895, 0.6575163019184751, -0.048415280741252543, 0.7228215885825909, 0.4157629177412804, 0.029471608102178522, -0.2896261072023825, 0.6429436194340081, 0.6198329438002466, 0.5151188440063643, 0.6103373001884821, 0.4657944611541476, 0.20389168888499581, 0.4520406705169103, 0.7320726786188175, 0.838912139504017, -0.10237983956727106, 0.46969148504650304, -0.04598706808780317, 0.7369482861850694},
    {0.4016434330457892, 0.565942297959917, 0.6118801332339238, 0.6257218423647719, 0.5192503922144406, 0.26932051986144107, 0.7626052128018781, 0.8135031622059221, 0.7554557814881901, 0.8735609747948712, 0.6881861462421894, 0.41995310776695494, 0.26043812046388926, 0.44659881258583106, -0.2035516586827845, 0.42112548757160406, 0.8455866722667511, 0.36800940561699896, 0.09042282554088477, 0.584338704263944, 0.7775125074621426, 0.4041439781287729, 0.680877574322261, 0.4291134768431717, 0.06270794620786459, 0.44246357668864, 0.6287167190879475, 0.44700269127195735, 0.10590780044580765, 0.5740369325734924, 0.09409638889008291, 0.40938606749355705},
    {0.19182627813002587, 0.4652937227308616, 0.5360106251141787, 0.5319565258894853, 0.4765859233354079, 0.4469500174907582, 0.814027500656842, 0.42020547127444813, 0.46100913489046397, 0.627017614284827, 0.4085661725852895, 0.5022358708493583, 0.5534309139760516, 0.8134124371593252, 0.09579590257089549, 0.5085945755512927, 0.7490599668119722, 0.5522812935370948, -0.0006070444077015672, 0.6646068185546696, 0.7896782368131977, 0.7603654676534758, 0.732613237411703, 0.4642985776532133, 0.5711913557146788, 0.530908149947032, 0.5464285465402262, 0.7162651300784617, -0.07502962068007353, 0.4162385650903729, 0.27536199592716637, 0.518515448577774},
    {0.08330828999952106, 0.840406069432026, 0.6000927949716433, 0.5078018972012428, 0.6695828316000927, 0.45367229530958336, 0.6371143094439069, 0.7903800717673207, 0.7205600392838675, 0.44879806429848046, 0.7488714060617918, 0.5041850640625584, 0.42182087831488035, 0.8246043081099164, 0.03373414194384089, 0.5771143887644105, 0.4431951347629256, 0.12666055755030872, -0.009476904744652473, 0.6176054174488756, 0.6790503738739437, 0.7552215341124586, 0.6111639322189456, 0.6694005668879212, 0.2317716778761971, 0.6280108688800259, 0.7810044976164054, 0.44185798580546054, -0.09638024893076089, 0.7307924119357464, -0.08801359752495534, 0.7964249563562703},
    {0.3088889969825559, 0.5414329290810563, 0.5545302203560566, 0.8616168662182122, 0.41512828422981646, 0.7221903264197581, 0.5936321464894392, 0.7299276621427169, 0.4635235837350219, 0.6239711004529901, 0.7874262410200185, 0.5371995483258435, 0.5672258609098911, 0.5355391942097134, -0.0173752964715642, 0.44207280239441815, 0.6145131270093469, 0.4913545086797274, -0.27596838161524667, 0.43292125237756246, 0.6481467581970868, 0.6753469369007983, 0.7035489421800806, 0.4806564982289481, 0.10789530531561989, 0.2626015536270868, 0.5098783705838823, 0.5173039763357854, -0.023810931838509342, 0.7233548564557617, 0.29167295441967817, 0.6155228265749201},
    {-0.020082983293970475, 0.9145121242108956, 0.580618714907706, 0.6614585934820194, 0.7545205083694617, 0.3404067795853263, 0.8286388265520774, 0.472448044868063, 0.4332738893541103, 0.7004759447096328, 0.7274357810639767, 0.7845348565115765, 0.4573298304006377, 0.9060106503122363, -0.10583189082289593, 0.5064001637858071, 0.7563833927383338, 0.28148502366763256, -0.2512358361295396, 0.7333656414126418, 0.7656846040340742, 0.8586973056900621, 0.5179241441505951, 0.467234841724789, 0.1106269680828796, 0.67384942649074, 0.8635638025728628, 0.7530816969141612, -0.12473282315641808, 0.8099537250784965, 0.19966406221724162, 0.5561724948473935},
    {0.44931559337608734, 0.8874272260296205, 0.6736063956512138, 0.5610318692016547, 0.7511483246277652, 0.6606431081624566, 0.6454690521587152, 0.5589375409284936, 0.7932647157886574, 0.6145350250409775, 0.4070961405830791, 0.7223621990563899, 0.6015878327483004, 0.47271591717413397, 0.024769298433877863, 0.7160148210799301, 0.4978047829941755, 0.3713869685658581, -0.2044390770546013, 0.6753513388127427, 0.4488340309912896, 0.4895940882454613, 0.704269884509567, 0.2848136196537417, 0.2886838528272387, 0.321966595231645, 0.6928091988139193, 0.6711831382393615, 0.10688811533451517, 0.31016282747570556, 0.05481684266292129, 0.49665176234646524},
    {0.3346850015750018, 0.612275516637625, 0.7731453843095706, 0.7898531155367137, 0.4943461611979983, 0.44843431378291587, 0.6208287738742951, 0.4237031248946557, 0.6725742181317361, 0.6119761304388114, 0.6599495272401686, 0.6538197870462152, 0.4911602633167402, 0.8841852761251513, -0.03629671462248663, 0.8191419530665232, 0.5692601964447368, 0.52475311278599, -0.025098540904512228, 0.6524537926694515, 0.4698140036123856, 0.8957319260898635, 0.6918621176875949, 0.36867254840879166, 0.39873571171619904, 0.27787483574324306, 0.7299295636017895, 0.650375123191532, -0.16970965064096147, 0.38424855500607424, 0.3401737614698882, 0.5241380241579698},
    {0.28839652141823846, 0.47117285262961217, 0.5389786575027786, 0.8890658377221938, 0.5800568379650741, 0.24909061190874127, 0.7921042651314328, 0.8235217575296023, 0.4773843412287822, 0.5110366987541792, 0.405339206548015, 0.8202321512780063, 0.3197166890746969, 0.6360774684593395, 0.07941074459969684, 0.6754393584010785, 0.5768154775404202, 0.1139028753634638, -0.0032649568554103626, 0.8290802265140875, 0.6216089644935244, 0.6037027289293548, 0.4530766780463621, 0.6694231398774063, 0.3228320963557554, 0.41813378458052064, 0.8031513078926402, 0.8903733198488006, 0.18019267334506248, 0.6883202220318975, 0.08285646015339165, 0.3949959680515395},
    {0.3124060277997416, 0.831745271015612, 0.5243717786020788, 0.7231831151649613, 0.5963148600329934, 0.7643985217991961, 0.5984733603969412, 0.4953009740443512, 0.8585824843239764, 0.6385883311106282, 0.6440186081565421, 0.7234372902203671, 0.5514430128733595, 0.6458520019165125, -0.06966985841992591, 0.7095449000943619, 0.6205640767831001, 0.27829188854874365, 0.1978660936188483, 0.6474856924356096, 0.4594054083116269, 0.8816579911122628, 0.4550104789458841, 0.6033889022885438, 0.1550144271611006, 0.44781735524039346, 0.577569197343222, 0.6677887618062835, 0.17126238113649617, 0.7084406770953193, 0.20309806063214356, 0.6839904268148935},
    {0.2519034296859856, 0.8154695424783216, 0.716696177387171, 0.5435595544589732, 0.7936764716305762, 0.36641497984287846, 0.5448083183061068, 0.7904602564406237, 0.4214384227384998, 0.8363764482759095, 0.40256648492588165, 0.5253627897800056, 0.24559917924949506, 0.7439854376920522, -0.012813845462282938, 0.4383575266319608, 0.8685384686326465, 0.4596236491664296, 0.08233256435103731, 0.4168508581855686, 0.6108265959451437, 0.7099400865115705, 0.48356996552162795, 0.5033465214673402, 0.24220313075270966, 0.2398600314397589, 0.4305052417244113, 0.8953879008383416, -0.25971012529002035, 0.7803608783346918, 0.010990518328696136, 0.5075190316100657},
    {0.4247146228394735, 0.6936527361529398, 0.8709240930239351, 0.43214536655953767, 0.6025750347981788, 0.5854607431530928, 0.8649646803094891, 0.8066482076536202, 0.608937201312489, 0.601385775570111, 0.41977177876460064, 0.524975325197764, 0.29560387915134956, 0.6925405749780995, -0.17794097609612622, 0.7914001663690905, 0.5299727202028743, 0.08013062013575785, -0.10570049834484527, 0.4707855346743938, 0.44448561093078715, 0.6517324490124854, 0.48569952871120303, 0.6887440050584026, 0.016345793364639146, 0.4242515410283152, 0.45234753986637777, 0.6310847757363448, -0.09488778686457555, 0.3522177182098697, -0.055235157995937596, 0.6543432105929371},
    {0.1522380867994692, 0.8345640028185662, 0.45934234163098253, 0.8346932215523734, 0.7927156247419868, 0.34480972541626387, 0.5407559286626681, 0.52101046840557, 0.47111084046288243, 0.7207204196613316, 0.7525749272917753, 0.7783856762414908, 0.2796556108044379, 0.774403704807164, -0.08728982906019693, 0.8429910822277079, 0.8356534429333369, 0.04780257508433212, 0.1435271974801789, 0.6975308949200187, 0.49447699619532715, 0.6312450022397084, 0.66314082655605, 0.5521339006999404, 0.4044661338139714, 0.26597373906623684, 0.5216754589590998, 0.6085446124476985, -0.1416564058578926, 0.6209265283289125, 0.25856669117588976, 0.7847547722833835},
    {0.15901290440256818, 0.6492533924988242, 0.4968528969142105, 0.7417760357625545, 0.5996682379609156, 0.6460523068293927, 0.8191638107212347, 0.7385725903457625, 0.6779218155642812, 0.8559682502041213, 0.6545705796218216, 0.5044094207205032, 0.40453285452704235, 0.6232571827670561, -0.11574188512451479, 0.5995388135201694, 0.8584752339135806, 0.08745969233053554, 0.11935347204193728, 0.5385004777937241, 0.4134134327661087, 0.5177341872580136, 0.8436717649665307, 0.2927728394058564, 0.04735497127186093, 0.6272037739988728, 0.6052539278337363, 0.5807379681391414, -0.14605808777838694, 0.36950623325538035, -0.06057100374307862, 0.5933765215355625},
    {0.129611617041724, 0.6009392445299372, 0.7754781547556592, 0.8657613874261129, 0.9018985439499912, 0.38166510184244284, 0.6290770440339225, 0.5074200998943572, 0.6998781806934316, 0.8535014643617843, 0.6933890086670375, 0.7891483215424611, 0.6258024261424588, 0.684913834172564, -0.21943151206701744, 0.5429237377534106, 0.4490379889944506, 0.4608493723016052, -0.21024850666260536, 0.7056517791228331, 0.8773446667643308, 0.4940275885582372, 0.7537897213224991, 0.6752912690649044, 0.24167477859999456, 0.6076736521566983, 0.8500199557829426, 0.507839454179037, 0.15599325289551605, 0.8699298022206704, 0.20824911067761284, 0.705711749456063},
    {-0.024844059165400247, 0.6150915951036823, 0.6893405436342661, 0.5755891220373209, 0.5841957049925957, 0.5742761761018584, 0.8269205846806562, 0.8471773436486947, 0.7371505801927839, 0.9044634819634949, 0.5738970757573673, 0.8307744814658562, 0.7294044006867625, 0.6408402171867534, 0.18386945863211643, 0.573811791958969, 0.8208976684974987, 0.5598685258353058, 0.11828526726634912, 0.7680337679200898, 0.4336781159164311, 0.5379902294768802, 0.831457110182589, 0.5636780592265034, 0.29826873420704325, 0.5435404670311241, 0.7549439507247125, 0.7914016228913221, -0.1206656905080788, 0.5856337358869266, 0.16202877988534622, 0.8351827202006025},
    {0.10337529232614034, 0.8993129918160273, 0.7825681226522302, 0.4303493680294407, 0.8735620556082334, 0.5997639313566021, 0.7847221041693482, 0.5528854220103825, 0.3994161350487597, 0.8252115890193136, 0.5769694679343411, 0.6441475501369703, 0.6124421495624316, 0.5657285234695356, -0.004753947640190245, 0.5506511610887539, 0.6239395524018054, 0.3325495185827941, -0.10236330441842237, 0.5531430469283143, 0.5396165439922272, 0.5274788595201751, 0.8012232431122881, 0.32205136205822715, 0.047018012277792814, 0.5044102550625083, 0.5229629278302113, 0.7089068161386577, -0.11131587719596377, 0.45488037114205787, 0.12396387682304663, 0.8461448797046784},
    {0.3517673819288773, 0.7054528627306467, 0.5205538277597769, 0.5793213023971882, 0.4793276135109701, 0.715372194333033, 0.6694117922869259, 0.5903292072799524, 0.6372969698179028, 0.6212137884945003, 0.6700548331104502, 0.6138743093906841, 0.3977923524573692, 0.6795614711386845, -0.13870253212110908, 0.601229148327028, 0.5096110100404257, 0.15989683124723122, 0.05155957775851489, 0.6447639155886089, 0.8220160072024371, 0.9344518149318849, 0.8136562402072445, 0.6547448464081793, 0.21334418325095986, 0.5194445812618934, 0.6467861868652978, 0.6202273918148036, -0.24636426020359994, 0.6197896572572404, 0.35592635636917913, 0.5032757456972198},
    {0.502135800936277, 0.615851110279022, 0.6120247225503861, 0.8352046027335828, 0.8763005388690015, 0.45554571342783406, 0.4814118359596941, 0.505232056677878, 0.47355748293581895, 0.6346869341157205, 0.8051014511294133, 0.5914172669175237, 0.6745645276598121, 0.6149730172834997, -0.19288492942122631, 0.503693815417761, 0.4472046154677656, 0.3060216300441013, 0.015349242699185018, 0.9093307565945784, 0.7399049348972578, 0.5496236571870914, 0.7686144011633125, 0.4354683351176236, 0.5525926797001013, 0.41041210822610213, 0.6187066825334924, 0.9427806760373075, -0.1596727102109676, 0.41486472524477325, 0.39012358036934636, 0.4354058784564469},
    {0.46526683297445687, 0.5811366726380754, 0.9384960394956916, 0.44188399766533126, 0.7136260808665971, 0.5118212754991257, 0.7454009986118176, 0.7127251659003244, 0.6603842918228052, 0.4741197319212915, 0.5619359461927719, 0.89472346803186, 0.6187042891430286, 0.6638210171285085, 0.1054746685273033, 0.8370691083606369, 0.6477385903777962, 0.3058282452087132, -0.2283133193859339, 0.45205104592342527, 0.6929732323465357, 0.7605578582857991, 0.7875776086299473, 0.5035772573132341, 0.0827934547824902, 0.23088723706303277, 0.4696832788810144, 0.8202615093653006, -0.29746716503183696, 0.4052169090135142, 0.07084794861831244, 0.38986798694652364},
    {0.37785758371687317, 0.6987156590811002, 0.7877559808271158, 0.4853642493000582, 0.8453741175899099, 0.5671903900712058, 0.9027888519203334, 0.6987194274030348, 0.5316242785803114, 0.49621157464601556, 0.4219532946042665, 0.5694162509429268, 0.3583101119104516, 0.9099999383341956, 0.07016049979927128, 0.7650597939311383, 0.6847239431817503, 0.27018085903225875, 0.11143052213996676, 0.6457654497191968, 0.5566381616992374, 0.8352964950807686, 0.391844717963616, 0.6050944063141881, 0.14218685665384384, 0.677318360629166, 0.44241840579069197, 0.7646181220104767, -0.20212038905111585, 0.664834589207359, -0.14220597737883447, 0.8903970897135859},
    {0.03271618559642748, 0.4390569682927899, 0.8614414700274942, 0.45500748170644456, 0.6975506501761012, 0.6890772346612974, 0.472292654957842, 0.5391934126729523, 0.724867209115146, 0.46061315831202637, 0.43282598743869033, 0.7150721455726965, 0.4005266652719095, 0.4280144095499529, 0.043502093380094836, 0.8331860306314676, 0.8088844451789036, 0.04585136027578728, -0.07213216079502856, 0.8885079154986907, 0.7683647614230742, 0.5701909982361447, 0.5926509391786923, 0.47811595046962135, 0.36967135938884066, 0.5407607590200338, 0.5586138745300321, 0.6279236485243861, -0.28504580731273677, 0.3485727524279774, -0.08600147294994652, 0.44626524847308996},
    {0.2948919762199013, 0.7900354004315792, 0.4916463974446618, 0.7727042029199126, 0.4744905144770338, 0.29249874031914586, 0.7835494408058014, 0.584139051019936, 0.7825738116147453, 0.6184616502912952, 0.5507892833520515, 0.4727196617487968, 0.4531142357910815, 0.5762192491328101, 0.10165635878818359, 0.5665459710454731, 0.6239225973316436, 0.18728769035196383, -0.10799721679452973, 0.8101535378240251, 0.6815538764767742, 0.41581066509246195, 0.7112014610747448, 0.6626497266834699, 0.4078543254665745, 0.4959849829062301, 0.45047356501503927, 0.5519155820339128, 0.19121186447930713, 0.5115085836287153, 0.2435122793748361, 0.5580754109765783},
    {0.15001636577308908, 0.8855656326652767, 0.774582948328339, 0.5115286056912217, 0.46689559812041276, 0.3098423791965665, 0.5705880911723055, 0.6771242183020006, 0.6994271088404892, 0.5321587283716586, 0.5304645009971194, 0.788323973071826, 0.5042114198632867, 0.7914022444369561, 0.029138534228804334, 0.5114993471579781, 0.5800526600663557, 0.011098195076999082, -0.23671772251610954, 0.537350429567288, 0.742622923036305, 0.8855038070576768, 0.7783856474414481, 0.4617590566738901, 0.3074791801848013, 0.37150111036029687, 0.4750254145586569, 0.6106860143827713, 0.21146143431388373, 0.7850240918002701, -0.12363604700207698, 0.43519070214091277},
    {0.4132866141643555, 0.564576372948381, 0.8043658427288083, 0.7527785675147746, 0.6758217591651791, 0.6622006307589505, 0.6110640495422835, 0.762034151219873, 0.5875058213209298, 0.784970086014176, 0.6192434701874737, 0.6588806893237306, 0.47803690155366685, 0.7890337578441545, 0.17003280328276724, 0.7579388162868433, 0.8255236810008115, 0.23271175155325113, -0.07771767546786111, 0.8604242187373208, 0.7564394005963417, 0.8979535564505319, 0.5814933279217841, 0.39061021917158595, 0.08543040285717016, 0.5861780439322322, 0.7407833016548755, 0.6928615788548104, -0.08322622270242931, 0.4011149127142555, 0.01851632636510368, 0.6121288815341607},
    {0.19953505731993687, 0.790080043345254, 0.5608217352818833, 0.6110343345334533, 0.795693717585454, 0.27298042269673317, 0.5945463110251068, 0.45440410559722183, 0.8218679434192787, 0.8146831660342847, 0.5691880857506705, 0.47133838720724186, 0.5427098347573074, 0.6303669435708851, 0.17893779217767264, 0.5440589044052621, 0.7739647659805037, 0.11759594975733564, 0.04211620877941158, 0.6524054962171403, 0.7247977628762755, 0.6828592622806173, 0.381137516480943, 0.7310535768887975, 0.433700956898906, 0.3247853383283231, 0.8141547404020719, 0.5674383517220836, -0.15000979362667693, 0.6895616853349108, 0.12304528709588491, 0.8515965806374498},
    {0.3769547403026675, 0.8851550332555881, 0.5811567177833327, 0.5392198415029918, 0.782560212972845, 0.570699341816777, 0.9281701920460182, 0.7504389420931448, 0.8263104210423482, 0.6507594427679919, 0.43159216990401644, 0.6627402720884354, 0.6676148101470952, 0.5713909646018437, -0.12588203264330292, 0.5175855702705745, 0.5938607196277425, 0.3612623608532061, 0.027017704108310774, 0.9505831607583016, 0.6276213072111156, 0.9480523679675367, 0.6423958850039867, 0.7667150959176362, 0.2573623742055812, 0.46792544038405937, 0.6041574002429351, 0.8759358259168123, -0.12583847582374844, 0.6221989453560498, 0.3617843470812382, 0.9142781429029885},
    {0.2756013912728628, 0.6327159797047279, 0.79902345627016, 0.8325759661916511, 0.5398134904173134, 0.5486414433638493, 0.5538008843368695, 0.7365299815837958, 0.6170023421303105, 0.7785122579773133, 0.6630341521236646, 0.902989733585824, 0.2953561930952321, 0.49769185805759364, -0.17549080267138553, 0.7355659063471353, 0.6604334109499913, 0.13552931192475529, -0.0019045604272967698, 0.6671205601077168, 0.8620393993719908, 0.8537175642786489, 0.4521228048379898, 0.7015960578050568, 0.4337114649131543, 0.1993311223860139, 0.688086162322897, 0.7579618128637929, 0.02019637074418781, 0.6912420964166432, 0.29690465888036577, 0.9224402296445781},
    {0.2685666869354532, 0.9221010663609158, 0.7801549284193965, 0.8454661426411734, 0.8823368820851291, 0.4477693577530821, 0.5204860457932429, 0.4299158375191097, 0.4761243267124423, 0.6551484724266227, 0.6207646803964528, 0.5557501718024659, 0.33111225097127905, 0.9080480821786517, -0.2287547766511844, 0.7030764403021067, 0.8287624369315458, 0.46426875361540876, -0.20061128400988948, 0.49177264628063316, 0.46774597695927383, 0.7559210163127855, 0.6203731458435946, 0.5672305259104411, 0.36428652755373947, 0.33019653661670756, 0.6789169109992319, 0.7406315341226642, 0.08141336672805932, 0.5498660136250795, 0.4243931472944607, 0.4556549368320918},
    {0.11968471560810398, 0.808958608619095, 0.4963342178197423, 0.49194252434649205, 0.6794746692780017, 0.45107810365952666, 0.553386752627187, 0.48738829200498407, 0.568514363783851, 0.7270441485060043, 0.47517368728489723, 0.6265960509580512, 0.43257931523471566, 0.8304698200932942, 0.02955265021406616, 0.7756927270241272, 0.8302960233431553, 0.40306891571531717, 0.06402116290342877, 0.637389276314184, 0.5676377254119985, 0.480066458337886, 0.6443406322493125, 0.33578283174313983, 0.14324820019600265, 0.510001142860645, 0.4699741842669259, 0.42498452152235433, 0.04028227769655615, 0.8083089447353357, 0.3174153395798861, 0.580609340942783},
    {0.4637385161744552, 0.4885392569206447, 0.4476754197565337, 0.4689666061947617, 0.8214159793761122, 0.5940345725038746, 0.4982199668205085, 0.7453353284694209, 0.3928416844106665, 0.5097557461314112, 0.8267636796482, 0.7301211841328525, 0.2598340859527156, 0.6875027887476949, -0.17084111797615653, 0.46277600816729875, 0.8835601042220893, 0.08924876279448003, 0.10968810094024604, 0.8974439718023759, 0.42240971050788684, 0.6407113511145447, 0.6043580882239186, 0.41358910383212844, 0.4273451496116315, 0.4717830847440766, 0.5573078661819617, 0.43465142132369594, -0.013067139806860676, 0.4303461236040517, 0.18710698885325983, 0.7885852559674071},
    {0.006953061388152513, 0.5875846364909888, 0.7098975681433356, 0.7763937560106646, 0.791920564100316, 0.23800974735744515, 0.43883928579463516, 0.657565658078787, 0.765902387777071, 0.5656889754623546, 0.5013423630059523, 0.7772630438926926, 0.3398929758112279, 0.6538585787206082, 0.17998610288775913, 0.7144720906383334, 0.5569746518798425, 0.40276658078996747, -0.13246135710958076, 0.8370347021355018, 0.5976160271372932, 0.7898750272287633, 0.5224886036981831, 0.3510689899758331, 0.49182863005753835, 0.5496300278628141, 0.8233873308910574, 0.5776107411728085, -0.126259139071601, 0.517948206814936, -0.004466200129268167, 0.5515382272178185},
    {0.031892409602723916, 0.6557801560216704, 0.4904232147426222, 0.7926760639822288, 0.44800978954846665, 0.5840578707512957, 0.7910060393960062, 0.8033509742453848, 0.5941412826211337, 0.6395412913390485, 0.6177847552624735, 0.6976500465791234, 0.5264986394006606, 0.5129960964498183, -0.132149533551138, 0.4627240201884981, 0.4303830679142965, 0.3412945191395522, -0.14338822046666247, 0.8421730043091494, 0.4412154394936673, 0.6114875114201449, 0.6964039373910852, 0.5935300866894542, 0.1558054284700253, 0.287514228206064, 0.7019476083081653, 0.8400328209747414, -0.24373408810343689, 0.5317926647253278, 0.06791327926926385, 0.5449110004935671},
    {0.3739217280087552, 0.44907457603038003, 0.5693548912078662, 0.7870865021109884, 0.6564855551754549, 0.24164177807245515, 0.5580531799894489, 0.545857922588655, 0.4061071623326678, 0.7884149448229087, 0.3799070189659507, 0.6080469196074542, 0.619985004610109, 0.643596663657401, -0.2799817201836698, 0.6738673876913752, 0.6742220490937986, 0.4305229791756684, -0.08570876069274268, 0.6381059693487225, 0.8418242568381885, 0.8013392236318306, 0.7319213593799375, 0.3181555844792725, 0.24176803202050012, 0.5872248924958321, 0.8649679007138924, 0.6674589146070861, -0.21791773313428658, 0.3983778617994711, 0.09896840000640195, 0.626040124882639},
    {0.021526487026411315, 0.6194467288317373, 0.8140968983333645, 0.515008765182623, 0.5652458390278493, 0.6628275605885562, 0.4492530457109301, 0.7016912635439424, 0.7271320836821714, 0.6054531832982185, 0.7620534509929925, 0.3894591936758152, 0.362794319555251, 0.5151744254010199, 0.13721344210900635, 0.5155538178131246, 0.42986323219994943, 0.33215565394877067, -0.26425282693679925, 0.46099578800168384, 0.7837639878967027, 0.8910253952244189, 0.8628543622445964, 0.29757884177105, 0.37569683656681124, 0.16077820090524794, 0.4155796312782679, 0.9071868338144707, 0.16223977456290703, 0.6104704197163435, 0.3461859044891648, 0.6038616205884356},
    {0.2098123862908183, 0.8581259693204395, 0.783559437810907, 0.3982656449849821, 0.7511864900259092, 0.4135527262906792, 0.7657188449421196, 0.7840560128352854, 0.6443906999070976, 0.6796108988170817, 0.44670449221136427, 0.8400335894744251, 0.24207532679129037, 0.5531283152290434, -0.09443160318090092, 0.44311343889626614, 0.6142466778612469, 0.4018152579155261, -0.2818991688693087, 0.5462757690576087, 0.45696376950565126, 0.8722354732990153, 0.4316451721403562, 0.36504499516527655, 0.2979119496434009, 0.24273101027511032, 0.49271152406604574, 0.8753060764888281, -0.10217881919227417, 0.6577530799081569, 0.34736831109960936, 0.4425083287199799},
    {0.03564633343748338, 0.691481482879493, 0.560626754275213, 0.677964511607776, 0.9090120874189493, 0.3197540467875762, 0.4998517400435481, 0.8049937847047793, 0.9035486366997223, 0.5074416787529334, 0.6755042765659272, 0.8499767969291566, 0.43987643910173035, 0.607372951857356, -0.20240875448646609, 0.473884241670943, 0.8418978289407197, 0.23605713044835555, -0.16258504451922604, 0.5527928272196921, 0.5307463964007588, 0.708548812140366, 0.6068730380055782, 0.6950830797247637, 0.5351975922667703, 0.3506461136915978, 0.6271019654436107, 0.5975804152343813, 0.16159257371965613, 0.47011349287750837, 0.022794604351576153, 0.90206264405921},
    {0.11055474382412867, 0.602391627086132, 0.5705294753523463, 0.6201299518443132, 0.5046154225552925, 0.46585208460272526, 0.6398271243164243, 0.6065837503961908, 0.6350618950597173, 0.7820179214979284, 0.5151634473650857, 0.6248175060278557, 0.6492842180205436, 0.7385773507638721, -0.10821627560376068, 0.7051126539017175, 0.5648773127664322, 0.47411832238901186, 0.13119495401580894, 0.7626026682579796, 0.6141165562170626, 0.8310696113864303, 0.6430014715659315, 0.4970608802972822, 0.1477816764255793, 0.4911970315314409, 0.8082590461135416, 0.6774595934161989, -0.2563389382438113, 0.599508980363862, -0.08731596272190914, 0.7438852297149663},
    {0.2329943264752372, 0.5809013204249478, 0.4191162826361785, 0.7828185197085359, 0.6347304371929537, 0.5586165310933894, 0.46429076056038493, 0.4333942242564498, 0.7409691490867854, 0.8835969586489879, 0.7403416698723935, 0.6131840135613349, 0.25139504262547363, 0.8855252676573323, -0.20022624862339802, 0.7741616643900167, 0.8179308902478301, 0.4338247771525177, 0.12127063779474535, 0.7759181640340209, 0.7762336642559217, 0.8985892089836263, 0.6610853274527935, 0.3299065052667745, 0.2971689393376632, 0.5209124491542706, 0.5956217018982835, 0.4968863461830656, 0.1590247484594626, 0.4322403387235907, 0.4492478627173584, 0.5504348959307441},
    {0.33287901357867045, 0.6445972466924843, 0.803592235458302, 0.8544880481558632, 0.5831131703971719, 0.3991926254878791, 0.8091153918757479, 0.44015796137844393, 0.4316498176743375, 0.7594184463500382, 0.34777374598799865, 0.6405251022991775, 0.74524823181217, 0.8879002504140125, 0.18875270457239907, 0.4513120908445747, 0.8846757652561389, 0.31633117485547596, -0.048191305759398534, 0.8417851752015786, 0.8379452429311233, 0.564637950114303, 0.8226719248456825, 0.7795577721176922, 0.02602062632266784, 0.5862211443993202, 0.6167906546252324, 0.9099745542233172, -0.1495715021512457, 0.3530270057923022, 0.17933196115087846, 0.6657792368946537},
    {0.1452064005032062, 0.8519173898244946, 0.4112371282777462, 0.7691044337641667, 0.816628775923017, 0.31538247045790246, 0.7261965021919253, 0.5318437422031327, 0.4294920914317692, 0.7259545879536715, 0.5519792644736449, 0.7103389640142729, 0.4761211912930341, 0.42308037721608915, -0.17005590597968728, 0.8870891413006825, 0.48760024238023386, 0.2176800028907037, -0.13416991414144658, 0.5579479718054603, 0.6280353017466943, 0.903387910312503, 0.8402054231186118, 0.3973559234718444, 0.36782044371914696, 0.3565029674852649, 0.8093339788872475, 0.6563707762624511, -0.1692039174952349, 0.6617084319806666, 0.29569668164128876, 0.7288008450528475},
    {-0.00826518927965371, 0.8627905595475752, 0.6578128694450998, 0.5565526349699587, 0.5798729299782369, 0.40947210517144844, 0.649991419704202, 0.40975252916420046, 0.6816907479015785, 0.840756284186328, 0.5777072563625879, 0.45489731321907895, 0.2567933074273666, 0.7598448498471182, -0.1680463062598925, 0.7502720939040933, 0.8666741317906813, 0.2176728886667614, -0.2085810708404952, 0.4802033307966851, 0.6927204807508966, 0.8369976327882837, 0.649182877142064, 0.6268608072737399, 0.08207716929532476, 0.6096355085987137, 0.5699827626424911, 0.8124347267882495, 0.20978772606942114, 0.4990370235324198, 0.12362872836054646, 0.44855656894340334},
    {0.2873904014956727, 0.5685450872999706, 0.7043928598902993, 0.8539867323778079, 0.8913427865626284, 0.6548911650292903, 0.5214245179027135, 0.8965366498548583, 0.6478843583082329, 0.8952725061556766, 0.7673221280599447, 0.6045658222204328, 0.7556235584073352, 0.69358216955883, -0.14156884048775883, 0.7959395123058371, 0.7429707019176938, 0.28554759679798514, 0.059112513252215976, 0.5158560632075789, 0.6458176127649478, 0.4432679352347112, 0.48968877983164105, 0.6371480730064497, 0.45562362876590573, 0.3177556844873783, 0.8283458397454849, 0.6442563481441622, 0.147817614868861, 0.5066835261463744, -0.13696930884606195, 0.7154321712035149},
    {-0.027125416603244006, 0.8851819580030361, 0.67816607059807, 0.8539961685734787, 0.6078585909293993, 0.25351567454651563, 0.7568447897444586, 0.4538590794066575, 0.8208289624474288, 0.5292192972919566, 0.33303504137991063, 0.4281169214896012, 0.2912796390707719, 0.7023425350909999, -0.08071651991297236, 0.5539595531789486, 0.5163969898583555, 0.44264642310131624, 0.16483089338602022, 0.798178358227312, 0.657067608482914, 0.5708929348551014, 0.4919219486571186, 0.6348258321656476, 0.44598504220449403, 0.6749941713908887, 0.8275602768119663, 0.4890818293255704, 0.14646561133107022, 0.6209651659435181, 0.19424643179960716, 0.5658856566627579},
    {0.25644340008178157, 0.9046031282790556, 0.661861593169682, 0.4410698625396919, 0.8679877100633858, 0.6115708696895393, 0.5281741212881247, 0.5210904282764355, 0.6626248011410474, 0.8240068313826401, 0.7252290339499817, 0.6676483680462317, 0.5424209735042156, 0.6524646342790145, -0.05747280252687353, 0.46023642408033955, 0.4676119554935909, 0.4297064239428798, 0.031074003808990416, 0.8507100229653365, 0.5034271145084339, 0.8185357680117179, 0.6345254471690231, 0.6884333070318367, 0.276534333959318, 0.554318554182041, 0.7620910476974335, 0.5879954302741607, -0.08396637512349753, 0.770921964113189, 0.19980277121578713, 0.8191821796564542},
    {-0.04568928366021963, 0.741468846758681, 0.5799547740688274, 0.42480542682534683, 0.4906983376255731, 0.7019439064928121, 0.6989049905847361, 0.6185228404458114, 0.8133500901171787, 0.8507620518314369, 0.7591989177739885, 0.8408017564367645, 0.45294739005549567, 0.701245259610135, 0.0749700814416018, 0.6201758883788776, 0.4959429749141109, 0.19362627188200976, 0.16857595830048575, 0.44905225542279925, 0.6187791185159469, 0.7871822414943226, 0.871726140038567, 0.3197801874200052, 0.1818624319986517, 0.24915272395386767, 0.5415660672881903, 0.662903676073148, -0.20308978523136867, 0.4423629381820549, 0.1705257392301951, 0.7176015694706099},
    {0.39401551672797935, 0.5641150583352377, 0.7406641371637477, 0.8298288873668563, 0.5002969287037667, 0.43507738500189347, 0.5423946815539824, 0.703754013497198, 0.6838357358190886, 0.585372382095142, 0.5056761636826289, 0.6727590887406985, 0.5993098510101769, 0.41649868021028835, 0.09656823186731607, 0.7137856339210555, 0.4754325127575703, 0.2500630311985016, -0.1437064865436808, 0.7246473823965891, 0.6753066390016125, 0.5690680367396811, 0.8569339574734564, 0.7254173864684463, 0.16478368236202676, 0.4290299089476231, 0.5547062872190986, 0.4978965398613049, 0.09910921423302067, 0.436256022016492, 0.27776973303081676, 0.6413368849179226},
    {0.13154206618943343, 0.8260156953125918, 0.5278800384631324, 0.8162624321469278, 0.7862283324401946, 0.6713428001609788, 0.8182265121577253, 0.4409600514459933, 0.5519809726184178, 0.6682435266763362, 0.7782887651945803, 0.7438482341872803, 0.8428806626660382, 0.8777017552113855, -0.1686207580227366, 0.6645769280246734, 0.6906063604299828, 0.41420401144402225, -0.12391033261084564, 0.8712579998331395, 0.5420030569447104, 0.8569555820491472, 0.8235607107814499, 0.508529955815924, 0.45164598950868146, 0.36604796246507093, 0.5854242859936354, 0.6264335705145972, -0.159638303451862, 0.7732517506217609, -0.03373922582595394, 0.4477112339241812},
    {0.18413704239385834, 0.5449536565923583, 0.7191143268706199, 0.7810142435146291, 0.8438070418081938, 0.5370038810069487, 0.5460242134064321, 0.5786668910870416, 0.48412541069511683, 0.6824901121792305, 0.5116113260574039, 0.897791355379759, 0.4774704393370187, 0.5590971448853236, 0.19901251877173726, 0.5332134180718396, 0.6994667304692905, 0.33602547354097323, -0.13741882450843687, 0.6684358627273023, 0.6178701903570117, 0.8571163705643725, 0.5900793855411628, 0.6642735326314237, 0.27076151065376225, 0.31812364491567846, 0.5179456226352627, 0.7116874352790132, 0.1905650686928634, 0.7490865144903889, 0.12675592740708727, 0.7818116120059887},
    {0.46960476723774874, 0.47213357966091424, 0.7677315447675931, 0.3973029522491448, 0.628068685443245, 0.7029392143449479, 0.7159490797036151, 0.49996144140764254, 0.4636523609257105, 0.5878440584148743, 0.47669992325595795, 0.38947265439636963, 0.6881132608740342, 0.7935694685465701, -0.21529884901439217, 0.855347496426881, 0.40178654243405454, 0.49647236246894005, -0.2851503891075547, 0.7472626032833393, 0.4777688993288681, 0.7955691468415597, 0.38186154904885844, 0.3467406171337479, 0.14205677381296888, 0.286970279104796, 0.7360952563895288, 0.6910962088660692, 0.0691674458836651, 0.36108697892509095, -0.003184222483522049, 0.40999057423495233},
    {0.338556996473526, 0.586532194717445, 0.8986290904567023, 0.7704849781852883, 0.44589904522323254, 0.524963649181057, 0.7451508202763095, 0.5623819143859912, 0.839435694758567, 0.5330231519357737, 0.6429293428565215, 0.8453047863767339, 0.657265060873251, 0.6555470991420377, -0.06483793503005846, 0.7922478560387267, 0.656748339035965, 0.22143292775474333, -0.2561950182253379, 0.7522323158150193, 0.7913346215870208, 0.7090804166100068, 0.6916836246985982, 0.7288503969138895, 0.1408849389259681, 0.25908463562316963, 0.5364409226175926, 0.7857412538149496, -0.20304123661486176, 0.34397673613177016, 0.09435182330693061, 0.6636850176520127},
    {0.30373392600371296, 0.4581312770031228, 0.7435754995416451, 0.5132293843000342, 0.7147107217547544, 0.46808776660893775, 0.8334330081177296, 0.4568683737355515, 0.8013039264280124, 0.6342249816753754, 0.4062725487279472, 0.5690183986647731, 0.5287953176770788, 0.7459355100278816, -0.11613912558040504, 0.6681981589677466, 0.8939678547717805, 0.20939057445990003, -0.17396225685696529, 0.7811752152276147, 0.526609623632854, 0.830696991752108, 0.5297092478125577, 0.664659504408021, 0.09536131774432341, 0.6125528940162319, 0.5068184932588772, 0.6211529485292309, -0.21751560507084278, 0.6003083961117949, 0.13973629508192512, 0.6499845997606611},
    {0.36087849938442884, 0.6895100648828772, 0.4689013056746578, 0.857505013711441, 0.5573441485038659, 0.6812931226186533, 0.8730332121785035, 0.8204843146934238, 0.534275908573419, 0.6399727820276134, 0.4975298900474536, 0.9124005723836232, 0.5954571089348611, 0.6456330468242413, -0.2598653333971045, 0.6383392373234814, 0.7549099298374501, 0.24587975679215315, 0.0724301028837072, 0.8466803637833451, 0.5860468927204954, 0.6520351213591433, 0.7435986934279437, 0.7614324798024973, 0.20308555237937562, 0.5498792373458347, 0.7332375716275553, 0.623943242486699, -0.06396404755652643, 0.48595957217287633, 0.06864256584953259, 0.48908230358116855},
    {0.27732912362701473, 0.7472021470935398, 0.5149948209514782, 0.3982738079646825, 0.6130747835265999, 0.6262296096558173, 0.8116258086442669, 0.7257665586387061, 0.5689430897387409, 0.41091919857619424, 0.5582719140994201, 0.43396336407903724, 0.57566237687129, 0.5916518766419718, 0.18543700742109043, 0.4467009238373251, 0.7783387453047863, 0.4041046804433489, -0.19090575152981967, 0.5838084342624564, 0.4304310925257341, 0.47505183789451844, 0.8158215306709066, 0.6896617808424356, 0.34390521163169996, 0.36874400771116933, 0.6207383622986357, 0.6723785619913315, 0.10924362950421947, 0.7988777101694395, 0.011162041830377317, 0.6236969983110565},
    {0.4033944616252104, 0.6423635401080673, 0.6223104181557856, 0.6291828217342865, 0.40569905621557356, 0.6393467682425963, 0.5439313610164875, 0.7636389327393047, 0.5997298379144117, 0.7699840086828307, 0.7139880883599379, 0.7683239142901176, 0.4666545183894525, 0.41810160027388027, 0.08489255351887717, 0.8672897675471551, 0.5315036409906856, 0.13641313774416533, 0.1785135307584962, 0.7545522260456998, 0.4908043588724346, 0.7098746775614663, 0.8513929148560928, 0.31121871146940083, 0.16060259852193842, 0.44454340557152855, 0.5002066775407793, 0.5947886215659153, -0.0938382167368896, 0.4842846593735907, 0.2535999425729711, 0.5020825244361131},
    {0.36777744825085856, 0.5489665675398294, 0.8075052604582763, 0.7590961303249418, 0.4973120714477931, 0.32598358943958966, 0.5208788619535659, 0.6324831602435294, 0.7311772886246606, 0.8504122635579531, 0.4791519699168806, 0.48634243597846755, 0.32622073233116905, 0.8171493961227816, -0.24825008381312758, 0.4848960286967298, 0.7814514591146651, 0.0751568659952289, 0.009925808377247375, 0.4416816917596245, 0.5753605063396151, 0.8214131704384976, 0.5572726211104606, 0.6172740711175281, 0.45717940500965903, 0.16705888222820223, 0.6903263026150451, 0.6099745054371746, -0.17798680327387803, 0.5050324967217691, -0.05768856288563903, 0.39122684942468366},
    {0.19183971067400868, 0.8013215786276696, 0.560287158462387, 0.6584955308643522, 0.4660285755474965, 0.6952477682527046, 0.8621848277741467, 0.8143602994842271, 0.4666628834049815, 0.7741006527408468, 0.8062028470655092, 0.7837243815980541, 0.36394771355998495, 0.5273845949558873, 0.1522423088561042, 0.7249476241310482, 0.5749942153946312, 0.10221687131771955, -0.13249115295469105, 0.9112664891290472, 0.6659589330992322, 0.523170454751493, 0.5928988558090774, 0.5145681409581382, 0.3328977891453306, 0.6292755733093729, 0.8211805938044939, 0.5506598428938724, -0.2030683231450705, 0.3662483070561282, -0.006892481828196725, 0.6905620389815204},
    {0.03624237919459378, 0.6742329360062399, 0.8077099323720954, 0.6304411592331766, 0.5959026321063964, 0.6522388794209204, 0.6097505699771489, 0.8779864520756124, 0.5925416254268313, 0.6289788065188437, 0.7661591589754824, 0.8202665023036361, 0.4072238892206737, 0.6142776866891321, -0.25263041516790774, 0.894727951879401, 0.8646179803498311, 0.33424768168926544, 0.016841667273467434, 0.5239496070311123, 0.6556311577268543, 0.6282602036577941, 0.5891047038695323, 0.5882534086184298, 0.18569699456730498, 0.6060470087128612, 0.815217745648774, 0.45657422395908176, -0.02212658068731417, 0.4414320218866084, 0.13457591139471342, 0.6599731758783188},
    {0.2229332500444383, 0.47644678149321273, 0.45566269362708034, 0.7783521999523983, 0.6163816385254737, 0.5986548091943026, 0.6399708447350307, 0.8315063226359123, 0.8026664779682279, 0.5434051606411652, 0.6432859609501319, 0.4562511454698059, 0.3640936112474063, 0.7905962177996924, -0.1715504544381074, 0.8329900010642348, 0.5664246728367404, 0.16154867132460393, 0.1477308718398837, 0.6542054982776899, 0.7513768091940046, 0.6725445093903476, 0.6555597704034253, 0.699303221178831, 0.25591717097693, 0.19261940102349073, 0.6496320429926862, 0.5677776572844947, -0.004906347381834212, 0.5539475942153413, 0.23355379493937917, 0.41636327190636563}
};

static const float b2[32] = {0.250091389466385, 0.6348496230385303, 0.6633042417347338, 0.6695820532804609, 0.6121358865521205, 0.4814839075340738, 0.629331832931345, 0.6310126142422038, 0.6317257106698607, 0.6152376361884988, 0.5693885945703763, 0.5986712693420877, 0.5566651036458429, 0.6243139787292761, -0.030993361572633795, 0.6457444271380824, 0.6150974082903766, 0.3308806642869505, -0.056729828476798486, 0.6499566413978285, 0.607435997201307, 0.6387701613420046, 0.656656453722572, 0.5357461788844843, 0.3539505822723778, 0.46417794565052267, 0.6100657582739618, 0.6648401049944836, -0.058831374435803704, 0.5660908318807644, 0.41140126603632665, 0.6561882911806183};

static const float w3[32][16] = {
    {0.22638527932295643, 0.5486493759706189, 0.1483524112626121, -0.10652996535373493, -0.35517030321962356, 0.5030737247561907, -0.2758987727390888, -0.03117673809508589, 0.35293767843278145, 0.29539433232674694, 0.24756471956042833, -0.023546418933612413, 0.3433088820744463, 0.11616840320215585, 0.37328115570794773, -0.10212891195763786},
    {0.3280028359531503, 0.4748705852502577, 0.5778776805664693, -0.3158164114089083, 0.26720258080672626, 0.9972313293813064, 0.07762994451548394, 0.12653732977904614, 0.8427556516531968, 0.7012363316907031, 0.8235042578242341, -0.26332327833863955, 0.7344023439594041, 0.47165449249027885, 0.6143460916140097, 0.029965678853577708},
    {0.011851705701383788, 0.7848917825137802, 0.6146260157858229, -0.23800678964574404, 0.1512678068119067, 0.478296219499761, -0.1778953167224307, -0.21869601186978418, 0.6693536971698458, 1.0246039711526846, 0.950274847493047, 0.14469305620919093, 0.6122902749638547, 0.7920333146392751, 0.45687221359137353, -0.3466000738959716},
    {-0.23031942039263353, 0.741772923958328, 0.9668867817309221, -0.006447503860345344, 0.15325602039395908, 1.0106058369173843, 0.0408509496170203, 0.04430044420986669, 0.4630304972047105, 0.7892414215462314, 0.9666016672330214, -0.08062240356187943, 0.8081450001877428, 0.5639677406515561, 0.8560343349975684, 0.06941854735809651},
    {-0.0795221451474901, 0.7522743505944284, 0.8201739115736567, 0.21707331317714726, -0.33605319891510166, 0.7639833073822418, -0.328613603391053, -0.09896244098950427, 0.9369075366451619, 0.7329170121471061, 0.9436080168494897, 0.015578431832514686, 0.9740935684791688, 0.5214899843793889, 0.5154949321994445, -0.4036654404317384},
    {0.07348336102205569, 0.6468197482165048, 0.6796592420993943, -0.02185778655785398, -0.15521084799041748, 0.6364173634399743, 0.08268573274578005, 0.26764754733258755, 0.4592034426063059, 0.6777869110642802, 0.7500305533409101, -0.30933775146542314, 0.3125302617665599, 0.7618255326627013, 0.5302972405727131, 0.10753925427050132},
    {-0.22917258208742694, 0.5487079393337952, 0.44981530042295104, 0.1241202255154402, -0.09153180163900915, 0.7798988911013982, 0.24979545309552145, 0.21405535552477548, 0.953267079126338, 1.0580590797524312, 0.9145574286467645, 0.28492054774801184, 0.37810443779931074, 0.8110411853775171, 0.9918477180970371, -0.07876911194900889},
    {-0.11065265628834947, 0.3012265766929295, 1.010881054651449, -0.3431035860597855, -0.024624181386621084, 0.5765093486493954, -0.18366920801929212, 0.1048496401793877, 0.5173025653190299, 1.0711691202488673, 0.6554318294919234, 0.05005952053219893, 0.7335095623777007, 0.8838567730866262, 1.0246111077534918, -0.10042898662174513},
    {-0.10119965854686344, 0.5989679593426822, 0.3086351522242657, -0.09468695561345264, -0.20601472907532561, 0.33098000160702046, 0.04208055389731941, 0.2197265242906158, 0.9599985499406534, 0.9353615289678493, 0.41091110782823664, 0.1413065746055616, 0.4261996429523733, 0.7136016169563064, 0.7572071919185427, 0.09914045718200508},
    {-0.09023665816565667, 0.6014638247546937, 0.4217537609102451, 0.0693856317680872, -0.22820886483467234, 1.0513620073751908, -0.1429745854551427, -0.21688635303334078, 0.7248909231796296, 0.9473929808908894, 0.8128457286129335, -0.1746477155648591, 0.5938862188693127, 0.3798325876841742, 0.8331817925500591, -0.04994689544353173},
    {-0.122515147440396, 0.4053380495644632, 0.5596253147903998, 0.26512823895917587, -0.22581782434505845, 0.45618171742298574, -0.17324163599748207, 0.32339794417957785, 0.8356654299810898, 0.6598958269805257, 0.35026084198773794, -0.19417736997737503, 0.5321177846036731, 0.8617424256101416, 0.7503200065311504, 0.2708464411035115},
    {0.04055243544111244, 0.7842566555831896, 0.8875728842414858, -0.06388150218034697, -0.21538184066043758, 0.5475154568177105, 0.016276993888727782, 0.13108510775002277, 0.9602051746964299, 1.0111804839569414, 0.37726496069801974, 0.0022479212389539104, 0.9493219971000301, 0.29638829379351483, 0.9487331655373431, 0.26471398171204086},
    {-0.05104017976135764, 0.6062333595568655, 0.48335332667259145, 0.042584388400192165, -0.25183717174930675, 0.45113712644321075, -0.30269640985893276, -0.3609896456930159, 0.6366044929490886, 0.9764886370297738, 0.8913004340836296, -0.003272342356295784, 0.38675333939106926, 0.4408948181234125, 0.2999243362008279, -0.10484149958086691},
    {-0.30133855030705714, 0.545984420532738, 0.3795804254552998, -0.17850525994756447, -0.332909289176174, 0.6580701708269134, 0.06767219588574831, -0.3273360276093581, 0.8261064119005184, 0.6676747705414836, 0.9685901810106547, -0.31650715307384036, 0.8431576972023205, 0.2528764268051458, 0.7991813687973227, -0.09501745049520889},
    {0.2847009294758936, -0.007744231770567308, 0.3771811235488074, -0.13278617500860654, -0.16662217227733486, -0.19737640748943217, -0.0952755756658299, 0.07165386487066407, -0.22141993237630722, -0.13472096058192337, 0.16706600229247387, -0.14198804033876725, -0.2855388323932835, 0.248553914502098, -0.2022578497781561, 0.1363794608071839},
    {-0.2340992914436961, 0.5097220300370882, 0.5991373475318666, 0.3314621165509176, -0.2746780262132979, 1.012641705361831, -0.3607792156995944, -0.1876975977478948, 0.633067355447185, 0.973094228677178, 0.48147381975543174, 0.1747302339587981, 0.7738278984566368, 0.795807102939363, 0.48354948501474065, -0.3385928993113572},
    {-0.06457822307416644, 0.43384976362484384, 0.9586851251536502, -0.3074918028614034, 0.25422766748445746, 0.6431154183208632, -0.3269498648931102, -0.06098952792390874, 0.6575932944617409, 0.8103306564614395, 0.8866736591262232, 0.13270141751881054, 0.6991389403890498, 0.8659849475411914, 0.7082455831776568, 0.08552782526219072},
    {0.3256978299094477, 0.5540950525277387, 0.5986235996655186, 0.08329155724968142, -0.3463844311618828, 0.45198300838801353, 0.08067392786035839, -0.31603744818828966, 0.09800938130045682, 0.3414178146834604, 0.2788869870313361, -0.1612316370271185, 0.3442566986809128, 0.5446110756330061, 0.5180963727831096, 0.1508770751825205},
    {-0.055188669246783034, -0.1961027105504159, -0.052226345952931706, 0.14588917377503322, 0.012805351374340553, -0.18850669621204907, -0.13104347959364646, -0.04442136129802318, -0.20264570781925165, 0.16309175352552518, -0.19014553729212805, 0.11286132730855276, -0.07339790278817891, -0.17858810517696033, -0.0304985579925193, -0.2035404753422187},
    {0.1588649564432269, 0.6219952703665631, 0.9730800435330524, -0.28371245731183364, 0.05348299230639159, 0.945523451396352, -0.34516488674555174, -0.2645251251243497, 0.878946167299108, 0.6224044857604062, 0.42062780269102645, -0.14444068747514036, 0.7758877479581643, 0.617278009037685, 0.5149964386592212, 0.08225119763252636},
    {-0.24564456508217217, 0.4607034851683492, 0.5846332322767157, 0.29190620258132804, -0.011247094517079396, 0.7031423461948448, -0.11467951747786528, 0.16298909850760257, 0.6400823533585116, 1.0073911512925684, 1.022006338053162, 0.2866011717807682, 0.8134149881385423, 0.8266709283105831, 0.4293031390043016, 0.12034332876873512},
    {-0.25034987283240184, 0.48680531571710084, 0.8429472163502669, 0.08702787476206272, -0.1135753317542274, 0.45882110632926926, 0.16607490085758653, -0.3765999351405611, 0.7998595922189936, 0.8768972844676873, 1.0152058152489454, -0.21053217934396848, 0.7360983343715455, 0.8628881282068598, 0.720899375384111, 0.04581411833472551},
    {-0.012187412126194189, 0.5194479776106714, 0.6917711431427844, 0.30737977225807056, -0.04723098244970422, 0.9674209817478755, 0.24790028899883176, 0.11273372043105573, 0.8950118732793415, 0.5508493259848531, 1.0197299207203168, -0.0074334729012699476, 0.48813928808065554, 0.5474058118917898, 0.6549113688627136, -0.025422120298612082},
    {0.09461357368939202, 0.39069915843094977, 0.696544241470558, -0.35539004903737864, -0.2285878165701235, 0.7955324435757638, 0.1686487190394025, -0.29958252813383607, 0.5880843662295735, 0.697530172913441, 0.533851008689762, 0.23744589935703103, 0.5633107863700311, 0.7843535944443003, 0.8972666025531761, 0.26151863948102},
    {-0.32246241673408693, 0.294785707347652, 0.3474317675211951, 0.038044552910555536, 0.2849910273839503, 0.2084839982833019, 0.11463340799530422, -0.3531553494009276, 0.14461550727745442, 0.6849690824156625, 0.21896455395287565, 0.23137400679544629, 0.5801960826748902, 0.33095744242983144, 0.4587518424575712, -0.37626899760224813},
    {0.06691019913505337, 0.5011599469388093, 0.3524532024974033, -0.20399034367248933, 0.31542945727475435, 0.25819361746721553, 0.1587686876181283, -0.22928674692738937, 0.3378595048571563, 0.7236277535484245, 0.643239339353717, 0.32492304868726, 0.5835686474759934, 0.6349875160578135, 0.9438877436839329, 0.2123553521758176},
    {-0.0647555755218207, 0.6332123975872861, 0.8088018505591754, -0.1532651565341495, -0.19899424720925257, 0.8225368010258928, 0.21330501734495017, -0.10466284163005714, 0.8164440744503018, 1.0159691642335447, 1.041752887284544, 0.17789768769942518, 1.0132063993609028, 0.6273546897960613, 0.6294739103652904, -0.3334113070974383},
    {0.08750123379138307, 0.7164891251274185, 0.650009777717449, -0.07631380662595807, -0.18778360561910742, 0.5692044092479764, -0.10642396954786314, 0.02873028268578263, 0.9934506608269266, 0.6001308705056364, 0.8628918189344658, -0.09252377523026485, 0.6390995862663033, 0.8856960925448771, 0.4808376618742098, 0.050964576438163454},
    {0.0343846391057483, 0.12232048472599612, -0.22890272741503445, 0.22179546602415948, 0.14189182069267087, -0.1939484607258582, -0.26695043866847296, 0.1143776492219434, -0.06277142890192253, -0.01091988759914527, -0.10564861384770953, 0.09346888426499414, 0.3901583223321148, -0.2340233639138857, -0.030753169762672724, -0.22769256577723535},
    {-0.29057294004758777, 0.8728327224369465, 0.4326992068300062, 0.25270448931688827, -0.3440407612406992, 0.4170023839268241, 0.010448194556328566, 0.13670097490143274, 0.6034943033712583, 0.9283448379795025, 0.5863206510171421, -0.1280912835162847, 0.6496836996471288, 0.7020175447299756, 0.5878897858807681, 0.08057998817158012},
    {0.10523225927611572, 0.5452944662570851, 0.7459596022525389, 0.007273181281617802, -0.28518739330520343, 0.27581277547702626, 0.32124399401495923, -0.3103972929656685, 0.14129420960777514, 0.21134660809402186, 0.39064966572906623, -0.04055508524701127, 0.025481653563682524, 0.4585025006393974, 0.3599618698856018, 0.23440036956988486},
    {-0.19986244902925596, 0.6901571307576265, 0.7495982994282525, 0.04690849272762308, 0.09210704706404627, 0.5545962626478628, 0.20114782608222967, 0.032951324703588726, 0.4624378526336947, 0.9368579575767135, 0.4431147990701427, -0.20918842091160358, 0.9908107407373334, 0.25714945137286216, 0.6687316857667059, -0.09261512138083326}
};

static const float b3[16] = {-0.004706245558085359, 0.49362487129675753, 0.4867052773751834, -0.027071806053161045, -0.02676566232722875, 0.5240513095933054, -0.04413720857375418, -0.018567726307297337, 0.41122561446378264, 0.45383761650406884, 0.530075729932498, -0.043638555650250196, 0.4433403795714673, 0.3477349065153056, 0.49960389205006667, -0.03707877650313232};

static const float w4[16][12] = {
    {0.2770164939185005, -0.16293524539723933, -0.47254384656941983, 0.20181650872435958, 0.16548630172703202, 0.3575076430282792, -0.1716957098521782, -0.04367732794333993, -0.39525670161987825, 0.04505804932138637, 0.24299801875687047, 0.12055916431494461},
    {-0.5695259676545086, -0.21751122637037967, -0.9005648972380462, -0.24504538693424358, -0.6141208573169847, -0.27056199560812777, -0.7272853878729151, -0.8209421702262693, -0.6706009418230022, -0.328446430802939, -0.6011446570204764, -0.8938311299770929},
    {-0.8450526610474145, -0.6681673498924452, -0.8176935949505733, -0.8947898414352728, -0.3505061581089093, -0.7794662034504606, -0.7839044727148565, -0.8362771871824497, -0.1737199017240831, -0.8962113968814434, -0.4890521098031835, -0.15380486194817702},
    {-0.4316599738113804, -0.22274508714631716, 0.31050662148223057, -0.01884212546933501, 0.19897134292352925, -0.33383721455875554, -0.43073726766902964, 0.33019456421852894, -0.11970385195991079, 0.2222590390603914, 0.059277384380554035, 0.0388700230277277},
    {-0.12728704467770321, 0.3863557749871841, 0.10359428291032219, -0.02141783094999685, -0.4190733001490978, 0.009487637019197819, -0.13141227186422763, -0.4638853470285458, 0.24455129251211724, -0.20048221494943033, 0.4106836189209958, 0.3236875147638174},
    {-0.937624295304645, -0.514776816919511, -0.2537711765066199, -0.5745011284073179, -0.8111817115480304, -0.764212826618331, -0.4266971424220723, -0.17693242989251792, -0.37132093130275484, -0.39478287473027623, -0.8034017882300105, -0.9391654058824858},
    {-0.13187094771469224, -0.20453569704294133, 0.0723954849828425, -0.019530852319380468, 0.21309854913838275, -0.43729750976477066, -0.36649342253450623, -0.05038499445935533, 0.22652950489452073, -0.12969635925304404, 0.05179411447711176, -0.00011754646124365536},
    {-0.1499570308743017, -0.200221971557727, 0.08744632643967994, -0.16648088585328552, 0.10490831764567574, 0.39977599914817114, 0.3460897644890796, -0.019904296132918033, 0.33388187423225085, 0.04522377291168399, 0.415208576467909, 0.1460484213526401},
    {-0.8951569924302192, -0.36411415141274744, -0.9248918901367333, -0.9835253420231005, -1.001715365092159, -0.816794684319331, -0.592567835948114, -0.8206954395175426, -0.4533049770848574, -0.5643771561708595, -0.8894449009169746, -0.7736391696264184},
    {-0.1717014786021313, -0.6541267302299992, -0.7084519749217301, -0.43881478867312124, -0.5166164477747301, -0.3979585578011361, -0.7098480950252736, -0.6657469096342519, -0.8123455521355559, -0.3892900539318872, -0.93054337074683, -0.9255208686638845},
    {-0.8730127886040957, -0.7157370186534189, -0.8212495408641233, -0.6098762006217536, -0.23644410551809752, -0.5793655153770394, -0.7174966873541284, -0.31849847579186835, -0.5161081329749492, -0.9462235169319916, -0.30873548567738246, -0.6509262566985154},
    {0.3178871288666403, 0.07558265177846915, -0.3064052252028019, 0.27050954031246166, 0.02797434910752646, 0.11479619769088635, -0.34751015470719276, 0.2081915469341981, 0.2109278737887466, 0.09739233811141228, 0.3565121870627445, -0.11669818633766875},
    {-0.8533882559272511, -0.5897438694240719, -0.40546562149563437, -0.48727874235873714, -0.7544270827002466, -0.705091498225393, -0.8101602370160483, -0.5166047882129168, -0.9610067261508866, -0.7783974216851393, -0.1589053336588261, -0.491845371813079},
    {-0.19990314405274845, -0.6293156359743854, -0.45920766154304044, -0.9071391118642987, -0.5581896221659044, -0.48850619599012635, -0.2100465341011935, -0.05348716007700601, -0.7347841443272225, -0.18660274103944233, -0.241209182139734, -0.3289318620535062},
    {-0.21269538283664244, -0.9775126453644466, -0.2012855920872585, -0.34234262311927993, -0.5633769708995854, -0.5298091724889384, -0.5361483220228193, -0.835742856700751, -0.780709793253785, -0.8698489515383179, -0.8461505147035924, -0.2380858967780111},
    {0.23558401566387632, -0.19223815472345523, -0.09691432321807139, -0.23729150143780095, -0.511314047556967, 0.337337701641004, -0.07473157047563524, 0.11054120253682775, 0.26568379500316297, 0.41940057757563387, 0.21278278364102748, 0.330472774667036}
};

static const float b4[12] = {-0.14817522707748906, -0.21312014770133764, -0.19494089464094536, -0.24856312677488665, -0.18294776711233085, -0.12801657103633235, -0.20403916022559926, -0.2582997170539929, -0.22785665649204997, -0.1919182758354468, -0.24820676113583434, -0.2689998650023139};

    // Input Layer 
    float z1[64];
    for (int i = 0; i < 64; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[32];
    for (int i = 0; i < 32; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 64; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Hidden Layers 
    float z3[16];
    for (int i = 0; i < 16; i++)
    {
        z3[i] = b3[i];
        for (int j = 0; j < 32; j++)
        {
            z3[i] += z2[j] * w3[j][i];
        }
        z3[i] = relu(z3[i]);
    }

    // Output Layer
    float z4[12];
    for (int k = 0; k < 12; k++)
    {
        z4[k] = b4[k];
        for (int j = 0; j < 16; j++)
        {
            z4[k] += z3[j] * w4[j][k];
        }
    }
    softmax(z4, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
