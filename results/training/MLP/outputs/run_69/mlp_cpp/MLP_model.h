#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][16] = {
    {-1.3917207628443524, -0.6032331417512985, 0.6170794454021236, -0.48010247493656977, 0.7940752172461627, 0.6571980830998361, -1.474160098639138, 0.7729626961452224, 2.0514627541073116, 0.6993711144539824, 0.6312555453389087, -0.6066333844067793, -1.8059390412197456, -2.5085868590909604, 0.08484168050456593, 0.9712854285081617},
    {0.034950639356072975, -0.7237009717855105, 0.7289059801709743, 0.29103821641169925, -0.8415753597852997, -1.3994250298619177, 1.8512395279376188, -2.0234098895994865, -0.8874365261205166, -0.5758803662594257, -1.3261281625640662, -0.10518355810557085, -0.22892577194343405, 0.7004463343521831, -1.369435465599617, 0.4371835738923867},
    {1.5214367848932806, -0.8903090294385742, -0.8381035562755943, 0.7318983510548479, -1.3804813495429191, -0.3221428226428716, -0.4042241505370611, -1.482470577577485, -0.8537585451100678, -1.5028156365748337, 0.5091943382478935, 1.51544216637773, 1.1989670423293421, -0.8802670444014085, 0.6401480987571387, 0.8056410293148332},
    {-0.3062303531633214, 1.1218285634023963, -0.6001473576915279, 0.8789342283304685, -1.8144320818040258, -0.431100347148001, 0.0763208070036749, -1.7397829934733233, -0.8136264225344839, -0.7708837835620983, 0.8792191119341008, 0.6083615250580648, -0.3253803429248283, -2.0031577414456954, 1.208123792965678, -0.8793987845767663},
    {0.6911584561195331, 0.5011911149475854, -2.5944657086673817, 0.4313412518740126, -1.1867679150490817, -0.4333473279128439, 0.9227775794279933, -1.1560911126590128, -0.8578504548571716, 0.09125979397650434, -1.0658285618578485, 0.21095979117363234, 0.496535365548678, -0.6707220658968963, 1.0722224362380828, -0.6341640797226069},
    {1.8025257210975674, 1.5963819396060097, -0.611358466910741, 0.6119809614913388, 0.513309896252974, 0.5907907707225463, 1.52206857672518, -0.3651273509024849, 0.7267455271519387, 0.7549878704323131, -0.2430644334354025, 1.8402185902391968, 1.7311652320735884, 0.16975184323365272, 1.2150688143768145, -1.1220780080873072},
    {-0.3045829861744394, 0.6036043825941368, -0.3597537572318194, 1.0953465335678547, -0.49689065054945974, 0.4205254090902764, 1.2268441055596275, -0.6505315629337493, 0.3648776300790289, 0.36816099014273707, 0.5318615190165707, 1.7826568151961422, 1.1701691972644388, -0.3330532266837242, 1.5376782602728207, -0.6903413671800015},
    {-0.4370322288806901, 0.40726093267986796, -0.662272024415269, 0.04094266253893924, 0.09621022175021202, -0.3902475224707809, 0.6332747618352894, -1.4722807111824832, 0.3394841199359396, -0.35430946096769916, -0.3348550712249911, -0.2505476365010623, 0.4083551292276459, -0.13859387278162713, 0.6148370906147991, 0.29279585476440145},
    {-0.0967112003060417, 0.3442661792733019, 0.7385937372739939, 1.6541919656872193, -0.7434983612608128, 0.46022062860164514, 0.8498568012061559, -1.1371770981339462, 0.4672023233379255, 0.7854168080889039, -0.542166701904012, 0.3499816331813124, 0.14625037994389795, 0.15336024313034016, 1.7653617419025145, 1.1869648749209316},
    {-0.901647283723747, -0.371022299172849, 1.3231002384165422, 0.31556119974897623, 1.95382145364788, -0.6057210202720956, 1.0328615051585104, 0.5936903955242923, 0.0645593145597156, 0.05427588052929287, -0.10273643404292927, -0.3185237871345841, -0.034068753948124406, 1.666096530221732, -0.5361298476645694, 0.6533782232427486},
    {-0.9807890494296012, 0.29444398736006316, -0.7778109690670771, 0.3958939739054612, 0.29317663180796294, -1.4259005878596873, 0.8250286514344312, -0.37706188501666066, -0.46729561327632674, 0.14634594447723898, 0.6300433354191248, -0.35158690484052507, 0.5506493071045291, 0.13197404795637505, 0.21016117422236238, -1.113671763186291},
    {0.7173657550720052, -0.3226955086167154, -0.12583952636496978, -0.7083748568743078, -1.5274211758156717, -0.5726724170988557, 0.094062148611822, -1.1564079315131102, -1.4339236705976093, 0.7621471601556064, 0.6515654034470674, 0.3013508785140592, -0.12089876020197834, -0.8941832505268703, -0.1977880829564612, 0.3168635156092552},
    {-0.6884293784582208, -1.5451383927835811, 0.2919650588714125, 0.14490035326204764, 0.006958912040339179, -0.38803134467777983, 0.14802601101855248, 0.28903298789614745, -0.0003272324015716909, -0.3135653564760184, 0.21391061738702782, 0.5388870220968363, 0.1876901910757916, 1.2357732074311214, -0.2996156231473623, -0.18129630406197078},
    {0.49061500991085205, 1.4297068103159893, -0.22570201837625598, 1.1531298210254048, -0.7465442234008504, -0.10705148304497958, 1.0556521250402027, -1.7177366195675547, 0.3893121681628104, 0.5927818471756595, 1.3007241269765368, 0.33690905528841786, 0.9244386926188294, -0.2325101608643466, 0.26420463692676127, -0.6568970138461254},
    {1.2053999710074528, 1.22205335335474, 1.1014555752372526, -0.02504739621730799, -0.3133047308600364, 1.2956794042602937, -0.25793846116902674, -0.018147628281763067, 1.7753668298384844, 1.9748715927241736, 1.81375938169736, 1.2597122896319708, 1.1072510212211435, -0.6479603630718932, 0.9413232407102036, -1.1191539634990217},
    {0.49640008756123255, 0.08491860738426753, 1.9739442172275876, 0.5925643419450561, -0.5652272650492267, 1.2113669018961872, 0.5292206360708193, 0.30475467913949406, 1.2894826583111305, 1.4603961385171447, 1.4632516829364461, 1.0910565694865872, 0.9753088300160493, 1.562515058656293, 0.10658511938155611, -0.6436851573649229},
    {0.25767507950084734, 1.6192911725569934, 0.33146191041411877, 1.2336989866946921, -0.06336761150225806, -0.105779518969708, 1.3820117186063423, -1.088766608984418, 0.477104800748509, 1.0504098792082401, 0.6380054396662297, 0.9351473586251556, 0.7950092435886644, -0.6395791757091602, 1.176277574489311, -1.5392967418493695},
    {0.12956714354102544, 0.7812711039185947, 0.5547522673354005, 1.032362399795656, -0.02200210426256795, 0.012817261553783195, 1.1046977305690262, -0.04655256958825304, 0.4031859661083328, 0.994458267205133, 0.8746617505471883, 0.6099351380776111, 0.7429385187339475, -0.11491985762175223, 0.8518244193101179, -0.29799419440758046},
    {-0.16727048829131416, 0.08939643998243456, -0.6480776168416478, 0.7177480224223555, -1.5813724341908366, -0.483439144925048, 0.43949350458174524, -1.6485633084166715, -0.5753427740515866, -0.015018061971404833, -0.47009689870898064, 0.5066983857617762, 0.3391993229451658, -0.8400287455884448, 0.5082448217783497, -0.3603890577214142},
    {-0.3368553923966089, 0.39940315032499035, -0.45397920431823874, 0.09846452696541111, 0.21502011895235315, -0.30710380543715005, -0.3303554515119087, -0.8806779700016742, 0.4676347426206811, -0.5925397187523155, 0.26942002929368325, -0.49797407536839483, -0.464340130484129, -0.960772482751969, -0.3538779787721126, -0.7229390828730315},
    {-0.05820507259854077, 0.3322000519889876, -0.595948366983764, 0.21901485746292657, -0.9899683389221455, -0.9219407582334478, -0.9151150751230293, -1.1929552510162176, 0.02284538494191278, -0.10116866279423052, 0.4229038267834467, -0.12965337592060142, -0.3407130998229557, -0.8712969808890852, 0.19898042726247692, -1.0715813151364022},
    {-0.2955355986563207, 1.4315852494764998, -0.7286142315923412, -0.42570157843175904, 0.4991554926767606, -0.46536295272564293, 0.04255130229836995, -0.7627542973647666, 0.3650003305811395, 0.44596539548102726, 0.8859248108488929, -0.8854790815505191, -0.021424028047182592, 0.2732722580257478, -0.05980455167679795, -1.7615835887051172},
    {0.8381023984387724, 0.2935209561387944, 0.3028305156558915, -0.522475263323847, -0.2859652249037211, 0.14248973028551382, -1.2041167227440415, -0.11982859075418889, 0.09514493094454884, -0.7750816062179559, 1.663264149635321, 0.22325737757680375, -0.10303580806852969, 0.36495726884180624, -0.49640843347828656, -0.5128098483009486},
    {0.6088341425419835, 0.05525871123242908, -0.37001404266000515, -1.207164968207484, 1.455051517603501, -0.6094094974501215, -0.6700409219224378, -0.7108757711607167, 0.10050959856996022, -1.1627036374732194, -0.14172227782689775, -0.9915605107408315, -1.0722128571169518, 1.2096861752294494, -0.9749203757676436, -0.23394919462394279},
    {0.04475682789006252, -0.2573776325351664, -0.7273756743927836, -0.24452354971549245, 0.8710467884054869, -0.7414815135450855, -0.3590026315224931, 0.0889187787971709, 0.2520033954269177, -1.086194980459471, 0.7849135299689975, -0.5062413390279878, -0.584641754391118, -0.34649949174092615, -0.15170393508155317, 0.2323160196545343},
    {-0.891117073464732, -0.7963975206551654, -0.9243309866672422, -0.38230497947969005, 0.486567978990994, -1.133369298316773, -1.2020670612741193, -0.30294746545037954, -0.7446572971550273, -1.8085730614899578, -0.20027893810610983, -1.0707061856285462, -1.007459980385909, -1.0824043086447963, -0.7332904141936456, 0.9896476946697377},
    {-0.9869093758810541, -0.40058816543974246, -0.14150917286926717, -1.0992996251523643, 0.9212148781559735, -0.33599850434307393, -0.6539626650353494, 1.0397275588853983, -0.9646061388453251, -0.18681969150163572, 0.9241981926734444, -1.190685281921586, -1.0255644029967128, 0.049983225170072185, -0.9589241553691086, -0.8575823127812168},
    {0.3742829695737022, -1.029044449905473, -0.7394743152160017, -0.7952585796126601, 0.6208833940811102, -0.1517429892757158, -0.6806150403606473, 0.141724408904728, -0.30210480115811267, -1.2038039536381182, 0.13392378840800193, 0.26382696964427943, -0.46412581644106143, 0.5903828478078489, -0.2499205903957974, -0.10943666889534204},
    {0.9808724117321442, 1.0382559922820882, -0.5086324723563937, -0.3396297554255219, 0.13452576288409107, -1.2683897174693441, 0.1853069400119128, -0.5824606942592346, -1.0172073908588044, -0.2411579998609932, 0.8134250388017329, -0.46109213669270216, -0.0872668841959041, -0.1318981802219757, -0.6351278233419766, -1.078339056164888},
    {0.5840437572148179, 0.2037776024326815, -0.9991729123628227, 0.23843607942056325, -0.40824170840117957, -0.7379682531025751, 0.41514219570473576, -0.6706905160949859, -0.7111995415001638, 0.34404799994470686, -0.06896601499428083, 0.08942566011898734, 0.9318720026839429, -0.4271012839125877, 0.44486315982939095, -0.8515985390111787},
    {-0.6852464494180146, -0.8567780089151685, 0.3913800157401565, -0.756018791041895, 1.7704382380535213, 0.7507391906809433, -0.5640199317340971, 1.0838311314904114, 1.7901471046409063, -1.2554447921845424, 0.11629061225606631, -1.6878237401886262, -0.645986729533385, -0.3582744077278956, -0.5160246102490651, 1.121820419631363},
    {-0.2938943321258533, -0.7615250635451524, 0.9845267010171125, 0.06234030868259956, 1.6297984476345404, 0.7907120406907154, -0.967045459834973, 1.0448239776929524, 1.920929790525525, -0.9247502122891467, 1.3706311624294745, -1.19310951846885, -0.6655362170510541, -0.03944480660422984, 0.09052889190728426, 1.321577038612953},
    {0.06514946606531374, -0.5071218983208894, 0.8733802825751313, -0.23684870743617872, 1.8812989335554453, 0.4690531513592377, -0.7241342688845791, 1.2865125495751193, 1.7664517443984968, -0.47676360614436697, 0.6623757908290772, -0.2574692477921603, 0.018595558095697053, 0.29149312546736506, -0.2298332461614682, 1.281525984458394},
    {0.40623723666557016, -0.5348070568940081, 1.0461665472464385, -0.17728592255941789, 1.7617137475760378, 0.8802343511146563, -0.8401953935864697, 1.3482081222980256, 1.6889742931077536, -0.8093940863070699, 0.37493364314515726, -0.38994901120636166, -0.06176362165639948, 0.2781460209325716, -0.09349526090528952, 1.393766701161923},
    {0.3765502356641512, -0.2194701401245954, 0.6829306146338625, 0.41022176170396546, 1.667479680076665, 0.1327542233522779, -0.6417635445874939, 1.0567713250065487, 0.8577782001274926, -0.2980456642017776, 0.6291019874421977, -0.054951836658813195, 0.09648487075316108, -0.3359548325315974, 0.06306110193501759, 0.9269295178965551},
    {0.06431811475741563, -0.34411918981940115, 0.38223943390223175, 0.38499937935224043, 1.4023418150518856, -0.24040307358047003, -0.3798220605802384, 1.2545190001778221, 1.0957781652819352, 0.03746160394906098, 0.8202583314119504, -0.04604210691043425, 0.08846664305175946, 0.15243313125155064, -0.04554123275958169, 0.7467074600024233},
    {0.3729030828542141, -0.6993415427317903, 0.2695064421836815, 0.0777118198105434, 0.8535763955374949, 0.5369176450520146, -0.40778384264037126, 1.0120996574603716, 0.5643612656198629, -0.24209416962905253, 0.09634778879711238, -0.28322851526364073, 0.2980662912971202, 0.06536181041647078, 0.005661285017075155, 0.38884645409740026},
    {-0.027520016139314804, -0.12269920241580597, -0.3988962269775114, -0.7167665635769271, -0.8990990636546012, -0.09327230846440653, -0.37640691231038764, -0.03174630580197882, -0.3237297594540169, -0.14740745346011477, 0.16904271719852793, 0.18000874615653656, -0.12922703360264576, -0.503081378390383, 0.28467854339631515, -0.3348079788261381},
    {0.07624923187326896, -0.11308580252938963, -0.3898278599627193, -0.12296872599644797, -0.266981868744016, -0.3814759616081517, -0.5811851503066685, -0.056563695360625464, -0.028433971594153336, -0.3923096733155493, -0.12336392883371274, -0.13890273217073817, -0.04568584234524993, -0.2676577298148388, 0.1052218046048461, -0.3607739743815818},
    {-0.2657042420581923, -0.5208536435913559, -0.42770325945840093, -0.02975671070880194, -0.15627239192816184, -1.3573482255271994, -0.39028319466707406, -0.711282841265278, -0.34135749448422326, -0.31368216187331543, -0.4342175647417359, -0.09846601713956378, -0.3372419936423982, -0.5507522601087683, -0.17099468320727515, -0.49451800666424595},
    {0.2832029787311265, -0.17970235564122192, 0.22337830699812772, -0.10782300935329239, 0.16793035504091713, -0.9892486405736775, -0.0018110602369535047, 0.1741807835467006, -0.281067050618844, 0.5554126364783517, -0.1892019528241904, 0.43379881971543144, -0.34170329913806163, 0.08505587115667122, 0.11360615171286834, 0.23901251676255927},
    {0.18682936997287028, 0.08037120792204251, 0.6363998772148655, -0.4263056268951831, 0.7820116301098323, 0.1649971039608621, -0.7674924747594534, 0.5014942731055558, 0.6820526743348886, 0.054845820192462875, 0.49043062439876134, 0.020697851317697052, -0.40267759382368584, 0.5473052097745671, -0.0342752945426376, 0.24589656013920472},
    {0.4664775514772689, 0.5565365872245372, 0.06579229838303516, 0.1513598994832219, -0.4210383685773344, 0.22687159295956244, 0.4959589740077625, -0.7993062459096698, 0.2559586094075431, 0.6025279433313688, 0.012723602446799733, -0.2506574764185796, 0.12036665539274032, -0.06016313859026118, 0.13819094047560182, -0.03473897926737969},
    {-0.13211768260281664, 0.21993109278743328, 0.12182834386564267, -0.6828888991748869, -0.27203961166957447, -0.44233425564827666, -0.16933325126252782, 0.23458504190958404, 0.06357734291496189, 0.12193204001350784, 0.01993801370976405, 0.42428832631181, -0.525790040678268, 0.24960828400625767, 0.11212318285563681, -0.1617926525828282},
    {0.05090926815294372, 0.031072805261656334, 0.1849762706890717, 0.1448620652897477, 0.15360088069053904, -0.31826143321018857, -0.3056273078458773, 0.13847329949233772, 0.12628188552183073, 0.19111942112440547, 0.23666477627851637, 0.1830437589269336, -0.15556431590549827, 0.14797201670185414, 0.18756334558398144, 0.3684421914805175},
    {0.7315451625312095, 0.11294472961788958, 0.1264392509215086, 0.290593214451415, 0.16104257237816777, 0.29650106161922674, -0.2898526496403454, -0.2692808954791914, -0.09242467406103186, 0.1029491240449337, 0.13432821585154836, -0.07378607103737919, -0.21595208667180893, -0.1365961631410047, -0.03198665057470973, 0.45600515348639636},
    {0.30859246811629976, 0.02999305960364731, -0.2937084535905142, 0.01770027014521082, -1.123391239596912, -0.8266448378873382, -0.2448260199419287, -0.7373970872255996, -0.7963427149041578, -0.18213946739123654, -0.4899272154560776, 0.10753850350709318, -0.04090916486486444, -0.21152064169126103, -0.17876779069822965, -0.10967646139384304},
    {-0.11786835045844528, -0.20467122714531774, -1.1461800900767047, -0.2255875918076539, -0.8434152042906919, -1.4503770811924963, -0.33728570960564686, -0.41272433949642595, -0.7988785587176285, -0.5360318298926953, -0.730701438271729, -0.06184597469234437, 0.2864515882263626, -0.3720381763626054, -0.041243155526251726, -0.27325523392228546},
    {-0.03916332299366314, -0.20644707852229532, -0.08603346579023101, -0.29693252420196853, -0.3071310960609377, -0.5263808434598779, -0.030999755638773566, 0.06939520589711684, -0.18538884565032637, -0.7160910771990906, -0.22783793224883336, 0.20602017954639776, -0.05554587361926796, -0.14691104640232078, -0.12568627590167952, 0.6133819754634133},
    {0.25604320192198526, -0.10012897502712324, -0.00256117172147527, -0.3648102695743852, -0.2607298495828479, -0.9548421028214685, -0.6779211257319255, 0.255811791043663, 0.1687797508712704, -0.057102114279054664, 0.13802151992588532, 0.2923899907419688, -0.0038877482512443247, 0.32936333241754817, -0.19735496312400827, 0.2015781122208142},
    {0.3507907964113097, 0.45670690637827394, -0.11122268822016446, 0.35044811942573867, -0.24156415318071758, 0.10695652730393072, 0.15333632498892114, -0.048847444486801936, -0.052441224002146666, 0.051585161049224906, 0.2743138013930194, 0.4955050071105629, -0.013627265718651442, 0.33955141220225304, -0.2128571861013139, -0.08729997128381946},
    {0.4510456492417451, 0.28413470800250035, 0.3820478338085611, 0.1808127176563931, 0.3248020406555687, 0.12013594981895255, -0.09556143326796229, 0.11872488664606876, 0.49272550528019327, -0.08217875106492552, 0.6024268923220244, 0.1703601975116878, 0.16669442705708104, 0.44657585330193256, -0.031734372127170125, 0.15597460383797393},
    {0.23360092389183448, 0.4935013902269061, 0.6270442721266704, 0.21920213633516675, 0.8461826049639865, 0.6493264482834586, -0.2354393565768755, 1.1415291911972503, 0.5350916955035231, 0.15933707756195736, 0.619579985651952, 0.17883792750973682, 0.29899308275331504, 0.4027556618149611, 0.25836232622654426, 0.773668236566626},
    {0.21510647813474554, 0.31337420568601215, 0.3047752535099816, 0.2939266279868772, -0.10078384916399744, -0.20572524186704966, 0.2655921440445208, -0.11180168710279371, -0.7015664824172931, -0.18348118477452485, -0.011226598523294043, -0.008011093775047193, 0.4160998809017952, -0.12290877238459272, -0.12226293530224305, -0.16013116696329996},
    {-0.050459707986924125, 0.14637848649719748, -0.30809001190899876, -0.11600727788725906, -0.5852503577019712, -0.5045973740472606, -0.13494945597803742, -0.31543868312080425, -0.32440843849558393, 0.06809566771028161, -0.07524196617213255, 0.24883012628942197, 0.3017179588659866, -0.4618637183546218, 0.15714780551760787, -0.3316474607046339},
    {0.12498029721988439, 0.5164427985910905, 0.07730069572961515, 0.3813713931038279, 0.2864894342231586, -0.137446475960634, 0.3796246126512504, 0.06562065136489088, 0.056252498712609754, -0.012295568298521178, 0.1866880256175334, 0.19992916153174517, -0.18225975566326327, 0.03505819537300497, 0.11178732173557637, 0.1744741579104735},
    {0.4082665617348977, 0.37108850335145527, 0.5592468756180102, 0.22222265717692552, 0.5301404644661759, -0.053707292299014546, -0.3728702507757265, 0.6803466770113705, 0.02479273346639322, 0.3005428800198501, 0.20298204708173892, 0.8770558766690109, -0.21625978899650214, 0.2985662119907141, -0.2376776635979332, -0.013390854987417473},
    {0.6428349567456376, 0.18158304342034884, -0.20450128009990282, -0.290493113600721, -0.3185000322967747, -0.4075912002771414, -0.2952305033190742, 0.02350410692519637, -1.280557102846996, 0.5324463744145623, 0.009514178773185113, 0.8328749166527731, -0.4995341862785765, -0.21230923158114626, -0.42758630996496794, -0.480925293047689},
    {0.5365997007582433, 0.4412173617727421, 0.24029358607094986, 0.279871185165174, 0.07351642933166716, 0.5222720076934458, 0.4247765360816281, -0.14380009818505274, -0.3422170212429184, 0.5810150035555245, 0.25070594311551336, 0.449708838543964, 0.20755918793250738, -0.06472642210687304, 0.14271089247911267, 0.113290337158686},
    {0.4933190852365206, 0.08413333297995139, -0.20696942678311112, 0.11036840637086823, -0.6264353555044985, -0.3523343997039597, 0.5178463795546437, -0.4916649308554546, -0.4222659561496124, 0.21378382367034432, 0.0696600775105793, -0.09343329085704244, 0.3336220254392976, -0.4808126082604007, 0.47022440004400606, 0.013985146060263166},
    {0.018998926609925425, -0.04224935965017891, -0.5874124969042183, 0.23359472042740323, -0.790121028861108, -0.8573116473505599, 0.5473564806107424, -0.8544319519760254, -0.8593620119941506, 0.2522730242674306, -0.2993515656907614, 0.2798063345474621, 0.1495790143909788, 0.17875528790911235, 0.30322258081958636, -0.7844173589984996},
    {-0.1338220155690799, 0.018827543172592383, -0.2552402417397783, 0.18534935200713268, -0.0019423401616220108, -0.21696140106010253, 0.012149875194936027, 0.15225532150677942, -0.1883628591143205, 0.024608942343104248, -0.29758758686718256, 0.15779364439409702, 0.12414707482410071, -0.2937076366495337, -0.11918816671558982, -0.347433964871383},
    {0.29425249171385864, -0.08496550422114076, 0.9462812299944379, -0.17115226032988787, 0.6482577905040933, 0.2832852090473855, -0.3213507382543112, 0.7451159744804523, 0.4609435673037511, 0.2324631823888047, 0.5713768273552563, 0.08395951064049052, 0.3616229564112221, 0.6608395634960285, -0.1231369146431883, 0.5739029919168817},
    {0.09161674375364018, -0.05638109466596806, 0.9065168659452459, -0.23814402112566313, 0.967210993857078, 0.8003212440286914, -0.08325532932263342, 0.5625725340318224, 0.8760938329669961, -0.02913851449695316, 0.8242993741935917, -0.08671040550762618, -0.0980745594463187, 0.38906767232638007, 0.3445225737129945, 1.0963727805138348},
    {-0.25412870427417383, -0.5803727746707746, 0.15097727284584775, -0.43863740056854567, 0.44085940125468653, -0.0365824170658096, -0.28139041588851044, 0.30533758449281784, 0.585594344531474, -0.4611000034579114, 0.1892199470966044, -0.3416649572589934, 0.2335662062908468, -0.11623925870527488, 0.2420530744367478, 0.34798840539369164},
    {0.03614583194396373, -0.1661867713063354, 0.07734564517357374, 0.22694447536967868, 0.5699529816615956, 0.5968881114286244, 0.16842571758312552, 0.43570285369440953, 1.0655362810549722, -0.3311401986148042, 0.294164894177049, -0.28879957447217325, 0.4324023549269599, 0.24864834749860465, 0.12260164563443304, 0.7857702990519896},
    {0.17527559005812995, 0.09587422276136129, 0.48870771591654777, 0.4175166554574186, 0.9890058675926783, 1.2235793535533876, 0.37792460091783786, 0.6819350261982416, 0.7631369004815188, 0.06575667447218593, 0.5124040194660068, 0.08188776925302474, 0.44182052044316816, 0.08823076226556494, -0.008238267235846334, 0.6418332318266935},
    {-0.31081617052811056, 0.23605194500519633, 0.07607529321788328, -0.04184355573281673, 0.28994176244465397, 0.4754169061970558, -0.28022291236371055, 0.081981176621366, 0.10603789396654434, -0.09541451149459719, -0.040964891936071335, -0.0821704580270937, -0.5233284034204013, -0.10709695827009073, -0.5277001273024966, 0.011233689429116954},
    {-0.17168562014068067, 0.043602857814610894, 0.55733824296742, 0.06249374052736118, 0.4201477808545981, 0.43607954853367514, -0.38969565688892327, 0.37956554450323643, 0.1127062870339787, -0.06005291643322971, 0.18862328023697172, 0.35210156168678547, -0.3580640070420555, 0.06066015400056168, -0.040641034098038716, 0.09907045627956015},
    {-0.09086704474122427, 0.4468497664855114, 0.01009130808913349, -0.06529003231362779, 0.04839604725490646, 0.12148369168022635, 0.04561338131753481, -0.05962343880773179, -0.5115532045290829, -0.001001383516560539, -0.10911752444187585, 0.21391033261142012, -0.32889886498423504, 0.020846494145404394, -0.10624780161954109, 0.2539984811222143},
    {-0.07995816503162222, -0.08673877210630414, 0.14657239940026603, -0.4332776968255454, 0.5196016519702266, -0.4157623408062575, -0.35186968593716067, -0.35766691347461876, -0.47059348917052807, -0.28331237549105504, -0.04552653114954195, -0.023594962005424408, -0.4682852589767841, -0.23755672771748423, 0.25540473901967253, 0.30889335487263514},
    {-0.08727771893598482, -0.22316171331276816, 0.11751565463183147, -0.2880960103767553, 0.5278134448327342, -0.3792464475475705, -0.09176358369219287, 0.533349353558353, 0.3832254272043774, -0.4777590616488949, 0.4953802169795632, -0.23092860547830601, -0.3132039675105765, 0.08212587117209325, -0.1770353796674308, 0.738190653122175},
    {0.1625968424019734, 0.3321696801176078, -0.2384027893307137, 0.28250767378726743, -0.14863492139811382, 0.3861930373535137, 0.22205348354961066, 0.17492461421543035, 0.5250184164997824, 0.3702730614369602, 0.4661976705799108, 0.21606474359789343, 0.04276452734801513, 0.09647372930254174, 0.4304646330084953, 0.049114886710624535},
    {-0.08875264856163989, -0.2350541840697968, -0.01976074646173508, 0.10633210017676754, 0.0663214540080165, -0.09178559026709383, -0.5173743925642559, -0.03416499674830237, -0.13640486625476925, 0.09708388553838873, -0.5101974416130292, -0.06365853796782808, -0.05338359159898176, -0.04761994954208693, -0.26064755019626895, -0.28016221122313456},
    {-0.2982335299915331, 0.04850640211405514, 0.14239871649979532, 0.2922498807443089, -0.08890274194287348, 0.4648010847508562, 0.17569345876469744, 0.0509789192251969, 0.14626757950877464, 0.09058242876860632, 0.3369897914875108, -0.15992553657220998, 0.10563270131335147, -0.25575139929663177, -0.023281152162164132, 0.3662452994762248},
    {-0.014369512318413116, 0.3103340390961765, 0.8066894421882764, 0.11469389489383365, 0.7775452886369312, 0.995550437824424, -0.1591554500287252, 0.8272814500075225, 0.9100010771808174, 0.44788055294346224, 0.32126505325304044, 0.3322956031497273, 0.11366271405856128, 0.4075934434861154, 0.02363294391029091, 1.058786156692852},
    {-0.5596178385145785, -0.2599488088060403, -0.3996001656717656, -0.06191758258105883, -0.29335553577717993, -0.26848817078133014, -0.22762112334173382, -0.15668623220449734, -0.6715847535047265, 0.016672722533884205, -0.22337360514353344, 0.009952491736639613, -0.010326556897785144, -0.399883455714488, -0.13220767134589748, 0.16418975919078097},
    {0.23349604742343485, -0.060089061610260924, 0.019228805490363862, -0.08646248633764013, 0.33175032091287404, 0.03991302236827959, 0.16019289273079204, -0.12556745901000016, -0.05043550542183023, -0.11278510730192937, 0.13479121877557582, -0.05764130184331142, -0.1933592190796934, -0.05017889002910189, -0.0070310298046436575, -0.17939975450951365},
    {-0.25482877031259615, 0.2981842199414331, -0.1460243920668035, 0.18155244059106276, -0.27848303677361186, 0.3235387251554443, 0.21358159093295945, -0.45714446989922886, -0.11163019823060688, -0.3361399728481232, -0.4037235896244208, -0.058438398576553405, -0.0824541032136655, -0.3946623972735271, -0.327537308053079, -0.2797485438431314},
    {0.4451416021057125, 0.5502397057803062, 0.8399680933300373, 0.5720710906254612, 0.7689381819008423, 1.018121981452153, -0.46340869891433084, 0.545880008034272, 0.8620720006780367, 0.02862422806027653, 0.5934210202999715, -0.3805618598889107, 0.3974001992504009, 0.017531143461744822, -0.1897229046541824, 0.6804617261232536},
    {-0.3172880695633264, -0.928871068303756, -0.1315196309423668, 0.0442441932049566, -0.016067391659855188, 0.13190815410008289, -0.18817359897891284, -0.14228258001422697, 0.06711181624677212, -0.4745690700677054, -0.004792222340519107, -0.7198883012765899, 0.11405449891869505, 0.01832023825997321, -0.05910303767576648, 0.01747563152069926},
    {0.3380307495869693, -0.04275002796937625, -0.45541359677077287, 0.00915783338959279, 0.31108484214435617, 0.009250870168681211, 0.39982285245249444, 0.07164302872693888, 0.16605735531804094, 0.0018781623750581257, -0.13878873951395346, -0.15399397925726008, 0.21193217952905627, -0.11502838405863314, 0.3429128388886242, -0.04756355360647958},
    {-0.35024298987175856, 0.14468021668075332, 0.1976268255985104, -0.06106076396549822, 0.24154496321520677, 0.44064286953194687, 0.49493564991071276, 0.35165472362279254, -0.01007719910794013, -0.12278939210078096, 0.7041876695885494, 0.19434684154397358, -0.2891065214703033, -0.31568864977673883, -0.2998778176310498, 0.618105276872342},
    {0.29805000873668985, 0.20185760561561042, 0.01115617521355346, 0.16862733536117017, 0.347521931925088, 0.1870182984726211, -0.34114633599183863, 0.5995083129704245, 0.2159963244182106, -0.06673041019763114, 0.2825818221897163, 0.17083859936566118, -0.024067422705636405, 0.35331686990142486, 0.03505252176844309, 0.19077460612474734},
    {0.05931974882801371, -0.15504343161448816, -0.30032317047548174, 0.15759305398749224, 0.10491253247300016, -0.37895892891119, 0.24625524536846605, 0.003186653842975223, -0.040572744374638314, -0.11876492175257528, 0.08820812454866757, 0.10729269242540304, 0.5337558010410356, -0.04745880837557276, 0.4669923502350917, 0.2031004862574476},
    {0.04400687038308256, -0.20766015418692643, -0.22807229343740468, 0.11037088650492718, 0.0854432092059329, -0.1684357698147518, -0.4714200371066634, 0.1726349987779653, 0.18486545555611808, -0.1382516639038254, 0.19807972945721108, -0.18320144302395974, 0.10979014384892309, 0.18745733740627785, 0.003928133926687958, -0.3168036223602413},
    {-0.16978413643436732, -0.09237398228110662, -0.5770834358386361, -0.05931252524189438, -0.5278274370327557, -0.16863110312348575, 0.18074812464131404, -0.3314873977108798, -0.8605459495524564, -0.4517525498707781, -0.1525890222737923, -0.2877004762581822, -0.259046684903377, -0.15517260606088634, -0.419924948068901, -0.6563246916714499},
    {-0.2829074290281917, -0.011654928078256596, -0.43928721455403114, 0.2637392881039067, -0.7354756560275155, -0.4491593691170441, 0.44686820416454603, -0.4079769444792567, -0.11417524963155457, 0.2881348157903244, -0.18073990965570597, 0.2922124826179076, 0.4220104727879784, -0.04982684267668161, 0.10774946575488752, -0.37582332712095384},
    {-0.25138621054430177, -0.03776667770466997, -0.18968448738304866, -0.1551397990503198, 0.20774780663890494, -0.49269332383695785, -0.14707356108029748, 0.10524872295205476, -0.07089312585288131, -0.16465585086789852, -0.23899642216059577, -0.11732408125452842, 0.10487651929271284, -0.37490897964606396, -0.26426988977383997, -0.16427889844330043},
    {0.05613493961176313, -0.312400136021421, 0.04977604824863673, -0.3254696044174241, 0.1883006881779812, 0.2704382060099174, -0.3179763157157999, 0.05803365330371823, 0.30891654964476667, -0.29077409611652943, 0.0960995101944884, -0.25321928016745626, -0.1247487937889739, 0.18616990750940163, 0.10565993294992364, -0.21024729533838898},
    {-0.39672916995456003, -1.4644933977094423, 1.397503590594072, -0.5457510567620675, 1.96998938890272, 0.7692448523876096, 1.0214845333574851, 1.318376106554641, 1.5569926270896075, -0.10166380899896557, 0.31557389163854654, -1.4719075811397055, -0.8520809651769929, -0.5070215942918879, -0.11716377670268628, 0.7912491321785349},
    {-0.14446408004077016, -1.1000181213903852, 1.8098346384779365, -0.19555252007322238, 2.23230256747393, 0.5311199325822102, 0.45377640020052645, 0.8269985000904544, 1.454911494854363, -0.8160479452137843, 1.2312264149635812, -0.9701821200922719, -0.4950755699129062, 0.007634376217373163, 0.12219002649621354, 0.3169953934211862},
    {-0.2795253832591869, -0.4085277394609221, 0.8573172736845697, -0.26365828450549567, 1.73691290398466, 0.2862843389580778, -0.7656587815472631, 0.912714043553616, 1.6982092366390185, -0.5503284830986337, 0.2654471834569101, -0.4594655443207258, -0.2327110909029943, 0.6475689277331504, -0.24148634313787926, 1.1225928975660735},
    {0.3363378016171072, 0.10631266429835814, 0.8462346373792499, -0.19239952392922777, 1.5126366903149095, 0.8326939042133824, -0.22084695058331716, 1.2913027717545604, 1.4027070423649304, -0.22710328132937918, 0.3715254625223363, -0.3546658576131061, -0.4112147538070882, 0.5729364783491699, 0.008532078023639443, 1.296262688262942},
    {-0.09456660887117721, -0.1564705471838328, 0.9298160071618365, -0.014246081852839307, 1.2167972084742424, 0.41784148756488176, -0.07627680713382642, 0.8196512808785228, 0.7253137604428969, -0.24192454400459384, 0.13333316136717402, -0.23889965469022728, 0.20669238099570295, 0.09718640676405751, 0.19152299707768325, 1.0053817714504176},
    {0.334109743394139, -0.2666027863463579, 0.5256730106594105, -0.06643111991032019, 1.2574717731943288, -0.15083751191111083, -0.1149895129157901, 0.814753797194285, 0.8293490619723031, 0.051249050030441674, 0.3859869186863883, -0.3041275842348366, 0.173818480581798, 0.3979341017559014, -0.03180991387820687, 0.3040543676668035},
    {0.5509448788113155, -0.07747472145317244, 0.7457694714975297, 0.5406218782420913, 0.7410862550940245, 0.5585451421806409, 0.1302783355198786, 0.4173667418589362, 1.0548460073567347, 0.0675446227174558, 0.46875528139916584, -0.052656151399796014, 0.519049356379926, 0.5563345221846087, 0.3320063215052598, 0.36374678736338556},
    {-0.08789270692652408, 0.2593459381202426, -0.10734930587483352, -0.29983554667300066, -0.6091163965518314, -0.4224704609335578, 0.2588435982232248, -0.6660328329981664, -0.09007909595869465, -0.351876235035959, -0.0723223683730785, 0.014318782897402457, -0.21920123575477635, -0.6598716421930363, 0.0686252983287401, -0.415541324437674},
    {0.25980734015533685, -0.31320473517216013, 0.24938968386929555, -0.023727889850270092, 0.2017334465553999, -0.16161357878303506, 0.19048269021738487, -0.5841384824180903, -0.05615047926300088, 0.1812001946617827, -0.4459980870484066, 0.02346152831597529, -0.27779195160896764, -0.2548507021968742, 0.13258489844609694, -0.6866203682143108},
    {0.03261458872817385, -0.3232003030353562, 0.2761298595933575, 0.2100476260959816, 0.6894804760201814, -0.45125274004589955, -0.33892396965257826, -0.27991289596555713, 0.3823670637431602, -0.313571927531875, -0.26853668750816306, -0.062156982750569814, 0.19623530613263102, -0.10299547237451824, 0.3378552442480064, -0.337878903371575},
    {-0.5347270975965399, -0.61123128479283, -0.5225425573277653, -0.2543414233776916, -0.2494586668759626, -1.483776032151276, -0.44586147182036223, -0.48228750546749743, -0.8176668678860397, -0.04540849521239106, -0.9250010314464964, -0.5284128507871033, -0.4967489701462384, -0.5833534943898767, -0.11649437571266373, -0.6822704152387622},
    {0.06887300740172678, -0.33915552750132955, 0.7275188277414023, 0.3749024887457201, 1.174792609935017, 0.46434161295754084, -0.3076322355891137, 0.801044156338328, 0.44287270997083783, -0.5280960019464734, 0.6054613370366105, -0.2690672411749656, 0.0028362629555195155, -0.021173202109782966, -0.2710700394909624, 0.7311641973535344},
    {0.03384608767964283, -0.24120571096393675, -0.0787335149440726, -0.09205203417737197, 0.5445398332284288, -0.07122005733399735, 0.0772013107671191, 0.19281100523246622, -0.05651527674720371, 0.40135432028463547, -0.11765527558301837, -0.29157439999033313, 0.10782080696800422, 0.05357136837283832, 0.1222810054941728, 0.09834476002890799},
    {0.1289674743413643, 0.49231862934166076, 0.10836252857985741, -0.42809842466695547, 0.17981106489021875, -0.04332955591888482, 0.03228310211801754, 0.46014628328948326, 0.5376144135487866, 0.0009805724279602535, 0.31735894370923645, 0.27430574351271314, -0.31017369739472006, 0.23686212308885296, -0.20375851970135692, 0.25309331390797773},
    {0.30365657357773046, 0.33832527570667004, 0.31092919121154583, -0.033738081552592156, 0.01151819066269256, -0.30526268239996257, 0.043173440000653485, 0.3751496645211353, 0.239721237037709, 0.19219142082940402, 0.16787846905142104, -0.008033047976856698, -0.02033672376966994, 0.2722358128724835, -0.48760215126288176, -0.22078776609529524},
    {0.02191780283390735, 0.2964161289256869, 0.4431515847763993, 0.4257883169207759, 1.1387960652887708, 0.8691710896190075, 0.5263100095061786, 0.1939669445126554, 0.8401243703825829, 0.5511476525732755, 0.41569905275038466, 0.141010553639991, 0.1291254047726334, 0.30490966641190426, -0.3731568180672002, 0.38472727925355776},
    {-0.43225080509172575, -0.3262144914698021, 0.09128241529186941, -0.3176036487662521, 0.04431099269354127, -0.5082616439285804, 0.06800861745314125, -0.31650122701845135, -0.3673967217676074, -0.35852003549181544, -0.23174716199645373, -0.02205452892351995, -0.24896474475959623, -0.27295302263353016, 0.24486359579297268, -0.43212297912239633},
    {-0.5633948308363316, -0.516863739631119, -0.10303131609999056, -0.42263491446888884, -0.8244708053598108, -1.0151848179396261, -0.233397937536702, -0.41397828732476494, -1.3036979326465556, -0.3369513871152578, -0.7053882363572989, -0.5094778282466892, -0.2785981596608357, -0.6225636665048603, 0.07103126209387899, -0.7725968031650589},
    {0.10472446855681956, -0.08755447977935452, -0.03651102573431541, 0.009660046257635488, 0.3458928326336647, -0.45566075288016106, 0.2640290732886504, 0.15060415204181832, 0.11310959663362385, 0.04825493603198641, -0.048740308186521974, -0.09600086207131811, -0.18486276074616304, -0.14822162935897504, 0.1405475784526804, -0.49288033151739347},
    {0.45579451518377184, -0.09780405590294904, 0.2061480847562623, -0.4573376124289311, 0.6793344566090127, -0.8553129754942832, -0.44123850344010107, 0.5824670843213581, 0.2539620779680714, -0.17008077729722176, 0.327833507961061, -0.06487944176567986, -0.6855038096437128, 0.2354856106998896, 0.09854207067559001, 0.16374308244108735},
    {0.5683114543521102, 0.30130687474703743, 0.15923672538633765, 0.18631124080649156, 0.5857777179650074, 0.17644496829389983, 0.15514412307374864, 0.677907721824192, -0.04366750432220571, 0.09488103360863863, 0.2630155006728373, 0.39313813311775525, -0.17722522083616776, 0.09864447502946119, 0.04215649017300894, 0.34955092034675944},
    {-0.1886743873385669, -0.003537129611958816, 0.44923694451224766, -0.014996837459183869, 0.7025472797209513, 0.2034035246200653, -0.11349473189747636, 0.5770758247656687, 0.9105519622906689, -0.27618725339893085, 0.24566455515431537, -0.17832962359440444, -0.06470943388194476, 0.17452561939087682, 0.16036778451909917, 0.1562903064960254},
    {0.07783259667802571, 0.047788375672861226, 0.4943891026418138, -0.05806331075224082, 0.5000053791303007, 0.47239410807785376, 0.15282853558675483, 0.13379908048202716, 0.4011864867592422, 0.09269691349530312, 0.22924452110620294, -0.07981444870740875, -0.020541498382370377, 0.39517642979892437, -0.03838950463790377, 0.5187164346348119},
    {-0.06765580757416645, 0.0011990430257589298, 0.3557443238931451, -0.0037357317910891633, 0.12290232445380823, 0.4346046224565252, -0.20854362651905106, 0.38348870479144864, -0.16805840378501496, -0.24371949500929926, -0.034145619603071456, -0.5596109017290111, -0.05626991856048904, 0.2913890994166731, 0.24133261436402437, 0.10913638807111234},
    {-0.5633512935683159, 0.005940282734804888, -0.18195707442647374, -0.2835588396465962, -0.041769477685506325, -0.7514346803385412, 0.043323251626498784, 0.10824846566147571, -0.37260742453016, 0.18474269843179844, -0.46858066799140097, -0.10987109121225487, -0.3326894174321204, 0.013700505969605488, -0.34284573264402446, -0.20529051995871975},
    {0.1928724607954996, 0.08681459827987331, 0.10111582683565723, 0.23765938857547725, 0.49534181601561594, -0.24822630258055034, 0.11152437712220935, 0.12845808167169404, -0.05559834879725798, -0.16477908901151866, 0.3203096339325904, 0.013049985027005469, -0.3237239457057559, 0.1379458473492389, -0.03405923861486719, -0.23961156862936703},
    {-0.28376825128133165, 0.025450187140121098, 0.3845646833286572, -0.2986675276649879, 0.9478769111132801, 0.3944032548466614, -0.4790080288364411, 0.6781977595887404, 0.18955267785369867, 0.31395312205038783, 0.02948468664792577, 0.049722229537209076, -0.5200830474687935, -0.10756329473027625, -0.3913782679117614, 0.45275529357852584},
    {0.10725921880569421, -0.18544739429583362, -0.2844743507918191, -0.5314142249779268, -0.3438644616722558, -0.8424084533388724, -0.6019755584880349, -0.33908603707390306, -1.0760880801860833, 0.2596233441655221, -0.27655835575933424, 0.22749583822021271, -0.6855750411550996, -0.120543933475215, -0.01656099718135833, -0.047706913234130024},
    {-0.030488255624120813, 0.09154918540925011, -0.21227935127979916, -0.03787520985756702, -0.026533160872195923, -0.04482127649572123, 0.2372519592303593, -0.1530206292791395, -0.6047894141590278, 0.15523726360858586, -0.02166834372065899, 0.1234034033052328, -0.09605003003356193, 0.045172296064267065, -0.04710726057434268, -0.4920431238268109},
    {0.4082423934371903, 0.016278300141823725, -0.01344254130301971, 0.33225727407591377, -0.5535843630217426, -0.2209754645540838, 0.40843228856245983, -0.4187288903802167, -0.30628768309324594, -0.08236823771828017, -0.057204383922368346, -0.29962660113511325, 0.5037093949054628, 0.21910929631714524, 0.5083388561600135, -0.14059258969763896}
};

static const float b1[16] = {2.233563810564153, 1.367018348034067, 2.783704469124714, 1.488890903861367, 2.831632493846764, 2.219997424793275, 1.5586782062991498, 2.785533238024778, 2.390684150283639, 1.7523678640798994, 2.3091048122252493, 1.819349247472055, 1.5643919407538205, 2.1422437219118393, 1.4341722834166282, 2.7168753788226843};

static const float w2[16][12] = {
    {-2.1031791229264174, -1.335850980146755, -0.5979000618464474, -1.5388288385708957, -0.4042608117715517, -0.8604177137407191, -1.5379170843553374, -1.310334196169847, -1.3185353105600168, -0.9357987533472876, -1.435721263310787, -0.44882164686661674},
    {-0.7543580379559665, -0.4785762454226025, 0.041214570966016745, -1.2385538061727503, -1.0846463616685333, -1.4433157298948625, -0.47283072597260417, -1.7456737605264432, -1.1751470039649325, -1.4905144954182368, -0.8995058391538553, -1.0487159674211974},
    {-0.7120033729400603, -1.418293727641496, -1.9935256995817903, -2.045764241338276, -1.8452587566165182, -0.26141856318588896, -2.1981350775234665, -0.9411124977696411, -0.7994243328569345, -2.4313105303145184, -2.0635046684055687, -1.2059222415951358},
    {-0.5264155173794366, -1.1928386423173911, -1.790522492957956, -1.4865946317328467, -1.5585333996165125, -0.5673755833067992, -0.4663098083438039, -0.7475358477241464, -1.0043769314351974, -1.6692947682348849, -0.6744957183996603, -0.7190711532119042},
    {-1.7622908113335725, -1.0754509897156281, -1.2278435535609344, -1.4351607485180633, -1.3570383398464287, -1.5625684314571067, -1.8880166051501075, -2.2672844589228083, -1.2340360775186927, -1.8028666687411798, -0.6910221512637339, -1.956733057992001},
    {-1.726367753865972, -1.715177458089707, -1.2409454019064659, -1.5419984190579596, -1.3074550731014731, -1.5095936713307607, -1.0836003843503974, -1.3363844529369575, -1.8605089972952957, -0.7936169885973043, -1.1801137462180913, -2.0586162611302994},
    {-0.8359985151208994, -0.5600483267345722, -1.7907510773547832, -0.5324262261317634, -1.0140990995787507, -0.7414044251882448, -1.7819145456213312, -0.8883904223974892, -1.2190947664693574, -1.6030574206346906, -0.6527927963796174, -0.74307134469994},
    {-1.218098093342168, -1.4040903345880702, -1.6478431015165156, -1.959972560003796, -1.6553928907309594, -1.873615306853916, -1.7692747045737456, -0.8178997820309802, -2.4556970907776896, -0.5227982201879156, -0.8238080899528409, -1.6544567710888576},
    {-1.867418401550191, -1.0475217343908436, -1.2186503403065303, -1.555517596903403, -1.5247584579450602, -1.4051333081936075, -1.005249343409593, -1.6897619231761025, -1.595941392644073, -1.5813242993986023, -2.4235201823952037, -1.6136568974560042},
    {-1.3314753872784244, -0.5507161087608226, -0.8755583226120359, -1.7344680322961907, -1.5042909153126365, -0.9463556543462323, -1.0489743052091827, -0.3049175743475834, -1.6193466843034658, -0.9717925720270039, -1.315535126696992, -1.5746644720599972},
    {-0.9343812524743491, -1.054776572641721, -0.9744623754196239, -2.1486632627685514, -1.7606859390013403, -1.5700891254104354, -1.2256474962484698, -1.567486442749309, 0.09516140661697288, -0.7167277157217936, -1.808510960081787, -1.1914158925808038},
    {-0.9232121109877592, -1.708129572769296, -1.7783661582230825, -1.0976879328151516, -0.4091670409924855, -0.8360223697826649, -0.9805445442985312, -1.2282058350267897, -1.1494147015652083, -0.2696200786509751, -1.7724520575900584, -0.5777753370230627},
    {-0.642977243322111, -1.1665547091222548, -0.7025315061157391, -1.4942800687951088, -0.2560214235560023, -1.2316887994034713, -1.3881347516401699, -1.5008487336464225, -0.8881703584285237, -0.4147200965217888, -1.4815228233826239, -1.3682407825070493},
    {-0.25453815802293966, -1.4269098145441348, -2.178892099578929, 0.3832839748906044, -0.4478697847316283, -1.4999701728916663, -1.8624824307829166, -1.1986467894788475, -1.9696523101731576, -1.6806203501117343, -0.778009791097542, -1.9271114301705017},
    {-1.4047205972516659, -0.8129771262849014, -0.8036043594798887, -1.7646104364560855, -1.5952247866950302, -0.6300258229128585, -0.08738825626024263, -1.0559280532138737, -1.626664398604121, -0.7837768322224808, -0.5801180752773943, -1.8199680845756572},
    {-2.3820554136916665, -2.564614300583794, -1.817763885861818, -0.6620133911329468, -1.1663611295599792, -1.7797697672397503, -0.8840941522950486, -1.1681318973102248, -1.5570047962046396, -2.0605182456270703, -1.6618194256696655, -0.03606797728743599}
};

static const float b2[12] = {-1.3623085388665828, -1.296116831758556, -0.931073087442598, -0.9761127517024477, -0.7309210585263662, -0.9368329478997027, -0.8333459171269876, -0.7716044108622385, -0.5744647940263347, -0.7104538399577134, -0.16629670183901454, -0.5833102927157184};

    // Input Layer 
    float z1[16];
    for (int i = 0; i < 16; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Output Layer
    float z2[12];
    for (int k = 0; k < 12; k++)
    {
        z2[k] = b2[k];
        for (int j = 0; j < 16; j++)
        {
            z2[k] += z1[j] * w2[j][k];
        }
    }
    softmax(z2, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
