#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][16] = {
    {6.311095765410228, 3.254492828163201, -1.1053310490547732, 6.361308887584159, 1.9926092174766252, 2.760679613383194, -2.538122015234147, 0.7623751184429712, 6.268982636098815, 0.8949968388968588, 6.424276752924353, 4.351145420581974, 0.6133996910156709, 0.5767991138383068, -1.2656364102740358, 5.73410665579217},
    {5.018683459474982, -3.362504429857146, -4.916152847706376, 5.647221887390841, -2.1803849055413287, -1.0530872821250679, -2.6766738681103344, -3.592608966287076, 4.310468710861989, -1.8681304957011144, 4.653478311225362, 3.4070630868485288, -2.8543216869579697, -3.2047565792883113, -3.98973626311996, 4.76828705777726},
    {5.285345209239316, -5.360299746507436, -4.978249842164904, 4.689107994817112, -4.148256729527412, -3.606447056308239, -4.675910418850111, -4.997137515009802, 3.868081679770938, -3.856886095850493, 5.343071742723276, 1.8017952109166893, -5.236725635543745, -5.105427213031256, -5.003089399160951, 5.1591222657851885},
    {5.491016363593324, -3.3314855861043924, -5.668554730876538, 5.104360277889849, -4.594378870097523, -3.5366710119577385, -5.875062379562038, -4.9754351374996, 4.0044980052562655, -4.419043151998816, 5.541899684781379, 1.0216963960333665, -5.294231393663746, -5.251058065989021, -5.818716563167388, 5.461817240402988},
    {4.958020792008347, -5.5085562028817785, -5.6027916589779005, 4.216569806994136, -5.057335713432937, -5.063473062511019, -5.774153992103077, -4.6094088936173145, 2.080570835276166, -4.993241459905568, 4.8530209084767355, 0.9452227905712269, -5.244099530864661, -5.477433756607902, -5.504938253509142, 4.935340982535576},
    {3.9277541272854535, -5.650023953723275, -5.392229629615412, 3.135866699144672, -4.777511115553331, -4.835947539931973, -5.423359327307718, -4.0685569413010665, 1.4490857008444331, -4.906657196909436, 4.072416393833906, 0.5178808208718435, -4.541870012852123, -5.674916324691181, -5.088430908859818, 3.6555382456332026},
    {3.5939093480328688, -5.737431355744653, -5.625657492992189, 3.475827405006501, -4.303310180882839, -4.873271734979763, -4.789624869792533, -3.8981560579327, 1.9067069969246706, -4.281518578640125, 3.5243493033509674, 0.48741429010771037, -4.273658647876594, -5.175118385055098, -4.922017257479909, 3.148959637687699},
    {3.95242395722293, -4.744828746874872, -5.400100559522536, 4.0488304124268515, -3.989905147004571, -4.2337821235434525, -4.929002580752258, -3.120410067340311, 3.2320975215722285, -3.767052960254179, 3.9486019566527886, 0.16269500980663681, -3.2139166230155363, -5.009907150416013, -4.927833940934594, 3.5178397285514365},
    {4.364639991978796, -3.4845254044410394, -5.03923576829193, 4.683035460340574, -3.719472667830306, -2.8076204520954984, -5.295960185489561, -3.217995440851308, 3.1669146818652423, -3.623699135257786, 4.177513807915995, 0.6259980831899884, -3.3452081134686016, -4.970769229806128, -4.641576889065818, 4.491839906465403},
    {5.565490028573731, -4.646566943823774, -5.403750542640245, 5.483383881772705, -4.0053492123937104, -2.474027922075999, -5.015061303783986, -3.7028125576133384, 3.7114096910103824, -3.7294296047070126, 4.661072075839364, 2.097282620671303, -3.540395468741151, -4.773448211549542, -4.822342589770975, 5.284195389031663},
    {5.968750957571349, -4.107760724589344, -5.035083068709777, 5.511311554431255, -3.0644051144773043, -2.8225893207745956, -4.293989247130163, -2.9551773722797665, 4.146260747554917, -3.097976258329942, 4.3487516622571345, 3.432969474321884, -2.84298917045469, -4.654807157405229, -4.137454454089148, 5.677644462524876},
    {5.169968041137075, -3.492955467052762, -4.875614146459365, 4.708064223779928, -3.835302951476203, -2.3697420436405214, -4.6843425223643465, -3.1501475859608496, 2.9922680016596597, -3.6392317009170894, 3.6135267712395183, 1.415269119369419, -3.24047593110884, -4.926017243513715, -3.9867376896777413, 4.91830286461638},
    {5.205612513457198, -3.9330692214108653, -4.882347281885292, 4.330416651261469, -4.386039709438655, -2.4384187603136267, -4.55516928997613, -4.031258015488024, 3.158954133007836, -4.296833999154226, 4.1384680965646465, 0.7287202970076586, -3.6726495069501786, -5.043419640618302, -4.738750073881123, 5.079873823761521},
    {4.542469183200013, -4.796868064179078, -4.8253472926075185, 3.6587600020431057, -4.468630910205559, -2.27362647615163, -4.621018458423108, -3.578746122994071, 2.9340406338928053, -4.451352421639989, 3.8571593665850665, -0.08702584934451515, -3.7124962775089845, -5.172964068516559, -4.735089092033679, 4.8474821157099415},
    {4.982702310749882, -4.926488126951211, -5.169219627043423, 4.6066356113752125, -3.742041545343567, -2.5079013948122917, -4.703247508896494, -3.1797897785912643, 4.38968486592789, -3.545122853638683, 4.736537627548858, 0.3752946677438109, -3.0474387728313914, -5.418338763075885, -4.801466336226218, 5.149770825171181},
    {4.616045308857325, -5.619841258496149, -5.540926480499996, 4.403967164949237, -4.630314817801116, -3.0706388999864016, -5.303363030893736, -4.359359996647251, 3.3678641431605993, -4.553132761703937, 4.719939102428421, 0.4617800144267514, -3.8933756523741625, -5.447001457396672, -5.400871003414318, 5.038634356677443},
    {4.8731624722314, -5.238158704061726, -5.476724097860056, 4.706609371943673, -5.062236601124062, -2.5149024014786163, -5.43236710618696, -4.644920711788422, 3.359432852498989, -4.759752407209585, 5.023068623601036, -0.004942810630865674, -4.6759350516736795, -5.505939297900136, -5.471447408696053, 5.77922635078353},
    {5.61573844647971, -4.431060359476076, -4.512335539766362, 5.175034779167498, -4.015526228045828, -1.4235217228463397, -4.9406158565039995, -3.3771033381340314, 4.6447223932949155, -4.204560158194182, 5.911566408021769, -0.01578789024238408, -4.381739855777813, -5.49328980812538, -4.534241382702491, 5.978107186420046},
    {5.720748804965162, -4.1885046389589125, -4.3369209282519705, 4.917557478655998, -4.056621035263033, -2.512448676030624, -4.834385334983067, -2.7317733091408423, 4.046210287033116, -4.241393557918886, 5.706682724031987, -0.20062281368214593, -4.336166660655798, -5.722116168199708, -4.739100812263609, 6.0246444148321086},
    {5.754819434640814, -4.603172233389724, -5.27452136857894, 5.142964748707095, -4.23930006091941, -3.0674701013660757, -5.200724044067045, -3.3559175945624893, 3.3405831763466014, -4.887197697048086, 5.374961705226648, -0.23355354341130785, -4.760496558584828, -5.50210676517186, -5.2983813528160955, 6.184951343018312},
    {5.603402499952813, -4.12561434610771, -5.07273223446164, 5.350318481572096, -4.381632329167393, -2.0982133447563367, -5.06972774974044, -3.622425389420307, 3.194216626256176, -4.296225940894398, 5.405805927941737, 0.6173474915424951, -4.322049731094329, -5.393051036811189, -5.11061843457681, 6.3056086813987235},
    {6.481438073372025, -2.4833286013597506, -4.551387651594993, 5.981229391427941, -3.5002062998970214, -0.961287646591134, -4.834000135950796, -2.7784219658884477, 5.183080075948707, -2.953525555893793, 6.470945066578557, 1.6812634723686968, -3.981621656263273, -4.885655439787609, -4.549697478991809, 6.716821071974567},
    {6.3800899828648685, -1.2526038682605514, -3.7578318565781914, 5.889120029334405, -2.3038000523717623, 0.08081753561174104, -3.857401727971203, -1.751113044502314, 5.532845357494843, -1.914012029873457, 6.405433170817881, 2.2979531543841043, -2.981874836491628, -4.129225722986927, -3.5953937390957127, 6.2086516360041415},
    {5.901318143473538, -2.8012189593940255, -4.273187022866396, 5.754451902050577, -3.4624720113681224, -1.227434831908692, -3.993304680849748, -2.5473108473170454, 4.849407600214453, -3.049919426284815, 6.231453477766901, 1.0732103022048776, -3.7073489408938283, -4.685786793075466, -4.2322871266818485, 6.096584682657988},
    {5.593468130287613, -2.8933508839945175, -4.4439236235977635, 5.2567791429630315, -3.508187709708867, -1.6469817598010483, -3.845513420976703, -3.222823826725195, 3.5599662318609093, -3.3402437688162694, 5.395895887853231, 1.0656619853228304, -3.908282749870775, -3.9550025702139187, -3.9436096845376762, 5.751874980127992},
    {5.946058952620716, -1.9077395278104352, -3.4957366808254426, 5.38122885567402, -3.1791709775067574, -0.6185719168517982, -3.5598024486337483, -2.6755979542508888, 3.65248548303636, -2.958667884344659, 5.454297513121189, 1.4466790528694977, -2.954620823258654, -3.854705428562556, -3.2435300363588224, 6.0645070366290454},
    {6.134767370315416, -3.1767130711157607, -4.304646992209214, 5.93968319245032, -3.5532312689927936, -1.316183698907843, -3.7076401352471375, -3.53042971592535, 4.802578125870083, -3.070547981196082, 5.917121684892309, 2.2457830965012024, -3.91771496086376, -4.245805218036953, -4.118128365428569, 6.40895107204569},
    {5.963098749307933, -3.804823372403607, -4.864949191229743, 5.849271455785168, -3.686785783378287, -2.0454741044446942, -4.850753746828272, -3.742860609374421, 4.482156983405955, -3.8426168005385963, 6.101066763235428, 1.5086101114762103, -4.747024610809842, -5.035159805337756, -4.661935804171982, 6.234787812876056},
    {5.881568668603513, -4.480097364119988, -4.632530192787401, 5.384324064598083, -3.8971214070207667, -1.6003092337791345, -3.976671512379525, -3.517472424197704, 3.867470393721164, -4.262299530485534, 5.509438499803151, 1.3797649904560751, -4.390574427296411, -4.973353212703795, -4.115983485953367, 5.773293444052789},
    {4.942287883652222, -3.5666749546389296, -4.853361166919876, 4.855647713063365, -4.090096725704302, -0.6077776292865662, -4.328502367883256, -4.116577376910937, 2.4699887650212347, -4.67931845317714, 4.9095273254093845, 0.22693661180865082, -4.694887948462374, -4.601319837090373, -4.54553344654523, 5.169474165745369},
    {1.0839656290426307, -2.153355778369188, -0.16253151794938217, -0.45490203336474794, -2.091152045756418, -2.1956556240935168, -0.131058201859228, -2.6642655521360963, -1.41917065522491, -1.5229728171577983, -0.5140261304963533, -0.07479529886155081, -2.3893294892929835, -1.1761955453351194, -0.9840550548615242, -1.2989122842389138},
    {4.060800188260668, -1.827571871508804, -3.363803785571148, 2.9294637724774537, -0.9763980380428424, -2.2530863284951903, -3.264850705368038, -2.3585898144048487, 2.113301288135209, -2.573175817448222, 4.0474214108138336, 1.1596851897854008, -2.571009050573302, -2.512032505279677, -2.232909532502833, 2.6057714676194808},
    {-0.4760838896510638, -1.1812628432554886, -0.04312632650494185, -2.4714537327865367, -2.307193771460501, -2.1541892593222096, -0.8579846394842815, -0.955704185469514, -2.19466452474109, -2.068891328604653, -0.392081126030127, -3.2466092423845296, -1.7973992721910976, -0.8025718896994983, -0.6933414657880792, -1.4634441082680736},
    {1.237740705035271, 1.1034430875209642, -0.2541661045055101, 0.10581915673947802, -0.42558360990855276, 0.47022899883861474, 0.42166358645450075, 0.8785535752708905, 0.3218693338786481, -0.6099812548011894, 0.5130760911313588, -0.39903899014311917, 0.22920077083556134, 0.913401294518202, 0.6247177229549958, 0.6302756718456557},
    {2.4927103796833143, -2.3811491778225435, -2.3425342892764, 0.7343770745686536, -2.289445509787495, -2.3948185620244873, -1.5668506164327902, -2.0745266195308654, 1.0419665423207196, -1.8744402620903533, 1.4996422380956902, 0.2585488219552042, -3.0566528382056695, -0.3356746982307939, -1.6595631997970044, 1.5576781769489034},
    {1.835996716956174, -1.4299012055153384, -2.139210277861686, 0.3291447235249523, -1.7891363107739546, -1.3921981460734063, -1.3861018148946407, -1.5923480491795567, 0.6026507133377346, -2.3297316727170405, 1.5152507214879403, -0.8903342923194305, -1.787205173792104, -0.22842722786786782, -1.2809497297217292, 0.8053495765226574},
    {2.22322596186115, -1.5873979325449616, -2.321463728193515, 0.6535675721140627, -1.9531458685288494, -1.9198556642399798, -1.2519060088120435, -2.3306347857412173, 0.36486664200097124, -2.885468817553565, 1.431800331214516, -0.6558765224886433, -2.1988303557345765, -1.0320320641316814, -1.5688693094547896, 0.9894377628581114},
    {1.3710255109403873, -0.9739067002168061, -1.8385192261250551, -0.002554240150658729, -1.2531542894237966, -1.1405097172269276, -1.5250059213847134, -1.857551295870146, 0.5937661667868785, -2.0698957252799057, 1.4933173125580606, -2.067245024060209, -1.4994977446361692, -0.946631133402384, -1.4334256278881068, 1.0184734110447},
    {2.007192460064719, -0.9346614397812388, -1.1763228649645658, 1.2243859346196608, -1.050398844911877, -1.533747478900708, -0.6363862933474019, -0.9363046031636075, 1.1904552147842355, -1.7689139110138008, 1.235716025379187, -0.8499984757390324, -1.2820389636611185, 0.4834359635965128, -0.4984982778303185, 1.2650953147331678},
    {1.5997538105321307, -2.5635631379377344, -3.2358837988198332, -0.05538853061000338, -2.984532310764364, -2.7758187111300185, -2.0827162492262965, -2.9416533600555117, -0.42651716461747696, -3.177915936336175, 1.2274647668058882, -2.1275981403574242, -2.8667786091420546, -1.3603993144276485, -3.3486034106264886, 0.09508478279435487},
    {1.1374054364898276, -1.4991305639031072, -1.9615075226068883, -0.3522631385625643, -1.9159306729022456, -2.478793174490089, -1.2647175614386894, -2.2103332576767376, -0.9497038836760888, -2.727608789726342, 0.08188116193206242, -1.2934097900919976, -2.8986834557687096, 0.3284841477425236, -1.6611924042539392, -0.2207243376215432},
    {1.2270706704543108, -1.5640433834951821, -2.153612431389066, -0.6376490347420534, -2.7991186846109377, -2.0531174588751164, -1.0916461211370854, -2.2672032333591035, -0.7562392328560319, -3.5441372354763323, 0.5636326906925239, -2.404444429671595, -2.4252094240926536, -0.30256636045040386, -2.242685454329678, 0.1126541476977328},
    {1.0045787341989636, -1.4977643504131315, -1.5434601164413848, -0.9317020299064105, -2.340291989491176, -2.22282435702634, -0.6334033007873722, -2.7773462871132186, -0.86975342585457, -2.591169989585159, 0.5404485485296864, -2.131467610223611, -2.497056169409096, -0.17359251142333687, -2.1776499880436373, 0.11042636149381707},
    {0.007982495364338102, -2.8441474134443703, -2.472243214510179, -1.8094831574063124, -3.0825825189670963, -3.0166467575615012, -1.5120254978908358, -2.9868695398321794, -1.9158223509687062, -3.5169302971172245, -0.747365197341121, -3.7125623494443385, -3.1281095760662376, -0.5312383800987428, -2.407958100376893, -1.457636731128737},
    {0.9455417956446885, -2.7021097931073195, -2.1057062445086325, -0.05348205000876287, -2.744793094141087, -3.5112148117758983, -2.090651171559031, -2.284750783698628, -0.2741047604548957, -2.978208754998854, 0.6421738543587533, -2.0925687553465924, -2.7963494786324072, -0.445318650431355, -1.8282948623513284, -0.7667968337462453},
    {-0.8418322309019836, -3.175598721365889, -1.7316082484650381, -1.570545794530999, -2.391178845746712, -3.314801039964829, -1.923731298967209, -1.659075762596689, -1.4639030625309009, -2.8569484584867646, -0.8499023052223296, -3.5788762070047055, -2.55110601121012, 0.25962149008818264, -1.6876498871720609, -2.4955850743057715},
    {-0.2864907338232076, -2.0468520273900936, -1.8349628313301578, -1.5349319260358618, -2.025588190935347, -2.1766748076232934, -1.2706731322578464, -1.7825882243824491, -1.4115841280064438, -2.2314396065014184, -0.7072963826332545, -3.9930860518018796, -2.1539111775625406, 0.21568142618391872, -1.8418545196772054, -1.7338716287764346},
    {-0.20502990271888075, -2.198640059601748, -1.4018880608539641, -1.9799142655484396, -2.7125714243313928, -2.2172763106075823, -1.3018385838588644, -2.660241660910627, -1.1454517146015146, -2.86032409429062, -0.06404183424192712, -4.021711307346499, -2.4270261313901074, -0.18105185275872912, -1.9735809623211027, -1.4825287937864158},
    {-1.663668664906991, -2.104709510362371, -0.13513681688316442, -3.840023850937639, -2.7852785687999253, -2.999499617045981, -0.6389098523927171, -2.603365380518409, -3.5433653834514303, -3.0115359638949375, -1.7164693440239271, -4.703890000919574, -2.688373647865214, 1.032616452595235, -1.1861120612837976, -3.0825691153545725},
    {-0.003987630549514169, -3.00408949835204, -2.3897511336003974, -1.6297498052931805, -3.1415709172945556, -3.9679240054946416, -1.1288075052661593, -3.0872577061438298, -2.16944118127465, -3.539280828824514, -0.5505691874227941, -4.045118802453422, -2.961818523011212, 0.5798088477718882, -2.118751445190143, -2.024699820905248},
    {0.05872570417607895, -3.135992879303747, -2.73702887496557, -1.85911246696954, -3.7877987872235863, -3.615022711260138, -1.2360288007905866, -3.378428164857662, -3.064594535920415, -3.784842479673864, -1.1014300893548836, -3.3589632583567903, -3.330960139212054, -0.2994801006111821, -2.6778977549405005, -1.31127917893107},
    {0.7143092943281789, -3.76637072370221, -3.0422945650258444, -0.8164594522906504, -3.952568753957516, -4.383203835526321, -2.6756095269985143, -3.2792177288550977, -2.519546780426492, -4.165812474583299, 0.5326943112990008, -3.0479256878076235, -4.41047079785096, -0.908591186882755, -3.0712375014770394, -0.9198856178741535},
    {0.3698947734007744, -1.9564061373777344, 0.4933950048156509, -0.14859200744839998, -2.2584712880149733, -3.7715690973433036, -0.4831040156749878, -1.6052954294828752, -1.0743769615327274, -2.192788056408879, 1.0918870852889468, -2.4430359338116663, -1.9565258532436136, 1.9305056024257725, -0.335049367572263, -1.748304439194766},
    {-0.6328494116884823, -2.6493631259369668, -0.34617919484421444, -2.9546209015225644, -3.5483218245029167, -4.103970927476854, -0.2377501140871119, -2.3541840789682573, -2.6912846093354124, -2.9651222819423633, -0.6627371263223482, -4.564173139258379, -1.7963602036344641, 1.0499969891803431, -1.5722840701168, -2.579392616485133},
    {-0.8457884044188427, -3.6375681968832634, -1.9337641954238443, -3.5982275849263354, -3.6756336460766907, -4.483188015924396, -1.286673659441191, -3.81519079086616, -3.6574427877930367, -4.256875427938129, -1.0104941241694436, -5.425909644956394, -3.8597805522975133, 0.5699345992407157, -1.9874092816965685, -3.420793636592949},
    {-0.007289442513745893, 0.21151504994065623, 2.187981850979209, -2.517156188703224, -2.341460895763063, -1.221854440543901, 0.8832545225653403, -0.6553237246250423, -2.954159692240583, -2.5077801309809256, -0.09303302414705453, -3.8244663137190065, -0.8599990220956673, 2.546051979441899, 0.8675501397583084, -2.0591075160974963},
    {0.2363199456133128, -1.9860579915157661, -0.40245159138227343, -1.2041926061210362, -2.2659837968887766, -4.096962712240629, -0.06175961739176763, -2.0320085544276285, -1.2893802454523746, -2.1815918243699306, 0.1442100341940675, -2.6816328794382946, -2.2201936816545644, 1.1137988168973845, -1.2218863761829646, -2.070965745306463},
    {-1.3923032423724961, -1.392032973658526, -0.33632080373680107, -2.68673912439872, -2.2562822980364063, -3.3692144026139377, -0.2855124022505776, -1.4876062848996514, -2.8953934616825063, -2.5173433584051614, -0.939803680567624, -4.6194194987323165, -2.082485412815015, 0.771683736562055, -0.9030414313408452, -3.444789483905694},
    {-1.153263124529003, -1.4809392445647884, 0.5508337537220239, -2.1599612166203492, -2.045116808060689, -3.098250670565425, -0.2365351335941516, -1.2611719066892275, -2.0729149407825456, -2.3062994688110376, -0.41084799836327546, -3.565430954028963, -1.5385041162521729, 0.8526211025445962, -0.08177042853576368, -3.0898381609362664},
    {-1.5684256169033535, -0.429776266504396, -0.509922792580935, -0.906338438086983, -1.8701777789596779, -2.5868414514396685, -0.12454591776599652, -1.736852412112303, -1.669463926611469, -1.582601019042991, -0.8162294598818617, -3.469751679657944, -1.2935262701502563, 0.9159622494645756, -1.2300765277149084, -3.7868282665753656},
    {-1.941992498144121, -1.5176167003332, -0.39247243639966106, 1.6480855732935586, 0.055012522161897816, -0.7797676349757903, -1.1078599090847787, 0.692888798084212, 1.190173772068578, 0.49749028950038104, -2.2839339987671163, 0.45337044842861834, -0.19155803888506684, 0.6950153230431805, 0.33706773052367567, -1.2077867458522453},
    {-1.8356504049099918, -1.0508976455407804, -0.13163091862136625, 2.434829886109848, 0.9268406295666706, -0.551138404509059, -1.36409596311794, 1.1500066059656182, 2.158283340537634, 0.9026992042917757, -1.796144414065436, 1.8668172719752807, 0.4899110442524199, 0.3816537365783039, 0.9029721360742384, -0.3510931202208942},
    {-2.571076716545906, -1.0009729358443245, 0.791791685957572, 2.487361392455622, 1.156064050230033, -0.7608092716841315, -0.9434552746270964, 1.4019960360436843, 2.3229367514218784, 1.6024585377311846, -2.549871146849797, 1.665236930168473, 0.5334159507299804, 1.352301019626007, 1.2893239094351325, -1.0902157999196154},
    {-1.7671959163415474, 0.11740249431234916, 1.1132553501301465, 2.3796011250101037, 1.630404951480406, -0.13706330851675352, -0.206557860307643, 1.9763146399069589, 1.959235345808888, 1.7917881692559765, -1.7658669807458833, 1.4249464362139457, 1.2803918637401368, 2.0776109674466112, 1.903858414338824, -0.8807066282085636},
    {-1.2493423554870295, 0.10293852641808135, 0.7679637646141289, 3.3047815627453505, 1.4791454600438247, -0.019026914527381637, -0.639335590799802, 2.317425423568162, 2.863671463922745, 2.194269064628384, -1.0253654579493747, 2.1579653352179355, 1.707491532511336, 1.526296942461141, 1.6685122179025214, 0.38322059835951366},
    {-1.2067971117192544, -0.9760765729106956, 0.5432751195762766, 3.192540598134154, 1.3588923761470548, -0.9538981083093823, -1.1765957276025887, 1.7519583801313312, 2.693985567901154, 1.4695398352060283, -1.4131197441397647, 1.6842134855457154, 1.0051647761491687, 1.6346328677362072, 1.515859863204617, -0.14488116027876202},
    {-2.0020903477052197, -1.3978449244392954, 0.05934843872599971, 2.047215822940181, 0.9544952372859383, -1.6606814759545474, -1.1014078646535754, 0.7862694362848053, 1.4240803526995804, 0.7766614394089767, -2.292246219158341, 0.6389310109352837, 0.446981401345298, 1.3977851361902862, 1.5896730677177877, -1.0323271395692126},
    {-2.714251343097675, -1.8918415409824596, -0.3394848824315481, 1.995961326976646, 0.7645227775574844, -1.5129519852538216, -1.642035671864799, 0.9538774172147666, 1.8025680969652067, 1.075406908384705, -2.730762958784956, 1.027738631163761, -0.22399959980435688, 1.0747717857939798, 0.7906366915975728, -1.6134866580105691},
    {-2.537441511573462, -0.9991005021987389, 0.36952326478793485, 2.471326616479539, 0.9045216842785386, -1.1935910892422812, -0.7178706330008486, 1.529708183028885, 2.294381920086454, 1.5057048523819598, -2.7912516394319904, 1.0846366505076328, 0.7422986477511022, 1.270199799780349, 1.4699113095835172, -1.3444116788231664},
    {-2.5032189121962047, -0.9739569058241931, -0.17453264212692746, 2.8183331366477895, 0.7403766608463654, -1.090567824042036, -1.6261010737015773, 1.322628936578875, 2.3116535298683427, 1.54165451678942, -2.7680718349545437, 0.8627646690907044, 0.4092336276935114, 0.8314826932678138, 1.160974462195863, -1.2259639120944652},
    {-2.1380557689968334, -1.8568416126527714, -0.9655739826888841, 3.0469088527770487, 0.37003430492297146, -1.3814083785387365, -1.9510170500903976, 0.7242243167546613, 2.4181458830612024, 1.1789011485855525, -2.7338816843642824, 0.8990319142268908, -0.016851544666914544, 0.08848589348455947, 0.4566571400837415, -1.077301352622397},
    {-1.7790725408805321, -1.1216836603781808, -0.06712503239431983, 3.645297295536707, 1.3411691549434943, -0.7766518971979235, -1.046460940713558, 1.4872937713442045, 3.1317916573235975, 1.812831584504094, -1.7224682180930457, 2.2594540442680695, 0.8478214605002059, 0.8638418390731908, 1.899174238055236, -0.315352450171429},
    {-2.257878789982731, -1.2069998701786708, 0.3891741505674368, 3.3394619492909885, 1.7340844621459468, -0.7821508074631245, -1.2701225297334773, 2.2671319009279074, 2.8971281125581587, 2.375940049230087, -2.259980357576834, 1.9096518566641896, 1.0587553311625644, 1.46464390001713, 2.106486458027625, -0.5643896032223523},
    {-2.372976121340062, -1.267258351940649, 0.060428769481164164, 2.7150440296126868, 1.4949206897481273, -0.9685314638920877, -1.2423085449631837, 1.6420967905263235, 2.344274273281995, 1.8488008337587052, -2.8060342282742403, 1.2476268029382385, 0.5389921831786699, 1.719846167626351, 1.332304712313696, -1.1214359155171083},
    {-2.1926445322890937, -1.2351346799168514, 0.174524410192264, 3.2849815723531437, 1.3119076541715946, -0.6865371254409881, -1.0470001860134777, 1.5770876867438808, 2.669558552099016, 1.5462770806908122, -2.5242369037552774, 1.6860881030511963, 0.14010873749450808, 2.3805839869908083, 1.3807598591389243, -0.9836180819668872},
    {-2.5177679847145074, -1.5208127531479956, -0.42268486666481514, 2.847111786490662, 1.1701795944650781, -0.9467863937461186, -1.3678240439867302, 1.1590887594964916, 2.4618776909262094, 1.4205818292228112, -2.7656731842188376, 1.3663441777983942, -0.10867856073658501, 1.452959474064113, 0.7859364061757558, -1.8588184283312406},
    {-1.6025767485768234, -1.1164454777989583, 0.03500522495508622, 3.694049433025782, 1.5592659294608726, -0.6645810618888408, -1.2143651901129933, 1.8729655374284404, 3.3467786353854856, 1.8243951081470005, -1.967113140551293, 1.798469983377796, 0.7916430206857312, 1.3131734658945728, 1.4195526296433807, -0.37332074558325695},
    {-3.0964102329472785, -0.710805352348343, 0.5820025783476851, 3.0620350080931233, 1.9421869935703127, -0.5081624575076055, 0.02618179226001329, 2.094923007065314, 2.454582312506465, 2.181861518435998, -2.883160383090147, 1.2009083337271327, 0.9926363902587618, 2.380245905154113, 1.7489677141585775, -1.6533869032631014},
    {-2.65596412178048, -1.2454119137538024, 0.8328015484244827, 2.737292492489993, 1.7668827732215617, -0.7876587449265092, -0.285636706591917, 1.7726636405308454, 2.5270022620427812, 1.9931110132242609, -3.19161314334223, 1.2503667311920112, 0.29754428404321864, 2.338195961997443, 1.9737718813818677, -1.7513869972809744},
    {-2.6100249686924686, -1.060848499908024, 0.7522956333617616, 3.4289585875551456, 1.8043323593576592, -0.7523644726773504, -0.9417646076084182, 2.079558839396747, 2.5296940308902127, 1.8651017449192497, -3.0697556743445853, 1.9630383902204245, 1.1179691464876207, 2.1797540258524304, 1.885802197237517, -1.0948701637212586},
    {-2.8426179914488854, -1.3177012845690164, 0.15498765088148084, 2.958571436031425, 1.102290438101118, -0.7735408984461531, -0.9864955867245475, 1.105265196006167, 2.5676318609447537, 1.3782322806938672, -3.085361534584605, 0.9207626557316497, 0.452088825600666, 1.1799292201664862, 1.4720536981940373, -1.2797956623313416},
    {-2.3183478769297334, -0.8397814816379423, 0.5187848208204799, 3.5158819390615497, 1.5082734790826688, -0.7652208633848135, -0.3737267188661208, 1.2388664604004904, 2.85017942790724, 1.316765436197207, -2.8999705881963616, 1.3907834875883578, 0.1270373370049132, 1.1555135009305944, 1.399780487467598, -1.170790644531124},
    {-2.543006957731167, -0.8492467434968587, 0.3922245137262223, 3.0652130695365942, 1.6343709091554035, -0.6569108448170499, -0.7588584097530419, 1.1944835010772599, 2.2169539115840986, 1.4181980803904335, -3.0848807172136077, 1.3068921537270555, 0.06927312969486983, 1.3609628261783293, 1.2500109730535358, -1.470726720595452},
    {-3.07130262716083, -1.5717141870088336, 0.40603865670761957, 2.914489617311756, 1.3214102434406594, -1.1906594149408887, -1.013158181445063, 1.622490807041173, 2.4210991781812314, 1.724253246365933, -3.6224903128245027, 1.355091540108407, 0.4700231369141342, 1.616576875169481, 1.5577124165561587, -1.5867859336703625},
    {-2.645542837095489, -1.6847105193032068, 0.27936833678719697, 3.83012095076265, 1.4598560040520023, -0.8427342372010139, -1.1815767736261824, 1.5256834490002276, 3.3060934364931, 1.806759720947769, -2.9804170568771804, 2.3393610499785864, 0.784287704318912, 1.6084876174542102, 1.2996263406752986, -1.4766304829768546},
    {-3.8518085319452715, -1.6360317171523044, -0.03193221743631683, 3.118598970012988, 1.6099047779848568, -1.2952563843920253, -1.2555355626651599, 1.7141219065784266, 2.5074855997592618, 1.734597507746046, -3.8855427150440396, 1.6224655528648533, 0.23421425852298902, 1.610856888394174, 0.97088283543445, -2.7517845639918894},
    {-2.5363499049823797, -1.7946386710583582, 0.2016611253739145, 3.499179269003188, 1.9355982904581464, -0.9321681024218098, -1.4532894448027738, 1.7664479367289712, 3.4005414317098324, 1.718211183561238, -2.8483251628320008, 1.9146817478060905, 0.2558250884900369, 1.3553028723522345, 1.0836413478057207, -1.4165223672932468},
    {-1.5714985501545904, -1.041952651981071, 0.9324231346445397, 4.448462301696272, 1.9868141768536094, -0.5768246234053911, -0.6360204480075313, 2.4645326257770925, 3.778348743974185, 2.299528328236206, -2.1471497367752903, 2.468899953152409, 1.3257009990483843, 2.25571488756492, 2.0377098908075495, -0.6388580473744992},
    {-1.9244149752106494, -0.9097207091630952, 0.3906534379477613, 4.132623467218114, 1.7403819267025764, -1.1318682312046404, -0.9315303414528447, 1.8740784135432333, 3.6366167609123, 1.328393795479517, -2.31496637526636, 2.196440539828711, 0.2906080282926454, 1.8403814014445525, 1.664777464476826, -1.034416291848689},
    {-1.6601277801482621, -0.812278316473866, 0.6132455043705455, 4.1719646334500275, 2.3274946086306154, 0.14039050628698518, -0.5245562653434424, 2.108358915138103, 3.8589472834556666, 1.9535602717746632, -2.0841053102186273, 2.45482906872328, 0.7187204285939163, 2.1409990213210968, 1.6015119767453794, -0.783359626837876},
    {-0.0061104886348863794, 1.898021831285278, 1.6344619194595749, -0.5677561876341549, -0.3142465485268371, -0.7954835917911524, 1.167915635132126, 0.05527905655095181, -0.12561913320244064, 1.4521520457375527, -0.8703240440110667, -0.5719291933324556, 0.8108622570940626, 1.2976697357751819, 0.6506591995596905, -0.920728733877727},
    {2.225058300933793, 0.1472602026453211, 1.9623171230078205, -0.2444431363774078, 0.6004761576385056, -0.07311531033380536, 0.6748342252530932, 1.9400784044936061, 1.0057514792515962, 0.5775240491507304, 2.418065137423782, 1.0779941881546593, 2.0791619153059226, 0.7823673580468828, 1.9642826435819718, 1.5558814957524778},
    {0.5837169562955877, 0.7195157511932615, 0.7277484373978537, -1.02052727481432, -1.1042559191112042, -0.18355083570139438, 0.7509878381041142, -1.0494615644178515, -1.8577034780496795, -1.257603823550669, 0.5201040691013176, -2.149169939237546, 0.4949749544787848, 1.298412377186834, 0.4541759961892247, -1.3129703790576912},
    {0.6509040376104462, 1.0103845398856073, 1.2470944221320246, 0.24588487586187016, -0.18846009176129053, -0.23122520325474655, 0.5713888260649664, 0.45394574268581367, 0.5677150597068922, -0.1778109848871825, 0.3533693597729772, -1.1460625306536598, 0.39227677542936146, 1.70724204815012, 1.321885442864164, -0.4282333290773734},
    {0.8400188899644014, -2.0428178201310536, -1.3783564782876034, -0.05276317421923158, -2.166350504470499, -2.4590491769133562, -1.766003072773793, -1.7191665908069018, -0.23955663850724218, -2.361868957906247, 0.68090313884274, -1.3007571507116094, -2.302121019059676, 0.39880835313800383, -1.1475494850234367, -0.022649392869389027},
    {1.6461942151852946, -1.4495119100805933, -2.026939814527638, -0.2398291391869754, -2.3656220520827587, -1.446394607181334, -1.501159627407443, -1.5606141408080503, -0.022374852347991206, -2.1660918874948183, 1.1555603177157778, -1.639170599899862, -1.5064773273841452, -1.1496808951376927, -1.2914673915596109, 1.040113332104407},
    {2.169789268200724, -0.7336399740501375, -1.7522904223340914, 0.3155248337196731, -1.7576128316226585, -1.560213842251779, -0.703615398153241, -1.7530868965130673, 0.0480378616656284, -1.7690479885631425, 1.5133649368524842, -0.7232342288132458, -1.4213845902384759, -0.5637089107038957, -1.0671293455679487, 1.2234185772333208},
    {1.1982220308999196, -0.7746806488000306, -1.4718322715812473, -0.2108208583216429, -1.29939231091614, -0.29546557605858115, -0.84408680405491, -1.1197847074383254, 0.0057900299062641465, -1.271271414795589, 1.2667956577631865, -1.7455641427569537, -1.0148352123668338, -0.4265317748331344, -0.7540364325416428, 0.4916221504614985},
    {0.4444966261583463, -1.1289546435608753, -0.8144820726330024, -0.7611731922751183, -1.935637246348099, -1.8969490189292177, -0.8243362293372024, -1.6009477796072218, -0.7920161007767451, -1.8678392291513684, 0.06837010577109194, -1.8631441430759015, -1.407936032787255, 0.40020665948324813, -0.7430118630018732, -0.3367316221427146},
    {1.0961406684488317, -1.6897460404923481, -1.3476593876512477, -0.27957417152001524, -2.549711669666838, -2.3201950467394292, -0.9180354238199356, -1.8718559487504114, -0.6854929729256036, -2.434677141535369, 1.071095189828271, -1.8258939846449265, -1.9830713933355815, -0.2080576909863299, -1.6174534360320818, -0.3984346928275502},
    {0.8336207531653118, -1.164251965946139, 0.0341860890466337, -0.4176315930191096, -0.7577918822197945, -1.9250544368750373, 0.2203108684338325, -1.0903100007862827, -0.547542365575097, -1.9091901954711956, 0.2369971037847968, -1.3566979661894014, -1.5045444506820795, 1.0421476028028562, -0.05873663861355129, -0.2787548764857588},
    {0.14942300286984714, -1.897460693262387, -1.5179009829809216, -0.878304422227901, -1.6328387963847495, -2.091925300423259, -1.0396251479829852, -1.6646706749577205, -0.5883210738783785, -2.140466824023989, -0.3700956425583959, -2.27815883153931, -2.017667173131741, 0.3511774220569393, -1.4657269310734156, -0.8174792816460812},
    {1.470316309402379, -1.3831510156465612, -0.7051736695682019, -0.2786459172704471, -2.1758339237587014, -1.9286734066882691, -0.11476582522653976, -2.196037975597963, -0.5572120191112941, -1.903374614080215, 0.9658129663289065, -1.5273256462438225, -1.9844041137913744, 0.31171309287008403, -1.6026989431110592, 0.37935949787739603},
    {0.2567612544362728, -1.5062718535017556, -1.4529014102509248, -1.6622101720212392, -2.519411194228019, -2.4231783952353507, -0.3668562612196496, -2.1745467254326596, -1.831812143351146, -2.803517880301178, 0.32397570633706213, -2.985182966213849, -1.9946781052784999, -0.12456244839159013, -1.1408257044091792, -1.088853798065138},
    {1.1167198844343198, -1.4174809860565687, -0.978114024025532, 0.3265557505092549, -2.122733254630483, -2.310770795616874, -0.9118405802095378, -1.3809834666910328, -0.177893084131956, -2.1510134712811007, 1.2430343968663962, -1.9267310354006837, -1.956707602087912, -0.25213626548998774, -0.9802662551106517, 0.24736876354898593},
    {-0.46964524773722954, -1.101561526777291, -0.27633137034945865, -0.6566222123160894, -1.5892030975329599, -2.3913291338660545, -0.4255577306772126, -0.5160322827410924, -0.9737866516155839, -1.4801873886762393, -0.030375351317698508, -2.2636538368187993, -0.7087396949609036, 1.1509762191350317, -0.20377627241039573, -1.8174647646416195},
    {-0.6059778146136556, -0.4485045827352986, -0.545385045391313, -1.255498308673642, -1.5046247836081856, -1.6111626455427885, 0.022539959995956222, -0.9567293359845888, -1.9478683668092374, -0.9750897205173163, -0.8827556768405218, -2.689517873088694, -0.5628857279077039, 1.7446446566446387, -0.692455296335499, -1.9535683683829959},
    {-1.0841580912030386, -1.6034553546556816, -0.023928585798470434, -2.7303534053609506, -3.043625900673556, -2.686559665561112, -0.5785502901604298, -2.296901726290076, -2.8932758875265705, -2.8188895376590777, -0.8560091937968143, -3.9587848642139662, -2.0292418208223877, 1.127969373821027, -1.4297265656682527, -2.9683134889920284},
    {-1.0486847490264686, -1.1699687628843072, 1.2798415726523755, -2.1564266406545065, -2.0975728420833044, -2.574814200880138, 0.3249553045416757, -0.9769010089379512, -2.0756553050324094, -1.8640238470823451, -1.3006301842328016, -3.2998782659041117, -0.8332113270696774, 2.0995866188288335, 0.4676526744458086, -2.93149293388744},
    {-0.03691335056908195, -1.3856645490001245, -0.7290321772901538, -1.2691871578177987, -2.2530601094716936, -2.833721413600708, -0.27209728508008996, -1.224917505099262, -1.4384152735956004, -1.9347900702022764, -0.20363251017110537, -2.147889460742748, -1.29086923476237, 1.709315951991351, -0.6751963412360464, -1.9898039591982086},
    {-0.6253695877608499, -0.8181862830223695, -0.7054962966460673, -2.305963818310591, -3.0103108044751417, -2.962317319005512, 1.0035744350725864, -1.9489139542079341, -2.149847042993474, -1.7599250215096998, -0.7491852202495227, -3.664248797160026, -0.979189313142236, 1.782715950830075, -1.0102046337874833, -2.153742354396326},
    {-2.4950304814568893, -0.7866803458415984, 0.8489687290553384, -2.7104821349033235, -3.0299438609090497, -3.287150702806338, -0.10173471643411587, -1.0791992824982364, -3.4566728775234172, -2.08419053257323, -1.0065303206933873, -4.178645415418006, -0.7922498985716591, 1.9354299051460904, -0.37120474762096106, -3.975991947498754},
    {-1.6742392550962484, 1.3308629343611695, 2.913011960806818, -1.2938128636798558, -1.3599213545154354, -1.4966170509350731, 1.7966206421355242, 0.7609847881007261, -2.1261458184399555, -0.18310563463468785, -0.17996851111598533, -2.6047559192206995, 1.9653799320859968, 3.432110977617276, 2.004446107611896, -3.4844019125800494},
    {-2.416901897838591, -0.4560356662290749, 1.6318862355711918, -3.2317538432413593, -2.9133286362604074, -3.4261546279849973, 0.4652622062063754, -1.221975777250674, -3.2816809446491293, -1.4676961008848308, -1.432182951284143, -4.176778206070014, 0.6471997839914531, 2.1667508543553184, 0.15449438679040853, -3.7988348644243026},
    {-2.0891776695673823, -1.6734520204358965, -0.43356143999817864, -3.670993621308268, -3.224160391882966, -3.639237870909789, -0.8420755429254975, -2.219332330146747, -4.063705047253333, -2.688791055209903, -2.0279600629331784, -4.872766644775225, -2.181895260811249, 1.7999553425758925, -0.9636563413861444, -4.3970688486178515},
    {-1.082581849578002, 0.8165956968049799, 2.5452136207189797, -2.7915113222725294, -2.33808470845001, -1.284500354109579, 1.0383312396899826, -0.12424729799026527, -3.7008981909846694, -1.5563308495930985, -0.6868044384606635, -3.7823183415422075, 0.9694306689806039, 3.1439741302973396, 1.3704300415766397, -3.623577280211882},
    {-1.3623550115465128, -0.7468609703896955, 2.0229151021905096, -2.640857923820376, -2.674518193292809, -3.315992326503554, 0.9595823373292961, -0.9801982227195498, -2.7421223925351246, -1.495290423113912, -0.9731347985302881, -3.817602289813043, 0.4833754949566843, 2.608501225450818, 0.673234179173361, -3.66408766612492},
    {-2.770162520232563, -0.5777131821055276, 1.8522759973851624, -3.5189360518162975, -2.847044271504643, -3.1623641302579517, 0.8729850187486087, -0.8262132175997648, -3.9489110958936027, -1.4679993611470064, -1.952029355822188, -4.7580492254592786, -0.4177725712763503, 1.9449077996262185, 0.3326533003490834, -4.372633478182112},
    {-2.7314824221940146, -0.7997820635953655, 2.177300422088184, -3.523821737129928, -2.9330586285201266, -3.514414552467336, 0.6543689029769619, -0.8469567128056426, -3.781268221662147, -1.8288135874302318, -1.6709421139514304, -4.55094175321906, 0.41862689479521537, 2.488796250250877, 0.9837690187556093, -4.598720329305544},
    {-2.968980352437963, 0.8096746138191998, 1.5767628547495947, -2.6725149851943226, -2.2172559061690955, -2.190984458058847, 1.913960642228023, -0.05940687007165388, -2.855495629088445, 0.7593075490391756, -1.953773245965491, -4.1963593736022355, 1.3825752929311095, 2.896220195203648, 0.48709542910856213, -4.6283491439259565}
};

static const float b1[16] = {7.189311495432295, 6.170128695984647, 6.276077249162919, 7.1513113955575225, 5.983995398915039, 6.5597973224827, 6.394007568634139, 5.830138977599023, 7.147902747794365, 6.175180869971395, 7.19688886274359, 6.905162215540518, 5.728925039763359, 6.342906655893165, 6.080458176482422, 7.014759483634134};

static const float w2[16][12] = {
    {-3.2651192410616035, -3.407906731894041, -3.827208144030956, -3.630234918885209, -3.6928485595023197, -3.623213391103504, -3.926046076051651, -4.281731186893754, -4.272108616475125, -3.3311177957256186, -3.254578350302059, -3.620271835003918},
    {-2.0032355237490127, -2.263563861205572, -2.554015138442312, -3.175867090925629, -2.178507563124566, -2.093045380989158, -2.678892038845173, -2.547445126459144, -2.263431877256037, -2.162332526606598, -3.063384619756593, -2.3242013185570274},
    {-2.5623574476438984, -2.342941546940978, -2.281738969456242, -2.647206412824558, -2.582774419510683, -2.9001905274945683, -2.3268775755738793, -2.6432772637672204, -1.8403987058796258, -2.591993076555143, -2.1366933758947586, -2.0846544579493878},
    {-3.7859660052362565, -3.0056753874590663, -3.9593295996065225, -3.590799812358087, -3.7566420633679765, -3.6339420518802266, -3.445217087345152, -3.2826185903556437, -2.851465377879609, -3.143242451785108, -3.3695687769461564, -3.479609887487461},
    {-2.0125559103552684, -2.5255615005974117, -2.4680699767267877, -2.5439115322008727, -2.2897963552733565, -2.8647980996012534, -1.7032943667309222, -1.9370831587593573, -2.6304335337560043, -2.1806187248461786, -2.845241328868804, -1.6847633070128223},
    {-2.8050667625201013, -2.383586563589323, -1.9037579167386312, -2.1111449840762386, -2.4447460991106356, -2.562156004250738, -1.8418121790154323, -2.360893137613152, -2.5690594639482947, -2.0351861731308913, -2.335454163969601, -2.764926462787363},
    {-2.3364209721426423, -2.785466834394087, -2.5232816306207506, -1.637728689037736, -2.252864031114836, -2.3545054438749906, -3.1684894618650015, -2.5368665101038523, -2.8254071983772318, -2.747775270315263, -1.814175690615931, -2.49502168115693},
    {-1.718614047318086, -2.1816947952251335, -1.8934803053608262, -2.012547576232811, -2.653529180732848, -2.158183823525665, -2.523104937669182, -2.5653563752896797, -1.8181629350304855, -1.9988666021013473, -2.508748665307121, -2.6212272296923866},
    {-3.0551025945202, -3.5825006552288117, -2.563179038807325, -3.2792558325447088, -3.117493290069171, -2.927988140149487, -2.96668489850464, -3.630809314768601, -3.7491542756547793, -3.7252665911334333, -3.335994278149976, -3.417471509763113},
    {-2.235411482469141, -2.7637967001455617, -2.0376039062568108, -2.6212748911821535, -2.0409172039481316, -1.80293736584148, -2.2538621742737495, -2.3901922974134426, -2.457984110213421, -2.320828198512838, -1.6871358498805131, -1.9891237322389659},
    {-4.079860544015231, -3.707359792165638, -3.784763278091435, -3.738498293104068, -3.724203511520745, -3.5845287348286585, -3.471777999647114, -3.955536100476292, -2.8650627795803025, -4.267945277998401, -3.8867939748079734, -3.5107011583544483},
    {-2.7315658092297794, -3.045054984000059, -3.1031872581435436, -2.264523989922284, -2.2558559922686987, -2.7643301538866734, -3.199297815198703, -3.1546705402978175, -3.057133241066657, -2.682706391486551, -2.594967582812197, -2.433310353160909},
    {-2.49225300356598, -1.6239264657236085, -2.893848185020446, -2.0263095801574007, -2.575621078152509, -1.8607765693190552, -2.581198235004094, -2.3946261938003097, -2.444972824770463, -2.91579008514609, -2.410153262813442, -2.4330436815944005},
    {-2.790956083324756, -2.442525842877497, -2.6028095680607337, -2.6203071523150854, -2.4559162080948154, -2.1494543677394393, -2.545433757401433, -2.4212201027986167, -2.494861624696326, -2.3722070837136635, -2.841392405323697, -2.634540163454011},
    {-2.5240777171070534, -2.1348328731432815, -2.188383276430542, -2.0773401680022237, -2.0805519417658633, -2.6901444580410727, -2.5457179239321777, -1.9159849338754316, -2.503068571651146, -2.1008745397216444, -1.9747216827039233, -2.767218710146723},
    {-3.7529368790007824, -4.031764337184212, -3.5005663392118005, -3.9804342382582596, -3.991248892233918, -4.021003379035937, -3.701882421932358, -2.6521698552585606, -4.017506125519104, -3.5513868446571712, -4.125473746129937, -3.8848021481759445}
};

static const float b2[12] = {-2.767638117029657, -4.368508257029663, -1.5161457540267633, -2.5831104737639214, -2.405685412148788, -2.790057734547696, -2.367175154248207, -2.837150901492027, -1.6493618902631557, -3.219295572139538, -1.878886209210742, -2.4242572472117208};

    // Input Layer 
    float z1[16];
    for (int i = 0; i < 16; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Output Layer
    float z2[12];
    for (int k = 0; k < 12; k++)
    {
        z2[k] = b2[k];
        for (int j = 0; j < 16; j++)
        {
            z2[k] += z1[j] * w2[j][k];
        }
    }
    softmax(z2, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
