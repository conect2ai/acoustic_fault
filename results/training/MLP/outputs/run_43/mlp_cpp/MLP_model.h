#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][64] = {
    {-0.4027778369367935, -0.7494811230485052, -0.5148839516091948, -0.4366176597129149, -0.03316436687143426, 0.4953100045288506, 0.4619476610025329, -0.6515117043929554, -0.686541502114384, -0.5152781325162353, -0.3113130278179132, -0.14532194261923742, 0.5334268069998002, -0.7361220844511269, -0.10573588112521866, 0.14302295970086012, -0.5155842211230806, -0.25396521384293874, -0.20581730821983152, -0.5612895512409938, -0.9051109212124928, 0.21353944056372634, -0.7190819819568889, -0.30610638707790827, -0.8766178241493728, -0.8632939222754228, -0.34003567137890595, -0.8290835812656693, 0.020674631106291134, -0.9140513426228216, 0.18521026631563844, -0.8911240569107877, 0.12745221995096015, -0.5328442009645654, 0.19511982595832117, -0.19889284000171517, 0.00040830046650550464, 0.04205035175148938, 0.13126155610862164, 0.08274387624443764, -0.03929493738699786, -0.7823615145288842, 0.2386694289663126, 0.549013577961753, -0.37049550530156355, -0.1472065421310458, -0.7611663479579408, -0.650858907897736, -0.07902108233567745, 0.2049181133978676, -0.8903560927635535, -0.6942863937131196, -0.7075160361698783, -0.44975239146761214, -0.7534472357502601, -0.013013935051370691, 0.0618413615540498, 0.3573493989301204, -0.17796283282720862, -0.6897136436250678, -0.6627098296501989, 0.5842347171031917, -0.8795923386202642, -0.019714940568394686},
    {-0.2495007062865588, -0.5434359909937934, -0.8871357692862732, 0.5086947465527392, -0.5972585893743473, 0.39924195964534903, 0.2402326031481522, 0.5145967749626085, -0.6216273646894961, -0.1747373772918009, 1.1256895375956137, -0.3256299273517692, -0.3886501213419664, 0.015904620501143506, 0.09219298290611386, 0.0678241288525662, 0.07659439690878424, 0.03899901178969938, -0.05713501890976408, 0.6142612317123315, -0.21244908797719414, 0.04192505625968744, -0.05185114401976768, -0.19230646376209748, 0.20977723036132048, -0.8131561715900911, 0.4521423801421529, 0.207276770580429, -0.8709234721883763, 0.3945530792797012, -0.5545473232681841, 0.7458904762811366, -0.48945243878381245, -0.5731753511990388, 0.7901815621665571, -0.5495706915389558, 0.20934346013559912, -0.4541577905617304, 0.8205267816946572, -0.9150154393283996, 0.25760376028325793, 0.5870865722430475, 0.19904781041495534, 0.02289099695745598, -0.8458692099483706, 0.38912412009857683, 0.13912023062308454, -0.06769128665358407, 0.5572934935200103, -0.5275188290685786, 0.3445341406132514, -0.6857711149037535, -0.03940720963685913, 0.14627119552680212, 0.601304234268041, -0.2261864894714302, -0.2107432565872102, -0.7132503494713348, -0.3237308037464485, -0.8484941121286744, 0.05904205890760819, 0.8146059188420436, 0.10342777944795589, -0.13120516691307718},
    {0.7011924411716358, -0.7390142041600827, -0.14784998512103995, 0.6265940388989014, -0.5047226769869175, -0.08637263565834151, -0.4493066713111074, 0.5524491114862569, -0.5283511181390348, 0.10395536096659912, -0.3507606429313504, -0.06772414140340496, -0.1279187519444094, 0.05202959760697702, -0.16573616227496413, 0.3360145113741732, 0.9744445371606679, 0.3588695728774089, -0.1927881963848677, 1.2015233316896894, -0.42284020477299294, -0.034510987926946776, 1.1652382237171548, 0.5404722420837815, 1.0149303568558619, -0.1870836023676447, 0.6029705640670306, 0.7706806197837139, -0.0021446608064497204, 0.9607775383820044, -0.5245814354942006, 0.8027296796662858, 0.07362714930780653, -0.31334138473246204, 0.4649341066659677, -0.3076089729933129, -0.6374836982915968, 0.5501234932995457, 0.5466270714450948, -0.6435644591789991, -0.22962698703201537, -0.5659085179049715, 0.2499394033246229, 0.072988860764771, 0.510433459197263, 0.09952555053748449, 1.0230149053450643, -0.0009465508436146699, -0.5939375438052433, 0.8910563810287744, -0.2618823131400005, 0.7176528902482288, 0.00974243984574659, 0.6758209954940889, 0.8090577598907195, -0.4373037165672555, -0.5118838096333008, -0.04741260006118853, -0.01782019115498836, 0.8425367218502658, 0.36175468991193993, 0.7009476307452559, 0.6215383667897756, -0.01746807341461381},
    {1.1706786868948906, 0.06342823328410839, 1.042041144023091, -0.41534604677231923, 0.11930195407386963, -0.6694770890258499, -0.7660708171094298, -0.029373058702242126, 0.6365334449295246, 0.7301447465717815, -0.9176315589294601, -0.0063812794929544395, 0.2027245787365684, -0.38471052915483045, -0.8661334291139703, 0.32896909015656267, 0.7946793081260621, -0.4244926637210412, 0.049261055917407474, 0.15652430552381236, -0.08651736548084635, -0.20424957746560518, 1.0101067567331434, 0.4538856135513542, 0.9378540331191793, 0.7247850199533646, 0.37714947321067943, 0.28504852144258824, 0.49183663507497527, 0.45766998461293273, -0.2274724422057815, 0.10827209925159971, 0.5648745988743828, 0.5296983723507821, 0.002418634948887324, -0.029364816834913012, -0.871699324661043, 0.4339492099026011, -0.468190137320536, -0.029560264421618326, -0.17436309337623201, -0.851635559207402, -0.4733782688382761, -0.43765849721077593, 0.9177501664429021, 0.27483824471589574, 0.6979060609788955, -0.2538900322499688, -1.0501843270326434, 1.0015368859483487, -0.44418850468590104, 1.1334377966541807, 0.10037961847861711, 0.4170437153482489, 0.20026366738602264, 0.03691069005266816, -0.30228010064735067, 0.44643713214337066, 0.6501857645358597, 0.9877089654785299, 0.8226514838824123, -0.5937881105838377, 0.8036546819422641, -0.5608985289571229},
    {0.7039753162384407, 0.20295427045740724, 0.7957744897099568, 0.18008013238945283, -0.06385337777295871, -0.4735217174702333, -0.6525824650118777, 0.44741175035850256, 0.532827454223956, 0.26022963849260705, -0.3635273215681057, 0.4614241859245696, 0.03587337740352419, 0.5733418150766896, -0.2076129959039339, 0.3103208641246673, 0.7522683421838132, 0.2953377382720248, -0.0011666116535679828, 0.9675413868781655, 0.7913013120233999, -0.07015540773713257, 0.7703592052451856, 0.7816362643178594, 0.9181330325208299, 0.8894871507097307, 0.38717741089295016, 0.4762807324877209, 0.4926522255667803, 0.5814956325897266, -0.15253672890940048, 0.6673595844659763, 0.7426605040240045, 0.6692171400361064, -0.045702079591907044, 0.08311442798907004, -0.47198965357947736, 0.6718827840294721, -0.4115927340847502, -0.3924068033250876, -0.4005102134485576, 0.21709727063511328, -0.1576249547275032, 0.11427090520755767, 0.3136901155328809, 0.31286044880582664, 0.6296933004624686, 0.5168905602120855, -0.49101510041819646, 0.7815780400860681, 0.2945552559030774, 0.8171402700843694, 0.7263572978102446, 0.8304704926567564, 0.7509638426252171, 0.4917934627979212, 0.25615540662584907, -0.32974409443001623, 0.5181810885520033, 0.8283917092764167, 0.477047820784777, -0.15606253012104468, 0.5722979586356435, 0.3895821836539271},
    {0.6402275856642744, 0.14081732309481598, 0.05791205906034987, 0.09201305611621943, -0.34493337065645685, -0.5241773976439208, -0.42410231603481674, 0.8413192149950173, 0.5660436010123243, 0.6166517245059431, -0.21624980701974678, 0.4214255515713094, -0.5150489067420665, 0.548093233785729, 0.04997556578276674, 0.4647413147799219, 0.8376854693608045, 0.13854659039132838, -0.14018368069581566, 0.8978351178437589, 0.7331625142680837, -0.4560887338657313, 1.1308274368349482, 1.0813625542589924, 1.0008702143666046, 0.8147093015021519, -0.15735049048850383, 0.6412806629895087, 0.45659665454796666, 1.1778648582528637, -0.5540545254032022, 0.8703830244789502, -0.6653622095237055, 0.8674587647824397, 0.020575556783725062, -0.44255533049844586, -0.07177985131621417, 0.41231568837364363, -0.02066215466483083, -0.5342521327807048, -0.5614034987393657, 0.2993819084676658, -0.36719407284946964, -0.2201522296066857, 0.5587563831053692, 0.1779053318770135, 1.048350244653808, 0.7789163736009886, -0.1344686751850002, 0.6221342638756884, 0.7052930468972661, 0.9840702587117534, 0.7355434309326659, 0.819879695912407, 0.932357382144153, 0.3070156187672007, -0.2951020370599384, -0.17851035775455515, -0.0985475328592908, 1.111636867705695, 0.47314654400555667, -0.31444569908957665, 0.699650039477801, -0.0560103777396929},
    {0.5337676592335123, -0.27031407219556625, 0.1630968857136813, 0.007071194153860363, -0.35788077824559156, -0.7509785572752631, -0.7068506377905922, 0.4088645184688605, 0.3859332916245952, 0.7102590086401709, -0.5785809761416143, 0.1123638940061248, -0.7272518473492056, 0.2677530096482715, -0.13295802556780212, -0.14130322948469126, 0.7489121790510506, -0.2686916021858868, -0.35963297164264973, 0.46103949827668267, 0.5507286995703118, -0.4403314688542199, 0.9705687830297673, 0.787869313917824, 0.6876995371636515, 0.5049191943370063, -0.7200627601041915, 0.682234168983769, 0.09197642207757711, 0.9554381845631679, -0.6066686318948673, 0.9535206337972809, -0.5442106626709868, 0.9613613563077656, -0.396599514106655, -0.8192028916178927, -0.710974828461749, 0.14863929044707472, -0.45450712201087334, -0.8635902596373037, -0.587930250469455, 0.00160489022725419, -0.4466157558973363, -0.31092139734617086, 0.3103864209819864, 0.0018526958931106405, 0.647649949293054, 0.17673540056003048, -0.7288555773748203, 0.29878234009468846, 0.38319959809190657, 1.0740821156354656, 0.14913405602144691, 0.3870092480433523, 0.3895807165072222, -0.4831545274863696, -0.9053474817850595, -0.7208452716865715, -0.7296242035336693, 0.9732097031359142, 0.08813628274243167, -0.525755330409719, 0.6206113983699877, -0.44513133460745985},
    {0.5634301871529378, -0.26707973789900064, -0.605351947790246, 0.266456700282716, -0.5029372674849603, -0.1932117111332716, -0.15340078069678367, 0.4028721006554813, -0.638900098296237, -0.5665659084749989, 0.02521410942651351, 0.12563860725554618, -0.4206680102879881, 0.4189139224179423, -0.1206424352688779, -0.20709596922598897, 0.08597873307727978, -0.14884326902410644, -0.06739576540159052, 0.4185645366853166, 0.7431379695841245, -0.19109786285076713, 0.5935294159848076, 0.5118745621275113, 0.9283066910478026, 0.12454795360471789, 0.31852978313802865, 0.690570710152208, -0.37686915342891053, 0.49549790507798697, -0.3870341308602933, 0.6024864999023387, -0.5008456437376209, 0.03846411922110081, 0.5284940463869526, -0.8042094324435124, 0.08359858956848991, 0.10843478430582607, -0.28994054178395756, -0.7596432579373641, 0.11773996089600057, -0.17452884841270402, -0.051864877426115966, 0.0819810151679828, -0.4509844191574959, -0.2717946764977683, 0.28195353997964023, -0.4178853689334679, -0.39675103019198193, -0.2488600905167398, 0.27599355859883035, 0.2625797049031609, -0.029632461262190275, 0.5233156979078147, 0.33451658494896996, -0.1373217598003002, -0.16042913080853105, -0.5512643783453254, -0.3169584001108266, 0.24941145469073142, 0.005276555701191639, -0.12327032532137312, -0.05716103898729456, -0.06922413835720047},
    {0.09258286997552256, -0.0844343202090054, -0.15799019505219533, 0.3574818672253675, -0.08588056957603807, 0.26462656879585905, 0.5320067216230674, 0.892258596063642, -0.42355811122466025, 0.11381245270979203, 0.4475030394978748, 0.36832842503072144, -0.4821228271504344, 0.6383129795131771, 0.38984264343517316, 0.8284026415741793, 0.42972605334959835, -0.034074508792385966, 0.202893274910442, 0.6373404174146067, 0.11100195253019737, 0.42398985618445084, 0.6696013280738067, 0.20746904603303232, 0.7790039208599705, -0.17548751797705622, 0.5405705380579892, 0.443691019260112, -0.2016480883546851, 1.086545567368839, -0.7514452029299581, 0.6415566481098843, -0.5564144134368025, 0.3706087281483844, 0.7232514456222214, -0.4159435958265884, -0.3424915757405999, 0.5208557766175331, 0.5726684207254419, -0.5497445568297019, 0.19202178264795686, -0.28202228679771857, 0.26146638440909603, 0.389547690618506, -0.8001318644902332, 0.40036259391531376, 0.45976118517674974, 0.3431038875252484, -0.08419075006301163, 0.15938857271024076, 0.6750588007009695, 0.44787827726775725, 0.09723949046276399, 0.20273995457253619, 1.4215849990733402e-05, -0.0810973316619806, -0.7464426624674458, -0.5340613340076678, -0.5698696105100074, -0.025206008729153802, -0.0895409103106129, 0.25653226244636895, -0.04571042209782384, -0.1197744402257156},
    {-0.8617365139986345, -0.435083227486512, -0.7056339664237263, 0.2311666410546532, -0.08945234211009548, 0.994814325087862, 0.10284697058362864, 0.48917553136369046, -0.6680556393086569, -0.47846186113416644, 0.9359711639666152, -0.18721219334351266, -0.2025069517564642, -0.0030589173636671376, 0.3996479033720122, -0.7548931967476751, -0.17348705868908607, -0.3792900870358954, -0.20320389554183144, -0.16558396244139698, -0.3356233381196638, 0.5963686391254701, -0.2769617724520057, -0.17073756892421582, -0.35295178051009574, -0.6502563750756218, 0.0881470647266187, -0.2483264716077319, -0.6452484354874014, 0.0028950428533432004, -0.3347675593401977, 0.8580691220517702, -0.5806137063367104, -0.5227184902422712, -0.23734460838316804, -0.2765529481686943, 0.3845988103498406, -0.3536816697763067, 0.21015110210659824, -0.30160110676982843, 0.38954343863837165, 0.9346181588463666, -0.3025738790221265, 0.24047790265011335, -0.8045766611761005, 0.11243661035403042, 0.09630408131909012, -0.48628831277439266, 0.39457432286897487, -0.42281040507538753, 0.06700365564213297, -0.6303655607682235, -0.2847104851175431, -0.15707770737235605, -0.1361979687780066, -0.67999693189271, -0.37859720930544527, -0.3567163307315635, -0.5974352479531414, -0.6371601005695923, 0.45695250330571263, -0.15382619536449194, -0.010644608087234345, -0.3166663551250065},
    {-0.2551716224439246, -0.32845809121983827, -0.38220087042080425, -0.12464373062555355, -0.5473664355754547, -0.5582958138064712, -0.4264974572311695, 0.20694209036856237, -0.23403369330789314, -0.006450892100542907, -0.408154500587203, -0.23965003310639893, -0.5551719984107303, -0.1438160865348143, -0.25050090755698695, -0.7438049701446766, -0.14631613542998126, -0.370778516067611, -0.7891670030494286, 0.1851608218077642, -0.4022800995163932, -0.3529125344490195, -0.044308242815880854, -0.23941810035484934, -0.2930887576382597, 0.09605601684788033, -0.6429566290933774, 0.07155901310696398, -0.8648336299806016, 0.3959259009240968, -0.6514445853409851, 0.15502398440798904, -0.4848788146181167, 0.10146359629104051, -0.804232641604856, -0.6229146108703111, -0.5864627342180261, -0.8861108129100104, -0.4387640772136148, -0.18757952127323058, -0.19383245927497345, 0.46070924320015705, -0.47614137122393657, -0.4614928029738959, 0.10083291900623585, -0.4102616360800994, 0.17017127929202494, -0.05671949628267612, -0.2857382838600606, 0.254398262963854, 0.10316385626489524, -0.06468373493002542, -0.6343831002422881, 0.28811860754031743, -0.22421093015497873, -0.575853577674244, -0.2750456385953748, -0.518568375253494, -0.5408289624756764, -0.3122910703593131, 0.3439912571200921, -0.7915405404158454, -0.07501268483650206, -1.150358075867309},
    {0.690496972783764, 0.15685387997021985, 0.03362189785329516, -0.14006054124410164, 0.29598760219208015, 0.26680689773455274, 0.589585725125775, 0.21025780407465627, 0.3001202295496052, 0.7019615609102913, 0.1146749255886693, -0.38047500715342997, 0.24021751638630337, -0.4339070556314578, 0.4158304630857187, 0.9656103948227244, 0.1591565993569168, 0.302989174389586, 0.0001900092731967792, 0.23064039392913568, -0.44558717747020893, 0.416312124986523, 0.7132327522890018, 0.15052706101514707, -0.31653960495337974, 0.37530997819306305, 0.5569061275860031, 0.008308974022186768, 0.4651961712840709, -0.5059838831557207, 0.3710836042371653, 0.10166085640460981, 0.39083391320037286, 0.2241629156618458, 0.6331725879056223, 0.6605458428591897, -0.17422129558546695, 0.13133367708117294, 0.5159717181477607, 0.5486729378458404, 0.5669176193371044, 0.12580905365541326, 0.8039470663189813, 0.2669178053217923, 0.06848734139319584, 0.0488492078879604, 0.25313148974597716, 0.08159677539762232, 0.30436261327247877, 0.07245970156796866, -0.4503531669492552, 0.229894380542051, -0.3776569189127139, -0.08375103099828748, 0.09285489026763558, 0.027194241526517775, 0.08884190964450597, 0.6779992801624853, 0.34603880202587023, 0.19713088058592237, 0.2972889665177152, 0.6112541732012177, 0.4626698924563649, -0.20745841321852918},
    {-0.7258970767271, -0.7620354979115472, -0.7502376933899993, 0.7225210470857778, -0.42810979437654906, 0.11569260570458145, 0.4239709963750584, 0.5675567111090841, -0.7372812204448443, -0.5940686378704405, 0.3701172763048687, -0.5080934827359613, -0.730566325896461, 0.2959644174573251, 0.6788693703336601, -0.3859866306422253, -0.49102267105357306, 0.5183831009333869, -0.5681268644644165, 0.2594061402388834, -0.31352082182845403, -0.3775986166960889, -0.40011706572165784, -0.18213467501893063, -0.6188587966012981, -0.7228011023125285, -0.5271538038706247, 0.23593626713356827, -0.5554007924121594, 0.08405147417358072, -0.46344680813639344, -0.1232838261032796, -0.997372811033165, -0.6611197576372011, -0.426247248299262, -0.7800128963276948, 0.1355953117611121, -0.10117560416177733, 0.5385348127874083, -0.6391577862846973, -0.13056370671589382, 0.5132067822877565, 0.2683128539844603, 0.3810774152260342, -0.6693644638374495, -0.02244420771212567, 0.001110590989176784, -0.36405446433455696, 0.49854985839510524, -0.7311530018334714, 0.38083256037810476, -0.6846950392292999, -0.29927888450977025, -0.15912757475473802, -0.28896263097742797, -0.6417285804547957, -0.4491600763545916, -0.6412212462695905, -0.77765553335616, -0.8224691463954513, -0.452921311498396, 0.4344440542853432, -0.9648839788772476, 0.07152756482817556},
    {0.918234657915398, 0.3640932362268467, 0.7798353255464135, -0.7097042445636187, -0.2000112995774833, -0.8406036541086931, -0.22858902426448496, -0.3543999460811995, 0.8985128704355022, 0.9490345801298791, -0.7018200069832368, -0.5433102000713907, -0.7782528670661445, -0.5386751476401359, -0.11833110247701549, -0.215015145847733, -0.08257602876953367, -0.5665716447833328, -0.6361673301757108, -0.26642815289698224, -0.0722762028760824, -0.40977756634565465, 0.175468958915666, -0.40369009037470466, -0.3351057480437626, 0.49706405491461814, -0.4729097740049796, 0.05916926451299418, 0.2518837111469844, 0.20200308478942364, -0.32284210103403116, -0.524357508936215, -0.39922726080524595, 0.9076403089972351, -0.6091948609304946, -0.05879479933476774, -0.3435518705959625, -0.7504488394089367, -0.8519911480624502, -0.11563194066834133, -0.7003605100566223, -0.41969014097893115, -0.5848140334016644, -0.6223589861965855, 0.5567242968278673, -0.32032578583570576, 0.383502847498922, 0.07955108970107527, -0.24165638060848835, -0.3175041100954841, -0.5658221577562959, 0.5322530582803235, -0.36168150366327606, -0.7395559457818769, -0.3887007542464944, -0.3034655767954886, -0.7434979028810681, 0.3002726702522812, -0.4051298337448415, 0.2571143944649394, -0.10507350125180133, -0.6981439463769312, 0.901542927720439, -0.9716379977656767},
    {0.20604808949930734, 0.8400132450877718, 0.9321510381162554, -0.8220593538205169, -0.07893623150443699, -0.9434231597395663, -0.04906949572552306, -0.137641011103218, 0.7866102084984138, 0.5305003791164769, -1.0690278624759721, -0.3317232716261895, -0.5994525949599954, -0.17062637945433828, -0.1111379102912357, 0.3124406816252975, -0.47904301235170943, -0.08436505033871981, -0.03214346534069889, -0.8870929654812086, 0.06633959177841958, -0.7884388324720211, -0.0006237929029049962, -0.3737196392842889, -0.7572245521648774, 1.1209319077505635, -0.6191330111471558, 0.3537803806904215, 0.5414452629411707, 0.4874703864732109, -0.42096445783990527, -0.9573513485705817, -0.49141982385131344, 1.0198355274617872, -0.2802869350368666, -0.2572900189490281, 0.18695261069064614, 0.34633168141640736, -0.8002938632435705, 0.7465334260942125, -0.9876474330438475, -0.4745292727676829, -0.5476558737491578, -0.673579539906892, 0.663056984962136, -0.34807580359613444, -0.32415551433016765, 0.6058326338427709, 0.14316624611528175, -0.26775622123634873, -0.163613524485918, 0.5226274299664359, -0.573093841776671, -0.6531530247658109, -0.7577916145650367, -0.0914305523971562, -0.940691399462954, -0.08733146163659983, -0.9063399996669059, 0.4073718620251231, -1.0091034040116367, -0.7710022432533356, 0.38636529656503454, -0.34338667637917086},
    {-0.5211267566615728, 0.7099850629630439, 0.5969375301066505, 0.11442066209522561, -0.3012418374690963, -0.6887877715416205, 0.812408338327806, 0.20046279894038269, -0.18588161406777548, 0.0498254939516833, 0.11158636810135038, -0.451360735941513, -0.560470490579939, -0.0035217358289529933, 0.8225457277496387, 0.3415110176922435, -0.9999160659498701, 0.44514054921067336, 0.2735027524550126, -0.5533524920803219, 0.15835730577079818, -0.8471748776788086, -0.5673829773790869, -0.8088470336803375, -0.9581299263308647, -0.39658070523117467, -0.3328727310228311, 0.36359108576107324, -0.2493317007905706, 0.3986330778412216, -0.7843531339319855, -0.8988023761031108, -0.6904467651009967, 0.3529727230805048, -0.5010625399826127, -0.43344998262935536, 0.6365320326053273, -0.3589547713302208, 0.08519304166725443, -0.3361143578643767, -0.39603237933345475, -0.12082144734357361, 0.09254646273652854, -0.49485344103232043, -0.7547017264180852, -0.22036668821702904, -0.19796415580829674, 0.6584381058823822, 0.8893464232628576, -1.0929141103993183, 0.017810454530046843, -0.36101509106637164, -0.3833921456837371, -1.1017950925548432, -0.853566899695261, -0.6354569153382249, -0.37068723491767586, -0.7876090181545268, -0.8314364234028748, -0.7772906859615334, -0.9797350463984411, -0.08569585481598616, -0.5762304992793423, 0.2080244762175577},
    {0.8570055293984044, 0.8410083976302121, 0.6200547140765196, -0.5978965579092272, -0.1515133464774712, -0.7580639782470892, -0.6169035057494903, 0.4596456897236052, 0.7972366547469335, 1.0401887611407281, -0.7255968054113422, -0.650115981844787, -0.4304041112737944, -0.25534476738364814, -0.6434592784166415, 0.06625473203719875, -0.29117646495587063, -0.5790797073029395, -0.3746761246188425, -0.16874843681716598, -0.10749886006308938, -0.1949299214447725, 0.6618119001083205, -0.6673157386408132, -0.0826438287044385, 1.0650764414740084, -0.49488663149744205, 0.5515367979470538, 0.22943171120425582, 0.7841484158115127, -0.5167193698383791, -0.3949793359213084, -0.7248599611494512, 1.210820015672398, -0.546473989204479, -0.22273685106718577, -0.5695272060357011, -0.3337818491819838, -0.9517542384204332, 0.43209288041583294, -1.0520955649266528, -0.2318910682253215, -0.4666781188201182, -0.8569934167535853, 0.5279473084168496, -0.46298173342296967, 0.2923479612608384, 0.4887511691689811, 0.01603001771590857, -0.725769015704124, 0.07850028029853566, 1.1040737830600502, -0.47451011519081915, -0.6046655146980731, -0.209433623358379, -0.4058776049065257, -0.9882074524328655, 0.34880021628376406, -0.3612403990439431, 0.8409648045472164, 0.06885384944099672, -1.0810170576317033, 0.9239247795448363, -0.6303113216771411},
    {0.5628534582331609, 0.4032227741049205, 0.7429177072958677, -0.5490053893384322, 0.6165090915155222, -1.0282815200670445, -0.20603622572117544, 0.5694495877735009, 0.9226713232474716, 0.6648973077571472, -0.9365624185030386, -0.346490914677859, -0.8530477217652654, -0.09633624918015771, 0.026897729461982402, 0.03415246524216702, -0.28499842842526324, -0.2642634268248785, -0.4370215757053602, -0.24189170346979844, -0.02586016461049052, -0.48599887454041213, 0.26157475953882847, -0.2217442314493987, -0.5173621335828021, 0.6318796815630885, -0.21448071367513633, 0.32570829231884246, 0.7139099390831158, 0.46382162065795807, -0.3690702090906477, -0.1264390413098949, -0.5160811335143889, 1.1554221296809386, -0.768933288852688, 0.422070156252074, -0.0311980318062897, -0.5085989082367598, -0.7741276857974938, 0.37809366702039837, -0.8370192991347035, -0.07442462223317159, -0.46840678763119414, -0.5647067550793966, 0.20388410440614127, 0.11266537904182088, 0.5157122113133625, 0.6937527109784034, -0.13470045111118592, 0.11606106825371162, 0.16477960255766522, 0.6756390487275298, -0.21783077509184365, -0.3864051299233247, -0.1526929377221393, -0.37191708598608547, -0.7566616802199543, 0.4110464931757128, -0.608952977814529, 0.49564645791423684, -0.002954574233509136, -0.8324837028046119, 0.8964124763912668, -0.9937583462325659},
    {0.7661590055878259, 0.9189611749802926, 0.9597068494101041, -0.21779454497519773, -0.02929299438518537, -0.7089559345892837, -0.04789085089341291, -0.09734104396008368, 0.45381423914571073, 0.7315427765232774, -0.34246936618886475, -0.8284676437348332, -0.335547804151472, -0.3254058712552481, -0.2966195892573896, 0.5877679309144691, 0.06558820764577919, -0.3835369010549691, 0.15721368705395933, -0.11430635149474651, 0.14868198689824108, -0.1337331394679964, 0.49675022225505766, -0.0771381192812494, -0.18489050704883786, 0.6068777339615677, 0.2730982015451389, 0.8578708620689613, 0.5470423292331255, 0.11217809612322545, -0.004443198804946918, 0.1616192889303239, -0.08997575996002853, 0.8258868178051312, -0.40592265413206235, 0.16867401553665945, -0.11754988785834031, -0.1573254837965862, -0.4059839273111036, 0.1250483827857204, -0.6394221581498293, -0.39953510233578143, 0.39740548673651205, -0.4514299686524935, 0.1505497820830591, 0.17993512384458676, 0.36893515769341617, 0.4805531724730856, 0.32944696932207673, -0.718549365470995, 0.16176767861321514, 0.5724842451204563, -0.21553689287044545, -0.6654747519937015, -0.0408604423153898, -0.06477551966496639, 0.16835928059553057, 0.6555309236078131, -0.13841376480196066, 0.4268210171637564, 0.049449099603291594, -0.5779926446717931, -0.1385317129630408, -0.26901157937344994},
    {0.06942387551513914, -0.6400864375422773, -0.04843776967720399, -0.13421530104993346, -0.23364124682246154, -0.2390617702878762, -0.5071448590670401, -0.41731285184400757, 0.32410569429434116, 0.7685256544526451, -0.541116799238766, -0.851538753658283, -0.1467084792385139, -0.6384718908252567, -0.5216774714154789, -0.7385491444746721, -0.6621392824695547, -0.46007047139117024, -0.5402901278935639, 0.09596688686058863, -0.44444086635219743, -0.050053934874750475, 0.06527823883101387, -0.5257554140342108, -0.7141686604913692, -0.08628217576622263, -0.4522150715705919, -0.2891845621486646, -0.5268649629101048, -0.07323242061845732, 0.0745938163519338, 0.41404366384905267, -0.5105573691366352, 0.09383738002927791, -0.6201368351254294, -0.3653638282919377, -0.6405292561368845, -0.750759465117998, -0.8306590577057659, -0.094952338071479, -0.6432969846812435, -0.8598535500297084, -0.4113804398940519, -0.6689624961300381, 0.3158092253697656, -0.8704035663508382, -0.37098924297067015, -0.45533381364701, -0.29474320825882694, -0.3626753948513188, -0.7733358649267497, 0.6293748881635146, -0.6792410648368609, -0.33406812318841295, -0.03462843229291932, -0.4714448805855959, -0.06739900017857807, 0.28209236085670636, 0.18375785498801653, 0.510091776754808, 0.5184168902711359, -0.4203253142021397, 0.128511306779353, -0.6054618390443721},
    {0.7828384641322246, 0.48386200227081927, 1.0836286722794597, -0.7599777076976099, 0.21153098091214048, -0.4810796889282447, -0.12521177878124465, -0.8174985406732406, 0.7640229162319411, 0.9231267578891413, -0.5940396069560314, -0.2824618599796103, 0.2420945626846219, -0.43055936898048786, -0.633620813223755, -0.37152578974872236, 0.031087862572681584, -0.6009304169837792, -0.146155692079319, -0.33694151895429214, -0.4244659926683636, -0.2832034120057574, -0.3982427766800564, -0.575327510652061, 0.23142247425416543, 0.4466233079030993, -0.059829270654846015, -0.16275287925655998, 0.4664202886743918, -0.10403897060488794, 0.13312108559993413, -1.0541322068575953, 0.20650108570519693, 0.9030498475246383, -0.43502058976259106, 0.6911177075286808, -0.5951185999877339, -0.13356879034824382, -0.6031824853778818, 0.7624878243827303, -0.0271183400982323, -0.854638430676159, -0.44502811424537925, -0.7927443454880693, 0.9171388871564525, -0.5970583967976533, -0.5496439123214142, 0.04457447412020077, -0.17846415600456475, -0.028160532484653156, -0.2618097920360952, 0.2105953004458853, -0.3875597647531657, -0.31322605050827146, 0.19116509755261432, 0.30236422964009, -0.00021317599307252842, 0.6394423515475957, 0.23626842522205857, 0.6729094369904286, -0.07748672233694266, -0.4865939182313032, 0.2289162259988679, -0.6586258378026574},
    {0.464606217237189, 0.6277079141769636, 0.5928670894908157, -0.946589436777874, -0.7559354326288906, -0.7943083014344436, -0.6798688215475706, -0.7693850025169049, 0.714343753037091, 1.0478725752949034, -0.9053889972962706, -0.14846822294991435, 0.05786652887574921, -0.9266387285699468, -0.771161079326877, -0.8587213141621188, -0.41093188835696803, -0.7613338766296524, -0.4672926855781378, -0.611579900204612, 0.04267826492979771, -0.33200449273448557, -0.43374454724549094, -1.0312652154008153, -0.3046970559833821, 0.9463167842483182, -0.6315794881995237, -0.3368543290529387, 0.09575109190870561, -0.46881363589281094, -0.1207126829017131, -0.9304162262364744, 0.02094510069090981, 0.5992778988218267, -1.053628145377494, 0.3477856320449398, -0.6588765118192024, -1.0922509563780756, -0.963719898896329, 0.66458157214305, -0.6688383043014604, -0.19556850974898785, -0.6921032943083496, -1.3316601212995232, 0.7417634277150964, -0.9930040556792433, -0.5549254408126565, -0.373146316418389, -0.558734355809047, -0.34293101499759204, -0.6365955638960208, 0.6401270517981132, -0.31137366598348004, -0.5685913644520855, -0.42545206531756663, -0.3491045223352577, 0.07767272623453012, 0.10247579472773426, -0.15442001431370891, 0.48732761226755905, 0.2202473004036314, -1.0060665039472263, -0.01224192096910788, -0.6812192587073709},
    {0.6590107313666886, 0.3341086191629997, 1.1725413374554876, -0.8176201272948406, -0.2354328133208806, -0.36888454032585205, -0.5203819773335141, -0.8614155409320104, 1.0633314742091524, 0.38588525634761556, -0.7673301435167993, -0.5050366258910435, 0.051644605564762636, -0.5601565499302518, -0.5501974328585146, -0.8557196836028738, -0.2611701341758773, -0.44565787382255934, -0.1819515441092428, -0.892553807370236, -0.38252815162861104, -0.9284681695128703, -0.4108266843578881, -1.0343991210646941, -0.2019164970794907, 0.23875052433867003, -0.7380825389232599, 0.42315764368675995, 0.17862468383688226, -0.7171117091935473, 0.1576024806707484, -0.9059941526960866, -0.05939475487290688, 0.5294549892384158, -0.7255490743437868, 0.722143108833259, -0.452532974459803, -0.5948682897375632, -0.9008636325027016, 1.007375978449792, -0.44772730611051054, -0.4181255296809557, -0.5974499924331735, -0.8684240676453632, 0.6957424616452164, -0.2515737744752573, -0.463393665059517, 0.3108517719999843, -0.502594453674419, -0.4882735855522574, -0.23759124826782796, 0.37366192790157904, -0.41202187084084296, -0.23578402385075553, 0.015149877880317214, -0.28666475760815385, 0.20693341126209827, 0.4865483736205218, 0.21211996006865033, 0.05934227386807722, 0.2839706440237844, -0.594043289344795, 0.2789662897306637, -0.40786960151926105},
    {0.531647302297833, 0.29342276803875994, 0.14504102974037972, -0.6394691491020553, 0.10974046500775764, 0.31128707096179226, -0.6449646067795614, -0.9512891017556196, 0.5629109842834937, 0.4066459826668614, 0.11120739782515796, -0.479424100435039, 0.43006972271839766, -0.5857811337291632, -0.5619002670952249, -0.8867935855333396, -0.0050329448853398875, -0.6977402524787979, -0.053989067177649015, -0.6064585135274868, 0.14583354890494601, 0.21406660754604107, -0.9380982563829716, -0.700406298372647, -0.4886271399373447, 0.07340880407931512, 0.0008807162948999696, -0.2835614839070447, -0.26158670629077946, -0.8747998696875019, 0.7908430209954194, -0.7287353964616927, 0.5450073113171238, 0.08552738767631778, -0.6167691602592407, 0.7155960809890765, -0.02764931847875556, -0.8515836008978414, -1.0756255895075584, 1.0318179891784833, -0.08253307586150845, -0.013962649626962807, -0.8669186986321618, -0.9277828645221576, 0.7526374941286069, -0.10800412380522523, -0.7380370072772571, -0.25973747353060195, -0.6172765712407671, -0.12729585631001494, -0.3014319847186463, -0.01268466236466139, -0.07109907711818324, 0.38127310452175084, 0.20747289000549238, 0.3156175577034501, 0.5707974609810311, 0.7734654479125296, 0.8865675988794607, 0.6745511248174559, 0.6042813433984483, -0.8419281667664581, 0.43223469728990244, -0.5612529758258026},
    {1.001453207835367, -0.24202613073948503, 0.5345550096767919, -0.5229896450790479, 0.2034258755581513, -0.08415709774837637, -0.9601331592655418, -0.7603158602283445, 0.6964188760152484, 0.7926512361220894, -0.5492624889499592, 0.011341126494460094, 0.6130144945123779, -0.8154265300417066, -0.6200703327335391, -0.723773979028842, 0.8828785777841266, -0.589752112300968, -0.7118889281544585, -0.09913701776629064, -0.44740079094033364, 0.73994113796217, 0.7608235744789245, -0.41951870157040105, -0.10636487666258854, 0.7971115090707532, -0.05607851101091278, -0.5260104662585338, 0.7087063298705137, -0.3891195815480568, 0.49756307534235983, -0.43630423339345176, 0.784838321212557, 0.8906671809606262, -0.39182927669699225, 0.8849912421525193, -0.7395563309828016, -0.9832146142354666, -0.637378388952239, 1.1392088041410457, -0.15931556167526262, -0.4957286746996247, -0.35996263113668514, -0.3726721753751035, 0.9600374214380643, -0.2256711083268021, -0.07958217310192574, -0.49137210358583727, -0.6143586078878606, 0.40786123667297436, -0.4974559730319, 0.7062284473284816, -0.4598971718261715, 0.2608324992326575, 0.6391181855327296, 0.1565381868961847, 0.10735294085349582, 0.7445367296487667, 0.4856749800403489, 0.5148097417124387, 0.766180818278901, -0.5372774917137702, 0.8051490259623791, -0.9004000363826145},
    {0.34402758315743714, -0.27066267007890804, 0.5653657513162289, -0.5500243417699491, 0.5776459346650211, 0.5437351214286342, -0.7480609082219966, -0.8190847597470685, 0.3364994387974384, 0.4820540893071664, -0.14594259653813085, 0.23608621401134022, 1.0813316995752609, -0.8902874461741477, -0.8700276254251811, -0.5297882575602114, 0.898933919582941, -0.7967222617156807, 0.034604516717975486, -0.5627812444575542, -0.3593950240901525, 0.5966122070870595, -0.423219836772253, -0.3874621670580514, 0.10041442568526832, 0.5960659528254711, 0.2594723783862933, -0.5302269472634235, 0.7709729476884728, -1.0504620554262503, 1.0046722346894998, 0.09218578528134058, 0.7645162907861697, -0.18902712601957242, -0.21409030325471687, 0.9387410283994422, -0.5093967380074377, -0.7189010094351135, -0.6911825036662762, 1.354275564225739, 0.43885974607753164, -0.3219131541702533, 0.04071422837601045, -0.02529677488028264, 1.0153726366064217, -0.22336939318633958, 0.03166203152812202, -0.8746699205217479, -0.7846208223217361, 0.4129277395360606, -0.6835688548680383, 0.09080228352426888, 0.14821625705290523, 0.1824707758649646, 0.346954142148009, 0.41652439739395114, 0.8838998336607155, 1.3911649346058486, 1.02524150384988, 0.6090019361523432, 1.0406650113258988, -0.31716991999400396, 0.19663130029097, -0.34179984482452913},
    {0.2598544381143195, 0.4822558258015339, 0.9267426042648103, -0.7101938828742375, 0.3477930537635481, 0.10216094621788153, -0.6106743087124364, -1.1261636806136546, 0.8859124731758407, 0.192268753729681, -0.5499748680416761, -0.3052195615364164, 0.764553285831917, -0.5506778475472768, -0.6244519016557935, -0.7663081197798907, -0.3544325960130503, -0.8376555456015754, -0.12652178103572076, -0.7300568025492001, -0.4237695909699857, 0.018997846074722706, -0.592157251976242, -0.6250634726259502, -0.6169641104998822, 0.39314882910294174, -0.49646163002417215, -0.6428078013405932, 0.41979111772886946, -1.119391610897114, 0.8711438361346984, -0.9378462321993802, 0.4877112940318256, -0.20293212338967406, -0.7092396944064348, 0.45645496332126495, 0.01234400234332898, -0.7057157570898481, -0.8352627427639437, 1.18471521318731, 0.042611312762922016, -0.3899730543485565, -0.7481767232291969, -0.5846700842234714, 1.0535776980394127, -0.16720386309803523, -0.7200978212171322, -0.5552125538314399, -0.5110217914078522, -0.47265772824464997, -0.5158388759220838, 0.11436738809632492, -0.38407612102943134, -0.3738843218501196, -0.5721139085152211, 0.36622587940672047, 0.704438003746816, 0.6353419358794309, 0.6413206186845477, 0.6119192453909338, 0.6241354942958087, -0.8627115596766581, 0.0172087967994575, -0.4123729197295149},
    {0.2543905874463716, -0.5288598893360805, 0.05094508177599713, -0.47632558321235563, -0.2635114356402171, 0.16330558276482016, -0.4967086198945985, -0.9640539630630817, 0.2300705528893905, 0.28620574339778226, -0.11682572140731169, -0.19947965451514238, 0.19880986291540167, -0.5885102906775054, -0.3903310712394298, -0.3413411545662801, 0.5465258722584393, -0.12591884975103193, -0.5468486819409, 0.2734908787329932, 0.05454379824286909, -0.18805465433717675, -0.031871428673213215, -0.05919694459233582, 0.0818336120717549, 0.3597007601585657, -0.07426442849760062, 0.17181715650494925, 0.3068878073540358, -0.4206893441589933, 0.39999070637211676, -0.06851728541091479, 0.6864432775212729, -0.2676443043975766, -0.5731944237222326, 0.12916890448044324, -0.7373974928488447, -0.17644264359052864, -0.6351935290577098, 0.4961349614952039, -0.01082624289867575, -0.510758584883315, -0.537452065945242, -0.7216892910022167, 0.7377834356505321, -0.6143559969689703, -0.6016620134155877, -0.3090301816150016, -0.38041361402097174, 0.10544111180948142, -0.6704764230594861, 0.29482316928855845, 0.29344703083642837, 0.46884011001262704, 0.16698481284489036, -0.12177843682428678, 0.24427887171160073, 0.2836507920631067, 0.6875347783642094, 0.27743086435246533, 0.7586541270988496, -0.6940486606085683, -0.33607648230503817, 0.47900323513419985},
    {1.0126851179738916, 0.2803560997956945, 0.6467421924383251, -0.9451925814870156, 0.15036645700073406, -0.41325643376259436, -0.5209551221886758, -0.5710956876078379, 0.9441801075058587, 0.9179525481534488, -0.9304487626723434, -0.183120359621153, 0.7319433935361281, -0.863260192791843, -0.678958397155915, -0.0458806705699313, 0.5350107266382811, -0.9552543043466898, -0.3780850243765337, -0.38727970857043326, 0.19456908927772593, 0.1812840142987841, 0.31712348792552614, 0.04864391050034634, 0.059662464198851996, 1.1277350126297965, -0.05460220704417974, -0.3914288464891282, 0.6761685954535291, -0.6060181750995111, 0.5893548891195112, -0.37074710844032527, 0.5731494421300668, 0.5404268627521768, -1.0152078973128569, 0.6863972687747142, -0.6978731920376803, -0.8336223912126293, -0.9358055661915519, 0.8834192047169006, -0.1494011617490656, -0.2815510654807725, -0.6064257476093758, -0.6124102213800013, 1.2532662523721283, -0.35894505215103983, -0.14053112559527278, -0.1840632522031546, -1.0120459422302759, 0.0581910686111502, -0.47433492734516663, 0.765205835123752, 0.10167537231396757, 0.49318803938072964, -0.15173245347681696, 0.21759605355405362, -0.12536215227891498, 1.0433326243855436, 0.5044261106605903, 0.9186625781596277, 0.6872543913297722, -1.00738495244762, 1.0072251721725975, -0.5709525525498023},
    {0.7188506412050979, 0.7613255446664771, 0.7732901999676415, -0.5819009615938642, 0.08197388561471328, -0.6910439870766981, -0.8702091009337724, -0.30809262395512027, 0.41893282393913445, 0.7850673993644016, -0.7574644246983993, -0.5601569743515458, -0.07302326556106335, -0.5266576426881862, -0.4224259267135835, 0.17864934511714395, 0.32916322764004635, -0.3983314783194796, -0.17139504881332818, -0.4995531995334103, 0.21134043072340958, 0.34063576025197584, 0.2803087249529449, -0.17308409211617082, -0.08840750759320662, 0.9573714662392669, -0.4932462582654962, 0.25822971142503287, 0.8244975950462743, -0.359200246863043, 0.41109595407061345, -0.4157745078777501, 0.5973722503603789, 0.7066488673372904, -0.7192628058432254, 0.5304702799368328, -0.27923493953432943, -0.6553361757896611, -0.9003627061107118, 0.7751624701111225, 0.14398766038765778, 0.34377755251046116, -0.2752176496724458, -0.690195377905998, 0.8536160088316121, -0.6147160062804042, -0.11368512875871421, 0.3288282736108159, -0.6396183139289442, -0.2952513647293877, -0.5775420522998941, 0.4046302685305523, 0.2071778770234406, -0.1796304660723035, -0.16877265755925822, 0.7019390027798379, 0.27806063044241086, 0.5106444908668424, 0.4321013846794797, 0.905276539115536, 0.6605334021195833, -0.8320607051403572, 0.8124522341519588, -0.42022371081593707},
    {-0.5623184644530261, -1.0221951689387918, -0.6316044574314668, -0.7788643455493526, -0.8868452903439809, -0.38180349788321377, -0.7930227994459587, -1.0623067739557972, -0.6494893090988244, -0.7824604759471304, -0.831938441622556, -0.9051714895224133, 0.056392705647477684, -1.0710413521077888, -0.7934067973718003, -0.6506142739866295, -0.35431168438557564, -0.8550710601987882, -1.1301487987914567, -0.7852433707060588, -0.7184336170394682, 0.459253234781464, -0.3533555445089549, -1.0592014539603298, -0.8066365389348266, -0.4839699512717341, -1.2281124822259089, -1.0935003458337638, -0.13006493017914844, -0.7702686771380101, -0.30661989029337994, -0.24008597179414135, -0.890902703595585, -0.21965791103820323, -1.0130901894249813, -0.06567042529578367, -0.8558384032227331, -0.43228244746725414, -0.8702968605694354, 0.06094350100951594, -0.8309895484800216, -0.6782783073350365, -0.43529741775224684, 0.09204153647038013, 0.35269162905044565, -1.0489788174983505, -0.8286590884575904, -1.2632502950209201, -0.6861030307983178, 0.012222000637971379, -1.0766517738537427, -0.1490563030961907, -1.1847741811364856, -0.7982919316302233, -0.8415426195017542, -0.876353592453999, -0.41172436175138527, 0.18846480681226702, -0.6168565782325484, -0.5230385632112748, 0.3330489944596636, -0.44551912252237696, -0.7583005894457046, -0.1453000776031115},
    {-0.2844753179687818, -0.8532322650151006, -0.5992805534918715, -0.5782247146712683, -0.5922063144944352, -0.30158654494854525, 0.15685759449197217, -0.6079337815612588, -0.7589875284193032, -0.285383309876546, -0.8726505739527267, -1.2556040060305664, 0.6230204249287006, -0.7221257723796789, -0.8151552968851339, -0.4122442312239734, -0.35033022767706506, -0.8071200834697455, -1.055441182593615, -0.18160214926002907, -0.7834465888140758, 0.6004238799011938, -0.17736764975974253, -0.9618546552590966, -0.5852890485023716, -0.11758967331767158, -0.5179142086042938, -0.7555821066801662, 0.028515507973576795, -0.7676006537454113, -0.5698493508707828, -0.2695091785656961, -0.2932330148524187, -0.09048273152624742, -0.03431955216837243, -0.3430212519677779, -0.4637920637895293, -0.8026535395092728, -0.5278511593044117, 0.4659563595817989, -0.49564630403157783, -0.749088353411778, 0.2477012782568787, 0.5915744317980454, 0.5729731617968085, -0.7568286435671869, -0.39788009640194527, -0.8343945029154524, -0.992535940483245, 0.18440410126559945, -0.8980792152047378, 0.21785685859427928, -1.0452303187302714, -0.30698257894816183, -0.9458799732018808, -0.8898576915634788, -0.19262706742170366, 0.5380477614870497, 0.0035540493491599545, -0.10343439867765669, 0.4972738569491831, -0.7728434910501409, -0.17588650749303433, -0.31749697461246124},
    {-0.7899646940976658, -0.8884622159327539, -0.5455457610887897, -0.18677607007633157, -0.3049335854868942, 0.31543935034830994, 0.211458279904518, -0.36736759763054505, -1.1598677370315993, -0.8430888722101545, -0.7292201571887972, -0.7138832536251855, 0.6872451195369083, -0.8197621635255032, -0.22348784825822324, -0.4756455715606335, -0.2410332602959089, -0.2046196376884703, -0.37828555314189993, 0.22212889899199087, -0.4798103760415789, 0.4204836926444259, 0.18991722818758708, -0.3616534578329381, -0.618290471092685, -0.5829762806220075, 0.03464055121076987, -1.1067562576495036, 0.07204654084237029, -0.48072774059415596, -0.049085775271712304, -0.2850721991457608, 0.17895276600083268, -0.5395290007520529, 0.10694692650547084, -0.4841608551737433, -0.4286331001863199, -0.09847338615010477, 0.14262686952769113, -0.17682349364593605, -0.3652688040267625, -0.449464502874072, 0.3950372290886855, 0.48187263031520067, -0.039714707783013066, -0.9787960874935211, -0.36615692765114394, -0.7439754353018105, -0.10705547252007747, 0.49321731642263333, -1.0588110319058022, -0.4461898677860256, -0.2083628215125051, 0.2509332424954658, -0.5896942436306939, -0.8112087878296652, 0.2432317102203876, 0.48918976897087285, 0.08666154166316689, -0.483858475058513, 0.00971076144500868, 0.38240286119957867, -0.5934243108075177, 0.3913794290803738},
    {-0.16778041885884604, -0.262678224511491, -0.6100988815342862, 0.30508006137225824, 0.06623838225914845, 0.6437455879284399, 0.3100422653848999, -0.20957951023506485, -0.8934698817458925, -0.5883123183940787, 0.17813936161879695, -0.40354387443162604, 0.7277955081507638, -0.5961717403218088, -0.6894691653505883, 0.06601553676741691, -0.2880121221218024, 0.07869590058829998, -0.29004014248788235, -0.01685021164243195, -0.33580645924087726, 0.8371106246584448, -0.26937708143661626, -0.11261928873155781, -0.006938695222537822, -0.558423726753238, -0.2162250065224793, -0.5754295121172592, 0.6427296136692369, -0.5898671871326526, -0.5149656199217328, 0.1616361969642436, 0.2908713574288056, -0.5652712370184286, -0.014949690039800395, 0.36288527457561387, -0.020572958548309067, -0.07198266240699629, 0.4265754590791837, -0.045450766338949546, 0.04855195453875774, -0.4238423692958854, 0.29607294126306977, 0.5686660887412756, 0.07446201292797369, -0.5104007037530585, 0.23519472261117083, -0.4624890125381744, -0.5273102486887322, 0.4636577485506727, -1.0528219377326593, -0.5011393324096143, -0.8190811439868376, -0.35999806001951706, -0.006791108612498426, -0.6378377830993206, 0.15839509616058184, 0.39813681053796635, 0.6683511877704756, -0.21783637201735803, 0.23370361604069817, 0.4722262583114378, -0.5164033037042851, 0.5429921904632196},
    {-0.18666217766655202, -0.2941565280946087, -0.3760004882845467, -0.28284594232573523, -0.3658408252095706, 0.38162665900907083, 0.14009530307615142, -0.5583344175184924, -0.48689797275164914, 0.1068651532406116, 0.1741928749751259, -0.4914530830159139, 0.3350178210828542, -0.5966793000116191, -0.05458461292212731, -0.47919016114460217, 0.2600905052040813, -0.1764577901474974, -0.291469958142619, 0.22028608727378987, 0.023872130846971425, 0.3750610880290322, -0.43878065294110635, 0.08372326075540505, -0.1783234271563702, -0.03347234046768899, -0.46413290364514864, -1.1476190576440861, 0.04367070191928788, -0.336061807587213, -0.2946489399071996, 0.3048511826155368, 0.082375097087232, -0.2940055190421462, -0.17758798279265425, 0.2827436568429709, -0.7320982174877644, -0.1011099021368457, -0.40476916837160026, -0.0010255392654053995, -0.32488547083848685, -0.7084142240903054, 0.7155287369317813, 0.7940153399106666, 0.7042654712707075, -0.34455138328718626, -0.23145892282497726, 0.09081391716221392, -0.49974065306668514, -0.033980623300367434, -0.5768292196167977, -0.08434380151855793, -0.5654170260730744, -0.016560383263724183, 0.022612407590772852, -0.5306579013742745, 0.7125132392119, 0.43880321947313966, 0.6606229814076994, -0.17672515479110634, 0.5007636671482264, 0.15740565594750092, 0.44386429341216876, 0.372005252553067},
    {-0.16784049582092592, -0.3152622082649137, -0.21151834181753487, -0.11874679985458748, -0.18407198554651602, 0.2582648874930945, -0.04588007614630252, -0.34784780813480026, -0.339957471024795, -0.1813219408221641, -0.05601774824564761, 0.21385690860907153, 1.1190483414503818, -0.4823826540388493, -0.2018941587479254, 0.20783826440878056, 0.7541180285515844, -0.8248743955997011, -0.5115859827383812, 0.23656455162872764, -0.6935635791258202, 0.7865361830037365, 0.10566664826083164, -0.04538987978326252, -0.07419468329876706, -0.3705443334530158, 0.4374900762574193, -0.8840082182599578, 0.5817695319821296, -0.972321269536164, -0.08727204052414131, 0.454061182490085, 0.2717140729577468, -0.055115809344201315, 0.31062755150486343, 0.6708017000673642, -0.12878663011675065, -0.3921379433223468, 0.38531324964351704, 0.3238200753649347, 0.08705805525363791, -0.5077237292347289, 0.48762632779651754, 0.30874777496156086, 0.2357883801605013, -0.31932924130125456, 0.03455080572712706, -0.5080237990516242, -0.302754776381957, 0.8680615189790805, -0.38589546845526884, 0.42701322396936275, -0.6982684539603927, 0.5553133954214222, 0.09815712540003801, -0.07389628864368736, 0.6872018870379996, 0.5096837063790574, 0.024854795816830016, -0.2807376409953896, 0.6383270422970111, 0.058937947597604026, 0.17193907792614754, 0.30320605744562457},
    {-0.35837488149834823, -0.037979492530996556, -0.4293063453483307, -0.03559862442975586, -0.32123092715957136, 0.061363174360492455, 0.7429903819229596, 0.5829863572649198, -0.5870351922345695, 0.13810611520169253, -0.13196030559624794, -0.6897537335908652, 0.37125271481369404, -0.6702143392384236, -0.15437412373716378, -0.12998927499943747, 0.5164355770989411, 0.48801365566364124, -0.6767819665024957, -0.17503735948913032, -0.08412919561529983, 0.40929267867732033, -0.016055232562247276, 0.28525593845683384, -0.6099220784652318, -0.00376279410542904, 0.1415430600211359, -0.42363929310632314, 0.13081202211339904, -0.1120385288856216, 0.19955807650359228, 0.27745981465375563, 0.8609747271166625, -0.2458932312664633, -0.3277934579427602, 0.48414293566352923, 0.07304990262721532, -0.44392547094659374, 0.02406352438765573, 0.49251598344647124, -0.018943550552436014, -0.1411814233638027, 0.36239118209654103, 0.8649940116257108, -0.3787506257043106, -0.3664849913725481, -0.1621632017486273, -0.11987424631278097, -0.22123699802618496, 0.3700683543427027, -0.5103091407748108, 0.18980088560650843, -0.03556734148298814, 0.3407573108366141, 0.05480757431749207, 0.07351407450363957, -0.4624510069804445, 0.5933100013133626, 0.20528569041583972, -0.11416037924420312, 0.8790626348789209, -0.17443467973860982, 0.00956991004109154, -0.1001806442005064},
    {0.25323949238512333, 0.08585234410066885, 0.07472502062418339, -0.6056670067935661, -0.2757375461251337, 0.23889001945371952, -0.32823266289885156, -0.29548447147662765, 0.5823203521648533, 0.10363926936675252, 0.07824935957215, 0.32137727828249807, 0.48016920037001737, -0.676630290116066, -0.2845000108215485, -0.29445440889648783, 0.6313120324959415, -0.17491232197970114, -0.6286734609557256, -0.2730034253370953, 0.13531898128943146, -0.14998115646350457, 0.43744250197820955, 0.022947042336274894, -0.012221714760471248, 0.053354740368430374, -0.4830273111849402, -0.3619365481576042, 0.2894185048936477, -0.5863967132740534, 0.21906256867737817, -0.7660800337168864, 0.43261378947751306, 0.5096472937259983, -0.15703025761235523, -0.19616059787601042, 0.7168123298542305, 0.5021652162999769, -0.49796305377556677, 0.64238946407789, 0.502781433822638, -0.5249204370496895, 0.05458162599566104, 0.1815507581779116, 0.5283000184266486, -0.2946953647706348, -0.054178063398896005, -0.4657720805967625, -0.6057674637602134, 0.28707264333640153, -0.6971223935901394, -0.32435893953975675, -0.16566413520006418, 0.15215453156193404, -0.09961604116453025, -0.008557551408320895, -0.15934771104615247, 0.3238837430797659, -0.10915278310834628, -0.16906828560033893, 0.5401471711098632, 0.35314986540540305, 0.18321474081974104, 0.27778664463816877},
    {0.10378267105292593, 0.05697555370587379, -0.2186761765176925, 0.008186064012312465, -0.18333506947746223, -0.2665203255505723, 0.2176721293717955, 0.025737248485172313, -0.3557784289077527, 0.6946462063465805, -0.6369481559927267, -0.33394841023307875, 0.25434143590549363, -0.07392746589352363, -0.5924931438963935, 0.2761557647798656, 0.8814960953993155, -0.4420505336300594, -0.575835215700813, 0.35297415318940106, -0.3323835022825433, 0.21684208111092698, 0.35562350958081995, 0.430807652699312, -0.6341775872185889, 0.14275724345975144, -0.5871996000067216, -0.5237276266626956, -0.004655797373567124, -0.49081754880069456, -0.5164067407011386, 0.13408651774189762, -0.42252200749520386, 0.44557788179244356, 0.07317854372743042, -0.349118457022238, -0.05148480448089422, -0.517071433981791, -0.5168955378218102, 0.5932056364538569, 0.2978673344848767, -0.9720331958075539, 0.06444360253770373, 0.35747572471638756, 0.20334213473809895, -0.10114683159430546, 0.017047961223683943, -0.7902906819782328, -0.11862488045540645, 0.5485623242893666, -0.8283912358768852, 0.1569982056678396, -0.5914441709777593, -0.5394804056375965, -0.2928800235120165, -0.537974963532608, -0.09936413854139471, -0.22431105326312667, 0.505546839973904, -0.34477803463053774, 0.5783067533721228, -0.18730556636507753, 0.5721834474861299, 0.019339407462566554},
    {-0.1745188970032551, 0.2873564353931802, -0.3181534146511313, 0.1163672785573526, -0.5209251705756472, 0.25339508116826465, 0.419372067585206, 0.46561225542134926, 0.18109402413160422, 0.5659475187210433, 0.3535259662660259, -0.8877364892801584, -0.24710675713818053, -0.5110457543904006, 0.41069998685329745, 0.2165433027556379, 0.7015825118394836, 0.10193739715044088, -0.4177074035993763, 0.42294186430830316, -0.020663530669663505, 0.41871268715832655, 0.5166916434571476, 0.06695928426119249, 0.30019077664513427, -0.15392549456026566, 0.299195929471834, 0.2703746059413773, -0.046100053706599205, 0.18664978535693752, 0.2241908316355032, 0.11050054504129557, 0.26559988448628435, -0.009354818221707077, 0.17032539168105762, -0.26388947053401224, -0.10981042280566888, -0.37230355047829783, -0.30580967900744427, 0.24382178914479416, 0.12649430555042498, -0.1390062958935403, -0.1753463236879623, -0.03627203572019624, 0.04710412786596776, -0.3588575390631208, -0.4962480541994455, -0.39497893542642754, -0.24516599321190613, 0.28446629401312634, 0.23416239112648077, 0.07086893522444607, -0.5689653907447595, -0.4901657587786084, -0.5800709162619134, -0.03432377906293551, -0.14020015227405733, 0.16812754318014267, 0.31685278576945947, -0.42818990847115135, -0.2036585430791241, 0.3235298489683389, -0.5401880029250868, 0.29195876962751965},
    {-0.6579238722750875, -0.33943833987159666, -0.3325979267937117, 0.7213452579698847, 0.8131761807773905, 0.44023855036300014, 0.7314983263702236, 0.00795557274097168, 0.4514027935116225, -0.034744934026724704, -0.13190678613717538, -0.01345255148545487, 0.33469442351784406, -0.032476161434558184, 0.4928543635887142, 0.1389855044728218, -0.11057648691874478, 0.2600166094079876, 0.09168280434178484, 0.14637650583660441, -0.3287327688735802, 0.35129435417087834, 0.4704944913256087, 0.21016917053189002, 0.06367218684333796, -0.35119235282764877, 0.5318801341796623, -0.31485749283855147, -0.5887906796853113, 0.32761387733244957, 0.5383845469442875, -0.2581478501060716, 0.3273430511583947, -0.12903475730356861, 0.3926808037469587, 0.6988106881814973, -0.16679258718041848, 0.34166304880875403, 0.8866293419661754, 0.3262010480706144, 0.4231372866685625, 0.07844358616059917, -0.19541486024019444, 0.4443961963775722, 0.12359455700357025, -0.5925423662310467, -0.8693565970233991, -0.41561182571917143, -0.3003693580098958, -0.1462982672995255, -0.3852940641289367, 0.42345443981157294, -0.053655290133348896, -0.16474344563969395, 0.35696430172975385, 0.3255522604425497, 0.3323080807892446, 0.45647515444111625, 0.6008421677135994, -0.5821070288795109, 0.2330366681822714, 0.6982202786633541, -0.15769303004918167, 0.2558923126264207},
    {-0.3196433300231935, 0.12504000007067317, 0.16522796823116223, 0.4190359399092051, -0.2941837559709628, 0.545810261209922, -0.05132844123505345, 0.2084066559442157, -0.2917384956149492, -0.045237498420935836, 0.16294497367582622, 0.09051452960685046, 0.15738247524220725, -0.3987528511216034, -0.27875487261591764, 0.037550511764808045, -0.07954114153143714, -0.6764597034446675, -0.48602566773989414, 0.42095366612845264, -0.023644721034817913, 0.4313102819787317, -0.18238301365364562, -0.24643015545247807, 0.19333724557847898, -0.23187888965580825, 0.43211203429524003, -0.04117085795781615, -0.14833346485095655, -0.15215588458726487, 0.11543152584372679, -0.09638767031350916, 0.3640812889246488, -0.5621780388705275, -0.33375462709932446, 0.20695109664401393, 0.436584956422553, -0.40085079561466347, 0.8009177327286322, -0.10270936532580899, 0.21830341181381782, -0.3426178751787111, -0.1714003042616359, 0.44358910045892097, 0.08849978246890518, -0.6881027721812547, 0.05574011965147536, -0.43079756039927347, -0.028445136407353445, 0.5224046517591299, -0.19579896397629645, -0.2383970544377057, 0.23174273242199955, -0.25462994822093105, 0.5614145660667644, -0.05246437605671356, 0.08710189999451588, -0.03570566858766526, -0.26876928595086147, 0.3352057497086978, 0.12172874700891713, 0.02320676188189604, -0.4247936428747348, 0.2153764299999769},
    {0.36054180140987, 0.32936937899694074, 0.19096746069629947, -0.2085964490196969, 0.019122775960436274, -0.09262738818020816, -0.5336849399743229, 0.19861600870535076, 0.2943297609245488, 0.06950482345717886, -0.05608035369247821, -0.08725083101903128, 0.83529804863557, -0.4093135487620165, -0.07373896468199864, -0.02714118971583258, 0.22645134212093943, -0.46157283044547964, -0.35825374536010257, -0.4167250652194268, 0.5322033717652285, -0.028537701721363166, 0.5391463423182445, -0.04890895110966435, -0.1174530279603921, 0.09723351931974719, -0.3641751290137555, 0.0695508262512323, -0.006373822253859078, -0.029006646016121122, -0.011876715697613381, -0.40331130600187126, 0.18420645491527973, 0.19016454737841398, -0.35982112266406163, -0.014712782592754662, 0.5499166967757046, 0.28034848361865156, -0.3204688645314264, -0.05453148086980602, 0.11502488013271601, -0.46809540887033046, -0.037110796974650216, 0.41847477487147033, 0.23818184032831302, -0.13636307179420795, 0.5537174678421476, 0.6918527944175961, 0.0019709872958958118, 0.25249100018010506, 0.11648101104814776, 0.19841339686481066, 0.3612834909201803, -0.5017923731459923, -0.3059373449231996, 0.026669402612420248, -0.2505832575868617, 0.559031034865431, 0.09170438602522012, 0.38701506705704325, 0.47363432966018215, -0.46758302224878323, 0.4147326256631496, -0.13157804773896403},
    {-0.06166249756871188, -0.17062724329457932, 0.2583412630483635, -0.13530982567663283, 0.32664381468375586, -0.4872397121465549, 0.38597334294606955, -0.2768141726808041, 0.1247145539035492, -0.3520353770133178, -0.3098808551405994, -0.22014986214278381, 0.29085757741646173, 0.42080344572345413, 0.042249223197486946, 0.21058946498475822, 0.09489449398168008, -0.26776157463127914, 0.41617731039093503, -0.06572939295118882, 0.13116890810547385, -0.23009201068471505, 0.286985776918014, 0.4326681085413773, -0.5576572367493128, -0.133664195134632, 0.10959364095164705, 0.23361758133219682, 0.37274987875769594, 0.012989280166025215, 0.47376451504196543, 0.05382213007107682, 0.11692401786562498, -0.024484077454508993, -0.07708473061398076, 0.17187824775203037, -0.32739448431784113, 0.4335592804318772, 0.3529595160686043, 0.2901012082603323, 0.18310106372884857, 0.3313130947505505, -0.759213097456486, 0.21179316909815782, 0.37386334076354594, -0.052772121904859, 0.15087246721393713, -0.12219715999013686, -0.43789040556457864, -0.7458225320231624, -0.44342407908358156, -0.19748583409154183, 0.0544789105460363, -0.1836434776915331, -0.2116550256064803, -0.12647738440125889, 0.11722791322896634, -0.478262148227249, 0.21275171424622086, -0.30338341936994573, -0.3035742115481928, -0.23024385640196604, 0.3017386477344845, 0.4211993530610133},
    {-0.12708636103523155, -0.45116309208082767, 0.2572686889760935, -0.21224115659079082, -0.4137686460765566, 0.23725407270961263, 0.14156587424067574, 0.3451542967338349, 0.36622621113596593, 0.21049877079416296, -0.09609280340879277, -0.2358839209964093, -0.02341313719534511, 0.08141616527686395, -0.1269532420818938, -0.08321545086978509, 0.34905038344915507, 0.0205815924406232, -0.0845583518403025, 0.3013566062769877, -0.17510652152088818, 0.28463753264203506, 0.6114267842684871, 0.16837697893027367, 0.40046602671341924, -0.1245971432571544, 0.12496695554516599, -0.2812889595267023, 0.4983016118768878, -0.21819637456508742, 0.2387250147518768, 0.47372449513251924, 0.46091867496688027, 0.07039759825648204, 0.33557378915011915, 0.13854827405439132, 0.56994072386622, -0.13435440037332652, 0.1130584908289877, 0.09716198657715307, -0.30529556235498795, 0.32647295474185767, 0.43940810486352977, 0.6333090281643887, 0.3968288461933364, 0.05193993801760264, 0.22524871766547025, 0.09509267455514377, 0.029833753534906835, 0.45357413145604014, -0.17409673924454389, -0.3417382567428218, -0.2112639366338747, -0.025817543881673514, 0.2462944427301017, 0.3452377812445291, 0.2483959170068145, -0.17522043477613683, 0.7015072375713576, 0.41574129076614463, 0.6744628117511913, 0.23657979010662825, 0.13136391944233108, 0.2266574885601774},
    {0.3583260739542693, 0.2153590913112104, 0.3589734759122674, -0.13132667790428804, -0.29794572151709225, -0.13212284023532309, -0.38511200493543096, 0.24843649123448225, -0.3444704537784571, 0.20605499653264622, 0.32850363196396687, 0.13566128253027787, 0.6730878584396642, -0.5223204229471934, -0.5682788689153854, -0.1387574142415296, 0.37880848071459783, -0.5452217899374551, -0.66877332930126, 0.168066283948438, 0.7028365115436404, 0.5001032438463082, 0.2566839132018598, 0.5971696022344076, -0.12300658994639511, 0.2921631306166387, 0.3208067942523289, -0.018564472681797037, -0.0813850199263678, 0.06838622092333554, 0.4944584197360867, 0.22410631110928603, 0.16299243159600904, -0.41992830906275447, 0.25908705436255786, -0.025959303311303986, -0.2788140405353098, -0.0054000919478163255, -0.2680459560061781, 0.2728563793936445, 0.16234452508154948, -0.40276326312386873, 0.3591984660786667, -0.13185414655903274, 0.03382680753275994, -0.507179310648568, -0.18511158259486887, -0.2697419862498445, -0.17925834649197359, 0.060754532043284286, -0.1728564202264941, 0.816953836135599, -0.3190585417908163, -0.5709697891793811, -0.4199194174667523, -0.43491922759410717, 0.0068448359608733605, -0.03931981050088694, 0.4621180512674128, 0.6725099606891338, -0.1197283052037339, -0.5033972799705492, 0.4797443423898869, -0.4215379357041287},
    {0.3621681032736796, 0.25478152527908715, 0.5543460343082631, -0.20446485658194494, 0.6698106619674018, -0.03306152639719016, 0.48974685419391983, -0.5377235572515562, -0.09430246895062173, 0.22437722213054262, -0.6713587647934177, 0.2403056162864377, 0.32292855829703754, -0.23895123869427978, -0.01552736966552844, 0.21426472293034063, 0.15468971017864191, -0.07952144040728705, 0.38913433900165445, 0.11372328014893383, 0.23407752187438294, -0.06207322744316892, 0.6408542313118653, 0.7804583444989202, -0.07792086089495141, -0.2596367244086978, 0.16589475471170634, 0.6478937844100656, 0.32760182068336485, -0.44575891548774493, 0.14347085711463428, 0.33930257512316675, 0.13350256967839555, 0.3627438370184521, 0.5254489088268605, 0.7405810418840735, -0.07202262245087787, 0.026837823410313356, 0.16253149017076646, -0.48286872703630984, 0.20881815096492148, -0.3191652224348711, 0.7646546241940501, 0.12337696253837033, -0.05301806880181196, -0.03970498109079246, 0.07469000247015102, 0.16848901942239244, 0.6729582598216495, 0.46221779548718395, -0.07674418590009523, -0.17980627467243612, 0.028966566434830015, -0.3569982565285261, -0.06339196095812134, 0.3002651519291055, -0.10492656175008176, 0.285502069264894, 0.4573671736947739, -0.18179887832350294, -0.5579676319579561, 0.240561209220933, -0.15669241674342066, 0.4114553569505169},
    {0.17101570588003626, -0.26286069934756173, 0.06227716080414893, 0.6833802623682754, -0.13451452542250103, 0.4638117975271909, 0.2762135159477637, 0.12864879088020392, -0.5959633115447667, 0.3204619653881236, 0.46229229481713996, 0.23057433165605853, 0.09022307575539278, 0.2444110670013444, -0.39800526462163693, 0.6553177965417298, 0.3427322707259193, 0.026808530474240363, -0.7753392071330513, 0.28556331581752403, -0.04733449183932893, 0.07022448350745769, -0.04759985131506577, 0.23029865477556377, 0.24471349966490602, -0.4123701467625387, 0.007452677481399136, 0.16623889801642247, -0.20713639556558763, -0.34242182171555025, 0.4681070561388727, 0.2728014222154697, 0.1493600382042679, -0.6529758254493409, 0.6699521634514944, 0.5840788603206976, 0.030194819416535252, -0.1845489884346159, 0.5584809656764962, -0.6376627679315946, -0.04194474866363633, -0.19496874378865223, 0.7961519712959629, 0.6668309590854414, 0.43114079881888523, -0.29828851559454084, 0.18595060679460987, -0.6586741805614331, 0.14679946322992468, 0.5062800208966738, 0.1636527730901794, -0.4220737896157991, -0.13410568619800334, 0.3007785992324082, -0.251189846290552, -0.23088665561465918, 0.2230958588630856, -0.22574135591052583, 0.8210551710877518, -0.30791531185233817, -0.28688301654811016, 0.6320783306934861, -0.10008574497099694, 0.06955499124712329},
    {-0.21152197278576532, -0.17690841587710351, -0.6559064723434203, 0.4214249253825142, -0.24667047715991147, 0.692619512331066, 0.33712250788812104, 0.33881369060426864, -0.08894015865327878, 0.07898994210050782, 0.7133960872763976, -0.30994487187382336, 0.195514910848757, -0.13991372394002258, 0.5014194443719662, 0.018194167334088664, 0.13645566910722523, 0.2656052940117283, 0.22655540051346584, 0.3399310399228451, -0.55903956667693, 0.3735988175559514, 0.5680035558060691, -0.4089095828022972, 0.05660239713413172, -0.6097894343897472, 0.04629151216961774, -0.20718413471172692, -0.3861025453206774, 0.14051946651411878, -0.20168822807475206, 0.034620030710243846, 0.33807513225574776, 0.006653929700271439, 0.5783892136474609, 0.1355821540810692, -0.2797062606738892, -0.07123614136464389, 0.7015499856474272, 0.010143016793929689, 0.2522466677677588, -0.8394760439829008, 0.5313434927427565, 0.30856083868990775, 0.20459629037495894, -0.5522272323491707, 0.694874336320533, -0.19143974570758523, 0.37151839394131664, 0.29045564593282935, -0.497530213682618, -0.45700152913505604, -0.21055303689818206, 0.13084488366107205, 0.7475561928984167, 0.2142892259945997, 0.19953688498055214, 0.1037971914889177, 0.17335353995885938, 0.06683372080333413, -0.18752629396992926, 0.9769881876115762, -0.12181120340185257, 0.012002200684776566},
    {0.09602265840728437, -0.20526181449348221, -0.29314338290446396, 0.3922123292185688, 0.7832955633157311, 0.38540264383502293, -0.05620436774707057, 0.2778548906715085, -0.5479194990944249, 0.09451743723303994, 0.5364245996778013, -0.05147631451571183, -0.2520141430381318, -0.22644957004623573, 0.6999932747034927, 0.10791430353748976, 0.6114848426643165, 0.39879963105297284, 0.1890164406230781, 0.5927369784298212, -0.4757868180497259, -0.18863686884019512, 0.32199708074868494, 0.38734746055738234, -0.023778071050877446, -0.6911198049576348, -0.36212550725737425, 0.27121333452361224, -0.18269294376631012, -0.2809782631951536, 0.06165246320710071, 0.4129655164095783, 0.3884025845523815, -0.10405678900116207, 0.5729799125544048, 0.15484956858345436, -0.2004140995983083, 0.710700304012578, 0.7292304943609819, 0.13543923703761004, 0.19658788435160865, -0.37290094940579954, 0.460285239636882, -0.177942411940703, 0.14662232406003617, 0.32390441856556873, -0.23178033367678672, 0.059007309639567816, 0.36427431089718554, 0.4427380592653763, -0.4831715524197981, -0.33581688275996163, -0.1124569889941847, 0.21392642253708383, 0.8855306741720214, 0.21586920186589514, 0.7859718181523853, 0.19960256951971808, -0.14480333134469192, -0.31203688571437843, 0.1780176050272294, 0.4642318532604539, -0.08171790609325721, -0.0640873567155117},
    {0.056778628016880474, 0.14193917272464654, -0.5417890835158691, 0.5857984090463002, -0.6488407728548394, 0.3416696660149343, -0.05649625819989155, 0.173555765660842, -0.36469215449801395, 0.521757313047784, -0.1395028284336796, 0.3260068747088948, 0.2219805699928162, -0.5110557949498464, 0.2905707638309455, 0.48419232064831746, 0.5203152579785535, 0.5577260887482591, -0.46011795541806777, 0.5575943381550971, 0.12885138093113122, -0.10372441257830951, 0.2811318507343086, 0.237165880691167, 0.6394955988251269, -0.08462530638395982, 0.7355042164442888, 0.4141547119429543, 0.2740186633833383, 0.17291314213643022, -0.5955088088646142, 0.5082001308863372, 0.4885654304043778, 0.3372373777616797, 0.665698055162292, 0.3727751905468782, -0.3118340528711129, 0.5723763574330338, 0.7624287055216888, -0.8150594909439919, -0.16262262838050673, -0.5043274341506839, 0.5001318815841286, 0.10889818366511966, 0.04290275821909811, -0.2573623532435952, 0.09049854688116257, -0.42531282209209564, 0.09659676016844991, 0.7046022782098844, -0.5532637831344928, 0.374524412612738, -0.10614056005153091, 0.21169746529736785, 0.8605615485829369, -0.08382773874219303, 0.33219697560044786, 0.3214284436332633, 0.34769038643349737, -0.5841809150477074, 0.48593649418572665, 0.6717128656245157, -0.052727080964026514, 0.7732807567605534},
    {0.025368316223572444, -0.6151990107450336, -0.38124972856583844, 0.7991352792406109, -0.06425471782291302, 0.25099812895895734, 0.6808513365890316, 0.6674832382518224, -0.2001874299795658, 0.2495408025793008, 0.47293120158195384, -0.10375056438570619, 0.2949607792950552, -0.5241527334376194, 0.34289917922658486, -0.19450819472269185, -0.03984122784479838, 0.0058873388670797454, 0.12969244454518813, 0.6427314830387817, -0.2272755507203895, 0.579979744883053, 0.5947464058126433, 0.05029924649486793, 0.024752107490978243, 0.15393008008074707, 0.6136990414267877, -0.22759656504822515, -0.7732885611790564, 0.07758010264318697, -0.0032341976676560458, 0.6109348362448542, 0.44527357583555816, -0.17753914475195892, 0.5204392617205893, 0.014705312915565052, -0.05358251061959718, 0.37055622018372436, 0.5876976003319603, -0.4945912521289841, 0.21569810623497013, -0.526225649556359, 0.7171068761328901, 0.18448397322731294, -0.507424030865178, 0.4200452098781927, 0.36553970350868137, -0.7585278214297497, 0.24795772851763523, 0.5680909512036512, 0.29585988219160125, 0.5893548722374055, -0.4603430357295404, 0.4095445623796809, 0.1788684424603542, 0.5043489478999135, 0.0954378261400983, 0.07848026945130979, -0.07239341838494026, -0.13990590211392978, 0.39086749691711314, 0.2737043959498835, 0.7789772615068744, 0.5688311548763495},
    {0.06704905538430997, 0.49804478413736053, 0.3209586087784161, 0.574233755233301, 0.6963588631537714, 0.23470866685463598, 0.7388299200590432, 0.16416859193237882, -0.4104913691864479, 0.4000723507926258, -0.27011041088771914, -0.2886708730103181, 0.2683936508780353, -0.0832095144094089, 0.12656521111089916, 0.04224476813169087, -0.7660206168490166, 0.5515096554267388, -0.8197043861591046, 0.11006988187262574, -0.4121072684082991, 0.28119442959823776, 0.19489694604283983, -0.35271683430001016, -0.3541478688537218, 0.043960067220757716, -0.45498448333462543, -0.3805525905006556, -0.10584872917412667, 0.2123555245449769, -0.007242483762237991, 0.7019043325853431, 0.030332233557674698, -0.44619355558003454, -0.21749978748771256, 0.4593966147273444, 0.45666307374462484, -0.4151185658419393, 0.22723962105785286, -0.18717110985182384, 0.07735671471042177, 0.020580426720575782, -0.03209469656533406, 0.4891980534805229, 0.15744337548305445, -0.5520021880514927, 0.5953879646136516, 0.03108293180140809, 0.22437426666440366, 0.826539972928311, -0.31497699263475565, -0.8188874429530656, -0.6884803223823672, 0.2221555180556618, 0.5779500396680484, 0.06560013102415574, 0.21975768979275914, -0.45298394819532883, 0.1974014789925719, 0.18655219371405757, 0.09204578873956641, 0.06081911465998285, 0.37950727468396006, 0.61657582444634},
    {0.532506904351265, 0.6948916491147938, 0.5229869015693498, 0.21430072482030732, 0.1571594446718605, -0.07708583937334815, 0.14100687738690315, 0.2138611640891409, -0.4653031200178002, -0.048161793079958326, 0.32646149347016273, -0.4212761916502664, 0.1428161702802316, -0.0936346248803031, 0.08222718703172976, -0.46090966689303936, -0.4386275719499201, 0.21757525957560386, 0.3683977456189149, 0.06063108663328638, 0.04263374680890294, 0.01291041960745464, -0.2113917217294257, -0.26653196626599857, -0.04077941326153345, 0.07989436894047598, 0.3874420020428006, -0.22876745003088916, 0.3874411804014754, 0.34396371774820833, -0.07151338709560742, 0.0564311395323067, 0.3005307341618498, 0.36134263777178255, 0.35677730787755474, 0.12756715567637755, 0.5356837756776233, 0.38797325977059777, 0.2701783656525833, 0.11998048758040793, -0.4406375235154177, 0.021760725717810958, 0.36652455899894626, -0.30124855969402403, 0.15154718242409965, 0.38387900612714076, 0.08508564907303436, 0.400289269615134, 0.2056407687068431, -0.21768545503494058, -0.6340239390654917, -0.5933630263365529, -0.5619431219564818, 0.6047602450216396, -0.04173542479157271, -0.49267384972120504, 0.4450422887188127, -0.23865855863783722, 0.20923403013353625, 0.028458076720912395, 0.5442132917576888, -0.16239671225719338, 0.42322535607722644, -0.5209438473503493},
    {0.004787584629774352, 0.6508568423856403, 0.6298512967627709, -0.683749283081741, 0.09131897808852796, -0.06408414410850267, 0.09888416224972542, -0.05505723694593174, -0.19505672227119522, 0.11939142796310274, -0.44310469350161913, -0.48465520923252475, -0.21424760825244665, 0.42732174614213647, -0.05784328828531741, 0.5462635486266173, 0.29523535699414005, 0.22662021536000346, 0.11869497047553362, -0.10686856394095685, 0.2425089113568224, -0.1381935984726942, 0.21736418075167138, -0.26163419138931404, 0.56043866012617, 0.37819295966659816, 0.13096691944579772, 0.24482766089453886, 0.5183558808321906, -0.03179258813925124, -0.10395437016316683, -0.0649649310616957, 0.18967335150891698, 0.029912823613768673, 0.13336975126564274, -0.28186621875640727, 0.4851701458103238, 0.1199627447489563, -0.0942261046556715, 0.07123254959049252, -0.8500944380265482, -0.6953850649736875, 0.3905763034603965, 0.011104700129888382, 0.03705590447778446, 0.252654511900007, 0.12479741957760303, -0.011361443317233365, 0.30706315233749126, -0.4954994633217795, -0.19705473408829943, 0.31390737800873425, 0.4098422379800047, 0.031647982488543204, -0.1390293218733468, -0.6272675030243463, -0.3789404887641976, -0.29668023300347285, 0.4566098093291059, 0.058618402978541054, 0.056826313242212226, -0.009506330194742658, 0.0448609467019533, 0.34389043000330943},
    {0.3493359656430173, 0.010998037872147873, 0.08274711127011312, 0.11014030188987044, -0.14436354111711955, 0.10587435848116332, -0.1937538616251954, -0.31415355510418713, -0.013335156477647794, -0.19309384363338114, 0.1218967443076174, 0.04335568876133817, 0.058443540768412294, 0.45762645562107557, -0.07634024690074752, 0.30520572283985314, -0.05084253602895361, -0.2920587669445235, 0.5828403201202706, 0.5097740477979816, -0.2718001445821298, -0.07154875497357857, 0.22251472087017066, 0.41507786169533023, 0.10856314966187972, 0.1659905236080669, -0.43828866596937643, -0.7094803916064152, -0.15340144582967633, -0.09207010714459521, 0.01860191486518706, 0.06630339074954737, 0.10289099930716215, -0.04449484071694154, -0.5816282029862261, 0.6321276708919655, 0.3634739451581923, -0.30882136752068684, 0.39733521213009876, 0.026432304902461838, 0.7035272268037087, 0.9262342032562024, 0.269631534087484, -0.15991548960042679, 0.2042130697095983, -0.24706545902619742, 0.8789426496669743, 0.151938368539904, -0.12633239001588814, 0.4045790109677618, -0.1842129919514631, -0.7732182841080786, -0.3514455232910453, -0.4757833836335439, 0.7598524719017593, 0.22069100758658614, -0.1452225599068308, 0.33558263395391114, 0.24958604825895972, -0.05040510453006763, 0.4066397199428377, -0.24150376621150044, 0.08388406246646968, 0.32218499578225124},
    {0.20165682472129368, 0.0521072775613398, 0.07043936211262021, -0.23694325312732398, 0.011656364941305154, 0.2606065944352496, 0.024687625620147292, -0.003907590727950036, 0.13027799778492685, -0.463107280186495, 0.06768524430695, -0.6136717544408903, 0.5423014609991882, -0.2965973206830734, 0.20279209290933226, 0.4037305620542598, 0.15184271365124352, -0.355424232157483, -0.25721503009113095, 0.11359658730731959, -0.6731498563442512, 0.7334363011095854, 0.011404274020580751, -0.3594539695255568, 0.34150779267766707, 0.06888148725735642, -0.1583671581751941, -0.15058490272807598, 0.003563755458436761, 0.09535307880043255, -0.3685419440600323, 0.33958943527766267, 0.20646038717651558, 0.18502738237002214, -0.045808040390701944, 0.9451001558186334, 0.29640989532025513, -0.013262882319253325, 0.2967256408217165, 0.4648161957855831, 0.4273506992428212, -0.5676499179064327, -0.02062810691985239, 0.3188790930931521, 0.5535889169590957, 0.2357592866588866, -0.18269474170166045, 0.9041372021478573, 0.1282452157914676, -0.05784765967609397, -0.15648883825903823, 0.20327598217279164, 0.10385422248076549, 0.12811409501655519, -0.03892072185745014, 0.11711769771455531, -0.09881980339945064, -0.3419908104683412, 0.9084912769131968, 0.3252533469905898, 0.3966424803686246, -0.026289000096652807, 0.21280884793875274, 0.1072135485942729},
    {-0.18360333436456014, 0.48340402858373294, 0.1051994299041069, -0.2499314678822361, 0.04225313919329836, 0.38475018395262994, 0.18916003966052936, 0.1162753455218853, 0.14286050974163522, 0.5825049174785044, -0.4187302374264841, -0.09311214690241643, 0.24324949724709674, 0.1559683810212632, -0.037209386609874155, 0.15342144768480945, -0.3953537683340304, -0.023887710109768333, 0.006151632181711642, -0.11639265217625135, -0.2565417942726954, 0.022959381911236677, -0.279075318626177, -0.6674118399175032, 0.2523498257259238, 0.43748491893538727, 0.30855312765774506, 0.11715296979364885, 0.042698793540242086, 0.06804354460525655, 0.03526339116849529, 0.07980857727950713, -0.059184317456387525, 0.6203665710792435, 0.4342712123492589, 0.08321903139481576, 0.008462991579820457, 0.1466134652074183, 0.5015302080354807, 0.5584389643237451, 0.18207075199327857, -0.03302846081345555, 0.5283331697055348, -0.45919941944981574, 0.6068326531281096, -0.1778220259078402, -0.5990243266068522, -0.06390450671511017, 0.15107804497429866, -0.3114133117570763, -0.6341374347062922, 0.3782734580234038, 0.04289342460904334, -0.2414207951761007, -0.3070485675067184, -0.002657292991631233, -0.2722848535367084, 0.6281021237802829, 0.6963010307564, 0.5643860022629994, 0.2805065642953823, -0.10405209393852856, 0.4001289973213018, -0.12083400109275066},
    {0.6968433351593208, 0.5515884278123226, 0.13988886030611414, 0.18851737276175823, -0.2557038194231282, 0.29745730495245654, -0.26221917236637454, 0.33014828799439155, 0.10894884312435685, 0.22283303399276722, -0.4753823383844762, 0.14576469166417727, 0.5637939864492649, -0.10990995611631885, -0.6844783863258647, 0.5035840881501081, 0.6345307157686011, -0.27399660410178106, -0.31629102291164407, 0.5210008544128821, -0.9481062666056069, 0.48759418233746477, 0.7688222389372743, -0.196985123842771, 0.5703724294625208, 0.4656765802072123, 0.6036160304503522, -0.2223819797078259, 0.5005475043799645, -0.3151428758179958, 0.04848357227835151, 0.4978391792137079, 0.5647634947727781, 0.2018532734871733, 0.7489222056298223, 0.7534462508183356, 0.3405142842653738, -0.19268176787822547, 0.12991221500867128, 0.5152621636293677, -0.010106570696068089, -0.06395656371013257, 0.2056409885381636, -0.046425043206081956, 0.6562972283195189, 0.08803038800281611, 0.5717758753447963, 0.6313717859248411, -0.17862952803203566, 0.580487516289495, 0.3009044781486699, -0.17237629760341522, -0.10814741925261254, 0.5517820311771656, 0.041790630173356366, 0.2025279448254446, -0.149670184282106, 0.686723586526451, 0.44598847016450205, 0.6451521429955096, -0.046978933119630056, -0.017069022551248498, 0.6964779614509023, 0.121265233343616},
    {0.487196582194263, 0.048885874260244745, 0.3139325018026124, 0.2554556711530926, -0.09340413999959192, 0.04805239203872242, 0.2362857604863456, -0.14875632145088627, 0.8167659925213454, 0.05694536802171464, 0.25396076408756096, 0.5411593107404848, -0.17763131192560314, -0.41560767121211023, -0.4722397253039458, 0.7117301727622299, 0.4497931165288904, -0.24573256381271577, -0.07516086493002849, 0.7489994703653831, 0.0208310074756478, -0.11813492143312276, 0.00037474199807411836, -0.045679536362841555, 0.4047243821206838, 0.16421664847933898, 0.025042362589358113, -0.05729427890425088, 0.010346581648577676, 0.14066144388654556, -0.09573413826225537, 0.0032205704003687363, -0.3604946818857344, 0.5136245033454317, -0.44404692905585397, 0.5191624368844305, -0.22225354882603282, -0.1093362243163589, 0.19010389738460912, 0.5432812189797331, 0.07169841310311784, 0.4915959964209298, 0.2579491338644508, 0.09469315583161016, 0.4414306622848299, 0.3169049866233858, 0.832547549157467, 0.33682632830297743, 0.38906450451500335, -0.4063872137161856, -0.20350114147662596, 0.2612880849291373, -0.3777303515816665, -0.18990060003987078, 0.03624901471183823, 0.38599241307707494, -0.47641144524902523, -0.33797444676739763, -0.05388309514239475, 0.7499985656023375, 0.5308179527497694, 0.35387940219445607, 0.9771460584228724, 0.15405065771884832},
    {0.32534533698816626, -0.21547763199755832, 0.267256176808903, 0.36440837703149864, -0.12097662869578699, -0.2019877631177124, -0.47055642679765586, -0.20901014401136478, 0.2051320783647349, 0.6879914784366546, -0.2587882176121339, 0.5051814955128267, -0.4161733149293706, 0.0894739455503188, -0.37651967084838517, -0.04597340115312529, 0.1707543750945123, 0.22831934387348204, -0.058729982251868026, 0.2153110180327111, 0.26182815416277355, 0.30014809270312176, -0.34235601386953507, 0.15428195473685874, -0.1518507058732006, 0.39748415514643154, 0.1225532112985004, 0.09110005880036266, -0.014336707436848341, -0.36601199200711276, -0.47180287676365945, -0.2203441214531987, -0.13735601669336453, 0.07660005986217822, 0.030746436432605575, -0.6145245218211429, -0.22774604443602278, -0.2810006486787364, 0.048242196461534416, -0.2491234748064169, 0.0879302358073919, -0.11612868595441189, 0.4351899401232005, -0.08292114973573168, -0.40028541564251446, 0.5327002779747089, 0.6173436854958017, 0.1451702211143854, -0.0034482244816840114, -0.2814510322279668, 0.482386384987568, 0.07594915383926756, 0.028212633792376256, 0.4306692059942232, 0.4014100576095213, 0.051622273838339526, -0.15192663007979304, -0.07103497705360572, 0.933076243370805, 0.039629848792494, -0.20101679649078333, -0.2616691987471787, 0.564678879502326, 0.0017324623190417177},
    {0.04896271010785228, 0.30842403124382745, -0.17684040965263628, -0.28278800208929883, 0.10445620312596225, -0.2887022967777462, -0.437977340082143, 0.07364749071287424, -0.30539525325086436, -0.3915050261687652, -0.2077468134916043, 0.8068349134164752, 0.09117021825768176, 0.5418696701958948, 0.04218304905220989, -0.5649558479273538, 0.32449789406326873, -0.1431905421124838, 0.5084214484547318, -0.10724164087502545, -0.505897793337854, 0.22361220973091858, 0.3223837658633772, 0.0171119829378174, 0.12283744553989204, 0.12439470011985676, -0.6134504665174813, 0.15484052344005078, 0.3172662890315779, -0.05981099699159651, 0.6013418923530377, -0.1369854915387209, -0.13185930171576143, 0.08000643333214391, 0.5251097898348557, 0.008571657635536538, -0.6134408691083314, 0.5674186367508122, -0.4147821932331447, 0.11271480641590131, -0.18260208765905991, 0.6307089623042411, 0.2815892625378113, -0.14715539092337893, 0.11348505518181637, -0.07514944259729216, 0.25595317477006146, 0.17860875351019426, -0.10499514935652733, 0.622848685432899, 0.12318090879380372, -0.311464204668669, 0.0393403880720447, 0.13134497228272646, -0.22733512029827513, 0.05825155467345794, 0.1702148073700951, -0.24792663484851538, 0.17953933883255105, -0.19555345196339527, 0.0813307480281, 0.12269589790994515, -0.23238442203956708, 0.5497114332013693},
    {-0.34418875291261636, 0.5318052436605883, -0.2342231076480543, -0.5173567017350924, 0.4936478352179548, 0.04823988211520185, -0.3326397950285687, -0.44744298788846243, -0.3657657393203531, -0.3352158388288587, -0.09183807952943393, -0.005018315629291356, -0.21366481361129092, 0.0993436193054187, -0.10834404200859916, -0.49656827723694164, -0.2543981290278338, -0.1052055565242112, 0.39452545213386986, 0.08006309913896398, -0.7091691963896974, 0.2043331161635001, -0.09903814247457941, 0.03774085659133498, 0.22232677231668882, 0.03187101248844427, -0.4216998895336548, 0.20389369179574068, -0.6493413553764449, -0.04549081005650454, 0.4792139098461871, 0.2163837156537569, 0.4045119334628436, 0.04616334436864375, 0.5693246280135504, 0.24184628520426957, -0.2932459681890824, -0.3217349639741743, 0.004085763162964983, 0.7812491358145198, -0.6692609766264712, -0.3176677538879705, -0.11670824095739574, 0.3366378071273727, -0.48119343752658006, 0.08515013774663703, -0.7527046786784486, 0.29652663381042643, -0.02484418447503487, 0.06116639131143661, 0.34135309805388947, -0.18468828728733863, -0.6125340770158946, -0.519168554273468, -0.13644812055593003, -0.41317988693066215, -0.08919073083996731, 0.15635603508541385, -0.1337119381257198, -0.23470935708199372, -0.7314322784683962, 0.2841659899237971, -0.10966024707466282, 0.05738773204763189},
    {0.14608946213999127, -0.3972820636024904, -0.14956050165868806, -0.21026708391265436, 0.05506209646796943, 0.48565795122873295, -0.19634335208181997, 0.031837853352244316, 0.41334727727356635, 0.05133070564342081, 0.23947861391156622, -0.14031691264881752, 0.1760587392715958, -0.2787065073178203, -0.8361924609823198, -0.16269156674162757, 0.05001273219939979, -0.14507953188153913, 0.36155080290188374, 0.17483086812994755, -0.16338450304736143, -0.1409802552506146, -0.010752496770540796, 0.030620360779630502, 0.14628916434657896, -0.1441581474542137, -0.15033494798310626, 0.22230515609676268, -0.2664750857478845, 0.41268049407765534, 0.0754212657855044, 0.056396056365183404, -0.08653860277172966, 0.1260052775772296, 0.38451047783581555, 0.08356343771837509, 0.0492618188018558, -0.027105898593546972, -0.028907971603734487, 0.5178913297368922, -0.7934529377904221, -0.35042752430438984, 0.12021156034589667, 0.3958784480808226, -0.05273871974267424, 0.05224113046842481, -0.5684091926594561, 0.3993495138669068, 0.07609638976069966, -0.24605653039409053, -0.16928072719567208, -0.3432553653756355, 0.2145912900625927, -0.5480947160085471, 0.12947117195942198, -0.07072334932660554, 0.005837699681166206, 0.48679131158789196, -0.20683684167400257, 0.40847696135968853, -0.15674975139001948, 0.12766653466223923, 0.03648476757429113, 0.28988247024523905},
    {0.0590805293405436, -0.3015946416710377, -0.2887919124511105, 0.0063589958789591495, 0.01877368576062509, 0.11943874296233026, 0.3213616416895723, -0.3972087946654274, -0.1398036355072935, -0.10068199381961092, 0.29670564773449687, -0.19438628849990397, 0.33631545955291037, 0.05528489253304131, -0.33972368087905497, 0.35052874510120696, -0.3882034161890276, -0.22597189373863896, -0.31026525433042584, -0.024411358976318624, 0.014349969238161557, -0.31516224432744067, 0.08563949693110691, -0.4481894480674639, 0.0767603362701158, -0.03281459430671633, -0.3545904459061607, 0.1450411366555677, -0.3575660171268847, 0.31976970764393925, 0.07235273862911423, 0.3973789315333853, 0.14869494114364668, -0.5925197352353363, -0.6838927984437432, 0.41766972331962876, 0.20499102756503404, 0.4460541803612405, 0.05439391287942594, -0.15433421776297146, -0.11146393400054007, -0.4175636375804969, -0.1015693348356982, -0.41116936277818866, -0.0246712930327598, -0.05093149448386851, 0.13600749074859897, -0.4171058731804555, 0.26241868628116793, -0.1386255273221197, -0.03483738148184863, -0.5140268959634257, -0.08521861475915295, -0.11824569590540489, -0.4132886378877833, 0.38981890656901547, 0.14917575157173382, 0.2029672041513564, -0.503153466317734, 0.18911456289858583, 0.7251471316315502, 0.25611424885592227, 0.5326461894653476, -0.29798477812122764},
    {0.237688515253467, 0.02618177572624087, 0.12870789955957943, 0.35857284377038245, 0.08646720399132596, 0.2410558714509536, 0.17544547749505227, -0.1743008991985239, 0.012626245563179322, -0.01898814555419286, -0.050385756113980655, 0.23212231367998637, 0.14718307128000913, -0.01766437849963805, -0.1273092322432738, 0.26616310398830606, 0.0522039104390612, 0.24493840594585561, -0.6421033721329611, -0.5151700200170916, -0.06430181579726754, -0.3257763649135461, -0.0898844714118524, -0.4154659050528933, 0.22091493982239507, 0.012276242390893878, -0.18091301955444186, -0.27967396456077015, 0.17714867959570596, -0.2657055764450829, 0.1679329382869035, 0.22922725376923744, -0.20103780874243848, -0.4251847375837175, -0.4806297899694532, 0.36189668994602286, 0.0019165282773171929, -0.2625759413082784, 0.1599464806252234, -0.29556845928433456, 0.7064826243212234, 0.23433790529713105, -0.26045393514490356, -0.14788438120179082, 0.41168512149727754, -0.04537416748418584, 0.6028661161211999, -0.07072846111219296, 0.35981215244866727, -0.21780866788890552, -0.7985168544608409, 0.17644631698384244, 0.1383429616694403, 0.23681321442252454, 0.28482548288265813, 0.3774246698597383, -0.24969120439324533, 0.6119160746592449, 0.2733678327829386, 0.26371996404777326, 0.3934156643731989, -0.19698468044551878, 0.591415978170394, -0.2782294879675108},
    {0.2777816906975786, -0.3578602850459935, -0.23063981163674105, 0.35156087905360606, 0.29876718176991246, -0.1863082313004752, 0.41995522439071065, 0.1742232022738929, 0.06301160081454116, 0.06313103642891157, -0.29780755746042037, -0.2915408739387896, -0.20644166982903514, 0.06528315002690234, 0.61938511909124, -0.06270496330788114, 0.5077016093831637, 0.7260759325761788, -0.42323971904193675, -0.33260391567777303, 0.0780863205435276, -0.37309677695264976, 0.5155935077532557, 0.13095297450184729, 0.11711188251165058, -0.49909936821831435, -0.01384812983892125, -0.3146629400802618, 0.04961472576096526, -0.23120015155765464, 0.07310065657897473, -0.058669811819586824, -0.3965889475546065, -0.0900332656259254, 0.39038034770826086, -0.2638558062881534, -0.03904238653228507, -0.312998811244317, 0.04452404189226537, -0.25702389240210144, 0.6611253927264708, 0.0018827661384030034, -0.5891567740047544, 0.38166973661051695, -0.3786771589628581, -0.10227925399794724, -0.03988862844633718, 0.34997637379068075, 0.5812361510212096, 0.2560566568549174, -0.4047218186589048, -0.04556487122552358, 0.17158154034339507, 0.059765513702406244, 0.12539668820414349, -0.44417062483041286, 0.29646102284149173, 0.5606965433489536, -0.16221752101473327, 0.1371844954154328, 0.03510154192583253, -0.07116897544374938, -0.15524735345145035, -0.3891134902879165},
    {0.09460487419547206, -0.17413433151153568, -0.4905064511644259, -0.14927905198275002, -0.018298838201523632, -0.6935230387622903, 0.5521092248732288, -0.20318440755445766, -0.3231263095554658, -0.00015169841398723896, 0.26910248519559904, 0.3038399327945275, -0.22846467702919007, -0.029916375540813476, 0.5097096544791699, 0.4410755730557341, -0.3930483965573336, 0.12613209582088566, 0.03188256932067898, -0.2502438929936708, 0.18259689519193056, -0.4153303406045532, 0.008671369929229455, -0.04230816728096027, 0.13787236536748118, -0.33224653773927304, 0.09667884497857324, -0.2615568981355207, 0.38834216570853813, -0.12503037894644173, -0.7270421262967962, -0.1343800152540958, 0.04478188595666798, -0.23427864634922696, -0.06486850043087528, -0.4393212508679636, 0.04017526173176086, 0.16794505172602056, 0.015943408282074162, 0.3793303255510715, 0.42991283158666876, 0.059887597126114495, -0.382815134080467, 0.5789909125894036, -0.24860388187459898, -0.36118036846737733, -0.4469475142011076, -0.32283789500741217, 0.06164226120120419, 0.4199826261507127, -0.16856915125682725, 0.34038876378739064, 0.6530083973790454, 0.031218717553419824, -0.0985136912673698, -0.1444484383440072, -0.32318412968769417, 0.5176758264601539, -0.04527152976048834, -0.28960885396036873, -0.17573951694686957, 0.1029834271492737, -0.24106807833552313, -0.2964614052128213},
    {0.23214886829727077, -0.016993229737974742, -0.06559605381232576, -0.3183357946084222, -0.053833047183974546, -0.3777448152899295, 0.07272144469065064, -0.31501517431556864, -0.23152272580050137, -0.4505310655372456, -0.37522128741783617, -0.5051743262243836, -0.021421949444142368, -0.05305504782358508, 0.2661095195881453, 0.23279272433280332, -0.5273572835006147, -0.017653839476387496, -0.4430977343237281, -0.22406719018662535, -0.07336630979553599, -0.4678442526228787, 0.25843013131358367, -0.006140668071724904, -0.23270633524006784, -0.011183410352208609, -0.008729579360974802, -0.42685191698671265, -0.15673365288793564, -0.15499403896179637, -0.729311152465959, 0.3965088047184477, -0.367906163962363, 0.32574487651333894, -0.051535366745966, -0.1403354868725332, -0.07547065864835947, -0.032331862443885216, -0.02353370063976475, 0.3453510141943261, 0.016802165464139075, 0.2795216754380067, -0.42667065570567153, 0.24240007763071966, 0.25485390715163303, 0.0749895471368069, -0.58502243917545, -0.0953866076856337, 0.19584993445653662, -0.3444906632527316, -0.4271954674897223, -0.15512218783838846, 0.7139184949331727, 0.2772351964487165, -0.10942336559884404, 0.05215646155277249, 0.3310547454870086, -0.06469203533619568, -0.7300355518166863, -0.0724550301599764, 0.042775499934697425, 0.16522128322590493, 0.01042033708558337, 0.19679945087593337},
    {-0.10157551879050031, -0.1953926549663277, 0.05550913888915447, -0.3736760806666177, -0.3189380958949644, 0.060235379218822466, 0.03289760643429409, -0.66710910972984, 0.06620427195642341, -0.2974303131389332, -0.4448800059392406, -0.5137984532422556, 0.1146050498152865, -0.30650602725430903, 0.054204258487608306, 0.1451776472474482, -0.14622463691556298, 0.1088336365139157, -0.03011346730722855, 0.191724710308792, -0.03276229627601455, 0.3549845161638665, 0.029210418493345845, -0.33713484151026607, -0.36412833507464143, -0.6221673482555059, 0.22920562556102714, -0.1402228922810166, -0.07493814050866485, 0.297882003332135, -0.38942553918512346, 0.383370031223883, 0.1871831050552763, -0.37941457841033, 0.16347352182034397, -0.21652067560894617, 0.17584318308197408, 0.041280908096468436, -0.004818435067547505, 0.43183783163635553, -0.40687529282934726, 0.1905782235008973, -0.3013308333867041, -0.03550655670189783, 0.4798426282462067, -0.1478727221863227, -0.48029913841768856, 0.5475505487421394, -0.3307776676986468, -0.3737603160907215, -0.17105862385740692, -0.3565651289300694, -0.38296505490671984, 0.45100488432973546, -0.22112997338665163, 0.2993452918048195, 0.8528828152904286, -0.09709474061926691, -0.161119044614291, -0.23020832901161, 0.2952793294563046, 0.27629307547958754, 0.17447364322616013, 0.3415977873451544},
    {-0.09999611421343574, -0.16739333698050965, -0.026117853454391465, 0.6579625309754372, -0.021613466690617936, 0.14270393104304083, 0.005415815925176803, -0.07231188889796646, 0.0194393081741895, -0.13311218280000986, -0.1531500095244783, 0.3205355660283183, 0.1630921350294707, -0.3046409434973557, 0.22821939793557325, -0.198171177783218, 0.30161418398306794, 0.25896229460532394, 0.05470140811654931, 0.5143226943502163, 0.15163742520824092, 0.3703977174084656, 0.006514439939544944, 0.09755406601438658, 0.6026380665318865, -0.14641123408479848, 0.6246623300675911, 0.13757221605305656, 0.6051812661475643, -0.47274204185174984, 0.24446165162601546, -0.07853207616230934, 0.5579117580417828, 0.011800508563325134, 0.1573987579566418, -0.13471341404558396, 0.634140185139237, 0.27118229785831927, 0.011017348468624875, 0.15545936360567067, 0.011410027076944242, -0.23667411460359858, 0.10240447354109371, 0.05064280698219294, -0.12876578317743467, 0.14794913207268945, 0.14757203953087733, -0.25067504316426814, -0.5061477482141916, 0.17023885565905722, -0.14693137455934033, 0.38780908861214364, 0.06641491601730028, 0.7822171336164362, -0.4576286336436062, -0.07755675580762075, 0.04015773723463476, -0.12327645225218788, -0.31822553809699833, 0.03077036919357025, 0.29053590980188554, -0.3060573045024196, 0.17314603462970887, -0.2643182681991783},
    {0.14092175528597042, -0.37923577676390974, -0.09165282328405992, 0.6119252582689848, 0.4090241781089808, 0.25920895767141827, -0.052658488945000116, -0.12424735270693514, 0.010127690662290962, 0.4070036921082808, 0.06702191591341325, -0.27033115781612854, 0.4039222131971812, 0.033159180072712395, 0.2516820346206363, 0.07991979436697469, 0.26197090039931, 0.3134649424099591, -0.3540504804806279, 0.5785045825246004, 0.08765295569106475, 0.23713978584282183, 0.04394254928368777, 0.47155253039505857, 0.5787805011776251, -0.31824430237072265, 0.6776256866850363, -0.1680450927938332, 0.1354983092190128, -0.2567819521197022, 0.4202070345064302, -0.009339934707625553, 0.16431023495893396, -0.2301577698425216, -0.2165970963085586, 0.46023418134705035, 0.10628313295463006, 0.3297314750099412, -0.01863182369152624, -0.030998513396350354, 0.4656738303628578, -0.5266777811697202, 0.312759649634562, 0.2333490188181909, 0.012326658984396773, -0.18086633775600672, -0.22663376181524314, -0.48773744313048395, -0.17398697986650027, -0.4417178537964189, 0.13849462409662058, 0.11037227346069166, -0.10139906084438283, 0.25234123809182113, -0.030917853556407294, 0.11745297206317132, -0.12587787697166006, 0.0931914055482955, -0.5442022568728389, -0.11142233461342149, 0.2722528647915649, -0.07589533892367314, 0.17142560121965555, -0.016924048556096985},
    {-0.199218162028659, 0.1893034002029069, 0.4998054631344675, -0.20002959980155377, 0.16060830714186122, -0.48081346101815775, 0.23620438775373281, 0.48370323736107634, 0.25050182612515826, 0.15505599157756644, 0.14247651539288406, -0.04844784896009104, 0.004861877958414737, -0.4294746467320263, -0.06493989449573132, 0.2784237156840367, 0.4172817349947044, -0.19686871809173379, 0.03467027594538401, -0.24887040686814144, -0.37540655512626514, 0.37909548814337307, 0.05750288682647945, -0.1268831936205245, 0.6992875933295295, -0.10941001963419444, 0.19547929201670622, 0.4628569035680256, -0.08527774197543486, 0.3918439295623286, -0.10080430648406452, 0.27599716688340914, -0.34541698903558393, 0.11522002488124038, 0.3146438286711139, 0.43189841874924445, -0.36918164763721023, 0.09059596773983242, -0.019615782899852895, -0.4020224502912191, -0.023396696901993662, 0.2095979421218333, 0.10130089804585175, -0.2326911622275587, -0.21436140226737255, -0.19988344246353737, 0.3192854491122254, -0.14112779488555413, -0.658234765038726, 0.17862477611658578, -0.36726655613868486, -0.0843445753263577, -0.7100186608238823, -0.45954433277048373, -0.21302779169160602, 0.3244897763125508, -0.03466181970403971, 0.04209942144233567, -0.5914289011388291, 0.19872796196884313, 0.648570914164765, -0.3721529700844299, -0.43997300252401844, 0.4828140551431401},
    {-0.6716397699609833, 0.20187337223169172, 0.2376382308698769, -0.19049514402175122, -0.3850473177358879, 0.3183516232637469, 0.011209707215257422, 0.8950540394999806, 0.08349058412007412, -0.5267821582016458, -0.2851741058383518, 0.12695682736498548, 0.578137053100149, -0.03380993238000564, -0.15755747044154392, -0.200532086851545, -0.6339897109658054, -0.6041170420440125, 0.1298292676906436, -0.4385695446979384, 0.20331190799796534, 0.3229732679898154, -0.5149986185607092, -0.32976207605682933, 0.03552932471903971, -0.4175504237380306, -0.6702582657307614, -0.05070407336275055, -0.15331205032136175, 0.04937210213869027, -0.10418484244280186, 0.36359323063782545, 0.2102145014737837, 0.09121112486854152, 0.6172606889193285, -0.007151076349504245, -0.6097193585574523, 0.18464228514900818, -0.20708019433206248, 0.09790798608677836, -0.013552629091328011, -0.30108959991934064, -0.2861272249462903, 0.029428376339913905, -0.013403381513374526, 0.28535102018526337, 0.21474268917521488, 0.2726725240648089, 0.27265167166463317, 0.2621316415877169, 0.25535159782096156, 0.0035139235894054792, -0.02863018120269468, -0.6951392350833765, -0.325285919422565, 0.48336094016595404, -0.08860990045284005, -0.016754942822831784, 0.05824718104827865, 0.5334979744050025, 0.2883366621084654, -0.09667237732687016, -0.06178105435474036, 0.2638825499405506},
    {0.18012481645684356, 0.41842528910012344, -0.4971150655257239, 0.2733788441753805, -0.52100731447968, 0.675638860926139, -0.27927243613708946, 0.36536181315295085, -0.3557390731098729, 0.11592990739615401, -0.07698352543886518, -0.12791007458987355, 0.35447211500978454, 0.21753840478298994, 0.3183271279764634, -0.017918640626006413, -0.6686495790551473, 0.2170361365501385, -0.3805914061919095, -0.35262669091523735, -0.20782713661937144, 0.27348529145605954, -0.10182798255516665, 0.19438023604530483, -0.3935228474337076, 0.2883730494657747, -0.38421976335272506, -0.0990800166872592, -0.035561772828545606, -0.18441608313184282, 0.10188678563938627, -0.2887026771750614, -0.067839114544839, 0.14932157585473518, 0.4542988444632698, 0.20947884425350205, 0.2603891003891829, 0.1410671674078929, 0.21901830671519237, 0.040072184731301884, 0.15655688426285336, -0.2849246067261531, -0.2069161738657761, 0.05130743324630528, 0.3076932975977878, 0.30359067812490037, -0.520115780627704, 0.3938726680072047, 0.22635087520135075, 0.43957561979245335, 0.8099790760756146, 0.0934129560497806, 0.2226560970827828, 0.23807921025737336, 0.14749507401237927, 0.6547659776276737, -0.29360514685833194, -0.18719682615077374, -0.05907651408406754, -0.25190326898791515, -0.4071511742645777, 0.40175292895073234, 0.16915081765058051, -0.08218992487919095},
    {-0.1784083261566913, 0.7120593652462494, -0.3642671734988572, -0.32888253284749486, -0.2809024890286706, 0.4076542182453844, -0.0832639468844469, -0.5279863113672292, 0.3347986954696077, -0.4168149216044434, 0.4596678791821174, -0.3650161263256915, 0.23298786674225747, 0.4099283537261608, 0.17505813591075828, 0.09865145774948678, -0.07482488192990844, 0.3873485313627616, 0.05111531011090612, -0.094972917335788, -0.294755327528719, -0.4129164470206954, 0.030099963130319044, 0.12304447405504142, 0.12848010836562834, 0.28395430937451815, -0.8374204815948215, 0.14716817566005647, 0.17378564496419824, -0.45293824969584834, 0.24044805884484985, -0.07124197962642144, 0.42480785861412884, 0.3507258306249326, -0.26993863540360513, 0.09222298046097017, 0.3934045738577692, -0.2580292511793524, 0.034089439982904694, 0.4856477026716274, -0.29816254427180117, 0.3526847645660689, -0.25540048603277127, -0.4356552760019529, 0.4667587173137369, 0.04583522185351562, -0.2387518694454237, 0.438460576635686, -0.41818288033098494, -0.1551228424136441, 0.23648073425472765, -0.040106207078398896, 0.6152125881682767, -0.20776378025457867, -0.21808896924674703, -0.3753219477787609, 0.1268642617833407, -0.006819094734797329, -0.21776606916323704, -0.11585403186287015, 0.14523800446862703, 0.4447928830495499, -0.32431195781578465, 0.026528436961139407},
    {-0.015611393365263787, -0.7607140289992635, 0.23575472576008738, 0.1842004013271315, 0.30999942923133417, 0.41644688919056627, -0.6458783184759952, -0.06136749694396936, 0.182421828539821, -0.4164491168722394, -0.12563496681631153, -0.2576013792029192, 0.04292543442261774, 0.15942079073318335, -0.05157871797204928, 0.5504057901108668, 0.005083632205301256, -0.47814756910863354, -0.0820324989108814, 0.27008380190050085, -0.04273018980342725, -0.613426764113919, -0.10590530736813089, 0.11185393990371648, -0.27195254221629384, 0.2337042317437121, 0.016369232516138078, 0.4242667232298296, -0.318939762980017, 0.25586128338073383, 0.37144236189159874, -0.3177931380269291, -0.28769700698032785, 0.2595707618352605, -0.788827188947825, -0.18550363098412173, -0.1952380080834452, -0.03934663362497475, 0.3740520155543302, -0.31222359581663794, -0.5693344702364923, 0.12071555664712974, -0.1648740806451864, -0.06236462131944933, -0.24457034216720824, -0.005738331408567689, 0.3388618983153271, -0.039622167072691346, 0.0008991548413845887, -0.33633948280597187, 0.11720913903780274, -0.046828383601213115, 0.0630959757571424, -0.22433480656314905, 0.8369569544706038, -0.3606166784759179, 0.1428480573208038, -0.0993522812852592, 0.2752108307108247, -0.08249155523601986, 0.5101175571874309, -0.017682256740049244, -0.06508213970601483, 0.27693652200362323},
    {-0.17375570348828762, -0.14411125161156488, 0.29548396842108515, -0.20104863184854657, 0.06676890758885272, -0.14051072914905585, 0.4156123766445116, 0.3277971825856165, -0.04964878915523666, 0.035625202338393114, -0.026231579006074188, 0.3238809114071821, 0.018231798810971964, 0.04425429057293668, -0.37159714382519815, -0.09297264217918685, -0.0540238756376544, -0.4405626877969031, -0.687728734289567, 0.13414008621820858, 0.3088293809770701, 0.23848264436736505, 0.20691545762571958, -0.015373344551728913, -0.7206846453110927, 0.32306622047149847, 0.3626177928594582, 0.22507162089656219, 0.15502202292449682, 0.3224066611156224, 0.22077903794125794, -0.38331112991115135, 0.2509579031637456, 0.29080763389731334, -0.3439449470665257, -0.1848069613003558, 0.08416403840437926, 0.21118090648379792, -0.10333376778875314, 0.03557114858246213, -0.39283652492797744, -0.39684473333958753, -0.28703538636465925, 0.05085612208671633, 0.15694104446824347, -0.3499349729988017, 0.029578143100194368, -0.16457309206334989, -0.6392850992612248, 0.30536039898488626, -0.2581562770893725, -0.016897375981486176, -0.5495301595882903, -0.41890483891851765, 0.2768839690136507, -0.008847985454537074, -0.44217618112086077, -0.11109536316426874, -0.045825991443206045, -0.0035961168877631476, 0.3463411365336647, -0.3777226593077174, -0.6045988342918319, -0.20824913093548},
    {-0.24822532346018947, 0.12126081148480751, 0.22614618049289803, -0.0525375501263842, 0.04573745474532197, 0.2700850405347449, -0.31797688009589253, 0.6348953193663606, 0.13722150073088735, 0.11181554893544823, 0.3580117287461952, -0.497193688816148, -0.05875346613587756, 0.3751308994052269, 0.13819023902195618, -0.3643570455623925, 0.07202823599927703, -0.22736454373387957, -0.5307472145286631, -0.2929795392996676, 0.07190063389953542, 0.5050239932350025, 0.18670357905707988, 0.11660768752144708, -0.27052038166545356, 0.646171232618185, 0.11855271549981525, 0.016756265510418134, 0.3200266839461961, -0.019844219504322802, 0.1476725782367137, 0.3909939118429789, 0.2780633448896164, -0.1591761447977866, 0.10874556662221319, 0.12102317634040606, -0.05613589459840688, 0.30000274041971886, -0.0015384903627497877, 0.13578113719413867, 0.08088774657016512, -0.18343708198595116, 0.16005594422718117, -0.6351593778253676, 0.15613624733025777, -0.048629763758076476, -0.017477370389075476, -0.025632442060249075, -0.2768285736763064, -0.2876038959814518, -0.24783696970230285, 0.312383473017979, 0.17476939431500016, 0.49429624732094274, 0.33047486699864514, -0.32106652270260133, -0.6844344893231065, 0.19835139776584998, 0.16574063416949095, 0.1411549680717302, 0.008234773479694518, -0.05260672228038778, 0.118513645876534, -0.5264796355255791},
    {-0.3007066650890502, 0.009512788193073201, 0.12187371720835703, 0.35741447070182963, -0.5716353945645847, 0.21258125414069007, -0.639643659128064, -0.03476178918571548, -0.12375208952164245, 0.5093744161715401, -0.2026905124953956, 0.22746616978732453, 0.5654694238227023, 0.16841791906154646, -0.14754005822629954, 0.3357084224228133, -0.01431092087238888, -0.2951042224163822, -0.12552997721238063, -0.15801780302137758, 0.07060384927088698, -0.3070499628900012, -0.36393025221226855, -0.17460786604815504, 0.2974018151162872, -0.13752098766658646, 0.01270861175188916, 0.013853373848423766, -0.5050079176699473, -0.08256299035626813, -0.01670806651978593, 0.17371391746164155, 0.27849398694252725, -0.23402902135006826, 0.4117319882523374, 0.1354839573032045, 0.24370530064185159, -0.5095929933245187, -0.19610750599841492, 0.29276198695188926, 0.3890552935948574, -0.43509633599204217, -0.06067295303041103, -0.2977714061766584, 0.18023803577595712, 0.16686641936752597, -0.03880330223638592, -0.02266756478317545, 0.3022182909549725, 0.3102092683013349, 0.32560683197125107, 0.3462276955152528, -0.34924800041446413, 0.29071977568001406, -0.0946115026133675, 0.5007528661666202, 0.3872649944289017, -0.0009677478119374543, 0.37406689479137334, 0.42920941740136115, -0.8574336962873482, 0.1817759732668987, 0.0847533098885729, -0.35364795553710743},
    {-0.014158351445290079, 0.17842623694224705, -0.3017925495190661, 0.19034215955623698, -0.10120321166108737, -0.4181712526127448, 0.0422505460315299, 0.19941478462336187, -0.22279176337969295, 0.09419199285834425, 0.13914662577916243, -0.3523247406979475, 0.2099948921519304, 0.30148971428835875, -0.2113826802150839, -0.3229553209211039, -0.2945201318350531, -0.31234432412012375, -0.32875629989025434, 0.542823388884326, -0.028960430204253648, -0.2083445765777625, -0.4264448594545131, -0.4123695469393926, -0.05244423646724048, -0.19725799765793092, 0.22465862592367533, -0.3776239692991137, -0.31097708270647895, -0.43129766704574296, -0.29179502658925943, 0.05118521489337846, 0.07231833560374697, -0.04887651108421352, 0.38909408017481156, -0.08502834372481492, -0.12669198282851504, -0.38450956027711847, -0.01745326157896854, -0.055094192463074544, 0.0407956737737281, -0.2555725187533763, -0.4152794629994058, 0.35731321234281566, -0.4516690977257632, -0.19167570375163834, -0.49608993686208497, 0.008595795328694422, 0.23070340530399575, 0.20965878521308826, 0.31959464160577183, -0.0063923445593534215, -0.135463525461277, -0.47104995206614336, -0.579791591090019, 0.3211888322845419, -0.25480923980331177, -0.4853777861608609, 0.40145292016203343, 0.2018841764975045, -0.5529631352382097, -0.132583027629104, 0.2547489974719998, -0.3990079451669637},
    {0.2816864551942475, -0.16071608284272468, -0.43819295327156893, -0.375843180789418, -0.2444500451737369, -0.10308449568222051, -0.6735337341249353, -0.23432869583420074, -0.2381822071870219, -0.11385391472640674, 0.012893742303606893, -0.13029532565171958, -0.2149659988059445, 0.2763556167341662, -0.3751018179755187, -0.4577955215497655, 0.22679569041105851, -0.18835758383488074, -0.022651218622623235, -0.19106837362361773, 0.1357032417880607, -0.03312957473801315, -0.21241610300227048, -0.19144745090044965, -0.22807346197235212, -0.18986112672957697, -0.34812856097000194, 0.5077925359395954, -0.14304761993078735, 0.3594325297844822, -0.08082876633024474, 0.12857022043251684, -0.07738682102281969, -0.3506644766611316, 0.05517144742614035, -0.7827969773288526, -0.26434744418504486, -0.07454691702768401, -0.08817774977368825, -0.5599659314654093, -0.20969421222774604, 0.04675725226064706, 0.031509062766473424, 0.22619452699855272, -0.4623411078020656, 0.27857598924568205, -0.27675791913944386, -0.27238950108023074, 0.5312819885863054, 0.02039448516936519, 0.11317065132521541, 0.13615321224498012, -0.3630086998350067, 0.47984826588344665, 0.08637604065360213, -0.2517866967153954, -0.1565822952490228, 0.09682882234433313, -0.16897598436034367, 0.3166209020890204, -0.2825525035156266, 0.11559889444291643, 0.5605974296555948, 0.035515995128460646},
    {-0.2346640972409869, 0.48793328666650515, 0.33737200238730897, -0.03740109460972646, 0.194903518096829, 0.1536428783483761, 0.0027817084588352236, 0.1527459249386651, 0.3700439973981816, 0.028923327953562512, 0.06832258272859223, 0.10550545798660758, -0.03599672531515803, -0.35313120059736375, -0.31888556194056955, -0.3781851053974089, 0.25051011780491605, 0.04338682255778571, 0.6537066813383321, 0.1341728102889761, 0.7202348358769581, 0.4462668960836259, -0.17206741469567083, 0.2892197024521983, 0.0064015214085915905, -0.4358176823591957, 0.4247393676358637, 0.6207478883780314, -0.03361982207884281, -0.18347183613392065, -0.3152365894809823, -0.4338427594072179, 0.05222261764475301, 0.0400381179864556, -0.4006143546480904, 0.03634400038240164, -0.19662069569083773, 0.33635210256146303, -0.12109431637681886, -0.2188952769145804, 0.1607346010278973, 0.24581562106045327, 0.014688712937165317, -0.16597939694621347, -0.11265434639003069, -0.19346403032189502, -0.2589009614512602, -0.11911247685874657, 0.198795373983499, -0.04796765761393737, -0.10107756787768928, 0.5109747954498264, -0.37145917874506734, 0.147925581603201, 0.12208270056207222, -0.20151179540997344, -0.18201803396888686, 0.031722145497348156, -0.3699956992680982, -0.6122876768857632, 0.06716567193309485, -0.24291838639742477, 0.10605543292444033, -0.3696289747832541},
    {0.23454636998846204, -0.25620978772438485, -0.206131421511019, -0.35032059317167347, 0.3455049709529623, -0.16759167789127255, 0.12640189185877235, -0.00567764361652267, 0.06810465499525205, 0.05332412092195389, -0.11378316757989923, 0.2649302347240634, 0.3521049276723502, -0.480933281126603, -0.2230798784046032, 0.23217939836556883, -0.3200086092960346, -0.03871314992975669, 0.18677224010645577, 0.2631330153000488, 0.32092940706578243, 0.051037265257268864, -0.14524444473729703, 0.3180170768488332, -0.22042819020845217, 0.3258821441314359, 0.5630944305735829, -0.04816948409311464, -0.29991431385038353, 0.5123900454419952, -0.5622491716030923, -0.04446820815046373, 0.16439116944223725, 0.26691977014385954, 0.4784520037093046, -0.0791863238580832, -0.6478396165157333, 0.418490067035787, 0.10253360319867025, -0.1598619105942174, 0.24540182420890594, -0.31726340507551953, 0.4173858497871265, 0.31838122736137525, 0.0006177462135223777, -0.24957000669345022, 0.1633210937595736, -0.20563739366670575, 0.32582909173060687, 0.40436302099574745, -0.08196694875764807, -0.053934005529287836, 0.013463516340992313, -0.5420208651980385, -0.26612734175698693, 0.2516489019478088, 0.5853583891198723, -0.3694697604122037, -0.32356330507704645, -0.61706714145139, -0.21138834447624888, -0.14599870784465194, -0.20226362228237138, -0.23665286016753487},
    {-0.38779161908418436, -0.43594690323335566, -0.1689432789990889, -0.2338008918798146, 0.6177392799754624, -0.21337660274530557, -0.26870238810898267, -0.20555653114628683, 0.1076537917405406, -0.06279043668421541, 0.13519039001324978, -0.2101588473414794, 0.1804914981182138, -0.05248707554285121, -0.45244669663621817, 0.04184872003661968, -0.6061196082260569, -0.14204655303118052, -0.02521011568869971, 0.11192998018028386, 0.1351885600553705, 0.22912168111117348, -0.07864535451829376, -0.42895638157283095, -0.5747531697615107, 0.5781334283495705, -0.21075337636735306, 0.35927759842710894, -0.6534447346068101, 0.2884120302211133, -0.09031184820071538, -0.21814707594115793, -0.23006412709381896, 0.1201391608689161, -0.43464974864459016, -0.15987496306644794, -0.29452375987412227, 0.38124373095969727, 0.3848930768391586, -0.33048121257323776, -0.15393969747705932, -0.2832970090824302, -0.23896281713760853, -0.4707328357006571, 0.1066908962327512, 0.3494235840632292, 0.08253404982755501, -0.34476054572283116, -0.233011852256001, -0.33211015404954747, -0.652110720526694, 0.2744175027792048, -0.11503590989705728, -0.3405417548830683, 0.1966969895120075, -0.3831075069644528, -0.1898904490411618, 0.26892581960197104, 0.43163247726257237, 0.27308606139223596, 0.23772721778586509, -0.7874279097368344, 0.4573580119438127, -0.3428009768184264},
    {0.19230600510538168, -0.06872522481304687, -0.04142223211255122, 0.38580174616684637, 0.19175890477098378, -0.06973406757346039, -0.11369457378270913, -0.4151774066745809, -0.5268635953577478, 0.11876373093826381, 0.16181419061037983, -0.8448241201204227, -0.4133560917610949, 0.29817545963055125, -0.0908019539155802, -0.2807316499472546, 0.01716079097506024, 0.2706304452728317, -0.24274210755426942, 0.1959198889919319, 0.33643620909120797, 0.6095081287525428, 0.019964764793328007, 0.010333697683549059, 0.09749493932140083, 0.07322252157212147, -0.49541842147824566, -0.09204821959674798, -0.4024236399621858, -0.13568229568556342, 0.4149629781202773, 0.11773656717640012, 0.22133791040154965, 0.22830206816928816, -0.361211234776596, 0.6984681476197621, 0.4322687132242949, -0.33707458359689635, 0.015904510386756453, 0.24824827357258908, 0.40808397137519803, 0.28377180936851243, -0.4177416376900267, -0.2092182759976764, -0.09001110463384557, 0.8058265870744262, -0.08074990653948819, -0.2248536050701293, -0.49659819377948633, 0.10168824068245425, 0.2814460670133214, -0.6572698567312576, -0.4036028056030021, 0.024550782673048215, -0.47443058048401604, 0.46599374306052305, -0.18067019794006647, 0.18101278478167035, -0.012272394157849732, 0.3752697196668147, 0.13646770363793279, 0.17919107990300898, 0.08600239795391569, 0.265836418969978},
    {-0.09897499017328569, -0.06372261566303335, 0.25391024872103507, -0.1991605949057431, 0.19768144466610899, 0.43337337062773984, -0.06908904193439266, -0.0588561315329151, -0.3233645546025914, -0.0691012347999619, -0.12013488328170822, 0.2973862232223904, 0.41295033939569725, 0.46600688620220226, -0.2189570587123774, -0.3257657658771864, -0.11587351699675805, 0.4849782616255662, -0.45585539916171386, -0.2451718375919156, -0.3024174391703769, 0.20511430815295192, 0.06499198745432437, -0.4371883723519825, -0.009673951844111652, -0.6137643219172229, 0.14281739712532024, -0.4810098744831455, -0.28966248252223237, -0.41081430315327666, 0.023867918109237288, -0.47927914976043595, 0.2348459923698193, -0.025307674418904413, -0.15869523449410186, -0.4120581069668027, 0.5981181333014878, -0.5918772967665828, -0.23022253378177399, -0.10435571573428051, -0.056303717987644684, -0.4724605875163083, -0.2942626954956529, -0.3226796484332605, 0.24494608510777763, -0.48515634671177565, 0.34865762309660336, 0.20640187237874927, -0.0016486815047513932, 0.1518489052156726, -0.17734595519438628, -0.10488843893212696, -0.22483250135723487, 0.10482171289709039, 0.03968692509014318, 0.026912094582672425, 0.16018169468231344, 0.28653642928360945, -0.15574363985831224, -0.09859441285535843, -0.5809627437211679, 0.4854075830759487, -0.0027321150388379986, 0.14873488410224606},
    {-0.2714487284633905, 0.5736246953856408, 0.31184438913654966, 0.35054749472794794, -0.21481095781660284, -0.1275809985381507, 0.07990097437811632, -0.015268314153799317, 0.3085213767131338, -0.06485903649069898, -0.10785906431903047, 0.09423521092185638, -0.06876890469986087, -0.648265710119432, 0.3147071977780886, 0.19528278308094862, 0.21894720211234156, 0.09003703866272958, -0.054144963400187165, 0.17634025478243612, -0.06441991742623636, -0.11666633094577854, 0.004178338261366812, 0.013320158417214812, -0.08869872841247235, -0.11056740884611634, 0.18597004686716853, -0.2554920562181524, -0.08181931270510712, 0.0508218778759037, -0.15983724432941432, 0.004992634813241997, 0.13807058028477798, 0.27174307873868647, 0.4100562023254075, -0.3634046244587928, 0.36335096444733717, 0.09045344073261516, -0.16319812036433398, -0.003098340634403704, 0.05917432430637533, 0.18358228475814137, -0.2543136303224925, 0.15131776124739035, -0.30901137374378224, -0.10493124879533326, 0.2825335581221935, 0.48669135601023983, 0.19709359764521303, 0.5530939975515471, 0.013170975641129555, -0.019079607198868084, 0.421714610891238, -0.024587483707353083, 0.3171146762719036, -0.0870148862618699, 0.03067545587375779, 0.3115804591728394, -0.1445925562048419, -0.1284559751174382, 0.057150892724263706, -0.17533486359062803, -0.15798920010757497, -0.10833636919474472},
    {-0.04598992361893636, 0.0798866809568344, -0.2415559806690409, -0.1000772532018901, -0.04723492549723635, -0.26973664177239526, 0.15255354743087757, 0.3552039025880834, -0.32819253325616415, -0.5704073656729889, -0.01469362668517014, 0.03788957370370274, -0.44208134962348533, -0.2649927323897575, 0.12025192104118865, 0.14670473867980924, -0.032235423634743174, -0.4216016165771906, 0.43543743327779627, -0.09425465416753592, -0.0470298258510909, -0.30987515994907766, -0.11473687614418482, 0.19156982900697925, -0.03769389659659644, -0.3982489739603568, 0.14298168943193024, -0.16752998411286854, 0.11204604582599408, 0.20921680581001018, 0.2655017214808059, -0.04214471882143718, -0.051047953294532426, -0.3457730327984619, -0.32805244437110276, 0.025100887823264806, 0.05595837631558403, 0.3001323112886011, 0.066926361026931, 0.03831295177196664, 0.5072566374840657, -0.018147850591627747, 0.0012300419698917397, 0.3610897483758951, -0.10306740199554441, 0.3725668379520006, -0.3119349972262762, -0.000836748741106533, -0.404491028590385, 0.16834620235221998, -0.052168155128457544, -0.17938466584477766, -0.10881448646608065, -0.3276098486569813, -0.01300547259016458, -0.011407082501217284, 0.3975982922834516, -0.16642528844159785, -0.16555772980437322, -0.5572901547811105, 0.17824028321511914, -0.27869757768415776, 0.04653508795774615, 0.0408113377133196},
    {-0.030731209341905364, -0.48591200951535635, -0.3066017062690056, 0.16012101885798408, 0.5521266314622123, -0.281412194901662, -0.2530386529175222, 0.24323538350155224, 0.15048160953660336, -0.2058544236714135, 0.24784660160424588, -0.14440658034045448, 0.3338019468523076, -0.739610036646386, -0.09895221695234896, 0.10669087253499422, 0.3894366039540596, 0.07816951940960136, 0.19638888422627723, 0.6206268303320562, 0.416712017642369, -0.6704508047231416, 0.451982745152288, -0.32637807605988417, -0.31836017170028974, 0.5486564965280332, 0.4868858134865256, -0.2848821120212549, -0.22828292608481812, -0.29706878763867495, 0.18188238604759555, -0.28020308204320044, -0.27127396145440513, -0.5334451468865359, 0.13008455623793014, -0.13922034525698757, -0.1069483359679087, 0.3639859454325286, -0.14516975255404138, 0.4422374002896717, -0.40158966160716497, -0.5569031114684594, 0.0806328533937009, 0.013535978434942517, 0.060141405963661014, -0.24286872166569304, -0.21915006196627, -0.6010303272954707, 0.4297896299188777, -0.7541071678862081, -0.05270430599985844, -0.33123676497768734, -0.3269941530325117, -0.1566840794287895, 0.0999476750067656, -0.008101315876530669, -0.21243246801082782, -0.08679022626044385, -0.08781510435172953, -0.33692962933662923, 0.5380300310890117, -0.4467538628551561, -0.25353337416279226, -0.32475372696625654},
    {-0.27411222666651514, -0.6282925911046121, -0.7490672494524191, -0.5834262153399221, -0.6721450526413689, -0.11325949191893171, -0.2835233687692941, -0.6495796571274131, -0.0652672023795656, -0.4522922221051368, -0.9033809048381791, -1.0617225035943967, 0.361214423790743, -0.8256706439961251, -0.9075107164817575, -0.3692391955241817, -0.3584731074609365, -1.157417124601044, -0.916281494658957, -0.5014759134506498, -0.5108337173248031, 0.16680890868746892, 0.043730624914881146, -0.654745249231736, -0.6884671877063077, 0.042103747230043925, -1.010146437043399, -0.8540504864616963, -0.17676329468144436, -0.9297777818672179, -0.11473046382800124, 0.11831503969951092, -0.6927350582999375, 0.05916571704405185, -0.7965691171573586, -0.10536989969768813, -0.5338173673994684, -0.5492767574251065, -0.522776430490626, 0.34187876442851173, -0.75005854806085, -0.17235214011627584, -0.6795904283206103, 0.021761931109939136, 0.4133233721381489, -0.8563004737817788, -0.8124398377431362, -0.8314101229522013, -0.8152824079418304, -0.09972945265487389, -0.8728073045740923, 0.04837969851464244, -1.1917156756564442, -0.5142947485031027, -0.9475707354471804, -0.600645375543937, -0.6051098185801796, 0.2941475394098977, -0.32712500589077126, -0.4499078879194181, 0.7028894741901527, -0.4089537454038943, -0.4967120211370204, 0.03524031712480132},
    {-0.13184996152969933, -0.4408461445022431, -0.4508329726221096, -0.5493922368531623, -0.41145936207448636, 0.18134842377291993, -0.00310248647559098, -0.8692413349252665, -0.34281712532058667, -0.0919481128391594, -0.7314916434777635, -0.9062017535896318, 0.6563990221963639, -0.9299368755849476, -0.5657155220977392, -0.5939160627156158, -0.1912065743203391, -0.9358763945135772, -0.38306398133522046, -0.7001619516356441, -0.7118987143815164, 0.6324060746403193, -0.13478407637656314, -0.925818894401552, -0.5911027513695317, 0.3809358863972812, -0.7173068391219475, -0.4778648744398875, -0.6108633576759079, -0.43096758796791407, -0.9848681089129017, 0.12135749251853459, -0.5228171558340494, -0.01618826446001474, -0.020217361809766413, -0.10866289241895621, -0.5736167485203281, -0.9772738213836665, -0.5687268556195446, 0.3710238577990337, -0.7038534892159073, -0.42053857948098083, 0.08399798601448216, 0.25194468266206366, 0.3410025174328013, -0.8249433556265356, -0.6812693323786183, -0.7983125645019996, -0.8123967689752163, -0.09877522575409395, -0.8213405013234423, 0.18417503328825657, -0.9279205248172305, -0.35409590791520235, -1.0593505564662336, -0.6711293461616856, -0.6416312933359505, 0.5863766359076443, 0.030102471186648064, 0.10320768078803773, 0.49217652533635425, -0.910630316425948, -0.16496610909814546, -0.45077952320451414},
    {-0.5303465487136061, -0.5619890249879478, -0.5674410753812065, -0.2160131606695815, -0.3505254620798691, 0.22484600571233146, 0.3066704096561577, -0.5087426786007717, -0.6829840120538183, -0.8175353327537404, -0.3606171686678753, -0.8971141521495808, 0.11148105108699534, -0.5973836251451485, -0.387017613592119, -0.4323007122427505, -0.1947230401625727, -0.09082620898652803, -0.210906542406513, 0.7028511879458665, -0.3668298041691246, 0.5349045375256192, 0.43573189520185324, -0.455079948676912, -0.5049950752516478, -0.12752757991922212, 0.04171120716162038, -0.30408121362871027, -0.3607399607013896, -0.434002070128471, -0.08321359062722186, -0.08308097675818076, 0.05202660840191758, -0.32264338191448394, -0.0911171767895243, -0.2769148163878948, -0.40181715260155765, -0.3351026459522036, 0.3396437927625015, -0.23287083964548377, -0.5068336243079127, -0.19928053828866568, 0.7171811909598339, 0.7579036725290763, 0.438822109160964, -0.6006070035011153, -0.9338701490821, -0.8855857520556356, -0.12285993707080778, 0.32275932395144874, -0.6730353547814202, -0.14172183174739084, -0.20972230680532558, 0.13399219555410455, -0.06901578165100164, -0.7679380501087891, 0.1556667219967887, 0.20987040205685206, -0.014677711145160251, -0.524323850891735, -0.011565569840015217, 0.003799655219315298, -0.34933852218448697, 0.4013683689809632},
    {0.05174227107786051, -0.2463248448945731, -0.0238485108251219, -0.3448720038459624, -0.03565602064580607, 0.6235710648416878, -0.20152501462139366, -0.3661774069847602, -0.7514575425805321, -0.2829275321492032, 0.17512771356426673, 0.19296188688320207, 0.895047423146762, -0.5432028671833713, -0.4973760633107552, 0.47137735663350344, 0.017449822585957394, -0.34551971450149155, -0.44148165291892305, -0.23142510122911675, -0.5498623816748462, 0.8579410581121005, -0.4696046537503562, 0.281311791880591, -0.025875010351215512, -0.5406707001150509, -0.15968891446470843, -0.3187259171229325, 0.48847424497832403, -0.748253871907994, -0.3216045946333491, 0.1616948352053155, 0.13349915958659234, -0.6884650555871794, 0.043502472307594325, -0.10894792451247941, 0.4658157485472583, 0.20898895016893546, 0.4025903194193546, 0.2526818965231785, 0.40974288686009974, -0.33501266809712327, 0.26136595092740117, 0.6646749705312558, 0.03240647794443957, -0.49792018569524255, 0.23092056510041398, -0.43740707205754353, -0.12437860781464778, 0.5797908496646721, -0.6240937599865989, -0.2659704430578591, -0.6155905133783964, -0.19387628329540468, -0.21683162901527447, -0.49087674772626094, -0.042963703778020605, 0.44445003965720997, 0.29352282337618024, -0.3606455686878689, 0.16801294650976764, 0.1364141873468165, -0.6023399913541596, 0.2882827145103554},
    {0.15622491281647538, 0.1717502407552521, -0.3044260414260134, -0.14488531042001526, -0.38811316709843763, 0.26796820587744496, 0.1955518507571099, -0.6011922766928176, -0.3593700176676885, 0.07974958602742825, 0.24348764304955975, -0.21024096030282063, 0.1619961868390962, -0.5843683438470979, -0.1564153406531682, -0.25241935949191563, 0.07452295905034677, 0.07902468161744061, -0.10513010092464971, 0.592060125775214, 0.0380097380502516, 0.33447559111638564, -0.5505868665428156, -0.5187576792504459, -0.2614352644946183, 0.3378332830506141, -0.3845398668766831, -0.6746209900758384, 0.01828393266763311, 0.03815244229376509, -0.3739398486342638, 0.006906852803135302, 0.20650219808120637, 0.024216252236182484, 0.08092890798523837, 0.03287361517096467, -0.6115583584124349, -0.4141060567167976, -0.12891804765385922, -0.0418746116675875, -0.1702281409457114, -0.4683470796472188, 0.8387358582293166, 0.5641401155616048, 0.6554416358150341, -0.6628968083167304, -0.6126619882172017, 0.1879935352362709, -0.35458838335174964, -0.17547004743621367, -0.4977692417742036, -0.5209967248210743, -0.7339749348440411, -0.05238575959180441, -0.19399799060456446, -0.2551000904470807, 0.3452222448333667, 0.45106781044255334, 0.7025431793806247, -0.2384306553901224, 0.47003991900635905, 0.28548146823564957, 0.37873380385832606, 0.541876164342338},
    {-0.06330807603239533, -0.5044819012505485, -0.0967285811363842, -0.41114909669480315, -0.561851961204052, 0.08225575942199556, -0.1311661283360967, -0.14250143429339066, -0.33475801896411517, -0.20071627063499656, -0.3774086241995547, 0.054576985635137173, 0.8819449958268523, -0.16023839218179636, -0.575109486066001, -0.07287278854882075, 0.3512752922057702, -0.820524738858429, -0.5155692912343608, 0.24493737913798783, -0.609783225058327, 0.8904059663375884, 0.024747072643098104, -0.06578314349601111, -0.6818871068512296, -0.3519831158090958, -0.20021164264411972, -1.052508899373645, 0.1899127424916397, -0.7616139444108033, -0.3994693661902019, 0.07739496889077126, -0.12493099092669732, -0.46930728540573224, -0.11172217415669927, -0.26675230719574755, -0.11230206787607873, -0.6774749099698838, 0.27213844780808166, 0.23610994760375728, 0.050789582456521334, -0.3226872556757019, 0.305457588120597, 0.07753925863240932, 0.1943080156484387, 0.02484246863834094, 0.14090325488330763, -0.49659881082338453, -0.5021077427196249, 0.7389250340474929, -0.40304206854162383, -0.1037125665006733, -0.6798496674881934, 0.13491918551303544, -0.5605529002120971, -0.12537315834799015, 0.3754842593239268, 0.051301233012131534, 0.1642584414578994, -0.3786157556069295, 0.6292604154270606, -0.018841262498881583, 0.29837251002880844, 0.19747543199067893},
    {0.02045121393155936, -0.07229728636661806, -0.17754496334738992, -0.5990431326967232, -0.5900042660895481, -0.4437056952556366, 0.4617533654237278, 0.7124260440059986, -0.18242681849332906, -0.00758278804682374, -0.18399408639428974, -0.8308440174500121, 0.26353757952956397, -0.6006517674230936, 0.008564902155594075, 0.1100858792808278, 0.4859582723389689, 0.3275005676949689, -0.7900317679724976, -0.03668918901497769, 0.06257597028212754, 0.22240842865384824, 0.17325068998405121, 0.25381704775696395, -0.6516186000477203, 0.13857589740485793, 0.004445741237528209, -0.09075289792317953, 0.09325999028741194, -0.361459573549351, 0.021593351547723537, -0.24826502531414063, 0.6937535043177924, -0.1902863382481785, -0.3300223575067806, 0.3654009097046403, -0.12908023406817948, -0.22761087304813352, -0.39070840211753904, 0.3120398382860557, 0.22335961954016004, 0.4502517498277963, 0.4628213974504165, 0.6246300027337421, -0.20855574228055293, -0.08979794651779949, -0.11259035864573808, 0.057790217640429256, -0.836750055368801, 0.33473062374059676, -0.4458481652063818, 0.16143854720788542, -0.1231772084164974, -0.14242514453391186, -0.1324175559294541, -0.052832021887915505, -0.18076163997545258, 0.16386169493978783, -0.119560119128579, -0.13354758837123853, 0.8917431337273757, -0.3109980438981949, 0.23903275861513426, -0.03552847812444933},
    {0.3705846344210861, -0.1663088434004605, -0.11336420498874178, -0.3830534228778922, -0.12564501169310763, 0.15315400682246166, -0.4332366263886191, 0.04478126220891164, 0.6106958182802318, -0.16885210493023012, -0.5177381157753473, 0.2614805172713927, 0.6024289292664291, -0.7585180244710152, 0.0326535668024349, -0.15060200998105983, 0.7589631859351306, -0.28461485168604944, -0.8361816939158754, 0.07081377367078062, -0.35967975290295723, 0.2349139117553899, 0.38524149616229786, 0.5199156864819074, 0.10262754845758086, 0.5071750591126808, -0.3793248771356429, -0.13160634409801678, 0.28172068443770787, -0.6296968616176686, 0.49873352096299356, -0.6378537119221628, 0.47711975179025323, 0.5589700551872341, -0.17160098350580996, -0.08332042241415256, 0.18681798600548244, 0.09692982355417813, -0.3987948462050023, 0.6927171089952529, 0.19858943913014745, -0.5821277970119826, 0.43587369251347996, 0.4155128526846185, 0.49053614354028147, -0.35231802588095107, -0.07347756047884152, -0.2978093365430116, -0.7750194915650553, -0.08234812248453217, -0.4763219584812971, -0.2658281348400068, -0.21759656188859772, 0.009944765688795548, -0.19486259973233055, -0.06209594435637742, -0.20693789731723178, 0.3287743416122489, -0.36130635542845513, -0.022656771968078693, 0.6583098727351755, 0.0977142732640503, 0.27124502626057495, -0.02303849967140235},
    {-0.5352641742496224, 0.05766266542392933, 0.018038361009710555, -0.09401954721801399, -0.7053113156419586, -0.15396557550283338, 0.20462246875881637, 0.016342586151156763, -0.3112719773091141, 0.3427902931325878, -0.2622180505850408, -0.5191398638918359, 0.17669203195235425, -0.48121644659296586, -0.44732497338003385, 0.3717194116694697, 0.31434805797904364, -0.7127229902768754, -0.4208007704626072, 0.509032657249673, -0.09387116243104376, 0.22248285318559863, 0.3106645956718072, 0.3660513086829022, -0.6167701687731022, 0.4309080271755302, -0.7424036415645714, -0.429642292462306, -0.42580372441994685, -0.7351814966602448, -0.4667382017399865, 0.06989194135168933, -0.14231811756913262, 0.4990337532482349, 0.06862365237623456, -0.6954547025044594, -0.33310547928944334, -0.8916778473620615, -0.40073802484677523, 0.5213384440369612, 0.22091078621804966, -0.7363811915450628, -0.15745442298497236, 0.310400919106191, 0.2991121255074158, -0.157541742503891, -0.11216470865191426, -0.7618802087664395, -0.22064003779886485, 0.18697376376280708, -0.5025524548416943, -0.21883060314763367, -0.741124734083456, -0.9636528648113685, -0.5446163060241973, -0.7112551482495281, -0.6113558574984531, -0.5222972465658647, 0.06085595877943355, -0.29599040978420654, 0.4426029683822798, -0.5347135172928239, 0.4242561797839199, -0.361374725218149},
    {-0.46031127374146286, 0.43998102832048686, -0.4214082980558258, 0.219821207498123, -0.9531187982390491, 0.15604210729774526, 0.34408356772562027, 0.42597052441102123, -0.34299455475495494, 0.6558242555820077, 0.13475372600538843, -0.7170884372044609, -0.1563793625532845, -0.4345581537447193, 0.2268722857142631, 0.15959613069245, 0.6523676753397073, -0.11320816045161368, -0.25342480952331714, 0.18670210635032508, 0.010932889242994393, 0.22020241390895973, 0.30528674060456235, -0.02426540045407026, 0.052486569925159876, -0.23712329050435044, 0.017733574092599617, 0.24023072320641548, 0.00296635602212756, -0.18967027066972467, 0.022417757023450825, 0.26916716894055404, 0.10981282234864172, -0.36057929969403957, 0.07851861660493478, -0.07954560507130984, 0.23412256787492977, -0.018580725004361268, -0.11937016642137159, 0.010492869100462095, -0.22581369300309878, -0.09919952443831818, -0.3669997629728492, -0.2963291844366591, -0.21684964300116183, -0.4093122441381695, -0.5888688716988644, -0.6360268472565564, 0.10852560588027829, -0.02118857400130824, -0.23191932079321384, -0.01268969790495508, -0.7745645515949771, -0.6617495879843951, -0.5692798726924093, -0.3412795254149976, -0.29184275383582237, -0.040111992661767494, 0.23777448102754573, -0.5342345280898901, -0.169090426244859, 0.21081922808039627, -0.5084232197702024, 0.09075188498227695},
    {-0.5889053325533975, 0.22060316769101806, -0.48404558856886265, 0.7546468881390607, 0.5072363890937149, 0.6755381175861399, 0.6582767464112952, 0.07747488382859706, 0.1640658093997697, 0.03612279872266601, 0.2161522471201304, -0.089437345767932, 0.05571099234536519, -0.25335325554318255, 0.5830732653222955, 0.4578665536970922, 0.10014015584268215, 0.3074992722803788, 0.16328228030087996, 0.14880655630700507, -0.25527914767818144, 0.2433170481449131, 0.18207171289030502, 0.022871071627020477, -0.047204989619243146, -0.2497645161241375, 0.49953691535170547, -0.01047040313943134, -0.7381242713069169, 0.2520189785870087, 0.29125679373281, 0.019139443029767958, 0.6049702466932846, -0.5742053729779895, 0.18160505705595592, 0.5884045759764147, -0.18289488980977947, 0.3652264298046712, 0.3389463255108657, 0.3608679631641348, 0.17707107381773407, 0.1223452654966795, -0.1620930317040716, 0.1811783817573037, 0.22282370438785795, -0.5182904211906123, -0.4827457697301031, -0.20646687757080562, -0.1867160481072475, -0.04719825381958855, -0.4891389187983333, 0.40365064066294665, -0.2555999471331746, 0.10508317844687924, 0.1517414339013019, 0.2709420410072985, 0.4064566045018013, 0.31255551862158487, 0.8251975863709982, -0.23490924878042685, -0.08256847961407224, 0.6374939763249955, 0.011736128472491234, 0.40723677500604105},
    {-0.648937887509364, 0.4500822303362657, -0.08602169271848577, 0.4056910505789385, -0.15113988822188523, 0.13245128210747623, -0.19431111498499112, 0.3834855981027225, -0.018331670343236496, -0.2706545829114765, 0.24482825445419681, 0.28970893496776234, 0.524812040534824, -0.6483187920511679, -0.15749283568199793, -0.1837394478645899, -0.04714626399774889, 0.13086128031545005, -0.4322992941105864, -0.1052640880141919, -0.0013675145902362822, 0.5518460881766439, -0.5124238748496568, -0.038316294474565776, 0.2747783116828566, -0.15416968592700545, 0.1982708733994421, 0.1534303994259711, 0.07436593976125933, -0.23135627384489005, 0.18733946191378043, 0.04532131756534364, 0.4615302031566367, -0.5166570056424377, -0.740211803635943, 0.021383725970968707, 0.47540365394496426, 0.038199108200640736, 0.7512931251342154, -0.07028893477774237, 0.07018138837352111, -0.17585410882931551, 0.17734416355591473, 0.24394095579442182, 0.15128716417298155, -0.2945131317021807, 0.00014271593600162708, -0.5152077420157365, -0.4427717560370973, 0.24970726400389381, 0.0029895603307011007, 0.05604512693919389, 0.09554356170424344, -0.25063359022406406, 0.3445299361572939, 0.21639252633846184, -0.17854367850995767, 0.023044849877664423, 0.1033243814920331, 0.5277785238505639, 0.3440368100018144, 0.16910432595358352, -0.5134803557250456, 0.459138009256858},
    {0.10979872749583316, 0.4180947472391076, -0.177810410221925, -0.3601452597165692, -0.6777490940422146, 0.09113375698056801, -0.43380266025478076, 0.34096168724187204, -0.012640323769683999, -0.21536746163377882, 0.04995778598232184, -0.3587486872052092, 0.4590695816022707, -0.41359232028427495, 0.5538873882877253, 0.24443953111222128, 0.45101356752901994, -0.38960643150655466, -0.09824018568787773, -0.5109954915438575, 0.08904155746176554, 0.14867926371997742, 0.5220950176535732, -0.05418840575373158, 0.02842098927517052, 0.20359315925350074, -0.30585202525954747, 0.09581710970644762, -0.48563959867544443, 0.012533154916417634, 0.3027818457157668, 0.1422001119640581, 0.22807719094087722, 0.07337209186869245, -0.22861064512111742, -0.3361159605570131, 0.19067350500416838, -0.06915247590963984, -0.04177528976687629, 0.45065175138232355, -0.03810705281383799, -0.5988298923106296, -0.21668699072865358, -0.09673256248098917, 0.4015474017519315, -0.48122520528378343, -0.17509809953635913, 0.22735280631738353, 0.07321161610330423, 0.23234885370853756, -0.34416722563545504, -0.2851407010448445, -0.19422447175269772, -0.7754562528181858, -0.30566522772489324, -0.05596554631850794, -0.5476705440404285, 0.5280175407593478, -0.0041863455577890625, -0.21357496962091924, 0.3701188547527283, -0.17316935595357946, 0.2740011444756564, -0.10378222052383841},
    {-0.27109352893383165, -0.1748169669266889, -0.09967621239687677, -0.2031516088741146, 0.164860633762025, -0.42287202038235644, 0.5628648120407042, -0.2859407074656034, -0.2077028369074976, -0.5777780190355796, -0.5166887314305564, -0.36052332506804124, -0.007018847203227654, 0.4485370649052401, 0.011585886421870384, 0.09769871897473201, 0.3964474308081101, -0.3376547696670196, 0.3569383981800222, -0.48220187420189925, 0.10174187200444694, -0.3560665057164287, 0.3565397175252839, 0.3036742878242176, -0.24817077392231124, 0.19522855717673926, 0.3001777210796016, 0.03793001814216467, 0.0041857386423691575, 0.11272787149637886, 0.19348424316433702, -0.11887815604730873, 0.030041899904843457, 0.26601271058530157, 0.08131218885547045, -0.15955527771019182, -0.4688585022277396, 0.3932029566375599, 0.2817433600235163, 0.10779274510716337, 0.023712024272542098, -0.06260340457062968, -0.8143237305221227, 0.4007362964038303, 0.18024368088224596, -0.0300403348731285, 0.35582617165053587, -0.26801584248620564, -0.5611207773830234, -0.3575698563887266, -0.3312938515194971, -0.4651767085907767, -0.11225078214816049, 0.04416747649785523, -0.37336862894621753, 0.09384611927330026, 0.0039229244968332746, 0.11875741186680167, 0.05557004673300576, -0.28644134263865595, -0.032333273125609775, 0.009425119861304582, 0.10035210004297282, -0.004330049551513907},
    {-0.5758100703252104, -0.4710205511586192, -0.2099752028941514, -0.2534171047978256, -0.3812214225245361, -0.10919048188096273, 0.4018629193015585, 0.27724448338657237, 0.34955832541408804, 0.6991353258998763, -0.03056462076420514, -0.26439143043689484, -0.2554687483363157, 0.12539299891282496, -0.022820435342268863, -0.2551616168742098, -0.48440448598214253, 0.019802524081941008, -0.15378187081331954, -0.015332987425937895, 0.038758405512074476, 0.2624541364358847, -0.24555978486469685, -0.08177381965686686, -0.05583805705822928, -0.09011719018519286, -0.4274234589152658, -0.44232491592787593, 0.12331713463597418, -0.380235869398365, -0.26024463850582036, 0.14032798944888716, -0.06872040648626186, 0.18326729510676804, 0.2923420039613083, 0.23940577206865543, 0.5899247628253934, -0.7281786046552355, -0.08948072713621673, 0.05081864178971982, 0.1505199857034573, 0.2502847303528184, 0.40936457130423753, 0.47868030258970334, -0.025792850540087803, -0.3489915190481486, -0.2749997351366005, 0.30960640192102123, 0.5144009966649841, -0.015981628765525786, -0.23522643654080497, -0.16578857217228646, -0.5955605011509245, -0.23679557173252433, 0.20592459476009675, 0.307013115209813, -0.022957419989685483, -0.2938973444319406, 0.362595673159826, 0.04910445595616953, 0.44897349424578853, -0.3327476106287748, -0.1749211427487333, 0.17857255384991755},
    {0.48776356969844137, 0.36307125664953155, -0.13317874680629355, -0.11628315333545862, -0.44756738852678807, -0.39098198306703114, -0.4782609428108271, 0.3786422550855788, -0.09913903711382274, 0.11611999606071738, 0.18839051157387227, -0.5470719039477503, 0.658996691479847, -0.6193459461391432, -0.16255105047887838, -0.07935264734733226, 0.28223612110714164, -0.5901181379077469, -0.6991508217564698, -0.3612935799933271, 0.5324934055044882, 0.319639446886002, -0.41264659100874085, 0.20338495957179512, -0.18734153955889588, 0.40829629428719255, -0.3349540560462284, -0.21532535747598228, -0.04709687550814933, -0.19916773171871888, 0.2411578104776158, 0.1988471505850099, -0.5125004967249596, -0.2608771822561418, -0.6691060889478164, -0.45174717170518164, 0.3108079122870669, -0.22936386854375734, -0.13202424058529796, -0.05653194368111751, 0.422901233703576, 0.003449495131818964, 0.34314730855805436, 0.21047309310900947, -0.13461923319653932, -0.5090987358729476, -0.14053320747511128, -0.22097482210076402, -0.0997719038799885, 0.005030853851205679, -0.6120953454643323, 0.5504215893576616, -0.5870377328051698, -0.8585286669828719, -0.28760510186038996, -0.6527628556822531, -0.5495344043283421, -0.6113180898943393, 0.6328682933699435, 0.4581736717770131, -0.29492809276045157, -0.2660781366160239, 0.28693911233594965, -0.6014821570946604},
    {-0.16673737213281326, 0.4588797461828501, 0.5252642445179047, -0.26436315203462674, 0.35866259303390136, 0.16713299555687317, 0.39850131736859734, -0.6123577327817259, -0.238547322964981, 0.26985859747881075, -0.5193966424106713, -0.09460840888160045, -0.06678167571747513, -0.5245993613851277, 0.1735675119002645, -0.0279532871124952, -0.0747371894447272, -0.28654436765751545, 0.3694359557997851, 0.12296182152408806, -0.17928243637403113, -0.06359955522417099, 0.13005250795728943, 0.3498499732800536, -0.1469554329339306, -0.5226862306500885, -0.2390486447135268, 0.20004088901185416, -0.24697291663402104, -0.9083483250242169, -0.44863863879887533, 0.2825440157808888, -0.3396019280740416, 0.049464566007839994, -0.04247192529700578, 0.38147052777026863, -0.38913145833662927, -0.28050224141866276, -0.2185008152493439, -0.7152149808627031, -0.28649588859208247, -0.0363280821965271, 1.0071159944853885, 0.3111010909606308, -0.1298391236000606, -0.9911943412220516, 0.0009895104197284175, -0.25485892921991404, 0.5087751248252275, 0.08643660557788661, -0.603782218006684, -0.3813867411220881, -0.5161573935393716, -0.36642957030015005, -0.3490855654433298, -0.15317452615583146, -0.4942794846783454, 0.4155043245019365, 0.180871999631391, -0.02741320742711448, -0.19437707367084284, -0.1564280492222116, -0.06747917216606311, 0.13978644060170262},
    {0.023154102140118465, -0.21732765340656354, 0.10090489906076755, 0.6542133474007281, 0.2427926617760265, 0.1684831514794651, 0.2335975192583346, 0.11049046208258764, -0.8077131509253312, -0.08774735508909445, 0.35181056067539995, 0.3315960251915944, 0.2140635984969904, -0.5616518055768736, -0.23892543308675293, 0.23148501949716271, -0.011972618891951049, 0.09892396069234431, -0.6405408859994348, 0.33306092192837766, 0.07793327684306744, -0.14785729862421912, 0.023639983597521282, -0.5197796015051057, 0.2550481024414775, -0.20043126639507639, 0.05105570046529444, -0.016416517857828827, 0.048153639562232786, -0.31744872251308803, 0.5628584369388558, 0.24185674511686395, 0.18532300348530065, -0.42328349836823154, 0.5508698037302677, 0.5332593416863795, 0.09805594821859666, -0.5233937839427046, 0.2708852806377221, 0.2546468952073926, 0.03665871801329857, 0.018630796814234213, 0.701826683682546, 0.6358778689486739, 0.12456411779126657, -0.36266838528302503, -0.002414501251353167, -0.407790836028291, 0.08454491997172268, 0.1639199643541215, -0.42520472011626936, -0.21348294185498135, -0.2474178382227084, 0.4263452411128953, -0.3025335091676373, -0.15025646417153876, 0.11500001230117221, -0.5625873196650883, 0.7009747064680489, -0.21033190968455245, -0.07089682130901882, 0.5162258721709154, -0.4533617687843631, -0.04260865258695355},
    {-0.41786687811502277, -0.038651635618124486, -0.41869700629893336, 0.534958925761454, -0.023790534075189336, 0.764835299272968, 0.21615544867087466, 0.18105324446673401, 0.10414526561699909, -0.32409294315840087, 0.15591518176424615, -0.05972044219175153, 0.48930089558219797, 0.06052673652634638, 0.5053863816012207, -0.14936024191351313, -0.5318422989701567, 0.447726284002456, 0.0068373060292013866, -0.19907665954875348, -0.8432627298782164, 0.20945293665425674, 0.7403449287075574, -0.44333682562085625, -0.26826126664007827, -0.15197577094635664, -0.0634184282580732, -0.4166394676557343, -0.5890110562422759, -0.13380601558437158, -0.13677174897086175, -0.02296496545247178, 0.2809415128917222, -0.04493979527164188, 0.2785716679241583, -0.1306272950009307, -0.6145741022655128, -0.3848612722835585, 0.3250596071798147, -0.02597045397822175, -0.0011912753705404999, -0.10934860048443269, 0.218917897686504, 0.47113514850405075, 0.4237361950287046, -0.32551289395918864, 0.24047603707549603, -0.353966282541223, -0.2066884008927492, 0.49940539165760883, -0.39873161209802005, -0.19047792399448576, -0.03333739757649305, 0.43434900876088667, 0.3959577473758882, 0.11952523903364101, 0.5330536919047905, 0.08229795623622418, 0.2824147248780064, -0.2629686726461519, -0.03383165862789558, 0.6181079058375029, -0.3230970538800278, -0.19144657373254295},
    {0.3791850151008209, -0.1888650883307719, -0.5893177198305539, 0.2167026820332051, 0.9306616734997938, 0.7413186747315947, -0.5005933815452134, -0.26876123248692374, -0.4434909620585114, 0.10762645478672764, 0.8522528514795235, -0.2947228288558183, 0.05429505201119435, -0.22664933747347837, 0.4851961439408885, -0.4931906407117155, 0.48957440787303247, 0.2533340426021388, -0.020677043208238533, 0.4688451559474663, -0.4579179635474147, -0.0445027003835305, -0.07096556816040128, 0.18629248263866582, 0.29224184808082493, -0.22850668021536538, -0.6193681787490937, 0.17531384958333762, -0.006627037314630224, -0.013754840380743833, 0.3560245691904071, 0.3021716939006303, 0.605979451112822, -0.010353341230977068, 0.14220956628836032, 0.034374156825621185, 0.020883544361100133, 0.31245003479828376, 0.26573830385547337, -0.05536914602784481, 0.5909006091871494, -0.35474253149208246, 0.23529544338846636, -0.10189115736009023, 0.3750441996022452, -0.05676990924431906, -0.3070695806441861, -0.5122128084306342, 0.11840531187091147, 0.39836833417621703, -0.2562822860165995, -0.02049618961505539, 0.2935900732160774, 0.6026224624419131, 0.8633212173164844, 0.28624751869404363, 0.39398007114972705, 0.17192744220698264, 0.25518356085179955, -0.37560242119404613, 0.3317591038247775, -0.020855084423262938, -0.1253199306926432, 0.07415920847878307},
    {-0.3886869209065326, 0.0038249117806682356, -0.8600241890938348, 0.8906253237886388, -0.1406522299533627, 0.6930852434828852, -0.0037089638172202854, -0.055632839392876096, -0.3876833071693465, 0.27371097308644093, 0.00473830547808846, 0.22889748495370266, -0.09068257665638242, -0.12884909966457736, 0.18042572211492008, -0.08104974989532006, 0.09553314482961593, 0.3161058933081532, -0.18366360845071864, 0.4357732423109074, 0.19495369975186583, 0.08899889680004759, 0.32785714256751297, 0.08922019569813743, 0.2268276311495756, 0.04739691497445519, 0.7902310767518728, 0.004226202337936888, 0.6620714687912711, -0.5328915606097311, -0.6055027011942801, 0.17362466743242014, 0.7317340411786729, -0.03362692141240221, 0.7021127151356761, 0.013661654158775963, -0.11432622867451872, 0.4678150383924571, 0.4316585858377466, -0.4561775800119428, 0.02456775481176376, -0.1588484667268221, 0.10676043511297681, 0.45389646768161, 0.28382378917834317, -0.41664364847067664, -0.3472470139794566, -0.2376804786477715, 0.22889910826158272, 0.2534933080858276, -0.5876170425531931, 0.6219374721370948, 0.04891377356071545, 0.2662683946680355, 0.46507490765604614, 0.050615044300816876, 0.6337679309307405, 0.4823220253522807, 0.22852300842627674, -0.5066917325499443, 0.40893138213559105, 0.9516675763003802, -0.32216214052886055, 0.571419377318721},
    {-0.4839695742733939, -0.4762881565354886, -0.21198045761246256, 0.6845448207314547, -0.11129548852053484, 0.4140938030470784, 0.5996747398100427, 0.566230552688425, -0.4383180365069733, 0.31225108531346185, 0.7473184789835893, 0.1597252767550184, 0.6181145377439814, 0.16177632463345049, 0.4835532468269399, 0.36990959355061365, -0.02989418722175339, -0.08187315962502699, -0.18972624198390717, 0.586780775581282, -0.40370821902882537, 0.8028610452773063, 0.6823961015557876, 0.05072971750117675, 0.06742534751014616, 0.06638819258556897, 0.4297342323952559, -0.08062108920334284, -0.6065948579888107, -0.099227796293638, 0.2855183170820964, 0.5750733215578644, 0.5122661181677511, 0.20902319231687425, 0.2015328814708767, -0.024168412998486113, -0.2002604889565005, 0.46342368075903423, 0.1809537446761268, -0.11943391805544223, 0.7515591038327059, -0.5838385980270431, 0.9064386214086761, 0.5318555469601086, 0.19149293546899468, -0.03930961425576023, 0.00958038915958792, -0.808524298428617, 0.3179476238153352, 0.5276907519072587, 0.28217138477472004, 0.5714329472226114, -0.3118729124071536, 0.60608701904274, 0.07684676255692098, 0.46018446612446645, 0.08074574739016356, -0.252424061753438, 0.2192562865161588, 0.013839447495509388, 0.8615353250042468, 0.24085505247619346, 0.6897880492998922, 0.23867988690776532},
    {0.13802676895205637, 0.58215022262649, 0.14213171504994251, 0.2775333146231752, 0.46015271054352563, 0.3199452311153386, -0.05316388325984427, 0.11594703509148825, -0.44945320166809477, 0.5318051999662, -0.3459219018091497, -0.4182595312401069, 0.6374361878240168, -0.5144182995863922, 0.18273584297559398, -0.1344071269475189, -0.22995211279162334, 0.24412763156371733, -1.0638481312955217, -0.2395182471186718, -0.7730629913797372, 0.5229878324987196, -0.2472972822467953, -0.661497118853134, -0.2303355406119947, 0.32752307769695754, -0.792865365529094, -0.5049703308613203, 0.04037893440600576, 0.09256890898074072, 0.26294801985121247, 0.5371762444580838, 0.38575613814771026, 0.03446934556337735, -0.06603960364128361, 0.48585212813661527, 0.7069490070961338, -0.68091780682656, 0.15110136997757137, -0.21692538846481443, -0.08656091752023139, 0.10974858542994324, 0.06572609560749244, 0.6412023634933299, 0.17931755240869543, -0.37522473279085644, 0.37269857978073745, 0.04370185338769641, 0.22754211966963983, 0.21483173717912285, -0.24669445759137087, -0.6715702673028217, -0.5577048864357885, 0.002587974912240567, 0.013355112738537884, 0.141197457622758, -0.02230575685540143, -0.3449649978395384, 0.015916093750814486, 0.24754867429705568, 0.10953225855051675, 0.13475979035197141, 0.03164554927907492, 0.822463751998475},
    {0.20304765020399435, 0.44866307449621345, 0.07338139781105553, 0.3206116526545845, 0.11611098644744823, -0.2649942828630981, 0.19760267181525842, 0.3368020711421929, -0.30791702932369125, -0.025130588599617483, 0.0777834268075055, -0.5051261704401957, 0.4398379831967243, -0.3581144263988241, -0.06655851773394075, -0.5199039769180027, -0.19767458159141016, 0.20884216144925222, 0.0005067365297089719, 0.05385127109359497, 0.34907287128639203, -0.042499144188886784, -0.4669861679802893, -0.04269297830892918, -0.06634889799226139, 0.07526109569409231, 0.05213195097854344, -0.07790811091461279, 0.2706187241448552, 0.02581567982244441, -0.41303445909644015, 0.13936393398854566, 0.3784873219328736, 0.43260291994452954, 0.5078307335064024, -0.09334930889854287, 0.49598423089213145, 0.28632553281035805, 0.4071992358150435, 0.37525305886301363, -0.3815331117864463, 0.16815133613653543, 0.010896969368703772, -0.3676533450956772, -0.10066812551191329, 0.25620090100237247, -0.3979044526805463, 0.3513102177336995, -0.26887747554407354, -0.1095854406453955, -0.9157267908982354, -0.20388149035338468, -0.6724714670463884, 0.5472828847016775, -0.011308303365361658, -0.3105274831654927, 0.13100757773077157, -0.5427673068931649, 0.20939213525217173, -0.07442130128022796, 0.5308250163490471, -0.37938832754495877, -0.3496336818138529, -0.7751700798717244},
    {-0.4432269404779239, 1.004888140564833, 0.3899778794916307, -0.7382192948929656, 0.6717242552176693, -0.16242552414990635, -0.18925479558144145, -0.08324504874764292, -0.16698954734037016, 0.19069563825214228, 0.3166330401752678, -0.39189780133064994, -0.21128085055549356, 0.011955371003603683, -0.27163646007759035, 0.29422973650802525, 0.7520981375851225, -0.2881728445115714, -0.12427770219556565, -0.171752571779544, 0.6605131842533781, -0.38885181632676663, -0.011675029300933835, -0.19313891140523384, 0.06439169295574461, 0.22776158551680878, 0.20288497192947005, -0.1265380364364263, 0.1150853614013535, -0.3994880139354026, 0.5183244290037378, -0.28893593944520213, 0.4686208080203133, -0.11559304235715805, -0.12089837533218498, -0.2821830325880713, 0.36059233205253477, 0.03183324003868644, -0.2998844279103243, -0.0050895875796585985, -0.5286580293429232, -0.9376180293024325, 0.2294380028535814, -0.24076081291460755, -0.11017794402570569, 0.34614267341318916, -0.1883319894623643, -0.3351389119310774, 0.05311456480847004, 0.013231101528599675, -0.31950837600406623, -0.04976598432014507, 0.5711746722636586, 0.14200643932072232, -0.5234451098969436, -0.30073476489065637, -0.4669423608556282, -0.43032900636218885, 0.27790084816118155, 0.1400017803637175, -0.026603537500778252, 0.0172262822037547, -0.02843982094508384, 0.5769188936147109},
    {0.7573472414426068, -0.028654686458300157, -0.0539835939544706, 0.2434286830701867, 0.14713140634307723, -0.057056540905486154, 0.004477751353911832, -0.4983947176635617, 0.07168215934795025, 0.019856445386052992, 0.2224955108555686, -0.20419591093669243, -0.0013199250395655702, 0.5614823542777013, 0.03723710687061136, 0.09462614329924242, -0.3086456569388167, 0.2073030471929807, 0.5003948238342296, 0.23231680339616206, -0.3501043971376987, -0.20091733345896198, -0.20760908162440464, 0.6827895684930596, -0.2559161095166504, 0.1608092138096693, -0.4294209466590229, -0.8069948662013757, -0.3426051228240521, 0.002591985321820219, 0.5519847052058421, -0.1463495658475065, 0.08348639334391272, -0.13551456868458495, -0.41846115888106455, 0.19918642732533431, 0.057779117802897545, -0.2532366025995124, -0.2496943179127634, 0.25124693055641784, 0.7583302794199714, 0.6647290674811487, 0.006920818038108208, 0.351463130635413, -0.1291566781700235, 0.27569851856535194, 0.6502407162776851, 0.09812029389045576, 0.028541080249992558, 0.38883789212670755, -0.23210865149670448, -0.6527935410119146, -0.3225833392763609, -0.2119701000444611, 0.6109996185870579, 0.010808549551368564, -0.1661476076736901, 0.1553915202518081, 0.1849190138301022, 0.07701169303499746, 0.35715216243797565, -0.2939675727726089, 0.1159028782170851, 0.18482235416422177},
    {0.007260357258935192, 0.3562788507281579, 0.1395137117137333, -0.035766065959139205, -0.4908442780063514, -0.0003382277031199156, -0.1435215663800547, -0.25026998395569733, 0.1741269681659293, -0.26293126224252933, -0.003053511599237581, -0.5619302348838796, 0.5435247810674808, -0.5411034427551303, -0.12165603057420737, 0.4504831313676916, -0.21382186471997303, 0.03305277783906082, -0.15620301204124698, -0.1621400635645684, -0.41922508891964105, 0.38998878778054236, -0.3013432376018506, -0.7411647868452782, -0.04657862042541312, -0.22534229844920858, -0.014908724793408164, -0.8030675678062303, 0.1030779328895334, -0.07793600092944385, -0.5394497118452847, -0.11964220277866328, 0.1603912642366326, -0.324097621026922, -0.09226083250034238, 0.15576094479293606, 0.4522744473924497, -0.6489298033529113, 0.20650772116173335, 0.11985006376873954, 0.3003250706990729, -0.2015771928725332, 0.01110680816442347, 0.2513074341087835, 0.4234097788497449, -0.42793943721595085, -0.19360933194912994, 0.2530486658036859, 0.005173387338626132, -0.08511296109362412, -0.27278408337779075, -0.3672355555594055, -0.09355792216949317, -0.07883358137307088, -0.28194367168261636, -0.030931979942031118, 0.19070913443162726, -0.31905072327854866, 0.7632418761801646, 0.027628826322436198, 0.023391136426006813, -0.0020231170635746486, -0.3137024585169848, 0.30616961564796213},
    {-0.13004119573892994, 0.2566036443603362, 0.10692335795272341, -0.02460294823045424, -0.5439731143553932, 0.32581123601878575, 0.14938492009372611, -0.09255558309820724, -0.24221762116278073, 0.42008683259520074, -0.5324728974243385, 0.20973700063781142, 0.4468968291592475, 0.02670546675124291, -0.02969240170519288, -0.26854958041249316, -0.6079689445306355, 0.04679259649843483, -0.42020598843935586, -0.15056441893730246, -0.18743441575484773, 0.04016536161013151, -0.33832878872327726, -0.16224312158333273, 0.2200742836786449, 0.3006187057890621, 0.5656065005489233, 0.2012215835768508, -0.3047276162925024, -0.2844003946728339, 0.008165883301142478, -0.33019703994469557, 0.08829988768688468, 0.559062264475523, 0.19090137612894628, -0.03526467815176681, -0.4245335302417281, 0.22997863663639476, 0.01509876270431435, 0.2518925924903613, 0.41228416275153384, 0.21593564810898194, 0.6312383412210892, -0.03324280302612736, 0.5717996486672398, -0.07927719873027114, -0.3737453328494781, 0.01196831103493446, 0.010000998416799209, 0.039486189389719005, -0.6128113124715691, 0.22931494984675413, 0.20960028086603383, -0.0539714130275356, 0.10166911811252072, -0.12959319661392066, -0.07182941622040061, 0.3764684795436205, 0.5355107942056042, -0.07702024175039257, 0.3583753354332441, 0.02395801676208386, 0.5801788733636315, 0.2307436039175952},
    {0.8015372306124051, 0.11161224179346281, -0.167274960190271, -0.1043531633779588, -0.3547050073555172, -0.11955092853517293, 0.13461692132175831, 0.23660735820974735, -0.17325530355880037, 0.15686538106825174, -0.45879975239603804, 0.2516498984803807, 0.27005621693194953, -0.6537490127287968, -0.2479297894260357, 0.36016299744002067, 0.7740984224974712, 0.2551890577236255, -0.4770710502112879, 0.2059414446762406, -1.3796460012593803, 0.4703403905618478, 0.8468146059057273, -0.6147012057682305, 0.32098917624696216, 0.08210566248414167, 0.2711827795221776, -0.2925672886903877, 0.4585721554584625, -0.5826113450310357, -0.07157633752819414, 0.47525210596364836, 0.6023276968132044, 0.06568908309656755, 0.4263901129519694, 0.6160533285384833, 0.2577009765504977, -0.46410185192481895, 0.1438794601836354, 0.19033699989489158, 0.07490619457491254, -0.3389271585369193, 0.02246541352470862, 0.17180453653242728, 0.7870292938801268, -0.5364687619777773, 0.3381233987350492, 0.20675681375632204, -0.08447311429081122, 0.436392396329623, 0.14789040119923294, -0.37777322816756753, 0.0624586151386308, 0.16258048782923507, 0.0067207444060893426, 0.1634516242778602, -0.40056542920147037, 0.30006759929946825, 0.6094716973221614, 0.21850969801468853, -0.3166057796088157, -0.18732504469378436, 0.5665515158574743, -0.08568080795877615},
    {0.342439380993485, -0.06133618976820626, 0.05804235263869213, 0.2292178337046723, -0.3914368055338457, 0.13042022538827971, 0.4158752860927183, 0.03794062457589798, 0.25717643937763224, -0.2906461208997537, -0.17425731949635784, 0.1524491592235372, 0.04156522066163331, -0.15526178702000504, -0.2333495104750457, 0.8527600576168735, 0.14187251797993278, -0.06393652477907318, -0.3591268031428281, 0.5806937597860237, -0.13799007114169912, -0.2055750892202369, 0.06115592456823302, -0.025140015477534337, 0.19218087530528935, -0.37520082252327036, 0.11446732385912677, -0.6679489162456634, 0.265626976004569, -0.13546797407297761, -0.5667808055628001, -0.16190800545914233, -0.19677085906397662, -0.1439257309946921, -0.4695902197821569, 0.7833157072046646, 0.22431561108308293, -0.22436380088870647, 0.30707360879143525, -0.2437900955935932, 0.1846443460627913, 0.44325821187634157, 0.7353460968059407, 0.09400876360120981, 0.25766947839675575, 0.04406508566460803, 0.5751442366653108, 0.40546860427309495, 0.5694969843246541, -0.08996166716077879, -0.007731939119399536, 0.5264380058723089, -0.10800289518806393, -0.47998383131959776, 0.08436126315206673, 0.006953502391014112, -0.1838071694293905, -0.1390505760016058, 0.26085873693097056, 0.20095621199281627, 0.10333353695428561, 0.29591942310392966, 0.42687490451582366, -0.023689193122914672}
};

static const float b1[64] = {1.2013213371019071, 1.1448374863412236, 1.2246235578341838, 1.0880530294766142, 1.088780817773942, 1.0993078968843302, 1.1465660134575757, 1.2633470881538629, 1.2088705865630276, 1.2276403740007247, 1.1877990259338829, 1.2241902982159043, 1.2114404005538624, 1.117417009288462, 0.9916814125074502, 1.1329529247727859, 1.182449923836073, 1.0326086591933683, 1.1822239102864818, 1.0380666304542998, 1.2499053846395771, 1.2353475374108924, 1.1297638813083066, 1.1784544007357056, 1.137494009832704, 1.1453051179376086, 1.1983343792525194, 1.1884483098022314, 1.1160544606682423, 1.147967397127549, 1.041589155429204, 1.1261417500609154, 1.048714226823692, 1.200742397817915, 1.1907923830920182, 1.144302400688151, 1.1758439819301112, 1.2294173915399191, 1.159098650767604, 1.256751452626881, 1.1679205564908663, 1.2354681867350614, 1.1698657354068553, 1.144126086047522, 1.2218106781970144, 1.1331532547122114, 1.185684445454679, 1.1765903097110624, 1.2062793935147895, 1.1783713038104535, 1.1651236350875864, 1.2519995689306564, 1.1420055777130151, 1.1997260504160854, 1.1318146055756222, 0.9489526650251048, 1.037875238953759, 1.2070891766923955, 1.2249454219364226, 1.1260882308503963, 1.1657370461245284, 1.1418475334690392, 1.1969838311689307, 1.1822675627311199};

static const float w2[64][32] = {
    {-0.11958532218758722, 1.0594246810897836, 0.8118015418293079, 0.01554015310560416, 1.0530664142593964, 1.0063671858306962, 1.0784668995743851, -0.004434015391654984, 1.0436837258989358, 0.8235975071889557, 1.133096239702879, 0.019119255627936562, 0.8505884056405986, 1.1762442027818103, 1.0736973522672117, 1.332759134273625, 1.0964599362843364, 1.2140874476098207, 0.969129714471971, 1.0945493870612606, 1.465352828199432, 0.9654121366836207, 0.8213930028783895, 1.0220748493050156, 0.631803736615665, 1.0959317012413679, 0.9592869215106943, 0.9516307612485643, 1.0757050727641595, 0.8111622133520745, -0.12597082298068218, -0.29298911465214844},
    {0.20703368002405875, 1.0185406735225648, 1.2016823315390146, -0.027774726837216813, 1.3178996030180155, 0.9405018834584117, 1.0116908831141378, -0.27156829080481504, 1.4194465996870034, 1.06613170003858, 1.2542486999153333, -0.1318054131121849, 0.8763139409212184, 1.006973198213896, 1.1747587909487707, 1.0357977989236993, 1.0930655666025488, 1.0470503396539035, 1.2360992027165663, 1.1313919626740794, 1.023129559343582, 1.0241817773874524, 0.9339656584325047, 1.0158494203607351, 0.7400517886175011, 0.8147768859041242, 1.1035883079769961, 0.9979096793465632, 1.1376111947014833, 0.7222861108366366, -0.04196501885368232, 0.02777511528585493},
    {-0.10747259111577297, 1.0067730328798576, 1.2223585358650269, 0.041643733169823775, 1.048150519154618, 0.7891870045369331, 1.1574053035781522, -0.23033169332741601, 1.177504722398234, 0.7137154745059064, 1.5010612697404355, -0.260210894288424, 1.5288707478005994, 1.1007946684038084, 0.7905430076274942, 0.6471671143672504, 1.0731041322457968, 1.285812213125329, 1.0060262940483475, 1.1960395096777259, 1.238902631119305, 1.4059552146993082, 1.0363995422286247, 0.671804321859989, 0.596414927120669, 1.395307641544212, 0.6299549834769163, 1.1247889615999984, 0.738654043093628, 1.0251535189043604, 0.1272237581154877, 0.08715631453188949},
    {-0.009770415732346396, 1.2647532762470353, 1.1598916632629883, -0.005694737764636993, 1.079712225412719, 1.1710301684104873, 1.3493900498401812, 0.20016021758313032, 1.2507547518159363, 1.034506979829956, 1.057226703961508, -0.31995010953715464, 0.8814030177505527, 0.9894861799092456, 1.0868610237927745, 1.0746715707698262, 1.02836546650726, 1.1034984758439856, 0.9350546221456862, 1.2554951414076858, 0.7886037191110297, 1.0921550025521394, 1.0006663959587316, 0.7889830763208282, 0.9585007274224608, 1.168217975545302, 0.9633677599120033, 0.9759378512959381, 1.015488433892316, 0.9217308804704882, 0.06171489382715162, 0.042005906709618665},
    {-0.022252111268825762, 1.0353286864162474, 1.1141782583865163, -0.08362315631965095, 1.0959117762744492, 0.9383466152235306, 0.9954588743351691, 0.125462412904881, 0.7538731568152479, 1.1380928111286523, 1.2416550830482147, 0.09325991086237524, 1.038968477229736, 1.052626982356605, 0.858147506730895, 0.9730980102791388, 1.0105142599609245, 0.9247752467098374, 0.8846901753655587, 1.3334550494440394, 1.091809432284524, 1.0535912595655696, 1.138596485418565, 1.1197208776797272, 0.5632398602194497, 0.9366778314062805, 1.3717015047478132, 0.7206640713158939, 1.1896740376165298, 0.8447604206119904, -0.006179379400302353, 0.11912509800640811},
    {0.0735588380072612, 1.2331632374901182, 1.2574794112278334, -0.4181305850592741, 0.8134108991061149, 1.140843716848552, 0.9846308381108495, -0.06914569972012247, 0.6807609791024285, 0.9544145072695809, 1.0776584027692129, 0.08235376203843496, 1.0446462115420743, 1.222229139826257, 0.936704967416351, 1.1656783824545252, 1.114655992674851, 1.4254754740614282, 0.9191282415817255, 0.7729965491460443, 0.953964739841141, 1.0386967619524494, 1.1846848317125902, 0.7261471890820241, 0.36356933532502106, 0.9773358787100549, 1.169213055136933, 1.1442563612105021, 1.3563058275596718, 1.0557377510961274, -0.06610052258296693, -0.20362360740286495},
    {-0.17343177465436665, 1.2062046754130396, 0.8860464434129585, -0.011127551940935919, 1.1169785980477631, 1.0996906680909417, 1.1338727015711574, -0.055320444163730255, 1.210390735343007, 0.9148445138680662, 0.9134626062063744, 0.09346331477328326, 1.273033680392437, 1.0798267607756842, 0.9460139831365573, 1.1485391974173433, 1.0568257100374399, 0.7623666592386091, 0.9654913472715437, 1.280024919555165, 1.4502444749979373, 0.8486958279931308, 0.8693683227859512, 0.7598843693664687, 0.7132635319367493, 1.080261932156344, 1.0624753083072345, 0.9438124317886265, 0.9290646990903304, 1.042932976668323, 0.09540578601478907, -0.32365167820303964},
    {-0.14276485042128947, 1.150329355704367, 1.2034058007250632, -0.1729522092196136, 0.8386039018982144, 0.7564693802972969, 0.7683202401827968, -0.3066082626810655, 1.0214579472927627, 1.2339745348051052, 1.1231427388049702, -0.05247261717077219, 0.9212167386052403, 1.068364681387006, 1.2206699412349005, 1.1566414688192048, 0.8484062159919691, 1.2875096796976235, 1.241816689476455, 1.0743205965464118, 1.175676826546591, 1.2374492730330064, 1.1584548490320492, 0.9883914447352473, 0.521313585347713, 0.989953376005588, 0.7651650171246646, 1.1252072890945015, 1.2445174287695615, 0.8327804914668631, 0.19985574093630204, -0.2970804632040396},
    {-0.11021045585651128, 1.2330344333776146, 1.2315495254472633, -0.022463406684258964, 1.1161372070394577, 1.2240690834230197, 1.407032356166701, -0.23886179414918796, 1.13870378108289, 1.3737155776901684, 1.2375370343635004, -0.31128202969199426, 1.172257300349103, 1.0982302687756058, 1.1841303470656954, 1.1778134604482058, 0.9723368415069622, 0.949160102325142, 1.4491739849648917, 1.2278968335938458, 1.0143586396531479, 1.102801488873104, 1.4707065828906198, 1.0163660003755572, 0.6536944247362984, 0.9750449673186238, 1.0598884205524204, 0.9743312138207383, 1.2479844109898826, 0.9500352464435751, 0.21000622787549816, -0.2082954876133083},
    {-0.13902608696458166, 1.2292081877256331, 0.9390683073885114, -0.21639394345302124, 0.9736368393840787, 0.9051027910637529, 0.9958017733589416, -0.22277668082918015, 1.0872499440179868, 0.9746945172126635, 1.3041756340367345, -0.13918988369780047, 1.5349035264109048, 1.1632288625675742, 1.1238887496421488, 1.1830845955533031, 1.1186812135457882, 1.1116848849757943, 0.9735582960430835, 1.4145062767358643, 1.2402566624220077, 1.136464381330027, 1.0107943612398111, 1.1501609401871804, 0.6162856196541006, 1.0181947457929068, 0.7510651315496955, 1.3033922743579993, 1.0597830369693777, 0.8893570000942702, -0.07046343238142413, 0.14876787728166416},
    {-0.24898365378646453, 0.9953020756658042, 1.1635843600843918, -0.16729351558413294, 1.2595334303334957, 0.8230919760154358, 0.9984057051438077, 0.1610070368276389, 0.7760383789730453, 0.8883843094078683, 1.3041115905847416, -0.13720690193994545, 1.1843916845673808, 0.8850476818785973, 1.098828800221457, 1.3773863288295805, 1.163379546059284, 0.8692689500521805, 1.3016780969612367, 1.182376905569795, 1.3378286949769422, 1.004881839865244, 1.0224382453446124, 0.8286787695397505, 0.21876165270223008, 1.1405437008698354, 1.0862173378544075, 1.2214600846828332, 0.8226847711755968, 0.8537162494182531, -0.08457962134189695, 0.09677779467009798},
    {0.0904293424098318, 1.0242211915109836, 0.8789820476025684, -0.046164644976433175, 0.9879459519814426, 0.817732180381435, 1.4464722353464488, -0.22921105685317925, 1.0744017076017702, 1.3305735229329356, 1.0394848028985675, -0.06856654899947703, 0.9022396627994611, 0.8954326216709769, 1.079836163631461, 0.6981557264150476, 0.9595808732382142, 1.2010631278849437, 1.3230597899448875, 1.3123444492351806, 1.4476187830724234, 1.0094106347633294, 1.0751060783129887, 1.0393679465928036, 0.6469920726273021, 1.0424196427238528, 0.8913310217611892, 1.0725964953183562, 0.9975877985021687, 0.9405567659443868, -0.040737859635097885, -0.5859073578288589},
    {-0.013637560068854844, 1.0695294222147722, 1.214417727482461, 0.009313226774977326, 0.9895664575462615, 0.9125970229346203, 1.1604650216414825, 0.02948652029848952, 1.2252377454839456, 1.0005306882833491, 1.0940266244613441, -0.22066174836414354, 0.9870508815333446, 1.3004226069400509, 0.8597765129382174, 1.5952570385112854, 1.1626757821640197, 0.8917045665099579, 1.2077251747443727, 1.224239261523078, 1.2185411878445778, 0.7486513458638077, 1.1849333570635672, 0.6385755115769254, 0.9118153455908459, 0.9877425915087166, 1.0970078666433836, 0.893824198618699, 1.024943884198867, 1.0481272427761577, -0.2924543873950455, -0.18597302715468111},
    {-0.11210385176931507, 1.1094797286627127, 1.0424319515343365, -0.06471016143238838, 1.1179946407836236, 1.0841366379538633, 0.7047392915331523, 0.05729365413614925, 1.0157636573198783, 0.8513603666771631, 1.2137232184739364, 0.06092961840495297, 1.0127101244379948, 1.0629235903470677, 1.20479539120746, 1.387983239628194, 1.182112768925629, 1.237487456787878, 0.8760248871869656, 0.8349733112414712, 1.1531136229742367, 0.9221007138837304, 0.6759230874331781, 0.7984026826138579, 0.6734524587269612, 0.9043091225302213, 1.2807609060411895, 1.3484495399544503, 1.0904387746339292, 0.983698021710844, -0.5273413350857812, 0.1405770590504217},
    {-0.23377409720937498, 1.010054514578347, 0.9854622443584173, -0.160825004767447, 1.05703078796583, 0.81778979608447, 1.432440158115482, 0.15502632744456113, 0.9867816101037785, 0.9917745863995158, 0.9344488344111481, -0.005918215315389162, 1.0899962292461434, 0.9616134721088734, 1.053264921924845, 1.2173695405331704, 0.8509959238048044, 1.231875389805457, 1.0525506470946266, 1.0540981946830366, 0.32944799876009473, 1.237908229484122, 0.975441291867396, 0.9258837971785925, 0.4361926813840296, 0.9847162655606636, 1.1269785888764403, 1.2612899962100084, 1.0643348852502272, 0.8088477920363997, 0.07966342432699888, -0.06229030319185063},
    {-0.13111788359956392, 0.7729593175541447, 0.9642719059177263, -0.013500814348938446, 1.056153884151377, 1.12273443991028, 1.035961884437088, 0.1231638928357015, 1.1897346945489837, 0.9895400949208155, 0.9630753054876605, -0.17019341276081304, 1.0258147538224556, 0.8869576119624598, 1.1372780014902633, 0.9491677090779238, 1.014326426241408, 1.0593835081977965, 0.9224679029587068, 1.1552889851967216, 1.361538965904061, 0.9412128879438975, 0.9143382657099576, 1.1767875106687447, 0.6790764277539844, 1.1623979281866417, 1.2025525710440925, 1.0050638563049832, 1.0555757383998405, 1.1728171344322842, -0.051187140814079435, -0.14987038492278043},
    {-0.3074152053246227, 1.0145049075432, 1.2638243765855528, 0.19920240520831511, 0.9403505439302022, 0.862305986455707, 1.0870773555565012, -0.10768530304795997, 1.170092097373709, 0.8293031422878779, 1.224037693585449, -0.15519794715566693, 1.2457307448387822, 1.4447203567382156, 1.1169028691046943, 1.4501199977411559, 0.9817655440864923, 0.9945368492332122, 0.9579660478365256, 1.1108696489711967, 1.0705608927852466, 0.890379990631829, 1.3235477666236093, 0.8222564124499571, 0.5531686440422402, 0.8958920636063032, 1.0570451628100386, 1.3079117966538187, 0.8436063334326077, 0.9553913802526861, -0.006536276048625708, -0.03209474755384284},
    {0.04542929121121837, 0.9420689641509741, 0.9791468592966371, -0.07377194951655176, 1.0296329636371582, 1.2586187361909464, 0.9130395002961869, -0.1717694489582696, 0.9719391655064614, 0.8945017074776276, 1.1733616216064189, -0.07047945264165362, 1.3796191672067286, 0.828746704868025, 0.8076942075484894, 0.8358567114524977, 0.7554668343117604, 0.9654423012774043, 1.3061433702322347, 0.9713081734999454, 1.0668242540222712, 1.0207695418468707, 1.230930927141506, 0.9643651075496278, 0.5462943842047856, 0.7536122870828079, 0.8954964370414695, 1.094424326136994, 1.0775809117012527, 0.9711424925936459, 0.1721942062371825, -0.3468152835145747},
    {0.053378961619467716, 0.8370032790448898, 1.0388013928257251, -0.10630835192016035, 1.0149332147388996, 0.8742955940323712, 1.1055442641887276, 0.06091733423112926, 1.0358082221814209, 1.0430731978629597, 1.0391986769209054, -0.08894176884052245, 0.924868061221429, 0.9928597236858316, 1.0207443357941268, 1.559405675518772, 1.2467504708633466, 1.1852250336537362, 1.1167550035529383, 1.2585735586714863, 0.9543591305345613, 1.2721969339098134, 1.1118900397082285, 1.0442206345115388, 0.5711372584992948, 1.1769142855015076, 0.8580285498728594, 1.130603672165222, 1.1085859489964935, 0.9873155169377272, -0.18543303376042178, 0.09703092354451784},
    {0.19350098538387672, 1.1029285829292088, 0.8872146435600329, -0.24034707564475752, 0.5467455144234862, 0.9232450899873539, 0.8097895204504586, -0.13219175379016307, 1.4803598955138142, 1.2210159352932735, 1.2216093880937997, -0.023658587451255198, 1.1779124764337354, 1.0731690966428147, 0.862057748184093, 0.999878415102687, 1.1610458311194098, 1.0685199972742583, 0.9257093828539976, 0.6778240245370531, 1.1364111387090932, 0.9702978193747807, 1.164861780693557, 1.0793189293681578, 0.3529494213746318, 0.9190936675026684, 0.9445561225849939, 1.150832046336888, 0.9580617575610834, 0.9397372261589585, -0.19908361636433375, -0.07492281450090742},
    {-0.3411021140350058, 1.2334822580800349, 1.1113653987722916, 0.17524157870147458, 0.8786386918736235, 0.8356063263837464, 0.8329993995317064, -0.0906012580760268, 1.128791137368599, 1.3818482301151653, 1.2648850367028304, -0.09838257735098074, 0.7760357964495189, 0.9389558161301697, 1.221164015605083, 1.1598887599431598, 0.9166389643482642, 0.8644652459085814, 1.1805477734229597, 1.192796902151021, 1.3012779351739896, 1.1218275402172884, 0.8975746820609379, 0.7923760468343193, 0.2844247144543669, 1.1567915193012233, 1.0793318456594643, 1.0431516777844752, 1.0247276463318777, 0.9950365296567305, -0.227771658243358, 0.14765220283868802},
    {0.1722425011524391, 1.101215973733284, 1.3019668932307873, 0.06713088126230952, 0.9845895411644667, 1.2401345673986586, 1.382300335281965, -0.14629390714578344, 1.1279668265529001, 1.2326586312661205, 1.187123953860269, -0.29686466326290134, 0.9774625324628121, 1.0276217895358648, 0.9352238871791126, 1.2165476591653572, 0.637298980112561, 1.1061567118960205, 1.180854616844116, 0.9396545428379492, 1.6161169039747634, 0.8253314427373987, 1.3000130713761469, 0.8319998489488272, 0.5637356819214648, 1.0983686066179505, 1.0664924259353157, 1.3707914298476314, 0.5297372704270209, 1.0314137564288413, 0.013380304418982601, -0.27245155345163774},
    {0.2097159670160541, 1.3964512635165474, 1.1745906515959945, -0.29873751009080635, 1.1581585645065386, 1.0218731436587072, 1.1912122147302318, 0.22534621501671429, 1.1494265808570532, 1.1407745795961453, 1.5101339281611759, -0.08723720404244381, 1.3719589360993363, 1.0123833706866003, 1.2440315875580226, 1.0282499247656842, 1.3409953309753686, 0.9918364956082848, 0.9527059164488942, 0.958417181658325, 1.1766612409550803, 1.111356656417531, 1.203237932383431, 1.1171966491757614, 0.9158294106795412, 0.9393519133139709, 1.1648695565877072, 1.1142121002185696, 1.1623782263603517, 0.9703972943853029, -0.11996485846596773, 0.20375190488877964},
    {0.3003990163564261, 1.063088961171127, 1.3052802935626526, -0.030642417025935495, 0.946363538332101, 1.1522593692605225, 0.9324025336223584, -0.3079742594835957, 0.9608730976214067, 1.1250211538161752, 1.3096234142576473, -0.10176812561728721, 0.8361093916136207, 1.2716755145988294, 1.0148516835268568, 0.9749665266391295, 1.0421266628179628, 1.047540284774079, 1.1004198234473246, 1.0025531931724687, 0.8941052978561933, 1.1828104840371183, 0.8746938445155304, 0.84514175686168, 0.8635384908437811, 1.144892191965902, 0.9970663093927409, 1.2131215267873101, 1.0803294976570497, 0.8602338511251684, -0.0020756491249128432, -0.1009929326823338},
    {0.20156310302821717, 0.88285326708911, 1.0388697385774661, -0.34225749532988126, 1.0868616883130704, 1.0561136737936463, 0.9921107110446464, -0.11760613815840032, 1.640091803536637, 1.08161213240635, 1.1114485552581783, -0.10649723703687529, 0.9561030350702853, 1.0435179386872524, 1.2129500142052851, 0.8140360293256829, 0.7120525423027982, 1.0278305796446556, 1.0395056586679818, 0.636407592227203, 1.0317820225616061, 0.962971802028609, 1.3506235929626438, 1.12169497093694, 0.7952429560286507, 1.3088792724625788, 0.9563751214314966, 1.1655944583786078, 0.8165924123270125, 0.9414413044609249, -0.03624175433817775, 0.063587832976468},
    {-0.2210178983157835, 1.1292001625105823, 1.063268057618639, -0.25759587770437886, 1.1098355102963156, 1.1021467596234829, 1.2832842748201223, -0.07305994879107247, 1.071618189154349, 1.1173622062781416, 1.2270756794098385, 0.38547377822777085, 0.9426989377986522, 0.7797713830393777, 1.2704526627938884, 1.2640411716759292, 1.13886503999016, 0.9865746092677302, 0.9895059457153285, 0.8890016571627553, 1.1732191489736292, 0.930906779879811, 0.8463727145080314, 0.9540436440841228, 0.4696920501236305, 1.039484247176477, 0.7869635958045599, 1.1426241021311145, 0.6121915605362145, 1.0267348637863984, -0.011944055211778024, 0.03924174153924098},
    {-0.02585276410108291, 0.9308783356485473, 1.19672163191094, -0.2692502160513981, 0.9360921443264978, 0.8948230498720464, 1.315055538720298, -0.10803785232718748, 0.9872620476075419, 1.3564216037253642, 0.8570693880828739, -0.11412891672764934, 0.9041256194441991, 1.0869078373812064, 1.0666264848508247, 1.155770186006427, 1.0482767218913511, 1.1169199177234919, 1.0995603321928171, 0.8780634811515519, 1.0272870358661566, 1.2446508336289548, 0.8066944792070333, 0.9416837003462454, 0.7749922148166087, 0.9392206191526722, 0.9241699876867958, 1.0964835960353059, 0.957463108433189, 0.8732308638139596, -0.36979544033473816, 0.15172631556303184},
    {0.20440909928121404, 1.100239110590292, 1.2151228799658007, -0.3630824216117593, 1.2048713855213595, 0.8812036572431264, 0.843205641937538, -0.008217134278136069, 1.107785015589594, 0.988676271915381, 1.2797617945572297, 0.07954332496496279, 1.3346937386662672, 0.840112660502034, 0.9981544782937948, 1.4641891262280275, 1.081573573682779, 0.6867542279105169, 1.3344674041869362, 0.907539877290012, 1.2304375388140427, 0.8553535112412015, 0.8978416559283242, 0.9736199553011282, 0.619268514444704, 1.0947054849726015, 0.7783699392718946, 1.2441237147091204, 0.835892761246852, 1.0643241364283191, -0.2144087017086073, -0.23746302665281865},
    {-0.2673309981464775, 0.8548036181693988, 1.0452231775721816, -0.147339687672303, 1.0532180715269601, 0.6789200253977051, 1.1562913029108746, 0.05072305797639446, 1.1503000870250926, 1.1574552059464285, 0.7834461265933893, -0.11989014379246243, 1.1463634895692432, 1.156966012051498, 0.8702980760012776, 0.6956508804647759, 1.1808540678499655, 0.8531091019975079, 1.1574694568583075, 1.1714678648055161, 0.9405213610451671, 1.1808000305925241, 1.146833406909239, 0.9059508925920766, 0.5661557539175806, 1.0994987886647885, 1.0379540556227433, 0.8450597190052781, 1.1601556640417945, 0.8473134603251247, -0.028450941562281184, -0.10978530617467999},
    {-0.04949461718407687, 1.1215194374464463, 1.1250301398435274, -0.4927463300304273, 1.3898043924484456, 1.080178890219645, 0.9733208326700538, -0.13883431944010777, 1.0155471740233837, 1.2493886576244653, 1.0435697979447311, -0.07095735160526517, 1.2140986511177823, 1.0860877042365822, 1.108915291451286, 1.2200660304742943, 0.8644659850255382, 1.053442896547562, 1.21374426996479, 1.1489944776062142, 0.9738954272687402, 1.1806808169407896, 1.3564551302820316, 0.9617605958944343, 0.4993953963323936, 0.9141413314054005, 0.976238594969029, 1.3036184953277887, 0.8406079943875351, 1.4238849723584477, -0.13305021370380646, -0.12307785453299007},
    {0.0829393161976376, 1.0131126657340481, 1.0116901511180503, -0.0021522695641626914, 1.197481498808286, 1.0908501769860355, 1.3848548901129119, 0.03871246633284156, 0.9262141636537755, 1.3158355150913006, 1.0181410097448456, 0.05504438300745825, 1.1347002795029335, 0.9457318245236667, 0.900719375305513, 0.9117035561832406, 1.0930892361853521, 1.1921916938660488, 0.9828277604001927, 0.9991998925409136, 0.9406185506814215, 0.9566750515002519, 0.9530587052554309, 0.7365201635323033, 0.5272558085955146, 0.7403696123558452, 0.8694534176509655, 1.0454037546458197, 0.7812639850958969, 0.9753091027807822, -0.2681094437313148, -0.2725966199889938},
    {-0.2547663057262307, 0.6005771851052508, 0.9577417656130176, -0.20164582362719574, 1.052354395879581, 0.8867409711170189, 0.6044596749763557, 0.09011236930932073, 1.1531184698094865, 1.1625260012637142, 0.6319719674042676, -0.2538554279803191, 1.3934401416194093, 1.0161769487481676, 1.1304639336789584, 1.256301417240201, 1.0460488907448702, 0.965680546380548, 1.2305830988135182, 1.465242636538858, 1.1045126159810537, 1.0512559518041895, 0.975328663377155, 1.3311380331455192, 0.7266883797117086, 0.8399859363351772, 1.3064030649575917, 0.8072715851577377, 1.0860744544974934, 0.8737068250055298, -0.2996091008307673, 0.09218146542870133},
    {-0.22237952319040857, 0.7619161229096195, 0.9359661093698429, -0.5756320242694627, 1.3205600835012474, 0.6579926929404026, 1.0913953526760465, 0.06399805198648559, 0.9357999976009609, 1.4436482756615507, 1.1395838073659463, 0.10519169905756987, 0.95788116203341, 0.7417235976658506, 1.0012707043727955, 1.0771717818883964, 1.075672920239376, 1.017828452402201, 1.0458936670461905, 0.7424160502317726, 0.995630211378658, 1.297599453793131, 1.0917735751432327, 1.189876112919094, 0.7002397269699474, 0.9870225614337926, 1.1831525155355322, 1.1371115649343286, 1.1310700221385508, 0.6316547550797009, 0.2172289650395033, 0.11700026052530846},
    {-0.1360620897865682, 1.1894671831951098, 1.3766320590467371, -0.18176559227034308, 1.2003831776652867, 1.0611473838075838, 1.1516105853428529, -0.1059656511836501, 1.2738484095484368, 1.1525270951331614, 0.5608866728734844, 0.05531705632929674, 1.0483091039917758, 1.034390657075304, 1.0347956174707005, 1.2748457325692963, 1.3410749128061332, 1.2841504484186865, 0.9258243311414487, 1.3010578633676673, 1.348483877118963, 0.9635847194862052, 0.9297990027197163, 1.0205901543458926, 0.5348112570762377, 1.0921643202445956, 1.165848656220415, 0.9628602092514903, 1.1184038379766226, 1.191540444772808, -0.295167374945129, -0.3062817601985376},
    {-0.14916241306017997, 1.2163137748280923, 0.951703106597853, -0.6462926016999168, 0.9505778193061032, 0.8571523772293006, 0.9031318818760363, -0.007103822887013313, 0.9436817423676713, 0.8027556729258123, 0.9697822116979712, -0.10496827852020117, 1.120487947293403, 1.4959528621650435, 1.1249071584555763, 1.017032013619951, 0.9211008641304598, 0.8988266980840544, 1.1950321386957634, 0.849668728165324, 1.411388770443996, 1.3731455842366085, 1.0439425826739237, 0.8626049601816831, 0.5778445186816747, 0.8899353099848291, 1.2048719076906105, 1.0744019183309945, 0.7940444837677758, 0.6446031305264983, -0.04002147254799956, -0.20877066703466085},
    {0.035846466404449134, 1.1464780415622984, 1.00566069853772, -0.1043543630942219, 1.2333085996832236, 1.0029282997854145, 0.810733184368054, 0.0826412468030014, 0.986055139632002, 1.0866465606638982, 0.7244214081109605, 0.0123524249173032, 1.348268783553814, 1.039822691313567, 1.2720044464651725, 1.1491310054550758, 1.0115295557019615, 1.3011937701202754, 1.0261843531350454, 0.8281045450053142, 1.2663064089300295, 1.1309262073006023, 0.8867884035330041, 0.9954762614555195, 0.8189357825709471, 1.1540264969681195, 0.8562234233218904, 1.0836055983124406, 0.9410792100350478, 0.5379938166697945, 0.0746500192273096, 0.12898075000315146},
    {0.002094523343898952, 1.3688819832508043, 0.7657659018686879, 0.029873248700027676, 1.0636630447822455, 1.0010183547157072, 1.1666675564796383, -0.23063183164064452, 0.7882077961405477, 1.296761758225214, 1.0386196374560108, -0.14009273022539373, 1.1016284715056355, 1.0292979562898787, 1.2012518314103227, 1.116948157246161, 0.9458437262603143, 1.0720926559097177, 1.279686466451972, 1.010913633264183, 1.0176996014143922, 1.2014909734484094, 1.0507946724135324, 1.0857823704135503, 0.6238637398890126, 0.5884407264764767, 0.5411079042911725, 0.9621676543349403, 0.7223459799995936, 0.7685313447880585, -0.09613149453797364, -0.1333022105098635},
    {-0.14363807839975803, 0.8686115371408653, 1.123506438046816, 0.050904206451331396, 0.922082412126673, 0.9774540493464373, 0.9535406568012105, -0.16184936168879985, 0.9541681238284345, 1.1151386615307235, 1.304938315168247, -0.2305336516415485, 1.555634312819313, 1.0696383591886132, 1.1255467545664022, 0.90886537123571, 1.198920765692081, 0.8994464599703775, 1.1443652267465259, 0.9404011529491583, 1.1503086160845148, 0.9745778971667054, 1.104449452451006, 0.9663018891491836, 0.4354438093818183, 0.9553486276046601, 1.1112122854163256, 1.3605829940559222, 0.8803508947152927, 0.8441959327219702, -0.33793018109285794, -0.13550427791035508},
    {0.028224467173333226, 0.8343364791009881, 1.2855481782002027, -0.08255066731585675, 0.5743880786512383, 1.1142522757825655, 1.3805805373740512, -0.23040881954547332, 0.8096996855746574, 0.9863947951013992, 1.0650853798829565, -0.03105706157458687, 1.0336980065994186, 1.0798541369492611, 1.2076327876182633, 0.8413414344951512, 1.0983461783451975, 1.0998559052354793, 0.8903145493380851, 0.9085755411856687, 0.9351334787569389, 1.2294274940920487, 0.9997378951654314, 0.8526595745591918, 0.5339339633935613, 0.8266364922624895, 0.9453672656406509, 1.0766585659540886, 0.777811309765492, 0.658447370097184, -0.36181679041949905, -0.0038931513374195537},
    {-0.08261310530463345, 1.3804455464060605, 1.2174705694045362, 0.01574523572865397, 1.0322309444932283, 1.2842384394534962, 1.0407038263971131, -0.07988651874557874, 1.085751361855019, 1.1031222003736432, 1.11332459571792, -0.11166249542638913, 1.0114083714160824, 1.3438435402122775, 1.0704375952026246, 1.0477615451069004, 1.1301601003952648, 1.1758012719428788, 1.1313063941325756, 0.9627977864553033, 1.0704752928913155, 1.2237650994658227, 0.9069012072285101, 1.0332855364416662, 0.49409240353318695, 1.14302836841832, 0.7164110665473684, 0.8704141895393585, 1.3557751171275967, 1.2112781126588117, -0.08170105180474421, -0.19525619775436553},
    {-0.048450030827824155, 0.9151757009142673, 1.1642629336024675, -0.33945224215346764, 1.0720720392040946, 1.2294893254155068, 0.7298562110770533, 0.11058297783564743, 1.017566714952574, 0.893769312901921, 0.975847661407406, -0.08074493039841012, 1.1909684066291704, 0.956319064527977, 1.0452530607552803, 1.1434239126314383, 1.0686941491849618, 0.9067671288350432, 1.1892439210748103, 1.122405818965932, 1.1341638295788015, 1.1242485660255126, 0.6004219821972369, 0.7914410589370073, 0.5434513067034701, 1.1506276337018002, 1.037150461134067, 0.920209443965173, 0.6104215634933471, 1.1228198453812694, -0.19245627088176925, -0.3539215766890483},
    {-0.4077167035304451, 1.053714138380301, 1.1120994263080848, 0.16153717461275072, 0.8779686697171695, 1.151765824203907, 1.081246384171341, -0.12937865786689276, 1.0247791527819108, 1.2909776527986763, 1.2717262250284165, -0.05106757822700332, 1.070830743169154, 0.9768574259506873, 1.121100710931403, 1.1306050445569384, 0.7851512275573705, 1.1201540406617163, 1.1791694397770862, 0.9777066947295288, 1.4161330139721167, 1.0567135974013113, 0.8774760562737994, 0.8433577370041162, 0.66445485224869, 0.9822611916189411, 1.1033023143988192, 0.9879454802654536, 0.959555160297948, 0.7159063185955774, -0.17702754673220378, 0.20946984273925978},
    {-0.06998453179060035, 0.5808961819874406, 1.0846186037615428, -0.24159674269643436, 1.0975167469427622, 0.6843987546804338, 0.9292738299482807, -0.35569871359509986, 1.3365570487833602, 0.8767149322829497, 0.8902066156727834, -0.4834470161077251, 0.885094817429247, 0.9973520421854554, 1.3243009393217247, 1.0606487745962059, 1.3264724361867433, 1.26888420113737, 0.9319595562021844, 0.7831413915082239, 1.313714981173337, 1.1463476278956979, 1.2398930010747535, 1.0144772629709253, 0.48265956439479696, 0.9240062998499157, 1.3651449942098077, 0.8914114468031431, 0.7716181820806335, 1.0242724703718715, -0.0704809197074889, -0.034770037484121656},
    {0.002506276899715306, 1.008600043031526, 0.9970675083827648, -0.23620263407036018, 1.016092821777994, 1.0135627470845967, 1.2923201611555415, 0.18272310345468468, 1.1749745385658987, 1.0137209080455574, 1.2427030839965059, -0.09592388714143113, 0.8432863941295438, 1.2252213186639358, 1.021352524353079, 0.8135753647067518, 0.9094173372884328, 0.9342701498517474, 1.1007087081511686, 0.9600360523333997, 1.0799195310843432, 1.0171872202597656, 0.9749154213933912, 0.8851658944173907, 0.7384112807377248, 0.8715711491794648, 0.7912055254205174, 1.0720830124105603, 1.2453283005548967, 1.0306368191865447, -0.18745335835087143, 0.10966813222244431},
    {-0.08262884100089467, 1.3102295884146562, 1.109642403332457, 0.2054744090484973, 1.1248019400273874, 1.0705987173495146, 1.2593832177676163, -0.41920761360687486, 0.7799525235527995, 1.235566911056734, 0.8956473314067718, -0.17319461097739447, 1.1091887857535514, 1.2283149829861297, 1.082981020213706, 1.2132927891408245, 1.0407135251398114, 0.8507490169298753, 1.2367223305277744, 1.062581445115022, 1.2901888593646913, 1.377633108956583, 0.9589097755570051, 1.3969054690994915, 0.6893536852310074, 1.0795607732481383, 1.00770691349662, 1.1008900995832873, 1.125377575643698, 0.9166450787157685, -0.08238357528812337, 0.16775500822030015},
    {-0.1682596879586475, 0.9744068605924299, 1.0194436394640756, 0.0010471594229331713, 1.1069074619063275, 0.9013645350082391, 1.3031402950321014, -0.19396208823540437, 1.2613191118472675, 1.029969765336623, 1.1254524563768715, -0.16105111010940534, 1.0062685053316465, 0.8294531031129679, 1.2686199471266488, 0.9863222889750181, 1.1301960626788934, 1.0619966723617098, 1.0272250051291585, 1.268413178294543, 1.288061629948283, 0.9006301077831356, 0.6874428214964398, 0.7682561424678375, 0.23954191246113596, 1.1346582690045743, 1.1251331217252531, 0.849410984773827, 0.981206054318903, 1.0941523419624968, -0.14035537732682785, 0.18236164310331815},
    {-0.034073823471163917, 1.0425854873016602, 1.0737323371454992, -0.20102761420281934, 1.0893122586347623, 1.0155215845853185, 0.6675286524587178, 0.11844369708941377, 1.2225480487405287, 1.1671095410201404, 1.0798491510736943, 0.009703294565013995, 1.1366213423734006, 1.1091311092367873, 1.5240602144715574, 1.2326474148018833, 0.9976838162307463, 1.4180881659850204, 1.1774108308337552, 1.1856109620651125, 0.9548265078702329, 1.2905225936680373, 1.010641470330904, 0.8100695765556547, 0.738958554565035, 1.1050250888919428, 0.9182074479200248, 1.2914585831333683, 0.7096040174557489, 1.170316406981817, 0.07975056832081964, -0.022401163465525075},
    {-0.017902812700787897, 0.6953307754618314, 1.4066212073748472, -0.19741279425383534, 1.1958308457903901, 1.4178842264819553, 1.0381156079004008, -0.23448454294120438, 1.202370988470069, 1.0343552050996905, 0.9076016222959002, 0.11140677349193613, 0.8486581754219022, 0.9339040143237856, 0.9631786404694282, 1.0798652055480853, 1.2181469783519219, 1.1030881729174546, 1.0082899885556535, 1.271414053314883, 1.2417918727435056, 0.9938080595730782, 0.9756972089242587, 0.9444215392943177, 0.3887791541070003, 1.119256226724948, 0.8275570377524355, 1.5496447895488439, 0.8424869363806534, 1.3307039739507913, -0.05885872716177978, -0.08118567497503769},
    {0.17720672295829834, 1.215610660753502, 1.3415167638633598, -0.028854297674680392, 0.9262482155401578, 1.192674252078755, 1.0260129179203588, 0.05191499326151402, 0.9430072775087074, 0.9858022142141774, 1.2812241379651035, 0.046796846149555496, 0.8618334178860242, 0.9879339336013108, 0.8904081870081754, 1.0868317330557742, 1.0798566015166433, 1.15381711646421, 1.1587467384649373, 1.261698928949718, 1.3252094094547195, 0.7801656558715913, 0.8246561688422726, 1.0147994919542476, 0.3924293237649167, 0.9805220880029762, 0.8584556021678703, 1.064834259058655, 0.8058585680478817, 0.8513499616123159, -0.23181979623605123, -0.14547842119439988},
    {-0.012907121433210628, 1.1127678386242166, 1.097382503609052, -0.18677379538083289, 1.081931127503366, 1.0826182617137656, 1.3462337114561116, -0.4032795873376404, 0.8878532765218121, 1.0274426961556293, 1.2338013018647995, -0.26769136939387467, 0.9725988291494524, 1.0784874334630326, 1.078502406425299, 0.9497393629614334, 1.1152170673450486, 1.0462656301336306, 1.0428543602368958, 0.7788578430009797, 1.2619031685571829, 1.0945058880222542, 1.296758315026066, 1.1792661134691462, 0.711960468380953, 1.2467003266232728, 0.9500233734624071, 1.1692355733092874, 1.2042507378796201, 1.0804776799798312, 0.043429148065995564, 0.07644193513248068},
    {-0.21181863693489986, 1.1040869491139802, 1.1086873587395614, 0.021350134134077443, 1.2226687487221475, 0.7344658646538377, 1.0076680249478995, -0.13711589067373048, 1.3209550720747116, 1.396872411006598, 1.0561285513383918, -0.011185877872702555, 1.187071480527416, 1.015529342347377, 1.0598719837710313, 1.1934921577212179, 0.9695206786857117, 0.9642201097384282, 1.128399980708822, 1.2099550967675754, 1.0808932518496774, 1.1821374697652145, 0.8299988715111308, 0.9572589031552133, 0.5324640565299161, 1.0107607251538855, 1.0355233375674864, 1.1150313301648356, 1.0569903111116652, 0.7480937948600608, -0.083735843879791, -0.41539126518227637},
    {-0.1472700816756911, 0.9227614761204348, 1.2159996078961786, -0.1572241942961059, 1.1946528692071905, 1.1619328539817104, 1.0692535371494167, 0.1539422007864709, 1.3572011519373246, 1.083883174824072, 1.0581198681393438, -0.14754408331348426, 1.2096366870156572, 0.9285970252501039, 1.3158907556405877, 1.0914739682444494, 1.1759936892770884, 1.0232130961366162, 1.036894667091896, 1.2430881503764377, 1.3199760267987506, 1.245643053846736, 1.3239430491577033, 0.9209274678363235, 0.7235007427201203, 1.2887935341814452, 0.6657688133447426, 1.0924972707315797, 1.1404302539820521, 0.8694092082965451, -0.4080479652983128, -0.020433821112479288},
    {-0.09396862336595757, 1.0191430729013329, 1.458050505564002, -0.12726969590553247, 1.1469961441880214, 1.1983164957928771, 0.9979829306514372, -0.398790629719622, 1.238233810798416, 1.20994044737181, 0.9998793746921831, -0.04978088365010753, 0.9506644859127653, 1.1668265250028904, 0.8533509773586138, 1.0451136285868088, 1.1080698238610083, 1.2968488230264525, 1.4307217380805, 1.3177871807017485, 1.039735672744787, 1.1122383415649637, 1.192001441326757, 1.286718469271238, 0.5426199246172214, 1.330671605014611, 0.8843182355008641, 0.8441150046903628, 1.0646130260709923, 0.7745163408137125, -0.3146119999686609, -0.1708618113156304},
    {0.11529202597415297, 0.8909849027386967, 1.1059966294175538, -0.11144435318059125, 1.000826155667406, 1.1089482056625675, 1.033966933312275, -0.1871364175153233, 1.199086764716359, 1.0688575852036932, 1.0631041017906466, 0.0898318015655232, 0.9453772862434913, 1.0063845182391111, 1.1615837951812462, 1.285793836799557, 0.7955059887429144, 0.8550954920137988, 1.1411672704048492, 1.0351154789644628, 0.7842879902548248, 1.3361703241167115, 0.9128408348556145, 0.8830437756909332, 0.5534837619164094, 0.72912954227545, 0.774239600843181, 1.2621907031467428, 0.9080439998053818, 1.1302460911790781, 0.09283381480308327, -0.05163692417348319},
    {-0.1110909557056991, 1.1189113721783386, 1.169976212353302, -0.024278257840610645, 1.0849708849406525, 0.9700948770263692, 1.1239721890308179, -0.22791903445467795, 1.2581597685728871, 1.093533626803534, 1.3345515363851905, -0.2734116754707761, 0.9798261651894326, 1.1354240278129626, 1.1916643761624588, 0.8814582988327506, 1.0834474990113807, 1.3530087081779893, 1.1289501978062289, 0.8865557213970728, 1.0676033502979925, 1.10485787989974, 1.143600068753483, 0.8142815949060564, 0.5502985531749235, 1.1647900563571036, 1.2639514366260824, 1.2638448564197482, 0.8138258797078659, 1.0050125091159539, 0.15345392686451648, 0.14847272093023026},
    {0.08447197794070505, 0.7843443724426028, 0.8060692947899049, 0.016527823962458634, 1.069001105143623, 0.8688664819938219, 1.2255470444428411, -0.10623569342923594, 0.8639555275719049, 0.9693538391996533, 1.0130356716839652, -0.01653482024205827, 0.912901469689475, 0.8866273280965954, 1.1981245953828057, 0.9549501006602769, 1.1003834622589133, 1.0389507434083758, 1.0641087246613807, 0.8078619473768027, 0.792501276934924, 0.8758139269879905, 0.7726154786661633, 0.9357936887291792, 0.5336988907032875, 1.1801965682039948, 0.9346392550589153, 1.1089162279459726, 1.2115645738391152, 1.0322931391603836, 0.21227776221135505, 0.26981401731168964},
    {0.1341850033643279, 1.0449509011231284, 0.9521735701838191, -0.14412423243725345, 1.1465131285966312, 0.6951529210092, 1.2818647971479085, 0.032845734154821095, 1.0957409701460064, 1.2732817206468146, 1.1227898207991538, -0.15610984644002293, 0.9065988405753486, 1.000313155608699, 0.78828794483728, 1.0649367376034593, 0.996816605671861, 0.7761941845782806, 1.0007733152162004, 0.7968312433569601, 1.0872770772386737, 0.9847981511494495, 0.7673158018802247, 1.0950432883310883, 0.6255905136094797, 1.116111366069996, 0.9408847491378025, 0.7948291670161315, 1.1325023929394977, 0.7456403753815222, 0.029948007784603676, -0.2428636149799923},
    {-0.2150913613320667, 1.1155370100038513, 1.2252010607869588, -0.030437275510656066, 1.0112492417334884, 0.8137737242052995, 1.4465160316983197, -0.19472884800059162, 1.1856681619103278, 0.8141925359396911, 1.104179809400913, -0.3381607005067307, 1.1204838791129708, 1.3566903858174464, 1.3198332851576116, 0.9418025599742069, 0.9973972359620804, 1.1251687836901523, 1.1316240797096118, 0.7306224133858992, 1.0312532566281103, 1.191045725804273, 1.3159053795749338, 1.1140347475508559, 0.8223811413878289, 1.1621712333302645, 1.3958547174702594, 1.001165375239838, 0.8202671463097857, 0.8972386769126146, -0.3051942082300943, -0.13414650298560757},
    {-0.2699307816789909, 1.0407911075866865, 1.0169554259288824, -0.2321750621541903, 0.8224790521822744, 0.9812689058283623, 1.0494910559892199, -0.0902572166991756, 1.1737081684865427, 1.0487029672192385, 1.031677725488854, 0.2330309971620241, 1.2270575855467818, 0.8942702320048972, 1.33114157870502, 1.1588461013632443, 0.9401032923258904, 0.8741841128726527, 0.8418601396440865, 0.9041338966907361, 1.4395450687230074, 1.292816402113507, 0.9438777378086803, 1.0868061250850374, 0.5016835774506873, 0.9805671769491143, 1.1272275768593933, 1.0264554141378655, 1.1352827490038573, 0.922252370890126, -0.07580340971828947, -0.1700964729496911},
    {-0.021784650446423595, 0.5392959159937104, 1.1602162711302806, -0.26013186640489117, 0.8966507447610537, 0.9500930044655949, 0.9462068461353101, 0.007948788004115083, 1.200654303758777, 1.0171604701527743, 0.9940459147573059, 0.070400734004617, 1.006365102766862, 0.86575186871163, 1.2517253876879897, 1.0051155793114313, 1.1625125406837222, 1.1104371990144353, 0.8879607540902091, 0.8832585641041218, 1.1341913835753703, 1.1179325410121832, 1.3049619674320088, 1.03344093173263, 0.5042438504716071, 1.1925960083309313, 1.4295412991783427, 1.1738199576404524, 0.9405190208102583, 0.8427750073473586, -0.08026436055141606, -0.03977452889016178},
    {-0.0325557283819419, 0.8611131884179919, 1.0852754277842573, 0.033338721651992684, 1.1832448904827593, 0.919972281602517, 1.0784050890980543, -0.16204128781115, 1.0261493923232219, 0.9480153896865533, 0.9546871626587263, 0.2824969006435528, 1.0010525407665642, 1.3987496328299425, 1.143574352850779, 1.2693677198913726, 1.0822438013871476, 0.9283874984528065, 1.2667827404711454, 0.8869387804884135, 1.1757448586511945, 1.0156705870968532, 0.915096721289907, 1.2817816240899045, 0.7501216284058528, 0.9862172000514172, 1.0149460094793, 1.1780865664276559, 1.046652316072894, 0.8405094215964464, -0.09222937161879988, 0.09578123992708482},
    {-0.6633107804267983, 0.9022877503800305, 1.0716579471459928, 0.12476593164717095, 0.9601478465164022, 0.9155426750679482, 1.3369569313725018, -0.1383318822452465, 1.0221768373253008, 0.8566556425552948, 1.1158421246381862, 0.22055145487261152, 1.2137413933015846, 0.8559359696424483, 1.0913553755056717, 0.9241953719363539, 1.014201382649524, 0.8767246088690684, 1.207807963641435, 1.1163049195801313, 1.067544746529676, 1.0313605073976568, 1.0233922713653463, 1.155588986472098, 0.6996208467740652, 1.0854280859809013, 1.2196011863567093, 1.0682389406597954, 0.9237500415081213, 0.9021922164075299, -0.2074718835377331, -0.027108242361122616},
    {-0.3282849574451344, 1.0556345555142892, 0.8147200623406069, 0.05161108481327192, 0.9976342714552132, 0.9284912007919447, 0.8157144654109756, 0.059054057051208315, 0.8082617169968014, 1.3317991817604158, 0.9971000547590402, -0.45696173977307747, 1.0149092955993, 1.1068589531293827, 1.1594578799632127, 1.2793132013625268, 1.2056664856946222, 1.344207880659329, 1.1040208396990796, 1.330112769847716, 1.1218068956883385, 0.9158140177869427, 1.1998997226152572, 1.0138274679415373, 0.7225441035285105, 1.0125412757521808, 1.0066124845855917, 0.8942215826773274, 1.1181629616208721, 0.8458462855722504, -0.24791971259908635, -0.06377830516331913},
    {-0.10761407079320334, 1.1989509106733318, 0.9621325282398853, 0.3200142676569624, 0.9606348773528118, 1.1719022380434245, 1.3885093260526133, -0.2433474062368912, 0.8659919050947036, 0.7498156477740874, 1.1602729745103335, 0.14984459819182674, 1.0689423906058135, 1.0743392431834704, 1.050174878573282, 0.7162146551276725, 0.9533258579254013, 1.1011211286295315, 1.051956174986158, 1.3346164792083517, 1.1705738066463323, 1.3528262705780991, 0.9625146220870869, 1.3494595246024528, 0.942441802643506, 1.0533330624631332, 0.9151367658436378, 0.7170647978277358, 1.3030162965387544, 0.8956950599938911, -0.15417606386122573, -0.3444502096241642}
};

static const float b2[32] = {-0.09921063386762123, 0.9989069506543863, 1.0713915223413242, -0.10346360082392778, 0.9361283777615536, 0.9692785882790875, 1.0425192721555572, -0.09837294951708722, 0.9603498519536572, 1.0243824360897518, 1.0955495388720784, -0.07434840612831259, 1.0795624073192587, 0.938882288012312, 1.026668041796956, 1.0323055375880594, 0.9803574803663946, 1.0025370849968214, 1.0054859939028589, 1.004958781382942, 1.0585354730842864, 1.049769200777629, 1.029883157103204, 0.9606819322860328, 0.6553831423703339, 1.0202853424977112, 0.9103157786158306, 1.0737695696332006, 0.9610144429227396, 0.917758529961835, -0.07296534989048731, -0.10057969857792387};

static const float w3[32][16] = {
    {-0.11173295081035695, -0.05241265103269757, 0.19295462392450877, -0.18168923590425134, -0.2700185330649682, -0.04355643977013538, 0.04764088049523986, 0.05573467580282079, -0.3011746354962928, 0.06436890024479776, -0.049380068603146594, -0.12012743146236024, -0.10342140825544777, -0.10002155604001284, 0.30695462917132355, -0.15391083392582872},
    {-0.0996725704406274, -0.14390079931586575, -0.2025528967934751, 1.156342312665953, 0.5515752299424083, 0.044083244107633986, -0.09211963537693457, 1.485839142055016, 1.3798210780065159, 1.3162210133356955, -0.15183203627173816, 0.014965041755722294, 1.0838051284307075, 1.1362675718540394, 1.2296004494424309, 0.9276507545614742},
    {-0.2705525815550594, -0.017102415783409725, -0.36278061204027695, 1.0063204800700893, 0.003951758530530673, 0.07340091976229059, -0.16349559792752938, 1.396744316118189, 1.5947805614401185, 1.0960381234015444, -0.209036880759744, 0.20673583744537907, 1.101770361465146, 1.6002061078992835, 0.6484142440192718, 1.157142270779329},
    {0.2151160453141356, 0.47541648782829116, 0.2408795280193161, -0.27409358158189995, -0.25590103776209483, -0.2807088786692503, -0.296865654878265, 0.09970834958506786, -0.12287509324317133, 0.2102556558414105, 0.21667297215059228, 0.3735830087352577, -0.18858498666519521, 0.17415226626996272, -0.03719031025957384, -0.06374795021971266},
    {0.4316884575876542, -0.2688933148468102, 0.054452933771143165, 1.3074926309564678, -0.06988312522189301, 0.33444260631295747, -0.16100019796195955, 1.5530832615269026, 1.2222685135032767, 0.8207353766177659, -0.00784659738030681, 0.2802576465784262, 1.4219560607409771, 1.1835878710580563, 0.9478674998804725, 1.120142235797748},
    {0.025716399249584496, -0.23713746929123525, 0.09936204689135832, 1.2790398858708745, -0.12569079783544823, 0.33673179925408425, 0.05548828591564053, 0.9499411946373101, 1.3758002122755957, 1.1834703406954994, 0.427104900735, 0.3268802540592488, 1.5271873583758677, 1.086014799593303, 1.3353633185356613, 1.5065992640144206},
    {-0.6919461332023851, -0.33786139025132533, 0.1654947580092155, 1.1838916500511607, -0.13898664211658127, 0.21717781709697295, -0.32666606032460976, 1.2956033936132438, 1.611180261684926, 1.0120315859426132, -0.16172302779151462, -0.387444369164969, 1.0411596060681507, 0.9563923439815819, 1.028089399103747, 0.9873904924465168},
    {-0.23036708419852453, 0.12445513966011602, 0.03633163415332899, 0.05950190140102194, 0.2977735444925015, 0.06662322605063432, -0.19362007794736402, 0.23939803340637014, -0.040382740376075366, -0.04825537522909211, -0.047593326211933566, 0.09057765434116283, 0.05005572507271941, -0.28160609695939454, -0.31894822012716656, -0.39454410961707953},
    {0.14976550979050088, 0.0722121161369114, -0.20431653103310624, 1.203968880450175, -0.08509430076057968, -0.07454344503673767, -0.040389050618625015, 1.3927144736976063, 1.1660494309007858, 1.3174584715704452, 0.31510381474503135, -0.4144846385326772, 1.2369845816140188, 1.437249614072351, 0.9753730050228512, 1.0441657252870349},
    {-0.2049127695323335, -0.29533965281413305, 0.12482672225102792, 1.2153146441629332, -0.3365286100730202, -0.24029531267505266, 0.08096752288591874, 1.1074697777479972, 1.0846421961172887, 1.87559422700608, 0.06277022478156158, -0.22422012646419093, 1.2637806132492055, 0.9327724298274885, 0.8775215544294753, 1.2609891076105082},
    {-0.26033195287676514, -0.04832581029682974, 0.32937277432319917, 0.9667494218599979, 0.28179830242288695, 0.01579292257341474, 0.1423070588059897, 1.152771635622762, 1.3878592809108277, 1.0632572683590709, -0.35133172868188245, -0.45240872122505843, 1.4680480805366751, 1.277452770594784, 0.9113661132953877, 1.0763949189203506},
    {0.058214928108880334, 0.36367778969678416, -0.8023726392254381, -0.24172285725021722, 0.060829338970406134, -0.077640321325692, -0.12447544845935801, -0.4491003335651902, 0.06411856603855443, 0.026246730186773808, 0.3317856425460792, -0.01099996450441187, -0.20165717405289932, -0.0019512034583852986, 0.269661455753435, -0.3256907242188609},
    {-0.14866804192417257, -0.22004097388559135, -0.11105207022381258, 1.3433348735028359, -0.020357520037566048, -0.21078772692333073, 0.0274628417847871, 1.040228748291989, 0.605100161609301, 0.9091726551818865, -0.05559257603347182, -0.07834910040730529, 1.293213644159759, 1.205193203989505, 1.1989959047798238, 1.3193866788866573},
    {0.17114552586569107, -0.18026029233925503, 0.1365386739701266, 1.5287013687179558, -0.2771505229918156, -0.4629625904354633, 0.057784067665064144, 0.7389642909433617, 1.136311495354477, 1.2793877143732886, 0.45526114261227074, 0.2890496429168515, 1.4452298477214254, 1.6777842591263992, 1.1121076982695892, 1.3682971351721995},
    {-0.014170800712754384, 0.01114454980839909, -0.24671966550177812, 1.4716052762129495, 0.16443214487336086, -0.404327164589771, -0.10970332018295605, 1.2259505543260747, 1.4291564270538162, 0.9050559282353773, -0.4233726831806023, -0.05560372383072697, 1.249934383801818, 1.1496627027167743, 1.136137855063677, 1.1649197589458855},
    {0.040673763968383986, 0.10028499708854881, 0.06506062191593263, 1.2492592491642245, -0.25779693618396254, 0.0012436322147734444, -0.39090024668077694, 0.4637288672519913, 0.904196195802008, 1.4755348874504879, -0.25474945591569353, -0.12240921423843477, 1.368152259344422, 1.2956936299573816, 0.9019947325283887, 1.0768833064550885},
    {-0.18655002348853106, 0.11817226356439633, -0.06172680221318198, 0.9303709105056666, -0.18546536867697822, -0.27555067959410234, -0.1404854206216382, 1.2468928858781807, 1.3756164192388178, 0.5784031696954713, -0.010654744954026046, -0.07445867351033568, 1.1069549754999828, 1.0096618387586127, 1.295644507248144, 1.3527458185254062},
    {0.17260904247947165, 0.023756076761048017, -0.04133154083419579, 1.077342488752583, -0.24303676493918147, 0.09518873432120865, -0.18598379258058534, 0.889218459229507, 1.1709644002639346, 1.7888500103680183, -0.3308494008652538, 0.1739325908986057, 1.3137651605199616, 1.180072329679125, 0.7137839059392005, 1.7470315829861849},
    {-0.02199753676518927, -0.4757836775669812, 0.03976222533513924, 0.8528575198407748, -0.12475869903561643, -0.34969054716465314, 0.24902970649771686, 0.8594087451649917, 1.0863931825288777, 1.3789666017405753, 0.1742103684112662, 0.06555711356383945, 1.698479764906843, 1.3874395837975206, 0.8466335162683346, 1.4826713693006588},
    {0.06802810894155861, 0.15134793158005444, 0.5290797303149714, 1.1558407525153835, 0.02339795201439883, 0.18918989757973748, 0.2476685710233246, 1.3155300958698675, 1.0941952852905967, 1.318728850127055, 0.11032784483483359, -0.16095543742703045, 1.3439321655139456, 1.360814274853447, 0.6985926883629823, 1.241763426086615},
    {-0.12706218960865523, -0.10683496229121373, -0.17565240608891122, 1.0881425586548898, -0.12537083712308414, 0.1156430720831588, -0.46212659080028545, 1.0882460945628862, 1.2903703876192962, 1.1724357678748456, -0.24689814726369297, 0.12079913703967808, 1.4394309896343342, 1.3338415232010359, 1.0355565736485357, 1.1823974025629258},
    {-0.06306934961669462, 0.06630966246047171, -0.014589006759627527, 1.0099338011826386, -0.22149225326920277, -0.18180415762770857, 0.3493098207092693, 0.8641755380590568, 0.633849005799176, 0.8186561836884679, -0.2139099049319199, 0.010672455094178005, 1.6198660401029887, 1.4266366538141373, 1.1602425976915338, 1.2457300632412807},
    {-0.36834797379715134, 0.33494173356128254, 0.46480184062034713, 1.4238578674596163, 0.3060008223887821, 0.041034105625556004, -0.026749741976408392, 1.1456156986843695, 0.9908943020854831, 1.175528054038856, 0.13921283881884655, 0.13684247416046263, 0.8823235233363725, 1.2895705247239027, 1.1048130512592143, 1.2887859430166568},
    {0.6005512438204628, 0.28238221533601743, 0.24734190757855865, 0.9146548367912707, -0.055720622386144246, 0.40936836713063984, -0.2562475990019578, 1.3403615501542565, 1.4219824492200142, 1.249611166024629, -0.2843752030532336, -0.05627679630552389, 1.0010683082031224, 1.297991970115719, 0.9100977002916355, 1.1541721557467761},
    {-0.10077472875134047, -0.5357179032120845, -0.13374299647178498, 0.9532439021003866, 0.16194706203754838, -0.23347300086297804, -0.14624578351500694, 0.8531843872896827, 0.6370637748201878, 0.9124355556054492, 0.21124399056463491, 0.04450833926244677, 0.6777422836649264, 0.5173586849333155, 1.1472342078854574, 0.8780458724598308},
    {-0.4382164686944428, -0.39400555963501366, -0.31746875299582317, 1.4291505048456246, -0.37680408431026874, -0.17746212744372583, -0.47583422109776724, 0.9100369762925635, 1.4630519494682783, 1.2353637523025174, -0.060948957225271355, 0.1022189041603787, 1.2141927401242152, 0.6864936571170083, 1.2003329847902102, 1.5141920681860535},
    {0.06418016121448702, 0.14919511255705878, -0.25560741289323546, 0.723228184512268, -0.16225080426357083, -0.3831805624041936, 0.44080400082227866, 1.4728314167143073, 1.2865024791146529, 1.5860012155946677, 0.36206902990938833, -0.262266319050597, 1.1208095358467998, 1.334740360164263, 0.7897938543341803, 0.9861449167934694},
    {-0.29023789825032165, -0.12711330168431598, -0.506105760078695, 0.9296804983824833, 0.1271063027860636, 0.44722103228528226, -0.38208123629967916, 1.345586121935335, 0.9730444451437212, 1.0067501916022434, -0.1263781618888255, 0.10262107674773127, 0.7052743846951397, 1.4269059763374567, 1.1416970310680825, 1.4477025348700625},
    {0.0824536635748605, -0.00035753341242952656, -0.48602172829905754, 0.9525133298741846, -0.012866933186199145, -0.0733501835686921, 0.14946453124127027, 0.8060282983568013, 1.1650106986716937, 1.1992743708259526, -0.03918822408028926, -0.46397466698564266, 1.3263959830125494, 0.7668094684640792, 1.3200121399991838, 1.6096257736540889},
    {0.21373710488839442, 0.12122225096919038, -0.5347694076564329, 1.4205856816173934, 0.3208719216239624, 0.08132844946158008, 0.06608953202955531, 1.171180469041998, 1.3257600403810819, 0.8184990572626683, 0.14308070597139644, -0.08878236430547051, 1.498237382289655, 0.625795047795433, 0.8747172702739453, 1.3010658643137591},
    {0.06441300877350795, 0.015471747120571287, 0.17025767026287936, -0.29130466126078935, 0.22444240242481703, -0.04583583455697167, -0.42085185017741966, -0.0627554633999772, 0.07986812190367577, 0.03132103230108086, 0.2132476543336239, 0.07686382052341939, -0.39029961502641936, 0.3703050072367289, -0.04403629575168404, -0.7165485417345036},
    {-0.49641206118453945, -0.258550741778308, -0.07701833229136722, 0.24820914701824356, 0.06169826985521473, 0.6454529195597172, -0.2522620153323953, -0.1193285247887904, -0.5073186722233088, -0.005562106414665108, 0.28082411244850347, 0.4429039740000651, 0.0760619943710428, -0.0014591447102881136, -0.11908801477096694, -0.5501378303949342}
};

static const float b3[16] = {-0.02973006848757192, -0.05910824810102552, -0.021918061689895227, 0.737915793728143, -0.03677644828047332, -0.018072518166046197, -0.049755101524558455, 0.7351829212797287, 0.7216802108892483, 0.7805870918643713, -0.03447385787211266, -0.0928683776868499, 0.7812951619336007, 0.7627418541070379, 0.7099621325144091, 0.7837275216696641};

static const float w4[16][12] = {
    {0.15424435483389926, -0.5127088723299026, -0.31291063676207065, 0.7324708653344995, 0.1696832242681316, 0.5175555254566548, 0.29738775645011534, 0.20998959042606702, 0.6964398075025984, -0.5298511919912644, 0.22928381982490656, 0.04165523523575725},
    {0.18853868652093003, 0.4159288138421938, -0.12719889064740253, 0.08959890051208513, -0.1818954097383421, -0.021188010892692663, -0.11950770673988734, 0.6041807775381203, 0.44320259705553006, -0.12763614176798718, -0.27751102551343215, 0.16362446568911437},
    {0.26600258428584284, -0.4292841869099255, 0.1505872732630405, -0.028920092981611734, -0.6047555342900653, -0.0049677716148030454, -0.2065327867842216, -0.04084750657305637, 0.17306675569404475, 0.027661081748310397, -0.018248226998580502, 0.14703775310104683},
    {-1.1999750693241058, -0.8015747755430328, -0.8246187912662115, -1.5709673762324703, -0.7350095302400119, -0.3125337330520538, -1.1620290703185392, -0.47868589914391807, -0.6573555806894803, -0.942786207072721, -1.488644907470782, -0.405366520764129},
    {-0.5196381793423481, 0.8234292582460679, -0.2213478091376451, -0.6817920875593442, 0.04063481461181649, -0.41423554668472523, 0.006078915640304438, 0.6546917730999636, 1.0258267509395658, -0.3681009820229259, 0.1215101517158168, -0.49403107837790744},
    {0.1340843845285931, 0.18104717359167202, -0.265653944675187, 0.18976425481175022, -0.22118405916953832, -0.6289263017035829, 0.2266663827702059, -0.03645164738227801, -0.2434167657129132, -0.013813518914766773, -0.18262428951549162, -0.3260791897355984},
    {0.3819178814961741, -0.14440715472496374, -0.31804128044319085, -0.3967813762758917, -0.27415557706879795, -0.2125128848695743, 0.10837032966287864, -0.6340515913304169, 0.24283532473486028, 0.5189161112012488, -0.04580672465642745, 0.2086801210397077},
    {-0.6311599747390384, -0.732062330373149, -1.6305325271417193, -1.0799734813025934, -1.0559038760792172, -1.4755494874422714, -0.991375624958131, -1.3521110865789856, -1.5029833461852218, -0.7560727616829581, -1.0153613628351612, -0.24346176232427558},
    {-1.368824236642448, -0.4623611151251255, -0.3521007178201273, -0.9243597813854312, -0.9370546527005356, -1.3607974797037674, -0.7382837725486532, -0.7374379491087758, -0.8490020479462713, -1.1183665334413873, -1.1920159267823602, -0.9225455344781909},
    {-0.6432987261506408, -0.49698754908442094, -0.899305635736139, -0.5865343810558121, -1.1694873412183513, -0.7506681460170974, -1.065380811094252, -1.3910288604741634, -1.2821601733405386, -1.5472458551019348, -0.8595316899733716, -1.2026161122605528},
    {-0.24142937783525406, -0.16514139023036953, -0.07308205096036495, 0.4704657709719242, -0.39462910627877423, -0.4096069170903043, 0.26293432148021406, 0.007601152527459982, -0.2543703514129149, 0.13593104925064903, 0.05419958818038543, 0.8462171595461847},
    {0.20754122134866906, 0.09599148178676947, -0.4700202223688945, 0.05237081866827984, -0.4439979358698875, -0.11538202277387781, -0.3136041673096723, 0.013311357074198891, 0.3438624579295792, -0.224360842539756, -0.2077959545369367, 0.3428258624249807},
    {-0.8466137483130213, -1.284727163648617, -0.9469476354954387, -0.7811042112747657, -1.1311879610951705, -1.2516064362048003, -1.2453059109927742, -0.7949141896734877, -0.7637561021816378, -1.0986623718037793, -0.9386127102931394, -0.8296005177550786},
    {-1.0357034240724503, -1.07324781422938, -1.0136124164042857, -0.8193933501283894, -0.9983879694280402, -0.5255373102047177, -1.1065563313491718, -1.2325086790044946, -0.8636100641283254, -1.1800266832084019, -0.656351387095573, -1.420023522794156},
    {-0.7905183339030425, -0.9714255506903154, -1.351408888374235, -0.7467826285403844, -0.7770525624458684, -1.1327153467131608, -0.6184610232058871, -0.8493135301010725, -0.43862698609897954, -0.7813849833854868, -0.21473732112331756, -1.1364497493515464},
    {-0.97701222996211, -1.6851314820922567, -0.6928423987081522, -1.1026996998298642, -0.759845762505755, -0.8020157172940442, -0.7014970436526864, -0.830736642764765, -1.1482294642715216, -0.24457787032016695, -1.1601444516005999, -1.3648964377224164}
};

static const float b4[12] = {-0.34004208885757575, -0.38531859754355463, -0.2692862153610726, -0.2794201341661031, -0.31722449795547947, -0.389237164480755, -0.41642704224738947, -0.36176874996666747, -0.3509343587863691, -0.41384772529897657, -0.3218419165078971, -0.27755089739799127};

    // Input Layer 
    float z1[64];
    for (int i = 0; i < 64; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[32];
    for (int i = 0; i < 32; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 64; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Hidden Layers 
    float z3[16];
    for (int i = 0; i < 16; i++)
    {
        z3[i] = b3[i];
        for (int j = 0; j < 32; j++)
        {
            z3[i] += z2[j] * w3[j][i];
        }
        z3[i] = relu(z3[i]);
    }

    // Output Layer
    float z4[12];
    for (int k = 0; k < 12; k++)
    {
        z4[k] = b4[k];
        for (int j = 0; j < 16; j++)
        {
            z4[k] += z3[j] * w4[j][k];
        }
    }
    softmax(z4, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
