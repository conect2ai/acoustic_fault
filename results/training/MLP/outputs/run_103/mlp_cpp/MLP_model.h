#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][64] = {
    {0.45542314206644696, 0.11184297608242863, -0.8112115684244372, -0.7924508522806852, 0.3574574551149195, -0.7231167357330419, -0.30555175671393964, -0.5373932772399879, 0.6991979668202901, -0.7127670829289238, -0.010478348751015679, -0.10654481569822237, -0.6828083819983878, 0.12817699283534997, 0.3423176051896714, -0.1768409292571388, -0.16867854848516634, -0.11907225070808539, -0.6849495117824997, -0.18774186764907344, -0.9337910432578339, -0.7343058596917694, -0.5307265086266162, -0.8417522851475383, 0.1665422197757338, -0.7741438829468609, -0.25197435318981, -0.47878144131360073, -0.8324468094490584, -0.538848197633913, -0.7194613093991087, -0.375189578437948, -0.5497973701822263, -0.6530225770288332, -0.6028739929328449, -0.4008374198588039, -0.623263462884261, 0.149506644192455, 0.45866728388604605, -0.809066819387682, -0.5421573378037423, -0.4400016930099363, -0.6479560747616391, -0.30060876933466135, -0.7347933820718905, -0.3332761926307296, 0.25527993978927527, -0.389704510101702, -0.5743532650639954, -0.6333160782567155, -0.12215990811221776, -0.735340197916163, -0.6696516384922521, -0.7296004226864196, -0.07266989667839872, -0.41011481397814714, 0.09000185899083736, -0.8279467089079239, -0.22070939248034038, -0.657483015437238, -0.20378087337095654, -0.24019748342440553, -0.2275090772239471, 0.516301406229739},
    {-0.5555958193906625, -0.08678362453078212, 0.5367528032265191, -0.05520861040955207, -0.1523562192395236, 0.681979366972156, -0.3376789737079757, 0.466817387592611, -0.504692129285185, 0.44707233616899, 0.24205205219946951, 0.24727269001340185, 0.0460862800717419, -0.2547085277003042, 0.07653397897556985, 0.4725604818757103, 0.04315350779269616, 0.750028073190482, 0.34352606704538824, -0.2882723861711871, 0.02842632462629132, 0.370035990716025, -0.15702331513950335, 0.5096646328592445, 0.05364935371392189, 0.8605042025524656, 0.2677452117604097, -0.30292072987323265, 0.3993214211116973, 0.559698519565179, 0.7966546508707965, 0.17062775017682832, 0.43925614079937175, 0.33282564013716265, 0.3141222721635581, 0.005445890137325744, 0.12181615145509701, -0.22688387345151947, -0.6435506280239645, 0.4974981980300849, -0.07936148191084413, 0.26085679605733836, 0.547095815510988, 0.3882060615526813, 0.2454327671399579, 0.04091110709894613, 0.14224350622395987, 0.6383671597305882, 0.7557182864409882, 0.09812751322040975, 0.16571127963678442, 0.396288206614361, 0.6273293534473704, 0.5559886260360113, 0.3092957356929519, 0.4781730042615862, 0.2660904098263108, 0.6475967606399314, -0.12896666969329576, 0.6594799025288791, -0.0805769610607359, 0.5192810086647353, 0.6259019056780939, -0.8208745657491586},
    {0.25749202135294147, 0.039213138188565214, 0.5046808958492622, 0.3632460902943503, 0.3531328748779798, 0.579342731205195, 0.6649342783061131, -0.4693653041371681, 0.5469164340099045, 0.5629369426522386, -0.0954662649435822, 0.39797411744330463, -0.09005814287279387, 0.2588689337294572, -0.23035366492738985, 0.23399734545833445, 0.26641632270268994, -0.001663887024806513, 0.5331171603300751, 0.05734118696948543, 0.23668471742868644, 0.310186063841887, 0.5055885461340324, 0.26372092890537724, 0.06628089336488395, 0.4613621255834354, 0.7287742467854347, 0.23847688789247595, -0.32479525386189106, -0.03076074291877946, 0.9004259861246221, 0.12387094526010313, 0.7288808324814297, -0.27980513813072394, 0.625332865076725, 0.24469101142574398, 0.6125057846002148, -0.10627718745425206, 0.31081203624355663, 0.11631786641006722, 0.5389001787191685, 0.42735574363442924, 0.6492938498403441, 0.08895385768741905, 0.4829192401640848, 0.5312047984623016, 0.33106194673423234, -0.6342059286357025, 0.30110650370609743, 0.24613947484553, 0.3242960493300358, 0.4844250232616343, 0.680070195665982, 0.24068698811274764, 0.10950685689906982, 0.16829251578720725, -0.8149209884500059, 0.6971206303468814, 0.2705858492420099, 0.5196586498778184, -0.1986069977586062, 0.12199731439267648, 0.4409063963901962, -0.07768629213563706},
    {0.43277913647168553, 0.47882868095220965, 0.5626761382312163, 0.4208476505368846, 0.28649113201797277, -0.1364714714076444, 0.8639503635060106, -0.14830073027262014, 0.584840705261129, 0.02416861515751862, -0.4531597385124968, 0.4291321205129503, 0.34401048249950555, 0.3068441893845811, -0.13294595786688643, -0.08284948307179259, 0.4887706607935934, -0.684121977226307, 0.04865594358602634, -0.14449449997027178, 0.2683681933751025, 0.16560267748292348, 0.7776765353254849, 0.36245128183013325, -0.38674763926668854, -0.010146540189770382, 0.17264586355417624, 0.8014961028603332, -0.08278432835413797, -0.23299058813869186, 0.19277323644708763, 0.36024933492139316, 0.32094257238291485, 0.2772403133933363, 0.5004902029369541, 0.6593105523062879, 0.5624539079036848, -0.25432837004376246, 0.9332250226402887, -0.019136809804018745, 0.7258445314690048, -0.48866114954964074, 0.6175665777930487, 0.024738139244476605, 0.6336148789878752, 0.42799014759656084, -0.2681632457748835, -0.37892538946826654, -0.029022218126534997, 0.22558024980660898, 0.167389342046253, -0.07902682395763529, -0.18978236378338179, -0.15059827396933476, 0.41201068582479605, 0.17256228495086043, -0.5000457879117994, -0.16170973940963806, 0.17712119629538267, -0.15941375697326818, -0.09552883129797737, -0.5563754333073573, -0.27828828755518886, 0.10247998864392094},
    {0.18824379507895392, 0.3177503120987424, 0.5551498690300006, -0.07300691374026942, 0.14449341857035403, 0.27735645940152676, 0.6390501840842732, 0.4420152253734264, 0.12196181498743848, 0.3554646418872468, 0.5483903859102097, 0.1503512881986503, 0.22663134500362206, 0.41697088255475534, -0.407012048818681, 0.16624807518688886, 0.15256892685896767, -0.5657409876177407, 0.29456236862639507, -0.3273555215641535, 0.6538823926929911, 0.4402348439012996, 0.5177390473408554, -0.3314560615199269, -0.33244239238502304, 0.14642746637513554, 0.26490874528227576, 0.31937132910832383, -0.2596370786029725, 0.5375078970196012, 0.4205615166564962, 0.34798581636976267, 0.5224260262303013, 0.43608397949274014, 0.2974357938312202, -0.2008980902234104, -0.08746068023265795, -0.7786931585555924, 0.46925231074140544, 0.5561093947920054, 1.0036690970495439, 0.33936385819192016, 0.7820478250851678, 0.10219393923739159, 0.10451207757719193, 0.5721091505669371, -0.47386622361014036, -0.434464031595903, 0.7043692572805187, 0.5320490141879922, 0.06085227375756531, 0.5183036189371415, 0.8653568915759218, 0.35891891645366647, -0.15159718080254872, 0.16500194659233675, -0.42193051520594727, -0.06723373726463291, 0.4051037559784158, 0.028019183813071794, -0.545773233189266, -0.007991879046424703, -0.43212889824293604, -0.43911541124646236},
    {0.233018914549376, 0.2820109271443238, 0.4970185904894256, 0.3873325887162901, 0.6840664322877157, 0.5576356520277371, 0.8935523157615785, 0.6312689102705533, -0.046702335989828224, 0.5111399486879489, 0.47732031834560246, 0.3618507522251545, 0.7927243926324044, 0.24825323658730106, 0.19074488238081855, 0.04516296212225348, 0.2256101861551434, -0.0535724401926644, 0.5946339748523114, -0.12408467439159133, 0.6459428964789983, 1.110267409137457, 0.19207507993653428, 0.05958934389116333, 0.16604547774505293, 0.12165244017345724, 0.5498514359197716, 0.5296500328827988, 0.18959329445095416, 0.24447203250108018, 1.001207859287323, 0.8751080921807267, -0.30975746834819523, 0.7302241242689109, 0.42116481733338634, 0.23021132183866574, 0.35106703010995755, -0.6501078790463231, -0.31978791609588497, 0.8950517624866974, 0.6317491816656444, 0.44374703698777873, 0.5042585853775942, 0.1461608470430429, 0.6959701560445064, 0.5246741431632692, -0.7148863332540936, -0.3680630682785643, 0.2992425853467062, 1.1275568002524534, 0.6164595107686427, 0.6162425956933764, 0.6799363578929929, 0.21676442851575362, -0.49404636234189686, -0.20372891024955916, -0.392389024619687, 0.8038242056642331, 0.7410476136400873, 0.5599174614841078, -0.14554157727873138, 0.509434035677967, 0.02480128916780137, -0.5822047408938943},
    {0.3482929224290507, 0.6678974300309232, 0.57367798530092, 0.5127863183483311, 0.32910106038374026, 0.19928425335645022, 0.659010054556972, 0.8958885002480653, 0.3103026815429994, 0.7353083161133784, 0.4711202753502101, 0.6444382881912981, 0.7526671430117025, 0.2493686249378033, 0.34507779061981475, 0.06913752939506936, 0.2324677454463494, 0.05316950452885448, 0.7615344039807415, 0.2720557498152017, 0.7192568455814535, 0.8084504575163042, 0.20975455372599594, 0.023312846153657956, 0.14149101683661872, 0.24711262696796374, 0.6360028715017683, 0.7039504050474584, 0.483610744830039, 0.43299414981679873, 0.8248661971390389, 0.8343443961928177, 0.09090127195097165, 0.6335514377260699, 0.45238965682758403, 0.6448595021912765, 0.5582168528551443, -0.3063301901652272, 0.11884148460243683, 1.0730104153346738, 0.7571343345165907, 0.6064289046722333, 0.5133470406949523, 0.1831184676970305, 0.5702461261918953, 0.7878086857322046, -0.8302232078938349, -0.22628705064861748, 0.44822456643899433, 0.7783643673944356, 0.6384996315237443, 0.44394304387815336, 0.6248050756254309, 0.5178263298107395, 0.1443813844545485, -0.03939644453095594, -0.4841332541735385, 0.6514951766345245, 0.8727635474478052, 0.34869763496265327, -0.08187985957129316, 0.23439625587530505, 0.1286998004128502, -0.13763502032324965},
    {-0.49302254207370927, 0.1738543460756395, 0.6864659738831901, -0.2113743054746003, 0.1844714533328099, 0.4198520792950363, 0.4792347556929015, -0.06934547137223898, 0.05827270601256498, 0.008591870494563596, -0.23776489860500946, 0.33167359637550736, -0.502080375695123, 0.28099919466708023, -0.1587389317597648, 0.2097800190753752, -0.05001656031749253, 0.30596539164454845, 0.1680182262393885, -0.7545110047910523, 0.3998495825406781, 0.28166430505163575, 0.3065739287564066, -0.2643998062425769, 0.200314922383657, 0.2160987566937476, 0.27669991403360933, -0.1612867146268492, 0.21571468665630197, 0.1956814017764354, 0.04423619869005456, 0.6957740560164833, 0.38889550234182424, 0.6013450299169606, 0.3454521334772658, 0.23904130132544923, 0.37907700997580956, -0.22601671447403257, -0.2508659096429162, 0.5022710767608921, 0.5107519889743136, 0.1673516713094016, 0.5319845165641536, 0.11727990162845918, 0.14826506452399082, 0.6328017001732692, -0.1639526804249841, 0.058337174881241745, 0.6076643207438911, 0.09111549400860491, 0.5279329008923563, 0.4433598325198632, 0.3991986884313104, 0.3307966181825182, 0.06296506018060058, 0.012782064933264843, -0.4979050813152205, 0.1412783831042503, 0.5953152581174361, 0.31311204209585475, -0.4245585053703661, 0.15401087223802248, 0.17006837620275556, -0.5195182822751},
    {-0.9394112039300472, -0.03338020615384154, 0.45138594679475186, -0.2958646501724363, -0.45497499309665307, 0.17446806260251005, 0.5295787117726463, -0.25918271127007614, 0.40850015370238824, -0.3472330597873241, 0.053600046091322205, -0.3015384573498722, -0.4908496394660477, 0.01737887836257551, 0.020525254419950897, 0.055276241594649424, 0.002708723115986786, -0.14846346092954787, 0.7305473123071516, -0.4150164859675239, -0.05121457902689365, 0.6556451767850381, 0.3838268166525887, 0.0037878277616149097, -0.4751285430412346, -0.01943128937952995, 0.3093689336981331, 0.09486302545550063, 0.034768437094744954, 0.06851538092072364, -0.1323657175786814, 0.5393780653398957, 0.47580705723652034, 0.03462983131537064, -0.27691312563606013, -0.22131049306638967, 0.5609976051729726, -0.6054096578967602, -0.41952499632164864, 0.32500205380028074, 0.5179264992716188, 0.17900704056268144, 0.7702790503116002, -0.37188518571671303, 0.34756046384341527, 0.5923730237346494, -0.40358135337064266, -0.27811065579360145, -0.019271780822770108, 0.05788974923885753, -0.3608755339153891, 0.34138062786187795, 0.4183607701613606, 0.2733230564587698, -0.23296612688843493, -0.3081458918940855, -0.2659620843027548, 0.19638149032186542, 0.6699030104973438, 0.3790770978849848, -0.41409765134565146, 0.32936783585168683, -0.3992952480492274, -0.5410480881454585},
    {-0.4356140192421428, 0.23411530739137967, 0.5485090852805942, -0.37193616174793254, -0.15289483157986547, 0.5716414167720035, -0.28468541369302064, 0.49464646739131407, -0.6070832279418019, -0.2348536834904624, -0.3310385796771613, 0.052694884705552426, -0.05879787393559585, -0.0863741968001841, -0.03758772229947396, 0.6783732435814304, 0.05962456384820983, 0.1931410797212132, 0.44983287490086754, 0.1953168819751858, 0.6627102718862433, 0.4567737013705115, -0.3393974627485609, 0.7220519517942537, -0.4147026321612292, 0.7199130972107871, 0.18970442707084906, -0.2147991125670285, 0.7251811911072824, 0.6575404524659106, 0.5329701334867609, 0.456266062503995, 0.5417004422105665, 0.5049041213169654, -0.2660122425030839, 0.1713311570241575, 0.4085778440448689, 0.41822591394310255, -0.7658688478602776, 0.2716138461880648, -0.25845935636374945, 0.43585078313347075, 0.47915128139105784, 0.11393686825593885, 0.3536125608817979, -0.02520764186565292, 0.179757477593696, 0.7992528889324619, 0.16750831035938912, -0.5201847514509254, 0.1659232728865194, 0.7221817484472767, 0.2996232899468612, 0.2874951483322382, 0.43105228827072667, 0.0510501331802841, 0.3257980856327016, 0.43298018881659966, -0.10687384873280167, 0.28417891445300414, 0.6316516713123744, 0.481869714844135, 0.21597183049257077, -0.11272317321705881},
    {0.17715979842445978, 0.10682208231592608, 0.2489953873264741, 0.007235959231923529, 0.033113181839276855, 0.05600997337844966, 0.31534153597906706, 0.566783062383696, -0.41287779879543185, 0.3364224479589927, -0.29759495949717185, -0.040229265475139386, 0.21905278221070143, 0.22826946223889352, 0.04212706558031031, 0.05826042876633759, 0.4789180425583069, 0.44939414461344124, 0.2680806014631591, 0.3602250798416448, 0.4966974463568962, 0.3856330991171465, -0.3810947934214182, 0.6381271658251512, -0.3928810461130058, 0.32999449428202166, 0.4987677360198678, 0.3128685926009364, 0.5450806831932288, 0.453220112421849, 0.35595012321588915, 0.16388268020657393, -0.31274336336837255, 0.3076897136271097, 0.0794437897625144, 0.31890142409391586, 0.06383620909842279, 0.241098502185038, 0.013935441725434004, 0.026962617983854503, 0.1419818033810974, 0.216053770909614, 0.2895718471676384, 0.2095013510581541, 0.5902843888627739, 0.3953845371375837, -0.7888661205522959, 0.5261769026058586, 0.28397194281302757, 0.3645098631856398, 0.15735464665894594, 0.3421162840770731, 0.5648481322091052, 0.2060071455091972, 0.22343005578101838, -0.33103980941278016, 0.21390771972533554, 0.4774567226392425, 0.5237471204799452, 0.5928312487191956, 0.4248354950239732, 0.3377746757576259, 0.20494044864429023, 0.19372709370896746},
    {-0.2462168505043892, 0.1532519737942065, 0.22025372644660526, -0.27571226434178236, 0.20481825681910637, -0.2383784604774925, 0.45296797530955324, -0.40980662822853003, 0.7789068734789495, 0.10855493289190633, -0.06605909050359954, 0.6331355415789366, -0.11811228346916193, 0.3256591361405801, -0.3739124797398538, 0.08016432578748717, 0.20441397387737753, 0.37147677579753857, 0.16665622466639132, -0.6332260092907093, -0.4080002262923123, 0.05491471715597903, -0.10132423260339596, 0.8400895711747288, -0.08058581781261197, 0.1130089879079828, 0.26739905978094153, 0.24574917968097684, -0.17767399119704042, -0.23044485914808072, 0.17090452096460446, -0.39457842027823514, 0.3504304805942214, -0.18488846018689395, 0.05801168748331775, 0.3224190824657642, 0.39997117985021347, 0.42957730608406147, 0.05932947053418232, 0.07625296896353752, 0.052968052221145985, -0.08844476340074045, 0.20084522623871356, -0.1336155652961808, 0.4079250678279528, -0.009249767291242272, 0.4473478302275071, 0.3019871902762841, -0.1201748188805741, -0.273427449346335, 0.2478049861998255, -0.19926025820872273, 0.3217284338128966, -0.024291889477473984, -0.0778742125953245, 0.4235219704072746, -0.17630979176544026, 0.4269693941895661, -0.4641434965523576, 0.2516303425279421, 0.523404666897535, 0.2153636348503506, -0.03851425435586403, 0.46897204220179717},
    {-0.4101674432681031, -0.7065700128891195, -0.13889272329372032, -0.1315776817877891, -0.31457081127885655, 0.22651376563539738, -0.4014063258771296, 0.3109446492429694, -0.5302091229512547, 0.02211238646447996, 0.4122134034311649, -0.12077088159879068, 0.22398098552130932, -0.32854420263633427, 0.3300053512703534, -0.4952596770786671, -0.15923183530247373, 0.45022483183157563, 0.2607085479366875, 0.1775442990157618, -0.1442956236519009, 0.5352161050241195, -0.4045204082239496, 0.008296410808287517, 0.2689526436512572, 0.24889960687238719, -0.3783878649333207, -0.271247785554634, 0.3474562006730611, 0.45742711129431907, 0.511310271250162, -0.2948845971131628, -0.23622351777717304, -0.11029106004178273, 0.6333911599182561, 0.16075541048770844, -0.1223017311998411, 0.16837256860329647, -0.7629950285149734, 0.37189851477043795, 0.14306476107743282, 0.09169425659506693, -0.03077100546603015, -0.11760706453977822, -0.027563505274678775, 0.6076406160911205, 0.40215643730328543, 0.12440561881229413, 0.1482860582229625, 0.47948851052572217, -0.12480081353261688, -0.0843034483806981, 0.4306444264044177, 0.45382835307468705, 0.08447602597561953, 0.09237172629321207, 0.1712141825692827, 0.6827653363832835, -0.11393167734093594, 0.6684545720531275, 0.1694029591464804, 0.0708454695094616, 0.5268365419326927, -0.4995885829660905},
    {0.12301801856410598, 0.4425693065945072, 0.524512770795584, 0.9634936898378376, -0.8945952731112817, -0.053954803831040586, 0.4626468636025289, 0.00925666834668199, -0.08554277096683612, 0.7692779276938496, -0.10505821811629192, 0.4403367646202149, 0.6621292380823598, -0.1701945811076396, 0.3649813380716898, -0.09643317987677522, 0.5241188368169479, -0.6071113866985669, 0.09529869540666606, 0.49129000058781974, 0.17480770576518478, 0.4586936369994435, -0.286021090734151, 0.6259256022500552, -0.6167438831029681, -0.4225986673662545, 0.08900340904107185, 0.8828409133468499, 0.5318467762539769, 0.21010670694714664, -0.05625400191792364, 0.31017143390646457, -0.5488504166746158, 0.4768909718275869, 0.25135149642795557, 0.7909040747755886, 1.0182815107462049, 0.3699899588411358, 0.032340037261970656, 0.2400441118350238, 0.7286393815171118, -0.5351634144969107, -0.02444285434140655, 0.10486551402531656, 0.5850744758281011, 0.286045831808717, -0.5884043299489565, 0.37336612921080664, -0.3943380212424475, 0.43804829366374864, -0.22386331756618977, 0.5722580679987614, 0.6013813170934954, 0.33647043646308167, 0.5419801970951951, -0.4019038281889052, 0.6573023533140471, -0.06312037772256583, 0.20735533298698652, 0.27139761892170244, 0.5993319450508311, -0.02777661682099137, -0.3432479506283495, 0.21244066909833947},
    {0.18857018165980677, -0.12122301760322339, -0.4694258580947087, 0.8663794774331637, -0.6578834770836521, -0.647214077529034, 0.0534724855546866, -0.3916662939721592, 0.11670575718939304, -0.12896360789399317, 0.22753506211449395, -0.1158480272227648, 0.07065767551175446, -0.022178429051050188, 0.11717898542101583, -0.515821915117533, -0.0024224672225238958, -0.5724874090842673, -0.6633538904389068, -0.08150462964200637, -0.09303284662777737, -0.2977957630197749, -0.3823441821707294, -0.23466325329600274, -0.31767065801547884, -1.0245255378801144, -0.3833904410681797, 0.45608722386576467, 0.44250750226374785, -0.749895871573082, -0.44572184887177896, -0.38081978250954895, -0.6465366182789402, -0.32312755704115165, -0.24931339519923784, 0.24149171983951945, 0.3903801133445654, -0.4486517680047406, 0.0399138913731432, -0.3365674096928001, 0.41958903372602513, -0.5751085277145214, -0.7616297282901514, 0.05882773881280008, 0.13984304569085015, -0.05243579539896739, -0.4759456731211512, -0.42289509726755536, -0.7403976632277395, 0.6158990865898792, -0.3313843994752457, -0.28402111739319835, -0.15108263088131868, 0.15293764742070903, 0.27667029117929065, -0.645591179170811, 0.06017632530026985, -0.2369586333836345, 0.22948419696112043, -0.042671348220111184, -0.1466835719043793, -0.5883943430154746, -0.6459338846913758, 0.03302007793781546},
    {-0.497330477102973, -0.8922972054184644, -0.4698126276952729, 0.5647890924386958, -0.5947751800662326, -0.4786934441540835, -0.35810533209980755, -0.14721192570933278, -0.3831917620568237, -0.02222392595834613, 0.5653111113663805, -0.4155356772386214, -0.32265533332555585, -0.6026380282377504, 0.7610425415706342, -0.4572335369706029, 0.10935026193330423, -0.04537245372034775, -0.3495224513163948, -0.04681460789163156, -0.4678953439587398, -0.1826059983194819, -0.41660213763370924, -0.4101244236236661, 0.1502658279272038, -0.6341316141842438, -0.6204109324121557, -0.12046099148510069, 0.5810938272366087, -0.37978986368126505, -0.36176186640308566, -0.5163631995491342, -0.7682413443060371, -0.1408257503531172, -0.5192446500097049, 0.249794626360275, 0.40177299959773216, -0.15517835893046703, -0.508019976865408, -0.11071585142436942, -0.015763396474979874, -0.19797489652066189, -0.5544043116669292, -0.28337268922885356, -0.2612324808553999, -0.2391195501121583, 0.029952134534042912, -0.28230744416967957, -0.4978028756159017, 0.2519655316005684, -0.5026627258695714, 0.06471872070683408, -0.10152193457423192, -0.21944752655944336, -0.051268877602077136, -0.6733296038500245, 0.708149438002592, -0.3471426741667089, 0.38668951479697666, 0.44556825547408496, -0.0031139086463770884, -0.5975849969435904, -0.1783091476250178, -0.0032625343267943404},
    {0.2163485703662331, 0.05493920471024373, 0.3720523265811552, 0.9014303830861402, -0.41999648243158705, -0.5688731091307947, 0.658758806509434, 0.5708485296285143, -0.08209350603005677, 0.4253746401012229, -0.18373894060211332, 0.37940659924344866, 0.7058631581361511, 0.5674551567226673, -0.20025172131972935, 0.000795522757370225, 0.16949250764844664, -0.24302986098082974, -0.08409883620670962, 0.12288173590437342, 0.3381424593797788, 0.48577330492729975, -0.06652703068796566, 0.5440284965308319, -0.3693661074292881, -0.3683649755173513, -0.20199194065651022, 0.9926622098487103, 0.7559965793070672, -0.10308023875025416, -0.015221119200358473, 0.4986699976551413, -0.43308712304029057, 0.6846153283035361, -0.15431957708450356, 0.5394015037144045, 0.9007812614559034, -0.14388461309687867, -0.07733658286892177, 0.29695381734378695, 0.49595454118531923, -0.3755629983375009, 0.0259446635715589, 0.0082641101884164, 0.5430619321835921, -0.1193457421157428, -0.8081513959242327, 0.4734903492859007, -0.3093271089496815, 0.6407901191492389, 0.06979625461420746, -0.3802010955368805, 0.6168576383829711, 0.26715663335741985, 0.5980426274712445, -0.38248009038054825, 0.7552683534887573, -0.07613854593840454, 0.35740989317198774, 0.18412515462921494, 0.5679791254819331, -0.16623907522937587, -0.3654442261525257, 0.21877627914933767},
    {0.14401680843024472, 0.06447414120692004, 0.29192382992764077, 0.5253927500601036, -0.36192302000567145, -0.27830698204206195, 0.6275607495614568, 0.44707774709354753, 0.10045653774001807, 0.1643520633152992, -0.038018136392059226, 0.46578048371693226, 1.038044124336643, 0.596832292432168, 0.24835117846459306, -0.6502352542176973, -0.035654877266533755, -0.7041959650291708, 0.014612769898548983, 0.18342157087350502, 0.11421744791990199, 0.8680363964157691, -0.5998795327885107, -0.1618337976814504, 0.2116930069197084, -0.10185727315443648, 0.08017139047166455, 0.6957021984432692, 0.17908792694681352, -0.29491507147005586, 0.5159883334783909, 0.5781500836328951, -0.37201571541417067, 0.3357649221123197, 0.17387931700146342, 0.5163865611128702, 0.6904927616474762, 0.20875327421042578, -0.20223698803167464, 0.3955248579510766, 0.392236265286291, -0.13295646853039858, -0.4154205165275007, 0.032128310647270675, 0.5774216280281248, -0.19724807228696226, -0.5495799851865827, 0.2048377186886523, -0.26401706128870084, 0.5056765716496044, -0.007863535259400709, 0.30762309842295077, 0.49496049037109313, 0.5877885563597994, 0.20424171029915772, -0.47432599252046764, 0.05135212732943264, 0.5089235598452516, 0.38885180838503497, 0.4070642691772595, 0.12226050590621945, 0.11573481009961302, -0.06033439047291296, 0.10367707380767668},
    {-0.27324446070807257, -0.6080693262712938, 0.2077233063004717, 0.7193806996954708, -0.1369863905682399, -0.6000698116914509, 0.2903113681493176, 0.04323885989542888, 0.41458646474947, 0.08702488383397551, -0.32821418171382893, 0.02455484297452812, 0.30617719133501026, 0.1294369041411029, -0.14377896288801761, -0.13773862195497474, 0.27704759906346066, -0.12979040432495045, 0.0030900273258922394, 0.37094642091407803, -0.4879061973352827, 0.3115978687062022, 0.19821376653222045, -0.4130104453356714, 0.22675849566189135, -0.27777591677687297, -0.5803532553333082, 0.3746312774482014, -0.01074763109507295, -0.5585157095493238, -0.15194821481995416, -0.26996833060783015, -0.0808866563946951, 0.18632909710035322, 0.4470161534526394, 0.30731438376890347, 0.6451751675152363, -0.44289943140241345, 0.2906664608584644, 0.08392959203388353, 0.08229279290030132, -0.7901466592369465, -0.16089142184218874, 0.3250773474840408, 0.4311645032343431, -0.3200744676123167, 0.01587448137862943, -0.16682822893192165, 0.09203777043314015, 0.46069925571416714, 0.03942106061749165, -0.19802482030046908, -0.10697935708474215, 0.14902884810319778, 0.34278890520245864, -0.08037418993931346, -0.008510206838301868, -0.43273838290965594, 0.40656318654746254, -0.19313838329993252, 0.3414387613701389, -0.8507605031551151, -0.10012294266166254, 0.35811934541666657},
    {0.7791543504012113, 0.30580468925983434, 0.5201702423563069, 0.4361432902534398, 0.31994918855729126, -0.6371494942817496, 0.2575916728558013, 0.3690337089935644, 0.2447739011389655, 0.18940705356576318, -0.47475824505474257, 0.46327293568392264, 0.20490079936524427, 0.8188012100818317, -0.3444036003581839, 0.3917168736110191, 0.4268342244345168, -0.0487881039610124, -0.26403441992704224, 0.6123804822569083, 0.05379377685813393, -0.46379806982848915, 0.06595533714437675, 0.6742301169566427, 0.44091990274978965, 0.6384603946586241, 0.059540845845109255, 0.8151691697742149, 0.3254032879060862, -0.07368404497053602, 0.12945138946540866, -0.6864135010574263, 0.543124732017005, 0.22687431650041395, 0.4568718238769278, 0.4443088694642747, 0.2949843278300053, 0.1282090202966923, 0.6143010534378297, 0.18786584627581807, -0.12230942093830503, -0.35265323306089935, -0.10540615296168643, 0.44633332638461426, 0.506066416875692, -0.160232391529122, 0.040680137357945734, 0.6315250508806041, -0.0549649963317988, 0.3580527820863619, 0.2637362474999215, -0.03683316420891119, 0.16934546345351909, -0.5152489118123246, 0.5014109922032208, 0.4088125727814735, 0.49144666595414127, -0.2947923278305373, -0.34754031253008494, -0.1370887341785209, 0.5716013213196893, -0.12996776520445633, -0.21227868914421344, 0.45680126821325173},
    {0.1541932782493505, 0.42763057975898894, -0.05180363051102764, 0.6516760350642928, -0.17030944646818308, -0.34979867610961063, -0.14984260244445002, -0.4026470296103176, 0.3606548625826885, -0.008822836343545784, -0.12271243318948279, 0.14480435143443496, 0.45350429818114024, 0.3387853953247895, 0.10974501520070998, -0.19373845569979836, 0.28937326213564135, -0.11420966608688403, -0.7162472488173667, 0.26885448863007944, -0.00019121958420342908, -0.5381743615131821, -0.01667028574992395, 0.13001140858850152, -0.09593824697247857, -0.3640045713401281, -0.15719849598660246, 0.7072621923791611, 0.7489543915386337, -0.5408246916789731, -0.6369071054495623, 0.007940798272264234, 0.3151888189651744, 0.0980386317820939, 0.2195412661633637, 0.3661202802484085, 0.5974255086802148, -0.24831406859967142, 0.6869104443988382, -0.2157063684789236, -0.20260978972813498, -0.652258174706208, -0.5606267464940621, 0.40556503409644695, 0.48487441224861344, -0.2652908804889893, 0.02644519879381591, 0.33880630517958316, -0.4228274571763379, 0.36236958743340664, -0.08895577246819614, -0.401201802416531, -0.4060597559303622, -0.6861977349039171, 0.4259908661664801, -0.171940089615982, 0.21391637193721444, -0.3420665043544413, 0.07189564179724788, -0.5918356824018985, 0.25299644826070555, -0.40841150296657736, 0.13468618025930787, 0.3591404210186744},
    {0.33176729646512165, 0.6506101044786314, 0.31814017011008894, 0.6154480484533917, -0.8750795974325659, -0.6668850242642419, 0.07287933882169971, 0.2396267212838529, -0.043824833043508545, -0.07734878464431597, -0.7118320789043582, 0.4694955362609237, 0.6766308631611695, 0.3845220782378911, -0.22288558890064702, 0.19190092325481822, 0.3458222008792159, -0.6531556545130197, -0.7249240994067786, 0.268393829613669, 0.17325752867805996, -0.3637711603682963, -0.5371116916521892, -0.00929855944900472, -0.1219851561167257, -0.2579696533065444, -0.5103795696463994, 0.35464852374904077, 0.7254330276807687, -0.5789960543858841, -0.5530908715581312, 0.16015747723247906, -0.2310706021066531, 0.5528160918578158, 0.19945795361939297, 0.6247640819617086, 0.41759369093910104, 0.517003002675131, 0.49781965652792864, -0.10468166371652597, -0.4190252722393786, -0.8869645822229797, -0.3824410751640741, 0.4313415786406051, 0.5702911362089378, -0.08182909756016106, -0.5044336498222572, 0.3124661815987645, -0.5788255530265205, 0.3608126183996672, -0.6985272425527446, -0.581898193023746, 0.10847080780783566, -0.22259047074060712, 0.5955501057275577, -0.7103206351782203, 0.5957788066758605, -0.7838524271754046, -0.23595030092421845, -0.25547077973722143, 0.5315582687535181, -0.5639457296034096, -0.47814992920121785, 0.41757934519769635},
    {0.37972343574844625, 0.20474943121553515, -0.18604219259791827, 0.7910197564898588, -0.40830825487919253, -0.35958851705373607, -0.2913711593699066, -0.012702490776220916, 0.11371345242533003, 0.08484062212950504, -0.25156747765105125, 0.4768460216095718, 0.4221276766097292, 0.31242142919963817, -0.1666663025530412, 0.1381801039566771, 0.38447684001539906, -0.3454726975393711, -0.33190288210617624, 0.5573321238572213, 0.24502575329467366, -0.5219124123824462, -0.019251934251540516, 0.22807616217311263, 0.9834231493488357, 0.2325197571692601, -0.35119290345265414, 0.7303236132409269, 0.537988411584706, -0.3191354801628135, -0.43115963502280197, -0.4852499507340018, 0.15114559012056616, 0.5797811411092659, 0.5163122616445226, 0.5459860411396674, 0.5561159662649608, 0.4040885911399638, 0.47115024085179724, -0.124026364219252, 0.012175313537690842, -0.43525158248039564, -0.43508057160408276, 0.6133610146320071, 0.336176391374786, 0.00845420219771673, 0.05422104566775722, 0.6259413963853407, -0.3853918683418388, 0.3792218922955271, 0.1113688504160636, -0.6473275919318019, 0.08732148581780476, -0.1767742474589216, 0.35319988900546323, 0.10942123737792056, 0.6383370687290609, -0.3174022941306576, -0.3802773989595526, 0.29268065389708564, 0.31973746307332285, -0.6748807610498463, 0.030836682561427957, 0.737905253891089},
    {0.6407149143736537, 0.3453018954885612, 0.14661333700451992, 0.23228092006808984, 0.21456790734781891, -0.3133762308251242, -0.4044451609667208, 0.32363706719833646, -0.008621843249474072, -0.36664991735995234, -0.7589014656811606, 0.3789333081426081, 0.026586225697929067, 0.30444556711767357, -0.5659490570209503, 0.8443396623699563, 0.371888797099121, -0.3265597569483678, -0.25906878845968145, 0.6145369668080762, 0.24440884368791796, -0.7987767753715761, 0.357549923832687, 0.4606239183949981, 0.3573980904997038, 0.7243110571996241, 0.1080348904112434, -0.18625695377279958, 0.7470303476956922, -0.22319523768191288, -0.08263316210071019, -0.6571321696186287, 0.6621063093658429, 0.4043355310899251, 0.46988665507416694, 0.6467188422599385, 0.01621138059004154, 0.24208598589742517, 0.5430760769381838, -0.1964215599774038, -0.7192024011400296, -0.15647483616787453, -0.4314554999748084, 0.47776097127932704, 0.32479383594660277, -0.3711832209734886, 0.34417974393331896, 1.0031799268373343, 0.35990149160304347, -0.6371073418303191, -0.09002940332328496, -0.39848043219348384, -0.2327559115892495, -0.3961000098201123, 0.4640711852445164, 0.19199570584745623, 0.13436680886256894, -0.3076626288817296, -0.569024464495057, -0.5866389120443108, 0.3036604979168054, -0.21408828146775474, -0.1199010346153081, 0.40366339276341956},
    {0.7987309943644442, 0.62752753573276, 0.5485164486693679, 0.6999827484885535, 0.22003989012441197, -0.28875764040613194, 0.5217308659487809, 0.00754883775745104, 0.7005447310172356, 0.4456367977055269, -0.7818066912669444, 0.8929124843949587, 0.4651211394701734, 0.7400441252515885, -0.07664619638706319, 0.761754281855482, 0.4336756287943051, -0.18670160783470843, 0.08675692052150155, 0.6115826921451027, 0.32091152849397386, 0.08880519338587166, 0.5406673272846815, 0.7756044442382879, -0.18363865474416063, 0.6499747703013768, 0.5937569093018319, 0.7883412942500329, 0.47166047008501694, 0.08824829843894298, -0.09207814622896492, 0.3076265408161026, 0.6194758255970008, 0.4503062228466948, 0.4940632780555634, 0.5937165322308988, 0.4097160896072236, 0.37895524282400495, 0.8816349819931618, -0.08798767107689069, 0.07061517541888745, -0.06518636898859644, -0.03101948972497712, 0.33807801175526325, 0.6766817437267488, 0.10296383876207017, 0.16828454627946562, 0.6302243932047843, -0.18574015347482598, 0.27788921960252966, 0.09094734625561486, 0.10556545103444928, 0.16997363903362242, -0.18227142060507975, 0.49122985553957876, 0.30799818664749884, 0.27733906478136344, -0.04635012854746082, -0.2713479839591571, -0.40690220765892093, 0.5454789247060589, -0.06226377112319895, 0.1500267513177196, 0.4834653423171179},
    {0.5535547261457153, 0.5415196375662322, 0.3222060577891475, 0.18277512741280946, 0.7525052205283602, 0.05579852570050372, 0.15289332283416304, -0.07269992753027557, 0.5581703067973839, 0.05375759801410438, -0.5424955313507533, 0.5329951353051232, -0.1542365388808965, 0.16603471478387516, -0.7008939562890901, 0.48394004958940645, 0.5919257992946614, 0.07853558354598134, -0.2273007829892524, 0.5932389547600412, 0.24268170187923757, -0.4924842525923491, 0.38738422046543725, 0.5878942199744146, 0.12395747479986129, 0.6483832975874451, 0.631031850293893, 0.5037140826697308, 0.38168403314284155, 0.09809598377348869, -0.3480676724459544, -0.6272903360817684, 0.6293780137574561, -0.047619180356579915, 0.5245101720674016, 0.5677070508968881, 0.38309496050190767, 0.6131339516039136, 0.6511639680739942, -0.2330400787407628, -0.7297037591974522, -0.052952442938202594, 0.14652390771966728, 0.5304568227187015, 0.4174417048840085, -0.2535922744035735, 0.7352173980099574, 0.7437961810869288, 0.1469199859089329, -0.6245580499968709, 0.351430619618841, -0.2890788209348949, -0.8444481804715415, -0.5881732866285759, 0.3396116541997491, 0.8120523808973794, 0.7009903798514832, -0.22239867257159837, -0.10509494385951891, -0.5565864264703075, 0.6941510732332234, -0.30779212187035304, 0.3883740044428898, 0.4251721542740202},
    {0.5508766488686471, 0.4656900803996552, -0.09237540859208877, 0.06712107167598698, -0.33101284288066374, -0.6552073546299245, -0.4251355180272314, -0.06629203986076246, 0.3463914005207017, -0.07029526832396656, -0.5402819275052104, -0.19320339512127055, 0.14404057794082145, 0.15379200431464762, -0.2944725172613666, 0.3783604671200068, 0.3404366872903744, -0.2996964486893949, -0.5755297180277748, 0.20396358735017156, -0.24195929582137196, -0.7291791280756824, 0.19442464979109475, 0.6334881363835018, -0.32549549370504083, -0.22157519508483176, 0.018899052471617314, 0.5993836635271568, 0.6604348788813215, -0.2563748771187696, -0.3385815567640891, -0.7087881912217776, 0.28115369281031644, 0.21667643515967697, -0.05590009468161529, 0.26912081884187616, -0.0005321233462918055, 0.5439248024464232, 0.6165726439538002, -0.5051165225971028, -0.7225165085852115, -0.6842010681419649, -0.6119895358233859, 0.4276286329602692, 0.4056173814412891, -0.7007869703589238, 0.3358833492288709, 0.6782716767971392, -0.4368703145479946, -0.22680693643336589, -0.07071897016436629, -0.5670497908947099, -0.7480469001063859, -0.46132683771501304, 0.22525204823717665, 0.3464636740377412, 0.5647947876330115, -0.712487494266283, -0.3412858466042553, -0.8258980452300835, 0.7525130442213468, -0.732539396329127, -0.4240036142603206, 0.6206778663069668},
    {0.7851740112680831, 0.22176673995527676, -0.005496838183199714, 0.10406013307221, 0.4423503746552641, 0.11425092816843678, 0.10467831336579254, -0.15862126648822789, 0.25344798024385734, 0.47867808537047296, -0.2006525454989581, 0.16887616710146902, -0.1479065045225992, 0.3448038322444827, -0.6818724590088365, 0.009752755735299759, 0.22690388083732904, 0.30176454769396577, -0.2631402178555157, 0.5287172560310328, 0.05277147318513422, -0.3245728982476759, 0.08939152460857402, 0.4856889730428082, 0.6695686681011717, 0.248468160090469, 0.32925486673511656, -0.15399022596935788, 0.32797116648093083, 0.3488944073894032, 0.11990257495470373, -0.475370159482383, 0.9723725155050386, 0.4248465979956035, 0.7011153612092113, 0.39343684217702507, -0.04207982355439282, 0.26107281112875913, 0.7251276025375402, -0.031237242896148147, -0.19619254284768375, 0.3172590403827679, -0.01847927120728929, 0.44553020875723814, -0.11080249176294901, -0.049253291549515583, 0.2250226731464377, 0.13929242378869527, 0.44760178613530394, -0.44943907359862206, 0.5410474128861632, -0.09528639215679127, -0.2508544570276361, -0.37154033702415507, 0.130391052855858, 0.8453308746925721, 0.10545667687934646, -0.0673365686194101, -0.4129811466859148, -0.5989259183114619, 0.10688182190929392, -0.33461438391174203, 0.1994930680478834, 0.39051765627452584},
    {0.7794414086008461, 0.8087013290197477, 0.7165429350753901, 0.6878106543369369, 0.15125673349894364, -0.22658091653353216, 0.2894305728906475, 0.277956964636558, 0.5349769535911565, 0.09965090914374311, -0.8682002504901453, 0.5908193369324021, 0.6575488125697614, 0.5548691034713743, -1.087975303020607, 0.3167058710133426, 0.5324710107127569, -0.4981891471286054, -0.369583597042983, 0.05329543964289426, 0.3146264977213482, -0.20311957482319154, 0.5803670749589728, 0.6611104683344499, 0.08959340153139646, 0.1413264756221988, 0.3342429566628622, 0.7622664009375253, 0.6254840502524902, -0.0947250884830317, -0.12649944686875977, 0.36201108963859685, 0.61041181641626, 0.4483317496831206, 0.5281722407609791, 0.5365396462430663, 0.5549057096858374, 0.6823646057384508, 0.7845107420116798, -0.3678861525501864, -0.0030606025352048296, -0.41242490333832, 0.1992966872249572, 0.5274640975659605, 0.782472056202489, -0.37103720948200175, 0.06014645711408949, 0.5523675315324504, -0.046864429924500746, 0.08722026547187837, 0.17561584723649795, -0.46445982303951777, -0.0020076378770214802, -0.5862515360217343, 0.3803305045371854, 0.14639342165361527, 0.37892028357531854, -0.35196849115340945, -0.04451125956977329, -0.5349487925931549, 0.42558616235357705, -0.6558351772656129, -0.02852354401536167, 0.42438778271144834},
    {0.4641135790738833, 0.37372580825456786, 0.3366244779314409, 0.31347816065834716, -0.3048993597645974, -0.3853576574900981, 0.328819989718388, 0.0974196333616366, 0.31734977030963285, 0.2370223351210617, -0.24640877157897326, 0.6052049870881571, 0.5368379318837366, 0.2894599050897271, -0.3985783171393754, -0.008372460300539838, 0.29542445150081953, -0.19318943073483477, -0.3715928223032896, -0.22361876927373786, 0.10440365075325761, -0.21215760000835004, -0.3389008003302344, 0.25831143671726725, -0.22951644275418517, -0.18021582592018434, -0.14280927027365645, 0.27308442333326327, 0.2816752976759127, 0.2634883974988779, -0.44146735337114523, 0.11724911849037611, 0.33963495119154674, 0.0005148265067409645, 0.3041277418083018, 0.05245659548871623, 0.3131736453782758, 0.13882397115998932, 0.6363144745034092, -0.007306593903528389, -0.010733429869056699, -0.4099797481896621, 0.08757841541549616, 0.1803221749059884, -0.06958706967142779, 0.001290002464030323, -0.45729729558267157, 0.06022075188763524, -0.26622511992186465, 0.050525704956873696, -0.18814204193953865, -0.27979338930106923, 0.03945252872861628, -0.07875119354886218, 0.558214101611822, 0.32921493535144924, 0.21156621648337848, -0.17807931658479162, -0.11303772557658631, -0.5371597550740357, 0.3570771137460718, -0.39141896867527975, -0.465416336130244, -0.2554323587829049},
    {0.430568858119282, 0.026278453436339347, -0.6189872718894225, -0.5728466351559396, 0.2874901981824554, -0.7779438003249373, -0.7295601490072252, -0.3554082273237068, 0.3469125108531024, -0.1804107215600582, -0.6011984765282112, -0.25438806606428543, -0.9082749483983759, 0.5196347018628298, 0.25210115065935773, 0.4847165874456179, -0.8728529054625563, -0.26079385750667994, -0.5180402177276004, 0.002035259084859574, -0.40709551947542993, -0.0728362926502979, -0.6179045448932885, -0.08192632096060767, -0.014654026857659161, -0.3587712742399768, 0.10036965050535517, 0.15031400361714103, -0.38397437372807364, -0.8578825748868427, -0.9762239286022956, -0.10911698029523775, -0.7390654217135094, -0.42796663971357557, -0.6111755492014612, 0.12462494727256468, 0.15586002365258764, 0.2623467785986774, 0.3748694837158115, -0.47621704059423864, -0.6652036671463689, -0.696171866940375, -0.8801022972627383, -0.2765692104766227, -0.4187588748929043, -0.5298227253661213, 0.5526078570327884, 0.3573781288770577, -0.271335627009655, -0.48924056864005705, -0.39917833530724545, -0.8695272396285695, -0.7530075159390384, -0.6359491051737812, 0.37086222060077534, -0.7277708058699914, 0.3549965265865229, -0.7337698212100945, -0.39527180194885997, -0.9875228096545174, 0.12390885562706724, 0.12973597737762255, 0.4418629307900157, 0.026847248930823447},
    {0.8052142277581568, 0.628152282154458, -0.39398602730076204, 0.12948895095399454, 0.1460944212462946, -0.7654255436719686, 0.15263031410085942, -0.6098016385504167, 0.5052159725382914, -0.4697603348120551, -0.6047660506998008, 0.3022159370991746, -0.7840340540374356, 0.48140721948898885, 0.37891577896150846, 0.4900173680221224, -0.2897283258235407, 0.458173748504648, -0.39805284039223127, 0.015173101277842603, -0.4533592089871056, -0.6235439877148843, -0.4776489017904813, 0.6642310002181626, -0.02713449573620761, -0.46822200490559174, 0.5447352042327375, 0.4773622905997396, -0.270681635166901, -0.7295161588688689, -0.38986131770572796, -0.3161208746921153, -0.1722214058132475, -0.40735656419238475, -0.4569087614841937, 0.3849393158038462, 0.38705412411471174, 0.4861763086372075, 0.43123431122469763, -0.5267262036737169, -0.6554488543594186, -0.6470484683428795, -0.47391196068861285, -0.02072880118015748, 0.21204335231571445, -0.2158060931673399, 0.17238082390713155, 0.388387613297723, -0.42852336022213455, -0.7035094091782529, -0.30083557658930743, -0.7912239714071442, -0.6470850167074755, -0.41984217523486694, 0.31457793229956726, 0.053132297450672786, 0.703153426375792, -1.0331758098523134, -0.21659942285543876, -0.6829058243826446, 0.5804669904483688, -0.09449100790652876, 0.1450236312573927, 0.4146666352515529},
    {0.18666888392100606, 0.12637718234365877, -0.7815741497943834, -0.30070703089763684, 0.45633961113100924, 0.014309197185330339, -0.21337775515374283, -0.24386361279946356, 0.3727724424947248, -0.5586969873802301, -0.6956080312143658, 0.10145755386006088, -0.1833935181532449, 0.3677629203354416, 0.4338407414545907, 0.320953150368772, 0.24535326721525022, -0.06188721296142321, -0.4680630188344997, 0.24624731219271304, -0.3956922092371949, -0.018696793159066156, -0.7692412884531933, -0.5862453701192227, 0.51407327162018, -0.27624312039923604, 0.4270528027657537, 0.0019417550816702353, -0.3075399609352247, -0.16681863799117308, -0.6271058968795236, -0.2638279776509545, 0.30267963262100955, -0.3454311106665203, -0.1735134655670288, 0.3876828963863131, -0.23270988064143336, 0.3942696670912316, 0.013801083196087874, -0.4238666931207248, -0.1902701528902579, -0.18106246850859836, -0.6484524985032241, -0.045667311075532686, -0.5849372735079327, 0.10356560427121017, 0.36117242523784215, 0.20387016180439654, -0.5102068006826413, -0.11899594152835621, 0.27476131771996865, -0.34013815689384613, -0.4849990559656947, -0.26733770981683136, -0.05056175506635688, -0.2940443864536266, -0.0036721268733780196, 0.061871109361559075, 0.04280548430363001, -0.5169993176704133, 0.33382220476252483, 0.36726876746187903, 0.306238185697732, 0.46750732082402263},
    {0.3130450815474646, 0.0674726556958066, -0.5732100095304874, -0.4930356143303915, 0.4431006286937729, -0.0022118697972808208, -0.08286183743362292, -0.6245387281299087, 0.8625835903911178, -0.22539425799018195, -0.4115446902802501, 0.32533992916787796, -0.28321565452726266, 0.42397004049092807, 0.46236159977488633, 0.02246770885685563, -0.4995749453265382, 0.19880157776917967, -0.13919219724710208, -0.22156312433210087, -0.24327779718113987, 0.07483259291692157, -0.7178638644674483, -0.2242702665267888, 0.28323708232379824, -0.23080168597657155, 0.05012597000025306, 0.11405505692594925, -0.5716379245396426, 0.16203202453878515, -0.298975029745336, -0.35225490751974076, -0.2528062326514385, -0.5007355788886585, -0.49475225555303615, -0.7122375104625999, -0.30919184706196734, 0.3310210039566209, 0.23761770911153599, -0.6216845515527518, -0.35518339249258907, -0.038109288770296075, -0.6555359658279979, -0.3272438924543285, -0.5403780162393677, -0.14549773966060234, 0.5072936192899431, -0.0232802541581781, -0.6270850180402878, -0.14479814117712927, -0.2438627576279175, -0.30361113149365054, -0.2581197238201302, -0.785536860009584, 0.15902235231307518, -0.08968831978055124, -0.003443152425642102, -0.4418537651950686, -0.15496178223049098, -0.4464238930310298, -0.09187979044033108, 0.09010637464889178, 0.3850252569461185, 0.5147242401718776},
    {0.5305147301791292, 0.7019716308812544, -0.4449775017060327, 0.1869016249995559, 0.3339308351375066, 0.025635779877721403, -0.05082984101852156, 0.3649218764923317, 0.3860998967896621, -0.2434276380642218, -0.3846533747300586, 0.15862700884610115, -0.36462334942271124, 0.28221679892789975, 0.1498864523715541, 0.4787048949091002, -0.23034130137055708, -0.009453889306304152, 0.2704550776271657, -0.012869333474349943, 0.08516089132013223, -0.005303241091347446, -0.3618100716139305, 0.04474179640145396, 0.059252528301614996, -0.1029599346626316, 0.41010809528112435, 0.7082131358072515, -0.24551963710905242, 0.02203702164971894, 0.15523220536942317, 0.3106987904302477, 0.49018704255455586, -0.31781113936927574, -0.2875910587528202, 0.05147507549008051, 0.2249915411028146, 0.3621331758510252, 0.8202594995959664, -0.329738145032202, -0.8663978109827476, 0.023686192064308716, 0.05993010428968974, 0.006253818799739126, -0.3153877178763498, -0.3658604276983942, 0.44310490892136606, 0.35223676399040255, -0.06814752506109134, 0.06451001424545179, 0.15128126485897794, -0.35818288368211837, 0.10142184914513777, -0.2194822954071286, 0.1710943851906384, 0.3627167867174293, 0.4488158392678516, -0.25806042441616456, -0.060066935022645845, -0.49508437420867724, 0.47045140729250856, 0.3835534749099161, 0.28975512449240454, 0.11871712745508255},
    {0.39671242734789997, 0.7526106339825318, -0.026743045179475993, 0.08007066159135943, 0.6272960684701412, 0.251348217594493, 0.507559623862468, 0.38407174224680835, 0.5613874524344428, -0.10746778982356801, -0.6827868096631676, -0.19075772998894178, -0.04723677894988796, -0.18518336417904027, -0.4696756325868612, 0.6504148707889662, -0.11892447152817963, 0.5178667686394505, -0.06445504303550584, -0.10416438967056411, -0.007932636364608387, 0.0876616307008176, -0.023925016377004355, 0.3887748732622533, -0.2587002536453859, -0.10592236625079478, 0.47825513972561334, 0.4667614988395873, -0.5223765187370789, 0.2128394707215835, 0.33100969742388814, 0.3239056467582894, 0.2621470580524176, -0.1659465429429841, -0.02897242019662862, 0.2412665219986562, -0.5364140250701533, 0.5007009973082006, 0.039505225462568766, -0.6563459868691692, -0.43115521852459365, 0.18462497772165196, 0.1952204137270896, -0.431888626665299, 0.2810171919403139, -0.37723318505623415, 0.30845738711355, 0.6467846242796601, -0.3130066038384026, -0.49133204484791515, -0.5555815142722397, -0.33228001718406713, -0.28023524917955717, -0.31963031407213777, -0.014341857574069505, -0.09955814722588972, -0.3389057597521975, 0.09681696319677263, -0.05585735130458845, -0.49115126279525395, 0.5282594638636638, 0.2794899785151785, 0.10820512879912059, 0.5775745810505998},
    {0.28462824148807475, 0.33894383236414344, -0.7125693402180672, -0.3477104406323586, 0.5124068623723242, -0.4350861785199662, -0.39216006852153296, -0.0701123237179466, -0.17450547754214008, -0.10530292585994595, 0.2163194985510935, 0.16794459827186595, -0.42082767709049695, -0.45146586686083834, 0.5176400945380628, 0.24987193310745376, -0.20524508046120157, -0.4135553353488479, -0.04688339174175035, 0.5480932152339287, -0.2377796481719676, 0.17694711732294555, -0.6523833290647574, -0.013368043354428314, -0.17992594987635727, -0.37121609197014555, -0.09675251797099238, -0.44934443073353375, -0.07926837519634805, 0.289444073320877, 0.033771539959971036, 0.16047259075085937, 0.09980181967510549, -0.5036919530099615, 0.8608384924113438, 0.0018739436566190377, -0.25786649287117563, 0.34411399313782914, 0.5263793292650769, -0.13860470989655765, -0.2243151542784226, -0.1941218240327738, -0.36455514034274616, -0.10004605197363918, -0.5823200183211572, 0.09948562661394898, 0.6729735992330781, 0.3660217016067742, 0.0870782645391128, -0.06114035442977541, -0.028511089571651868, -0.4247195657867459, -0.2703711801745722, -0.6041661728791334, 0.2165242045714156, -0.5922239042858924, -0.2668916128984384, -0.28984821205995326, -0.6020639476886777, -0.5805171521438606, -0.11012461178325889, -0.20338598588107606, 0.3810902085564761, 0.35282329157755726},
    {0.2587863425239254, 0.3722044269447236, -0.40244597618898037, -0.24904227244947674, -0.34371489018776946, -0.4324448729114818, 0.5336072935155923, -0.32671960573257264, 0.30129452786995375, -0.454809372976071, -0.19375216433437237, -0.5280747947181076, -0.0024335852487426734, 0.3157352858783769, 0.5618460809787289, 0.24494597923685624, -0.3097252187990589, -0.5855955234403515, -0.24675414485826258, 0.4370434445900005, -0.3991920733268674, -0.11447266595155664, -0.02456760559205341, -0.46761273427508826, -0.16825454844785104, -0.6178416320389777, 0.034355577838000265, -0.019581321191370248, 0.29718939018753715, 0.0497097089682245, 0.044323314948218916, 0.2423862690392648, -0.07284119394900868, -0.4685638217250225, -0.3482474958085373, 0.4388470943507417, 0.5543485439075158, 0.52595023997051, 0.2877639255619541, -0.3545313722916751, -0.1997895910061041, -0.33306476292277204, -0.13262679978394595, 0.19927103689230252, -0.21032560673962739, -0.31621666876691357, 0.13279583725262603, 0.18861625850681452, -0.522371538389419, -0.5324944450807904, -0.6107180284408441, -0.16513490294137517, -0.6049379783880231, -0.5038427817674401, 0.03361563092641955, -0.6924057747512763, 0.13363020507412754, 0.11019728340796715, -0.2805763143577352, -0.5172563423163407, -0.3133453042550457, -0.538314202498806, -0.23340521678303358, 0.18031519801112286},
    {0.18577600038606998, 0.44113460921331993, -0.6888613584827905, -0.22116814155695463, 0.36334408629901016, -0.052512529107253604, -0.18898048863728847, -0.3339460142300527, 0.16511531119108044, -0.26418886396640584, -0.5860263936555783, 0.029894140617354435, -0.6146386939439531, 0.29325726989143946, 0.605797505412971, -0.008146907038051843, 0.36541931385671766, -0.05108202867509786, -0.526279332168803, 0.047498942190714474, -0.23087481828847595, -0.19898327316409603, -0.4107233717116154, 0.37633985074419407, 0.10238148776749245, -0.428681855882221, 0.4652872917821288, 0.3969362813519302, 0.04015756846386074, -0.1481805659584586, -0.7298386463371588, 0.09143037751659307, 0.26485177526627196, -0.28408443793845883, -0.18116348441696234, 0.42819626975481595, 0.5814163791056141, -0.026058295754074434, 0.14884315593421393, -0.11825335478250502, -0.07258422272526167, -0.6802876791348031, -0.5174304145684381, 0.39819641414507306, -0.15698199072135582, -0.5991857863866319, 0.33587735157584175, -0.2186939898557597, -0.23641238068807877, -0.4265975897289054, -0.09657732241187036, -0.7084302136118554, -0.5305385506929393, -0.35704712254004156, 0.3521235388121881, -0.44283141290764666, 0.6611806939416794, 0.16023014033237037, -0.10020902955996638, -0.14308390790654849, -0.24965604207993078, -0.17335930248674508, -0.1374029677585963, 0.5211973901871213},
    {0.37054026070633916, 0.5041929010914209, 0.0947532420844348, -0.3733454461815318, 0.5443951426357442, -0.012749116764090162, 0.5969053918769461, -0.13274587695009232, 0.5462640390519673, -0.4035886121499834, -0.36763131350470146, -0.10460517386418634, -0.26448732050021434, 0.35089200703086254, -0.2580793236597772, 0.1764544748784731, 0.3953263009051469, 0.14729538110116994, -0.1400884860412469, -0.2659214724675722, 0.10736444203006373, -0.13442753752143127, -0.1308497972432044, 0.07823324266589939, -0.37205516301179054, 0.047528760235826986, 0.45169873711904995, -0.2205308932130328, -0.13916223714758152, -0.3908589124786669, 0.047635216431332894, 0.08534200466927504, 0.1566755790778349, -0.11547484068322518, 0.03034339051595523, 0.6390448868353896, 0.17302106717831275, -0.009926763886900137, -0.3322603313680611, 0.2458367814407212, -0.18825591106210204, 0.0009342045131031807, 0.16786027469081058, -0.07878211048979977, -0.543919446991209, -0.1562076219262869, -0.33750937070179027, -0.21797936892647884, -0.16758509054798318, -0.1721466162223535, 0.10240214649810479, -0.19438420050492827, -0.3236430571992283, -0.3918976260481861, 0.09792291284808545, -0.438631357236283, -0.3419683224796933, -0.39246233982238726, 0.1262238998224847, -0.09128981711397455, -0.20610680424200462, -0.2938485502046671, 0.37479121661886283, 0.3052919590020488},
    {0.3484795065464606, 0.1952862171746469, -0.08869791126456834, -0.4083753086815325, -0.2411590050023969, 0.31463027939897825, 0.3969918372711941, -0.3704523253565607, 0.025419082170207854, -0.18289945718971357, -0.15953610175591468, 0.07569539629335041, -0.39371088980322644, 0.6050290599730238, -0.1136271373532927, 0.10752791676672446, -0.07749295743621076, -0.3386581230645765, -0.2781954987531685, -0.3458131820615453, -0.13560109584026997, 0.43475260199351784, -0.013464040078817742, -0.18433285770372734, -0.2941993686956334, -0.5622008630395442, -0.12507449791813552, -0.35858197301364303, -0.0021997798519953096, -0.15471504568426112, 0.022485489509150268, -0.3400333116761868, 0.14185835369084568, 0.3037652416153074, -0.28568969061242566, 0.5368358365055078, 0.27966639151231276, 0.5256239775276893, 0.19713784799139716, -0.1429207672247945, 0.14011037210300484, 0.10627193356933526, 0.2952823850478402, 0.047117921515477376, 0.4326790010943947, -0.05338324039281683, 0.5307484403223612, 0.04128942620162981, -0.47730329161471413, 0.10463549782516264, -0.10814051447803903, -0.25146031126470436, -0.6483957214601902, 0.27568832656970227, -0.35987427494092034, -0.06875031803916674, 0.043966307327486055, -0.16703581009320764, 0.2069854382646084, 0.1105844086902791, 0.21311431017080668, -0.32288964885872834, 0.1473626717598398, 0.12644064956514772},
    {0.27314586536255747, 0.18267304218324049, -0.2826000871909101, 0.19077497426921533, 0.19884548709711714, 0.35727183566874937, 0.20615901332024145, 0.08338875350539068, 0.06214640458725978, -0.35016916212727134, -0.17435450351225737, -0.018502030301622518, -0.08112051407299907, 0.04071661413306273, 0.06875582759224191, 0.21560314855172066, -0.2448978876778732, 0.557060545860233, -0.15843848192742813, 0.18602669122940363, -0.1975695303917151, -0.22750476145673687, -0.3331170773179968, 0.4906667356108833, -0.25825419711735886, 0.26959022103719793, 0.45780914925900773, -0.3545202143982253, -0.07297953394962618, -0.5461649800001886, -0.23758260474886436, -0.43830136542971676, 0.05266071532948046, 0.13322343163422312, 0.013449549682315263, -0.19493208658040723, -0.4034218496408994, 0.20273663105803574, 0.0547725749755403, -0.2936337221638773, -0.1945771478688576, 0.46600115934518127, 0.036836940360749096, -0.13577534013805423, 0.08689412716124598, -0.1252724194017995, 0.27274972678649423, 0.527879117720435, 0.17007238266467134, 0.06027304422832155, -0.17152681675279732, -0.3214906026470388, -0.07548447828172412, 0.03078147547647948, 0.5949380226368167, -0.0853740172338136, -0.25722251720058553, 0.29193726976527173, -0.4585299024658267, 0.04604892221048205, 0.27971749398145884, 0.20826970564917588, 0.39160608093627264, 0.17772337812469063},
    {0.06100462796791702, 0.2239130319739559, -0.2087537038236364, 0.34373758302194146, -0.45662645065941126, -0.13490208547876964, 0.6545416214648914, -0.5765528652329082, 0.5783336925827882, 0.010994673119766152, -0.4025041519821913, 0.39587857393853815, -0.29254918997466894, 0.42506366435275955, -0.049353884623100815, -0.019619193846238933, 0.4323273536213098, -0.4888454086701812, -0.5152945083848277, 0.33734891146602436, 0.031741021342425464, -0.3481441916284493, 0.5515738799688719, -0.17689416008954384, -0.09348186462723139, -0.33148753340933435, 0.17289150682389043, -0.07816873089528478, 0.2790421726528384, -0.21044443986344818, -0.1933626541744888, -0.07929407601182771, -0.4940629529822498, -0.202074748761867, -0.30540247628266565, 0.31597262689768474, 0.6007100571722646, 0.27834551864385787, -0.02601049894648002, -0.2526489994103955, 0.17078218730689412, -0.2698636086252335, 0.2725015252022713, 0.14088203821020162, 0.29547752343310035, 0.15966345281010763, -0.546417353394348, -0.05620584629311784, 0.096900762042604, -0.2781896659624629, 0.3730087482000175, -0.38158245466036467, -0.9347338169083337, -0.4460521307130022, -0.36564086596048995, -0.5174840644980356, -0.13838133670222658, -0.13041367018917444, 0.14188498142592157, 0.21379578761943688, -0.48716430590720083, -0.1817781890505756, 0.04493553842883809, 0.36620850887362966},
    {0.2539730663469128, 0.65291762636565, 0.3316129296749662, 0.08334671268269507, 0.35791295807483925, -0.14566410952666425, -0.47127159784515243, -0.6440227927749428, 0.31221331184088713, 0.13321211619257664, 0.029787960288505177, 0.15096446302603306, 0.12526130289188045, -0.13838573142792546, -0.018972654224716473, -0.6492262354584629, 0.18861675695216326, -0.005834660009440064, 0.17962212607547084, 0.06383779795394078, 0.3197925427556531, -0.35244862727329695, 0.1172161016827273, 0.09722230665443163, 0.5077288488036834, -0.357513086869927, -0.6438703321514013, -0.04333000734361287, 0.07157439918103595, -0.22838916861084183, -0.6625396488018834, -0.5231630913917374, 0.04116241442034452, -0.019853365493100742, 0.1825165894107979, -0.12732717311078948, 0.04847490080733827, 0.11442025621411468, 0.6295839870148915, 0.018769821372721963, -0.4722508262088624, -0.2894494873501787, -0.307213376203083, -0.4162273337928589, -0.41763505809400414, 0.3816993828607927, -0.056714941332382, -0.6162066767573461, -0.40258132315634615, -0.5176087810434793, 0.376065719142806, -0.9273984645123998, -0.3650598274442892, -0.5415500243591649, -0.3372165418545362, -0.73724288884643, -0.29932098171528193, -0.12390674789184793, 0.35318918990051806, 0.1259076218267416, -0.28488537852461776, -0.5009464873257872, -0.7700403351302924, 0.3727188020197805},
    {0.4696124629228727, 0.26219912647167426, -0.017956532387414036, -0.11561467468144938, -0.1088714354870904, 0.07285865174039426, 0.5365257401998386, 0.021026117477893333, 0.23732405012883004, -0.2500100695807397, -0.18017042483601145, 0.09965182091777819, 0.1117787165802697, -0.3022786013191495, -0.3200469872192417, 0.25866557082072406, 0.5328133331233849, 0.16566909358652382, -0.2524231169546178, -0.23217347035365404, 0.44514833924581737, 0.04217592700787424, -0.017423303331028085, 0.0801903914399455, 0.3638255276029211, 0.10839487489007656, 0.3382112025873914, -0.0988571865511992, 0.047506992235302185, -0.552590119864934, 0.25460063566846614, 0.5739735309651097, 0.5177268227364755, -0.03512178101230695, 0.34376361654193865, -0.3726241264090589, 0.20656146858345745, 0.4466112736552899, 0.4163671736027055, -0.061154233848939296, 0.021974035164204556, 0.17782469433885162, -0.18251561172029088, -0.011843790007253644, 0.011054908070393464, 0.45124339817650205, 0.25883174657447056, 0.07260569668045094, 0.2247100278066652, 0.17206096592053172, -0.2386247688383289, 0.23783288492119875, -0.18239814086975417, 0.5175343952470998, 0.4727282589466131, -0.34658962458055, -0.503200163966126, 0.246448400516168, 0.22958150507693142, 0.15072461645135818, -0.6268681820587008, 0.05277543704245306, -0.3179788010700294, -0.20102301710443665},
    {0.0473088695328568, 0.29379549501758334, -0.09909983967932706, 0.08464021930113241, -0.2349252773775675, -0.1019944639292224, 0.4909825880223286, -0.05545666508273801, -0.2633620420467948, 0.05578474310913664, -0.5325749108974077, 0.30892221337156506, 0.2784573898434762, 0.32832673412258045, -0.32950208340618853, 0.4764390772932097, 0.22463468468586548, 0.05761115693761271, -0.2416071019705891, -0.6273773964698771, 0.05812623068531191, -0.14120754722193937, 0.22652320235906678, 0.17446141015721203, 0.20451711055453312, 0.13676549510946093, 0.12911259451564913, -0.24423505104985002, -0.255532646356485, -0.3092064227493945, -0.04160700650173188, 0.06425775696373348, 0.6349977848038273, 0.34120094648039184, 0.4420168115659662, 0.025760832083677764, 0.5193574878151075, 0.061607613635593646, 0.40022120473175216, -0.04589082745288227, -0.13235934438538854, -0.34584634932822783, 0.10482347443456347, 0.21200753104133116, 0.24229033921458326, 0.29709475592867585, 0.2045935255321904, 0.04720614418425019, 0.11490930016299018, -0.1520319821123451, 0.22074419526756317, -0.6603726723524957, -0.05325179454520295, 0.008657310057015366, -0.11861337824048591, 0.21247146251059754, -0.040861817115200226, -0.1890288173519912, -0.5848972131342696, -0.11392034525055292, -0.20672472672622172, 0.3513822445334674, 0.3016357112161527, -0.3311074107067654},
    {0.21540132867579184, -0.3603119594671686, 0.16865406453891318, 0.3977786116757825, -0.30358710103466974, 0.2189540489122845, 0.2663803229714794, -0.2729160460885506, 0.14796420788123366, -0.12202417090181246, -0.0575332833696101, -0.09384157091606107, -0.7609490687416798, 0.326984651518772, 0.35672212374387735, 0.06299507809480887, 0.006109786840108196, 0.3845240110975596, -0.3072678292381123, 0.11412476947684251, -0.02664785497991906, -0.33480055576117557, -0.0938043170036714, -0.10257106399364292, 0.24497206909772173, 0.06060976300420177, -0.3490427849986713, -0.2036727231793164, -0.041996234990957705, -0.5106963753279101, 0.4497737817390667, 0.5787213110107483, 0.3443232028528869, 0.36185020018555986, -0.086729377280075, -0.34176147335150114, 0.04888437458105782, -0.08321889886368394, -0.035675423724110006, 0.2528658412550853, 0.22702087699930087, -0.21635023186505772, -0.26097988159007945, 0.02691719082825114, 0.33390041402238185, -0.23208078813453398, 0.021887653847349763, -0.1034944553251877, -0.7136808860876931, -0.3442143722908035, 0.020742311668234162, -0.605373196094206, 0.1287784102951555, 0.16426629668154466, 0.527238887055246, 0.016237622434271386, 0.05988588363102927, -0.2369574879750166, -0.12523862213184517, 0.21470129877606536, -0.3643482456527976, -0.10130726543407026, 0.0020177072882547084, -0.08327349132772154},
    {-0.09990706147266033, -0.11043721851265204, -0.1972008151638259, 0.3023173896469487, 0.10614500790536259, 0.2472004889357354, -0.2663182059580597, 0.13939920784131207, 0.4812888700994145, 0.6833639710444825, 0.016506882083456725, -0.16085180042714636, -0.1651159286072036, 0.19346106431784668, 0.22034826127830906, 0.2553364958605505, 0.3729691530674501, 0.3132341317008691, -0.13620423013755836, 0.04725322344523337, -0.1607856013881837, 0.015727721532548467, -0.18954673360511212, 0.30945003772643814, -0.6166552955536981, 0.12049298028094327, 0.5963411726675923, -0.08816629845980206, -0.08397962533605151, -0.5739933574175896, 0.5899352856885984, -0.03822970833773757, -0.029740388301593472, -0.10641416545618816, 0.3616812617145954, -0.16672179458439718, 0.6521156522986398, 0.2581510871507883, -0.013090706526826165, 0.20125984653924742, 0.326650315311629, 0.24318657016296563, 0.35789660729019096, 0.5367313158225743, -0.31609362087706167, 0.019917940398460083, 0.37769176730617243, -0.4225559578864452, 0.37362830850004614, 0.4043157337635043, -0.0007085286757167956, 0.12127497252764885, 0.2879460805605537, 0.4655718630411378, -0.1614009378644001, -0.2523497189061103, -0.10766109434039846, 0.3162446513996002, -0.1032449627537565, 0.4303350770997963, 0.025682331961314916, 0.1465303170453564, 0.12704913610107363, -0.2545943690797957},
    {-0.17052553551789798, 0.28161001268330327, -0.07675791578064672, -0.5004120908284574, 0.22635978133929419, 0.2774837564056284, -0.23639583778424086, 0.1623833039682126, -0.019609181762633283, 0.04150850462396308, 0.06751060365638181, 0.09758727494127814, -0.03152260769573253, 0.1707153292710306, 0.5040514175763319, 0.22098027241831136, 0.1441234113601129, 0.5410527239894125, 0.190194635386182, 0.19172318812190012, 0.02136409953587319, -0.10456430227452423, 0.3128931340687584, 0.14004780295307837, -0.325164801022353, 0.34227116303417904, 0.33400953740570916, -0.21764366457529166, -0.13680731668447701, -0.11161620251843499, 0.3810072432861058, 0.16246911337945055, 0.5062223160854991, -0.16105734367860183, -0.3979680851262143, 0.27220775784653867, -0.13302986312989476, -0.05863178827626739, -0.7328886983729309, -0.15672842214732158, -0.13203832055563408, 0.3174600307721048, 0.19890526931369842, 0.05860614993916956, -0.17593395605742201, 0.42316904471878797, 0.01465465131096813, -0.11061357479482488, 0.4517889805608255, -0.1260510211505408, 0.12630648849287682, 0.4608995639313384, 0.3037630335457256, -0.6267248969987624, 0.1603786387291896, -0.26360058600858816, 0.06831767052334145, 0.3669454420289082, 0.1853280588511326, 0.2478752570366205, -0.08204271519276707, 0.36652323797403946, 0.5402624788157883, -0.42131716680068865},
    {0.23031510655278314, 0.005773681362481315, 0.0900950989609912, -0.1921004970433004, -0.12570286064384711, 0.3677145924005716, 0.10400027915985928, -0.46120023152548356, 0.7063728186243952, 0.04866784362096572, 0.07389472247466373, 0.5058351730412546, 0.31341688944942847, -0.29775703792756547, 0.4159424256047288, 0.614382217192402, -0.03137923581375359, -0.6006167196362425, 0.42131454396175383, -0.024998663094541775, -0.12445876427628001, 0.12439321835278584, 0.049145818708981985, 0.2453793195907859, -0.03832226034628121, 0.8203554698152807, 0.6278453970500355, -0.2269737751136231, -0.4924805619015284, -0.32932090210039255, 0.06998662218314891, 0.12602422933673108, 0.34654697489317554, -0.5150741192583778, 0.10067833292619814, -0.12612628326139974, 0.33699116001606916, -0.17357740241185485, -0.21048645235387528, -0.34096274933566006, 0.24204709068531233, -0.06815840712848743, 0.20256428149382197, -0.3049379155190073, 0.4683305589195401, -0.22052680749838774, 0.2926924460375048, 0.43612219612546693, 0.4813813298083362, 0.46396087533674607, -0.30933562626012423, 0.1260514387841551, 0.12621145027696562, -0.21380185707283209, -0.22129211624460976, 0.04319361442173235, 0.41913445853235237, -0.023505532165358833, -0.4337281357545421, -0.45460680821456256, 0.46442478774112206, -0.10278751943289835, 0.2345183712346041, -0.48504697900799687},
    {0.28140544059694717, 0.28025240918724303, 0.18693598397975292, 0.022196967103653303, 0.5002089098949514, 0.4812807358547121, 0.48867741686335375, -0.19538549096990068, 0.4132110437950927, -0.15486044489001025, -0.38107730538092444, 0.4055503764403898, 0.22252885589490443, -0.17177308025288093, 0.2727416320149839, 0.507092526194981, 0.0006132988505682028, 0.018012999583750168, 0.1831842750787875, -0.12279654762453074, -0.41639061694695917, 0.367891913309898, 0.10999376485097521, 0.23713732037652605, 0.4925352048869398, 0.02418507320704231, 0.6300900802315613, -0.004318441875672563, -0.4806949569243041, 0.35959143978520364, -0.23781192867661957, 0.14149387561681254, 0.33966073804185476, -0.010971426433855277, 0.39856676762099064, 0.4839359334083111, -0.03364008079701021, 0.10879780814423487, 0.19339624215921522, -0.08495438689262029, 0.008959212769807406, 0.3409234231154912, 0.5626882623154654, 0.2591092638254378, -0.20513189187201805, -0.008183663897053552, 0.5801936704157209, -0.1210711866487901, 0.2471162184252681, 0.10370784466660773, 0.23788922038648727, 0.1951953561853638, 0.32156781664609757, 0.299675118256932, -0.13853469907350036, 0.22339062342920735, 0.30470350548154507, 0.3540182891354939, 0.12097141134400731, 0.2338136824962287, -0.16966086577934789, 0.5406586103566867, 0.30767734923078377, -0.4048001709763514},
    {0.02458530273434684, -0.02681801606314652, 0.46795737152199884, -0.1822202903567476, 0.057352308119642814, 0.6053220754453411, 0.40970510913289254, -0.1018899165612393, 0.07441005221018909, 0.36690078509008933, -0.17481882857121311, 0.3760295209844721, 0.38683826081125977, 0.3481505098391175, 0.12434504965473238, 0.4840056593701904, -0.4607795910302867, 0.12344088916340935, 0.2754621228805903, 0.11890026685210237, -0.23445332205453207, 0.3143103736271349, 0.2533269273223801, 0.5456013278717097, 0.03530511954435588, 0.16883173302946736, 0.25342333136696443, -0.07799730236974278, -0.09729614960384722, 0.10717239796865924, -0.01925255053138977, -0.44694358144509383, 0.5020058611471185, 0.4969243920427055, 0.1773653537476488, 0.2555968919406523, 0.17408090025506762, 0.3853829618108822, -0.13487397831834366, -0.15605324782391788, 0.253447473249686, 0.6513627412753212, 0.7296201750338386, -0.26004219301395026, 0.2586355744643846, 0.08637393743443482, 0.21103204695596334, -0.045488084052731415, 0.4000666123808183, 0.09536245100831012, 0.43032811930907083, 0.48112178098640407, -0.4685792052088737, 0.344712186735528, 0.034244271358039216, 0.11337966043271512, -0.1502886661520526, 0.5732005534123347, -0.2764241309715956, 0.30555842514309983, 0.008865160908772216, 0.5327574662342405, 0.7492048531823198, 0.002156154165945912},
    {-0.1060257524960685, 0.40667817139915996, -0.2569388916110586, 0.14044504837549876, 0.15716991080492412, -0.13585370747633457, 0.4941013577806623, 0.26670584292010074, -0.15100388944827484, -0.5222737622243478, 0.2900253069748046, 0.015119478680331365, 0.10947294104129113, 0.30556375796621327, 0.5163479666774229, 0.2618142302250566, -0.10329196716529412, 0.2829638430890823, 0.19706738530248408, 0.4730183565016998, 0.0565322859338742, 0.24146037227470335, -0.1765666255238415, 0.1370433462942279, 0.2047132399333376, 0.28255310454751237, 0.13932785109171833, -0.09180567610960216, 0.12552534795796022, 0.058838276031455854, 0.4544604605722938, 0.25970597686018226, 0.4273220077623304, 0.3916974383922746, -0.08358673711478104, 0.3692715236111283, -0.08262645721304755, 0.3654584643791886, -0.236994126262114, -0.135981185191586, 0.1735508655571239, 0.46817699997051765, 0.3346733453853487, -0.18493217482454166, 0.41700238351311814, -0.05366362648895379, -0.003662987316521946, -0.12619448450982843, 0.07597142055301151, 0.4628239868160746, 0.3546798242229375, 0.40028606920221926, 0.43075236352620505, 0.22234587914692538, 0.06080615860595306, 0.2279709746009036, 0.14417517301430238, -0.06729314084596874, 0.05604162660837181, -0.5286053991264648, 0.20099253823950639, 0.3033077599059062, -0.028580820939843238, 0.07951862895435308},
    {-0.3437047993327505, 0.3289881041769971, -0.8485289541312028, -0.10314815442460427, -0.4047492019986771, -0.23119887228261055, -0.44135048660071946, 0.3652944627075651, -0.11119918504989211, -0.344133350643918, 0.3146020097837573, 0.4912112226838147, -0.7757248837778395, 0.013905558761785758, 0.3955432257460453, -0.1345206428964925, -0.00023410128132307246, -0.1457917595116768, 0.019005672848472526, 0.10985189863648656, -0.19631519924327756, -0.30418821893363857, -0.3439060108642703, 0.2952933190807393, 0.06378623375268813, 0.4013541979948399, 0.1925975677181757, -0.022824314500314857, 0.3527328311537252, -0.9109253387890051, 0.17302970383336547, 0.16069547429717962, 0.11246849578372223, 0.09602213713381919, -0.02477819694447748, 0.44818248790045095, 0.5905993003217881, 0.24660801086111744, -0.5000530246512653, -0.1016679901680017, -0.24852830142354418, -0.25905714630740184, -0.12642941148769204, 0.7334187303310278, 0.4329351185243723, 0.006571086405373526, 0.25365027704902, 0.2644601421288008, 0.21769404198755332, 0.2756328163941835, 0.1848374134448373, 0.3313762152267913, 0.08831158222525586, 0.18743159366352258, -0.5109397106285609, 0.5170737133792024, 0.4059125213532517, -0.06333659442385695, -0.1114385486473174, -0.4838374728385272, -0.009346675556827631, -0.037865532190464964, 0.09812149009683448, 0.10592846425578033},
    {0.023000027079735398, 0.3553288389419522, 0.24816809548944951, 0.44886696416725297, -0.22015384435072313, -0.09362084930404312, 0.3449646084964012, -0.4170777441097611, -0.15292772133445134, 0.29018624253567643, -0.3441163316325193, 0.18599580914378266, -0.3013355639796878, -0.07416655474096209, -0.055979824220132354, 0.32063398207070193, 0.25773064413870383, -0.29844686753642324, -0.40394276673281365, -0.2925922257556738, -0.04274939778153129, 0.5696492759431802, -0.0294858342787672, -0.2151765466494563, -0.130332848984397, 0.3490250416352027, -0.2811820769447126, 0.4412064729367445, -0.5159017177302223, -0.1383029195841051, -0.14015321113532578, 0.06954878111084475, 0.10917541420892442, -0.7010917620005146, 0.09225692067240483, 0.4925159618655205, 0.7403727046391847, 0.3000852359987197, -0.2936125454031425, -0.47165073696203774, 0.4048261176792069, 9.845801672085336e-05, -0.37103438894591756, -0.052854520188712104, -0.20141545709408068, -0.07322672437919281, -0.16682611086314858, 0.09591826528827167, -0.38924569852644414, -0.3597045553739926, -0.17730900533901722, 0.4315738721554453, -0.14872007273328883, -0.43808455050765305, 0.035596978211661204, 0.0017795909722205106, -0.04752189614248986, 0.1157657311480731, -0.1178515377359959, 0.5332951199194947, -0.549061533831427, -0.7924214120875074, -0.041592934850713796, -0.11451432141999081},
    {0.0019608408708297865, 0.2629492870141426, -0.4451903005664735, 0.012715825142506602, 0.4183775155193328, -0.3023538712006556, 0.11065473311640038, 0.3238961097685294, -0.06613369311634436, 0.21491230173606338, -0.03779532098769813, -0.10752295820247415, 0.22808329221055773, -0.024772277809504358, 0.20931090714188694, -0.09616332515777601, 0.20193470383402246, 0.11629479111298588, 0.4808075237434135, -0.3286719282495306, -0.2909252910264972, -0.2651710478756688, -0.14162762380029834, 0.23514926266094635, -0.028148647379166735, 0.24016349542228563, -0.002424794702992256, -0.29667013952679105, 0.009754445421804833, 0.4765439116228634, -0.05158286055374941, 0.21705725832628445, -0.11046800029102648, 0.004423387201978947, 0.719905715868468, 0.6484021736710553, 0.33730219867110056, 0.6406509580211228, -0.3865474418245194, 0.3653106481676658, -0.2799842801748025, -0.4312127394608045, 0.05704558493160026, 0.2826229460254913, 0.4307350522826262, -0.4049250292343372, 0.27116681551017113, 0.012505208628342937, 0.41529144592424416, -0.43880354742622374, 0.4410438132706268, 0.1293873179336171, 0.30440431890158487, -0.1699245803708521, 0.014123720072222484, 0.48567581645300556, -0.3552498088094797, 0.25014486376372747, 0.2219723503381238, 0.014194307572390203, 0.318272579834509, -0.15723625874105449, -0.3655465165241315, 0.20394459254757577},
    {-0.24032268021332126, -0.41840736369780696, 0.0728714777247451, 0.13943969843390863, 0.44504339351678707, -0.1579619487880596, 0.134214999940441, -0.341604009741847, 0.19686277591838924, -0.10651817746975145, -0.32472674664989504, 0.08622226252402154, 0.3944217655073365, 0.0835989900651165, -0.4085841857126738, -0.03699105292090583, 0.06761840257008099, -0.36107323074429953, -0.569893294687126, -0.26240934813940475, -0.48755768078899675, 0.47649356110881264, 0.3894406952763315, -0.09142521215795221, -0.257996069919544, 0.0527981315935791, 0.46274134117485183, 0.6454122482480964, -0.3057001752177156, -0.33417610922017654, -0.44063052969894667, 0.556653891894378, 0.5344075282207669, -0.009112807898443794, -0.3071965852059943, 0.07713813554495798, 0.11849084487974898, -0.09050587932914117, 0.2429383278390507, -0.47971315064814496, -0.47763720148122185, -0.3037439113198245, -0.0705728320902144, -0.0018869019497359007, -0.353876479769202, -0.5516337687501343, 0.0888702124215043, -0.23351621951504725, 0.023278370891482554, 0.05537016818922965, 0.0139358030077192, -0.4774782069064599, 0.1739086325005078, -0.00025444657676541, 0.010969286260394175, -0.19477640025719747, -0.21298460062899152, 0.2693121922048211, -0.3883121063837725, 0.24027291435931683, -0.19745115986132614, 0.32441543567410197, -0.594500468556062, 0.5291304782578427},
    {0.018040119556848578, -0.462046732878584, -0.2815572163716882, 0.550064928215711, -0.15894672374017735, -0.20762275385167783, -0.2808709219812937, 0.2417668055180833, 0.2011378944436967, 0.3829125142435289, 0.22259923618861943, 0.24161892215951417, 0.19142401279978172, 0.018020013310878782, -0.06438101252598678, 0.1019677981963569, 0.11404067413793745, 0.06041501051880779, 0.08976457870389966, -0.22680658718185276, -0.7902888066226654, -0.1874579108250663, 0.03938838932096636, 0.239632512751912, 0.05632626480785725, 0.1208450439006654, -0.02952265450468667, 0.4032597313224425, 0.14092122824771905, -0.18613508264799225, -0.43553174254849125, -0.18103967125441392, 0.03074659018455689, -0.40608765143828335, -0.2575260843796834, -0.15770343803191503, 0.26228239232070705, 0.2116331796504887, -0.0669728856127841, 0.3183720493502179, -0.5607581474678501, -0.3280901833758772, -0.07765013187393768, -0.07025593004713532, 0.5492867774358278, -0.20270442678054734, 0.49260714495449837, -0.008850794057963452, -0.1634799626322783, 0.36796221171371507, -0.02591963932956245, -0.25302581422536585, -0.32459667994770064, -0.26890751725209766, -0.03312370529276393, -0.031938551540093084, 0.5354631465065981, -0.014431458152298765, 0.15098990828999867, 0.4360239282993286, -0.2857610598707224, -0.26672950216066155, 0.3949455565987057, 0.07868895702208255},
    {0.9017585026518349, 0.7872200273958933, 0.7872956645743496, 0.12863051414996873, -0.05342380696330377, -0.006851410523530595, 0.633023958932614, 0.10368161745296967, 0.5540467889355889, 0.05406535698569023, -0.7502853451565505, -0.6245958886366567, -0.022081326518098247, 0.41089473455787884, -0.6754264127820724, -0.17825528944828584, -0.14820243053742413, -0.27658628114101325, -0.11255894760898955, 0.48425410366994565, -0.18970645334437064, -0.29434080237028565, 0.2283527789078164, 0.7554162143204338, -0.18503484031193876, 0.37262709624698337, 0.1523679505924982, 0.38567243747498287, -0.3835478957537415, -0.3288488531205669, 0.4434545175076105, 0.01585027309084013, 0.22837486854972827, -0.007107458237864572, -0.2857594510527105, 0.11368790663012318, 0.3035105805494988, 0.03473324977648788, -0.22192039768357463, -0.06426788348706333, -0.2892244866905129, -0.46642377004518926, 0.026056413183851043, 0.16095555281024043, 0.3454671090638244, -0.3805947530088652, -0.04909380089576024, -0.06510230631351015, 0.0812102890408425, -0.20354390894992314, -0.2660010510022214, 0.19161802670944497, 0.10257509709859053, -0.28088583719760635, 0.6144947660687925, -0.1661939980342109, -0.5511532927593069, -0.09521620832908388, 0.07945709337849864, 0.21229030769139967, -0.4786837573575049, -0.16802519456636197, -0.15471416851569705, 0.5837796471662668},
    {-0.02743501264099462, -0.1434816152258912, -0.0343160149110186, -0.17560307321038962, 0.26284276581919397, -0.2737810853349842, 0.2179466225470627, -0.5591554888138223, 0.1603151825782114, 0.048219835433412434, -0.07459986602825225, 0.5652625748915487, 0.3259069393466899, 0.44576501854471695, -0.42921249545909507, 0.046762654154984734, 0.13119896502631154, -0.013266393731332753, 0.1745814790385923, -0.05507194833612671, 0.12403670430870434, -0.21740597656886784, 0.35963428057491686, 0.6678898134311381, -0.40687649583155566, -0.2015718965568771, 0.4238166593600775, 0.04664702985362967, -0.08423502884504135, 0.283049215530311, -0.1113522026301067, 0.0788823585426391, 0.3239364803163132, 0.07255467613695958, 0.149867936883856, -0.20085447902676867, -0.019875547867962497, 0.41255208165445684, 0.3367343204959434, 0.1264703256333969, 0.30841045146474805, -0.10235864676238175, -0.12073468679076899, 0.4919993760633425, -0.07428042622249789, -0.4826149510425848, 0.07882562988504573, 0.20301399003363743, -0.08765308643207584, 0.034291968540130856, -0.1312301463771634, 0.3191121120142888, -0.1146917688230014, 0.5049343886727845, -0.11256172463965344, -0.21930066477592153, -0.10315373537336461, -0.10263720577727328, 0.3219723288825526, -0.07013350007957328, 0.053810487241355426, -0.38960075787250825, -0.14735687431006417, -0.10516671384944008},
    {-0.004493590329035557, 0.18791059201866436, -0.12486640902858584, -0.023485809047458006, -0.24247787860385134, 0.25723226233765706, 0.21695647664745235, 0.20596307792384033, -0.04306468066120046, -0.0015747899262581002, -0.23712994272381638, 0.12878905122198248, 0.23033145560327492, -0.193592921714345, -0.14599420181339223, 0.037698320297740305, 0.0338807209346296, 0.21574732891025847, 0.1492807535294288, -0.26881041857903, -0.5684221244068316, 0.3727107658944566, 0.42506939634070756, 0.4989919301444886, -0.13118640969713855, 0.13822615568762697, 0.07498969460762941, 0.4113166580171838, 0.15823606251194286, 0.1998610462345811, -0.5402131267942798, 0.056922680314041886, -0.22101879892511173, 0.19042908902740238, 0.3401568627558524, 0.2097796720284143, -0.1562898073011316, -0.059860988978450644, 0.3257896089060497, -0.09565745604046733, 0.182263314852499, 0.16953009497975208, -0.20703702647598055, 0.3817095017099443, -0.3489975715329888, -0.23273636610783252, 0.1171478377515557, 0.23802788609501052, -0.03009191250976153, -0.009512578108994748, -0.23021446624995515, 0.25086875070437015, 0.19389749800548617, 0.06425669762170678, -0.29214609063017766, 0.1619838663462795, -0.1653875749992882, 0.26580284860007863, 0.04952103550515892, 0.26690627798746325, 0.2961333305200355, -0.12342353413543346, -0.0932440797064659, -0.25648303892156143},
    {0.3783311373770358, -0.08966433091351755, -0.0706925744069219, -0.4718786265173085, 0.20962332624134086, -0.06491243204887902, 0.3592749805392382, -0.42331571538157786, -0.26695057094483815, -0.09970729291765736, -0.02253449794746567, -0.20531052819332052, -0.07518794222778666, -0.464922676571509, 0.1797133701264922, -0.1250528506526874, -0.09776099593836121, 0.4281946943540179, -0.23080909094477656, -0.15021069003206455, 0.32762332420407264, -0.2174110246560773, -0.26713188014618755, 0.25555934165828453, 0.3609274933555071, 0.3646364929932716, -0.2796964514653737, 0.23471114941901805, -0.19764639010370497, -0.021504607476285836, -0.08665075975719293, 0.18430800997619987, 0.07620959407489496, 0.00021671764778875393, 0.03990228880908855, -0.5833263148832593, -0.5966997009567561, 0.010399473691025193, -0.06699336068740043, 0.47185845490692824, 0.18387142013526156, -0.05203810089676264, -0.09037941100977574, -0.22472218748406972, -0.05369385398387095, 0.2818899499533241, 0.2555141119206689, -0.6698907166890626, -0.1363179858761442, -0.37713928425659493, -0.0855364378167211, -0.3703799558952159, 0.014565475744566967, 0.054270763283303686, -0.1425441405696528, 0.19639654355141778, -0.14708863650727005, -0.08470986001457131, 0.24129984672359892, -0.44211644683749957, 0.025788073611223764, -0.10261207148451108, -0.31145517303875814, 0.057240967656489686},
    {-0.23765042027722405, -0.2494258136077317, 0.24310458033785018, -0.09207565640169053, -0.2957782846991064, 0.3437529472098918, -0.09544203015485096, -0.22404830392428435, 0.1975650309124668, -0.18310640588056162, -0.3678096204883704, -0.38319648452272526, -0.04755039205238452, -0.2326006100693146, -0.16967417421226882, 0.16387266511888143, 0.12807091376720506, -0.6486757977568948, 0.052546702689891644, 0.7315834045244906, 0.39846950402372916, 0.19733492813861508, -0.38795793997503464, -0.04345759851958571, 0.387498335003944, 0.11297681917538575, 0.014271102884321894, 0.1999416223340629, -0.2814995536760304, -0.23324270495725913, -0.24860678652094675, -0.08847647959789245, 0.22031036550098884, 0.3092903425282155, 0.6268445313698132, -0.07215319861931119, 0.09113446177604269, -0.1670242434050627, 0.006343156878972558, 0.35400114819827677, -0.45143560498317964, -0.08450169068103869, 0.25986828657553934, -0.2706567580974541, 0.03632788697662877, 0.2719290840551815, 0.32942985480349785, -0.624799576526524, -0.3708359400355833, 0.24909682096130747, -0.08892077005291608, 0.13200415780933517, 0.3473244542693224, 0.08204095410526409, -0.23861866716472027, -0.2671912925481739, -0.10124618050065479, 0.16136794731238516, 0.21812467671188562, 0.025393389643698493, -0.0695499587448964, 0.32730623988733804, -0.16987436342850312, 0.3589057289681764},
    {0.07546941074397788, 0.0694324474232348, 0.11408877860997771, 0.20828807632739654, -0.6565263902985372, -0.079673779217577, -0.0036298023997176736, -0.43947325266343235, 0.4394303269572725, -0.049008388242347364, -0.04893916209915492, -0.13168383702895076, 0.06445573710857172, 0.07960965480243642, 0.3829939337285777, 0.3303249718744201, 0.647257836196338, -0.2790265152825887, -0.1752116008109739, 0.606982675855754, -0.24995179339828863, -0.11667991260124994, 0.38345376707501316, 0.013033867730426271, 0.5785949197903443, -0.2777591640341255, -0.2575770036392731, 0.21472464493596444, -0.2092353588222507, -0.3624208223411516, -0.019842308161934795, 0.16843746946561164, 0.22312850946061463, 0.1887249549107053, 0.37571166793876143, -0.11074303000809728, 0.22918767992009367, 0.2614940236539816, 0.05161444638775803, -0.3053322921280611, 0.38653864798403453, 0.2625745991084956, 0.08316207423673144, -0.1107853092147973, -0.1727956491282769, 0.13167940899315278, 0.1931576048471404, 0.21802535908105572, -0.08812599451062915, 0.5043951953790031, -0.33999569469850605, 0.00022581455996166413, -0.2022060263271934, 0.18033215323628057, -0.32084368596189217, -0.6618018708934863, 0.09192423013269348, -0.042493239542096044, 0.24570099544093993, -0.29116840443044856, -0.07040721937739418, 0.0003776953761255157, -0.024867857288373436, 0.6277682495647786},
    {-0.3371664310856616, 0.038409609006235364, -0.019013363929024692, 0.41426086567660453, -0.5202609831223439, -0.24011536260639102, 0.031318073892448936, 0.05125412973344188, -0.17553061610129989, -0.16792346513689477, 0.38937492962960996, 0.0008327123252024797, 0.06739083884352434, 0.2853018464283723, -0.23985469505712043, 0.6287239769735921, -0.26062433802284696, -0.5033099761434061, -0.03198676774030021, 0.3495218609368933, 0.23585284301101866, -0.3491823611654536, 0.1537311404198506, 0.15920566601763939, -0.19105356375167346, 0.14664323123149553, 0.13254524695844863, -0.38315929175131913, -0.1636336081611362, -0.013783747854369442, 0.5298946614185798, -0.039179920509312315, 0.09409693413237019, -0.29322884707233865, -0.7564701884115244, -0.126123358765539, 0.0938153606088664, -0.1597413816868294, -0.1256660009758895, -0.39751694678427635, -0.11249916038985887, 0.02181094467987021, 0.19241404664936237, 0.23659910601450648, 0.009422419948879324, 0.09132741702047573, -0.2843226186001312, -0.10433545159873907, 0.2290022854001065, 0.047860544907287736, -0.5513442765186254, -0.38201941084376956, -0.05016834931051639, 0.21254666610962988, -0.3097132498245231, -0.33246019635921287, 0.1823978108579199, -0.5502641397182456, -0.053420606423861226, -0.2622466228399143, -0.654779733196859, -0.3206460740057125, 0.3455429489020152, -0.230110278275719},
    {-0.12056059289195156, 0.09735634155818118, 0.2657951725136381, 0.33324932298211923, 0.028899872101582808, -0.12933595151757504, -0.07457655675113412, 0.14529406997691768, -0.6322666059341573, 0.2630986244135327, -0.12488800284600592, 0.07032286308163657, 0.16412375938320264, 0.561439916044531, -0.009319467230713478, -0.17104983985442457, 0.014095790169413038, -0.3021338223584767, 0.23157938179843202, 0.30129680907108447, 0.1974781835503517, 0.186739271611237, 0.2881803414871683, 0.1540668951513477, 0.043286439061536765, 0.25794647249014685, 0.048163625213977074, -0.2975524724089995, -0.19688816985805704, 0.19856215897511514, 0.15555429272881294, -0.22009723782010993, -0.3026787053668631, -0.1963223966082824, -0.053538457992467155, 0.42741743533767007, -0.2385835051981693, -0.06704434200420542, -0.21148183696810743, -0.3199554424412858, -0.4802306046394073, 0.14759752803750834, -0.12210394401487001, -0.5100433139645065, 0.025131990456098326, -0.1293699346312384, -0.19395042948766175, 0.1053416010553164, -0.2225492826324519, 0.12212975419519066, -0.033492909201964335, 0.3413730856505388, 0.14393390567109604, 0.3225773103441053, 0.7011464374282124, 0.5363730750621944, 0.26116883684214054, -0.4397828647179469, -0.18877541062465444, 0.14653427506642908, -0.27046826102716737, -0.2471611447956002, 0.11605820863887262, 0.07922693699042455},
    {-0.28025417199711283, 0.11935430924193292, -0.012372495938534336, 0.08096997870182471, 0.08104652006975034, -0.17770875421898244, 0.1123764298166112, -0.11527095059487316, -0.25356403435419156, 0.10658055600269445, -0.02281193712730897, 0.18369238406137872, -0.09126174463746059, -0.1063318647383997, 0.36683231175222764, -0.4138748173868183, 0.18535472787763982, -0.2902394368497409, -0.10189516133162196, 0.43478470228439003, -0.22011908050151133, 0.122850728968276, 0.40216931060009115, -0.0179100338452384, 0.14191818729416697, -0.4730548234819331, 0.048383479067199676, -0.20472317456669148, 0.26078177008546033, 0.03713430563371799, -0.07071017302709516, -0.1821412743980941, -0.2514910740200743, -0.27820848068393017, 0.15943919326351433, -0.21614994167485185, 0.006464031176930642, -0.13159152519946007, -0.19601388602244724, -0.4155786645389259, -0.059005851462215014, -0.34133176664769654, -0.05433616319627649, 0.37628835071942274, 0.22612754665797813, -0.11524473507550083, -0.26918640693421614, 0.4610722528939571, -0.07364178384888381, 0.3837023470426406, 0.2825200799998803, 0.10726967634979606, 0.2565162861163783, -0.11015663603442154, 0.6473196954967706, 0.5095706391487438, 0.2973428842035229, 0.5239495004992483, 0.2949234393823902, 0.03788891105253354, -0.10111264614646369, -0.3603425245403118, -0.05653898112822826, -0.027085771338173956},
    {-0.30870696528540487, 0.10994958448367197, -0.21116401900315643, 0.21110273384850956, 0.5087521699317438, -0.1730511600640446, -0.056946833003664446, -0.12201628761535584, -0.42153875850412215, -0.18109063731384914, 0.04711588565927989, 0.0587780415571356, -0.231223242959414, -0.48045522533080776, 0.2792142928860547, -0.3686187891797643, -0.10341981419832999, -0.38454456734655895, 0.1365232210233994, 0.23786918407657323, -0.14788044952448492, 0.05712014090242878, 0.026775054941831227, 0.11566405790527282, -0.1281297432798026, -0.27793209722721224, 0.29203607152972993, -0.4084759849754138, 0.23557475579812365, -0.21474823517124023, 0.36840163289822964, -0.4242690134461061, 0.3917497613115645, -0.2388450687643271, -0.17048179626646084, -0.5884697833053922, -0.15632847437223446, -0.40716156869341963, -0.09906118508916922, -0.21975800405208254, 0.2033667274644655, -0.47643581295752807, -0.42062541501290335, -0.2815374865122899, -0.009721179062207236, 0.24753906959618557, 0.07011043374039608, 0.06107820621364699, -0.03611157192712418, -0.2971907353650579, -0.07822232219454846, -0.10747839195193964, -0.0013413680769292311, -0.28903992294821357, 0.44881755567746395, 0.010057567402441809, 0.3995893743790286, -0.029410560373078223, 0.08593154374009661, -0.25124705360349026, 0.2291721667625078, -0.27540055939982344, -0.29231305884193126, -0.009776811080525555},
    {0.06026634263812679, -0.5619134082937441, 0.07459016543743008, 0.25636724387359644, 0.3455466409707637, -0.13670385024950277, -0.02389211478328649, 0.40495419992606746, 0.11424118481201101, 0.41864252651104494, 0.23316950066802922, -0.7901944728977833, -0.20517139361614756, 0.17888116067170037, -0.012348690652511783, 0.4046903284270003, 0.16971922612069762, -0.26606205079205103, -0.015893610866063272, 0.5669773507911748, -0.015766691621216206, 0.2234393202051062, -0.036817113547838905, 0.024704895569015266, -0.07334548931720787, -0.33235687946718784, -0.026219134811515124, -0.1341059663101095, -0.4432494715180532, -0.6292953991364043, -0.15389421967958292, 0.04912970362920674, 0.10228283891433214, -0.46726262737356683, -0.07432216691996059, 0.05547892040409025, 0.38502862365563734, -0.12416702978907661, 0.22835098446567048, -0.17430025433306046, -0.1082614683896051, -0.32130935080399675, -0.1282566299412516, -0.23595163446268524, 0.3334426025233772, 0.011489389062519631, -0.04111689947550122, -0.2636804235933047, 0.6836541291988532, -0.4178934196477234, 0.28552076944194454, 0.0843737781916823, -0.403379022505489, -0.2822361958887486, 0.14773464798196734, 0.22894174373189072, -0.19683541001298402, -0.24956173739111095, -0.24363247456059234, 0.17738723540997028, 0.11281246635234725, -0.06656858148341055, -0.11534984197873466, 0.23646432656997843},
    {-0.01802974960030955, -0.29011375572310066, 0.2645813605722527, 0.24261226637560643, 0.1533358446141249, 0.009009558627652726, 0.012034669157767632, 0.05519180737185101, 0.08569716970123636, 0.3493510563091932, 0.389714590708943, -0.12624373916196913, 0.0721478429100707, 0.15840126413476333, -0.32784811159413113, 0.1624305041152204, 0.3454524549309785, -0.23895189808474998, 0.1254266013195254, -0.280757305561512, 0.12341142505560711, 0.10002173652635064, -0.33090900411207586, -0.417701925271149, 0.5243847948011101, 0.17948816264576986, -0.25228593537839133, 0.06818611170799235, -0.028700735612920254, -0.10454525377871135, 0.1870166041766128, -0.19563526092208355, -0.3044399619655154, 0.12623027361441896, -0.08515847401691432, 0.3883790129049041, 0.2633112146000786, -0.10214720689768839, -0.2403783379312472, -0.013948146736132438, -0.04519340218567584, -0.1355969704495999, 0.20255261811805922, -0.18582853788643466, -0.16491874988180172, 0.2578317184800789, 0.03247443433490969, 0.0806288626145909, -0.07954090683082693, -0.3655049108788049, -0.10110055077380459, 0.37603610382073904, -0.4118713434865231, -0.46767461303675995, 0.25845503555642435, 0.11806677377246241, -0.13794158212216073, 0.22988691807341563, -0.08746695248731055, 0.09406617008353939, 0.19922500269120594, 0.37368933268661586, 0.5316803381831581, 0.5552242466503275},
    {0.1024875196550506, -0.4709989222093663, -0.03188979144325124, -0.13149258109046072, -0.19683016595609132, -0.4446681891525451, 0.30151912495733313, -0.25982290404881025, 0.14784636131079512, -0.4005753747118156, 0.08390051064616373, 0.021608868896647634, -0.46087461041505634, -0.38857178289617406, -0.07681991526450868, 0.5249252198986757, 0.2455242008053521, -0.019653699253576132, 0.06492300143424375, -0.9669370703725044, 0.3527070969590428, 0.12023900582583631, -0.3592114373388639, 0.19579963592786573, 0.1594619771768539, 0.43821841229938474, -0.25344126200002826, -0.10325784426060154, 0.012494969809267656, -0.0885162118602522, -0.12824027443154642, -0.5664157677104452, 0.3862923767682508, -0.4310240547970111, 0.1009993932403132, 0.08634833857108597, -0.3439944235031084, -0.23712236396913208, -0.3593929721189628, -0.40522042807612746, -0.24610266316264784, 0.13501183068284925, 0.46594272704484185, -0.24361242300267832, -0.09093721430093542, 0.15599990464463442, 0.053609630405033706, 0.29357110761130023, -0.15437346474857208, -0.17123340991006986, -0.10340620765907586, 0.12987522829830292, 0.2662990614303318, -0.24884525561763107, 0.07638844154535773, -0.1465487307837065, -0.13760997973108882, -0.15917974583602634, -0.16999330720171787, -0.24450256767318315, -0.0922138082732911, -0.16587138719258349, 0.7351803944277157, 0.5940098005431756},
    {-0.08611995924216728, -0.3450535465691718, -0.1922668663018932, -0.37716238310492295, -0.026776038552640408, 0.01330946690588272, 0.3079335593675707, 0.061389053212854865, -0.05118957457003934, -0.11413253034808142, 0.09320138451792864, 0.018732719781343044, -0.11058661527247722, -0.2759350528307976, 0.19594129377097147, -0.1517374656327505, -0.36648014527789013, 0.21838828729898604, -0.007036687432213159, -0.3139419225723099, 0.5551594658721847, 0.05655921149296968, 0.4338904414498766, 0.3711514422643987, -0.3759845317220347, 0.13268113225380626, 0.08824581106161655, -0.0742838687591368, -0.16613361053500375, 0.3922255006970657, -0.32482451420764674, 0.031425249877200995, 0.25179938689631826, 0.18383479408976616, -0.32818117250527007, 0.013379924769249683, -0.7281353029844764, -0.23618083427990388, 0.2840339660056761, 0.07429614692342416, 0.06277831174335438, 0.30117591765426227, 0.4198883168744668, -0.2947126100914351, -0.35684989088649954, -0.3906653281099432, -0.07765414231624335, 0.4348689058327104, 0.4031760356527514, -0.040373075315308114, 0.25529293529733266, -0.22629667176879997, 0.40061395763418467, -0.17029077847176693, -0.09726851098314944, 0.33613876432607603, 0.5859405188723105, 0.16218339339110444, -0.1901391122951421, 0.3384498659223828, 0.07205108197029979, -0.061113120233113064, 0.41132190210482544, -0.02505692240044636},
    {0.02568655571226384, 0.4595763790796043, -0.21015358230345224, 0.3111656778719332, 0.33060461209898845, 0.08385884474138165, -0.1390926088719463, 0.0499043695394177, 0.4018276611559147, -0.25638068365275146, 0.14575112694656525, 0.01228928001326685, -0.42086379094284293, -0.18262168188796482, -0.13245449108228047, -0.4917722503647881, -0.035076973497238276, 0.5040077751844165, -0.4146627940715651, 0.04289625358602485, -0.20976072372924756, 0.2247654746303329, -0.35672155869478034, 0.22691082188579523, -0.2731699862336053, 0.16150891153496397, -0.2991192008505716, -0.07461526353614852, -0.3562930683763256, 0.05007306345789127, -0.03662922089424975, 0.5242518992313091, -0.05495955275550342, 0.6887845174668247, -0.3220379429517057, -0.07869311042985667, -0.5741735265693334, 0.2510691612122754, -0.287212720522166, 0.43117385152147136, 0.24702753707686553, -0.4106210157414637, -0.39346055167925675, 0.15649948306827524, -0.15337029731168939, 0.024185368873383767, 0.045703401302524815, 0.05529227249978002, 0.16111046993191017, 0.1725525989343137, -0.25104743801342366, -0.26953592815496386, 0.20057691158658553, 0.3010695290685084, 0.5122084561972734, 0.456080224313062, -0.056048185537744474, 0.06740524501120133, -0.36423403482913, 0.10855226330447941, 0.06762873800091268, -0.07338733854554143, -0.42418583872212706, -0.44751647620306323},
    {0.2562521612689468, 0.3879412955005521, -0.15053426864665306, 0.02770686009760195, 0.24675268027495192, 0.5994872960036415, 0.01109226890184955, 0.10976413115618758, 0.004176085270767902, -0.14496674763599837, -0.21786316948249682, -0.30497890825738444, -0.1034236147472074, 0.3771586538493938, -0.05909777025074093, 0.07891107624594834, -0.2871384539159008, 0.18712248132965986, 0.01585937117585381, 0.2115362071060645, -0.05976224340954382, 0.33493393263338295, -0.510803147009259, -0.2448610743838695, -0.014791441747023515, 0.22465075777036936, -0.04466949983964567, 0.02804346436859678, -0.08295820702431772, -0.2631859720303165, 0.14616166102139608, -0.2481274620573171, 0.18055665928582615, 0.043012441276183276, -0.008653256438822428, -0.2559806132674736, 0.3360979694735233, 0.30527724204657897, -0.2763189420609317, 0.6235236638884059, -0.18474905836639524, -0.42891057082432016, -0.5136120181734262, -0.23158734033841719, -0.13289947800360816, 0.21003229146531402, 0.50606486775484, 0.2429335883903498, -0.21274770697971873, 0.18121119396096594, -0.13417400106818164, -0.354477691822169, -0.2493654425782771, -0.16285004607491485, 0.2206859858220703, -0.10883711268633403, -0.45858649081778974, -0.3413621601710269, -0.2627571838495808, 0.09758830449973578, 0.1974334052268926, -0.15333951882039767, -0.3707128591382713, -0.2523212166114449},
    {0.07415663331494345, 0.07740657747484628, -0.08417634779692697, -0.28405071838917456, -0.27926414749505263, 0.31691088013312396, 0.21356111873629144, 0.13885897040933826, -0.10561604862227397, 0.09653940137788315, 0.10696166531540026, -0.002148829472283511, -0.038625277228766165, 0.7306970105008375, 0.46398947178441535, 0.3245874699786031, -0.3389312161666766, -0.047997636612816336, -0.15972875657154334, 0.28880641019785563, -0.17126891709242395, -0.06427137328135689, 0.2981972288787514, -0.14792266747051214, -0.06699872499156263, 0.031456866005046796, -0.06282643659217003, -0.32912663589382113, 0.25025897988569334, 0.544340691622634, 0.0933071436240741, -0.14981215582505703, -0.32137392910106644, 0.008350316939313951, 0.24911586528702911, -0.2739023085004467, -0.0446832638864149, 0.13544981308941711, -0.41203439707452677, 0.22944546326272158, 0.1459350416618983, 0.07934979320749962, 0.32179082643109386, -0.13984921814079165, 0.5482513615884267, -0.4094550460208711, 0.27879008978746017, -0.4864081241507978, -0.19032188597991798, -0.14356944983654163, 0.31604221854376097, -0.4159547944638729, -0.3345642517853646, 0.44283773867354626, -0.129467464722416, -0.4005502680560823, -0.06333077859127796, -0.2224541931139924, 0.5056073744510287, -0.5292498941344222, -0.15594291105103017, 0.41207329738644133, -0.2786149170004669, -0.1970303240837058},
    {-0.3606472994865727, -0.4351371401765758, -0.40804859868504817, -0.22982009541516757, 0.33167213448070754, -0.031035392332486707, 0.08510083858118976, -0.1950014236639902, 0.27134999773253704, 0.17723492206850402, 0.08139445372090154, -0.040991433281685495, 0.20034082684160595, -0.18287111599166675, 0.32720766322196443, -0.059717604406910575, 0.10515606125097998, 0.3260478944260559, 0.13008181155356188, 0.13542373560890392, 0.5275984710258885, 0.42233005940655594, -0.0478437378796711, -0.27742701134788716, 0.011443112307202841, -0.04521206566406022, -0.062334286664536276, 0.3922991083523236, -0.1253764011481312, -0.04976468520771597, -0.06215874106155512, 0.19676180520035105, -0.4151313794989672, 0.13662143474183086, 0.26282199841016957, -0.16129487022984582, 0.07810999944403862, -0.2621383060842785, -0.4193966415328423, -0.32456223913778176, -0.19532338908375832, 0.1414081406287501, 0.49915472821558377, 0.32495706929594453, -0.14012262331777384, 0.07490121224691941, 0.26357742998419387, -0.08548777817432685, 0.24917072910836346, -0.04840038577759259, 0.3547209865178973, 0.05614758902816848, -0.2896876972708387, 0.3106270288975259, -0.39005037564516765, -0.33325650056876205, -0.10663488606206024, -0.1054830969799977, 0.3819607789944889, -0.41724754070995496, -0.4137941092459706, 0.05441068799219701, 0.3813632437932436, 0.26629420339578064},
    {0.07704792230333748, 0.0517378091957661, -0.3963355107693141, 0.2835025938832383, 0.2096920896629894, -0.13972227886283392, -0.043279445916172575, 0.23607935959685866, 0.1388046953706226, -0.19913237405379705, -0.048019365779606686, 0.31838376939304, 0.44396454750184033, 0.007091458865963732, 0.39536588946893, -0.0354683425073936, -0.2678986658883177, 0.13362309196832325, -0.05785142445872525, 0.4743962430297718, -0.26510622699108005, 0.09501372456542098, 0.46026515188094363, -0.38481615259213375, 0.3351013081253294, -0.033544184146340965, -0.5138131666354507, -0.3509382313780002, 0.06522535702201486, 0.11831848589871766, -0.38638106741345274, -0.17045811232225436, 0.08068430389953195, -0.12159229598102689, 0.054156121100374495, 0.07977305046598909, 0.18891215423731056, -0.2533074086862076, 0.1573723808828745, -0.1804322541899428, 0.365316448685535, 0.2671454608952602, 0.17213362057795523, 0.3571459119747982, 0.3180335196676885, -0.12083896560575552, -0.2058638299913952, 0.11651860339777322, 0.12255695540560724, -0.02651619376127847, 0.01419548733720026, -0.08464716495557312, 0.09978863861117425, 0.1604638006445502, 0.04341970472758126, 0.19695361269251013, -0.22414269539151793, 0.3382659301684866, 0.09691807443223265, 0.12033308385066838, -0.04474823516727097, -0.17289260887778532, -0.11323101536358328, -0.12919438717084808},
    {0.47309710478206424, 0.02914717424182321, -0.5956809249865962, -0.31304522038360616, 0.016501672350176314, -0.08151755667554214, -0.41749261407108534, -0.0450301380505118, -0.45408244857753016, 0.28260397074521226, 0.2510961060182231, 0.3038740874821366, 0.01795970137429798, 0.04772507450134921, -0.1359092743704025, 0.17372189411566138, -0.08239472414496266, 0.10296256214551502, 0.05323864387367683, -0.10560736934396234, -0.529660747076521, -0.06451520861153584, 0.8147128367567398, 0.2650883445048822, 0.05340165390089173, -0.3450029247502341, -0.34932645499091936, -0.13550039193448524, 0.057966304041847674, 0.017582281876825447, 0.07021432276489392, 0.40273179842446666, 0.10437464288567669, -0.32376591212259603, 0.2618767107961323, 0.3202708533083535, 0.028581190853509703, -0.05537038320855857, -0.29186912220021366, -0.4198070442807514, -0.2930575917508445, 0.25098165865002015, -0.3848419765975586, 0.23478502519258823, 0.10814572452621407, -0.337819963136989, -0.7104152725373502, 0.07535822533628342, 0.04644132973366678, -0.024882286913715565, 0.4520842969977362, 0.07669926093552783, 0.21359470729060823, 0.2850520940645247, -0.0028399404838896536, 0.06866929534153109, 0.2089874255461455, 0.2945180227108518, -0.09779476177306429, -0.3321607787605533, -0.0447277224468218, -0.013527740317145018, -0.013819369637623782, 0.08197358058588161},
    {0.3320515818851021, -0.027337374988773838, 0.25484688791451815, 0.397229335392725, -0.03779156135806975, 0.3882457169366318, -0.3887636493159167, 0.42025395428862605, 0.3230626816540547, 0.30674856814041207, 0.2835742714941284, 0.35371357111517926, 0.025859723436579572, -0.19161933233661912, 0.3299138268064744, 0.13385215614383073, -0.2344791623287299, 0.20119616349755945, -0.17254343009763085, -0.3855560053747304, 0.09335299146115074, 0.3816715345714615, 0.06772968169970472, -0.015759776667170846, 0.5901922805770168, -0.23836769068871314, 0.12169854812413872, 0.36049927072790344, 0.014974296829978941, 0.09282856915396534, 0.24199093214036282, 0.37821063343600614, -0.13002009254583777, 0.17749948322233491, -0.0852521940800066, -0.009200563893224743, -0.002422661652007863, 0.03153182967158983, 0.04673319791899555, 0.19166874539184403, -0.13577269444634832, -0.03554755329413499, -0.3135599687630445, 0.29775685193826334, -0.18570571678581552, -0.039699646843462943, -0.437067487881529, -0.08010212038472653, 0.009218502833893251, 0.1064109696496276, 0.2235703132441577, 0.09921438985720869, 0.015163308479786404, -0.23701540830154152, -0.14306851533140827, 0.08727845294436407, -0.020717470933981155, -0.16694705318420902, 0.0516590759923168, 0.1515985103846017, 0.190491685138209, 0.30360766249189625, 0.3727126694077357, -0.02113143164596409},
    {0.0815876680194201, 0.12441454630415494, 0.4183335586055014, 0.6990634157982204, -0.6328178256855692, 0.07466623081250137, 0.31506575186999064, 0.14020504746155543, 0.7384840273622657, 0.5913482296489293, -0.41951139292351114, 0.019391315514968057, 0.26970533351217474, 0.2609382381635114, 0.19562352172223132, 0.11450704511088634, 0.26079362324302235, -0.6398648545885335, -0.39305950956553753, 0.5312604469128284, -0.4039186596176346, -0.09072789763458544, 0.13680827721847263, 0.2809548283609895, 0.013024649938610288, 0.0868678534796254, -0.14117126882101186, 0.08785192099288384, -0.017527015964816577, 0.03275718815636085, -0.35036943740107873, -0.5032007633471896, -0.3722539971826325, 0.25799246027460576, -0.25195456113686227, -0.18189536775016502, 0.2870383715052887, 0.26298932261293806, -0.017462884545367124, 0.3575802313468716, -0.18166023032406303, -0.06852425262886816, -0.13547623606474643, 0.21160062580433353, 0.11959944187539186, -0.5810237192895826, 0.18686634771570892, 0.11929128717374425, -0.03535414020346499, 0.26329188182000485, -0.28779314745659135, 0.0190403131914156, -0.1516547834800189, -0.027890984332544094, -0.261188673556013, -0.2719706189603395, -0.2290461233301862, -0.051026188455651204, 0.06611810012668609, 0.6152415984336298, -0.2822452289365696, 0.4031620989196135, 0.024698082440564654, -0.3399872299116836},
    {-0.23788440945570977, -0.6255799589359015, 0.1830073549910293, 0.38577395766894407, -0.5220365809116444, -0.4027466076418841, -0.46065172140050065, 0.1781096268446663, 0.2562028450044085, -0.6803750117278682, -0.3306944940726016, 0.09449642428502014, -0.09115563539264845, 0.28555154424226736, -0.14112203180589294, 0.49456279674896164, 0.057132286104724074, -0.18735332113305422, -0.16514113872457473, -0.15420559917040025, 0.12850734225156776, -0.14172459919776417, 0.3234014828343184, -0.1516767418353634, -0.09215351876234619, 0.061133506551478985, -0.14274585218267288, 0.08233243858277817, -0.3077314627246938, 0.11297757037204434, -0.1760870999250572, -0.2201005689887135, -0.2066456164107353, -0.2929393581842888, -0.12140838404715149, -0.485819110375577, 0.09218266815810987, -0.11721588398024405, -0.0826066869933581, -0.08408741139539186, -0.32292353623208436, 0.06197037107132286, 0.009331508028455626, -0.21484422461099126, 0.023731220923474128, -0.06562119277735216, -0.1775858915387992, -0.1813535552238966, 0.43230360536145085, -0.06513876379156132, -0.6154843280592894, -0.1252529580766801, 0.0763121244907471, -0.06901205956000764, 0.005986402254736338, -0.07567781850985589, 0.07689833580941328, 0.2808184367029204, 0.22504391101215598, -0.1274194972675328, 0.20348600874056866, 0.1260586863424773, 0.12475069871606612, -0.26651997278789086},
    {-0.12651345216949147, -0.16182479466868144, -0.28602381279020045, -0.005450548038361317, -0.14611798706132287, -0.25614781883284515, -0.04540947220801359, -0.14622115685393286, 0.6015021857885375, -0.06081751886055146, -0.25027486437265506, 0.049520566312215734, -0.18274491245418945, -0.27103993346251704, -0.21029753619821645, 0.2934193292584018, 0.08637724887409215, 0.38671447608515636, 0.11048522843702119, -0.20588621849584915, -0.06598141079472747, -0.08055831017228954, 0.21999935779167157, -0.31710628987179973, -0.24495521830668815, -0.10013300061186982, -0.26936300838400146, -0.20918348439963977, 0.3151238833868959, -0.09881107359294829, -0.29657651002957824, 0.12705497190283208, -0.23611873457121157, -0.29714441428687804, -0.30338642776806335, 0.021174035688794047, 0.7199930319721094, 0.06535051096347046, 0.3593049499383521, -0.33387655203311456, -0.06420668254296137, -0.13386321428595324, 0.35999377702841967, -0.19536499193567022, 0.3490574829322448, 0.06272279095818027, -0.35632646361401504, -0.3014102342817839, 0.03671452865960241, 0.13913952877554786, 0.35874002760645124, -0.31678767032377264, 0.08472078258449213, 0.28729327803079063, 0.5202620494536316, -0.2568921901479065, 0.0308097668864712, 0.18478300664289787, -0.0040620827372929115, 0.27190859563150543, -0.37080416554619744, 0.374603859001451, 0.12971096318771672, -0.23033416969477832},
    {0.24404339798514593, -0.015673962840934887, -0.30257409570970983, -0.29034879600052654, -0.48459804787184696, 0.39104171641967295, -0.05391396568185941, -0.007337928667968789, -0.4446382755592999, -0.02734529358810865, 0.045979882712395954, 0.2572595184348056, 0.4692527260045128, -0.1678444775886768, -0.14466410932141582, 0.2786139949156699, 0.13251271035975326, 0.21726038065508407, 0.009466974038855025, 0.13277037229230432, 0.1741573499239081, -0.20264499559970178, 0.19455764630213607, -0.1421859777805668, -0.28630071391607453, -0.3641647009679888, -0.16310554022570897, -0.2676416158723744, 0.23627102098169114, 0.1303735688741781, 0.10069746045640532, -0.12558277704182835, 0.13461458597014206, 0.005669622934033964, -0.11399235339473329, 0.3014251135178409, -0.1064364373839914, 0.17884628158701946, -0.08406568758223319, -0.22959500013031883, 0.1904745140885582, -0.017592581403171346, -0.25437382841338607, -0.1503555117549065, -0.2705458145015603, -0.016446788399493897, 0.03761245246005395, -0.01685814780873847, 0.06652609461710335, -0.27706290074964474, -0.09086378765235938, -0.03058410444257566, -0.045248845184673744, -0.19061690380934876, 0.2818064187199226, 0.19065535879637063, -0.5567603480889479, -0.39376769791383365, 0.36354604277527, 0.14134134723350367, -0.15511257674755963, -0.025656320958742616, -0.11737724072566075, 0.3254266511724632},
    {-0.1499552443693562, -0.12495745205481716, -0.0355671887210527, -0.3201189873003555, 0.2138711814827391, 0.2673175628561595, -0.3895654807618757, 0.024660188570898352, 0.15598734725779645, 0.17217278447679607, -0.09148308665565315, 0.03888039336090463, -0.21918162422657472, -0.054087978033867105, 0.2804279338554173, 0.09791211479392765, -0.14872925030386663, -0.10027567378734158, 0.019165072472928642, -0.36179801099775466, 0.00012424298292406885, -0.12365762561471277, -0.08913919356808465, 0.2226593492827371, -0.5073069365779708, -0.07843519939299866, -0.07800018182178027, -0.26199492777524375, -0.26662211823497906, -0.03616055114152596, 0.20756719515635363, 0.09690546226734846, 0.24086408091960423, 0.15252983883016, -0.20062471110387306, -0.3881052915667554, -0.09441152777195634, -0.21167996361765234, -0.09717823995440562, -0.4838252536081572, 0.16852386631433208, 0.5002758644576049, -0.31648837930925167, 0.33608841308263, -0.05249913315787412, 0.039673522751969524, 0.2698042227992274, 0.17758428403893733, 0.23358454793431524, 0.17910479939563673, -0.35939802603989063, -0.09675356629090417, 0.04820475827417872, 0.2510614169882823, -0.2498590708802345, -0.16049150623178096, -0.37381348755407495, -0.16736513545450818, 0.16007913081161879, 0.25895583379449977, 0.10834398953371217, -0.2660740099588938, -0.39996331501216853, -0.34723028320800037},
    {0.4364146505037992, 0.44581224605547815, -0.5243799874187786, 0.16014137729898298, 0.0485099786028878, 0.007073681357187159, -0.4880623344615813, -0.1983707230011116, -0.11450850293446473, 0.17763641227984997, -0.056461782601722785, 0.392198813143485, -0.5409725700058954, 0.3474744986876954, -0.2807029153914981, 0.40042144583462297, -0.4703139390863499, -0.40393958310369554, -0.09000067298370204, -0.14563271001594358, -0.23118033132739343, 0.1624741785335015, -0.5899017968801368, 0.020277205223060986, -0.2583231512920253, -0.38323300180433767, -0.02821631061260603, -0.13902365942703784, 0.17067423813906757, 0.08944294179069479, 0.0008782130914558648, -0.010351368929642998, -0.1761083611944101, -0.23548834600758312, -0.682392884864372, 0.5374849992073242, -0.17740583947288396, 0.08253085309616572, -0.458677373172574, -0.1712109519719083, -0.01538992672094578, 0.04748625165099497, -0.5189282201086984, -0.11310330228697708, -0.08358793089654014, -0.37100231351738927, -0.08749100695792478, -0.09161374928292143, 0.11483018184485133, -0.29205643509988877, 0.14994030555537338, 0.2826493231789627, -0.19004689263767205, -0.46310336390241436, -0.4186417445839067, 0.25537686312881347, -0.1929576998928884, -0.4490878163361599, -0.4618292595202937, 0.25889796027662304, 0.04775961308040462, 0.12018441671129035, 0.5428839895005582, 0.40397744148541836},
    {0.023573885868982625, 0.26983604835946345, 0.027642294929357568, 0.26332272526269795, 0.6993156676300867, -0.025185510767326846, -0.02973952881617448, -0.37022212813427385, -0.31845375231866113, 0.14426487754098394, -0.1264793561638978, -0.4025418307586134, -0.09505440937607203, -0.4238646769201329, -0.14137354513116626, 0.302267686960267, -0.1936097680526839, 0.3624892952197411, 0.3161447988876271, -0.3890395784590016, 0.038620642715816854, -0.24850720620834282, -0.2546786131085502, 0.39179401179048223, -0.10268397065724023, -0.37152348040289385, 0.23367879644500408, -0.04059435602465114, -0.06889868276354837, -0.08289494010805741, 0.106637406601372, 0.3318721419306297, 0.1458064301540773, -0.05155881077720494, 0.38806808737451776, 0.4728893395255333, -0.10849651982083829, 0.1915170422957753, -0.0874948838295865, 0.1437993661970944, -0.1643382922712684, -0.10193600065369271, 0.0297994920002823, 0.053692918745960175, -0.13735660325791582, -0.24773706550403374, 0.12796736415826193, -0.1756260068131277, 0.1189311608208432, -0.030524070518918884, -0.13314271399966943, 0.06487612829237105, 0.02828678602191383, -0.26005472246690303, 0.5761792228086359, -0.14943278169439042, 0.04828604494902855, -0.19371505019718735, -0.544485562074602, 0.037196094355064546, 0.2215897360924082, -0.22762366878178775, 0.47121141004590794, 0.4796892053406319},
    {-0.08162781850365046, 0.20179986312281886, 0.5947665692381177, 0.2983613659632428, 0.08629226019554487, -0.2934547943554897, 0.00804344625703936, 0.5011425930615436, 0.020076030744082197, 0.317452955711407, -0.23391772242336753, -0.06294544501327352, 0.10153701596094844, -0.49441004359205226, -0.4806293001892532, -0.2360406139449493, 0.3782403705908905, -0.15593999925651275, -0.31788332740922975, -0.17991472649944315, -0.6038262995627037, -0.16969748528116183, -0.04470129451121566, 0.3972198013058303, -0.17892104581334595, 0.29922245207499276, 0.40467267400714074, 0.2617827913610198, 0.16057052535495633, -0.2753912365029232, -0.2386215313177558, -0.11475955932273167, -0.17249735261711874, -0.18167586944611192, 0.40926324532362085, 0.040233236399569335, 0.2277000508587565, -0.2026855448331845, 0.6112305565148054, -0.2392012911923287, -0.30667492250464595, 0.08408859696784585, 0.12281672882716098, -0.06335181080685959, -0.16975679798632143, 0.17542033492250264, 0.2992770895362181, 0.22276053082811548, -0.04195440675549872, -0.18925156179177516, -0.11286284293727443, 0.13100385280069476, -0.25802079459574195, -0.18719130880423468, 0.006609861608383642, -0.416055341894775, 0.2127111281245178, -0.21512872764497742, -0.1058740415035842, -0.013800543082245173, 0.20431644962688786, -0.05657348357916528, 0.7707413856649559, 0.014030870713424492},
    {-0.05225485295438222, -0.4173580346487342, -0.22121587628260622, -0.3127758013245808, 0.28527358184298396, -0.4432428320492693, -0.042177276357921165, 0.2969993211461962, 0.23480752035030128, -0.058093638685764115, 0.3836502909408095, 0.49928099754463207, 0.565182928813102, -0.01376998255246206, 0.14205339633060876, -0.34655544153668394, 0.2689369448885033, -0.3652316642288689, -0.011148415910145608, 0.14343146324453165, -0.23121719649568542, 0.06594976535121715, -0.2552626744893648, -0.1629410906200307, 0.32556363719718545, 0.17387563099460068, 0.13145608853657342, -0.02686216599196074, -0.15751688313117612, 0.12055837689252669, 0.3572434393498511, -0.3032973520020199, -0.18881819563824154, 0.46962630517816906, 0.2925417512782136, -0.03486550456595563, -0.03480507560011873, 0.31965355184435357, 0.2602700926768481, -0.22264882868590946, 0.2658594424710516, 0.09721815573774209, -0.1887355140001526, -0.23899083044780764, 0.132754754962621, 0.228681446113734, -0.272895907377235, 0.13645403741177958, -0.029001623877705742, -0.22820019564691707, 0.09652233631590285, 0.3629108074500613, 0.19771741470447948, -0.17051049814868494, 0.15779044588177943, 0.10032937282649973, 0.25845612876568397, -0.2513647385437381, 0.10349186970252433, -0.11777213792375468, 0.10079797546281977, -0.06811647933335738, -0.055574163159935616, -0.30447687538333956},
    {-0.2037336526944925, 0.19030003075243165, 0.03554922791421121, -0.22047448577909193, -0.16456609258804522, -0.27990997437082976, -0.004108979752925321, -0.19166678777453958, -0.046968019731721, -0.4304306825096857, -0.06395626043653131, 0.26167893708213885, -0.08634312742353172, -0.012006382450134042, 0.2843463845339959, -0.12436891616034924, 0.008138140204935118, -0.11583815005273312, 0.5115768969417592, 0.32798307409486116, -0.15186093246400606, -0.5609783013408577, 0.33412724959426165, -0.3589183516898327, -0.675693346656836, -0.12863831095234404, -0.046100081786530606, -0.26877499227536833, 0.28483309566184833, 0.6763223428884302, 0.27523566515390063, 0.06429309659833722, -0.320750527342336, -0.23714491385233694, -0.07731214186994113, 0.16385179287563817, 0.08733157713126861, 0.2892084272417796, -0.22795474307459135, 0.09879813067358197, 0.047874814352633015, -0.08320784576222096, -0.33528113426024037, -0.004315012632648113, 0.311730667384926, 0.41244651837935437, 0.046339170121422475, -0.3354416622718429, -0.13584616637547603, 0.06903228033162537, -0.2261806740189017, -0.0006676233012539205, -0.2564507644575915, -0.410225879431871, 0.12097887302830693, -0.3825230528081081, 0.1888744782930115, -0.19576822693170978, 0.03215079799221403, 0.013604290579113939, 0.1485880315706193, -0.6179752987599803, -0.60279183049615, -0.2130076262376859},
    {-0.5477667396059438, -0.2467892771948891, -0.05044822035251836, -0.19312093969439026, -0.0235857880927549, 0.19614755272877532, 0.011360252753793184, -0.2422287755518613, -0.27672247855562526, -0.14893081803643138, 0.02738143824145891, 0.1515611777123371, 0.24948275861572572, 0.24971168192605311, 0.5263308684876827, -0.041853954264303855, 0.16079376572927304, -0.08757848646469531, -0.5489540837248011, 0.5973840929187411, 0.15179138524606536, -0.0625386435696023, 0.22969747684667421, 0.32886982701875334, -0.3933564881735082, 0.19334803846497672, 0.04285651057303748, 0.3809634639319317, 0.47429238103248805, -0.01924142522448921, -0.26604125588559346, -0.05351199912959521, 0.19632525550167357, -0.614441195667924, 0.8131960228917908, -0.2518054540697733, -0.3645600351648008, 0.20757996957761055, -0.04998122486437221, 0.1265870422659858, -0.068411213982282, 0.23154332029935806, -0.21663150228386027, -0.009801598438992129, -0.3597614236739862, 0.2696353231000865, 0.2411404916477563, 0.16563784739967874, 0.36506464589556625, -0.2237814929020572, -0.09103357674368652, -0.37005638934143015, 0.0434060774735798, -0.08488757252335663, -0.1556951703730111, -0.42009989542677606, 0.2378268083656248, 0.40568418447582794, -0.0801580845765246, -0.17185102912625544, 0.27662586261387145, -0.4248868865431252, -0.07127245550929857, 0.1724907665123338},
    {0.42400229654540617, 0.6525193280589742, -0.6437654743796778, -0.5553035808997234, 0.20561589942018918, -0.7541459217167087, -0.24343168522562, -0.15465036882599245, 0.2610655985680157, -0.2981893735755217, -0.7311918637930364, -0.03760249222921517, -0.4905660843984189, 0.44981072456538285, -0.18258879562192046, 0.4751644935294908, -0.4335936237474096, -0.43937827143809743, -0.6979137047512478, -0.0032024952491817517, -0.20157613823266196, -0.08468071672307154, -0.5010457906376083, 0.32308767387448606, -0.03611235128651504, -0.6285667090137054, 0.4623890788815322, 0.27339693065374293, 0.004585627931022557, -0.2800700876521362, -0.6330519519090183, -0.06945016558663354, -0.28806130002835745, -0.3563396540879713, -0.5316513816740785, 0.5849659902175678, -0.11032461999133888, 0.3908978570756028, 0.3723280957886351, -0.39395230607519105, -0.7835750811557566, -0.3761003941455779, -0.7126833933533852, 0.037664727961634746, -0.08981150152515076, -0.3208491556017951, 0.18860584381846995, 0.3734981825019389, -0.42910419674784006, -0.31460054502845014, -0.3240323810174978, -0.5607419560098292, -0.590685866645668, -0.4494671304363794, 0.22156287613817846, -0.5595556663766976, 0.4769456920608528, -0.6357125684452386, -0.30615937820318995, -0.8076859317128343, 0.38418948475476467, 0.02911448094737246, 0.21553318899651272, 0.01699306420957526},
    {0.6349563977821342, 0.5449135453002946, -0.2574078430083255, -0.12144469367605297, -0.03837735719599731, -0.7799781504287896, -0.24082321603096032, -0.5515745845846219, 0.39254816642417356, -0.2685081271777013, -0.8324983239256423, 0.11896420954182045, -0.7505643220584197, 0.44153941060781765, -0.21138775016641403, 0.6323427326508602, 0.0795705319448327, 0.31301783243383097, -0.7374304802787602, -0.0358254481618588, -0.5729671298934164, -0.4997034128591048, -0.35326026094084595, 0.5645974591292304, -0.25619192770842913, -0.13826990989777865, 0.6643216117412225, 0.347905915367403, 0.37631993354847676, -0.2101822205795375, -0.6527520293230262, -0.3293023835862309, 0.37440533183731556, -0.40984662219446966, -0.1568207740672812, 0.2115731480675034, 0.37150843179321397, 0.7085916912688011, 0.3663724544846968, -0.7267600365920523, -0.8567500386821125, -0.6107834249190756, -0.4299375831659883, 0.18795327793392932, 0.26808527074979266, -0.3593276501934179, 0.14312848256342622, 0.31113554988491915, -0.6133844158292463, -0.7296383035662679, 0.15865226031470708, -0.7497793572203184, -0.7227481853732459, -0.9474496509375597, 0.13599025089584676, 0.15166334952710142, 0.5746855097292864, -0.6566075326158073, -0.1876110442745187, -0.8340972271807255, 0.9269737102629446, -0.25554176485038094, -0.28213647177254486, 0.25179200339416113},
    {0.3256098762959394, -0.009467790571779464, -0.4968035030079222, -0.32420786106130645, -0.033683578576322905, 0.05039561871108421, -0.23435911639852597, -0.43610381001149845, -0.04907458244643965, -0.5710193324604201, -0.5006848563658756, 0.44696491546746037, -0.47055722428535784, 0.3991902555283992, 0.34519733964615074, 0.6078105880877689, 0.17649232642412654, -0.06780576365463689, -0.7845430633206328, 0.0849098945558916, -0.3210509962886285, -0.24165055348246914, -0.42474390230837095, -0.24924554296003157, -0.127947191853903, -0.3718256301916794, 0.3504067083997805, 0.01284731703037878, -0.3912884672966553, -0.2026678802402673, -0.49329387709029165, -0.4143341519374762, 0.07150095287302394, -0.281939193054189, -0.39708573130326247, 0.29774797959862215, 0.1907591977792659, 0.29183890156333053, 0.2150947581516475, -0.6488063913769966, -0.25421520872597053, -0.09555958681634186, -0.706955923751865, 0.008913725083826539, -0.5125247964673155, 0.004748451080500917, 0.5058393566655196, 0.24125413372248047, -0.5281230581172772, -0.18134915127330498, -0.3171835079621304, -0.27203856111305424, -0.42118761528782217, -0.4871534730209661, 0.5357063913708888, -0.2732279620272398, 0.15547801461943794, -0.1819885800316284, 0.20989345180216948, -0.30537972895199444, 0.22407032490329407, 0.23971787676341227, -0.059715957206829054, 0.4443445257805057},
    {0.44295526506263205, 0.6038965394155082, -0.42808137643595695, -0.47090640951618085, 0.6057456462321185, 0.26906175722498343, -0.06270530508900458, -0.7018736384283721, 0.7613895853936594, -0.1728807353712756, -0.22799996400830974, 0.28790132721771833, -0.4371522190282734, 0.5602975143401331, 0.10805154724778428, 0.17229605552122443, -0.41541957545001934, 0.25559668721465434, 0.06697726437113803, -0.32986814096491673, -0.20640286271861347, -0.17060030491894573, -0.45939252962516824, -0.2625547061565929, 0.5070605021403457, -0.3083477330667464, 0.06891491548980455, 0.0589262160204794, -0.6439773542197332, 0.20744998736830492, -0.18627923943357103, -0.03302663127640051, -0.32260646690143696, -0.487899806002211, -0.24205994754152174, -0.3882442196129185, -0.2638980055124536, 0.4474388261681449, 0.16338571442541164, -0.34554309676338446, -0.7077371343378406, 0.1571621322812931, -0.3557404662589908, -0.14594801600213214, -0.5452282155160713, -0.058500111883310855, 0.5664851846260732, 0.4482093116495609, -0.7901468440580092, -0.04143593504243407, -0.553023395826359, -0.33090939179741174, -0.336192815055827, -0.28147448545137227, 0.08368804326240566, -0.4173221912832515, 0.01656792951727327, -0.5941151663081055, -0.3513869096458944, -0.33560219584696366, -0.17233690599537838, 0.13564057780652006, 0.37492875037264345, 0.208179677375209},
    {0.1879281642610717, 0.5730664357821055, -0.45807006328744304, 0.1236960873944865, 0.6199521189420498, -0.15388939491294784, -0.5955491158778203, 0.31320264903090544, 0.39918870705671455, -0.12886652119963363, -0.24500690604912026, 0.11443182262189769, -0.19507654833015514, 0.5488864680569724, -0.03910937400252958, 0.3508514114082427, 0.30794482176243765, 0.22708709417938913, 0.38949810873527546, -0.40249905945304265, 0.07298295445869844, -0.14007502812562672, -0.6114226445594866, -0.1254903626058912, 0.1329328031651123, -0.17497086620301153, 0.2215663071903617, 0.3699166962843009, -0.4961391061534571, -0.12390626892297181, 0.09351048988654899, 0.5043352237603789, 0.12000074979778944, -0.27671636534486954, -0.4930538181865731, 0.244429475966441, -0.16660593199847093, 0.3958731218774404, 0.6522265237167506, -0.058673469260449154, -0.645847356346022, 0.07438376487827554, -0.4739224874201084, -0.051458602272988235, 0.02369459475331857, -0.8019697550868653, 0.37273129800956323, 0.45121772172020996, -0.08112959801406641, 0.12785412758565143, -0.07779025783704108, -0.5183511371635816, 0.502452060296141, -0.2402894920550241, 0.28083982694224535, 0.3328643104062932, 0.3181702093281846, -0.6295754854335635, -0.1859053796669658, -0.5736415523731958, 0.35766168839901435, 0.033920423244549094, 0.40103301840768996, 0.3144984792546381},
    {0.27738244372055837, 0.4629600491752672, 0.008666513490976495, -0.3572635876620956, 0.22357729628068337, -0.050683696235439585, 0.4013754847444012, 0.20676275245176395, -0.13474773261378348, -0.28255791839053856, -0.554513317317787, -0.3278748684097128, -0.020581947877355566, -0.1944785469750252, 0.04590236660800461, 0.39535888326227947, -0.24488642056677606, 0.21763357746028125, -0.4143377095122487, -0.15430674822120863, -0.024559539364231706, -0.18241401755628214, -0.32010761565658824, 0.507778954154074, -0.612408112110883, -0.041797977336864967, 0.4767384400391928, 0.49748054330285263, -0.43991704064194037, 0.050557437962076256, 0.34540018457400756, 0.417173093026164, -0.15535824329045875, 0.04800549097393506, -0.12079653307700684, 0.3891839603134541, -0.612639228860679, 0.3127909270788709, -0.38547069974954257, -0.9697811302502857, -0.272806184243495, 0.1275492538720388, 0.2115841849217709, -0.5469967270328057, -0.004210141383277466, -0.34613590730613036, 0.4875281013635073, 0.47673810557178564, -0.3432429203860744, -0.5048462861391103, -0.8051645251173566, -0.18530791753545442, -0.3086316768702291, -0.4736180716362867, -0.15567907023271577, -0.4199703932435529, -0.3197555770823716, -0.2941832688277824, -0.3842096517843273, -0.5361650738995059, 0.8145909191217595, 0.40461764874351575, 0.07629751627916072, 0.4477734544043807},
    {0.055913168653351566, 0.5041588321352813, -0.6802433400682316, 0.10677994234640231, 0.11047068663969187, -0.2817725371848425, 0.3053389083071803, -0.37459716449928654, -0.2132502031401217, 0.07232569118321713, -0.3193530896825913, -0.1421550373555458, 0.13132700654490967, -0.15597416778885706, 0.1807171817230953, 0.1853276433794466, -0.21117905679652446, -0.5830510860075105, -0.2898086398089063, 0.4957246956416605, -0.18482929340400772, -0.05715230315864194, -0.5966025475026561, -0.3771457109589894, -0.1027003426667161, -0.6796292040704919, 0.40679920474982917, -0.2953562683502764, 0.09860949438338534, 0.14170336913405845, -0.12589926200629958, 0.20464901119311885, 0.07552890708706365, 0.010045656047388964, 0.5276249808598599, 0.42079762995235265, -0.1285242664036234, 0.20916805739194397, 0.07976661153692131, 0.11461707716665559, -0.5137561439462536, -0.45736178438600755, -0.501238509963368, 0.18707157938944183, 0.03041030633314572, -0.21145178983693802, 0.32069257243541965, 0.43362174290371985, -0.02774212650592787, -0.1001146969057013, -0.3610759998701129, -0.47275008689079356, -0.39511658948904665, -0.6971384436327209, -0.35338824539478036, -0.5744374161054621, -0.32790990228657363, -0.42663265015554935, -0.2515247267275135, -0.40557142331888796, 0.05103389924158016, -0.5976356489283989, 0.17613175661740846, 0.3020823978452564},
    {0.08096086209446869, 0.4688918989664343, -0.2993111485737681, 0.1638448315306047, -0.457179534294514, -0.13868406546234488, 0.34023974046132743, -0.22925447292239914, 0.2076254281029742, -0.6087789594615063, -0.4702601015890865, -0.2777368317826787, -0.09513266189084814, 0.017325850187599183, 0.25993174452211887, -0.1789977307674363, -0.05683499727871816, -0.12201831699272295, -0.49663990440208455, -0.01601705289580953, -0.45951374716910137, -0.07701888854402841, -0.04821163423702972, -0.3542092500908993, -0.32685357391169567, -0.22316219292578837, 0.10260306283374143, 0.021905845865847425, 0.02540938989498846, 0.027020628853620783, -0.052427875789150556, 0.3602000179032192, -0.01941642996711435, -0.33841124809066403, -0.21298188059039955, 0.44870816098821686, 0.49547010546272385, 0.2505536099032141, 0.14806564251462714, -0.32468463798640496, -0.18229565225479494, -0.774500976968578, -0.2979846294331306, 0.24863183049551152, 0.36752204898146706, -0.057245381353655984, -0.14577892976629497, 0.6379725338498863, -0.5117410292054566, -0.4433030463290374, -0.16514721665682275, -0.38111139929333954, -0.23825901188494447, -0.4530742235379742, 0.1109151113376645, -0.7544396100780824, -0.20455932820603562, 0.20290150844674112, -0.39943129295655705, -0.5111929358738408, 0.02648529297975472, -0.28716192993255596, -0.29161796686364816, 0.31765127183333974},
    {0.44904095156651735, 0.1465962714826088, -0.21709296235560774, -0.32992589141443857, 0.17387464496135174, -0.04528662009327908, -0.2825704587392752, -0.8110074783954238, -0.08626785223939289, -0.34530802560937723, -0.6115213170173024, 0.13455227599429806, -0.6857780798405814, 0.3116035920867785, 0.06163376698601993, 0.3546183634498736, 0.07463194411226548, 0.10130045573780024, -0.6290783708485773, -0.21772301388155763, -0.7822340596925598, 0.12622491538681263, -0.5742283590966395, 0.510076136806259, -0.0525875693503571, -0.6455437468129518, 0.25450044755837287, 0.13839483900548688, -0.2946452342016396, -0.23977079690022945, -0.16609829954607888, 0.3321769526724688, 0.13906858309545214, -0.43588426798547636, -0.27133032935294954, 0.632293061059859, 0.45352539918901036, 0.14250411173560484, 0.09354914907094718, -0.23863672416325982, -0.08062431332384015, -0.5661025891340524, -0.4501437256930387, 0.5205236313330633, -0.07513519260311127, -0.3445939623499536, 0.08588088540177091, 0.19219805654663527, -0.5848014412599719, -0.46972701553889873, -0.33509818905077066, -0.6447830751950809, -0.2828844218122932, -0.6073412340536304, 0.08523572912181508, -0.3409894136635004, 0.7520117266147154, -0.375425354787324, -0.47631668543875694, -0.5748370879695961, -0.009214094781789146, -0.40510276496339603, 0.20957351668249524, 0.3856324939860323},
    {0.23344136210309419, 0.09294969888183197, -0.00476110643286679, -0.0044921309543380795, -0.3365067647087853, 0.08686145089335791, 0.3800678329485154, -0.3838749498214395, 0.44504901333313657, -0.13441812078867296, -0.3495589005219695, -0.08590806313170296, 0.10747557269033779, 0.06625512805338676, -0.16947707819431218, 0.25197977945142586, 0.15118674283963937, -0.07407265395972898, 0.04461410832007657, -0.2714711078512105, -0.057919657623539005, 0.277592302666223, -0.24176605469239085, 0.06825290497654596, -0.6311008672983633, 0.009154167010771265, 0.3080973313844009, -0.25529215329383126, -0.6439054730639158, -0.501520396398187, 0.1205120478732659, 0.112334274604457, 0.2346139820289765, -0.001689033144593269, -0.12674162967482086, 0.0472979374786272, 0.17106117867679013, -0.014115395330864275, -0.5314210387271592, 0.17641350713537804, -0.28423507708340984, -0.04181185161918914, 0.04133960685120654, -0.17001887578210043, -0.30891730552238755, -0.3963648142366574, -0.46729688805358705, -0.07490992792061003, -0.393310948142923, -0.3069921369471626, 0.07204596383167715, -0.3529437203514834, -0.23119210347604746, -0.12051312157942658, 0.46452187649837706, -0.6591203843539035, -0.23709322481638154, -0.4102463013495496, 0.3207566114770521, -0.0008938779927804789, -0.14726443975291947, -0.5426200761777507, -0.08828621744138554, 0.05118986057796395},
    {0.18167516103181694, 0.3100276220915422, 0.22456847306332287, -0.43125470527745563, -0.03565559744347583, 0.39979542674774315, 0.37817267191491327, -0.23066478535411933, -0.09925124008491731, -0.08514566554514964, -0.04853325185573451, -0.11662103573274944, -0.052390414565228895, 0.3994499123826002, -0.2826305307386602, 0.35065146906978295, -0.1857136325935652, 0.04777112150170021, -0.5605126819799812, -0.23625216866815044, -0.4878139997245385, 0.41286942973827545, 0.14666170346052104, 0.4397216664003864, -0.42251641511161714, -0.40166285236026905, 0.3929719705854009, -0.226350096877821, -0.28319150751962896, -0.14685852492404108, -0.06880656936155931, -0.09974814547985122, 0.37108818691167283, -0.016556192504118463, -0.6982077774011356, 0.384190630586572, 0.2392453536938102, 0.552320814170081, 0.4241753051776989, -0.3761751487319772, 0.03538442282796347, -0.11002779724771646, 0.31971829429752024, -0.13619805556512785, 0.8043985196849877, -0.30536546826079897, 0.14018558854859084, 0.3273122399753881, -0.3100100399088184, -0.11813551764166266, 0.14017102404445925, -0.40809396136431836, -0.6199059462587226, 0.44082091719298694, -0.31403601049255375, -0.19532988215726982, 0.07245721037117157, -0.579303841257155, 0.3272098410264232, 0.16165058611017868, 0.19067294554900627, -0.14593813585027599, 0.04765011179102456, 0.36928108764058737},
    {0.09699375206405794, 0.07780131534183818, -0.15346689054754162, 0.41480561155199386, 0.33254939862873384, 0.23156319814562462, 0.36321152636640125, 0.06997051715641504, 0.5065157836315358, -0.7355573921235732, -0.024353695291332945, 0.06357047346392182, -0.01715604816696367, -0.2429699882634228, -0.0064488300320570974, 0.25014796422069924, 0.1445677139607411, 0.5188541153701862, -0.07379061604006887, -0.08861451183113427, -0.013910322826895983, -0.04985622009210878, 0.013261105817161238, 0.6143964402507401, -0.007869609486948936, 0.303357495115543, 0.42358953898044455, 0.37152939435344357, 0.12168101314023151, -0.4696486712066623, -0.3153320864082759, 0.013089477518595825, 0.14994079627037382, 0.16870647067107136, 0.1402886888220231, -0.32910013483727135, 0.12413404499602974, -0.11188550790990284, 0.4818301629620295, -0.2120203586235386, -0.11772023830576175, 0.31412184679097577, 0.2763526833434095, 0.091807251272737, 0.18604780554412229, -0.2531298916103452, -0.06049922343097872, 0.3331440675188302, 0.2569093038382567, 0.3807450806392272, -0.34047488448096225, -0.16282866550960845, -0.17549189412629718, -0.01582413739462116, 0.5430086608297725, -0.15551993597776187, -0.4551647541379578, -0.03388392705649406, -0.52359850090404, -0.13031634896426617, 0.09845412684835486, 0.02154363008371373, 0.2182131112019262, 0.11247380100326508},
    {0.016595378535191024, -0.030335096488069528, -0.3187412979166516, 0.201226050557306, -0.270742454653323, -0.1696584750304661, 0.4540903291336627, -0.017819335884241828, 0.6695661589988464, -0.3484129696134109, -0.1460274116859521, 0.5017418139491712, 0.031763746120574886, -0.0035950618872230876, 0.20559882698470244, 0.4121781190012442, 0.6051483541350102, -0.6438554746631889, -0.26743959615100016, 0.03734105357190545, 0.4181069654594065, 0.019549970341897913, 0.1474907381931071, 0.04379780214157056, -0.5978653420772477, -0.4545557210094966, 0.45224750853116535, -0.23794321822094838, 0.010893057562101143, -0.11682538798076231, -0.05246425227662071, -0.059439714636090275, -0.3165734489437189, -0.4317100946741641, -0.6051548079012982, 0.08301504165287857, 0.2668028870229315, 0.37482396826138104, -0.247520291255956, -0.4677727353271812, 0.1074122676668108, -0.45386446774023603, 0.5249608550951285, -0.5618680881910532, 0.46505008058197556, 0.10130565247892503, -0.47762089165322935, 0.2735448616716126, -0.13619009694627343, -0.22479864446892434, 0.12999930946607682, -0.29015866592265854, -0.6051320287745611, -0.2012269143826047, -0.3908270771386029, -0.6890954462979259, 0.0976496614509224, -0.24322197275063995, 0.24789062817379526, -0.08807845228934684, -0.2986891031249732, 0.004604198637442474, -0.044693919008767916, -0.10593042510227085},
    {0.31800537673718166, 0.4520530373623638, -0.2599389573047707, -0.01381957722509879, 0.002004171421006444, -0.36641075011800367, -0.20271583681404393, -0.5167869352585954, 0.2365684192800811, 0.24472178809292594, -0.2200200616416464, -0.08933759575582431, -0.05444019480984154, -0.30389082669924844, 0.3548261949385553, -0.23479710483402827, 0.42400087254738533, -0.030054872780487615, -0.0234987802456393, -0.41715791052339374, 0.3143402483956795, -0.18929793071385032, -0.6650114056178906, -0.05953462444686928, 0.585629622234062, -0.3867490698493692, -0.6001489034072769, -0.03231881623681411, -0.26740610138939286, 0.04031740529333929, -0.6119874528255872, -0.5040091078945627, -0.017935805426530265, 0.2306359339299402, 0.004147943877776069, -0.3638485273763772, 0.0160033281236929, 0.21678886535060224, 0.17799931391233947, -0.19258727617137336, 0.08817978615995307, -0.012699538660235002, -0.4923076903414227, -0.52229856297304, -0.5778003280100363, 0.16049274926349757, 0.23465693261379686, -0.47421718059876306, 0.029684197619564215, -0.7331388136727811, 0.3368309508307945, -0.7636427282584061, -0.23733539979564627, -0.5099907833104373, -0.5605268522596664, -0.4922920895091532, 0.0208301250111796, -0.30983719142286537, 0.25153150062628093, 0.3322473482254594, -0.2653457336169777, -0.5480323972328209, -0.8171276118975143, 0.37979745613881793},
    {-0.07988966780384439, -0.023588705469732827, -0.08097111134819264, -0.28048521913124386, -0.24982502770391932, -0.1647166686029389, 0.18639693437503302, 0.18793309537170022, 0.331698569797898, -0.20985313112243426, -0.5228794345049973, -0.17798095314320758, -0.06583931160412215, -0.41573992331520104, -0.032867598821404095, 0.21778171984229697, 0.35228414852079076, 0.36393733163856573, -0.2712374599998937, -0.0005511202062046751, -0.2529413913704117, 0.41222482734135674, -0.4187302763232135, 0.2636578741497561, 0.07286992380132855, -0.07001998718293603, 0.2782255689734773, -0.6586529784811457, -0.25266671331972307, -0.31011325925440675, 0.3409275527313164, 0.3002038667145885, -0.05181845156154873, -0.0251675166013803, 0.04735470109269558, -0.14560297910404402, 0.32103728474359583, 0.40573127760453476, -0.02580661181473709, -0.6551427222851279, -0.2962478255863079, 0.2838376179695083, -0.5950294426895173, -0.04963106931973458, -0.005248614003989083, 0.07050424545876731, -0.0037085604889164916, 0.05472416935778219, 0.1307145272997527, -0.07189320941772828, 0.023197075978635257, 0.017675283257551227, -0.13166666514740963, 0.4171733222744473, 0.18892673526556494, -0.21064093861621921, -0.37141063713101347, 0.10877592713726011, -0.17431784477190027, -0.21761771207672356, -0.23428138694715847, 0.5923472024116064, -0.1128795767384907, -0.2627328755508348},
    {-0.32350554540762466, 0.006127776102086995, -0.16898509715241017, 0.44198528812104104, -0.19389836999437193, -0.19198272252588816, 0.30552134364705913, -0.13367050941805547, -0.012705613094684856, -0.3522711596989434, -0.7484248805603467, 0.08524576559003091, 0.11209056759392196, 0.255111137307614, -0.017852332650151063, 0.3996775868452974, 0.29614107864911304, -0.2608336483088323, -0.5014302840530078, -0.5473013398137256, -0.04458887645326075, 0.30651858661420317, -0.2249132125142489, -0.016223157328935558, 0.12890386152054184, -0.275343193541846, 0.2793684975969356, -0.04424869027746347, -0.17527745079234897, -0.07050263813750071, -0.26499388234964977, 0.08103230433262831, 0.4947924730485387, 0.5429713866391219, 0.011103314843306272, 0.3713912267991474, 0.3013290116984425, -0.15463280692832276, 0.16729527802847624, -0.1648520805235429, -0.17940702288185473, -0.3692444366581596, 0.017394888566128013, 0.35206322851594174, -0.1584560947913806, 0.8009060915994802, 0.17188109796808226, 0.10325581897993119, -0.2861520707603523, -0.5557893867355119, -0.022167140803342027, -0.2464429131922106, -0.3178716041347102, -0.3636156734851117, -0.315326360115359, -0.0613739698794686, -0.18655763813294382, -0.3335414992365398, -0.6649811980941528, -0.3198841333914944, -0.022790899680749724, 0.10308289558972636, -0.33091958888929035, 0.037426280593431206},
    {0.33800141110267834, -0.0949942505157219, 0.2519987758233123, 0.3359969352472225, -0.18169287807849774, -0.3959298874554451, -0.22955086499481364, -0.10992572329132835, 0.04676012217746749, -0.38884608312827196, -0.16281092794293706, -0.3348329000732546, -0.501045047460316, 0.5490013765536722, 0.09930451805185375, 0.0367958559224049, -0.06931682344987439, 0.49622797985240524, -0.008318402602117771, -0.3217391881911711, -0.2901988327907534, -0.4703718901133247, -0.24362083272419555, -0.022192351889634882, 0.044410158581270426, -0.07853360121024489, -0.21523140873476285, -0.6417910171862263, 0.010221035697475449, -0.30789514543108265, 0.35918405864449127, 0.39225266971732575, -0.006724109204300999, 0.432487037190779, -0.05977460823389753, -0.10779952153240602, -0.016545652241899696, 0.19384169977488785, -0.2780605689022424, 0.4470571054289799, -0.3310927686717809, -0.26134139921304084, -0.32212354907906826, 0.41091753314297974, 0.12299777027097747, -0.2377051831601799, 0.20361140701246602, -0.14266050751430576, -0.41545480495352344, -0.7546225588380654, -0.03153658175793203, -0.022298804270589348, -0.31077987817502617, 0.020617626637659852, 0.656054728734977, -0.08451048180059045, 0.5072760938937664, -0.6926177097553154, 0.005420942570346625, 0.06563006417012134, 0.0957450145398436, -0.04678977458162848, 0.23197163652521513, -0.003340618709726322},
    {-0.2577310195018557, -0.15559697954457055, -0.3154736050663086, 0.19020006905778625, -0.11954901327656098, -0.14248448032187044, -0.6544160277569777, -0.38548347536830774, 0.19532882918728095, 0.616834688666335, -0.04459684307660938, 0.03213123362858007, -0.32354042780064607, -0.4418549210259768, 0.04983940184159256, -0.1579415355650641, 0.05095627787897781, 0.08573428819169464, -0.19617105114570937, -0.16332305953410717, -0.5920089518365176, -0.2368385464933711, -0.08765433444890156, 0.5023321102056428, -0.5083961704772363, -0.34923805814949055, 0.3832385510669144, -0.034653915125943846, -0.017751922291893284, -0.46001270923672455, 0.31915768586202725, -0.09084124692466525, -0.09879536953687994, -0.11560496681271391, -0.020350030256624588, -0.030493512780773432, 0.6535998526786482, 0.7186523273201242, -0.09146883688715904, 0.20340470527166707, -0.019475954796977057, -0.2704407389248098, -0.17151681131353835, 0.4158071434580137, -0.4357577910442369, -0.029806984943645448, 0.1289129026784428, -0.04877935155511913, -0.49680238501941426, 0.14863469883513236, -0.13806348191832477, -0.29757584402062537, -0.3802546943170371, -0.023476087251800018, -0.5990422531364055, 0.1011533982238832, 0.01712417934476755, -0.002149886854149636, 0.08603298755353302, 0.402560882857624, 0.5587024812000747, -0.11262365618430369, 0.3901666160150812, -0.05888551431652188},
    {-0.48435026590991465, 0.39680386648737687, -0.296215299360869, 0.00658103214943497, -0.15231713823197532, 0.10137324557180298, -0.3211808429956933, -0.20863909218692508, -0.21858514458080436, -0.08466076608684282, -0.32910190314113175, 0.11104653203733694, -0.2069078917951211, 0.2796470589978417, 0.3288725798355785, -0.23641769802317927, -0.03758763147225806, 0.33337885941895706, 0.059859575030570676, -0.4325635149952394, 0.006982598733102767, 0.031113921421393086, 0.08274310398359142, 0.20229935700679816, -0.7520210629175377, 0.3568448281641235, -0.04201117080702592, 0.1517768849423827, 0.0455930885283667, -0.06405945708342747, 0.038511441942940386, 0.1271119903275192, 0.292163676024354, 0.14293790390988692, -0.5160200946764545, 0.11296546042282779, -0.20436529934697606, 0.5137320103751865, -0.5250985517246847, -0.5915342580082341, -0.4059016292105493, 0.4185936408267714, -0.105257966865529, -0.02484081054154394, -0.21157628544333662, 0.4378926763040819, 0.2888339262499727, -0.3051618323724525, 0.4567880253908337, -0.19047960915217013, -0.2914051627796354, -0.03634579880549295, 0.184142378156843, -0.7100824607852907, 0.2582962109601412, -0.2464656055930424, 0.21227312770558412, -0.016288363509825123, -0.1124256971050973, -0.26590645511467315, -0.1080288519852237, -0.17907895642611027, 0.26072367176975936, -0.3456460285988781},
    {0.1529092305771899, -0.4532779367445587, -0.21049375341430873, -0.5639188815557599, -0.29925172854596827, 0.5354992287796213, -0.21391536330874394, -0.604732808780279, 0.6574725016629078, 0.36686091048626923, -0.0637344887526414, 0.2751032639623101, -0.015772856507007833, -0.14539573455335317, 0.21016097548132978, 0.5600640450656575, 0.31850561935126936, -0.08624925268156886, 0.5492960430380853, -0.3825107290051603, 0.20670497250139105, 0.04126417486276775, 0.19688553661369318, 0.4489251440207728, -0.3104579912366035, 0.17709294340905676, 0.7308253056281996, -0.21105612234470503, -0.40619726414185536, -0.3515234583934121, 0.0746646696556745, -0.009639417372441091, 0.4023960396952056, -0.25885428877282357, 0.3692806436551476, 0.31467905945952984, -0.22695474329278456, 0.1400149238037677, -0.27396291672724377, -0.32937264622679047, -0.18557545510444898, 0.21894816531549716, -0.04679936484086718, -0.3283857648067455, 0.3489487871010367, -0.3518153445834209, 0.495289716312571, 0.04864879690949524, 0.24358138026178666, -0.26235124870179916, 0.6043131082481863, -0.19080335107979582, -0.09042656846312608, -0.2128758173720036, -0.39445557977542833, -0.24238044890529362, 0.18162629669943564, -0.033759021388121264, -0.5466255621686202, -0.606184107543201, 0.7204657339081024, -0.0908121444208576, 0.3925714567022602, -0.26913474064061754},
    {0.6242121898126584, -0.08151324463719421, 0.43263155667341663, -0.18685400707883323, 0.35619941961461304, 0.4170541850729942, 0.29778586676291974, -0.7238990305426937, 0.09127948377353405, -0.08920081763889703, -0.17710670262197675, 0.5358340361300338, 0.19860970762631971, -0.49196037784558977, -0.02375059157909726, 0.605920405425129, 0.22299218563096418, 0.11593479977776244, 0.1663213507718947, -0.08805922266384121, -0.5043557471806741, -0.013303912780273807, -0.6248103051970101, -0.1579760291878584, 0.47841249079161846, 0.22601536168848638, 0.8389710416132051, -0.03528368881084327, -0.46908167834109277, 0.1639392017320504, -0.10506276274376554, 0.03644020638176488, 0.5819256728528587, -0.050761562621302145, 0.23129607327953888, 0.13469008042852912, -0.503317632962184, 0.3325634921489079, 0.30837307153536925, 0.006693833957750519, 0.0979146617998377, 0.3422226359747914, 0.38239362120942677, -0.07103241639698701, 0.2538677261495705, -0.7223325468739412, 0.3951121817686129, 0.1555271542536836, 0.4628664283131436, -0.08288291703890695, -0.06380524872225178, 0.24968985279374034, -0.20876430459324158, -0.46893514174636824, -0.30235713731260594, 0.24069468511454084, 0.23835079591581, 0.3385871435517636, -0.4568280767928557, 0.23131855254441755, 0.08371249982881386, 0.24234807437374228, 0.05655943952111455, -0.37845578105783384},
    {0.13105878706514112, 0.16303948858929393, 0.26491772661697643, -0.16234228808534784, -0.186956365941169, 0.6983289810165093, -0.040542873197822446, -0.4131229081431545, -0.20047443649255944, 0.04184889183789029, -0.13906179373814725, 0.2587540224600855, 0.4137280029861242, 0.5610556069091823, 0.2185983391273341, 0.8190206357686656, -0.4334471730206819, 0.38006146815564285, 0.4249033225870206, -0.12420912927831981, -0.20355270864930744, 0.3407128144774225, -0.043651937564162024, 0.23287196032793728, -0.2951563532265433, 0.49287166062238486, 0.047065148277506574, -0.042884831011100334, 0.05088826060263917, 0.15390154382887294, -0.015405478369735593, -0.19978396846758767, 0.5084372117279102, 0.5273272803393907, 0.009452806350446569, 0.4135844455394069, -0.14832729147683185, 0.19018569807702673, 0.01786707751097258, -0.060102355727873764, -0.011982257149151862, 0.6523310664540493, 0.30285988461275465, 0.10519371748788023, 0.2669165367034416, -0.2320044275939403, 0.3923516880477302, -0.19992301349826982, 0.269701241742891, 0.017411231606036713, -0.008882244363857218, 0.1800564375095343, -0.3906264911288987, 0.03484510858995189, 0.13256564662370712, -0.05838159369751101, -0.1651810016146599, 0.44895300940479216, -0.2282257458412206, -0.0276843132836466, 0.11137073007676766, 0.5841077655322389, 0.3293040640285865, 0.09495292416571247},
    {0.06219636351771922, 0.3191518702047514, -0.3120819430955084, 0.0330104381866839, 0.01452293500744972, -0.4498698124266727, 0.2729848539620276, 0.39209435078353577, -0.18137326141945423, -0.721430839707854, -0.019936340130479076, -0.3846463568898493, -0.056722254753155586, 0.3644022507443997, 0.5285632892718277, -0.20221145523388115, 0.0880415970193386, -0.028920924268046943, -0.1997812188769088, 0.17656143483599998, 0.30972343294913446, 0.1873056174951573, -0.10457836617150186, 0.015936313722046274, -0.3198890826973463, 0.4763306027470047, 0.5491126363330081, -0.29019242848878474, 0.0742787028307, -0.5158320358822296, 0.25508565811646555, -0.09238551068459029, -0.02470710504099583, 0.49448529362403826, -0.26941064052635083, 0.14262337069102696, -0.388071405855391, 0.30464077762721753, 0.1326553447281768, -0.28005916786817636, -0.039579384010475956, 0.009753672604378679, 0.37348012418525833, 0.06720920808521648, -0.10808296470021246, -0.22904494340618314, 0.23579973941923907, 0.026108945839722692, 0.6167966623277292, -0.0769244961711392, 0.21504066143685618, 0.5477096718040446, 0.026264663748007747, 0.1994462794276752, 0.24081361284842756, 0.49962140539743766, 0.15883892167959246, 0.098538882002822, 0.2365240514091005, -0.3424615039760475, 0.38197683535979304, 0.17917522416115403, 0.071527480395435, 0.04827270150752371},
    {-0.051827902822859505, 0.3948942046863687, -0.6132002935524513, -0.1363236616162509, 0.03143000791742276, 0.02550558503776449, -0.3975598365753069, -0.015213568110640233, 0.044309309638399075, -0.28148032760250746, 0.1749842371494833, 0.4118513506189497, -0.7465561997602512, -0.5185297143231976, 0.6766374460998569, -0.2682021182061837, -0.14603538089027743, -0.5885770152176197, -0.09630330137497985, -0.11684967945728628, 0.1240333232838208, -0.48602268661388376, -0.3012939086788134, 0.0036458747266210375, 0.11263984856360482, 0.13963476992771534, 0.009932680603502227, 0.12578587545299436, 0.18109831872029958, -0.4182988593589461, 0.14239492877595752, -0.2665249773783774, 0.24663783056842933, -0.03269532453329781, -0.003923930568852192, 0.24396690718656291, 0.016124688297011906, 0.0915972498150607, -0.6709308300970364, 0.07146235842484724, -0.0936334304400862, -0.4009958058908882, -0.35451634534236337, 0.891371240943959, 0.1947080022307817, -0.1301501279984422, -0.027055084198649212, 0.1264160273072901, 0.26269435183905476, 0.1259719004634799, 0.2581836709700206, 0.12693573229001637, -0.02276273275296846, 0.05379291202893398, -0.19198326422249806, 0.1815555646513465, 0.3673554350408391, -0.12716949803956726, 0.1644326097994777, -0.3339686149453961, 0.3662992616342078, -0.02693070927765493, -0.025329976467068027, 0.1090291169752571},
    {-0.13404483227541536, 0.16782546484053468, -0.5862207533746618, 0.4324976786523828, -0.2923553374387948, -0.009901557098122585, 0.2972916968577128, -0.36850838111246453, -0.04135176547888107, -0.027083856254975266, -0.5803395630584738, -0.030214259779939894, -0.002100382117734386, -0.24055346567955874, -0.5280848189236846, 0.42113456506340763, -0.08218360902816473, -0.5056173153086415, -0.1495484401442365, 0.09901997145050524, 0.2570117894401866, 0.06230707679525233, -0.06977015074964034, -0.3349423046166772, -0.057370637987509104, 0.10991216963390318, -0.20627725583981474, 0.47415544730682097, -0.15531559201160397, -0.5789316667058372, -0.7041443921279008, 0.3189824623094902, 0.05417535869736031, -0.30797676239168176, -0.2986330028837145, 0.17016084553535707, 0.9074336321613036, 0.269660203088203, -0.02648417856300876, -0.4515669753371727, 0.02578656092277813, -0.3183680693416574, -0.21974472927100067, -0.33864690941726294, -0.24986197803370963, -0.10367049003946449, -0.08259476704349437, 0.013289196688485468, -0.371375492030035, -0.441811589242952, 0.1292001534694834, -0.4655430388263353, -0.3410329155441397, -0.3096473938269786, 0.12109859872644897, -0.00045561415959996374, -0.23822511062840995, 0.00391908729710775, 0.022033652817361412, 0.30738313667626704, -0.43635486589403993, -0.8102188982765194, -0.26326971926885956, -0.11785151496273354},
    {0.36948507313401585, 0.36978102445062433, -0.27059128450067366, 0.5303449589279572, 0.5628249350709796, -0.36997439414647104, 0.18375421594458388, 0.259120631297329, -0.19215376927467973, 0.1608975486189384, -0.39106987562738, -0.6219341599661893, 0.0603065244551894, 0.12974553019994658, 0.46869684481666823, 0.1240785764649111, -0.004909648056216562, 0.2629223063243708, 0.3966136792052173, -0.285643263112381, -0.780320519405329, -0.5103832954769999, -0.22275348664708378, 0.1515424029912609, 0.3512304577939277, 0.12219357256886705, -0.22181136914314778, -0.043628320657933484, 0.22103370586410032, 0.5795648715044799, -0.30722009087977886, 0.19799203719077124, 0.004970411496955605, -0.6775229859812928, 0.11798104674598864, 0.5319911016938905, 0.18809387757150497, 0.24277415242008984, 0.006700578454660013, 0.045057759437030664, -0.05004133922552325, -0.29046566743018903, -0.11746767749293034, 0.6249092075789864, 0.4014494404104918, -0.36701583489642337, 0.17763297150378682, -0.43484410678359053, 0.1088747017266248, -0.35146916586832766, 0.15750586800658206, 0.2684139067111847, -0.07006195563378327, 0.0727396797531153, 0.29173919618014754, 0.3549237999749733, -0.3030438756176694, 0.5734737484643808, 0.1900676287100257, -0.2394773423881589, 0.27884655415880333, -0.07708322897722558, -0.6237843894944013, -0.018368696382074213},
    {-0.2661675998863185, -0.45885815895147913, -0.1018321961591897, -0.04838562284641429, 0.19899280735557914, 0.3526979754478965, -0.02656118237674741, -0.32025657665358287, 0.3486973133600782, -0.20918078745762303, -0.28929188473306733, 0.08152202601740922, 0.14380560786382535, -0.14755407969042467, -0.2573898262711144, 0.22475702013060728, -0.004582917331729795, -0.3502150815396108, -0.6875147054382403, -0.27581561350489203, -0.5582899660732971, 0.25156341369361734, -0.11187210490574878, 0.06373243255261823, -0.12814545133012042, 0.5127537585026066, 0.1668282158553381, 0.35274231734372263, -0.25802600664259057, -0.19812328204992902, -0.17527945227035177, -0.017131115549124908, 0.5886410945176088, -0.08298290739250846, -0.11452495498203331, -0.11426252674990338, -0.2500585622405399, -0.13677508841633748, 0.28612555935247846, -0.4173096918897604, -0.49495542078766014, 0.12213139094372907, 0.04071217340640443, -0.037602279906339194, -0.3576980000895376, -0.15806076181541964, 0.06459420129424309, -0.5841641826078312, 0.045128699162687864, -0.3346950235639004, -0.02348187706970969, -0.21272699105140536, 0.062455021929606044, -0.1740927251148344, -0.14690951224192003, 0.13268961387026867, -0.05079002861126342, 0.08822508937658492, -0.08480985381160655, -0.14088429299417018, -0.2804435948673085, 0.5294852914471008, -0.6963516809341901, 0.352107406166672},
    {0.3348331502109063, 0.15763063119078874, -0.17981633198083413, -0.5990106389824703, 0.003859833812390921, 0.10834903643040597, -0.32127800885751034, 0.2733680200958304, -0.24346643248047473, 0.4093934448817041, 0.08509132526245879, 0.08783705788915305, 0.022632121069535785, -0.16251111648430938, -0.18339698611332014, -0.1346363549802381, 0.3214971990430829, 0.08049105369429647, -0.08749411887255824, -0.5801867086824334, -0.752985824791352, -0.6747568567266173, 0.21258041913013487, 0.16382381245544, 0.13763603337636754, 0.08365689878566991, 0.19449232390573537, 0.16390921073292158, 0.18149213803614603, -0.24826657311019742, -0.17865707818724647, -0.4850584030972767, 0.1533232948866236, -0.748735579468574, -0.10402023300724479, -0.12390721072181955, 0.35149851267227883, 0.22621541779654805, 0.39684172771856124, 0.07238758603276836, -0.790094092819664, -0.1364986723688724, -0.05562474010277353, 0.23875032928215914, 0.18274938649671288, -0.8448568250231154, 0.4602247046838057, -0.15349698331700265, -0.089334523685205, 0.18050932246342588, 0.09654654431716694, -0.27107092494267104, -0.22876497992681585, -0.03048944422922326, -0.061969783259189545, -0.2140548329143559, 0.48802321980981184, 0.2419933777405038, -0.21624651789496305, 0.349111918715983, -0.4957717410923261, -0.31371735562885306, 0.6226093612947563, 0.3218511792229742},
    {0.4799162907617392, 0.5334329894104265, 0.5316176735922756, 0.21501678370734317, -0.037001578788250895, -0.04702480617259177, 0.7726425849329907, 0.1130546468937368, 0.5461689384129153, -0.14545500892133115, -0.087867299952369, 0.17460268525721948, -0.14556467625759734, -0.023021324978166956, -0.513079000347875, -0.3983307879700677, 0.22157790360404805, -0.2644312500315919, -0.17969668858535068, 0.6196129240464378, -0.2341872358022273, -0.2562954663692189, -0.08868355639086135, 0.760129750733341, -0.502233462270915, 0.6467337518550459, 0.13552378409266283, 0.3053158387350412, -0.3035074038213818, -0.06710277875653109, 0.6597671018990985, 0.34828686378724555, 0.2840655912307539, 0.06321829810003213, -0.5576413702407562, 0.017429891496101125, 0.06427818259901318, 0.2507911959392616, -0.1988245263010478, -0.3229438013975671, -0.20939742393192012, -0.3069869126672291, 0.30014916398589553, 0.15103554339828415, 0.04852068483427591, -0.5953123922281153, -0.05582625666523377, 0.016317557492576046, -0.06627627985135834, -0.4744088357150273, -0.27763850896075765, 0.4922278296976817, -0.24029000950591917, 0.12214794620406566, 0.2722875987406163, -0.054133749258433735, -0.19116842008005283, 0.2709527631361118, 0.45936356361650366, 0.5502239050863278, -0.7667196333229473, -0.013693289842792425, -0.25977717638410597, 0.482364422440703},
    {-0.5927340811286422, -0.13397018766894264, -0.16669341739378218, -0.011776881487273, 0.34074744310934024, -0.22881776580847318, -0.112082746657015, -0.47378925631069024, 0.029939652946973847, -0.3284681577497102, -0.3436992825338656, 0.3186332508811187, 0.08678686856207413, 0.21934248124904723, 0.16349759168597242, 0.10440081215473786, -0.021444724554918904, 0.1226549813715954, 0.15825588634367607, -0.4122853904938346, -0.11949557659722923, -0.028679208448330714, -0.07629267717977369, 0.6467650585198375, -0.3442092786547527, -0.0966675226723159, -0.017331176975463717, -0.0016761118524260014, 0.054707451635370385, 0.2151130534099224, -0.43422487581898755, -0.1256419751491041, 0.12451931565144188, -0.15519422656737097, -0.05010693038054594, 0.030438367510174213, -0.35593512810238925, 0.1357933005857817, 0.034480020040647014, 0.2614697005468418, -0.08432697835292373, 0.2999218840916216, -0.04651395171114011, 0.4716148172655476, -0.13557930916815855, -0.49156451069479856, 0.40433733035640257, 0.32323322905306484, 0.19798473013110524, 0.010701875021299137, -0.11299775645959177, 0.313437714010994, -0.4070524438687891, 0.10274537938565731, -0.48610931701468135, 0.16778120964540144, -0.1750204842679271, 0.0455124095638957, 0.0810284572050385, -0.2751554405744761, -0.11500759247746463, -0.20137330569222098, -0.13660881127815383, -0.6676431969309511}
};

static const float b1[64] = {0.8762458468288243, 0.8803956921728506, 0.8727750794879866, 0.893889427928871, 0.8848281330096369, 0.8854059600582094, 0.8677793636930335, 0.8101015878563793, 0.8933424880841656, 0.755926890089978, 0.908649121621238, 0.7081356884384556, 0.8871776198287534, 0.878553181793739, 0.8518720874451408, 0.809283746937091, 0.660136880743864, 0.9100247607654619, 0.868638457433433, 0.8845521068318043, 0.9078801157360167, 0.921015854792407, 0.8884348971282031, 0.885354317135694, 0.8564247184190298, 0.857199649842554, 0.8325063542505239, 0.8661069587733888, 0.7728315918676225, 0.7634617358926636, 0.9114278651398078, 0.8630990317241176, 0.828954617885924, 0.8539136911915308, 0.902528852074184, 0.8843764114109048, 0.9027000934730496, 0.7325143916415988, 0.8834664162151773, 0.9011528005522155, 0.8333004986702984, 0.8735790166863338, 0.9079793114161203, 0.728634241127193, 0.8504076813221688, 0.8497228720289874, 0.7873006586980523, 0.9071905704792937, 0.8023492809655081, 0.8731922186360473, 0.7001517465645571, 0.9104384183874702, 0.8326403407152544, 0.8417623904780619, 0.8377293043948638, 0.9080144648127411, 0.8882883719088975, 0.8999288304156312, 0.7273230344613002, 0.9280123301743494, 0.8838788761994218, 0.8717535935691949, 0.8246585298989272, 0.7613118374753856};

static const float w2[64][32] = {
    {0.4836161080627772, 0.9212011383160906, 0.79992751737122, 0.6996403318538501, 1.0625976211161798, 0.7483248056462313, 0.7186047920281128, 0.6827052617524253, 0.5821649914770477, 0.7232179816889633, 0.6683800263807202, 0.5003068035928547, 0.5760413834587741, 0.8738542561925677, -0.4946176821094568, 0.6354400572686772, 0.8244648566617354, 0.7675482136028703, 1.2356866673439528, 0.590610877303798, 0.6224896509669036, 0.8959753684739358, 1.014907116119381, 1.08992533038243, 0.5345383918493456, 0.5337344291295582, 0.05521196273985766, 0.7736964727506781, 0.6763088052226872, 0.8995183235298373, 0.5796919750357931, 0.6370932359450882},
    {0.72428677228042, 0.7317120542048982, 0.7589699757660989, 0.7505920119414171, 0.6320751003029247, 0.9192882328805453, 1.034230121443434, 0.8186709027926465, 0.7327012795286432, 0.5876260541211636, 0.9555935936719412, 0.8961386141671736, 0.4143974747105883, 0.7938618501604242, -0.13637286939646706, 0.7340513429712541, 0.9686528923501002, 0.8648772692782805, 0.7589613657359155, 0.26399511373577517, 1.0921899869267453, 0.5188329627368542, 0.9056015236589541, 0.5848469111880444, 0.87819443875339, 0.7707995089253928, -0.13275709855696624, 0.8043152209198279, 0.6253676431254469, 0.7491722077170739, 0.9011488882223533, 0.8270045117388201},
    {0.6892649571071555, 0.6180451464630554, 0.7944164324370881, 0.7623733133338418, 0.8327269534958482, 0.9727066641177744, 0.9109129440801734, 0.9055953788279053, 0.5295348066804875, 0.9491254760578841, 0.6298387048117065, 0.6516580723139168, 0.8165925363080939, 1.1627649852521198, 0.19943392389096956, 0.8649644045477651, 0.836739656883281, 0.6885790855416352, 0.8104933442722154, 0.6408642484960785, 0.8158901886038357, 0.35019352496235345, 1.1029591997323591, 0.9901251254724424, 0.7910157726078244, 0.18090209760248374, -0.23268632159427247, 1.1950204881719508, 0.5801671762447542, 0.7785613236561416, 0.7939454621563385, 0.8726120206392723},
    {0.24852738622022186, 0.817702068301045, 0.7426496998136405, 0.8903877235658764, 0.7499792831275105, 0.9766632604348462, 1.1104708771501302, 0.8474018000104526, 0.6430475206696292, 0.6375092482872646, 0.8290714151541486, 0.6751024031041354, 0.9200178388606028, 0.6670454369776545, -0.19735968816080884, 0.8511184553862772, 0.7416912298218747, 0.8247716374842853, 0.7976103974810672, 0.5106062708514292, 0.5874301218743517, 0.8325522695631792, 0.5266916504216961, 0.8718614551373997, 0.6986942141106095, 0.30311177278554025, -0.0007951618282832766, 0.8377819927540607, 0.7150518268624109, 0.5406763430432043, 0.879066588763683, 0.8513995451075572},
    {0.33662964389057537, 0.4511431445910272, 0.7702674395303604, 0.8161426556760242, 0.8247929875627018, 0.6664754805282356, 0.5399193995097875, 0.7892535083732873, 0.8211598174894104, 0.5960312489729775, 0.5404455096187819, 0.7062960370071278, 0.5095138304275648, 0.8247939549998529, -0.018181080803619624, 0.9714366919983061, 0.7384057213408083, 0.6443968772173295, 0.8142231530900342, 0.5779696377720279, 1.1045360474045427, 0.685722835965601, 0.47702932437027845, 0.9182931502258649, 0.988791512123843, 0.4209373175798721, -0.1265742503579727, 0.8118973255835032, 0.961781609440695, 0.8913840315814046, 1.0139258480650766, 0.990042328546431},
    {0.3307484991019402, 0.6826939837368247, 0.4966569290182086, 0.755293984001676, 0.8505772969022493, 0.6933924602527398, 0.4243845177238679, 0.8532596919615606, 0.680685374254618, 0.8458737337289118, 0.8883909368258561, 0.9263137004151026, 0.5254272317747403, 0.7852886964094802, -0.43563383826245117, 0.9169063149545855, 1.114451035143475, 0.9896423613048364, 0.7178294551209662, 0.7355117259532177, 1.0067776622968518, 0.7649885647123783, 0.6724997163084226, 0.9461125386393212, 0.6303187531756647, 0.5670956338002598, 0.07875833050710371, 0.886244593391815, 0.7232246139309867, 0.43933490877401515, 0.4963539718380441, 0.6976566124619944},
    {0.7610073598896916, 0.8410466565892057, 0.7531458885324712, 0.8933397913591159, 0.6253251019028598, 0.854843803106494, 1.0998943313056635, 0.7957114870104998, 0.5123720684283487, 0.7313947377031018, 0.6646917483811363, 0.7828191880340964, 0.6342438757930241, 0.6948820343859995, 0.045991794659120074, 0.8673679447603473, 0.9307549019223632, 0.5247153436368404, 0.9825764478455716, 0.5379467524604316, 0.6567905370931506, 0.5528672160652504, 0.8394859228529912, 0.9686772573712132, 0.9404594634886156, 0.4936454497673719, -0.3946260568002499, 0.9089098375866751, 0.8969937686871561, 0.397524494839209, 0.8074698412031311, 0.9127570152329537},
    {0.49692604475345126, 0.7137461672879324, 0.792549009314804, 1.1400976624244568, 0.8240755133643034, 0.7870297422407568, 0.8103105417999872, 0.8383560999970368, 0.9435218091644432, 0.40868917196772164, 0.6542403190715735, 0.801372983038005, 0.7856986267691571, 0.8401326292975069, -0.15847387595643592, 1.069291777692982, 0.6901399727244192, 0.7379019948863658, 0.8119150756018074, 0.3325779111803641, 0.7699057627010707, 0.581691196373575, 0.6980241001163054, 0.8795810841702438, 0.5378138809653599, 0.6321887884048205, 0.12159454326494683, 0.7195545345297311, 0.7356670563502373, 1.0085385842173127, 0.5226614541425703, 0.6088154448008012},
    {0.43931743255567374, 0.35780644575031645, 0.6927548718299223, 0.9821229571672476, 1.0906249180930234, 0.6299907385816997, 0.8051418493187169, 0.8165507798046623, 0.32815799225970843, 0.8561422468699625, 0.7492772068154775, 0.5263666093714948, 0.7025632694578104, 1.091140203469596, -0.06437822599641789, 0.6415010361570322, 0.9464161845266903, 0.654917855166606, 0.5579993001175078, 0.47324113627088416, 0.7457064450055657, 0.646733438708326, 0.6052124310674475, 1.0072109635535815, 1.083733109940922, 0.5795331119337197, -0.08378515205490397, 1.0694156796490921, 1.0749041717825116, 0.7265300380108783, 0.6937766487770821, 0.9332545082460555},
    {0.5744648900464369, 0.4018578972665398, 0.554404978608859, 0.5568662959917731, 0.7945976554442977, 0.9229590311275192, 0.8581234566636338, 0.6105141555107639, 0.7897317751812453, 0.8100835075974231, 0.8919389896457891, 0.8214574235309554, 0.6757642708089078, 0.5838909178766795, 0.3538969394150472, 0.8048789439275607, 0.7722422914743102, 0.8554951943221543, 0.9329992082056865, 0.6157112530276625, 0.5360244657592259, 0.7562261411606901, 0.7208000823986708, 0.48024003388170144, 1.0555400139802753, 0.711077140756542, -0.14074249922828647, 0.788327150754049, 0.7173681322052645, 0.843314093984244, 0.8167071222646486, 1.0718451128364381},
    {0.570062908810919, 0.4583377784763478, 0.5928656943617305, 0.5257406889327793, 0.8940174929030076, 0.6674941791121884, 0.8004512546869433, 0.8022831560337241, 0.9411276585847851, 1.1899486149248757, 0.7116680269515404, 0.7549401605848388, 0.95151110862116, 0.5699155675882045, 0.018654507153713556, 0.6529626944563635, 0.7708742858359541, 0.5956067719980155, 0.5163814195340424, 0.7181409601208715, 1.1619251526418888, 0.7736861721518526, 0.6037832116262464, 0.6355051884329425, 0.893380943905418, 1.035429159308258, -0.10949384463413019, 1.1564910145406853, 0.567676482339655, 0.7452921505857901, 0.6614629722821747, 0.8517954706094102},
    {0.3390646661461131, 0.6525217130710579, 0.8545993852677135, 0.8036666466499309, 0.7978936923185588, 0.6380686838616798, 0.6897161753671682, 0.6727401072938738, 0.8452430994508919, 0.3448686460003621, 0.894689207786211, 0.9408622813195243, 0.46764191318274845, 0.6046700680332261, 0.18265770922301114, 0.8930617157165387, 0.6855223682436491, 0.7223041881570914, 0.5795180640610487, 0.1647638481272965, 0.8747064175710969, 0.7083555243570822, 0.8958330463582972, 0.5324857847083663, 0.65408817644959, 0.6577027700649418, -0.1021662283608719, 0.8856549965562696, 0.46641407667818735, 0.9615368716281794, 0.6598178673437743, 0.9932233442716932},
    {0.28493610077254483, 0.3912386959622593, 0.5749850186920779, 0.7807585449143872, 1.164696571937438, 1.0051583946914726, 1.0658289971916037, 1.2160038657462338, 0.7698924158805593, 0.5801195141828657, 0.6645685088932083, 0.8233280460608381, 1.0479426665813272, 0.6027892245630097, -0.03421028882650529, 0.7690470707198599, 1.030189964327022, 0.5093685854470101, 1.191023684802476, 0.5388023692863879, 0.9489636711480599, 0.86611655034967, 0.8015539692910564, 1.1154509842934683, 0.7137385612636727, 0.7504444419046347, -0.0398370696416117, 0.9819149705234033, 0.685072737250247, 0.686766131920783, 0.9413850247784907, 0.7189025226388263},
    {0.3729462580573663, 0.6502749667058647, 0.6768584971709698, 0.8241076115337189, 0.7185183585557322, 0.9061166787784083, 1.0494429434657764, 0.591734447488804, 0.6582402182967787, 0.8293713670441517, 0.7318863029520315, 0.3239392204873364, 0.9867427917755192, 0.9141909432328901, 0.05006660726351971, 0.7903486600859931, 0.8954713763130566, 0.7605489232897428, 0.6901348107275124, 0.5506569400721614, 0.8843126157525394, 0.9178124985176738, 0.8480777560067088, 1.0702591528536083, 0.7158009794972511, 0.46950267648828037, 0.08448951189372603, 0.902663115820566, 0.6824839435072197, 0.7422012463757292, 0.6627390522488387, 0.8602431610800565},
    {0.8504376028141617, 0.7885275271120332, 0.7833325563204342, 0.6058839637792209, 0.8585296394523582, 1.024119918350689, 0.41474487185671155, 1.1378787263818764, 0.47048685033270543, 0.697261494027293, 0.9067233587199826, 0.6476638437681963, 0.8553354769384461, 1.10887620710484, 0.09352563265040248, 0.7586896330287581, 0.5920448653407739, 0.6723867638357669, 0.880148607800558, 0.5928609752914746, 0.821137112732811, 0.6647303458232316, 0.6287815940570005, 0.6573099414440028, 1.0351013076406022, 0.6072912854036436, -0.1969673130581517, 1.0576863202703866, 0.8704614946581753, 0.5853247730850164, 0.5417432598010106, 1.226631327178459},
    {0.4429790251169805, 0.6988281036886373, 0.690546238422026, 0.6102270026685146, 0.8746236866612158, 0.8979343666391751, 1.0307934334909628, 0.5697696830226575, 0.6770592182329196, 0.6729579212736481, 0.866652188552817, 0.5286775479769024, 0.581993464628943, 0.7703780560178817, 0.003381002964194506, 0.7959485492628895, 0.837768910446022, 0.7518805293131652, 0.6691219974265671, 0.8707011535681529, 0.8784650383201095, 0.6374906656505208, 1.0401407679237147, 0.6732129883661507, 0.9631969253548978, 0.7463063971049884, -0.04705147271469386, 0.624583653181896, 0.9224095359268056, 0.8228199882143383, 0.8160271844580655, 0.7582312439135562},
    {0.6923699780382532, 0.3652815665937734, 0.7137376412798584, 0.7469859640627842, 1.030019234874774, 0.6144361572557804, 0.30411309542395654, 0.667769379508407, 0.4171375796440314, 0.6730568922244644, 0.8673087377934738, 0.8372122772117162, 0.6361128287872932, 1.2634877251910261, -0.13218847727349278, 0.8648402991316004, 0.44986301435169496, 0.9178453130313691, 0.8910161661953814, 0.5842343211163072, 0.7234884550373513, 0.6850447247438407, 0.6644555336893114, 0.9012925062106572, 0.6450570046270478, 0.7621552760076676, 0.2148009551171227, 0.7738270987678847, 0.6989787837076216, 0.781083687282668, 0.8416694853331963, 0.958902578353527},
    {0.49540109414009925, 1.023614817505027, 0.9464933622964975, 0.6790881266414045, 0.8503035498888798, 0.7624013054910059, 0.6781899335993696, 1.0626643183502569, 0.5414199227616108, 0.8208262729048262, 0.6033339625446102, 1.054336607523476, 0.8032013625096275, 0.884622905156096, -0.32093988267271617, 0.8420156938800293, 1.2617782984827215, 0.5046784795839996, 0.7357478432910975, 0.511416778646757, 0.8778125351740809, 0.9121678781299154, 0.6377217359006805, 0.9043516552605555, 0.856910430155514, 0.9307232454058925, -0.3115875227153452, 0.6987751879792197, 0.8030083176017431, 0.8252439204824489, 0.807026044467913, 0.5635772133158927},
    {0.5039890803330187, 0.7557196180930709, 0.7158597705416798, 0.8074411603782607, 0.5887904042256139, 0.7032025327649222, 1.1273987016289033, 0.7886386975078186, 0.680736402443241, 0.9175259602392656, 0.3950539035185513, 0.5091987883912117, 0.934564242161017, 0.6892673248833858, -0.016926338016492657, 0.8534889813282424, 0.574157031280375, 0.8693931404149675, 0.874990667132365, 0.7547907283349014, 0.7482819043780145, 0.9057323886227502, 0.9679727894696973, 0.8492281864219259, 0.7991494108404481, 0.8001961507672005, 0.07719863768058897, 0.9812643913937802, 0.7518958369762946, 0.8877489970624607, 0.7572979533095566, 0.6799323367762524},
    {0.7315163416283367, 0.6035216426378545, 0.8478102408702173, 0.6364000156153755, 0.8924741680049129, 0.7980882752413277, 0.6327899096658063, 1.0023942163164001, 0.8024219937448074, 0.9375865025848618, 0.5571853109326371, 0.8272543000462123, 0.8928377354981087, 0.788252948770121, -0.03802814372515124, 0.7807791309279561, 0.9707225114132838, 0.6090461996848793, 0.8255343113503999, 0.49508519104698384, 0.9077626464335918, 0.6119887381319404, 1.0967341281381853, 0.7650145856602141, 0.7524702277899868, 0.7809999802214375, -0.033543493446688305, 0.9402698485532733, 0.6818707322640167, 0.760047941682622, 0.7240753886961286, 0.978524735276132},
    {0.6254123612737443, 0.4519649718314967, 0.9016949422136286, 0.6372357227746489, 0.8523831885594223, 0.8961871806525321, 0.6710758753916699, 1.0202223937379695, 0.6373149530416713, 0.7309801765782629, 0.6052771678551004, 0.7683578709178911, 0.5665461700429095, 0.9224857005808821, -0.17330864189711093, 0.7315092171482322, 0.9648221772415582, 0.6631392771295798, 0.9080099274609446, 0.48214303575140327, 0.834420895813453, 0.3334192720221026, 0.756818479863571, 0.7168699522759912, 0.9513066584159415, 0.6635271746045651, 0.2403763519333909, 0.7979328284005394, 0.883348057343116, 0.7323219746336559, 0.6392900309415126, 0.947171261824394},
    {0.9364068414186208, 0.7304867670550304, 0.6732282572765549, 0.7563301890165312, 0.9256301560158898, 0.7544362376740074, 0.7038388562855278, 0.7845346482029277, 0.5762646863005022, 0.806898637858396, 1.0130472657961618, 0.6109991146028458, 0.7146494987392036, 0.9548014462806946, -0.35354431057504, 0.752227777168989, 0.8995461817079665, 0.6266648525364507, 0.9946569157090129, 0.484166118295597, 0.7458050854142928, 1.0508778234605007, 0.758390301975449, 0.6533434585226295, 1.1574703178359114, 0.7852737374740314, -0.2251993463514759, 0.9853398954207641, 0.48585063785082794, 0.7785094759605142, 0.6780068161323899, 0.821701020469109},
    {0.5922026922507774, 0.9499570976277086, 0.5655852327279492, 0.7583715201943082, 0.8931343170216035, 1.0142586950884913, 0.788943230094534, 1.0183739363393034, 0.6511591762034288, 0.7700644130369351, 0.7130621585710392, 0.9978141960498871, 0.5205488159061543, 0.8670277653280176, -0.2814321363057178, 1.021682846525651, 0.7788007747315779, 0.7754189867681449, 0.8188886090183245, 0.30464116463128266, 0.8546904024866321, 0.6144843034107925, 0.7776925503636312, 0.8671705927776538, 0.5856390557759201, 0.9201534562786671, -0.07588567691206739, 0.9876369669068832, 0.7100285779104861, 0.9133389461115249, 0.7123034536871883, 1.0277577177275},
    {0.7051249790344051, 0.7284405241262696, 0.7001772318316328, 0.7153736919413368, 0.8506823461412741, 0.8217231440113318, 0.6580028931161289, 0.9236316664314876, 0.8176287557951304, 0.748052262322975, 0.5916635250904654, 0.7227412499830309, 0.3536286875974493, 0.5950932203157636, -0.10068965112110419, 0.878288674873149, 1.055046430970289, 0.6420347538852901, 0.9361538907205746, 0.6589393941451989, 0.8423169909984614, 0.6899482712629534, 0.6700001121354465, 0.8246980007397164, 0.9605820282194932, 0.49803605618138025, 0.014785099702028084, 0.8787879203349226, 0.8687838975893292, 1.0577530598244664, 0.9190818934990498, 0.6633942052015311},
    {0.5891797362706869, 0.6511521640346516, 0.9034523937793828, 0.6467417172080456, 0.7801440735983912, 0.6981064894464358, 0.7852047542179261, 0.9313769447063532, 0.4291208857947483, 1.0360866592757683, 0.7370102036436106, 0.9280536354661102, 0.6765112803328192, 1.1047770245523068, -0.008063590452377438, 0.7144959995443864, 1.0532890733793736, 0.5499183615836093, 0.8844765779357024, 0.4384367718712678, 0.8639161550614586, 0.6389216769138617, 0.9007280693865075, 0.7098117014219331, 1.0462267946716906, 0.7339366536493354, -0.2195258739282423, 0.5041085456892197, 0.8148319492361122, 0.6141033417996637, 0.7783364690415466, 0.784289698337662},
    {0.5191145507813065, 0.5525139858903165, 0.887077301749308, 0.4661417697581691, 0.6611467271929473, 0.6310922457411225, 0.7333130150816551, 0.6749612081477908, 0.8113577847848837, 0.9997957343283386, 0.845120251814785, 0.6825445678079343, 0.5641805717466076, 0.967483705124121, 0.08631958070810995, 0.9672989782547341, 0.9605219866373219, 0.6520286723972315, 0.8788870594368602, 0.5871853236595566, 0.6485193994808025, 0.7382270349334383, 0.772925548577407, 0.8888942020899065, 0.8964467652375039, 0.4890352814429179, -0.33520891470798564, 0.9086713412830103, 0.8893656503141723, 0.6896502479561102, 0.7720127752992625, 0.6386361057686013},
    {0.5731304806615276, 0.7106717934670934, 0.6220880418172455, 0.49577926090030466, 0.8486003473698959, 0.5009942755326082, 0.7646728832867452, 0.8163231276935843, 0.9585780586127972, 0.5764242207715893, 0.7357209533845862, 0.6306853603493621, 0.5076480890850641, 0.4507974218186713, -0.017651199178273135, 0.7098888279538945, 0.5692788488371815, 0.47427128067215957, 0.9257350065271005, 0.726164309363962, 0.7374209983935425, 0.29035296915017417, 1.0587079924866405, 0.9243486768821287, 0.7980976434075535, 0.3727170954119177, 0.265927796045402, 0.977783232157945, 0.830160169139518, 0.6245626471887658, 0.7980193544114104, 1.1024970629675315},
    {0.6345122942396589, 0.850074543955407, 0.5298632849689776, 0.6860313295190476, 0.6402126954031453, 0.9541448078481738, 0.927649692680397, 0.6319125350774892, 0.7603469667496329, 0.5620765346470086, 0.6416858105933345, 0.8647006797798544, 0.6373786064285503, 0.814280355585683, -0.15647666915825145, 0.8116655729030179, 1.0256477888506825, 0.5679459109924466, 0.7614423884599849, 0.3736955951688454, 0.7029245452799242, 0.9016653471507435, 0.9443319681351728, 1.0476471821306892, 0.8022708586550071, 0.7208465199180162, -0.4940215200003837, 0.8612911748699982, 0.9759223909447058, 0.8215293067888761, 0.7772425124797782, 0.8358124940126546},
    {0.4112932697376407, 0.8018990753957997, 0.9886601035481309, 0.5360156562664513, 1.0575385560899462, 0.768194872043662, 0.9515261114832688, 0.5393068548381214, 0.8888134437049761, 0.44653317893078504, 0.41995235755607896, 0.8594280648258034, 0.8763934300511339, 0.6208640453286058, 0.1844527116472606, 0.9020171720643471, 0.8848164767916749, 0.8238314545207, 0.5129295253004612, 0.33014060941970286, 0.7913634486376351, 0.7640118837866171, 0.8487010245715755, 0.8936858665484079, 0.9356242854577608, 0.6890523366239323, -0.045806230847153157, 0.746027999188344, 0.7351559824887143, 0.7969964171834658, 0.9239990652514747, 0.6155320749382636},
    {0.6889196812887812, 0.5938868068602832, 0.8001532903988546, 0.8673823899335449, 0.8556526710096878, 0.9490580862027911, 0.7239207788150972, 0.5196395590506175, 0.5650518434049724, 1.0827020767376871, 0.7032976283833128, 0.8045259980564364, 0.9360632067986204, 0.9352476307215435, 0.030856563622502973, 1.1238653194361228, 0.7054762656616115, 0.38521270511412214, 0.9093531210447672, 0.27433718557504305, 1.0743811173200526, 0.9947429572637237, 0.7198625128134104, 0.6445963861950418, 0.7749883067528747, 0.9485494213603826, 0.0933880603283487, 0.5471461975191768, 0.7427486778004145, 0.9406376779100668, 0.7019585158945565, 0.9135475918306887},
    {0.21180543037958263, 0.6948731390787065, 0.846029404916614, 0.3788753986046919, 0.650728904254351, 0.5382525945655473, 1.009684942338005, 1.1636092738040529, 0.5750688230568826, 0.8988951922604583, 0.6893956112549696, 0.6754388835379381, 0.5999335606833632, 0.6857063793090815, -0.09669253148760873, 1.0402738368107827, 0.9024872587453415, 0.6163940132377921, 0.8078910318062598, 0.2705797100051535, 0.8102692401532496, 0.49302202734008344, 0.8421177888422325, 0.8938541569449406, 1.0573125779561239, 0.5973557315534875, -0.25043968799741695, 0.9065981389547295, 0.9633506717747419, 1.0423563682588495, 0.7766331076966032, 0.6295914271111309},
    {0.6514360389181485, 0.8148916687709922, 0.7516395779163785, 0.5120818564958591, 0.8725114303198466, 0.9011421660920294, 0.9343629269629808, 0.9396220470458159, 0.21849799136266806, 0.6180653473734953, 0.44103963120587664, 0.856452872477644, 0.7097334050523683, 0.7562895733437139, 0.1179527415446287, 0.7048532307658986, 0.9454613433955722, 0.7960128618400277, 0.6021292567353189, 0.21805935150168068, 0.8243556721228508, 0.7134384858759163, 0.6614407025203453, 0.7662431774302082, 0.7532444131016157, 0.6523530459656365, -0.08250822364659731, 0.7957982774239898, 0.8113522676512338, 0.9713884463463105, 0.691156120828584, 0.8424659681556222},
    {0.5949999357143725, 0.8243944706865851, 0.78407765078165, 0.5318618416314749, 0.8652335935246439, 1.0617487316717291, 0.8282823594600482, 0.9176356605621743, 0.46367140035920273, 0.8968784323729594, 0.9009063702464813, 0.7475695272284555, 0.8211394257846589, 0.8375862150952228, 0.16319835657929235, 0.6239403790707405, 0.8017194282677849, 0.5322240232751875, 1.0947665184369972, 0.1912975922593937, 0.5977752346979678, 0.7055980854450956, 0.8590546393672736, 0.6441971904509078, 0.6484848697210022, 0.8176796829139361, 0.012725296709172303, 0.9586524054705743, 0.4774147218895955, 0.6202205533107562, 0.6774086746949975, 0.668317200533336},
    {0.4847621875154565, 0.22146066376285145, 0.5033154385077838, 0.9231222334849654, 1.0318816620971383, 0.8706428932377296, 0.7942817849989768, 0.8038477849170282, 1.013707513506062, 0.6489751025169794, 0.6965806120932392, 0.630027156265133, 0.7782158158840865, 0.6753611685317628, 0.3036964409593726, 0.8171012399271756, 0.8460107358311558, 0.8604831461985938, 0.8640797862308974, 0.38289964402814347, 1.0889465993510716, 0.733280540437162, 0.8740100084057305, 0.7462214907260442, 0.5940664471070402, 0.8688814967134277, -0.16989584761499035, 1.0561983187599855, 0.9281909223098518, 0.8019851089859714, 1.3495146427997895, 0.7694931221547004},
    {0.3023711517302314, 0.8225596542889114, 0.6553266766215168, 0.6574576168185406, 0.8436840086642027, 1.0943476979995932, 0.3737486074061922, 0.7758736590738898, 0.5915684797157954, 0.7193749886326104, 0.9257209600864819, 0.6771410975848444, 0.8392909699673293, 0.8765705879908857, -0.1187766829531597, 1.0242188366104055, 0.9831112448470631, 0.49461063137016376, 0.8795600648764033, 0.6803039084207215, 0.6254184927802765, 0.6904608937244313, 0.98128880969294, 1.0951252332331116, 0.8734910407171226, 0.8353086120428158, 0.07293443295303476, 0.8187172178594689, 0.6002303360123566, 0.8129717519219133, 0.8176134706515312, 0.599482278627301},
    {0.6199422378331642, 0.5085182362255529, 0.8336311819676536, 0.26601160054863104, 0.7807160048531666, 0.9132156753423099, 0.9435465800360736, 0.7353794938208887, 0.8858520361474399, 0.3366842491805848, 0.6410155755447109, 0.5702488375428905, 0.6510833237694256, 0.8827597396461863, 0.030307176760101855, 0.9790488655915638, 1.006135861324436, 0.5551113256626019, 0.4268119564608455, 0.6074876301324622, 0.7655209861232455, 0.892651918102683, 0.558426233863509, 0.8727437695233391, 1.1899018883878922, -0.12948862984835277, -0.1427530853319334, 0.8130529483989024, 0.9663296361470791, 0.538434347470015, 0.6232789680591743, 1.0057017195106208},
    {0.5752215951468106, 0.4410834580909298, 0.777625640955254, 0.7655857167835204, 0.9887378304357605, 1.1114296875201255, 0.9298070774375237, 0.8429151241788626, 0.5591625093263295, 0.7527080324412067, 0.98673330555585, 0.6603046633045444, 0.8129207428318245, 1.007112441417279, -0.3179664161721891, 0.5001054778962726, 0.8754256142713557, 0.5907707699939342, 0.6964874646442477, 0.3834077337880656, 0.899770305866536, 0.7787638004254369, 0.8554908221903879, 0.9425466072260356, 0.7765714643956634, 0.8503656590939156, -0.22179327814196712, 0.8877879717432611, 0.7621137109284404, 0.6266643074018899, 0.9159702569287588, 0.7656080910494991},
    {0.5962981527343635, 0.4080075385720653, 1.0256341274148948, 0.8001456408404585, 0.9169858845878643, 0.6758485689909136, 0.5243488087633255, 0.886188623922832, 0.9735437094705437, 0.8020168202555918, 0.8814404277621852, 0.49799817298606547, 1.263928431602096, 0.5457193735509274, 0.05056843116443562, 0.6488538862630001, 0.9314721399725242, 0.657899094160297, 0.8334414775535505, 0.3757041121067675, 0.9625247750829332, 0.9607682128592745, 0.7396060105063972, 0.692702081778157, 0.6071187661889414, 0.5853950531751678, -0.22954154971359106, 0.6938758463647899, 1.1541147848126654, 0.728431910101987, 0.7215913379678749, 0.4746110639787329},
    {0.5417945869062006, 0.9842416536489251, 0.8234741347379904, 0.5847884775769172, 0.5527649307378686, 0.9896336804016843, 0.7995965481406606, 1.008744672705166, 1.020352341484467, 1.0509749464320797, 0.7742109679038418, 0.7727959460840311, 0.6067242704461844, 0.7109384246120833, 0.032461845959067724, 0.7265749405068395, 0.811096912294593, 1.074130105513629, 0.6662900729185558, 0.318738943116038, 0.5789713118848901, 0.6380135982530735, 0.9390005751146491, 1.2665695219745519, 0.7361703169308571, 0.5192920444699214, -0.529604191172128, 0.5826177091396114, 0.7551796690880423, 0.7645366348440934, 0.9979523850918977, 0.6852102753363815},
    {0.5961895160976357, 0.823829927775628, 0.970369021024015, 0.47804329824613273, 0.6538547000879555, 1.0937500462869219, 0.8343066932549714, 0.8083284776564851, 0.7032331583974538, 0.7659791635713081, 0.9122378487713572, 0.6088052239036871, 0.7214000560530123, 0.5626793250559257, -0.1963285862184185, 0.6767858589313113, 1.02193009317041, 0.7898620877792513, 1.1499969763787938, 0.3781554932003527, 0.9666740395433525, 0.7076989951102988, 0.7639515602512059, 0.5431232794058756, 0.7436866932202332, 0.9002453629917883, 0.07178783234639047, 0.7267172208484348, 0.7475475000783145, 0.9679172290857585, 0.6633871790507723, 0.7854216682281794},
    {0.2954358409709316, 0.5818814126960846, 0.6273787499347562, 0.8831776286873751, 0.9222007098356414, 0.6324630909833265, 0.8901382374653314, 0.9430842705546894, 0.6538788059635064, 0.9421539176914796, 0.530592535278537, 0.866912478819809, 0.7399435080313366, 0.35418904323702827, 0.205338150367784, 0.8564536527463734, 0.9228360360502895, 0.6799323352823493, 0.8079293236946808, 0.37649562329330993, 0.5653874034366645, 0.8935874258461444, 0.8125952889752056, 0.9582521042427748, 0.6951470834778127, 0.5360633808328065, -0.02826744178005159, 0.817489592026066, 1.0041257905015588, 0.9306177771983394, 0.9840993723406803, 0.7544831689048781},
    {0.8235479835817118, 0.6742870054478105, 0.6872162893900882, 0.7745853165343601, 0.9900290430394998, 0.7574469063197611, 0.6839053525519886, 0.9422875214114094, 0.4877724827287488, 1.032258428744994, 1.045232647547806, 0.5786063067196772, 0.3132925651113232, 0.6006231476374249, -0.059095592809253576, 0.7607617067940777, 0.8298431618726226, 0.5894559000109046, 0.49432232007814714, 0.5050975234361013, 0.811073231432547, 0.7921562316519319, 0.9948944900300806, 0.6470341000489602, 0.9734484483138065, 0.5718338086063921, 0.021441516507391574, 0.746583353930079, 0.6909114407051425, 0.5316258513559247, 0.9742604053315272, 0.8658583268475222},
    {0.28137112319792923, 0.6409202888886167, 0.6202050880182197, 0.7298686606151997, 0.8878095947650798, 0.6763586317745046, 0.9399911459273959, 0.6692532393188014, 0.5222686880709032, 0.8974586743314673, 0.6633299201742722, 0.9609337722574921, 0.590096207164851, 0.7573230757172841, -0.26041940708822037, 0.7762134472328965, 1.0303617609296805, 0.9408350554180023, 0.7549069295049171, 0.20802783864822366, 0.8279731682836659, 0.8830456381032264, 0.6932260682321462, 0.5625701562119341, 0.7172959650546467, 0.6762213332920091, -0.01252001664078296, 0.9011095823193733, 0.8463069373911611, 0.9758581871289121, 0.5305903022407575, 0.8682985912346444},
    {0.6418565855074991, 0.593100024830876, 0.6301777416923923, 0.5230770431684393, 0.8681477258045772, 0.7968429076042928, 0.6481079157376207, 0.7539256517994077, 0.5396898400936261, 1.1194247974554588, 0.9682067766038388, 0.8296340648776758, 0.6500137788698752, 0.6794691644043935, 0.16010052866619248, 0.5389418420868284, 0.5820151198079844, 0.665859175765652, 0.7484043517210491, 0.1420221764090029, 0.6745322948658836, 0.7933094624953085, 0.8082299833841796, 1.0575008145037388, 0.4511449270511088, 0.8087185786481991, 0.04732923501307582, 0.6827276935612077, 0.6876458336383495, 0.5075738542467019, 0.768116121937007, 0.5379575247534684},
    {0.7771717640269838, 0.7088490755391527, 0.9444148311895625, 0.7905502639773508, 0.9976902936275667, 0.7501932524818988, 0.9116146010567394, 0.8290114713568499, 0.647040931184851, 0.45235139297702615, 0.5350350604070767, 0.5760759900784651, 0.7937616608031903, 0.5000450309485469, -0.15973232734140683, 0.7278654238482258, 0.6284098441952759, 0.38243603446644814, 0.6345212497952795, 0.7459280308709301, 1.0684112203684144, 0.6607290385019948, 0.8068775541756356, 0.5538563899747881, 0.9889784189155383, 0.7954784895988818, -0.06258740242955263, 0.8755135575712686, 0.6581316884667477, 0.8289129848458245, 0.8723596088398741, 1.1654568628963486},
    {0.4733227200479432, 1.1136086509942977, 0.6725598569670842, 0.6236578623454977, 0.7513984584305957, 0.8066397348038327, 0.6264269244642197, 0.8221159644308522, 0.47209723266598486, 1.000913472307262, 1.0890763581572291, 0.7228459889234332, 0.896173006012603, 0.793898857676605, -0.34226277694888313, 0.9580528320353117, 0.7855918936521645, 0.559247558818032, 0.950052995968541, 0.6574290337868585, 0.5464681264607175, 0.673126334607384, 0.7610674933542898, 0.7841778797788104, 0.9062884119378596, 0.5212548346468638, 0.09446165223221206, 0.5660640801691464, 0.9044571363597497, 0.8095695377773404, 0.8908068962800327, 1.0537948891624662},
    {0.8280213226146748, 0.9651079521451471, 0.6593770969664343, 0.7314364886249303, 1.096421357267491, 0.6297905577047505, 0.4909027712290433, 1.034366134107898, 0.8155833174997289, 0.8563861720425513, 0.7316951200030958, 1.2488604085064412, 0.9037652012978098, 0.8359681437239753, -0.11505120515807082, 0.8670425653100302, 0.7631713225808959, 0.500819357595346, 0.785964997435032, 0.7381297231253567, 0.8183414798445503, 0.8385839613332808, 0.612796131981851, 0.821234913530781, 0.9423669405615085, 0.9500377791787855, 0.012369506921188671, 0.9082414445695073, 0.8941394931890654, 0.8936050794588316, 1.1487660840930893, 0.6587999555999539},
    {0.31444457172605605, 0.7582527253473872, 0.5637411785355078, 0.3858039465045547, 0.8317165607247236, 0.6357377792140878, 0.662143137492569, 0.9632350837800405, 0.4073574505613523, 0.8344117443833543, 0.6515780538932916, 0.6273594564723232, 0.6274027819900566, 0.6043572934897232, -0.15392206879768963, 0.7891444460217514, 1.0286628836311, 0.7160531839902149, 0.9026633906213651, 0.3605804936562138, 0.921503583805251, 0.4955691768457971, 0.7259376587755635, 0.6020059102787062, 0.6299161632251101, 0.5969527718118011, -0.24568335627593346, 0.8140827806582612, 0.8224487698973615, 0.925637466748161, 0.722811156555089, 0.7477625837338601},
    {0.7644807981931975, 0.5641533580673771, 0.8752605735011662, 0.6481073051379755, 0.5344030090186632, 0.9811443060370634, 0.33282179379751536, 0.5961877536522046, 0.8715103414236559, 0.7630001530237379, 0.5992602703641376, 0.5851831163606911, 0.5180182794991931, 0.8234739525252278, 0.0016159036993187092, 0.6139414322706571, 0.9914625113214206, 0.4810178826059138, 0.4901325437823718, 0.4345439441217222, 0.7742844482994985, 0.6594580762360728, 0.7989227333639974, 1.0909300308212302, 0.8229984594050004, 0.5604191645955184, -0.41787615398776756, 0.8041935926298, 0.663401965063041, 0.678309075742231, 0.7312965076253223, 0.8828501228034944},
    {0.6612317698210427, 0.717164212673774, 0.7306606081005891, 0.7937323647884819, 0.8186262904281852, 0.6290128419954624, 0.9874671208931023, 0.8443373685156386, 0.4226854052569273, 0.8283914424708355, 0.5960801411189993, 0.5592670529993027, 0.899583411136388, 0.7930436718560419, -0.11613626042351369, 0.7339679618200365, 1.1192128068682352, 0.4727146725794744, 0.6095616198050108, 0.3607277391711909, 0.777908016199432, 1.1242424539737899, 0.7568647676366941, 0.7672114729036306, 0.6307045963178024, 0.6275737317059364, -0.04437140084909903, 0.7986819220976501, 0.6029904424255159, 0.9603547149505565, 1.0125997586217916, 0.9375095057320573},
    {0.8338721843485091, 0.7622866177735844, 0.8343287556214379, 0.8335232184697757, 0.9169885107937268, 0.7868385662550674, 0.884212641882458, 0.5658159742569413, 0.8190459688679534, 0.782463857211427, 0.5496006755053503, 0.776366998726186, 0.731349050692249, 0.9367358071164104, 0.4102796887404179, 0.5102243651081899, 0.8331443132423012, 0.5497198463237736, 0.8750163089401155, 0.4375363152612689, 0.6343043435176106, 0.7554268118607148, 1.0363031391497295, 0.28725437869749754, 0.8039289054660878, 0.7544645350308196, 0.020183144622753498, 0.5470401111214418, 0.9907262225413963, 0.6509314540526439, 1.1098891920464429, 0.9785204538386912},
    {0.5044311216497193, 0.5776115155453453, 0.544167539316754, 0.6898239733659552, 0.8276859725480965, 1.0634185460709888, 0.854935527008449, 0.7593880682396777, 0.7674046393713791, 0.7239744921635659, 0.9727756566332346, 0.8271869952961988, 0.46220820619248354, 0.9055113989404409, -0.36130838567320794, 0.6348681029004679, 1.0188570337186846, 0.7202877813158072, 0.7264640427344201, 0.8180711644600156, 1.3214423796252202, 0.6165562158901486, 0.7233313335756498, 1.0754112661704076, 0.9373342531209974, 0.7159074622418917, -0.20711735867203748, 0.4849204957216446, 0.7380704554972499, 1.0060303642132902, 0.8523502169467265, 0.8128408411852062},
    {0.720562100048089, 0.6874173093741801, 0.7447598874013202, 0.8856382938242884, 0.949085731704149, 0.6948819618205115, 1.0313028824988002, 0.6204022572270728, 0.7101600612096595, 0.7542380109466038, 0.5709964429231537, 0.8987347805522008, 0.703779266036223, 0.7513113928288934, -0.18378478884387686, 0.7251998717269108, 0.5249658802549916, 0.47083875652696516, 0.742724872676447, 0.28298238751885946, 0.8534249071579686, 0.8695037280515718, 0.5737358263046501, 0.789017819921368, 0.8584274294981925, 0.33599690379890373, -0.09324426998833109, 0.8638970841941732, 0.8704110921600798, 0.6208100616153497, 0.6695871352086321, 0.7627779499040096},
    {0.7100712008729659, 0.6968085491594934, 0.7296033607703026, 0.5768220700068273, 0.9764152446670398, 0.7591782844745183, 0.6766531753878872, 0.7269380915552273, 0.4098090968666228, 0.689581047203186, 0.6953274027671248, 0.5816288601988877, 0.7500176714993577, 0.8530419264796737, -0.15909461283785722, 0.7159754233236143, 0.8336556505721882, 0.5758262037655528, 0.5653183147312426, 0.8938233883685355, 0.989141296363535, 0.6761153709717428, 1.104961908976442, 0.641137322535499, 0.8986015509346645, 0.6071309549888898, -0.4137926506246605, 0.7845554953188733, 0.7990749305335464, 0.8663144539242744, 0.7532157213298979, 0.7783583244683503},
    {0.7032634644297769, 0.7355633081229946, 0.97584718329806, 0.6671248474456734, 0.8078150802448408, 0.9872691895092848, 0.685076262161428, 0.885438093780782, 0.5451502059060329, 0.4458438989684241, 0.8732128323208848, 0.8832472188475913, 0.4312845070689127, 0.9699556888210723, -0.06239872942607484, 0.7138946104486164, 0.949917484322372, 0.4979851347550941, 0.8031328417978799, 0.3603453602226307, 0.7572397216575053, 0.7372970936563531, 0.6799642649680959, 0.6610801890923733, 0.5898306416493905, 0.619749211772731, 0.02744771524256656, 0.8226575291273658, 1.1732347474740086, 0.8023549078248244, 0.8262226355132173, 0.6621670313787135},
    {0.6687673287558494, 0.49894920677016424, 0.6505872668079422, 0.954708002510702, 0.7574794509937024, 0.8558620517343599, 0.8666157278545575, 1.1082756248584833, 0.5789620928287201, 0.508712595600407, 0.9792733777029913, 0.7248132393439197, 1.0930783078824762, 0.49273255554073764, -0.07105620875024397, 0.6985793433883999, 0.7834334875598216, 0.6126148373837197, 1.140552076541177, 0.6294228151585981, 0.8561223762912553, 0.6520950110263102, 1.0003741607161336, 0.5126609816106523, 0.5031389269927659, 0.6654516040946806, 0.12253230250897834, 0.9296518719541033, 0.5513399620806304, 0.7624157025069336, 0.8192134487326793, 1.1343077062641231},
    {0.2656685479322703, 0.6889887144535707, 1.0131866374350467, 0.49633251146558544, 0.828880323510618, 0.7282298798711783, 0.8976001493243504, 0.6554519460500191, 0.6512259479930155, 0.6638178264097929, 0.24948245067064012, 0.7838751579129831, 0.6104849481801344, 0.6604405523205412, -0.5201589230823963, 0.8171379622994143, 0.8433228914579225, 0.6646086845114365, 0.6847323471127605, 0.6046729949254216, 0.8655671183625094, 0.8110703384492405, 0.8189367778235905, 1.0229174481769792, 0.7121845268545189, 0.7866663548767691, 0.30989549786677556, 1.0053943280384152, 0.7337081624550681, 0.708990133530373, 0.6800248206498651, 0.6691806942551132},
    {0.15548790044694055, 1.0524408729700212, 0.6674198576044728, 0.6852564778983746, 0.9710307063974825, 0.8270314211184142, 0.7635855811433906, 1.0035996724356997, 0.8098938137054612, 1.2655130593910933, 0.5109689949856626, 0.7684884623179814, 0.48700582610960075, 0.788818117828706, -0.02470657533965297, 0.7806427576165272, 0.7873799969573593, 0.68285056843597, 0.970129572963391, 0.6241210431484536, 1.04613137809636, 0.5257407630710684, 0.7287803602667046, 0.8538713076311351, 0.8092854803651781, 0.7662695853671604, 0.03149957124416142, 0.5310736799113174, 0.7962338866166827, 0.8201883571577806, 0.7919554165128053, 0.7540803394438185},
    {0.7410831163748395, 0.7961675365931291, 0.5182824748992017, 1.0628481658483424, 0.3769853835079715, 0.6692551018700514, 0.42795356702676113, 0.8348301143295868, 0.8084181813857292, 1.0159669223468, 0.3827172255613146, 0.6418270360514802, 0.5148970596268458, 0.8229301936833768, 0.05904739824253221, 0.8227574940854008, 0.7509823689775582, 0.7075555316162666, 0.8047637744640758, 0.40381755502006234, 1.113040379717648, 0.5255781887758948, 0.6122964239691594, 0.7732726795348582, 0.7983469082719618, 0.7696886145383015, 0.0014411030114530109, 0.6762548195733337, 1.015137364009318, 0.8175022574797353, 0.9346942498172063, 0.9250122162320259},
    {0.6599551508692432, 0.7611401926179436, 0.8888054635615352, 0.634065383929522, 0.7558672754375135, 1.030491141974184, 1.0693831687807358, 0.8340944648091825, 0.5827349925629667, 0.9782843184031824, 0.8070255797684796, 0.5633600183661489, 0.6922356351314431, 0.6567691709873439, -0.049255073981692994, 0.7417667181595584, 1.0008628367710284, 0.6247369871854095, 0.7169091968231179, 0.5513585892199351, 0.8612951432651448, 0.8409643029117712, 0.8387161986158086, 0.8288857823357679, 0.6212117244238095, 0.9001630092413205, -0.305916608943157, 0.869658333983844, 0.6381066741290928, 0.5621362359824844, 0.663477725356983, 0.9128642824746378},
    {0.6153784779338385, 0.7474995367709579, 0.9437666429223139, 0.7383926536268396, 0.8376350105617529, 0.8479827611867793, 1.0169137419598275, 1.0600259619347983, 0.6686784791621039, 0.6649618563880142, 0.6905397171516365, 0.7005774953581172, 0.6077082795632134, 0.6141961494909691, 0.0884797771153602, 0.9050035356001987, 0.6122943358862322, 0.5130365135353818, 0.8438951064099212, 0.32095338030041287, 0.7848751408533612, 0.8836106157433727, 0.6061869429133313, 0.9511285155645738, 0.5689257225494366, 0.9222150785122696, 0.011522054613591336, 0.988732366959093, 0.7844850203443203, 0.7218954205753925, 0.48546118059527227, 0.9354443465754564},
    {0.5082777326284784, 0.6708179816379356, 0.8156823377687721, 0.6536451807829649, 0.8859225457215125, 0.9439852556202993, 0.6024525779937558, 0.7169345745363466, 0.6335432954808872, 0.996501992809467, 0.8828977595615335, 0.6329874899923428, 0.7767451435828868, 0.7257750449125006, 0.11502225866417423, 0.8349802260809235, 0.9290681418980204, 0.6600529162105103, 1.000092140925338, 0.31145661870515845, 0.8030832944106948, 1.007920760615629, 0.9304462291880418, 0.8264271247414311, 1.1504390122924542, 0.7497540519108697, -0.16755806096479184, 0.7182852001691425, 0.8712831331536203, 0.6744886442681346, 0.8257125055916841, 0.9277175422421714},
    {0.5151427098492568, 0.4460527998829715, 0.5409261543560634, 0.693530178547259, 0.7572899833738067, 0.7237152806690926, 0.9130071526569529, 0.7593078157816786, 0.5580614032608633, 0.9635023375135386, 0.6766899547916477, 1.0542445725054825, 0.9977921745597923, 0.5479322969266082, 0.15165782220247503, 0.7922449379840449, 0.7138285560875478, 0.6071299453539309, 0.7622013283524854, 0.7133827174254075, 0.9394330683554822, 0.8130483507433454, 0.9036356013525423, 0.5829369471290582, 0.8998773580980535, 0.5347321916042498, 0.04477971310613823, 0.8643497393776844, 0.7587122683935963, 0.7109632184016865, 0.6975752967255884, 0.9392157314928987},
    {0.729040243163959, 0.7324736748856338, 1.1952001758393729, 0.4860642287511809, 0.9934884098976439, 0.66233767465881, 0.6854985554018427, 0.7726916744974406, 0.5787649055726588, 0.6825614139718441, 0.9329051446491601, 0.7934687095340869, 0.7903927436186892, 0.665581761198932, 0.11767633859333484, 0.6441140257319441, 1.0064694420076483, 0.6362080726910376, 1.0726340044208191, 0.5654215943462396, 0.820780209185249, 0.7356403227186048, 0.5069902506620918, 0.8790968578276463, 0.5656333337571986, 0.8317969342578907, -0.12567104439625712, 0.9080365118697775, 0.805148676253865, 0.6844195238310398, 0.45162686122941015, 0.9641955850657467}
};

static const float b2[32] = {0.5290342129002293, 0.6961647640689371, 0.7216793086729144, 0.692275285432585, 0.7780949572839971, 0.7426349816276971, 0.7585752685740872, 0.7911020763464959, 0.6459984712871771, 0.7604550966274577, 0.7531652365805683, 0.6697307156283508, 0.6789319143773787, 0.7644861749203519, -0.13260075556672204, 0.776755078909552, 0.7729669659145075, 0.6859756791219488, 0.7662561088668867, 0.460499965960503, 0.7698225767343354, 0.7309526319500569, 0.7575874458875796, 0.7627976134352425, 0.7919684696862067, 0.6015969220946525, -0.1135558719118222, 0.7770341672048927, 0.7734668165594603, 0.7213051744084826, 0.7879018365073945, 0.7642285739823711};

static const float w3[32][16] = {
    {0.7272491631101278, 0.27925239130004176, 1.1197645727286871, -0.235327803907948, 0.527787894381161, -0.031172821386012784, -0.2194576329635073, 0.7474434501777524, 1.0111365112889177, 0.015592429177390177, 0.6758628545021313, 0.2814158138307561, 0.5377041588314859, 0.9936117828007774, 0.6927248977147684, 0.4909941236802041},
    {0.4971356273325708, -0.40135423159673733, 0.46980770380906794, 0.11735463658587537, 0.8909079767482713, -0.009140155225439501, 0.1392267562831732, 1.033627173518579, 1.2637880845490688, -0.5991960296383303, 0.6081542360655352, 1.029115087523529, 0.7623758291982317, 0.43185525127709895, 0.5485927623142459, -0.04190425561130146},
    {0.7781943230970146, -0.30954242172663293, 0.7896901846126265, 0.07502034603079619, 0.7619079832119429, 0.14465301332340857, -0.19988705567429696, 1.2334928952416955, 0.8817498827561819, -0.10313665126535253, 0.7153899333740736, 1.1946765631530905, 0.42316641698897595, 0.9212071807359821, 0.7409246151636147, -0.10595226055178775},
    {0.3738624048206854, 0.04574103921645201, 0.5903682814570572, -0.09009249073583528, 0.9092250312417264, -0.2914606544037339, -0.23433161788245502, 1.1921317523577195, 0.8159936456131487, -0.4870450027437323, 0.6002156482245953, 1.2539658515494445, 0.9199858564972375, 0.5674773007129393, 0.7209122539217496, -0.3583904848846891},
    {0.7491639260182072, 0.06542068399642466, 0.7185864376705992, 0.07879864600876245, 0.7358666075392412, -0.04132446366233679, 0.25329662823847476, 0.8466181789747943, 0.7410248444612957, -0.22432861587255373, 0.8378107736653385, 1.1669567770135718, 0.8781532128756198, 0.9405293137661677, 0.8835059457670629, 0.08899192036661892},
    {0.8497340738262827, 0.11269916606122303, 0.758943258979979, -0.23100392371706102, 1.0036449005817147, -0.09731091690151936, 0.03720016782809558, 0.9201109814275357, 0.6137695776687138, 0.25392229156670926, 1.2496174265998898, 0.9905217953382031, 1.0726516507504582, 1.1897558723273958, 0.49567213229320767, 0.019102614786245045},
    {0.794124496201778, 0.07780823931426015, 0.769169630563425, -0.48588424358716137, 0.93927139407171, 0.029285940208474026, 0.12755594349996519, 1.0373931700732009, 1.570830483695003, -0.6031287642423772, 1.0624541202108497, 0.8739855577996753, 1.1877424622637105, 0.8980408572872149, 0.627842184746479, 0.1318944643847347},
    {0.4958662858311075, 0.032152494737876486, 1.1176638133728225, -0.09823958702406858, 0.602085619281876, -0.4398684932675548, -0.046112647237696834, 0.7984303394547655, 1.2333843334759635, -0.10206231250248843, 1.3179417689732515, 0.9239643500997642, 0.9535495327287007, 0.9239256993899474, 0.5144138086818111, -0.20272966866155545},
    {0.4651948704461631, -0.2460042442839229, 0.4545586597631578, 0.32597507206648424, 0.9570278228548486, 0.08552317323276046, 0.14514016436659488, 0.7319806597904822, 0.5583547237744437, -0.33522683850786017, 0.981660382996101, 0.9542495575791362, 0.551479940938757, 0.28071617198165727, 0.9394249857248205, 0.3204743298098371},
    {0.705533589832298, -0.4298589089365925, 0.7692517710492479, 0.01739977870189955, 0.6258356460252428, -0.43661637089840694, 0.0022628356666477903, 0.21556854453794014, 1.0944087317048232, -0.15479669714495492, 1.2860563721787104, 1.0415099288158722, 0.5944730462170147, 0.6031816483359098, 0.7830635254794093, 0.1855317099894397},
    {0.8568601321407728, 0.1271783199925601, 1.4726503373257138, -0.33313643277814914, 1.4175447848833918, 0.28144829865423865, 0.44711798350207743, 0.7250052623850879, 0.45579177351627415, 0.26133404530148785, 1.0346190043933123, 1.2571556741588272, 1.1955439741770708, 0.8251589529636412, 0.8506707669323847, 0.04714934252008567},
    {0.9138949084554436, 0.28172846583064454, 1.2301387489514202, 0.08619066862381068, 0.6816012652687017, -0.18382507460461545, -0.2025048457348069, 0.4922393793994109, 0.300746528269979, 0.10983838225130968, 1.0945614605058949, 0.9239058074527753, 0.83723095409319, 0.6334156732084643, 0.8825518299840011, -0.13778021673681415},
    {0.33587107681407274, -0.17690072901783715, 0.8483088455313554, -0.39996678922943674, 0.7323098129554755, 0.08296301949390224, -0.42059486910292215, 0.7693011454913268, 1.1299065427545756, 0.04508089927765072, 0.5321093357672445, 1.4216631738849923, 0.57550232667177, 0.9397154290226672, 0.677094621732508, 0.14932664747526767},
    {1.091731745004904, 0.15303234868556922, 0.831101886692404, -0.0013659260562748116, 0.8438003375090729, -0.15543033100495326, -0.07623527121170928, 0.9501873371629145, 0.9918164004111714, -0.3091085079972648, 0.661934025293736, 0.9753326705626184, 1.0873989491509495, 1.031372957803688, 0.9455324266939884, -0.032063727022553626},
    {-0.29424064094256747, 0.7368539530513069, 0.22440491932400833, -0.01938050924552159, -0.1387306276169305, -0.1182872180275046, -0.012729895454421315, 0.2685463070916598, -0.41028098449069894, -0.13336853710587906, -0.1328757993741486, 0.18652282868914144, -0.07393751116721263, 0.027563996455274783, -0.2579160703920615, 0.1599042194339235},
    {0.8911738781181936, -0.2940468503955018, 0.7777113643560543, -0.3620639894513551, 0.8014867499467154, -0.23237305527131485, -0.16058172003796142, 0.9918100850213811, 1.1044587022701333, -0.23814057565591462, 0.7905027093945082, 1.0676709736460153, 1.0016985427691805, 0.5344988135210733, -0.19576648514434092, -0.048873682351612394},
    {1.2800697137853656, -0.17559177796901504, 0.844402400659811, -0.007262470507326652, 1.1633333670967745, -0.034652599068083614, -0.32180304608536203, 0.891741114052546, 0.6791219231279965, -0.12651662007003792, 0.8017969228937677, 0.7373766819659866, 0.7419371966666108, 0.6978674505330905, 0.34472926479895455, -0.26619795014545145},
    {0.6823273457167329, -0.038328149536730916, 1.0677100143031586, -0.08659039206496304, 0.5335977865643929, -0.14876493198034904, 0.17243989713855767, 1.0066184743812325, 0.6891415252419868, -0.23557295980910922, 0.739743408509684, 0.6171486789112578, 1.2187582605951552, 0.3796994821201527, 0.6917033667629604, -0.17637414218529515},
    {1.014148162604209, -0.3167191524096458, 0.7622666759336906, 0.06474193306053623, 0.8836823827948304, -0.0951603526207626, -0.14052451030222696, 0.6921131883924472, 0.902472271647337, -0.24040078533481507, 0.8513609546606784, 0.802795299276582, 0.8808302906058989, 0.4777367859214323, 0.5303575395898353, -0.5808391512689006},
    {0.8399131196769432, -0.07736238261209774, 0.566918256185189, 0.0013450889885777252, 0.4598039738642115, -0.40712973648618767, 0.15831065336294056, 0.6835295159973779, 0.6993438780477047, 0.10067081384027071, 0.6494840105312989, 0.22510491233572463, 0.45278000835443044, 0.9575839739590236, 0.4850241071836805, 0.2123860396034725},
    {0.8827266398969557, -0.40462561809477265, 1.1004091248227486, -0.08848829495904577, 1.158403080005796, -0.18888409579248772, -0.4072749060727571, 0.8413061192077934, 0.6359008316800782, 0.3465392723223513, 1.0651801646757997, 1.0262892960970211, 0.8189091087071652, 0.9814174030634365, 0.3754893041946478, 0.1256251345964142},
    {0.3459877939314334, -0.2969145532399131, 1.1303981873937408, 0.22486837337106808, 1.0390506894958424, 0.0016571936044449131, 0.31251273826417003, 0.3786366440872808, 1.0219921554786409, 0.19986409598946753, 0.6480891544996696, 1.1015536816890321, 1.240553412687008, 0.9649937861094916, 0.3745025699054211, -0.16182554230730023},
    {1.204499367333559, 0.1988495996652906, 0.7329815035941037, 0.1062084229900613, 0.8876871509977574, -0.26782381926103116, -0.19973135647285847, 0.603314552913625, 1.0363645633061425, -0.5191297222179586, 0.9637175332393318, 0.6982456106231005, 1.029932422130803, 0.8690359120841842, 0.9674299491836943, -0.015014782586996712},
    {0.9868950976977585, -0.19308254911773584, 1.032634465622361, -0.24359808039869643, 1.0544206996178673, 0.030439655006957486, 0.19550823411546223, 0.7786279477808657, 1.1523470801122269, 0.3126889033003102, 1.0488294430576566, 0.9675012737714442, 1.2677997325773709, 0.5279040972742275, 0.7289186335831686, -0.0836711977201149},
    {0.791846596906087, 0.034746206414234454, 1.0222207730232935, 0.059942102983953034, 1.1335458785824, -0.17236857451143406, 0.17613533778701748, 0.6689363628808589, 0.8385003038744294, -0.255941491285049, 1.1033127870112474, 0.584434278955386, 1.0000709514732964, 1.0105467819590925, 0.7938278732452929, 0.0628819188987257},
    {0.4578011263185346, 0.07739178824900718, 1.064151384348677, -0.045256336532698595, 0.531582326760362, -0.04321612968153899, -0.13013795907804593, 1.25553298352473, 1.1394820253507907, -0.09099631322191004, 0.5206586909851038, 0.714163155728903, 0.755627553166222, 0.9854946414262736, 0.6400063580332137, -0.2821321590734917},
    {-0.16291754883375759, -0.22201004841382832, -0.1502491037928266, 0.12006891311924492, 0.1947488790243722, 0.4097774978453968, -0.06514136949128707, -0.17431861733301832, -0.08363590397194777, -0.28492419292731636, -0.22408836592023484, -0.1674633305706884, 0.131839889815208, -0.47501529842020884, -0.3786279848986718, 0.023703780821699882},
    {0.9995606291645466, -0.07705277163929372, 0.8266662428476543, 0.23341985017074382, 0.9708888961021612, -0.19968036836057157, -0.11323667861334863, 0.5970445181292141, 0.8366766373456705, 0.09988177718928982, 1.1313440675521969, 1.4016215241258965, 0.8764378980818012, 0.7822152114781128, 0.800490277042951, -0.08119935255306089},
    {1.0304393461036665, -0.047540679113984505, 0.8176298901484239, -0.3615441525412264, 1.120572906984481, -0.13258557928520323, -0.23991052554825723, 0.8997661512223702, 0.8559197249484927, 0.01627285906628378, 1.02269055657975, 0.5313297199491148, 0.8713087937271032, 0.9583984685635085, 0.9992413427339613, 0.31624390510672806},
    {0.49969030234559325, 0.054479707113127274, 0.5578841499909781, -0.08601780190789278, 0.763772432308873, 0.5407443285184668, -0.011279775170262836, 0.6834476584951258, 0.5528934031971788, -0.19297919363802704, 0.6735635736337197, 0.9512530516521739, 1.4869137676877056, 1.2998042920891582, 0.8569077815825705, -0.4480328692372734},
    {1.3674056460784092, 0.08801639399457184, 0.8315534037168499, -0.08498189752733575, 1.130570893652829, 0.19411468059829504, -0.5505955610781798, 0.8522255342507047, 0.4716459385727645, -0.7734059046407759, 0.9590657311319267, 0.5569594243436885, 0.9786713889569577, 0.7753468399546658, 0.4028250656492749, -0.2650184308126671},
    {0.9502665649262649, -0.09215030959635334, 0.6753577247499992, -0.2121742088174429, 0.8606788953832908, -0.1474431230807325, 0.005137048585848366, 1.0728444648782085, 1.1174622349331615, 0.13210467383696367, 0.8430194999557011, 0.9218825327499574, 0.9219725916163137, 0.9908559624072353, 0.6236671095915712, 0.251931218339774}
};

static const float b3[16] = {0.648808277817559, -0.03192909220872544, 0.5888177556940176, -0.03370129835347163, 0.6182909604812302, -0.032711343890949485, -0.0063632265475222815, 0.5904896262240582, 0.5836397303317445, -0.05677197225381851, 0.5582932000899584, 0.588717367242851, 0.5500997019164802, 0.6289194242117468, 0.38914352483394743, -0.03264858284808634};

static const float w4[16][12] = {
    {-0.14699846623930418, -1.5930990820558388, -0.5793716152617715, -0.7764407642577666, -1.0057811151166378, -0.640338690455859, -0.7526324228071299, -0.9091814078349639, -0.5785946874412892, -0.8479211290917948, -1.0364925665224443, -1.0027625197353374},
    {0.10463969402262355, 0.13839049665265224, 0.8519332674408442, -0.10880164933094012, -0.12039365912884532, 0.30604931129253027, 0.12190763926780111, -0.41430310886996824, 0.20289766448794358, -0.2556701714509206, -0.003413363384602624, -0.7866301922416066},
    {-0.7610738490205654, -0.347504224318933, -0.7087457309471994, -0.28874414541413923, -0.6594743069046011, -0.6918411139673565, -0.9573743572560095, -0.40869099938333175, -1.288719899873911, -0.8441480109587992, -1.0418365797276599, -0.5950798060351008},
    {0.11473092009942476, -0.045749013398450535, -0.03720055657501107, 0.022523439482790664, -0.19417610195802695, 0.10295216990299923, -0.23621775246317547, 0.16230720595988626, -0.0926631455894911, -0.05710069317827616, 0.11557789059970029, -0.4469261904869357},
    {-0.9795371755424983, -0.19880295511583443, -0.8386248460604195, -1.3765596194592884, -0.4349330787795384, -0.5699235952841735, -0.7630735099102494, -1.0943149430976988, -0.6978940117993843, -0.3485750255171464, -0.6110315861084754, -0.5894912313917137},
    {0.3972957587560777, -0.029647002256102926, -0.3204431684447418, 0.34758695789397476, 0.018002983600428107, 0.20307595039578746, 0.2924148754333894, -0.500763437720987, -0.08532502795137166, 0.27379393770612487, -0.3552360230725446, 0.31415068103183164},
    {0.3186887316153218, 0.10403580345999162, 0.06165301637931643, 0.2767043963599232, 0.2716978161411172, 0.12246311615273382, -0.33208745772047793, -0.2842191570708904, -0.025799756467820324, 0.3382328447978852, 0.5073155554861112, -0.23683138372012347},
    {-1.2178181902011747, -0.5781887549949796, -0.5926143832244929, -0.6705217742100623, -0.1357420975548743, -0.5858097605063175, -0.8676466236045413, -0.9346598540401464, -0.40821722555629353, -1.1901284380990622, -0.9707504663488226, -0.53570595310015},
    {-0.7411357639123773, -0.7671902971741267, -1.059368723524319, -1.3856924190736992, -1.3280450793084255, -0.743861087776462, -0.6906357703229324, -0.6133450607393458, -1.0281200640330432, -0.24693102276072176, -0.9290561275590149, -0.3086020587424278},
    {-0.03347528591711771, 0.06335850023652614, 0.38687524958993036, -0.5954761779010153, 0.08637619191592687, 0.17622340423739, 0.15883096440284453, 0.3266925260128472, 0.3143291406279948, -0.28888571759133364, 0.08323263942463585, 0.1462813609708697},
    {-0.9221655807097568, -0.8082815451560779, -0.8910369468756937, -1.0368168929240773, -0.5706811743103037, -0.9240238288255916, -0.7300180293476297, -0.6366355255579916, -0.7629010413092746, -0.9215683250834795, -1.0147387558627083, -0.7457594722975363},
    {-0.9423634165042756, -1.1818663932942943, -0.7309552096739365, -0.5873563544033974, -0.7814888479374396, -1.0097590978631032, -0.5312246718809157, -0.6702844097318735, -0.8927734756304168, -0.3073462687181553, -0.47873098226762495, -1.3632133889948017},
    {-0.5669980928648702, -0.9018125090136314, -0.4693723521121546, -0.45219533305264975, -0.8088694967293177, -0.8716972398108759, -0.3729455586477284, -0.9641121849075628, -0.5611338569622494, -1.1182486596014962, -0.06957778620074198, -1.1604241204115522},
    {-0.7669693458638929, -0.9874673216414143, -0.7622246016787889, -0.5871284254718402, -0.6612654090273665, -0.36446006637997574, -1.345136735886657, -0.7457160462773013, -0.854880265070663, -1.2844162233721657, -0.6127895719144165, -0.665484196437003},
    {-0.1386425873687539, 0.032773006590691524, -0.7989911607632383, -0.15328473104689186, -1.0702462348043895, -0.9840369616238125, -0.4216841296608163, -0.429601678549941, -0.23813849011420204, -0.34074093012782947, -0.7520195235577454, -0.37199066696665406},
    {0.07848634846712002, 0.04856917704554113, 0.0129406528414479, 0.12646195059295204, -0.31822317749191703, -0.041136384509934114, 0.22224798291273162, -0.02843063146961235, 0.289640344049631, 0.006264279796684581, -0.4648613311102687, 0.13036959590731612}
};

static const float b4[12] = {-0.2238882845207893, -0.3308893893596551, -0.2872219620454381, -0.3465961837825649, -0.22619891204566395, -0.3242289789625633, -0.2338489824440292, -0.2302002344449168, -0.3026715804998942, -0.20446232651940557, -0.17770016474313496, -0.273837133306853};

    // Input Layer 
    float z1[64];
    for (int i = 0; i < 64; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[32];
    for (int i = 0; i < 32; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 64; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Hidden Layers 
    float z3[16];
    for (int i = 0; i < 16; i++)
    {
        z3[i] = b3[i];
        for (int j = 0; j < 32; j++)
        {
            z3[i] += z2[j] * w3[j][i];
        }
        z3[i] = relu(z3[i]);
    }

    // Output Layer
    float z4[12];
    for (int k = 0; k < 12; k++)
    {
        z4[k] = b4[k];
        for (int j = 0; j < 16; j++)
        {
            z4[k] += z3[j] * w4[j][k];
        }
    }
    softmax(z4, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
