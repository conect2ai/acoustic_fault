#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][16] = {
    {-2.2402799918638405, 1.7977165668423762, 1.8268347155520057, 1.3933868766499362, 1.0151836536476304, -0.7326536312405745, 0.8541988192007497, 1.5168016739871784, 1.9609366544795348, 1.2833132121147008, -0.14924196917796656, 1.3096599445917978, -2.134986179115635, 1.8075731644376785, 0.3007356149457841, 1.3480112868539558},
    {0.6548193492478618, -0.6001735736331748, -0.8925674287383114, 0.37478885781965504, -1.0477883511456465, -0.037826088482302275, -0.9401050709073945, -0.9245470615117377, -0.8485155690642503, -0.7736912701488701, -0.4197160258695633, -1.9337427710986683, 1.7887731617517733, -1.6706160647103916, 0.2141319994914473, 0.6242349139510361},
    {-0.25880162667852297, -1.4966592765161173, -0.3952810025129688, 0.24905104307166706, -0.8182791023182759, -0.689686149675513, -1.7808425145937796, -1.2643534127761484, -1.4902615260095864, 1.556584407560493, 0.5554640883772104, -0.5801580657907964, 1.1512026776961628, -0.8851534533961325, 0.10279607571941364, 0.5019807560064538},
    {0.2398246230315023, -1.2605887534045317, 0.25706956443164397, -0.015181282864758621, -1.1136594719805604, 0.8254665761108356, -1.6390310261892695, -1.715945590096644, -0.08988268065070502, 0.5532266109269499, -0.3998078613600058, 0.5029019931596872, -1.1503411034859243, -0.1837278696313851, 1.0038027216525125, 1.0531293198463307},
    {-0.40486985395827274, -1.9239548548265466, -0.6596127240036765, -1.482217375802805, -1.6844078259308155, -0.2873103061015908, -0.6840026095256256, -2.430752877350388, -1.7056743649693422, 0.32894209289310067, -0.06293768749039946, -1.0207942023068308, 0.13695566227265932, -0.45429497499449806, -0.7938844618063573, 1.130308152868135},
    {-0.17861371942585305, -0.5611939990911083, 0.4812800594653769, 0.3621711675868424, 0.015513696634503369, 1.7885463221122602, -0.4549760254412148, -0.9824330062386862, -0.07630161235385138, 1.4734001874408127, 0.5300427665823954, -0.7054851321730434, 1.1801945988781137, 0.529593964674866, -0.49413303174989215, 0.45102724411361655},
    {0.28651806730594886, -0.6093594296262199, 0.7241551059417348, 0.5055593915116886, 0.24585643721500577, 1.7721712100643159, -0.7466489975368072, -0.6128263154083092, -0.5783400482054541, 0.9720546549357341, 0.5632503141843964, -0.715199600603029, -0.01614001957169946, 0.5861490224656963, 0.06556267863107886, 0.8942504766679206},
    {-0.3435872793540936, -0.892615508248946, 0.08156946813768381, -1.2903134033209667, -1.2359034649962728, -0.27878754435555764, -0.7566133993480293, -1.1589531887886044, -1.2210013723462083, -0.40414800772861437, -1.0114021428738773, -1.8616981370729495, 0.7648343191745446, -1.0883877096585444, 0.022161559747977663, 0.8702860845294877},
    {-0.11054174317597963, -0.7063871739205408, 0.5975822803416548, 0.2137221247920238, -1.375781253236033, 0.07775072109109463, -1.1513769806728453, -0.9272779891523129, -1.256062681438603, -0.15000111179264877, -0.9657293230626948, -0.33925589659690547, 0.242578507882301, -1.0056409679567178, 0.822394165037886, 1.809420078665811},
    {0.7565069770118682, 0.8745117429752195, -0.1525990423131135, 0.9782243077887842, 0.5836318999467438, 0.9006120624103848, 1.3753857244266456, 0.47698835304773296, 0.7114084103937179, -0.9329064331849057, -0.5650317814349148, -0.8404715067673271, 0.1841424429412858, -0.48386046647098646, 0.3237558962789676, -0.3237246035322174},
    {-0.272726801428059, -0.9873745064353489, -0.7089171035291706, -1.3175084926821035, -0.2778687050532553, 0.3466068755380744, -0.056524098984614884, -0.7596667228088698, -0.1557663620365371, -0.5682645040646822, -0.021207918938054408, -1.678971027175842, -0.7257520847496924, -1.1759121914957025, -0.33615865013210927, -0.06472990842358149},
    {0.023851363872281574, -0.501509682279171, -0.7053886397828516, 1.487738540054566, -0.772899735113041, 0.16367581390777297, -0.483881622508898, -0.25124125778882295, 0.43926631653103104, 0.7830500392535266, -0.4302972089159781, 0.48963825906791075, 0.3331175936693197, -0.2688257607778032, 0.4172958326436167, 0.03949352934787046},
    {-0.10858016663511878, -0.08149608403480038, -0.7752488147232738, -0.6445019358772036, 0.35979523824190585, 0.2334083692756467, -0.05886513328929205, 1.141186407899599, -1.43622915984743, -0.07270218297912229, 0.9120658215569484, -1.5908816809485797, 0.9292040603927204, -1.4766114204425933, 0.0039220479754628074, -0.07208409122505921},
    {0.8750329332644642, -0.87302720172294, 0.5022968661205339, 0.48577843337781124, 0.43371624226166783, 1.3148503472003836, -1.6972364387606254, -0.6978790759355386, 1.4489107701534711, -0.4613903154733487, -0.6908497166600612, 0.7201160710999521, -0.5587631969672916, 0.49662407524958896, -0.213239455935287, -0.5137733311224807},
    {-1.1246283889728546, 0.42314180284379255, 1.8239972282496402, 0.31192531483861885, 0.8847461882754083, 1.0014369801080818, -1.0475905731056525, 1.0955285831723343, 1.4098633747145168, 1.2927192582654354, 0.6699958957971599, 1.7638720596089759, -0.611438131105326, 1.1504485594198837, -0.8002100640822974, -0.6912205433243873},
    {0.18198032013039367, 0.8058863762091681, 1.1570237843765325, 0.5718576708891306, 1.320830474937065, 1.0799573888195217, -0.22415042384337788, 2.1265313577341396, 0.4385721035407775, 0.11613203454848318, 0.7374768426236572, 0.8523023526076376, 0.7015078281426878, -0.3763516546917807, -0.21721233414796262, -0.6704463415090096},
    {-0.010571512037629523, -0.34232489706142094, 1.0707763980469953, 0.399743566316285, 0.7139178551491177, 1.265477957350341, -1.3046521685708463, -0.8120760863569578, 0.8111074751611193, -0.24308287187526162, 0.2109239199404985, 0.3106752002665383, -0.6211068595701192, 0.45974308485271975, -0.25803229810239164, -0.007331019344068074},
    {-0.0983416237111109, -1.084963077427366, 0.15004066108720063, 0.6936470616451983, 0.6098173420901891, 1.043455360249977, -0.5653665193509447, -0.43202561529992994, 0.177057902662974, 0.12108280443082237, -0.023498742014183237, 0.00901295840367258, -0.3562223427948141, 0.27482597342305803, 0.05979302435498476, 0.2351651990043215},
    {-0.34474376389716, -0.78722602514059, 0.15809196763677544, -0.1459267871633501, -0.24648051143571034, -0.6693391427867214, -0.8807570480948101, -0.8121896878651987, -1.0990749231120798, -0.506440800130246, -0.03192456896471764, 0.0621310480959263, 0.44743436870766384, -0.19440932957081722, 0.07993427579812286, 0.2727827288064453},
    {-0.36579041141864954, 0.6219024005029797, 0.957253887276774, 0.6189945881583643, 1.401672792043747, -0.020634257701199966, -0.06301110166247326, 0.23491736202538502, 1.1292785947518373, 0.29719084671675094, 0.1541755238615768, -0.10443829687041566, -0.3580412043001441, 0.5501704541856882, 0.4864405697399969, -0.1894941113138912},
    {-0.4471381612180689, -0.6636734078242746, 0.6242022586008985, -0.8849576688008104, 0.15828116930177244, -0.37996276660867073, -1.3455491215690532, -0.8621277470472737, 0.17217793585156072, -0.01784340913407319, -0.2820262710787655, 0.5605309406289847, -0.7154778266975971, -0.09586084119490158, 0.05749301939129044, -0.5163400376266969},
    {0.3932601365607342, -0.29108032992207555, 0.658856402606975, -0.5745753214927293, 1.2699420480310148, 0.7873112935578549, 0.1799818825067988, 0.2522600128708428, 1.622861830219607, -0.7381615348668799, -0.5427698476845906, 1.0290060875046076, -1.258574681007057, 1.340299518943823, 0.02771923205743707, -1.0496307079115204},
    {0.23672634540620424, -0.3408366180800195, 0.3252224629648875, -0.12807433317548655, 1.4415660496865175, -0.1563548362971337, -1.1697224211229444, 0.4640496893411863, 0.7120692799143261, 0.4448266089479967, -0.21272774083644314, 1.4621027432537583, -0.19357990504691966, 0.48592181222809855, -0.1309259510282534, -1.1111444030433626},
    {0.6100658639199289, -0.4876002350564808, -0.3963955705352257, -0.9280167391783147, 0.7229159283373446, -0.48298394200060907, 0.8384365831136796, -0.4883777388236478, 1.0249776929784384, -0.9870417516414531, -0.5535918094974964, 0.2925741350272677, -0.09574707970651856, 0.8372247653979116, -0.0685162669441854, -0.8497982808782371},
    {-0.34265384013362277, -0.9128680428809426, 0.10277935358240042, 0.15125129618108998, 0.9658036867838853, -0.5791489809191628, -0.15130736920181953, -0.8413058228023329, 1.2367391516996151, -0.1593792274742597, -0.3222581073166714, 0.5095582899017163, -0.8283803929688246, 1.037682303384249, -0.4093144796062885, -0.309379903172367},
    {0.10652825245341986, -0.466245397503702, -0.41755267373850125, 0.2059669526268559, 0.5717056202063076, -1.402838198127998, -0.09230791917915496, -0.9765041669074814, 0.15712999761990473, -0.3847509880015408, -0.0751318886045309, 1.0193671117656342, -0.9100878119324013, 0.2067676067763398, 0.16653301255406028, -0.41779342504706934},
    {-0.4749221717238095, -0.20784231415874949, -0.7051009611013378, -0.9238367181609295, 1.1092291798368032, -0.16944613302169997, 0.7654322762310074, -0.3948381393633917, 0.8360733350862034, -1.034385572930695, -0.6718965818399419, 1.0012407551253015, -1.4638592178820202, 0.2271116327963939, -0.27194525732191516, -1.0491872894397045},
    {0.05378555264699432, -1.4009835812837954, -0.8424800517400861, -0.6250383358337296, 0.07830892945885701, -1.137451767118334, -0.3184724612851999, -0.938519415022366, -1.1305702077686834, -0.5511995236734203, 0.6913742007933742, -0.4295989408555555, 0.03497344401378906, 0.09809236724683733, -0.2620790144674966, -0.8225286845334429},
    {0.050542921331161554, -0.6698287439835507, -0.4861168764311184, 0.28506003687895537, 0.5799276545658262, 0.46516844005066227, 0.19534285553858763, -1.4293320468762232, 1.2062732325429601, -0.12995183742858527, -0.22532229860817274, 0.6106813369517009, -0.8981465752640049, 0.801188660884489, -0.34000595396818994, -0.8823106532723436},
    {-0.09231299265153961, -1.7085422239754429, -0.7981548981161987, -1.1350069665840732, -1.169451262879713, -0.11752544980641208, -1.151790641719387, -1.6987824938956972, -0.5474213950631645, -0.4087920678527814, -0.23357472652534464, -0.5186450330570449, -0.26069041875148913, -0.22180443451776077, -0.8518550351290315, -0.7567308726614804},
    {-0.7674697310320218, 1.46391555919144, 1.5047379295624113, 1.4273617930959213, 1.6161471773688432, -0.2840356763990274, 1.4049650220569128, 1.5909625024409104, 1.9312351553983436, -0.8978542148168586, 0.7768326815644107, 1.5070414417442313, -0.8792836638192824, 1.8036553380483018, -0.061057904335434975, -0.584840685922987},
    {-0.18772707520086263, 1.4745776292197637, 1.9417905410481093, 1.705020992591727, 1.7505476461617497, -0.9751767599930141, 0.8928829801655892, 1.1225321955279721, 1.6521265199194461, -1.00158590360601, 0.5065770157935003, 1.2869580219707437, -0.6383967386438163, 1.787813717632824, 0.380063870077394, -0.4743574260144858},
    {0.09091370110824043, 1.733629370562249, 1.3643405266562654, 1.6804288553975513, 1.7322822533315467, -0.30423192187358256, 1.029629356060715, 1.6289201051062745, 1.4341572292441496, 0.16620720002828904, 0.7789812552074619, 1.096822272357896, -0.5348372552944491, 1.6986882201592077, -0.018234696100585836, -0.5461104336682705},
    {-0.1665892238789789, 1.660439404537397, 1.2602269180862145, 1.6269564927391627, 1.364075284482947, -0.3119465671359616, 0.9772031129889227, 1.4721143279804958, 1.1167183633501603, -0.45256696647065925, 0.46505161555710683, 1.3838789963373346, -0.004824716408336454, 1.477356435508534, -0.015189561358473843, -0.7798204959971217},
    {-0.4153268263056074, 1.4870572803941737, 1.265926453270034, 1.201054093877372, 1.5561414404567036, -0.11261007128221129, 0.9496129698224433, 1.2543134239711504, 1.1458570660075977, -0.2518666101784689, 0.9521526322451831, 1.2517062390904417, -0.27009188917518484, 1.2631582760250832, 0.02288677137703949, -0.5377832732773887},
    {0.02959985358495847, 0.8227539503191874, 0.5356686363892806, 0.5977431809633514, 1.0546818772279392, -0.022987173151656694, 0.6128273281601152, 0.6937136022561422, 0.9348023040529181, 0.1953015368294951, 0.4898609604625979, 0.3414891213461843, -0.14780049656647665, 0.6910004822985162, -0.1813603878824363, 0.03841029052152697},
    {0.03563239700097587, 0.4638183945943213, 0.0005525963882159436, 0.6516297614014155, 0.6514086374742641, 0.02739974403219199, 0.3982427102063836, 0.35699693104524255, 0.18193129110482353, -0.21188833979804766, 0.5003538158486048, 0.5965282980005473, -0.5590022287158649, 0.4767797925835682, -0.3815033647280172, -0.5203167220597625},
    {0.06213098977841855, 0.5612003155822956, 0.07020718339796578, 0.4175596879086374, 0.32325502141837675, 0.045729215107199316, 0.29113948248785726, 0.6672647676024767, 0.4860414699415706, 0.34699008278970145, 0.5733231805178324, 0.7664439103883053, -0.3268867315118532, 0.8023732215024411, -0.11642619630400598, -0.591356792413294},
    {0.0074734991692719, -0.11203970976800783, 0.5612281075779944, 0.4436535893419623, 0.21609066780243866, -0.4872963748339287, 0.3843264944223681, 0.2985800587600564, 0.21641223293308953, -0.020276730927709728, 0.8836644493777855, 0.5820512946661156, -0.3245854131470575, 0.4012480978389442, -0.002683820526070355, -0.3951739862697834},
    {-0.22328425386571535, -0.47613916066729395, -0.3422565895788096, 0.08138718025732693, -0.3413050163207807, -0.2700281591815105, -0.222194808097873, -0.3507182302891209, -0.20389726228384675, -0.034645389830965344, -0.1090241811418077, -0.13121669749791096, 0.18703588817579786, -0.6274395194121681, -0.052473290096933564, 0.012508464861966391},
    {-0.0949558377792013, -0.05742377593487605, -0.2494576507685497, 0.750799442607187, -0.1303600619453142, 0.19947494309877078, -8.978342457948128e-05, -0.012447841698186198, 0.23023947233231382, -0.14985938207663715, -0.09877089361598258, 0.02735990165283542, -0.032264599764089276, -0.3147454635400106, 0.18246710334570448, -0.0018431570162097495},
    {0.11188870693126156, 0.9817421422359266, 0.7074274109778635, 0.9144082046117473, 0.6106285714158017, 0.036717071865586676, 0.620758650767306, 1.1459718754338333, 0.8294704762809234, 0.5158473558163529, 0.41148372345155115, 0.8091510853965174, -0.16832450695072765, 0.7475782081188699, -0.06937575018762183, -0.49908950884070985},
    {0.027314798328935238, -0.6184980372635548, 0.22786831156683204, 0.7149250952268509, 0.22155912916259704, 0.07911814930757313, -0.22832760102279356, -0.606420415497725, -0.010771210421827245, -0.28542739522559585, -0.8797000224495465, 0.49739995387367386, -0.41384360926031877, 0.4309139978851776, -0.002662276327409689, -0.5010995967318568},
    {-0.006791749988017034, -0.7960415639865012, -0.42807274805658785, -0.5363381432228539, -0.7153049032833805, -0.17698715260423697, -0.48043964543138307, -0.41180637770428663, -0.6594958630431809, -0.14401222670085076, -0.6591867225964442, -0.5268635186660868, -0.512109600917915, -0.41486494303289273, 0.06277127240890275, -0.3493833599831052},
    {-0.2770900995849818, -0.1822875906820477, 0.17863438275570906, 0.3809041648929208, -0.23258310876966648, 0.05381197033456628, -0.05249340180551369, -0.3855362086418365, -0.46105108349914686, 0.42366092762022056, -1.0181506456346805, 0.07286274273010569, -0.07011373754923697, 0.30961422944258643, -0.16695507110094343, 0.05666699640707833},
    {0.2829217007479533, -0.019536466312205625, 0.5099747141621395, 1.194405874647564, 0.7583386178455661, 0.3122028255237375, 0.5936897446324373, -0.014794612334136967, 0.7296420804120048, 0.3832326646279458, -0.1208767797894793, 0.8733877023392055, -0.07314098412147788, 0.40313810612457546, -0.2730976398053795, 0.025479532628150954},
    {0.18080035214114412, -0.09852428686972817, 0.21640672080653275, 0.26995071644392865, -0.016339260946153684, 0.08213877793740491, -0.4269208326384191, -0.3773095037047494, -0.05630646207378913, 0.22481547164478516, 0.13182118452584865, 0.45509072456946553, 0.16786916875235788, 0.19837085964281595, 0.025653080504327748, 0.14237667031178594},
    {-0.00467780351033673, -0.16966334536022593, -0.8683109014511802, -0.8085138045420008, -0.917969741602392, -0.34030060265380935, -0.6799013218947284, -0.7710586459050734, -0.6601530397041686, -0.1134866118580792, -0.5383394671577337, -0.9601521749385352, 0.028499992188869342, -0.9909266994957285, -0.3687621820026623, -0.09228791050172978},
    {0.37218931662078564, 0.6124857647950552, 0.16890486154381013, 0.7350562413298992, 0.11946149729744812, -0.13125309891271267, 0.20761715885177975, 0.041605032343695995, 0.3019304989519748, 0.4358752383448273, 0.043863185300755364, 0.13239675059490133, 0.12745386480565116, -0.07642274450208225, 0.12298346043092552, 0.1429522775485101},
    {0.15548784778713404, -0.8170091555003881, -0.5191664190536104, -0.047845884685666244, -0.6328887492896805, -0.04456714143551286, -0.5212178779241684, -0.8231846697238107, -0.38647617935851053, 0.7878558863181558, -0.41979869787416524, -0.6288671589320952, 0.27842421950763896, -0.8132941251362655, -0.2937127460830085, 0.2502583063196304},
    {0.24673335740174712, -0.04874401977910226, 0.25710821424486074, 0.2779280542197969, 0.22806317430399084, 0.11788986996683566, -0.09641345457994832, 0.2808609616356834, 0.03019341463110656, 0.9097688723405064, -0.6937405919431402, -0.17738230168954938, 0.3799470278844825, -0.1652123777160871, 0.08572714081070053, 0.20618655720533044},
    {0.22133656929358134, 0.30898723001667916, -0.22564701879156038, -0.09333639110196926, -0.44808838387188205, 0.1964477455874603, -0.43041077210588935, -0.09779526705404237, -0.016374631237490535, 0.5792880876075371, -0.25439290462436903, -0.4828463697665615, 0.5390944523068573, -0.5908135010652485, -0.07103625660478041, 0.4684430503741878},
    {-0.06167561378064233, -0.40040804485703957, 0.13309830006664433, 0.24766252799079697, 0.19638686635375815, -0.04416120799868706, 0.14701142151650776, -0.2609117043700093, -0.49630562741971, 0.07207637817068319, -0.3985340142484232, 0.35010783260678235, -0.4796176523460827, 0.1399902778417495, 0.0047075328437233355, -0.19092006826030078},
    {-0.0705815599830804, -0.1969291315113067, -0.5183055322320202, -0.11524376674480263, -0.12915595415963196, 0.235829942245032, -0.3929545267736886, -0.26192508298785555, -0.36444228041223803, -0.21546087897773408, -0.1326765391569582, -0.017834260928583135, 0.14866922115954245, -0.18986764606306838, 0.05990734393764202, 0.056387621317132215},
    {0.0046732329014789005, -0.7698305141134103, -0.31449084102235575, -0.30056546412122065, -0.5251600921700564, -0.2434253371622357, -0.4096875536467886, -0.6727938779745538, -0.5643563256935956, 0.061425126967297614, -0.03977991473870901, 0.05627706511720157, -0.07103440406235792, -0.5184516215700687, -0.243343104114896, -0.3479147878717968},
    {0.0597763555376978, -0.2900492529636152, -0.12918338691498138, -0.13608234759807647, -0.3202755724881854, 0.014293030141692096, -0.2768360067114251, -0.5347766897918108, -0.2537096145994905, -0.20201738920964535, -0.11484535852530384, -0.4812104350392622, 0.0868179425468594, -0.16457692666436724, 0.1384946049067623, 0.13221131605312222},
    {0.13956644282020447, 0.34748290340514304, -0.024387152416172092, 0.4721863176237759, -0.03491732762645698, 0.4621715072625181, 0.1806463698742576, 0.4242202553143519, 0.1524975870026067, 0.4969049304856332, 0.2855780575038044, 0.5869903231473934, -0.03368065284632814, -0.0836045471748913, -0.017416273494951555, 0.2354257386827942},
    {0.09259560385279159, -0.6348616704789003, -0.42860583251598755, -0.12570663380125824, -0.38442644655656505, 0.041067494526423345, -0.6226221310539759, -0.819718721480295, -0.4527339054080766, 0.33470722205585784, 0.23675813202597257, -0.023765572227810998, -0.019943956750796243, -0.46257184468110996, 0.038489930391450565, -0.31990617864778104},
    {0.07144072322037322, 0.2150153243498738, 0.5086327943857415, 0.5016649457266162, 0.29185795838772977, 0.34558248943925907, 0.3492262528604853, -0.6315446225125985, 0.5018819338585568, 0.3791109025408133, 0.16395890938155555, 0.3064622200954596, 0.1192617216492402, 0.2905802315349, -0.15324686113249494, 0.1641991426396752},
    {-0.12884680328822637, -0.09507566573441925, 0.23910582455962295, 0.3376054073508577, 0.20018199425746455, 0.11488010043447615, -0.25586589257798453, -0.5932692366003042, 0.25191631557081307, 0.09239485239399567, 0.03451200499462523, 0.3269337756479216, -0.052016486169145955, 0.3605668368964151, -0.25300605269286347, -0.0932691423381489},
    {-0.3351400989329315, -1.4720866086055526, -1.0932835734763393, -0.7148994655053358, -1.1000193430564575, -0.059238634832655346, -1.0016446558489684, -1.5296717206931585, -1.1573768111433973, -0.0715173893361646, -0.8325100685801303, -1.2347465126949246, -0.1354789598741549, -1.2812447015343578, -0.3275406494332885, 0.3055819310034772},
    {-0.13802261436975174, -0.10790087825507136, 0.09294345615247065, 0.09228771006977253, 0.05563897916626809, -0.22732197350211159, 0.07887023161540892, -0.04351284105259472, -0.2338656940917153, -0.3724295855823183, 0.5972591860204638, 0.006015654368408984, -0.319120968682193, -0.03936183037007236, 0.21174013360708116, 0.07687848827823272},
    {0.22590475376270427, 1.1562187464334115, 0.8016663562503462, 1.000503451758727, 0.8150555838884778, 0.05406268428646114, 1.0197135523151493, 1.3761074697817268, 0.9407315591075682, 0.008628289681325934, 0.8658583750146873, 0.9051565261749787, -0.07360947555084281, 0.8523996743181335, 0.33156439322474146, -0.12860880073580774},
    {-0.07461057523842549, 1.319710784863994, 0.9436369351966385, 0.6233362147173164, 0.5310267915718473, 0.06068159931960526, 0.8060508405189145, 0.9728710209079946, 1.1039728248786926, 0.1865328263577112, 0.9792989645031851, 0.5085188762830791, -0.04257863994589397, 0.9843482684063698, 0.4116449760695825, -0.30820418465325833},
    {-0.023773599421829425, 0.8226566754288133, 0.4378950308786785, 0.36310625906192295, 0.8647375833902562, 0.18278028593495207, 0.49776481050263743, 0.8403481339956484, 0.500253584891896, 0.2351055377126026, 0.16424568522040386, 0.4855769266977747, 0.47887094349729864, 0.6068471478773786, 0.3973262983612935, 0.10701461942990188},
    {-0.2364857677068454, 0.08755833923353216, -0.1330343727710303, -0.08407257054521444, 0.18178175431365826, -0.24720964239165882, 0.18651710448814496, 0.027450659174701558, 0.12523645288387786, -0.319303672704623, 0.3987619645388709, 0.3613239712544814, 0.07417103746933011, 0.5196839965377932, 0.23284907527986595, -0.06459221657556272},
    {0.1976745840375283, 0.7772053468226187, 0.885078046213925, 0.8064878827247014, 1.3383475191241592, 0.3646198411165806, 0.5336886560215425, 0.686101504716281, 0.7453349811587635, 0.43076947568868684, 0.21018524158231078, 0.7829557300413653, 0.12874491857355427, 1.2248237731335334, 0.09360866500521715, 0.07014926712752109},
    {0.025331926689146494, -0.023406589305078482, 0.2741916767738205, 0.4003315510647693, 0.39133913157064265, -0.12293996259057828, 0.5257821266234941, 0.6104100924395394, 0.3349661581963586, -0.05071146729066575, 0.0979067790812756, 0.516762011488494, -0.008383065845924543, 0.573567333282504, 0.16021937956698698, -0.3375111927137834},
    {-0.2726166223639653, 0.15887793687627852, 0.2278647012427693, 0.11566621249144816, 0.42257455110385833, -0.09954960162072199, 0.3479208986241265, 0.4893632711069607, 0.03522851826546518, -0.028576856457079042, 0.31810822903118113, 0.4927049664861547, -0.06146752411158321, 0.3466926985878248, 0.28987296098479826, -0.06373224782253413},
    {-0.06424540699055095, 0.526028078248954, 0.6811765486843326, 0.7639638840517424, 1.007542377280094, 0.24632832150822645, 0.5107154205598047, 0.5367199800769836, 0.6633285728592894, 0.1435813197731348, 0.4031907711020386, 0.72067216187675, -0.11911550492131336, 0.6263353208629114, 0.15811888741720803, -0.20645273771436026},
    {0.021553182455699153, 0.5946808770227389, 0.4895426952284094, 0.6157746790975743, 0.5303343126847262, 0.028290499489289054, 0.3226303973471915, 0.6841848224884118, 0.6935570178294166, -0.13132967731532266, 0.2567990779077574, 0.6585132868971277, -0.11731612542546495, 0.7677472448104484, 0.23563449046598453, 0.044330082136166134},
    {-0.06855446050943514, 1.1954417921631497, 0.37822760521077453, 0.24181586251284276, 0.721812812116013, 0.1192621165103496, 0.5260990897453001, 0.7579806148778752, 0.6080761576607607, 0.09567021784242434, 0.34324317970923174, 0.5954831157855929, 0.2384950210724367, 0.7776707967010859, 0.2684862148120175, 0.03872403995162824},
    {-0.007807480567566912, -0.11970593483243326, 0.24864904952247688, 0.06129794536828509, -0.04725418374242405, -0.020955439218768794, 0.19242999022990007, 0.46324611488425343, -0.016735125404434073, -0.010516998466516977, 0.08839181704492145, 0.07615357862462253, 0.19904905100229667, -0.0411331141733029, -0.01593294640667151, 0.14785343891458516},
    {0.16991495830443412, 0.22004329660572006, 0.5100216311308674, 0.5465403134080874, 0.38471245120906933, 0.41779570397853705, 0.44722070312437584, 0.06353396995932428, 0.1637075491385489, 0.206493677330534, -0.19077714848919416, 0.45323220762651506, -0.3815780738213775, 0.28184257452391864, -0.20569250452138174, -0.21696072484507312},
    {-0.15612609407803657, -0.24575072496575917, -0.0963095236440425, -0.045309089999979284, -0.1759434211716285, -0.041736369506605336, -0.16137677742557208, -0.2258932053458345, -0.11995975655780429, -0.30193891027933095, 0.4703548478368679, 0.16822658822388997, -0.15842077935436785, -0.1853076506462759, 0.44050472702486365, 0.05551841017245967},
    {0.206711057058044, 0.06807942443064256, 0.21413349281116265, 0.2251846292657658, -0.13279093017418978, 0.12200550602806762, 0.298531246806584, 0.8438389943137963, 0.23331996122075283, 0.11954333313723847, -0.14494021022678064, 0.22886264017884433, -0.12000127396725004, 0.14634508413610783, -0.02977134379298338, 0.18516857684072335},
    {-0.20303147206491542, -0.051588232553207554, -0.330381808862548, -0.13435167180153215, 0.2441855988865477, -0.16999227192835087, -0.24428023039051772, 0.10664736080044704, -0.28884129061602265, -0.11491577410770122, 0.22161747603325394, 0.011567681774788976, -0.13227431854757318, 0.5763025767718726, 0.47120049921572094, -0.1496823763076776},
    {-0.09316046787865441, -0.545719412585004, -0.1628942270374061, -0.019161584801502905, 0.3317975077621916, -0.12449945899915613, 0.0018753495777559118, 0.19366782020953122, 0.34152383025265537, -0.35803908225191894, 0.6123590125878591, 0.1964207829834121, -0.19856991705023946, 0.3001453193564836, 0.1496368236562935, 0.07276334183414315},
    {-0.07876917846779685, 0.16432053401919286, 0.1040625325844756, 0.1571155342661315, -0.11539001047202549, -0.31983603239786873, -0.12583363155411287, -0.0718270982846481, -0.03280880920285533, -0.10761028184276221, 0.1358677539367286, 0.12182343766204967, -0.03928034230852794, -0.017553430816129888, -0.02155934206173759, -0.025653751694392067},
    {0.24881886124141767, 1.163465836418354, 0.7862881106527756, 0.4639242940008636, 0.7307898748494277, 0.1819527916404914, 0.6988041970302736, 0.7287900042001721, 0.6953578962446775, 0.7176322329718873, 0.24992159353915427, 0.8958280949954099, 0.14862798626309587, 0.3783258931319628, -0.022498577242754725, -0.10863789656241046},
    {-0.03684001004719085, 0.26148672165851966, -0.2443399316782674, -0.29698867088022657, 0.12421893341275508, -0.12590365874790804, 0.15487361169208522, 0.3511714493892092, -0.07979118602462928, -0.19654895213115253, 0.1924682028019788, -0.014625113394156035, 0.46389412083483456, 0.10238513097747479, 0.29807252945848095, 0.13131375665311087},
    {-0.22356320655338652, -0.12478049897524655, -0.07420942137244238, -0.34582662287809524, -0.16879583159179073, 0.039213597011319164, -0.3380464915348404, -0.01842576424342094, -0.08772898928337296, -0.0016064956778032774, 0.0935704921559047, -0.2620738039816875, 0.05745421277782909, -0.1551821653177642, -0.10667217561407634, 0.06236858983647915},
    {0.20261387875451473, 0.08275801865779799, 0.39349962370528024, 0.5689258240071113, 0.9712446711051775, 0.09625163634481186, 0.09974036915039917, 0.5201976313139908, 0.8341791717660387, -0.12506350767263433, 0.15006218752838021, 0.6310995633911358, -0.04967469399862346, 0.6459513190803042, -0.03431486762661082, -0.0663347245039782},
    {-0.1929720644886785, -0.6170654474749645, -0.32614407070898405, -0.24166836658567573, -0.4242483383847683, -0.04457268719206029, 0.11884848924183676, -0.3355334985647154, -0.1244231093484327, -0.10501829081037833, 0.13245699410313244, -0.10633883769265769, -0.385465955036771, -0.07814558244765113, -0.3480713825876606, -0.05430966620117236},
    {0.23304649946881445, -0.07586639971788743, 0.38808912934300205, 0.39640854872596065, -0.1994970568818829, 0.2926077791788087, 0.07766461763162888, 0.22655208375750802, 0.32295298105217213, 0.2557786894578176, 0.12813377024597714, 0.014567243552339931, -0.04635228422763386, 0.31251204490522494, -0.0862633634541261, -0.2968019827495405},
    {-0.13968219517643932, 0.029940628623650708, -0.5812959925360617, -0.22325618158378802, 0.02009158055012556, -0.13536417007263152, 0.026878591606892415, 0.09332532988330243, -0.4379085623764031, -0.10029022672770097, -0.21222826149019625, 0.04004846119274459, 0.15918573701106348, -0.3728217801221579, -0.09710249849563972, 0.2484986477249843},
    {-0.11194400850060582, -0.4323379850266778, -0.6497634682439816, -0.6535976049325868, -0.0793866666569518, -0.2395397471176186, -0.1597853839637255, -0.24762130824193535, -0.1873945920406088, -0.4649402318759388, -0.38386736321133735, -0.15217057895841182, 0.10746254042776228, -0.5059856325154176, 0.08675429811666223, -0.0367725939052943},
    {0.08561333409242793, -0.23037048358388934, -0.3764307701566701, -0.20814770640834335, -0.26695925637189766, -0.3045939694835347, -0.6342472572595937, -0.07334676828592943, 0.09599676119012274, 0.1024144757227086, -0.09684521155514281, -0.4385684316930806, 0.10438794433451119, -0.017148346699629093, -0.02849797543188019, -0.19829547926312183},
    {0.061880152331402594, -0.544083656732009, -0.039062220257574845, -0.04045856133661787, 0.02443567583514436, -0.059504715399405855, 0.038594969548598035, -0.2663782399945462, -0.5311334826767546, 0.19632791784699796, -0.2867675351167267, -0.39936908514761044, -0.5049838561826786, -0.4741743050284412, -0.23678340778787965, 0.0354039155095809},
    {-0.17804616294979447, 0.48352600787000366, -0.47948388855924884, -0.48980907303076343, 0.07027206568518611, -0.22768658511226425, 0.10564388849673098, 0.05410650338674247, 0.07267492942621606, 0.011448278354859702, 0.12441033635254678, -0.22071869033201552, 0.14154679929734046, 0.07544529178220565, 0.13619711636873638, -0.04832003689840791},
    {-1.5171413303159402, 1.5737252083487063, 1.7973443167217493, 1.8823353464320467, 1.9266000541331167, -0.09470666872717419, 1.4742357294807955, 1.3981846848229036, 1.6040334486849777, -1.9924799287912105, 1.3473403344820964, 1.0641448829877416, -0.7423792741152438, 1.5203042516349055, 0.32041590965337124, -0.5245485631007747},
    {-1.1061352150479458, 1.241395986930559, 1.6576262331231515, 1.679959718915987, 1.9779106292185835, -0.3826593253550231, 1.225410464769186, 1.138473583822198, 1.5258284222138476, -1.977377447402868, 1.201359975730227, 0.9194339516149803, -0.49106725582046756, 1.0805525501053546, 0.6154884968633558, -0.7927434159806457},
    {0.27347346922862703, 1.4183048148232753, 1.3258374360253695, 1.1168094986005654, 1.2526438025150404, -0.2822318088059153, 1.2747134621791596, 1.6039603308653243, 1.1855065520786459, -0.5966017418494397, 0.6147690518183959, 1.030091604035073, -0.7452865514565511, 1.1707671562492978, 0.2700673180200375, -0.9855954377983139},
    {-0.09678106478697691, 1.4131792211678589, 1.1026010156921373, 1.282245231376542, 1.3492682012134791, -0.2594968072899741, 1.224997398853969, 1.6611154884594557, 1.222709500507272, -0.601333761488422, 0.5760528584572524, 1.0185704526208081, -0.3452510436164963, 1.505882021923566, 0.35808877255236965, -0.739729218676405},
    {0.201269654797372, 1.5555638943849566, 1.0560292320523403, 0.742940342022924, 1.266336213024106, 0.011641820238111257, 0.6620678122783424, 0.9868395838375634, 0.9800329635625835, -0.010813476547233575, 0.6421883104438515, 0.9920298035772055, -0.1420448549251863, 1.0796451993374587, 0.4486697399337636, -0.5126618576818937},
    {0.03678817474574329, 0.6558737662240193, 0.5967262393457468, 0.9223327436463664, 0.9819799678049176, 0.13780853308560811, 0.6708814186718843, 0.5830564873643015, 0.8333056733275159, -0.05190105090329745, 0.2641167296433274, 0.7530689719457285, -0.20270755141415242, 0.8220807040624187, -0.11748422643962465, -0.5865506753337563},
    {-0.11848370950337161, -0.38420285677056526, 0.09762348813449544, 0.7563780323519879, 0.5103130376562387, -0.18246862644390466, 0.06199438841305158, 0.08853408564917131, 0.16579884308714457, -0.5940967556988829, 0.2990075146742427, 0.4702580026958637, -0.14878859468279798, 0.44114546654805664, 0.067307603924779, -0.30455475895210976},
    {-0.14923674199234874, 0.06874512501925666, 0.7448370780103641, 0.7650519837930173, 0.40853321313594293, 0.05274174995013289, 0.2633158811176582, 0.3857694471805146, 0.7332903694634064, -0.17374956653670842, 0.5269083495851649, 0.6345815450071004, -0.15888411749964657, 0.4960859781025079, 0.1254553133456254, -0.3875221457274704},
    {-0.3574226392926201, 0.23119326824362654, 0.7538860515491582, 0.6114480488432201, 0.6914701904033649, -0.10028905678648097, 0.4528764039841719, 0.2521786807176797, 0.4347605464218896, -0.4287918169785764, 0.9308448237409812, 0.46311401018555703, -0.26142368320533044, 0.4767980407218683, 0.09000277099060813, -0.3169220193198056},
    {-0.012458509736443484, 0.06426493320213349, 0.4700231984820241, 0.344921337554147, 0.41994415856890815, 0.01988202408092182, 0.3088235743667292, 0.3545155365923819, 0.47931467431807034, 0.04825184892383457, -0.12032918912868074, 0.048461627065347256, 0.19360814650638414, 0.005958681392231481, 0.13507611508518713, 0.17332791611988843},
    {-0.2701324319545853, -0.1375892920030824, -0.3012351930245644, -0.1561541065280392, -0.34729237131703483, -0.1952175818140851, -0.11367328359339242, -0.8337681233178448, -0.20547285301095394, -0.4475516656405817, 0.23887329499351326, -0.1868413479636405, -0.1936128468578333, -0.6674155446140257, -0.17144152523951878, -0.12913536579531026},
    {-0.02122399920017184, 0.5932386450214981, 0.3412489693134906, 0.589554483210868, 0.8197551985950929, -0.35117582208941156, 0.5410990557546765, 0.9400247124310533, 0.42823580082330576, -0.2820034155997801, 0.6584029210928322, 0.8526353213985844, -0.13647132899279574, 0.9080460875162973, 0.27258709610167947, -0.12329125586165737},
    {-0.2340857570080303, 0.19602129568258617, 0.375709643599751, 0.9492246187004492, 0.7665028863284851, 0.36306042964376495, 0.6259392498203264, -0.021495006573170772, 0.38056338134992773, -0.02598524210583212, -0.8102011399577379, 0.7727056336436049, -0.4685391292256654, 0.5726092309227057, -0.27910480505604635, -0.5651187247404394},
    {-0.08756831520869295, -0.20763472523721038, -0.04666840090515932, 0.14660704547246675, -0.2978423114442558, -0.0007757497422045422, -0.06705785110326286, 0.09824031548428745, 0.09355070407353852, 0.21783343175084413, -0.3473340158784028, -0.14189698624783129, -0.1731913616310625, -0.0793739589360508, 0.016355471647580153, -0.4557580347308439},
    {0.19040150851587878, 0.2403171532168722, -0.08364372597655129, 0.30339495588048493, 0.34131945046710715, 0.1885312242286311, -0.108501830294384, -0.2296847617891059, -0.028601204652715373, 0.13520161833584976, -0.8812534757480861, 0.35595005403493085, 0.07475912033624368, 0.20148108751468033, 0.33573082329722603, -0.5675385341941906},
    {-0.11844377739691657, -0.28528827658504596, 0.6597940203120163, 0.6448256471168728, 0.8990803206114607, 0.3081818073319836, 0.3372084789983489, 0.07869412176785862, 0.6830787258245996, -0.0358165866324275, 0.08139169464661537, 0.5193836874136807, -0.2362674372152339, 0.052804163490938937, -0.22277270432231155, 0.13877061278979594},
    {-0.12268487397970386, 0.2812505840256554, -0.11236252103657675, -0.08296121903885688, 0.25137104774275615, 0.17943357938244672, -0.027913067689533232, -0.202906364473207, 0.31022382034499146, -0.29323510803308134, 0.3019736814079382, -0.12268415662182545, 0.07058603361412466, 0.1061340012172371, 0.2662984103259933, -0.003005348273701973},
    {-0.250133984966163, 0.1189711074943677, -0.5532929393984628, -0.4466512072175437, -0.8469898159332805, -0.22391492820249279, -0.2281520053304672, -0.4041427335203979, -0.36223143523635476, -0.48244551424878823, -0.017861085167279078, -0.29930491636280704, 0.008507164868435902, -0.32261695572907884, 0.36070035393308514, -0.17710119868176644},
    {-0.22902956418049614, 0.24356607239586509, 0.27388593450595805, 0.2635045160997243, -0.07698073423290472, 0.25891795049361677, 0.03917690585517061, -0.37831175457281946, 0.13813178624851044, -0.5911195388029321, 0.3183750877049243, 0.10130101231321714, -0.22090017878699628, 0.1765538432355328, -0.026130200500999807, -0.014524571617742262},
    {-0.1699880814294474, -0.5430566983954376, -0.37116956524461137, -0.2507311339323314, -0.5416894107642286, -0.039333841295312845, -0.1963408502234298, -1.1469096247824169, -0.15852225418648347, -0.1206992038695106, -0.14551839323680893, -0.3988290433062638, 0.17209700213752643, -0.5052632943638249, -0.0181021563015198, 0.07096036855066123},
    {0.13055683262036574, 0.4890155669771967, 0.018969640948734035, 0.3061263206850865, -0.0011233588345574421, 0.2766666728586159, 0.5014377836127001, 0.3159518325583664, 0.2758302721632618, 0.4794753182033965, -0.35563545817177394, 0.06783861233075603, 0.049670462946665536, -0.04057291787723059, 0.03167243253716687, -0.040360282429377274},
    {0.2084335601731799, 1.0565934788325488, 0.41127322480101064, 0.13340349817504274, 0.29558271341958053, 0.22739307702558856, 0.3530277856805909, 0.5907379255655216, 0.6006565329584905, 0.2868335048625066, 0.4633739214337008, 0.11823147892010323, 0.17438721869758622, 0.18381983917619246, 0.30840369230717046, 0.2786767202189903},
    {-0.09568941265365473, 0.3844970867654951, 0.4374737886656465, 0.31247933066762346, 0.4935506932793669, 0.07310992207476093, 0.49469461711495616, 0.6503375671445224, 0.24687511205161872, 0.030359096037606205, 0.1516673830075996, 0.6141989730656661, -0.14014157464330798, 0.18510293587301271, 0.27574047654881084, -0.41983444428764394},
    {-0.15445760532678807, 0.378593355290698, 0.23486253732083776, 0.5141672146883165, 0.54083237541545, -0.0403023400986244, 0.570148497752212, 0.27214491151334136, 0.47795642373029434, -0.2956181784499978, 0.1112586687705062, 0.9701983495035341, 0.016440665559056104, 0.32254254183488995, 0.11617556034391073, 0.2626695339890397},
    {0.08972997752355574, -0.46468651257751176, -0.2714662238092344, -0.010092838789698976, -0.5981349848228169, -0.08012785502433081, 0.0984406712602286, -0.7593047279051495, -0.18488761619159694, -0.3055074141199107, -0.3058470953487689, -0.39099385268997716, -0.6124164919925795, -0.4383593826218523, 0.020686059455688747, -0.18516892656906658},
    {-0.04848622041221329, 0.12314762618218754, -0.049905540940262776, -0.15916324913430993, -0.15163916654151438, -0.054848212858457666, -0.11862383515193635, -0.03785925321719768, 0.23062043269683208, 0.19915521531954994, 0.05269298130828916, -0.12609552396275822, -0.37991886999065994, -0.3885337307419942, -0.04447628680679053, 0.13508716157812614},
    {-0.17905518770638387, 0.618327594269307, 0.023563390461194284, 0.12605373577954418, -0.0687782801422885, -0.1163054418795627, 0.2702188106249621, 0.20044819402987002, 0.4730607407725781, 0.002779446587196145, -0.3356083110269151, 0.5673897940195881, -0.04406506046975393, -0.3035988197335855, -0.02756211506419546, -0.11824201029774002},
    {0.321207582776664, -1.1629297005244281, -0.5729469762915025, -0.41457620886056284, -0.7563772041999751, -0.056778051385838704, -0.6630191719465733, -0.7279036784345989, -0.6423237824141468, 0.10362366070973719, -0.02284122331279237, -0.58341756296439, -0.379318742981058, -0.8572818561556518, -0.3337974806281838, 0.22059017103267886},
    {-0.011429897333010891, -0.3660631518668371, -0.3523104132387032, -0.08043654214173711, -0.10974143379395788, 0.12411594874878397, -0.11511484282312505, -0.6607040616626726, -0.04905219512981447, -0.10527819516408776, -0.16466858151818486, 0.02287081041141179, -0.001232973400466003, -0.42356559870250243, 0.039236537877400335, 0.09282810456724258},
    {0.1419017675651414, 0.3863877104828239, 0.4018752554935369, 0.41747826721766557, 0.6405275034954026, 0.12873186245486545, -0.0260495116505949, 0.09811343497518889, 0.24174384576470448, -0.36916728655374387, 0.06323936455639864, 0.5952338268244723, -0.03120115136871528, 0.5984918712046273, -0.05672144175308078, -0.06644350283867438}
};

static const float b1[16] = {0.503986925506691, 2.239986804693766, 2.4240101066587347, 2.4581645282834383, 2.477031861239571, 1.6414382482198646, 2.3719505757999317, 2.305548574080154, 2.4507595279599332, 1.7423182024238952, 1.980377168813768, 2.4636971317800036, 1.3515909024239385, 2.143121148509403, 0.8008158716328562, 1.4302926632693538};

static const float w2[16][12] = {
    {0.4861286377059886, -1.6796550132651713, 0.05791761231803031, 1.177419166254255, 0.11857498684635873, -1.161576725331565, -2.019691756334204, -1.3887111489674095, -1.3620293642831485, -2.5355966636140463, -0.6464658662608231, 0.049111472476978835},
    {-1.446972838643401, -1.7851460467357674, -1.9133765815742172, -1.7564546807762473, -1.5605769333406578, -1.3315099359966474, -1.3113531713523665, -1.1101494894081465, -1.9733228572304993, -1.4896617928882505, -1.0418212987443574, -1.2429768915432156},
    {-1.5215279348412147, -1.1773063191296111, -1.43332300371833, -0.9524783735592329, -1.6043662583824665, -0.881370968962011, -0.4056729623692883, -1.7645060060213142, -1.1818432338260596, -2.064825143404085, -1.7596398684214707, -2.0876338505630905},
    {-1.2919233656651055, -1.5321013548804678, -1.8795234670586058, -1.3358439592796791, -1.1637236883935942, -0.7027462682519015, -1.4790286262978876, -1.4565834426024964, -1.6043768876220397, -1.3715554391731857, -1.592403605626486, -0.005699793355648872},
    {-0.8716172256850879, -1.201190614933593, -2.084829464280944, -1.9225832838784, -0.5415253481154084, -1.7335980135945117, -1.7687037709561415, -1.7118232127921638, -0.9094490842094324, -1.0800346136326275, -0.9492779891913946, -1.6346589491245547},
    {-0.1338619584427164, 0.08877906074344263, -0.8872615753056535, -2.7268036251203265, -1.696569409573345, -0.5585287459004589, -1.902736142619658, -1.8446239921199168, -2.772021389904417, -1.0460846257196932, -1.3395863478579737, -2.9815526150115055},
    {-1.4149674530928873, -0.9860409102822663, -0.8536842850633248, -0.47033093469687487, -1.5490362463743184, -2.1347430226573496, -1.4546618660792001, -0.8312781362851352, -1.9490954600106145, -2.172891092657246, 0.3362444687064098, -1.7345881108282406},
    {-1.127298769549188, -1.3839690956086286, -1.7530742036759777, -1.2928884224928978, -1.3024008432149377, -1.3178134887927067, -1.6295031761838417, -0.8578747506610268, -1.5490334503984915, -0.7258564804801693, -2.358744934980689, -1.5671472467073957},
    {-1.8042440282435344, -0.7356455469913374, -0.9551239167715717, -1.3777162509912537, -1.9383194333855536, -1.8250000524306154, -2.0618415995317103, -2.179379303205661, -0.7205148714825159, -2.037111463273494, -2.010842291306004, -1.105733167104212},
    {-1.7324978271520812, -1.7681414823362116, -0.8316946333204162, -1.9090994571841582, -0.5036615791398543, -1.38542989544691, -0.13969314806065888, -0.6782588464093573, -1.1697943253001797, 0.2204142635034906, -1.3142497201266221, -0.3847833327079386},
    {-1.1582880375188702, -1.458310255334669, -1.314753493448275, -1.6051824699923594, -0.8649583478036255, -1.0845004141878214, -1.6291007482230646, -1.371078231704496, -1.1240547780644514, -0.35893052468784226, -0.7961329320583441, -1.3645952212000625},
    {-1.4704831692833802, -1.977087527771885, -0.9999804387362333, -2.1064062367275525, -1.4560311640435144, -1.4431618092814282, -1.1344530279589826, -0.3199577602196583, -1.1118300033393937, -1.14424990261269, -1.5974383533143668, -1.8744034112345267},
    {-1.0408686815626136, -1.4800613732295635, -1.118654624543585, -0.28495851504970177, 0.0778240414540689, -0.8413998190304781, -2.056338475438166, -0.7856027948710703, -0.7308300575874838, -1.200661632206032, -1.5422613769745879, -0.9147184951145398},
    {-2.2284299458035455, -1.5390758009552155, -0.7340288259358089, -1.2493928141948119, -1.727268211894272, -1.6243069683464686, -1.1561721537878735, -2.3419453064993347, -2.0046791068309524, -1.383558111873292, -1.824073549515855, -1.5625373803364522},
    {-0.4467350775788925, -1.7372016922994145, -0.4044112894626862, -0.14414056957372692, -1.8094173497914507, 0.49368545124721597, 0.07765381831085827, -1.0471097334691677, 0.6089424035855229, -1.3522916314207603, -0.6998647831669571, 0.29583230978657904},
    {-1.2244823373181726, -0.7261746621930151, -1.2587531392505078, -0.9620814248624934, -1.4665339381017155, -0.610289989107915, 0.03420789313910878, -0.5764804810623417, -1.0740172397289796, -1.1911491039681357, -0.43378941641560376, -0.5190709719981056}
};

static const float b2[12] = {-1.1055343214764821, -1.057430210503259, -0.6191216436081409, -1.2042282465939202, -0.743414198866136, -0.6434905726287998, -0.8499574264397476, -0.971454793649971, -0.5782412082860838, -1.0165793500499192, -0.13369503307097128, -0.5070427789466355};

    // Input Layer 
    float z1[16];
    for (int i = 0; i < 16; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Output Layer
    float z2[12];
    for (int k = 0; k < 12; k++)
    {
        z2[k] = b2[k];
        for (int j = 0; j < 16; j++)
        {
            z2[k] += z1[j] * w2[j][k];
        }
    }
    softmax(z2, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
