#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][32] = {
    {-5.346159256556648, -1.0897837367316712, 0.3090313036703553, -4.814513721204458, -4.554098619022496, 3.2026569757447354, -5.2768536668787505, 2.752359764881006, -3.879873324776459, -0.4374040811924376, 3.812755197584011, 1.2149676930029323, -3.2407616022373458, 0.46822875251646423, -2.2615474274770655, -4.334327834832282, -3.4119110526600087, 2.44182484521978, -5.009126732606727, -5.051034893983611, 2.3116606850583397, -2.824672198861683, 3.3557709351649927, 3.3211061490805074, -5.226875098019589, -4.821980783136945, -3.122210506978499, -5.100441430353355, 3.137667746214602, -5.32007678462724, -4.454751318342237, -3.8976014019011953},
    {2.373578245225913, -2.2431978261366727, 0.9897623898342118, 2.6704032394549775, 1.6501387585923297, -3.651453494491069, 3.173095252471851, 0.19538174047669213, 2.466114684426189, -3.2733520455591494, -4.003121898137112, 0.27947402602542276, 0.08342513101028812, -1.2795221677163593, 2.6272792295124767, 3.5103511118992357, 1.2198333793068683, -4.162054810170351, 0.4546536895866919, 3.681103212547661, -4.026350937235022, 2.450432609890134, -3.8157335279053526, -0.3851840075966835, 2.230707823894771, 0.38764839299612225, -1.0668844545985436, 3.3858791973077036, -3.8235666523157237, 3.217441461979585, 4.2324102767458625, 3.4657540883672038},
    {4.440058083436365, 4.0594158069071264, 4.21541592845587, 3.315066225424418, 4.947491945739706, 2.3709026082274964, 3.3833819691815146, -0.3110713352914871, 4.873219393703902, 0.6395505327617909, -1.1114426935111272, 3.6620179876320207, 5.475118244071065, 4.367292011485919, 3.2866987001678845, 4.789343861763594, 3.9319719679893743, 1.4643818250373133, 4.436645770609434, 4.398522546302699, 0.7288969969279755, 3.193556999226819, 1.5488077986845818, -0.6733042193839837, 3.0133937847206536, 3.7506189460004733, 3.5324060088908937, 3.3860091848831977, 0.4438049605227628, 3.8067932276888268, 2.8681053646311936, 2.79240365045332},
    {2.253366741911682, 5.715130115334893, 4.68546282294535, -0.12883907747869494, 2.8035354436777586, 4.789455050290463, 1.5349026704610416, 0.24725979988628008, 3.8006220405707687, 4.410637927761124, 2.7153964807496123, 0.8987516601308654, 4.979004086317757, 5.2906453485948, -0.6041567432442717, 0.8097242279065895, 1.1749419965428558, 4.585028589495871, 4.5073094528074344, 0.9136891540715395, 4.008723291428453, -0.14701609675349672, 4.138255818803626, 0.35485005505468764, 1.1853932249068007, 4.565056229065185, 5.260155203811583, 0.9895413005536186, 3.336136850919545, 1.6572876289213105, -1.6726279346980382, -1.1884924556897911},
    {5.260206473376353, 2.764236211224216, -0.36492888208279384, 3.6318784708187493, 5.55302716171254, 0.7358891224531027, 4.680753666168719, -2.318785378862769, 4.481046729948249, 1.0450387269897727, -2.4261843448727323, 1.515111556698289, 4.243310307888532, 2.5275198487454977, 1.6406979565891857, 3.9125933734033183, 5.315334602021958, 1.5349929383509087, 4.998592895930146, 3.646213414829145, 0.810453315361703, 3.154296878298924, -0.0839242978037006, -2.9628770408786256, 4.390806824004112, 3.794688057877295, 3.012975189525804, 4.393738736270257, -1.3763754767995593, 4.577515315447684, 2.213313219005998, 2.8213262401234083},
    {5.629243627160229, 4.346996335104991, 3.2438768553001784, 4.399417099743966, 5.337264481495794, 2.3468266012743157, 4.298458060565603, -3.3080150875294256, 2.7183995390067883, 3.4784504974729376, -2.135090352302381, 4.713041574974449, 5.71339713873706, 3.543120293217543, 1.6168692098420194, 5.012594635841878, 4.6261834953512695, 3.8389477112348174, 6.464669365694965, 5.077122822285903, 3.503633933754598, 3.6551091218423664, 0.9072277206324307, -3.7762252239310135, 5.606100674366571, 5.893933080350944, 4.6871409051158315, 4.604311498220507, -0.137731566284771, 5.439701975592015, 2.487648315650487, 2.3679988266108407},
    {4.990864673704125, 4.918548363609429, 3.5428428860244017, 4.02111916063054, 4.751541438195039, 3.0682977076824978, 4.176536481425607, -3.1931666553506273, 2.308033213013252, 4.2147975318548445, -2.0750300413904457, 3.351238725959606, 5.4987208768478295, 3.926154371078607, 0.7957180879072926, 4.380903924253204, 3.8142171913323444, 4.509296143850048, 6.286827885338686, 4.992348304017512, 4.169002689252787, 2.63736057179235, 1.6773384481615892, -4.294870790332873, 5.11295540070653, 6.3876482444882, 5.5034802659817235, 4.288844010200549, 0.3578909369048158, 4.9624427192787, 1.7912587002342886, 2.257600435980007},
    {2.443957735062895, -0.39266999062382946, 1.4099104781818184, 2.5489689310094445, 2.319483826555167, -0.8457820128483295, 2.563879284310876, -1.3814489994071106, 2.0025078099689972, -1.4595454983220515, -4.241331132757474, 0.34174871846677457, 1.8178485537077986, 0.49955205083221527, 0.9532390769927174, 3.1521483107801522, 2.046665343494167, -0.3560968718009947, 2.6646390914561255, 3.1224932098655573, -2.3435267102050386, 2.588308298153763, -2.9695710467937984, -2.1280460451427086, 2.213252947454712, 1.451619580617587, -0.15663202758963615, 2.64182538742606, -3.747995885005251, 2.4435725377452786, 3.012566536861416, 1.9872064607682687},
    {3.4473384291800397, 1.0646169614824617, 3.1722085220926672, 2.817264082045783, 2.476654095965458, -0.2254904232537751, 2.532188121089952, -2.0535464935528895, 2.9477894140990855, -0.48989179014067746, -1.81972879178671, 2.289243556563058, 2.5682263014941005, 1.827303953622739, 3.1405850475225536, 3.903551905964506, 0.9415909393462537, -0.0031647297896162324, 2.8120496834426376, 4.2801651592771455, -0.9762536495668372, 2.613406336772173, -1.6876860460390255, -1.6428824032889635, 3.462043730950901, 2.1705989269901416, 1.5441312915921446, 3.456673720098043, -1.5670059345687384, 3.180675451153489, 2.626991012012865, 2.8890346807070726},
    {-1.4910664280855521, -4.290553372942847, -0.769925096337027, -0.6100576089259724, -2.382197143526977, -4.447885866146719, -0.19373214600146735, 1.1452304739873957, -2.650342510823431, -3.3772477219724406, -3.6942326819719464, -1.8369802117617318, -3.014306888164966, -3.62895712521289, -1.0646024444773923, -0.5096481893238414, -1.977214583372546, -4.1510128948505844, -2.874359649893162, 0.2558028720407547, -4.080354320151108, -1.0452640102760395, -4.4467841733089, 0.9502556276089124, -0.8968385285979223, -2.799272926061121, -3.3656478604585063, 0.035277880991856345, -4.068433681608478, -0.8714512850888763, 1.2897305016700342, -0.42231674878319225},
    {-0.47953077971073665, -1.493179138881818, 0.7809765530694427, -0.09818183105033088, -1.4457677484845288, -1.8963496516669898, -0.5405836806450449, -1.3331031231995352, -1.7383157276532473, 0.09924679045822968, -3.213846787218028, -0.6189807079255092, -1.3316323799605174, -0.7908590022827514, -1.5894433524030123, -0.1542104755936808, -2.0436879624278075, -1.2374766517890874, -0.7248810639107913, 0.9095863758764482, -1.2451365305629025, -1.0529565624400044, -2.2904012829840954, -2.6038472390388248, 0.38162695890940596, -0.9927611143228292, -1.3525404982045148, -0.08469245663716665, -1.934179237621883, -0.45730183662751644, -0.39589330556884644, -1.0433764240988244},
    {-0.7756257590392029, 1.8913526313445652, 3.3961181294373346, -0.8946997476456074, -0.7139851602158116, 1.7847398282023164, -1.0001508367273404, 2.1961314528842384, 1.4503601812269582, 0.8122494098616742, 3.1394657252883666, 0.3231835249909716, 2.3903675039492334, 2.6301562278341186, 1.327318879099251, 1.1434825763278202, -2.39094004418552, -0.2802190948894257, 0.6825317633401369, 0.4819760541093269, -0.4349273555546654, 0.08305897589760594, 2.3975181573339155, 3.8765499610046232, -0.7869469925326096, 0.31222946722650613, 0.9536567710149538, -1.042654219604609, 2.155216459913659, 0.2626161399303693, 0.41877144062035043, 0.23011408697563238},
    {-0.4859310601829354, -3.5370644723724274, -1.7366372264794692, 3.2012527588712962, -0.6481848309114194, -4.159375955591743, -0.8091511610385285, -3.36853869766506, -2.4530080236771212, -2.8181457418907803, -4.080389847559016, 1.5172641081094869, -2.429613520066631, -3.9508947042705307, 2.972258247260879, 2.4340387418657756, 0.5600714552831005, -3.37701431930421, -2.3279980625168197, 3.3209177561281304, -3.5072274299714428, 1.8285996652878402, -3.7983302105935275, -2.5244593823222083, 1.5921928663764535, -1.5387568827968547, -2.840830294558339, 1.6941392537225077, -3.9401170409883193, 0.49792867502198895, 3.8039640532257426, 3.2126154930614264},
    {0.2665399765935291, 5.410053933987154, 5.1061699569850045, -1.2031658850729492, -1.1317637594520098, 4.444419832841338, -1.3930649015725751, 1.168998165372702, -0.010956738092298442, 5.52578996692641, 4.167266797166511, 1.5709492433321992, 3.465602218295428, 4.506752302333106, -1.0226371544291937, -1.180226683737255, -2.62529523291121, 5.150978733677845, 3.0763406211885655, 0.034221182886289794, 4.936222473610385, -1.0208824147027218, 4.285870933937179, -0.40006205862037103, 1.4859197538229336, 5.169064928095357, 5.290485000706072, -0.9869739959026106, 4.4179329607238715, -0.045979051715177334, -2.8265323403191602, -2.281262542906607},
    {-2.870126505074795, 5.0464886944929495, 3.2089984388810615, -2.22387024237918, -3.11456924882561, 4.161130872213597, -3.9065196269215683, -2.518351660544889, -2.9821156515445937, 5.453543251306087, 4.2430303691818905, 0.5470031548055428, 0.45155999918713446, 2.7965600212096837, -2.5595100532458126, -2.7563398874862113, -3.9826338803964916, 5.739601934536015, 0.9497418895178172, -1.9583261605433904, 4.9041963468760486, -1.9192958425833848, 4.120296644762721, -2.1617614014276225, 0.21861007093964288, 3.8329886494529837, 4.6787344145662075, -3.7412707831090506, 4.33937650084839, -2.4627632516295814, -4.426823714102997, -2.788196286245899},
    {-1.8449902435856806, -0.3373514938136536, 0.6982781368263206, 0.4183668176657783, -2.769688043891826, -1.8161786288966895, -2.854589602737262, -3.913905221003524, -3.1783795079657216, 0.9116015505426014, 0.6017010095946737, 2.1378954195596855, -2.738717246076899, -2.3123902426575182, 2.371772237662287, -0.8424544619882012, -2.755671724997445, 0.41401545534697, -1.520879244891794, 0.7087414405056521, -0.08238260267885768, 0.660865713262869, -1.479122134329162, -3.0474181924606603, 1.3883846000149793, 0.6301300513593807, 0.43297312089315604, -1.1409000697568858, -0.12053909297407739, -1.0380826740746842, -0.48334800242536924, 0.8176784604781491},
    {-0.2769886419076159, 5.450171871006741, 4.639971186098846, -1.0475520831397964, -1.3724176340515963, 4.212074528468251, -1.2080605572181367, -1.6207027259119813, -1.3653051480220102, 6.003087526667579, 3.238006491917542, 0.24598153575247395, 2.952801316886146, 4.213188712529369, -2.177627472689127, -1.3115690079770228, -3.3432307727152053, 5.569833660969878, 3.4474360440572505, 0.006706748471646466, 5.178944940699183, -1.4631579235292747, 4.303502604814014, -1.857132249015677, 1.9173861410761708, 5.655970037685774, 6.123620279546958, -1.2676015016215347, 3.6809858492301646, 0.535103894651369, -3.048532244685144, -2.169432896975925},
    {-0.23908759730492585, 3.676953472827918, 3.7193483885186946, -0.07009637776001923, -1.319240672147882, 2.2365688611095997, -1.5577686145340304, -1.8106381472301525, -1.483064166166124, 4.5425748458732045, 2.189751140814906, 0.7192151260815206, 1.290499205621955, 2.4398757269542903, -0.4046766369450196, -1.0757183262353358, -2.3538840601879425, 3.33845744925488, 1.8393691317876382, 0.4576641423851546, 3.9106831791414103, -0.6802201053118158, 2.679584531544723, -2.211669467142345, 1.5669889757189561, 4.154613909237755, 4.472587484580876, -0.616841491744247, 3.349393013251279, 0.7609057701508902, -2.02622793216869, -0.7885825010951953},
    {0.5659915682166062, 3.7305119384929366, 2.789315991584363, 1.1208140104730593, 0.7802342692000849, 2.901526665619778, -0.39744022223030023, -0.9911853908151309, 1.8248394680586966, 3.756093574340382, 2.2867584973510344, -0.3584006928754955, 3.0621866226694983, 2.4512041726823184, 0.44342218431564806, 0.396431740116186, -0.7781366455157539, 3.4107001862856126, 2.646409507533057, 0.9505936602460928, 3.1342950658785247, -0.2682728471432913, 3.3325335453294977, -0.46984993518373, 0.9614684043786546, 3.0814475210734797, 3.6834288912986763, 0.14216887991039073, 2.6424635875768527, 0.8907855882564606, -0.92952809943067, 0.920487289285153},
    {-1.9557306984686509, 3.1608226917189275, 2.778508892971536, -1.2921925729141677, -1.4779722683500278, 3.293091731103961, -0.5080291276550996, 1.902236095351873, -0.4793797045451613, 3.5960503976163727, 1.006215164788867, -1.6712191401349008, 0.4555328197379485, 3.2188748439942407, -2.5529513359142713, -1.3139386847463064, -2.468807458862484, 3.0400452567061125, -0.5747631350704465, -1.5434656230242882, 3.291063708908049, -2.3393495328852696, 2.594951877033385, 0.5918307110621407, -1.2639463493994245, 1.0679876223945626, 2.4084166099033157, -1.2651862286268902, 2.1227740408948184, -1.972021781302114, -1.3314192758437957, -1.9004395930018592},
    {-2.1013685363237116, 4.719974423433628, 0.6375656296484635, -2.1476615039976963, -2.703911903991532, 3.7633749174411357, -2.009212808663342, 1.345674797651421, 0.4050027252642094, 4.703282800981975, 3.800079865358327, -2.1957979699794974, 0.9588855825233988, 3.029537735877996, -2.6359840032979664, -3.6130440126420997, -3.4155746747474223, 4.303489183408351, 0.5632504567488885, -3.2140065792410173, 4.174917799359877, -3.20511769876046, 3.8643546208270783, 0.16619880334819134, -2.7310783996119947, 2.13386745774413, 3.772050211362623, -2.8705485814900955, 4.024188410371211, -3.145570475619333, -3.320898157737814, -2.253116103606393},
    {-2.044349079955891, 3.73913780335905, 0.07589099396251611, -3.339897838842015, -3.424944569925109, 3.384831808785893, -1.6373255106072102, 1.5986058348620609, -1.9021805509541225, 4.411478352086472, 3.421569397580249, -4.085615396060238, -0.8675912241497042, 2.219267948628693, -4.508467475754043, -4.264437005771229, -3.10443962985013, 4.235117719705439, -0.4052277391501151, -4.001348301109302, 3.7349040830160347, -3.2565044511225603, 3.297291176022777, 0.6367233427136719, -2.338278723134573, 2.1378303778405687, 3.266521049632366, -3.3271572994237935, 3.3062621290941236, -2.941588569574085, -3.965268887454029, -3.6813101567379523},
    {-2.466141964363989, 4.606621758431372, 0.4133258293348631, -2.7093687918593057, -2.4983641091238016, 3.588538803090862, -0.8487879306270087, 2.1755250036686413, 1.1627331537227663, 4.824862595548679, 3.983384333294911, -3.7245595134321356, 1.5885221479276435, 2.962402771050414, -2.8751612635105905, -4.155697329453163, -2.3690923555654964, 3.639511998635453, 0.4561237206600516, -3.5156056275961274, 3.951700517784561, -3.4740832631476914, 3.9699177990077725, 1.0657917331658988, -2.4229697585128847, 2.3026205620575024, 4.185918034974097, -2.7111101887810194, 3.8320335219276793, -1.7813926790431946, -3.382593600617767, -2.410401580710801},
    {-1.6742170254692077, 1.5461165343458663, -2.8890774983609404, -2.5985556703409673, -1.8546132302417673, 1.440878016030595, 0.8615369504084917, 4.500445524275976, 0.42062833459029086, 2.1553399138415266, 1.6825603718054318, -5.506622753198303, -0.7357791227416112, 1.1882359582070057, -4.2607728591664396, -4.010994012913096, -0.9317335972605597, 0.8063174266551728, -1.4486745372316012, -3.9167380165107577, 2.091362323061241, -3.16948232985467, 1.9795980236749922, 2.693696176153227, -2.8830372070260526, -0.3220195843273706, 1.4437424235883298, -2.0258990728551893, 2.0110373123679453, -1.1813292387317598, -2.4380372101521557, -3.0571682518672425},
    {-0.4046725149307191, 4.954460268948485, 2.3234668015209547, -2.933314758096098, -0.05458539553027011, 5.480531807615586, 0.37691715402351517, 5.092885560651933, 2.140418914139766, 4.620476769134718, 4.7225215120631425, -2.9699748880486094, 3.2724101295595722, 4.987644704554738, -3.094493916986547, -2.9299549003436396, -0.7638496209024508, 4.712599734911424, 1.6738445525150654, -3.155921257018093, 5.596340064482417, -2.6829064690244064, 5.467817522731663, 4.1625130632919065, -2.323658489166504, 2.438922572386474, 4.0645171966573965, -2.036077549413595, 5.229166065682882, -1.223532264112734, -3.0564698395808962, -3.429629896632414},
    {-2.313790728044744, 2.319895125518456, -0.19607663168690553, -3.884678700655356, -1.6367107032077999, 3.461059369115757, -0.5833295475611963, 5.377095897376023, 1.7633484286198087, 2.7393142035134814, 3.84775588809568, -4.251642317124217, 0.5265780140836427, 3.142113384348385, -3.781616228356876, -3.9693567251538564, -1.8752638217131283, 2.391806313208778, -1.4903670265394677, -4.226439549241106, 3.0019440664613404, -4.162647149308238, 4.211204977072981, 4.753980202724397, -4.216723434759884, -1.7173030158856497, 1.2278756457731301, -2.4076829868268943, 3.7178839950629747, -3.112576655634901, -3.364865518979216, -3.66493786091548},
    {-5.052795660634065, 1.0606834698231713, -2.454102011165527, -5.777191555909913, -4.80642445420863, 1.6030277227176033, -3.1182647805389636, 2.792924512154679, -2.444966720415304, 2.7621912723497895, 3.7059291498486444, -5.910461010387908, -3.4636435993148083, 0.24312944934591962, -5.420681399127329, -5.974822814564921, -4.428941430937697, 0.863562524041804, -3.49041596718044, -6.092876025061544, 2.4633720550797835, -5.601389124667106, 2.835796421858318, 3.421319529446367, -5.473098054995563, -2.8171151364428444, 0.8090906581365527, -5.421068778118132, 2.8194605366121324, -5.34116980605554, -5.584202511671981, -5.1420736894469385},
    {0.8339927523992982, 1.4635895195976418, -2.2270676905170395, 0.13290392047294797, 2.1496484932719158, 1.0873550269871186, 2.1904259127220795, 2.2891338048584022, 2.6583262060789097, 1.37579052194101, 0.8091073157637795, -3.48846551341554, 1.1533343370611076, 0.6330864617473179, -2.039088720171552, -0.944720842721619, 1.875113181482791, 0.6961471321479443, 0.49690332499780404, -0.47556738804178184, 2.5363185021286254, -1.52062188458925, 2.1605801799440743, 1.538925830431266, -0.8975732850549571, -0.6005189669417783, 1.0360770510881216, 0.6773601700719231, 1.5116570165403496, 0.366116082849274, -0.4251309504242743, 0.11766289762702876},
    {-1.498410118409582, 4.672451978914194, 2.080216697462881, -4.439699660495727, -1.8366504094510572, 4.869697428779613, -0.711635888181358, 3.288022967788133, 1.185163555596871, 5.092189827620851, 3.469843506931056, -3.7101962049638244, 2.8977718016437644, 4.510623686593206, -5.32735394583282, -4.377848803093035, -2.5476261303037946, 4.430037439278621, 2.076482752327386, -4.2149096639567905, 4.851002546525964, -4.705675906176866, 4.992844245562543, 2.9352367627575964, -2.51310604153049, 2.449682090644337, 4.289585894929567, -3.32162313114086, 4.504265858914454, -1.4311088646128955, -4.761444760100489, -4.712199410758627},
    {0.8644714874135814, 3.4383196393021116, 0.08853251164077251, -1.6754380113260392, 0.1957696675373003, 2.332523869865678, 0.48556483427639274, 0.4546844392992324, 1.6871146053201806, 3.799584934947493, 2.2135426593785335, -3.422352427047855, 1.971920222962493, 3.0135541406045125, -3.0707030465818024, -1.8815387678926614, -0.8560161320058132, 2.619573367180739, 2.320727550097933, -1.4451830191354453, 3.418735799392288, -2.3670089414506466, 3.3094725611808786, 1.1927905309969422, 0.49437704909706964, 2.1374014943857924, 3.0498930722398474, -0.8685882839813848, 2.684370978948578, 0.02833394539140233, -3.3915671298543106, -2.1471487514177263},
    {-6.59548102318775, -2.416615376122637, 1.2868431744652478, -6.574368546770469, -6.2603342039064005, 2.666858734244711, -6.3848633019493946, 1.9523355261600888, -6.162581136961593, -0.08546935597506014, 2.0761004246094545, 0.5022217376106363, -4.545770276166288, 0.7523451672115888, -6.464186033285074, -6.198435427470795, -5.334802550945534, 2.1756743411200854, -5.586084321255356, -6.247763354562949, 2.290932351232052, -5.179485060523829, 2.2448195789716996, 2.1897340342879175, -6.314598716170778, -5.175452710662749, -3.266354081203281, -6.540968377046066, 2.1496343268620874, -6.56930956559494, -6.383434132914706, -6.40261398601456},
    {-5.1489369561321565, 1.296520521127976, 3.7259724211175813, -5.5039777536299095, -4.997495887918156, 4.430162695498811, -5.279033907366389, 2.924738077080386, -3.2128684842427737, 1.016310468491831, 3.8053573453785607, 1.5393106583129597, -0.9535859694631936, 3.531252587570295, -4.688159454457213, -4.087044540982898, -4.991729910201395, 3.5074734283393463, -3.0745637398397947, -4.533842386936405, 3.1024785582091208, -3.8643192646363955, 3.475493560360273, 4.006737503766572, -5.4440810032798455, -2.4959849101584752, -0.3772026479191713, -5.767960424416628, 3.8308033998325888, -5.492438956521534, -5.316083396302346, -5.53528400300852},
    {-4.315185005218011, -2.47992217061471, 2.598225733235957, -3.861682567352058, -3.4679047270332277, 2.8743098178324584, -4.821493667869803, 2.86041528489087, -3.930178023003546, -1.4834555228751736, 2.9990331577765117, 2.3436954507796375, -0.0914238671823313, 0.9320702980396937, -1.211968673804742, -2.26669511190957, -1.9598035092809463, 1.5565605926058623, -3.224148342601264, -3.633292144206175, 1.9750062266542479, -3.1382340878500616, 2.6524055013202625, 3.3995156713837877, -3.622506326616306, -3.519016955151822, -2.740061592150773, -4.312629713437436, 2.518448752173319, -4.4254416773805705, -3.4206970050154784, -4.198772839055165},
    {-2.968752051867576, -2.6273624191000775, 2.552105746540786, -3.1419956001389733, -2.205768464839299, 2.1252915743204484, -4.223351753302247, 3.383949801830594, -3.1819448413678826, -2.3586228523269073, 3.2129893991480034, 2.3589607801108623, 0.27413526111043823, 0.726927825460563, -0.2187337716757472, -1.9630913722000392, -2.690259103072201, 0.8044415534243871, -3.643222416097899, -3.140783400145438, 1.2567804015457822, -1.955567047587061, 2.1036539073343863, 3.252358070789996, -3.983931074542302, -3.477003041555081, -2.8229879733934267, -3.947462660040469, 2.7098035204184314, -3.833947270770617, -3.0645121735189993, -3.164336520720618},
    {-1.9502371129491327, -0.9321150514628154, 1.1886593825209153, -2.2696665567063006, -0.8645090492839831, 2.6697614367648677, -2.0299549929638117, 2.7067562638170903, -2.4465718256801887, -0.39181025213557474, 2.713794904104406, 1.7447137020592438, 0.32117822576163835, 2.068009666004589, -2.2197497610279204, -1.5689693577296833, -1.5288422994708457, 1.989154872421016, -2.390209735934157, -1.0474377413167941, 2.1510196850364256, -2.168796443600619, 1.782444987937704, 3.418005308151261, -2.834567340208616, -3.2469723647752216, -2.273846015053357, -2.917591179250691, 2.5029464469432656, -3.170601647961666, -2.0227042289726973, -2.525853976815515},
    {-2.9183871323629327, -1.5801789563791229, 2.1488874823543, -3.31900994986329, -1.2776962437976787, 2.460720527473234, -3.092378871478125, 3.0280779177223835, -2.246936304293218, -0.7766406314578773, 2.176665159555691, 2.459224319290078, 0.6822219672236531, 1.7924087874286074, -1.0932909928898933, -1.9468323926092326, -2.243386516874598, 0.2058477055775372, -1.5242842213112173, -1.649747482511413, 2.133686909051734, -2.469966704660999, 2.424341081010431, 2.242355803569284, -3.5038189928495314, -2.5810694681483817, -2.352411729233921, -3.1283299439670773, 2.860405311628708, -2.512274325795495, -2.1870299060555767, -3.3544255130038385},
    {-2.4303885461638446, -1.3351145226885701, 1.9451354691463763, -3.0943062722439665, -1.1082017650777103, 1.3001648460184347, -3.340410832378464, 1.8192685028928741, -2.112511859475473, -1.316165289156695, 2.0767888910831624, 1.8103816714731829, -0.007750217926875282, 0.9376560816942672, -1.8731509311227226, -1.2586587560768328, -1.0549871984619144, -0.21610487522294808, -1.3167752886567945, -2.0461991746890114, 1.2566894690873844, -2.13827468975221, 1.745405018667425, 2.4535012682102595, -1.7005773922630645, -0.7059198896760497, -1.552952391286852, -2.9743571185614104, 2.5350282606068926, -0.932324809702769, -2.1422798627151605, -3.100104144016121},
    {-1.210324571327796, 0.4545157282543288, -0.3257214753490631, -2.729607342080321, -1.1229136792732217, 1.3579198616777237, -1.9541854959231033, -0.6218232183479975, -1.9175291521171243, 0.5372729807217058, 2.5740765512967223, -1.4252675002831816, -0.12080073896242816, 0.9643517900555846, -1.1663206093307652, -2.358335996054209, -1.9250325818075362, 1.1149698864459987, -0.11661605673492356, -2.554437068637469, 1.462595384218675, -1.369402530121256, 2.1615304973667295, 0.19490484557663917, -2.8870224873194332, -1.6635224147524033, 0.4642561205054088, -2.8276027215290087, 2.646731849605392, -1.5418876286884844, -3.8623479749710428, -3.088332844038563},
    {-1.2666848249028895, 0.480002390600536, 2.5317666324256427, -1.70663366609151, -1.4561764628283635, 2.3605056702050176, -3.103089811059023, 0.8091968605069673, -1.166437302918491, 0.6796100758428611, 2.451864311675996, 0.6548771892040894, 0.9938723897836839, 2.4506686971644847, -0.3328073312791408, -0.8008504358772863, -1.9740019258237507, 2.4212891256449223, -0.18975766553974352, -0.9729374291161822, 2.836660878869863, -2.542293967317968, 2.30111291736065, 1.3510055229364624, -2.0600703938103324, 0.006510804120686353, 0.3987989630313936, -2.4569941894956746, 3.053788030909895, -2.130379834930988, -2.97089443121594, -3.280696575168907},
    {-1.244905296263792, -0.7272676591667078, 1.9148704302091266, -1.407530384948026, -1.117599168093165, -0.02069884076584727, -2.332423248956502, 1.242035540615828, -0.14429862922671172, -1.018085444348362, 0.2226233783039578, 0.6157736310646184, 0.3928955698071849, 1.3834310033661597, 0.18651027295620906, 0.049128296089568216, -2.0186748970872475, 0.387007575469472, -0.7129608447277302, -0.5075003114456642, 0.051598065154549025, -1.0321158886176351, 0.8402535745872891, -0.5726259204603655, -0.2661715996093145, -0.6985064306095154, -1.2304454561034732, -2.2103007298410544, 0.2059242632103033, -0.47361244276455566, -0.18375533172706102, -1.5543853344081624},
    {-1.9811791404436827, -0.9576216952095568, 0.3074012371869681, -0.5992810546151385, -1.0027652383626295, 0.17983467463881034, -0.12757761635401807, 0.7165435698340173, 0.16030277292071063, -1.3113922583140074, 0.4865868890240727, -0.02016079949478317, -1.0030482592436634, 0.5982768846778739, 1.7880557205745435, -0.08408514877467081, -0.3002579710252882, -1.0022156371706914, -1.69756226070119, 0.3623722440930829, -1.0908818568744014, 0.27611144802167664, 0.7285185577785072, 0.7897625617745239, -1.2899296878327209, -2.1539398791943354, -1.35283591293553, -1.2378312326852738, 1.290159819083116, -1.79647117102851, -0.3059927580421837, 0.4769047454176868},
    {-0.15911270791667997, 0.08866391663076968, 0.3233483674642369, -0.35936171430877234, -1.072825440337327, -0.5930115138462569, -0.13357067046427173, 2.116888095978912, 0.8206734773753777, -0.22438095869781327, 0.9222386221437145, -0.04631586213735713, 0.21134137061542185, 1.1743798462223465, -0.17566293298044844, 0.42543472727930687, -1.702370952993205, -0.6141343038998984, -0.7091295398598716, -1.1328399309625938, -0.8854790492061227, 0.22745690536690058, 0.5323106866573353, 1.6941855959871017, -1.025745753081895, -0.7853778435693569, -0.48471503619931433, -0.5516432301068286, 1.1376203347648546, -0.2248015876585738, -0.2561642542659201, 0.8679568957967807},
    {0.7397618563423585, 1.77108169197708, 2.0047480926996153, -1.8621533584011998, -0.07104806860231921, 2.603288952319894, -0.009990885608566558, 1.0412359613924904, 0.7640594946720517, 0.7474970211424232, 2.8629522661559523, -1.6981940968833096, 1.8946690677118498, 2.888897990147075, 0.26707129689498865, -1.2329268313270165, -0.26211498340129114, 1.736954339173119, 1.0838047248690024, -1.9492409156579278, 2.3252143143424027, -2.1602190650429343, 2.3685563464485084, 1.1873482543816154, -1.03620114620522, 0.37281951316887263, 1.8472042586205735, -1.45543168374347, 2.8022292555923767, 0.43458134491810674, -2.3030643283412373, -1.5780961796828952},
    {-1.958497857287129, 0.6950470681778722, -1.2970655098738217, -0.7954967331662444, -1.6042916691209317, 0.2475015155521088, -1.0379160915013836, -0.7779635409123656, -1.1308888060715616, -0.1662638297284358, 0.41193943017161816, -1.285993425049815, -1.3554760302230693, -0.8208317459062295, -0.25125164596005095, -1.043923973003341, 0.3285163215435151, -0.37820854508250323, -1.605972186366341, -0.4110497829084431, 0.6543420566973749, -0.34267219766072765, 0.6174055276731006, 1.8218453114056972, -0.7674149581177594, -0.6051112075105283, -0.4268281488632543, -1.2283473829696698, -0.8446510073115837, -1.7857229134757346, -0.7015163801229118, -0.6124587303514416},
    {1.3975750667786169, 0.9187605916056814, 0.7198714624518641, 0.6995958401916735, 0.645905946918131, 0.5997329770081208, -0.021023129287261286, 1.55176518611833, -0.35152158917657356, 0.45490278689865105, 1.087240335096335, -0.5095937155150199, 2.0043435022885348, 1.6675512604179932, 1.0346782224815017, 1.0765583195421713, 0.6728449893846061, 0.7213639955202641, -0.03904442780032909, 0.5981448887830877, 0.5384067261189842, 1.3708520425139148, 1.1284245912896511, 1.200385930239731, 0.02460918901192978, 1.1848124447572117, -0.5129537042950589, 0.2819032270711036, 1.2156805912820607, 0.385330350659085, 1.4698017859523447, 0.6801506365993444},
    {-0.5958471743361168, -0.010894044569838248, 0.7334353371285215, -1.0400764052756064, -0.8083468538018602, 2.4474368233610804, -1.4344223207976319, 2.218982002930059, -0.20247836026045118, 1.1085613099810323, 1.3864806182801488, -1.6885076719223466, 0.7265829228196395, 2.398626420862173, -1.79378771501099, -1.1948169475488082, -1.6223852483577594, 0.6118786129071568, -0.9223595738404793, -1.8525668819163716, 1.249499934816637, -2.4118414043706515, 2.349715438405897, 1.3079191528114162, -1.012635958167547, -1.1289044292320638, -0.018549274665431954, -1.32980108914336, 1.7426316398770092, 0.006686969169608314, -1.154111297477593, -2.1972718351869176},
    {-0.5594408596458141, 0.7399906607828999, 1.8514646599930475, -0.3065761362831316, 0.28721663924961127, 1.6252045638108377, 0.138955892607329, 1.0448178981012834, 0.7121817435030722, 1.1000006625345138, 0.6356511173225838, 2.3012073143710103, 0.48239185727961004, 1.6492113600449563, 0.9030764822880574, 0.6345635165419107, 0.10834691582471029, -0.04553593730524727, 0.5061712622537946, -0.17347343370360718, -0.5594912587582761, 1.10405751435063, 1.0570080208036434, 1.4101441728572395, -1.728856442543168, 0.9850420524700247, -0.15904684589461424, -0.26197159355417177, 1.679550333496874, 0.007502073120392397, 0.17759925872389237, -0.3745365422152112},
    {0.051678387292345994, -0.9214832029320329, 1.565450745769719, 0.23493859059094366, 0.4998141020288263, 0.6539094455660226, -1.3243540790961383, 1.4577184615258194, 1.5033252759183129, -0.9954123329217656, 0.08103135485619169, 1.649545064651057, 1.5895438709879808, 1.0890427693264626, 1.3541335981377198, 1.114498553192734, -0.04957583851128946, -1.2762763043224814, -0.6944433000571729, 1.1508420832769166, -1.4356202832142821, 0.7490038633832631, -0.22800206532633507, 0.6091521762545798, -0.7576330411407124, -0.9557393576495723, -1.4601793776732568, -0.28630154495121796, -0.08167108418543674, -0.4318159096321808, 1.2133070588243222, 0.4040398425735378},
    {1.1174464536167839, -1.0536254671895824, 2.0809333960269134, 0.7687555627286284, 0.8070345079002937, -1.039639492896863, -1.0973733842414013, 2.1712052552671817, 0.8968522408852614, -2.670451915230991, 0.16298384597043042, 1.7955817136033692, 1.4476663264694114, 1.9336483401825786, 2.7365915728571912, 2.7577918859610753, 0.11111550046707029, -1.489376644368898, 0.016904430510958326, 0.9709244478270037, -1.5978893269509225, 1.9475743625109516, -0.3688642587789833, -1.298393169217468, 1.0386783115204081, 0.04418124460814194, -2.012082438943792, 0.4663905004169261, -0.7588057100136998, 0.1427164830191094, 1.6765049357916895, 1.2523809680552258},
    {0.17992824128220256, 0.2208263739442019, 1.8867274986536782, 0.2577199677722999, 0.6548797987729251, -0.6939634437114973, -0.04222018637253349, 1.3149197477225516, 1.8614033715786225, -2.1470319569871115, -0.7343688779600185, 2.100116468410001, 2.164947610760881, 0.666876639777113, 1.3337059431340939, 1.0286975053281537, -0.11110272998651853, -1.480461708500585, 1.114560800091905, 0.3693164763876282, -1.0482768521693913, 0.2885314613484869, -0.21829380310684066, -0.8023195653853334, 0.32412879564332836, 0.6163653071284739, -0.018606433934978808, -0.5118676082962064, -0.8631620887202847, 0.5003956542850374, 1.5703469728490875, 0.9204045571406553},
    {2.058623574836949, 1.651572617130036, 2.616035296075001, 1.3310858154411178, 1.4928768262478866, 0.5869135820058355, 1.4897217180645779, 1.813532383547681, 2.7300249280144913, -0.4229327410423481, -0.11569219594119252, 2.1748869034920544, 2.9318059991391556, 2.447960159556144, 2.3017400870290494, 2.604718228196915, 1.2073597087807066, -0.6610446983718816, 1.7729975347308853, 1.6140847981378903, -0.800215150332676, 1.6698942456869372, 0.4100278997209984, -0.35260201248175305, 0.06487863032054059, 0.16104113114913746, 0.6743835040138886, 1.2749224223338989, 0.8557212152764467, 0.7604147460937011, 1.4511133352349874, 1.3028593591214834},
    {1.2753786748092737, 0.1666938134286483, 2.7721930742187735, 0.8114424958137063, 1.5371062277589627, 0.9170894794573333, 0.8612139794926782, 0.04453468633960262, 1.4058255132313506, -0.17634501268780695, 0.6652392373565755, 1.4955678322974624, 2.9167170140163514, 1.3539294414615728, 1.282549378525105, 1.6567156264077871, 0.6361922037404295, -1.0217502620182077, 1.9567756812540993, 1.534998745683166, -1.0524974131363969, 1.0148242382444816, -0.20427743980315236, 0.43769438395552296, -0.026306037218222757, 0.895272769165184, 1.3495951037771374, 0.027067176063068594, 0.532025407691958, 0.8788838303184517, 1.2642031463119614, 0.25049585587026735},
    {-1.3899154891997592, 0.26968188308990376, 2.0756608647180532, -0.5773405002995159, 0.4200879338620572, 0.765795492273339, -1.190032005557049, -0.029279517780542066, 0.6730327445989499, 0.6366309962005725, 0.7458325573226315, 1.9851831970938973, 0.39553073555708385, 2.573895905422001, 1.522991019046135, 0.42460324830716895, -1.0630315047639327, -0.1757809539160556, -1.1831267239447636, 0.31365869692117165, 1.3446633825356633, -0.5689125364397254, 0.5103688124094024, -0.17681529070071703, -0.7143991694007207, 0.6887493438569862, 0.2681173054416713, -0.8766159826868541, 1.3997563891760643, -1.225996880428599, 0.8729327859408885, -0.8013886205111217},
    {0.5030862136901334, 0.3000136277798085, 0.5632252229799414, -0.7461481091800127, 0.20014421186756115, -0.6523762121112097, 0.08803618647102242, -1.5694206347638915, -0.4429148157545033, -0.00221931518342709, 0.7111388146072193, -0.13729769755222654, 0.06499006986186932, 1.2460112767056801, 0.17923614051698059, 0.13822598097411942, -1.1950771953723915, 0.9507189127450167, -0.15132456824428403, -0.07826485306586974, 0.9777697416808586, -1.7082179746402995, -0.4587756005997885, 0.9131302499662881, -0.026490320646600285, 0.17670176551080463, 1.2012420496021388, -0.16983067438747526, 1.4437750056953653, 0.15674063868265523, -0.7594899124533939, -1.1244838363731497},
    {0.21087175585283083, 2.067928440595432, 1.749255498583014, -0.5331038193230152, 0.02267451942813156, 0.6562688651737316, -0.9720426257154088, -1.2793527858198797, -0.5052153984753812, 1.6082969797213391, 0.9565921910089232, 0.1009445315412351, 2.1848588744891853, 1.5924470918540574, -0.7660098450940156, 0.7033471337639465, -1.5503511973910136, 0.7642027776231508, 1.0203320476184288, 0.904919146588273, 1.1562666212490118, 0.6279564316550129, 0.2630273558923996, 0.2764475165355107, 0.03786249488266521, 1.8269048261790946, 0.9032085843069811, -1.1094602314530648, 0.7228935291693656, -0.8587043364129184, -1.6082951994326153, -0.9447464723125943},
    {0.5073929877699808, 0.39121573794372483, 0.7487899175361065, -0.899854035932302, 1.0115179104233811, 0.23807698639472577, 0.21886146020539016, -0.43747923044531395, 0.13940207518322983, 0.7760794844486857, 0.08068924830658747, -1.181641736310636, 1.5808181855210774, 1.124031819147772, -0.9441535068521529, 0.6094875466608931, 0.5235904778456513, -0.35846436130758136, 1.6071694540579942, 0.4802084274526221, 0.4791285503957103, -0.3604973350692909, -0.5858086442599735, -1.3768884500080465, 1.152980879035181, 0.4815983847145029, -0.4505215154388328, -0.1733876616322369, 0.6752141586034968, 1.0312633008699343, 0.09502450764407724, 0.2846229854438108},
    {-1.955398296741884, 0.5986640435907907, 2.560190893253229, -2.6325838618275945, -1.1225899258560443, 0.06217518865507106, -0.9276576907849858, 1.0932924111903304, -1.5199704340799196, 0.7152343601427381, 2.4429792418184215, -0.2484175212287271, 1.1178359727016696, 1.2513411127524836, -0.9260235320980251, -1.7335194474321503, -1.82030492454446, 1.759231806356326, -0.3702502034052386, -1.8093850982189439, 0.6199458558036236, -1.7548048216796266, 0.21102550775558407, 2.3681003349818823, -0.42682926665934434, 0.1433980309486593, 0.20287525303416196, -1.7445476483259976, 1.521237682738105, -0.8807669073981522, -2.4221749105586503, -1.5278933941873356},
    {-0.5952629155669642, 1.7671160514828936, 1.851188384505133, -0.9631813638936684, -0.4965428434165535, 0.6178742615801093, -0.0815734890458119, 0.8521018809897648, 1.0807684234243045, 1.4329193818194843, 1.2233646139913776, -0.3247439505114392, -0.8098360511557705, 1.3165963650949346, -0.5783195075525539, -1.2196020448952023, -0.7356051273398971, 0.10690036847881218, 0.8186099527982432, -0.9427161710162738, 0.9941790760287029, -1.6273734521691612, 1.4818288201800216, 2.1209737803428856, -1.2816223834512377, 1.3770946718189723, 1.3037933032096283, -1.3718459370246665, 1.889262368980836, -1.1596623429197865, -1.8532891280104928, -1.525952799844394},
    {-0.1318696530692702, 2.879267769066394, 2.331222719433705, -2.1840892343178586, 0.07108559566143649, 2.2549641935490508, -1.1195665314249574, 1.4320581471475213, 1.1202119267446615, 1.4912469994877235, 1.465664594817521, 0.0031369328566626924, 1.5287556860815772, 2.6543749678804374, -0.7167970065369866, 0.2467007797849719, -0.34183732236028147, 1.1945790993741545, 0.9966832249969868, -0.39837112127240776, 2.5058350783215104, -0.8314638593460006, 2.274841306525836, 2.5272783645064876, -1.8324322347345203, 1.9235116453244827, 1.9798110385243262, -1.0189127851547566, 2.3245249164910615, -0.40681415100395596, -0.5051392682203131, -1.8626767899053212},
    {-0.3115015998877009, 2.617606136901698, 2.301797901786232, -1.8390215374540142, 0.3171874791752547, 2.6940221776517146, 0.7678302331624911, 0.18193266018016382, 0.7917453100408663, 1.005783007669351, 1.010981783062119, 1.2596807160623245, 1.9247924262223934, 2.1360222106304727, -0.3278545716903081, 0.14354806839148776, -1.161672566669263, 1.6939503197394599, 1.5694803878147916, -0.059640277401949104, 1.56808106457418, -1.7162769409898748, 1.8846249989039037, 0.12408517839562844, 0.9702200981894294, 0.9284742252073883, 2.0199127362349616, -0.9487000931139624, 2.040079994053603, 0.6737446457634803, -0.7909472461479069, -1.0615379367534},
    {0.8531057063843267, 0.422230979637153, -0.6672449614078891, 0.25371361768587397, 0.86598558093247, -0.6561090341122275, 1.5930022422735648, -1.0448163986910939, 0.34515753300997754, -0.06009656887424045, -0.6895249872861655, 0.0628560394070275, 1.859166603689249, -0.462698183175146, 0.031018723821997576, 0.9762800474522785, 1.2579365787191454, -0.23893874150304759, 1.4955801062893723, 0.6267542932526552, -0.6862191888613294, 0.8630466070986434, -0.2935310150607527, -0.20711459106793953, 1.3910036161495347, 0.686756682698855, 0.6791257243163517, 1.478092562579922, -0.8768245494484587, 0.9805187591128313, 1.061333630268071, 0.8388159203184345},
    {-0.16451317237089652, -0.3618981677049342, -0.036574553354026595, 0.9742825336861497, 0.09749421414960247, 0.09349173399574731, 0.08085055038933359, -0.7260844602705899, 0.528137274909155, 0.2405807680561701, -0.24914759768404707, 0.2654150584505585, -0.930379072230235, 0.24388598619283905, 0.28133069390854465, -0.1683092360452439, 0.3028836602050321, 0.533017423908192, -1.5806610464526785, 0.23798686566943214, 0.4365885221185118, 1.5685801371864765, -0.017297724468010537, -0.05252134400072305, -0.03591626410701872, -0.15745126921148364, -0.08591893163896676, 0.702944057243428, 0.039479190390025676, -0.20468709354660133, 0.7992324234429227, -0.1479118520969459},
    {-1.2441586068539505, -0.5468627554019182, -0.42732581993016394, -0.315681422565015, -0.1640858247363893, -0.8358297023348584, -1.2663460815286354, -0.42047802814246554, -0.5752703816163983, -0.2907841964676516, 0.2714549428425763, -0.6295243382528786, -0.36757701690537103, 0.4553247771601675, -0.19866062343410806, -0.4608512990385868, -0.7669360159064452, -0.40807343598349327, -1.6862317497181918, 0.8148512618252636, 0.18277280986459532, 0.5355425898550854, -0.5046222183657234, -0.12151291488642188, -1.455736471439826, 0.3193715204978354, 0.07191162255073132, -0.9193201870698555, -0.11829079642300629, -0.22477181451458206, -0.008076036212223879, 0.08748598730986527},
    {-0.39207132733169736, -0.29624097198017096, -0.6032313490022106, 0.13066588338500448, 0.23096165811168543, 0.19528285723912084, -1.2644770650665895, 0.6580436214687957, 0.32795754118986475, -0.13800623146141208, 0.194061377724692, -0.6439705323216238, 0.05069176888181985, 0.320110432038405, -0.7155020608340676, -0.08786412600972007, -0.872122644730397, -0.2524572207797023, -0.7536906699048552, 0.18570566118180487, 0.4634785820873029, -1.3374558144320863, 0.3923638173976073, 0.4144176816027956, -1.356102682163041, 0.764914659896436, -0.46165089421032307, -1.2363439514052283, 0.20885301359678843, -0.20741580445439275, 0.018900652968044437, -0.6776663587610616},
    {0.25754926326516436, -0.00016777293591157787, 0.5729652420504797, 0.1692345895030412, -0.03381215488592065, -0.44338930394370724, 0.371222949221465, 0.526909383764753, 0.016129143978672874, -0.32465470791931894, -0.649483293855447, -0.45351353594926264, 0.17083946799934818, 0.03666166122779899, -0.29047556603760327, 0.5704641844617427, -0.5736950647456798, -0.8534357695752663, 0.4175840393099815, 0.17239406567248083, -0.6758126864597892, -0.9516070864875907, -0.8570842660195681, -0.8669584422579496, 0.29960571315704604, -0.6032633149740503, -1.0495703248373451, -0.43481202645317, -0.05780973041984324, -0.7716670943096102, 1.109897598095087, 0.9256186619975681},
    {1.2333502400176406, 0.6043041975743877, 0.9549522891248737, 0.5742459075435304, -0.20541562428591295, -0.129738719191225, 0.7900705980862294, 0.39283854654791445, 0.6523084526144506, 0.3146058195088779, -0.32660902121179747, -0.9072213256726825, 0.2572209710039622, -0.6328474365476326, 0.6487192590479411, 0.27466372393294214, 0.5107306943782426, 0.7361829891197293, 1.6082173644594537, 0.0009143156733625244, 0.7369958305151296, -0.448311622715804, 0.050174414098820126, -1.3635790625057815, 0.37549305184232423, -0.040754999939531196, -0.24747096497375878, 0.3320971389947183, -0.07058258647721245, -1.0458313149047824, 0.11904408792682988, 0.4351210338825296},
    {-0.04567670960409265, 0.3471321405685474, 0.6637719859354474, -0.6904456844361205, -0.13885175860360816, 0.5097026850824107, -0.5358791408334647, 1.3951286010493067, -0.5436712583304774, 0.157978911825627, 1.0124270146441514, -0.5317613903095086, -0.518600527434349, -0.9373549733002319, 0.367430111510751, -0.19984603068780546, -0.5432128933670717, 0.9845005100814284, 1.009287793758115, -0.7767261537890242, 0.8038165147519939, 0.059000203194129124, -0.19979700263638367, 0.985238800424847, -0.7008889037079872, -0.6163248781237357, 0.2008688952220065, -0.43960003302291395, 0.39314285954193784, -0.20104190418254975, -0.6503749088073884, -0.5761175355154338},
    {-0.7644173629127953, -0.7881953011575784, -0.07490889879085989, -0.8108310037847607, -1.0840406174589827, -0.17137022503964275, -1.3745157746101488, 0.24862918492908048, -1.4201409842544581, -0.40636531673970056, -0.747266281085707, -1.0885661956675687, -1.54983083666751, -0.48881313382390434, -1.1154237952495794, -0.6255068754522496, 0.010764472083168112, -1.2538672736740057, -0.8736249590146409, -1.0448113872810145, -1.132383815865843, -0.6365543950078858, -1.1825537255653864, 1.6248564670375867, -0.7729539943313795, -0.4735676920106079, -0.4776619692303361, -0.8550562114027365, -0.5075798194915042, -0.5952747476388506, -0.8157164105294681, -0.44979002902153825},
    {-0.045298790208599476, -0.7284982741054977, -0.1400216495351046, -0.6181596228019611, -0.720000488733714, -0.9021117971686065, -0.8021117463433254, -0.10628962278066381, -0.110623393163796, 0.005204539555940161, -0.49454729430145283, -1.175124553685821, -0.6373431179832924, 0.017349883413574258, -1.1616482691917185, -0.8362060397508904, 1.304237327872053, -1.326550493523812, -1.007720303400587, -1.2232322427878435, -0.29642709401269474, -1.9990551148295597, -0.2516817159872491, 0.5786174753058173, -0.5833451168376863, -0.5446359852267834, -0.19041651379754762, -0.38228185657876107, -0.3793322405652283, 0.09063361362258784, -1.1583516199404738, -0.700007537484132},
    {-0.10820328838148591, -0.1255122995999815, 0.041208225133682004, 0.059748452385200344, -0.9182235202314669, -1.0389943323774036, -0.490310031150346, 0.5181741932804188, 0.3777323140928043, -0.7107448004011017, -0.3223585795256208, 0.12510809766889344, -0.13226067555663126, 0.024719637691678186, -0.23022685538272664, 0.04495706850257594, 0.5206007547656317, -0.9052672828243326, -1.3645696712834785, -0.8708377651263246, 0.34615510033107244, -0.647399932952274, -0.611863872276717, -0.4235549116168836, -0.16300869957207234, -1.3004207374091648, -0.9132321951083281, -0.46054108932639093, -0.5698580640068663, -0.00297760218328588, 0.004852561837598505, -0.6621519177092555},
    {-0.5143466063386881, 0.04621495209802945, 0.05185485167128055, -0.22536493545123776, -0.43948722922693084, -0.17260484783770563, 0.42897338215371744, 0.9909122283415542, 0.004162993739743704, -0.6202070365583839, -0.2918365531989096, 1.1540618040211472, -1.0087756167644, -1.1250368523420633, 0.42078830693189145, 0.17533081495825395, -0.9221387878319335, -0.4130174170066591, -0.0846066420769755, -0.29365379451319457, -0.03748051129835714, 0.1898127705506289, -0.2528191344998529, -0.4572493432951637, -0.16071208836015857, -1.6725248477563235, -0.32254376410057245, -0.2504073842880236, 0.11580445650738536, -0.36619811400561586, -0.14831987659312398, -0.6512380044490576},
    {0.14682252175117905, 0.1718859241509725, -0.32472329158413515, 0.4900593963508675, -0.0497229128495091, -0.31620942910423977, 1.1504156894000308, 0.1812463216102245, -0.6236538223234998, 0.28476597086994887, -0.7038519133684262, 1.6863071837138734, -1.0374752119238786, -0.9960976817880701, -0.06717013442927014, 0.6998994231624914, -0.61773415389043, 0.08853203630051995, 0.8434182133440669, 1.131701737702173, -0.48142978091510286, 0.9453141551417843, 0.2929230518716355, -0.18707406905140608, 0.8063159492615111, -0.47109687331782474, 0.1382498687879197, 0.2533916301176352, -0.5664225694189096, 0.6305821965497815, 0.6242217365703107, 0.32624124837144813},
    {0.39299073621013764, -0.568878942796831, 0.663493263290957, 0.19103764808501342, 0.48544914749831475, -0.31227793579330254, -0.26864817369096916, -1.760303149268524, 0.04307362380194544, 0.06658700097689353, -0.7457227520495725, 0.5544890570263155, -0.19159805721241624, 0.44380901692743174, 0.26136678095598015, 0.29638290452288774, -0.5095658239359655, 0.27108623756535444, -0.5906410664917828, 0.3392422832095915, 0.5083823568912499, 0.5381335921084273, 0.3383651056015673, -0.8972607182105596, 0.333959134256499, 0.9624132097539418, -0.3729602938640747, 0.12154837496937536, -0.01545840606896197, -0.24104147636688988, 0.3386134461702969, 1.1609373347926546},
    {-0.029831194580854994, -0.5268125730272425, 0.3759472762467877, -0.8479719670739588, 0.45919510271196884, 0.18599092366375253, -0.01652499365064239, -1.3032368233282263, -0.1119465691522397, 0.7383425489578974, -0.6073479000639437, -1.2612756929734643, -0.8799558125618382, 0.7531350110998484, -0.15743498881510126, -0.5446209407474274, 0.08837931449397572, -0.48348374325387494, -0.9458628639888305, -0.9990937540494066, -0.29236021027363995, -0.3301378693299129, 0.150379668107499, -0.8722932899947959, -0.7626888028732423, 0.7110357677820527, 0.12958536021420905, -0.4277646406589808, -0.010905957198782776, -0.38787184015695675, -0.007405891839120826, 0.26282689386300434},
    {0.6592893626048162, 0.06893405761922716, 0.0288898993298639, 1.091000460756647, 1.0883167017864543, -0.21803800975934493, 0.5484257076054664, -0.7360063063044666, 0.5921214141695255, -0.2057563538130799, 0.25208825339691787, -0.34608974917457336, 1.0797110287389666, 0.717033488449491, 0.608686887650061, 0.39272886486210007, 1.2467549609952804, -0.0903284379364578, 0.835731503875243, 0.27109289811002957, -0.7793122341891263, 0.7405931998204047, -0.23412740267680285, -0.43645293502024857, 0.887453646987593, 1.0388577891487978, 0.5957320194244421, 0.5189880054911762, 0.07779774904952992, 0.8689090910914661, 0.6930297602829507, 0.4204436367598121},
    {0.17652546672312017, 0.751978968405998, -0.44383449191729996, 0.27629374780868343, 0.612063401083387, -0.049346500474371224, 0.12859588638704694, 1.0117716782554214, -0.08582863548487835, 0.5133380114440654, 0.38875505640532887, -0.01142774517254091, 0.5944624442057247, -0.11561705920451212, 0.4897576567965661, 0.564906451154943, -0.12517142233122208, 0.3800244492523302, -4.560116377779793e-05, 0.6365189363500231, -0.10376618924174474, 1.1278446411391538, -0.09246580654080605, -0.2572816969139344, -0.7354809292247102, -0.6172996754717233, 0.06648183413650344, 0.19412465808013252, 0.5643813317457863, 0.795788109264016, 0.0038837210566767724, 0.18138711128945192},
    {0.40332117333100004, 0.547098390770732, -1.3432531279788422, 0.08713993363520063, 0.11561059368706238, -0.869651377821023, 0.7601367816940174, -0.0696342872160423, -0.2727830318073836, 0.9295680551697746, -0.6429630256088782, -2.012607442645442, 1.0506589228619896, -0.6817757731660301, 0.143388293123343, 0.20960192244380565, -0.6227435261019972, 0.2887526634767697, 0.5452046665176249, -0.05749087638289, -0.7763952029026663, -0.5633622799503364, -0.42265001462077106, -0.36207238550548365, 0.908999498122834, 0.23536554071690843, 0.33431299155961625, -0.1014246505645973, -0.18152667702826256, 0.8033499648301972, 0.5764201653244789, 0.8093721083146801},
    {-0.24442503889024275, -0.09308844949941802, 0.5444070773372633, 0.19105589054426858, -0.10946641086743757, 0.3794433369780166, -0.7875083689325939, -0.14320685769763744, -1.2080598739963835, -0.5331843590638777, 0.8450046116413924, 0.6121185553737186, -0.028672839120458874, 0.7809473907503398, -0.450014770567147, -0.20651840870453883, -1.2442540164150304, 1.6297705538107632, 0.27281732697830063, -0.40345174845665716, 1.055731341825325, -1.1346269011947157, 0.5877117963152547, -0.32765808443075617, 0.9368442703712809, 0.2074188174112743, -0.08582776810023747, 0.05299935959441833, 0.7858056271265244, -0.41661235356456283, -0.9891237812357601, 0.14068066326174283},
    {0.6377910762557876, 0.4896349618233223, 0.6256693678477495, 0.536521320171747, 0.2229773041795876, -0.002114562168657909, 0.23260548567379283, -0.28441596697132454, -0.6139838931696538, -0.11086072891672549, 1.2087630113481158, 0.029393712117258792, -0.14448284005868062, 0.39318068967486164, 0.5348923282222738, 0.6720142403048225, -0.4791673382814283, 0.8468892798647992, 0.5691268924964527, 0.376570972675852, -0.08045844766496664, -0.010852802749307904, 0.1755300902444108, -0.9151135940904102, 0.47965211784511097, -0.5099615993385053, 0.7228813894119303, 0.011409649377598242, 0.9279670142207708, 0.6136358528162338, -0.7196598254773835, 0.32730944450789495},
    {-0.3396356482514011, 0.11048056729294192, 0.16784444478896493, -0.2666227594454803, -0.5737420429988785, 0.04828578153496531, -0.007333192733249773, 0.606963272028009, 0.0687833082590259, 0.5196715239664248, 1.358826615793272, -0.8398067305722614, 0.47500848584418526, 1.0655799876410639, 0.3977838491843223, -0.562802381365405, 0.09691128310400743, 0.059588245395118686, -0.4418938176363537, -0.5496604525709412, 0.10785327978033199, -1.232211465086793, 0.25404326884708445, -0.03189926318980205, -1.1771367956196952, -0.9403955465057912, 0.4725466333854948, -0.9224943767668631, 0.10090283766950335, -0.8808856339515304, -0.47946560416114753, -0.2180779655145656},
    {0.1343631987986549, -0.7543967855620449, -0.8019669701351557, 0.1808320014262956, 0.3522227222948956, -0.717967363739358, 0.1660897281244009, -0.08872308088032749, 0.2201605507222047, -0.33547858483837784, 0.008726103790956757, -0.7654874362556731, -0.2329398691819768, -1.1245126385574507, -0.4292689742767197, -0.03049171239673453, 0.6101270065447151, -0.6762627846904821, 0.2720888407708717, -0.2895456273941638, -0.9239980951259639, -0.6662173750657573, -1.323075397154964, 1.1744765750927328, 0.20442019031596073, -0.9922540430756349, -0.16042974810426097, -0.21276705605123994, -0.4720607004743288, 0.2650159188267378, -0.6036090817772388, -0.07374777236366148},
    {0.280450881198938, -0.21973140430477064, 0.08639440115912506, 0.46106474127480884, 0.16124759119269655, 0.48588327107395857, 0.2956781245782917, -0.5399442971535201, 0.9349627118897619, -0.15181443202826633, -0.29654522870491645, 0.36314614593772987, 1.0628000771923967, -1.3501325061068858, 0.4037269258753189, 0.7485352690708625, 1.2251119941391693, 0.09906068868034087, 1.2420634859721427, 1.127096942736744, -0.41999260243410813, 1.599801433086561, -0.5422517297853834, 1.409803860635185, 0.6747193772175221, 0.699801088930794, -0.18817455539059344, 0.9148846911848985, -0.6556386088763312, 0.277105139382265, 0.496710867839595, -0.01598218927500151},
    {0.8330770609353256, 0.13963430687148626, 0.9975550227934897, -0.14910683419323154, -0.2648810092325624, 0.6776690752991386, 0.8417170317341968, 0.5333468421453812, 0.34984250396463723, -0.10421262799854068, 1.241771015103157, 1.2780208885309883, 0.7854818612320116, -0.13378129548680195, -1.2248422038161193, -0.40931658848435815, -0.35415783350878505, 0.7218062278354084, 0.526673469263658, -0.09272442037373194, 0.3471620746923958, 0.24954705158671517, 0.18492629108370526, -0.39293778838453136, 0.7694807402618793, 0.9739680262998043, -0.0871598497674353, -0.04973349499532918, 0.3371919729048721, -0.21713311599893662, 0.02047042117452043, -1.2103872818859658},
    {0.676040609620906, -1.0744629023527275, 0.3569241943641818, -0.3484248660896274, -0.7437670566781825, -0.06986971288636475, 0.49398163068517736, -0.16635133248836265, -0.49433049885670954, -0.3242011639003286, 0.6012231139388104, -0.031996131603401465, -0.6968166796937071, -0.3292376145256703, -0.5688662170315103, 0.09385768265405692, -0.22850085890258665, 0.12356128713111807, 0.7315373191027943, -0.6175132623865551, -0.00991514932228862, -0.8470108398426619, 0.16585723372125385, -0.5236734814159325, 0.6247464518263914, 0.44470045095482336, -0.731961562516151, 0.14112015878840678, -0.062303959127063414, 0.7268347571497782, -0.6936469131007021, 0.05559440337005835},
    {-0.6677819200306647, -0.34495428014340873, 0.15135700072092229, -0.939227059966985, -1.0633799320355568, -0.44522610394948087, -0.011874508156791617, -0.4547794552154704, -0.7568340482665437, -0.357940524319973, -1.1476578177920913, -0.2679399497663395, -0.7719340602080479, -0.32388144514702055, -0.48188175301307956, -0.6764809985663229, -0.5509164777076575, -0.12551835691849314, 0.016347567154559265, -0.7078324494910131, -0.762723485074646, -0.8189523474783686, -0.05367280301367962, -1.3753797412702244, -0.682176278276349, -0.023328122382401197, -0.8854498591840999, -0.3501846421452229, 0.3864624477134006, -0.3219662665985168, -0.8057084257437898, -0.83355091858439},
    {0.03681675879045483, -0.1308892426394765, 0.17319627824959813, -0.5579115684448641, 0.45204590770695235, 0.3817592455113262, -0.10420868011006161, 0.7960302624846481, 0.17663528162792977, -0.20073771233856816, -0.3582638974766345, 0.2884833987884275, 0.06652575599760113, 0.6910786097139398, -0.373195344796045, -0.21332316932304307, -1.0188588555603653, -0.08276223301549883, -0.015956094736038314, 0.7543732094651487, 0.45435371772182515, -0.4191102721108125, -0.7287823477139713, -0.19650304999893609, 0.40235868607697034, -0.5862487482648259, -0.6933733613865751, -0.5709227921613038, -0.16321675015212928, -0.8572724948666611, 0.44321598025139014, -0.4221573658878184},
    {-1.227048257988623, -0.5979865212951933, 0.21568242112127084, -0.922863776972341, -0.6945206822914061, 0.9884170584298477, -0.7871566647469913, 1.8721948005436673, 0.03611413263366598, -0.4356477390137284, 0.2895067259375934, 0.8013437196626432, -0.10491757887988287, 0.50787809375379, -0.034887057844689685, -0.7338733451650149, -0.8222749506706822, 0.099046181412812, -1.2524130682479169, -0.7399998322329918, 0.26173879680763457, -1.0743799855735903, 0.7966803906278904, 1.6746622811464733, -1.915863091710396, -0.8165376943030929, -1.086069083868274, -1.6323460778120833, 1.0205273495849383, -1.2036155642, -0.49537391359269445, -0.3456034940946287},
    {-0.3010358329210472, 0.6043651679575887, -0.35908786581345925, -0.04907337444350397, -0.5026566557773038, -0.14799953344115108, -0.11721044366804191, 0.7489640737869544, -0.7741099213341384, 0.7531303923959999, 0.6875869923239433, 0.2621039412661566, -0.49426988387423487, -0.008929800460303216, 0.9118483239908823, 0.1682916348446122, -0.2448582170303092, -0.16725333228148015, -0.5690063679086986, 0.012614730197089273, 0.41499773939581425, 1.0039810423412359, 0.7845655579701665, 0.4761286844243371, 0.24110179347836475, 0.2090644190049564, 0.7816223790365836, -0.3076048065231056, 0.36748515633454193, -0.29608299746696576, -0.6058908494415659, -0.034685993321805074},
    {0.007796968837730436, -0.6012842300723488, -0.37213863736859043, -0.5609859467870336, -0.38816552760358886, -1.5764171462402823, -0.6187678240643586, -1.0342222884533285, -0.2290122535845437, 0.05661505093958346, -0.6809040048293603, -0.3182833974092085, -1.075224892229054, -0.08893599556899524, 0.1825871386029091, -0.3002495592236027, 0.34194580777313477, -1.4962150716482177, -0.9768485558596639, -0.6864584331962722, -1.0857387185416512, -0.7535737910504983, -1.1499755101064486, -0.7409291825323429, 0.025477279737266083, -1.5833781870684778, -0.5324467285884, -0.45677188529919016, -1.3571917031851275, -0.4298693572324191, -0.8148819815938019, -0.28658366102239946},
    {-0.7561001820682178, 0.0642065338977301, -0.1409200170432729, -1.1072605406570108, -0.8150820315038984, 0.8000157947000173, -1.3961750036828584, -1.1671879591718952, -0.3217737328942823, -0.189571703276657, 0.620874485073496, -0.9480765872111863, 0.6333580705622986, 0.7285194613244692, 0.025154593556070835, -0.5684651735997105, 0.037400447338880545, 0.06186971209751452, 0.21795592354615842, -1.1620784346326722, -0.07866983772179205, -1.871894281733751, 1.3139565366633312, -0.6070060669989554, -0.36700829669813506, -0.2550939947881899, -0.42607035032326795, -0.33156721615696977, 0.6782880816947457, 0.14900279158014534, -0.7372061981390206, -1.1995886599545336},
    {-5.851181977448642, -1.5826066003678927, 1.7062556102049138, -6.171325107968346, -5.486967103348402, 2.4427489122735593, -5.652520798073762, 1.6369496619666648, -5.129356444235534, 0.03354903721332264, 1.74304816390872, 0.6367424212409677, -3.5916223362147615, 0.6689040292013686, -6.3396945716105195, -5.625963719373581, -5.295544143434212, 2.195730183839536, -4.702491510344809, -5.435841334058679, 2.3622198586067653, -5.123782552545026, 1.8591003655671179, 2.458028928400475, -5.546570500632911, -3.8572837697523075, -2.0748619201995058, -5.855551464257748, 1.7742441999921983, -5.914226249613068, -5.997435884356514, -5.957218206542851},
    {-5.429675096373644, 0.6510996330913557, 3.191810622414578, -6.126373739528394, -5.302439726484384, 3.149551978698192, -4.764824766485093, 2.3967715947923898, -3.5553894837406568, 1.181222451898497, 2.978034973292492, -0.054929045388185264, -1.6484878962028795, 2.7887646683826737, -5.855581351192074, -4.345975158374044, -5.7502317107983085, 2.780644893500769, -3.0832990988987605, -4.62447734332799, 2.498367895285832, -5.102821198429772, 2.5405980113637865, 3.8352392765399856, -4.916323133552695, -2.3307874438813343, 0.20418143232499922, -5.9601464807518045, 3.141367352871071, -5.120043719550773, -5.7784329447227645, -5.669729029023111},
    {-4.012861235915726, -2.5745430856597165, 1.8349737612026793, -3.7105131620842684, -3.7544045610816017, 2.16964974542652, -4.044508632055406, 2.702615525691696, -4.070994167788162, -1.5314117411074553, 2.3740951729385533, 1.3473393774066482, -0.6844595039290656, -0.27043750659025767, -1.5916876605686723, -2.4475724359597097, -2.094097076363161, 1.0932854226684934, -3.302367538397277, -3.62020605946698, 1.579345493712289, -3.025558918193333, 2.1519103473363517, 3.151093800592697, -3.5534440150119675, -2.692622982677407, -2.3814408303797694, -3.7766614678500123, 1.7943173417875204, -4.0499747524837515, -3.1906257845759387, -3.8920141190898963},
    {-2.4217023245872116, -2.041588765213026, 1.2149710853672497, -2.715308747459895, -2.0606100749670904, 1.4466536910973251, -3.104181278188745, 3.183647205926757, -3.1547253688008263, -1.989251522585854, 2.834394089445598, 1.9173668648537887, -0.3067159660248043, 0.4077829321781013, -0.3866069635989362, -1.5270272606997684, -1.914188084853913, 0.4168530256490632, -2.8445226793901908, -2.4747518401037745, 0.9641746956139854, -1.3243247127711408, 1.6081675157609707, 2.8935139508849073, -3.113865871089868, -2.837379758052056, -2.7263398702151673, -3.2039925466558468, 2.26235464731571, -2.5462997400004608, -2.80373639891491, -2.8658598142943306},
    {-1.3474248808441676, -0.8765304501096857, 1.4837475794901864, -1.9017801042563132, -0.9178029028831546, 2.0336657067288475, -1.8053720500120707, 2.806229241057981, -2.227856601941238, -0.6043207885902263, 2.6159244813108242, 1.9552042063808635, -0.016671812329858992, 1.4069361044297797, -2.021228878969006, -0.9337923126390039, -1.3034893261762521, 1.3209112043752609, -2.0863817372658047, -0.5214464071562077, 1.1822835552838773, -1.847532153363276, 1.3512787337801906, 3.4459858419313165, -1.761676616691876, -2.5098930948263387, -1.6439088087967533, -2.546536468068069, 2.2280250231391032, -2.639871984040486, -2.2053963647640265, -2.4896813133082194},
    {-3.0937455977788684, -1.897396062928053, 2.3771496848371987, -3.6063100407896314, -2.030279129777377, 1.417458491765764, -3.762764243215129, 2.4286432711698693, -3.7299117826709174, -0.6288627466974, 2.294686633348653, 2.052215527250662, -0.20961525262241767, 1.4732569696410682, -1.1011480192436818, -2.416699162174378, -2.9894413439089, 0.8041675307998101, -1.5245870036919393, -2.033203359256576, 1.3967224528268896, -2.8401411863616426, 2.076976325286631, 2.029782913915032, -3.0664336333077533, -2.0516182363333813, -2.3689109860095097, -3.6162785655642735, 2.2387008046545382, -2.332346823562287, -2.506380094463952, -3.5292981132964862},
    {-2.3275470332857715, -1.0511243424532726, 1.8291287583631994, -2.893271103373055, -1.6774947204879616, 1.611731248497738, -3.393592025581561, 0.6532353511990462, -1.9880309872271154, -0.7751118085779668, 2.589024745726241, 1.5951663788891235, 0.9269594725189865, 1.3959606927638415, -1.9681651994942368, -1.823359485240384, -1.6040837466674838, 0.4142490694324991, -0.6069414816371086, -1.694567743439555, 1.304798522154666, -2.611349775239668, 2.0042579512205436, 2.6825438151676675, -0.776032653869569, 0.7041829540529444, -1.0122471192390754, -2.5006980113954276, 2.8011885345956635, -0.623802938031401, -2.0860271220941016, -2.94471039567012},
    {-1.3846234445916454, 0.7147690909435421, 1.086183056718571, -2.6935193510890776, -1.2810940801149924, 1.3729240143093686, -1.9304530900563175, -0.040333274593481176, -1.9651372820748734, 0.8653788391944048, 1.8504413633989671, -1.163038443956854, -0.16033143714450748, 1.448092415288418, -1.2736504798772734, -1.7651758752575926, -2.2739711087321983, 1.5418348647314637, -0.34274585775389116, -1.4991193250074004, 1.5248503496561943, -1.6495038116662781, 1.9406582377677264, 0.6527156537041012, -2.843314507814655, -1.3217413807009464, 0.6894412922458749, -2.678323490790473, 2.3106382565500665, -1.1548985473300408, -3.4084275265861357, -2.5312985019257286},
    {-1.6885071811998726, 0.7030148514579191, 3.125596540068734, -2.3453766294933254, -2.015450299685219, 2.250814749284165, -3.3542176747935493, 1.4298847029813426, -1.1180515354566802, 1.5993069327890028, 2.7663883934730427, 0.34297568637943776, 0.5334191297784926, 2.5837925481131565, -0.7954319999354337, -1.1031170302057998, -3.270554260875475, 2.5052926303280425, 0.10609091314802216, -0.8585510404333074, 2.7280580409547612, -3.075598036637158, 1.9106390457779194, 1.7647167600509603, -2.0432576662780733, 0.5574628970483615, 1.053840695928446, -3.2796190498717, 3.0288930513969614, -1.7453070299362428, -3.263083676841265, -3.599230543907904},
    {-1.17632200460251, -0.833873154144728, 2.2349102814185016, -1.6939219650768964, -1.2916855150793118, -0.446552805070648, -1.949098121793668, 1.192760282238271, -0.6745361563015255, -0.9236932743490155, 0.39935258876689017, 0.5006197349582104, 0.3306444151492765, 0.8065047934738442, -0.02148015816267531, -0.08576418553479107, -1.9301138841388734, 0.6783859858516359, -0.6355926264133812, -0.10831806327580033, 0.3195884741638833, -0.5935264858109284, 0.3464043059999996, 0.04069708848391934, -0.022814988943880142, -1.1323932731669006, -1.0369574189134276, -2.0965940571714596, -0.06855920551296105, -0.23226145113691904, -0.0885892248010387, -1.6591290713612146},
    {-1.7895496149801924, -1.4317459621515112, 0.3108290764824479, -0.62183622604845, -1.451188802237133, 0.04107163917609141, -0.9305834045641936, 0.9657118098030438, -0.33377859452880565, -1.4387410724803462, 0.11843905931144497, -0.5148221792190655, -0.6728124038416925, 0.40021579081713077, 0.7531481342257335, -0.1730218202931851, -0.7426677774927515, -1.0322784275779668, -1.2057349104473563, 0.4047686307828931, -1.2402066291013842, -0.5373302193320849, 0.2603979466451583, 0.6999062961240761, -1.0716676563351706, -1.800198122323496, -1.2782137355798777, -1.6480758496310528, 0.6454208458911671, -1.56393362575319, -0.6214860313376221, -0.375188994760827},
    {-0.0007804532846409906, 0.26745253341140224, 0.8907139089751718, -0.3663525062578462, -0.7747628363484808, -0.2468410167157202, 0.19074654222814316, 1.3672468931374138, 1.091347922289201, 0.8954649138648578, 0.10180236518275408, 0.1541545200254743, 0.9557648987626964, 0.9939601265817923, -0.6595549015598541, 0.5499196741288809, -1.6475821693872459, -0.5191226628550593, 0.3096223435710735, -0.7492319992326493, -0.3680782891230955, 0.5874983071797205, 0.7310143213961315, 1.4710255487687496, -0.30527595143909253, -0.6338936921397678, -0.37411754600348657, 0.14214905168634168, 1.0724653564951485, 0.26129909787665256, 0.493069154690957, 1.070851686366798},
    {-0.18421690233398197, 0.35609250526917113, 1.3107403013338264, -2.663139579041259, -0.8210463205874223, 0.884626727282996, -1.5420114029948182, 0.04602603384659894, -0.8232169841232806, 0.04729338575585466, 1.9586599888189997, -1.7463567718847384, 1.0781124622104714, 2.2811112915539575, -0.34632617791629167, -1.9115463146551557, -1.4399355312366393, 1.068858563076774, -0.1368012355008446, -2.5289790930452742, 1.2122223902804634, -2.747029114105861, 1.699229726346848, 0.31231199274995314, -1.788468240235892, -0.8895605894553376, 1.0074912183875433, -2.378184714929735, 1.712806941610056, 0.02454068678717848, -2.8881287388236663, -2.0738598421595222},
    {-2.0964132873482324, 0.11415218131268674, -1.0748070139798203, -1.1409634089265237, -1.8918498393893575, 0.3440792045549384, -0.9520998420891915, -0.1403656784788869, -1.378279611769545, -0.11194055447521287, -0.10291027077308318, -1.4317269368458534, -2.0662678700708668, -0.7868254997355422, -0.9895440925775465, -1.1853380700537839, 0.11753854600540486, -0.7136687185706156, -1.8703795890569561, -0.8532089729169916, 0.33218486499297695, 0.014003474266577089, 0.18424233825817027, 1.6291443835361952, -1.2589309918689253, -0.19859096574350113, -0.30858588214415245, -1.4311430973828545, -1.190841293955218, -2.0786914492377213, -0.7123014961359388, -0.6680320579483915},
    {0.29354307730961315, -0.6116330775405538, 0.4564783453235028, -0.4834639224768139, -0.9096953307931996, -0.24822838726454674, -0.7844662397823624, 0.2245971542183367, -1.8906361901486854, -0.018576137955123334, 0.6858025073631334, -0.8926643473399065, 0.703143066943442, 0.8159824039286656, -0.5071421715887285, -0.11960322368143121, -0.5393388026588739, 0.5008082744357635, -0.7976215446786812, -0.5741555338800803, -0.21418648014553113, 0.20647329974579118, 0.33087513154314696, 0.1789437613254799, -0.14290146637999498, 0.4461171166366937, -1.4969968998860446, -0.999326121859936, 0.7140075139070998, 0.04153019894026361, 0.21522008469401224, -0.4530164020118852},
    {-0.9381876036472846, -0.423664374232895, 0.9277246574453102, -1.1681201231809448, -1.8133785873367014, 2.3057285006931836, -2.3332975686325153, 1.2476205098826654, -1.3246604936041608, 0.9743835578810613, 1.792744456411509, -0.9588459190629487, 0.09739774696327909, 1.7842906402264809, -2.19086201909482, -1.5561096919355655, -2.506897822064963, 0.8210346071857434, -0.6208882431596595, -1.8822027276047224, 1.4454814730258763, -2.8874991214428216, 2.115231626377818, 0.5315392256081274, -1.2082933541503529, -0.8486990474060682, 0.2684165593572606, -1.9527780576462817, 1.4240188598578807, -0.7374349284769718, -1.4516147780265023, -2.453985930157818},
    {-1.9055894065091297, -0.07456646020603772, 0.9766723075876507, -2.2165483586482733, -1.4884118231842702, 0.8414674099861016, -1.2423443918841293, 1.1173082206753857, -1.5263390524205924, 0.6368087524983247, -0.14706465338377633, 1.272805827373007, -1.7185133342751524, 0.17936689145391774, -1.0968668185230537, -0.6052084910405245, -0.7590227677147842, 0.09841308049567472, -0.6938231737519566, -0.9226742961102887, 0.01427919544610528, -0.4830180737561941, 0.10348240980158485, 1.8908833098397002, -3.080893095378307, -0.9326911772529365, -1.3389801710525253, -1.490851288751351, 1.2694293360962048, -1.2609700612533714, -1.4207595576636103, -1.4069492675512492},
    {-1.5552665583908445, -1.262176116216106, 1.171958153990726, -1.2788775719577736, -0.39509796395827845, -0.11201006173593143, -1.8436633511619238, 2.141820907373299, 0.5047159661189723, -0.955820028761204, 0.8645330834202986, -0.005736900559979374, 0.07461714075589256, -0.06012983421006337, 0.45606882416521527, -0.23759789869474596, -1.7365792563927285, -1.5199776544111816, -2.1639205073985854, -0.1260023522983596, -1.7193429510028002, -0.7694256424698519, -0.5067397705922175, 1.0259557719218502, -1.3431061237293407, -1.3163872781943375, -1.7562795676169, -1.0429047286188708, 0.5001584171820446, -1.935129984096132, 0.08465623793903036, -0.41951320760621463},
    {-0.14669019846909082, -1.1130773858455507, 1.121947462730567, -0.19665715235863387, -0.29885389004763, -1.1019395727326702, -1.647654415739584, 1.7118009486451413, -0.7019699718693457, -1.7001189686241345, 0.5928269780137237, 0.31816947520332345, 0.31356329322735865, 1.6030554561658457, 0.9317979871645566, 0.8833042284071712, -0.7994931196070952, -0.39237195686406545, -1.3460864942668127, 0.16794289132032222, -0.8001267170891604, 0.19614702187774866, -0.09695949284694877, -1.2567108293794733, 0.1851245197360436, -0.3219510888681005, -2.126051219162742, -0.5392209038980005, -0.4818929504133175, -1.2437650246368392, 0.13540483068821185, 0.13582534548577435},
    {-0.7060947713772353, -1.3003640694476266, 1.6085674986571659, -1.1151042777970783, -0.7129747362389848, -0.5919716142154571, -0.6106768108942447, 1.9332097095683973, 1.1045471158758033, -2.5404061376959373, -0.33893728669480677, 0.6496982805088679, 1.3490267057357657, 0.4491117679162734, -0.29917215326570756, -0.40509450616755716, -1.379121168357481, -1.8930713634655805, -0.07344437828140545, -0.7969916903101042, -1.1305251140984636, -1.2528261335593627, -0.31216298487237143, -0.3141909127312212, -0.584651944803155, -0.7600321351603341, -0.73171279821631, -1.5782568187112878, -0.6551149478611378, -0.9615157379823993, 0.3806020349637956, -0.12376549623636536},
    {1.1397213117146299, 0.3928829055999061, 1.4398648862392376, 0.4376985591899056, 0.6688425849615556, -0.4294407182507573, 0.5344113729085622, 1.9264391898563369, 1.4749664067727424, -0.9389639922559958, -0.3831390093044995, 0.7981837618216909, 1.0699253651209777, 0.9923778187623509, 0.6167591675030096, 1.0188070776318972, 0.24167222585533923, -1.326852663014687, 0.3846426841189499, 0.1893312509629457, -0.9256724673527729, 0.35653172049141457, -0.5660351489485247, 1.0396973955336068, -1.5815641973176295, -1.747372863273747, -0.39795139348068936, 0.3643632552882757, 0.2494946936224342, -0.657639346970166, 0.6661787713544459, 0.9123182237719569},
    {0.061340239243656856, -0.19217820865199836, 2.0801850534635387, 0.06125178833847761, 0.7280248150442287, 1.0251274515765778, -0.23032793583186575, 1.3468383937854447, 1.1738168014643418, -0.2734661558833473, 1.1910014042179158, 0.9988157464682976, 2.248430471686004, 1.4899770746675298, 0.6187349488015509, 0.7890560998870813, 0.09785003174986119, -0.46836724322825074, 1.29012442492731, 1.2893048793628699, -0.6305166319783537, 0.4621873232892022, 0.05158623011596199, 1.5379736807599604, -0.6752916393188229, 0.4041618438506996, 0.7526333868656624, -0.4550617559321804, 1.0659697049289167, -0.0550640685329289, 0.8880343397489693, -0.2863014371495792},
    {-1.7194149006361246, -0.1825143962338908, 0.7973091356782246, -0.7924349436769731, -0.3599293597060727, 0.3780308043315393, -1.2031591309303993, -0.03665761173736218, 0.30488608460259503, 0.1511112990533766, 0.5135285811912442, 0.710170604743771, -1.3700789699881555, 1.5438188603315401, 0.6601469355132469, -0.10729271948498342, -1.4582379219507597, -0.37219167948955745, -1.8083120521958418, -0.6934508923686709, 0.687956643543638, -1.1991463595372733, 0.01441500877978459, 0.3079607761364082, -0.8632030793347331, -0.4802387425467324, -0.6379057026522018, -0.9373429585585472, 1.417334692395206, -1.300903507060168, 0.7479502861774956, -1.0535283104032989},
    {0.5994959705858024, 0.2104764624956033, -0.39809369298754166, -0.40665253495629466, 0.46101394150757025, -1.0331166940925967, -0.1377503112801839, -1.6318901356183324, -0.1920677027117244, -0.9784306399673084, 0.2510430490588073, -0.8694953808946361, -1.1258180051819047, 1.0245345543589643, 0.13312031425022855, 0.37305341924587904, -1.001613451317994, 0.5572605271737693, -0.42362379885396856, -0.18743168269097923, 0.5902492028866604, -1.905804161377013, -0.8474784076165736, 0.049894426090864724, -0.8162261135240835, -0.7333018810784903, 0.659140080672414, 0.11721245373700906, 0.9211948531469748, 0.27865557036091687, -0.2939004120884201, -0.9395028058301065},
    {-0.739101280841455, 1.0298407566503538, 1.039929373121908, -1.5462403660996258, -1.1030411584516706, -0.043935194361345214, -1.3143153474620508, -1.28690713732461, -1.4424229844994678, 0.050818783686731754, 1.081145065971024, -1.3404849576507207, 1.2921112374452874, 1.212049731192556, -1.8982999230355244, -0.3076488300301789, -1.6152365345549695, 0.40134885060196984, -0.644243570197591, -0.24281843125012734, 0.09550459741417433, 0.15256902797990354, 0.3891638388285307, 0.7304338380091352, -1.110578684263489, 0.6631287971062769, 0.1110617941035233, -1.9897666920940096, 0.9295668358345769, -1.4550858325043357, -1.9814903592063278, -1.562420814935046},
    {0.34637020707407945, 0.47829400184546805, -0.37618008787019463, -1.362985879830655, 0.3642758020919814, -0.2628874895892785, -0.13433286535869618, -0.07187348329529053, -0.38289960218095215, 0.8315968102102693, 0.5303841722778574, -1.9637102275964804, 0.25244046880348764, 0.901432947968721, -1.6817912498556828, -0.05317369169017703, 0.33279871653120613, -0.22026716829926585, 0.3966270012447277, -0.767404705605815, 0.5393245281853641, -0.17803056960849561, -0.5753137418222484, -0.3963688558583202, 0.34404662725373336, 0.15948678038089914, -0.9150697467001958, -0.7579052474090731, 0.7721329316432091, -0.1779213464707084, 0.14015999146976532, -0.6644502506503001},
    {-2.365721984534828, -0.18929077910507963, 1.652816492123255, -2.753865574211146, -1.4374431695844458, -0.40860998534260645, -1.6464220122592637, 1.2963553314141252, -2.640378766813569, -0.024128692298318093, 1.7889696318231636, -0.5919914315952258, 0.36967247961957517, 0.336725032463958, -1.412260630971556, -1.9746412809842144, -2.011008220201944, 1.3700110833803774, -0.8677460047457524, -2.276406221534349, 0.07678016456322573, -1.4928208667553557, -0.08022777254258354, 2.309158414341898, -1.171332150304907, -0.6356257473421603, -0.6733680186875073, -2.289714745742864, 1.0135099375999679, -0.9851155139004488, -2.432608028722486, -1.8803874934098403},
    {-0.5636165940049186, 0.911419251902546, 1.161667502171681, -0.6833900470046251, -0.03615197978616131, 0.10054238164391296, -0.13632325736463807, 1.3265122191062677, 1.1142718073406934, -0.20174137339426945, 0.3391222592369134, -0.7272970998775493, -1.2139501408986426, 0.3872453324035604, -0.8577109434868776, -0.535532778615053, -0.48611857513575146, -1.1034354237551334, 0.24284810412227062, -0.4629173270353054, -0.13320215283377895, -1.6996002568502273, 0.7807693726952486, 1.8739217524284626, -0.7587821087194064, 0.9139555647375928, 0.680273345285923, -1.0337858852398263, 1.1455327495031005, -0.5604089782433173, -0.6911733037865272, -1.4739099183413642},
    {-0.8662211839542129, 1.4747998084746887, 1.3468892326638902, -2.0334682080564948, -0.586244816816855, 1.0778937364432746, -1.2297682010100852, 0.7669433858011917, 0.6842003128634491, 0.39287121847860246, 0.29930909313961873, 0.4537084997267273, 1.1840593060651314, 1.372039506497051, -0.8316436513986366, -0.5796978176591616, -0.7566858593827388, 0.8931577233330269, -0.29201339614523736, -0.4063596971214266, 1.6162991111322194, -0.6563234518780757, 1.3605289099924294, 1.7250267505453682, -2.3382961376933737, 1.1178319411656228, 1.068191214893612, -1.4208033165764329, 1.2540446743169684, -0.4654095638249035, -1.0498581305957426, -1.8821340303064003},
    {-1.367072645172725, 1.4254147758639988, 1.8338080203356852, -2.3102928516378363, -0.9643434112411745, 1.5815958054448565, 0.0841682708165778, -1.1029555924029053, -0.10798639099960994, -0.2866025513634411, 0.003457240751410734, 0.775325148753537, 1.2589196600331651, 0.9281961016418943, -0.40356624094171795, -0.15574846181099564, -1.6846530349080278, 1.025738338997984, 0.8908437004870704, -0.24469497831830014, 0.8250660422598348, -2.396051986108047, 0.401398764929572, -0.05472280012595704, -0.1747579116887126, 0.1726553533302414, 0.60528646006281, -1.1526602487247266, 0.9593431829166467, 0.22761118309073627, -1.264360025394762, -1.7872714153428915}
};

static const float b1[32] = {7.874394418758014, 7.80087248760855, 7.662839888753731, 7.797696887634944, 7.8844762890480125, 7.757305912105191, 7.913578242171437, 8.057555860258601, 7.877569375012511, 7.846046237154725, 7.863624651002267, 7.770548907781881, 7.959524001947841, 7.840851612614262, 8.025572813464148, 7.743405746770069, 7.942764479890892, 7.78056849338424, 7.92420037825717, 7.832415958429855, 7.828096083571688, 7.9268126912579975, 7.89821004703752, 8.017269228785178, 7.954569720572064, 7.801322206511332, 7.813403699665574, 7.7711268142673235, 7.94350757418217, 7.871082933264994, 7.785347352579245, 7.834837508547371};

static const float w2[32][16] = {
    {7.080240625851686, 7.280218403001609, 6.9199687733516555, 7.1897465396619955, 6.910613424501688, 7.252712201263554, 7.208530446405658, 7.1644756760285375, 7.148797448999394, 6.954414224256286, 7.350764220658402, 6.876180104997279, 6.932312416198483, 7.367942819422865, 6.948165059561894, 6.637841875973107},
    {7.150968328426989, 6.925214730298304, 6.858850102304228, 7.242737417075386, 6.800664060261709, 7.194712716205903, 6.71344394303929, 7.188299651367349, 6.739797269441032, 6.694014111963327, 7.090984515938344, 6.542263972759436, 6.158280197957488, 7.291285363245229, 7.227950197584678, 6.759081263907196},
    {6.974360282149911, 6.853331686098942, 7.17464691432265, 6.869309351740807, 7.063941635551123, 7.338299217624484, 6.809751699519087, 6.724681624372788, 6.851665092043277, 6.88356031677852, 7.025957310029668, 6.665969657837225, 6.530109651185425, 7.1397894501064, 6.98453888735621, 7.056731758992508},
    {7.319511239817732, 7.311093011135737, 7.238813903316542, 6.770200158770197, 6.797515053544163, 6.763671090237341, 7.141633820510224, 6.699813458473183, 6.774319944004337, 6.498861364551088, 6.894984966789014, 7.145004303086434, 6.443055962774657, 6.931725124852644, 7.044205871392952, 7.045824383428516},
    {6.8978483782512905, 7.109359341087997, 7.506317723943962, 7.008016323324974, 7.175776489611761, 7.090353615882753, 7.195123801545659, 7.251256476182683, 6.998034623680882, 6.839017840286864, 7.529113077058212, 7.05454027396145, 6.428866884581732, 6.97342186341523, 7.39277289956293, 7.272420109824002},
    {6.958852295064985, 6.5428081419197195, 6.627799889668999, 7.261441721477342, 6.953330391275734, 7.186834446191161, 6.9845644592075296, 7.11410217690865, 6.999983544473944, 6.338957823118655, 7.078092532376915, 6.828158223972769, 6.443640169827231, 6.918412236466737, 6.845148462371074, 6.285832748099307},
    {7.344252138515242, 6.879491228550921, 7.395614695990168, 7.360441218574473, 7.318583979564947, 7.348740387717561, 7.218515938632327, 6.9425997597283855, 7.019816473372019, 6.547734591064902, 7.382442762512046, 6.725223764838329, 6.781805687147056, 7.284211778493576, 6.789035524135666, 7.048330329410627},
    {6.770445259802493, 7.1227550350062065, 7.12033410977512, 7.139014573150993, 7.051861164687321, 6.804059943482634, 6.786762537756744, 6.950434617123324, 6.922939483871236, 6.944380694012801, 7.427008039788721, 6.9803350320393, 6.333851442565248, 7.0165325350248775, 7.11970437855083, 7.218691600491564},
    {7.346745910767489, 6.816000372980228, 7.099279998025687, 6.910306378504561, 7.333924804850556, 7.064630449417728, 7.413871857944886, 6.661420415532269, 6.980608402659029, 6.927032492035127, 6.935502722213574, 7.010367326710922, 6.806196395012415, 6.940445476327247, 7.05442890001745, 6.894598199672323},
    {7.327276424454035, 7.337310906338908, 6.6987177568976, 6.865555683086775, 6.959517058737433, 6.718327315350539, 7.209012779277179, 7.051797790739419, 7.157470102845251, 6.421181550274047, 6.954789571046064, 7.065510545335526, 6.834063592524755, 7.122475140488357, 6.663872756338745, 7.163588908744703},
    {7.114012374260844, 6.802123069321734, 7.07694115435396, 6.9759430168562675, 6.754110197674149, 6.949457859165227, 6.633962785104242, 6.70886382600381, 7.055805802112681, 6.722168130806802, 6.5764468030221, 6.801181058825357, 6.756331282425693, 7.129078627260483, 7.2114935113520815, 6.6685057111391846},
    {6.922865717507591, 7.4187819216805595, 7.036687322002489, 6.887459289116687, 7.091444761351548, 7.147402653907012, 6.9032262543516465, 6.851435025461596, 7.252950550201091, 7.040847113094834, 7.133202203071479, 7.224366319798765, 6.7352547422318825, 6.990826861853877, 7.259470590756189, 7.046755647774286},
    {7.39193849748436, 7.011152920688089, 7.228603619796085, 7.310860472910574, 6.865826273256553, 7.246361348275493, 6.792723564978306, 7.182380206924892, 6.814486026410169, 6.441091104739484, 7.474137114313856, 7.07680745516814, 6.571799306931856, 7.035142976385894, 7.04115504712604, 7.052130917557555},
    {6.961074682691714, 7.308229012116001, 7.290038330942436, 7.3890959473186655, 6.750420884868483, 6.767941190292051, 6.803951336422827, 6.872072177811577, 7.031052450179599, 6.8290803808163005, 7.4586068916669115, 6.585399501220266, 6.110462948079711, 7.286368409252269, 7.137918855814813, 6.870715514090233},
    {7.197988777396543, 6.9794828209385456, 6.770986927330775, 6.959706187255161, 6.943912566232837, 7.349103254727564, 6.900906134323736, 7.004594415497958, 6.854300323693568, 6.417045706029218, 7.455015399312477, 6.60044856717408, 7.122927085345548, 7.276267858834905, 7.214642243732177, 6.852605766617418},
    {6.85514486668211, 6.914840506189018, 7.177548558274063, 6.760789142310563, 7.318717427231803, 7.2638018908283195, 7.387379489370551, 6.750329293421856, 6.756832635683098, 6.340221805559478, 6.820652988610896, 7.175464844880814, 6.820493469570762, 6.8548810497751775, 7.012412401959023, 6.979049136961321},
    {7.422612599010013, 7.033551105157546, 7.43444262366562, 6.940468700702594, 7.07062756577669, 7.292568894062274, 7.258406782690856, 6.700996863772514, 6.891158471178585, 6.857862444029007, 7.482181462811066, 6.880485363968027, 6.726686394261924, 6.8753819220120524, 7.025873704493694, 7.23420009111161},
    {6.845290702552102, 7.316434695726561, 7.065382482537449, 7.384246515708018, 6.877065300091368, 6.970170641862965, 7.291531462662178, 7.094526855356034, 6.590044003707869, 6.29030334804072, 7.152200821838051, 6.751745973793215, 6.600221362173679, 6.696295021843612, 7.2981162568513716, 6.8070573846547715},
    {6.943447796608907, 6.918165292310239, 7.078034552350379, 7.0208132238207845, 7.367930375171822, 6.87828974169629, 7.3811194292244915, 7.172788663127934, 7.1811698856388295, 6.674742587554331, 7.398019176268648, 6.913699691699299, 6.417583812523485, 7.016763381820209, 7.315955420753409, 6.975147767111569},
    {7.222541785643787, 7.288958647761681, 6.968272062635008, 6.8400715713030475, 7.228207478411573, 7.258378413053735, 6.8397767995097105, 6.667952759444633, 7.2023580232418345, 6.3621781393186065, 7.359995334153715, 6.756300550669906, 6.779195867896502, 7.131622488430397, 7.05003677529304, 6.773797841362929},
    {7.235193291630012, 7.212026125089884, 7.10874717413291, 7.257927768358766, 6.721484469597504, 6.713480128606224, 6.846911546683268, 6.6583994228742185, 6.861080745631615, 6.895228640174923, 6.808626871862994, 7.090327791903077, 6.576356942254452, 6.867757415745119, 6.704692276073093, 6.7492852727010435},
    {7.057062423033653, 7.210539703999113, 6.6971455696091455, 6.718372435593838, 7.333571261616063, 6.863675329854303, 7.13187748154532, 7.130979482519303, 7.190476739403691, 6.383485538714825, 7.0240304473232875, 6.600155188710123, 6.637214494427306, 6.739542269702185, 7.063335022689128, 6.6652922201885945},
    {6.975487545281013, 6.962949138466033, 7.076018157798824, 7.231188110619786, 6.663029656288079, 6.700214064115774, 7.055107966795741, 6.51914990589583, 6.759645204730319, 6.319188567096142, 6.995609052977422, 6.636104295281046, 6.5571743429440605, 6.658921665963667, 7.163773837726056, 6.5027237066231836},
    {7.083234926148994, 6.720029836656192, 7.035846536499534, 7.211851897973526, 7.2422469950173, 7.0026955865430836, 6.790776969411959, 6.904349847734155, 6.6276062872365324, 6.859108886646472, 7.219733210102164, 6.673183705717769, 6.504366631256544, 7.163468078712791, 7.040456445903977, 6.842555598871749},
    {6.903997843595612, 7.3321575831850705, 7.1446826900076585, 7.26975050099685, 6.75816617811334, 7.003621680781943, 6.866133800131133, 6.809243633433439, 7.149845465793661, 6.892321389268969, 6.905321421465547, 6.958407028334735, 6.326750040814518, 7.236297786460562, 7.292859235640368, 6.717422478582944},
    {7.232195290048068, 7.560122005528202, 7.106348276947924, 7.288596240191787, 7.235505121073212, 7.234030875436109, 7.488014399829898, 7.218272545346993, 7.562616397207499, 6.964251574312837, 7.35907428424717, 7.296194115945549, 6.716816520353373, 7.2423020410103645, 7.076999364744278, 7.187095378791384},
    {7.14234125131291, 7.457402858272344, 6.902669225662957, 7.060643335748093, 6.903333700287094, 7.1039704289950825, 7.319204625850148, 6.985822626707671, 7.3375753462978155, 6.466182273929802, 7.243225433486787, 7.2212868343171595, 6.259519398465767, 7.013135988443329, 6.822305944754187, 7.1357214258287645},
    {6.787218237425232, 6.784349846115699, 6.774605682314219, 7.002540923174998, 6.946913711522778, 6.985623189321813, 7.303657726609467, 6.5757419449025125, 7.09180963136725, 6.323903045743889, 6.697609492112137, 6.972489780292609, 6.559210538167678, 7.31353187103199, 7.151715266145832, 7.159574939561776},
    {6.856210527187857, 6.681970044825105, 6.993831600904334, 7.171771465234922, 6.715887764320561, 7.065985659713193, 6.815301766495668, 6.479379292699683, 6.41694627363966, 6.384385772251261, 6.829687098604027, 6.987675255445249, 6.255831008569823, 6.768429602567359, 6.969043088308882, 6.662707972066185},
    {7.242104581239118, 6.855568628423927, 7.017010204933617, 7.384676745874308, 7.012818431341648, 7.424749957603863, 6.907538066214269, 6.944866962893323, 7.377670285625784, 6.428124662003223, 6.988546821223189, 6.756375945413539, 6.871589833841057, 7.246826180352104, 7.153205404026134, 7.053214572633882},
    {6.925048650065059, 6.740147228388075, 6.994635687881908, 6.709127058376958, 6.765028871560531, 6.874520636990486, 7.137577695019781, 6.938129392221749, 7.220326785783211, 6.45355879390835, 6.989560793293516, 6.4892425052222995, 6.473416781258155, 7.254193511174851, 7.024332257043478, 6.962920832229766},
    {6.903818461909422, 6.946109760854998, 6.6712645819371605, 6.762347715689355, 7.0626323831050835, 7.063453727549696, 7.28540701228418, 6.712511016261303, 7.2832418991222925, 6.5738865145195655, 6.894085018581808, 7.140923111058479, 6.457519852335246, 7.133157943985809, 7.1013344236536, 6.761939936957207}
};

static const float b2[16] = {6.606448965695813, 6.585726644068859, 6.662634900358413, 6.584954856083782, 6.5284209406903635, 6.60302023555361, 6.629008253420755, 6.684975393716954, 6.62409344763095, 6.826512713312766, 6.601246227376321, 6.6966618199561285, 6.639252210865235, 6.599730101130047, 6.627557829824275, 6.632010459359815};

static const float w3[16][12] = {
    {-4.885793024962326, -5.075553061373951, -4.472690731951159, -4.972544178424044, -4.4883659082766245, -5.013976341938484, -5.1012584842507165, -4.461905271584229, -4.273529589715614, -4.738512976147633, -4.786639625580028, -5.27409560746568},
    {-4.616797977987354, -4.317226523890518, -5.099512030099598, -5.2260314347490295, -5.171363070037483, -4.514821745981089, -5.17636185252519, -5.110937415042323, -4.753487435275594, -4.9244876930326305, -4.906806825331403, -4.629176567967905},
    {-5.39089682365747, -5.227883696378329, -4.849706649633314, -5.047401463827534, -4.753745700322937, -4.444905734509774, -4.461762662547221, -4.775574003403643, -4.9768378850786466, -4.583948001818093, -4.4720337812393245, -4.70318999152735},
    {-4.852019590468799, -4.295300798672115, -4.834640104598852, -4.990981602727768, -5.010489281012882, -5.014275158039819, -4.663575998200644, -5.113264252423729, -4.941612776619915, -5.264182557188005, -4.6351872893970105, -5.016090400584164},
    {-5.132326715413622, -4.996384719417511, -4.925302095795821, -5.119540902597146, -4.727516578871819, -4.8063112316667524, -4.976023112949919, -4.883169085948178, -5.012588504521966, -5.314563241222999, -4.595141051607917, -4.493843713990794},
    {-4.491729739799666, -4.959935695039909, -4.563329926997662, -4.887185822759548, -5.0600984444389745, -4.442052140090227, -4.381906009603089, -4.4587780770295025, -5.14609727482079, -4.992195605138079, -5.2286668495244415, -4.653986211243804},
    {-5.263798047282301, -4.596600258324635, -4.426619762053822, -4.973286627135636, -4.531777562932122, -4.624945995337962, -4.28552209340482, -5.039948377845887, -5.142443258006907, -4.636088576604864, -4.621352861442655, -4.901731754861903},
    {-4.563552479066035, -4.7211294417127965, -5.089212857589481, -4.4712844568157815, -4.889601890463085, -4.987491096537004, -4.782784572356207, -4.880244411983553, -4.43833372839332, -4.812268660197304, -5.1958357465517295, -4.370046714677676},
    {-4.482026163195006, -4.739639124279683, -4.444545431502222, -4.433176344998996, -4.948808439463964, -4.927796251412926, -4.838734467811609, -4.450806028285876, -4.282655185599353, -4.535157515640076, -5.28872893721181, -4.9865409562906775},
    {-4.461863870606647, -4.871755632138423, -4.152848269216372, -4.597517612410253, -4.5506025384383095, -4.8584497862719855, -4.813367321665176, -4.640638554531107, -4.638425162537413, -4.647302076830679, -4.600491218066676, -4.704898981396015},
    {-4.938070910116306, -4.4234567807953455, -5.240013474265082, -4.398054485864341, -4.86585869318951, -4.951386353105389, -5.0427021897188276, -5.275576205722186, -4.887199819344337, -4.634983221215207, -4.583037959516922, -5.199883811519757},
    {-4.6095688494553295, -5.083197947910792, -4.238358027651491, -5.230698706698851, -4.542072986592254, -4.9897539559914, -4.681217743404334, -4.98057540624873, -4.407102065685391, -4.347000878054026, -4.802515294166726, -4.540106020365387},
    {-4.397380730073888, -4.126289853410783, -4.864986901308734, -4.444095570378694, -4.544008841697342, -4.1670440476243265, -4.5315737611940134, -4.086579426543004, -4.893173568123288, -4.685544818097137, -4.532133525719043, -4.304929004353631},
    {-4.543079613572341, -5.032049776626116, -5.260958901751045, -4.343923988922781, -4.967553024923174, -4.435182003439802, -5.1331683560067445, -4.873232467827381, -4.866080130667979, -5.302984125044991, -4.912697552416249, -5.300568175614047},
    {-5.207595687263792, -5.041785921643723, -4.855604077681578, -4.5771032541901615, -4.6217631931306595, -5.037385585881303, -4.485755018376238, -4.592241521213902, -4.638892023970886, -4.421658190792251, -4.745143521279378, -4.9509141075332606},
    {-4.498800982418619, -4.898168520862579, -5.133741709707098, -4.604240249669112, -4.676162600963361, -5.164491835787248, -5.049427427415172, -4.767015867954184, -5.09722000635357, -4.553283107024731, -4.560106687382708, -4.396201315057159}
};

static const float b3[12] = {-2.274542984368865, -2.2877492183796746, -3.302808811678941, -3.095605077638135, -3.3017579683497886, -2.858886251176857, -3.15939005845548, -2.0071902540296445, -3.1645614395239674, -2.807049617234287, -1.3201807100240175, -3.3018241900217835};

    // Input Layer 
    float z1[32];
    for (int i = 0; i < 32; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[16];
    for (int i = 0; i < 16; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 32; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Output Layer
    float z3[12];
    for (int k = 0; k < 12; k++)
    {
        z3[k] = b3[k];
        for (int j = 0; j < 16; j++)
        {
            z3[k] += z2[j] * w3[j][k];
        }
    }
    softmax(z3, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
