#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][32] = {
    {-1.8304502574757562, 4.213922054475076, -1.325020898490258, -2.439099073694637, 1.5039022430479023, -2.0794654412161244, -2.3237067346381437, -2.08384874387983, 1.4563665482860884, 0.6342806608905476, -2.3356905347282444, 4.555437832676236, 1.4479342025531998, -0.5376059873024449, -0.5049929159085921, -1.4642364124585159, 0.6752396506901277, 0.7374230464630437, -0.10058749188238213, -1.5903699296937923, 0.582996398002598, 1.5589533737309236, -0.596655402086415, 1.0570746919025493, 2.7640681368877917, -0.10947180852957436, 0.5679719759456258, 1.8944155879503708, 1.0306150563166545, -0.43274174023651973, -1.3023822159586187, 3.1455267204557136},
    {1.3124749628430408, 1.9914678780945925, -2.1977164060536833, -3.207284713485858, 4.377309504391357, -2.3057875121693407, 0.03558568112346287, 0.09951205414287803, 3.75197449056865, 2.265883472987506, -0.957471186327646, 3.340601375302754, 1.2347785171598273, -1.63841226105791, -2.1626441145084114, -3.320667647011108, -2.6429388900867283, 0.531243290483599, -3.8237671688035566, -2.50228438788231, -1.9845582929534973, 1.6562235945950012, 0.9199112508507684, -4.989264569675808, 1.202227899528255, -4.0840305197655935, 0.06293724132179386, 0.93791156460214, 0.22534933851424965, 0.6475519839762259, -0.6276821296305916, 4.42708169109406},
    {-1.463655375263682, 3.812668882267007, -3.236230522893462, -5.264076803952739, 2.3594882626088682, -0.4775351735740899, -1.790831870870564, -3.296885953202133, 4.7300008551571695, 2.59519925709187, -0.14397407458857606, 5.9633483579227775, 2.003868408124475, -2.1343175460426416, -3.436554380939385, -3.9004240376334125, -3.685730374519457, 0.010871876337664583, -5.036956243198994, -5.6322162606023545, -2.2903271920576302, 2.7249820205064004, 0.462431946840145, -5.497176853134371, 3.367821923107676, -3.8429004456851725, -2.3804411173026767, 3.0672970027681394, -0.9263021589562374, 0.3915614834875958, -1.2598727576061848, 3.1364364594692447},
    {-2.9191700434342938, 5.943628713703758, -3.9879352640206878, -5.2204959323529385, 4.536133970237864, -1.0200631589920608, -5.566936291322614, -2.876539232446575, 2.665144254105522, 0.6116483991734537, -2.0156382515812465, 4.281238139422005, -0.5411422646729084, -3.8751648426356713, -4.533309282789057, -2.3392397738156405, -3.6217743934506026, -0.05813027916453504, -4.272498261517143, -4.570677907645143, -1.172347735134397, 3.2854257193395244, 1.0835121431959445, -4.348229850882284, 0.5613118160612955, -4.346537255167452, -3.9258192177346634, 3.977034292010995, -0.35199284493809774, -1.8818444238272005, -1.4033395464623986, 2.4683061044313974},
    {-3.651693783549582, 3.309747807695961, -2.8208150409402135, -6.727360150993125, 0.429322881235278, -2.1219955816419294, -4.810321713262428, -3.5307178495741494, 2.4125909028481813, 0.2991279053753351, -2.906837016503401, 3.0791880172909374, -0.22434261330538693, -3.604947091214589, -4.457890779334099, -3.823690845046373, -3.6165342157328584, -2.789636893746543, -5.505524672212597, -5.106848171384131, -3.6579795146397966, 2.3509522018314626, 0.2928492126283594, -4.693052664239924, 1.5510865665668503, -5.069874780071831, -5.789105160865237, 4.318370140575305, 1.2575617985326764, -1.4124089876448775, -2.863627482008109, 2.4398581599295808},
    {-1.0058109423747208, 3.752605421701316, -3.1850202917097237, -4.8257220778215135, 0.6423777073230162, -0.8069420031162302, -6.227676681777052, -3.4820563237158346, 1.8014515423302937, 0.2172675705497617, -3.9401488906656907, 2.902616155201739, 1.0871332480721239, -5.204568344498624, -4.935449943864963, -1.0321398687445105, -4.1069094412587095, -0.9946175990214328, -5.063428629168683, -4.8087220153961185, -2.4259281412372453, 3.285127061813331, 0.8738087134026093, -4.646951879266243, 2.6987543619035184, -3.4484111690192174, -3.9190590209449923, 2.9940801848739707, -2.1676554150421277, -0.6067153528730205, -3.4206125209339824, 0.20531289069507516},
    {-3.3252827865608343, 1.3201131540616071, -2.85220805370553, -5.924182104422964, -0.10568825147144874, -2.5175012603946727, -5.342428294496542, -3.452447707691922, 1.4943294728047192, 2.349898481250752, -1.5105236816442167, 1.364050581572385, -0.16621417428354107, -0.36431110642012265, -4.419862733525082, -3.2023405910717884, -6.300720403143914, -2.1355126328450673, -2.89359408253536, -4.540885956311148, -1.8472014642187697, 1.9049403054445362, 2.5864830316829495, -3.7130715220464974, 4.450640316851488, -4.903708244299735, -4.211254220908425, 3.137058155412056, 0.35149611310393086, -0.4865129858664245, -1.8826404616566659, 2.5786529812096495},
    {-1.6275050627284002, 2.3237326880459594, -3.811115742571864, -4.102069090288941, 0.098100518065249, -2.1021615235583893, -5.09441261452334, -2.792017845561915, 3.273201569325469, 1.7974662216818866, -1.139006694528357, 2.6595967554170064, -0.48710796179883065, -3.857727024612644, -4.471596417012027, -2.5429818150198877, -5.2222618923442, -4.454511497174853, -4.487665722489002, -5.625763748016351, -3.9164496749445106, 1.77505582323497, 1.4188062210314936, -3.8937715689122183, 2.3634964625699717, -4.233713098363477, -4.464166701125131, 2.224366752268983, -1.418396576190061, -0.3314687349326221, -1.8356951562232597, 2.058712589109699},
    {-2.411088777210037, 3.205993307408979, -2.884663386640765, -6.047262331682655, 1.3367563031982581, -2.917146242077529, -4.3745121934230236, -2.2345748147731452, 2.879579005581876, 0.6869044626883037, -3.1109098492830127, 3.692339362802895, 0.2728857631577066, -5.580723475054032, -4.829037596341356, -1.8921025025393832, -5.974695496044208, -1.7139132990402808, -3.5533107949133518, -4.5223831374924615, -3.306332536017196, 2.4012187939181033, 1.7986144890387001, -3.033729964726276, 1.4983479065189922, -5.2599956979753415, -4.81475267609782, 3.0969726675933975, -0.16838706703294412, -1.1935683497885634, -2.840695227933917, 1.3185709927991989},
    {-2.7277898161057674, 3.8777802073624223, -0.7728021674940737, -5.599546391206833, 1.418381594463231, 0.019999247479230618, -3.5323688241090423, -4.938413668424886, 2.2385006664331293, 0.5168334563549968, -1.3316252346050366, 2.7052835296949787, -1.5244426072457073, -2.9401773167244603, -4.407403447127301, -0.7017802885840477, -4.1484306728933715, -2.033227887887469, -5.108391800387475, -6.144963848332391, -1.1746556693243093, 2.1539770018878963, 1.0458982521884896, -5.1791299953139, 3.0539722424019056, -5.079008116532959, -4.661218287154869, 0.8853037836739416, -0.018228686143074466, -2.95092451262062, -3.143090349956829, 1.7886718519740779},
    {-3.433622458860169, 1.1303379105222136, -3.8486131870079854, -4.051296042127682, 1.5548415956214505, -1.3649445053652798, -3.7155305400755214, -4.392648100537323, 1.03762237704603, 1.4528289802786567, -1.870144700822775, 3.14000097190307, -0.7922482701885467, -5.183789379698714, -4.369530656759682, -1.7574325246301952, -5.95234815529351, -2.7900167190993668, -4.656205241132194, -3.992298697861278, -5.012760002602184, -1.3317030731617887, 1.519546851669981, -5.236113930287283, 0.7304518065837337, -6.68012427660359, -6.208282980963833, 2.139826127302383, -0.8963496968752087, -1.0735829732897224, -1.0558031232197735, 2.4534871725721965},
    {-3.7711052283877464, 2.1503232262122864, -3.8984699560265565, -3.8357648858284783, -0.569973676483602, -1.2195218426619685, -3.021998640032159, -4.749857148757168, 1.1491790420461183, -1.8751578893191934, -2.0399340903530914, 0.41521445477114377, -1.8088109540967157, -4.447999041270259, -4.998914823679201, -2.3651703879067365, -6.50427603132286, -2.6230970425136397, -6.292993787745576, -5.244222427867954, -4.164571379994297, 2.547079785207872, 0.7625040285177777, -5.818600880938896, -0.4565737978006543, -6.714849082824747, -6.048740151608656, 2.8562857416736023, -2.7590336878385213, -1.6182553119705585, -4.063426470677847, 1.8095076472316678},
    {-2.707950109720531, 2.2087815273556197, -3.2364885673396677, -6.438386430682907, -0.6547147766578928, -2.290966376677771, -4.036770237020435, -1.4506022928898827, 3.7618088912233714, 0.6357793186051952, -2.224491449581035, 4.369441775339544, 2.0347901739463667, -4.2400173817265845, -3.8882990472550536, -2.066303621904775, -4.5924972305851375, -4.973006854353785, -2.262799962015071, -5.12541109352093, -4.058658433418362, 1.1810925679434998, 0.10531853828231952, -5.076284179559693, 2.281560447874486, -5.706054851984505, -6.085743388045672, 3.8950325613594496, -1.7143348399681895, -0.6882405100436173, -3.7311393721845714, 1.4084803387987526},
    {-5.410397637020579, 3.1090182911460067, -2.3515094939668497, -5.9427596515467345, -0.4795987397705055, -1.5648004037477443, -2.1172745123279877, -3.285093497280194, 1.6680554810141017, -1.751262582048948, -2.0664653884225346, 2.507629071496484, 1.324455772447213, -3.340531102957434, -6.275422696619538, -3.0743729476021997, -6.306174030645431, -1.005933360382549, -4.750871621198632, -5.552000795002509, -4.536817483835783, 2.044727947806127, 0.5189721082787799, -4.9202353638892795, 0.017390419938280374, -7.235826565167623, -5.404965752113605, 1.845744868127411, -0.30860402614711724, -3.7763937097103253, -2.308375332873891, 2.680036668971531},
    {-4.444084692269074, 2.3698108258339112, -3.9529500161991646, -5.940345440913012, -0.5836067025107079, -0.23276633449005785, -2.7601975950353457, -4.128572111332331, 1.7466050312457777, 0.18597559234148714, -2.3072647727703406, 3.072999250865276, 0.6313243494189554, -2.7467255274259292, -3.497070673425633, -2.478901751557371, -6.347970493086009, -0.46464132500432953, -6.353524635549517, -6.043875997323792, -4.0157373952119775, 2.786514344030563, 2.6754169686445772, -6.328775211173669, 1.8321466444741112, -4.865985349633647, -5.137319017919446, 3.6718601760701803, 0.1266847753586251, -2.6907187702907014, -4.3819894068228225, 1.3042476671593715},
    {-2.6407026045700426, 3.810961845614161, -3.217761090442057, -5.381660422199423, 1.659382343491518, -1.6902228584352044, -4.188954065518107, -5.349158457501545, 3.147764509957531, 3.7054148532774627, -2.0919141561068217, 3.9556088106583456, 1.6100810274537916, -4.700573998412747, -4.32435857362235, -3.0556391452171394, -6.609288391295881, -1.320882611853886, -6.283586728156228, -6.3569557227002536, -3.856702277209894, 1.5512644501781356, -0.2944590513895047, -3.680739788160194, 4.282062269172333, -4.711980534483284, -4.997013972315076, 3.3415709402798384, 0.5161000731862038, -0.884052899250911, -4.344448573830071, 3.137724096003848},
    {-1.7867453995947342, 4.422830677308788, -2.051951543582714, -5.403232549050042, 2.3994232303892606, -0.884401204057563, -2.6280955412056315, -2.027448688279129, 4.14809793391607, 1.1648860424472869, -2.6384364146965407, 3.4298864349129694, 0.7109468839777516, -3.6847573026491185, -5.843974730735789, -3.4877566942631795, -5.230224495321477, -0.14849659396532802, -4.99041430973408, -5.077825590476093, -4.859770529769965, 3.569706554331314, 1.091927588092931, -6.921825523603147, 1.0884312697559317, -4.604395037966232, -3.6933832346215563, 3.303968197030955, -0.17468469279041612, -1.0140551360388095, -2.9935360140095324, 3.549789026244023},
    {-3.300015797186909, 4.05769710070708, -2.4954341643267264, -3.9265331131109837, 2.3128444602641562, -2.0094944848584313, -1.5578030138101235, -2.608153344846703, 4.109396789991246, -0.5405404137482922, -1.069830590079738, 3.427143942939714, 1.4129107829311067, -2.5079493460834543, -7.046121335268413, -2.9095535944834783, -7.223225508476586, -2.790953751404611, -2.705628753233059, -5.658884993232286, -3.3413659180972424, 4.038164290923739, 0.9037813374588288, -6.314451293037737, 2.5614491991019785, -4.559448880216508, -3.513544203691637, 2.0781054415466413, -0.633966717638459, -0.9180924459254272, -3.7157064975903915, 3.9206708351529747},
    {-1.5364912576662166, 5.017986474286628, -3.6794600893954663, -7.008592468781873, 2.181206604458572, -1.4974317889300583, -4.576776621534759, -1.9360047960411677, 5.079123696595299, -1.0908777536422956, -1.7080651404007494, 4.334304715826255, -0.4550081438094107, -2.5245040157706184, -6.908515317942237, 0.21279237873683185, -6.0714845228423675, -1.8724502760299246, -6.3733896521140645, -4.3464262878306, -3.7840558785835694, 3.339748537425493, 2.1720503385302443, -6.510665431468346, 3.9960114548594974, -5.632048294032632, -2.959706587602266, 2.5481301233325855, 0.6857238791016965, -2.6478454960195235, -1.9918714285989765, 4.010073559957114},
    {-2.684975124058691, 3.139006904827832, -3.8082179688593034, -5.275112380023104, 1.7993551375190027, -1.8293773465983991, -4.489267420968412, -1.8521923302633378, 2.0512605442615075, 0.1843756779194381, -2.0897198840117572, 3.564945986711998, 0.4277359803899728, -2.626935907349519, -6.189159034923433, -3.868458130241683, -6.891151357259665, -0.5193611352806757, -5.7541956281103674, -5.3668602694838805, -4.988414008044115, 2.8043112621861606, 0.5467385351538987, -5.538328194054065, 1.3914026651638092, -4.5587974102633435, -3.6307761369279885, 4.506388655353514, -1.710474818229799, -3.69431801755077, -4.568405993192789, 2.3933992027632396},
    {-2.829740304675455, 4.298202330615189, -3.6904406408909347, -4.846056998432374, 2.7285222476373128, -1.3827995065340917, -3.436450734693051, -3.0639892479119766, 2.2325974028663853, 1.3933653951509657, -0.6601855173430051, 3.894349121870719, 1.6678285526879126, -5.538498574451577, -3.289632208643057, -4.098459492636314, -7.154315327141534, -0.12332917833633027, -4.7575678467661895, -5.731396272509837, -4.543951338077785, 2.110162339936356, 2.5663831674978117, -5.40513641551926, 3.9377301091455785, -5.566455630557992, -5.809812297411391, 3.0781048797174724, -0.16449529374100458, -2.523366196443195, -2.963984399709967, 2.443784963288193},
    {-3.9579164875687423, 4.354191029928919, -1.4541401923536685, -5.852238982504675, 3.12770527574595, -1.2068269595531762, -4.001596849935038, 0.18721834072116184, 4.842469230956764, -1.0009327496780738, 0.5175647991428287, 2.742889632868214, 2.909665227730334, -2.1452975273640518, -3.578788025222572, -1.7786183652819905, -5.852501563327564, -0.932005693241731, -6.152060132971905, -5.710565940084392, -2.670522512027602, 2.8433170051680414, 0.5865092036385111, -4.1939803616784594, 2.530671879782454, -3.3626009371976084, -2.8892010742601126, 4.230618744907887, 0.7789286243414181, -2.402490942395904, -2.0521936689545384, 4.500354530154251},
    {-2.2319231113312203, 2.4784174336461415, -3.0537713057710665, -4.458179435601746, 2.7470765949179743, -2.4125646835154173, -1.1062633967486457, -1.9246121872616417, 5.322640282407558, 0.8752272882961785, -1.4734754051211998, 6.763389371506067, 2.352006190424721, -2.395957424434057, -4.363344905231027, -1.8693265106569383, -4.201356460620743, -2.128418829059608, -4.507357312091817, -3.279733164603623, -2.0888379133767687, 3.7523601349709703, 3.3030942373796575, -3.967290053904673, 2.8596825563638673, -4.654253986545439, -2.0673350559939996, 3.89223274763725, -1.7864996696867022, -0.5428942350272312, -2.0990572682716166, 4.394644079284072},
    {-3.877982102548523, 3.0710257043276963, -1.3445185679132745, -5.05258322037452, 2.7480991286653276, -2.4568910937781534, -4.162488658021419, -4.319278724148626, 3.4010884631836733, 2.8961393071470103, -2.2223387143637114, 3.530007999640405, 1.5716218800457498, -2.7452203372290134, -5.1703818823845715, -2.974273159381108, -4.895103640388916, -1.1562244762651812, -4.514257675606341, -5.083857031738502, -3.655204516148081, 2.011434433592789, 3.9577018953499326, -4.457135881668431, 5.031941005119236, -5.685060451504796, -3.35846424460281, 3.785725900658573, -1.2623773311660726, -2.6568630057505667, -4.296090022130968, 2.64323113893838},
    {-1.2890052758158281, 4.146548832732024, -4.345540457896485, -3.534443489708617, 2.858047921277829, -2.5746871499504835, -3.2097088108969296, -1.5399224142184875, 3.8403236157595773, 1.034884354371052, -2.267407211350746, 4.966208894988259, 1.310265142712712, -2.9888555467976454, -3.015576423119215, -2.038784003511086, -7.897910808070107, 0.04442797301317854, -4.946204570291022, -5.174721335852666, -5.8518260885099, 3.1310898807523007, 2.125577991632587, -4.977184403169953, 2.165783642360082, -4.710750520495866, -3.402413417690832, 3.452216156975265, 1.0502944416407964, 0.37274202593282507, -4.000564969518057, 5.0867205253803665},
    {-1.9336131957668015, 3.8874527598711226, -2.0734976283161477, -5.907088327303277, 2.5540175611352107, -1.8938931602181361, -2.3996934919992468, -1.2295058692455108, 1.9820120188694155, -0.6706846721530053, -0.7492732969793338, 4.0741221552668465, -1.1102901754508583, -2.6935715917152376, -5.265927410803204, -2.781926983722365, -4.680792363193835, -2.0935579124977313, -4.429468208146681, -2.2248959544098708, -2.539897892642733, 1.6612874316525623, 0.24472242481001452, -7.684013308159067, 2.5130923374292147, -5.151713120735442, -3.390905525567818, 5.9554858913906505, -1.03402311199699, -2.5797701012683745, -0.7724809746640782, 2.1215359315169207},
    {-3.982627341807375, 3.015629460093056, -4.9086825257087385, -4.485338034169569, 1.554419966851203, -1.5806847893398912, -2.5839475611866565, -0.733237255523389, 5.023376112184205, -0.3102715541516873, -1.3658470650373526, 5.963553117349821, 0.5961170727763385, -2.371991748942786, -4.528992790819555, -3.4664038561855457, -5.6533633950106275, -2.1008606816325672, -5.033359491593209, -5.422936582525431, -1.7193412586985954, 0.9513423123279655, 1.5248187699403115, -4.570882348940622, 3.4222480417372863, -4.68913903062551, -3.5487635234634167, 4.216916194854114, 0.4356099579484603, -2.6874434394072426, -3.9731898726130126, 2.8058890162864203},
    {-4.351966090934306, 2.6683390961557203, -3.0139106279915833, -5.363555394559317, 2.7268431546213607, -3.5567354451816273, -3.227051165429608, -1.886262729189901, 3.576509251520291, 0.5642860236192667, 0.2852418536294558, 3.5276145238342456, -0.7221508782643233, -5.050882652625266, -4.5085088165903064, -1.8086421416079161, -4.216272972714471, -1.660196099953893, -5.865494723119091, -3.9576594858743737, -2.8069928224912015, 3.1998793329038993, -0.014953912087031234, -5.355365453074649, 3.5144634733172264, -4.077854977135296, -3.3096457303566, 3.839705769850798, 0.06746996448878208, -0.6009138602867824, -1.9409974339536902, 5.925337016024813},
    {-4.259346369748184, 3.8420493572124985, -3.741747435057575, -3.75047123982795, 2.5937613546184677, -2.4982581643328343, -2.8861005698359365, -1.1577720618888203, 4.7242474311913805, -1.1386905746091018, -1.3275478302137964, 4.526962324988164, 2.2415571730610364, -4.2557662592916286, -5.190615314098352, -2.7724687068200184, -5.590678303834233, 0.005314965572508671, -4.596054208114628, -2.866489259455736, -5.148102710105662, 1.3541146488551723, 0.5504582650764126, -4.458562393585294, 2.553546241708923, -3.8425652811858346, -2.3530023768751827, 2.1402487209493537, -2.3276319802482894, -1.6681728879036035, -2.658368808904755, 3.050841956751432},
    {-1.770746642201269, 4.093008157631695, -3.6632293643725933, -4.190284857469433, 2.3568161259177485, -2.565448712716182, -3.526376776252375, -2.2914575831803834, 3.978478475558674, 0.6279585143704934, -3.6060027498190594, 4.534435844336561, 1.6817246742916332, -2.7317439968684916, -2.7635450749689867, -4.422592418831264, -6.256056510624749, -1.096584651546107, -6.154885566333092, -6.006070231231618, -3.0324128623905184, 1.7668284814854565, 1.905572918947164, -5.085845842576108, 2.6329788801000933, -4.112741709678741, -3.492545600219844, 2.870895030923389, 1.1634215939724977, -2.1489523215196895, -2.3580063490147465, 3.0421102184012563},
    {-2.42692855663078, -2.515292946657485, 0.5391046125910669, -1.4413713420198733, -1.6558945184553517, -0.48018122969831833, -1.304305814962417, -1.9606166757362162, -1.0820578279262318, -2.3432648447062254, -1.1013117506935866, -2.3665759843013676, -2.665316894463374, -0.9555273407429198, 0.13729472941080745, 0.3605355628685565, -0.8594513817075192, -2.0890111832837226, -1.5958112152396176, -0.6412231004933446, 0.9860248511522327, -0.5353301268507823, -1.253737140831352, -0.7124734357102244, -2.0514395970300883, -0.9991934704645024, 1.7740377019014706, -3.4571262669473533, -1.6160669231727243, -2.739326971634522, -2.38940707682611, -3.103400098520855},
    {-1.0365446864343162, -0.054776056110586314, -2.5927636914025807, -5.0026815115709695, 0.5850648241441222, 0.6725241793584106, -0.6731222187752991, -4.218297880126385, -1.6156510973466673, -1.0758406621046113, 1.0113397774826083, 2.8728290808128474, -0.03433066523782336, -1.1746156309017683, -1.3637802352002497, 0.1756149242732279, -2.3051034154951937, -1.9811859677336554, -3.027595707034498, -1.9232817668049471, 0.850205330957054, -0.3157128972937227, 1.0610658880255053, -2.3461935527275326, 2.1697443577874767, -1.0548285131539452, -2.4939889461924984, -0.014603035127029986, -1.1999054038808283, -1.273827863536434, -1.014834418626863, 1.1441308221609514},
    {-2.020470472945001, -1.4100091845312952, -1.5657934233137767, -2.688264908654588, -0.5476379195652259, 1.4801079052651387, -3.5599041619838263, 0.05981486391792196, -2.4686162301815497, -2.8736856121432393, -0.09672967258710934, -2.201977784467164, -2.2001883575484946, -3.0014516445492596, -1.9415945396333385, -1.2914790007090173, -3.956418993164216, -2.217665691493861, -3.876304662613554, -2.4688585979856885, -2.819147158375265, -1.217693609994779, -0.19385465225536705, -2.438084530155162, -0.7134489652884635, -0.7253360111345921, -1.5580964333971135, 0.613440594063776, -1.4789705400816653, -3.9348899757779097, -2.90967147991092, -2.2221195613036278},
    {-0.757674837381575, -0.9733195249248667, -1.7315628103504948, -0.8979473554332309, -1.927709580532172, 0.6065471945891784, -1.8830409028861437, -1.3732930795524343, -2.6586583890953035, -0.5453660424457657, -1.2673453052102481, -2.4842965483477517, -1.3039345874808221, 0.49193462574979313, -3.615590719937179, 0.2997451440546038, -2.3168729519495104, -0.24171908313776402, -1.2578033987667954, 0.7192849994191598, -2.192517048351112, -2.129321230919145, -0.8417995355822693, -2.245971026532096, -0.11469679679935768, -2.5995797107617227, -3.5537842346669555, 0.20417733897523743, -2.1970237656604414, -1.4970935321229593, -1.5407814165960212, -1.1698339865412015},
    {-1.6995732380161506, -0.29603810022939175, -2.015584931729808, -1.9996479674986467, 0.16494974665000764, 1.1479420489426468, -3.583350762283556, -3.294792952218176, -0.49366660773531323, -0.21160120297342971, -0.9029464924942029, 0.5739631389269637, -0.4324563101114147, -3.101828724409831, -0.4187355119134491, 0.025383715363028404, -4.119938654899429, -0.3062687759492646, -2.3630499780135588, -2.9869322014551942, -0.6159428249474289, 0.9887195439625617, -0.3557169855219546, -3.6741426452428523, 0.2285109765872081, -2.0683114313230497, -3.204138421108532, 1.1685888923463146, -1.4820815900230253, -1.4404408917174745, -2.3721355542024742, -2.005338704900201},
    {-1.161582841376023, -0.7562713138742221, -1.471216065337155, -1.5796676227416517, -0.2373872395657661, 0.3205970748000614, -1.8238444609318354, -3.4559598343331994, -0.6397049596464907, -1.6856477982417148, 2.025412601323199, -0.9768129383800763, -2.2618795097356754, -2.288592624625285, -1.449178968950728, 0.9755964872790664, -2.33166945029415, -0.5892950046950888, -4.854914319264499, -1.2364253575544348, -0.7200775401164791, 0.43390980976898474, -1.5640419363546527, -3.6130378691752574, 0.2556488730371392, -0.9303818961119832, -2.10788807976634, -0.2295144270860075, -3.497520773519986, -3.175939491305017, -0.3277481557146765, 0.8786187089469645},
    {-0.26343436403956527, 0.06630012973939763, -0.66496702954622, -1.0687564596506904, -2.0245200578614635, -0.31816891032897404, -3.0357897788185086, -2.648464459103021, 0.18451742564621973, 0.1854665421639707, -0.6925483765061882, -1.0428162151618623, -2.2279172136652767, -1.4334411296593024, -3.1772447897910987, -1.5461092594674775, -1.9793880857456552, -1.9553911102828136, -1.048206658418814, -1.9175324491782961, -0.3446821974866609, -2.926475859969503, -1.5264467359885618, -2.559588165502572, -0.6112690549948794, -2.9297855530447467, 0.039846595681879024, -0.07213919927429198, -0.022890744833141193, -1.3364296669762248, -0.39992155476291313, 1.504168403258166},
    {-0.31486430666986986, -1.0677305948592681, -3.636625860106058, -2.266442661372044, -1.282916398961517, 0.23596571790177973, -4.826273065776328, -2.4369077091984526, 0.054531980595485495, -1.554409269501969, 0.3907530182956268, -0.3126058812456871, -2.3650475678973457, -1.244010160219255, -3.2816220416905377, -1.12432877714571, -3.642184348212488, -0.3739896003146605, -2.4588126960891414, 0.17980990426686286, -1.636112914545682, 1.399302085949691, -1.1990779641345506, -3.8587692241954783, -1.1425887682004296, -1.1969419464346485, -3.0377617221948503, -0.17675669075633874, -3.4463872820900963, -2.7072363297649953, -1.8730458637710798, -0.5349365622730833},
    {-2.7375181709089373, -0.8627283188555921, -1.5547143798292196, -4.812276962055236, 0.6340036299047023, -0.8828164627614531, -4.774213415982895, -2.1432802806321276, -0.9884960102129682, -0.7700422845549284, 0.6932081709646191, -2.0268822121057073, -2.1079238299173264, -2.534143940989518, -3.12592258261288, -2.1523038261796934, 0.3121928067257858, -1.052721301663837, -1.3699528775579675, -2.8478299012034833, -3.9268605305480038, -2.494436858132228, -0.9977894269485305, -2.8540059971622895, -0.3908784686875706, -1.4051468438145986, -2.919645240424214, -1.5275345878115243, -3.7169866366164515, -0.27498035198552967, -1.9863153449343551, -2.206881956972599},
    {-1.3536915221183823, 1.3722425240827294, -1.6853189372560218, -1.7151984228104438, -0.5819132681469641, -0.8886182325401629, -3.642858724076468, -1.6664621373620343, -0.2616418268699903, -0.3710152248456501, -2.376248855181405, -0.1903253861322542, -1.1723801905040505, -2.438804444882355, -2.2625816555922613, -1.8129406385081224, -5.534706551368111, -3.6644353866994046, -3.832041254817426, -0.8495423713484841, -1.3091589480157166, -2.0153791893449418, 0.3444566483484462, -1.5429967566677985, -2.510177701352389, -2.9625553966798925, -4.319303285773381, 0.4883059832595175, -2.394557446813774, -1.8835521937788304, -2.2536852501941134, -1.4909574990571448},
    {-0.830047157137652, -0.28715684866662483, -0.816369442030354, -0.8963682939502688, 1.5262567730576722, 0.32231899578771717, -1.3405121778492848, -1.7263563780695537, 0.07528638660344325, -2.188788822553646, 0.02611033076209894, -2.663635451883255, -1.0888623624147562, -1.9196403646500304, -0.27595611349357263, 0.6697745585587819, -1.0635889848530478, -3.295276983817024, -1.4773525261292717, -0.8562191227643572, -0.9611228278327802, 0.5751100310666563, 0.6125660426232062, -3.6419588041502853, -0.32721574680386933, -1.5458523582410824, -2.0364991643568087, -2.1959968152254095, -2.238805668702659, -1.2611565887925442, -2.5105115656932617, -0.3958464521379716},
    {-2.917293360671339, -0.39722616212522227, -0.4403543189012284, -0.7261901340723256, -2.188763888190269, 0.06713228264923793, -1.3704099900805335, -3.854086063624773, -0.624550157145196, -2.7497507856724646, -1.035515757491372, 0.1434509189331784, -2.220531704984256, -2.1176028236546736, -2.837430580136653, -0.5794948427613957, -4.915568187477291, -4.045526449629905, -3.1433453989458955, -1.1099819605432997, -2.471451376729098, -2.750979976407337, -2.165559974467034, -2.2971401240288896, -1.5211895543927203, -2.964540001281298, -5.615595237753621, -0.14080306818580424, -2.866948605853551, -2.0737045849659896, -3.4944718956924143, -0.30249947638492025},
    {-0.9934836248886626, -0.94144942457619, -2.5983858244262663, -1.4927981474711611, -0.5541793469756575, 0.5603810364834769, -3.086230296790164, -2.97811504501604, -1.4226906463589815, -3.9873667502496564, -1.8909523934417525, -2.2616594826211056, -1.0461514565758938, -1.093706246135206, -2.9977551173042922, 0.11750256715992624, -4.526027935055797, -4.160164215148222, -1.9778769089335138, -1.928215246131967, -3.471421435865939, -0.3621775804067628, 0.8734340732544132, -4.058104039140131, -0.17812576920961598, -4.053388913416303, -3.3315549044844226, -1.3991187759869539, 0.48979209299092763, -2.2692442499907295, 0.04181088968991587, -0.522602004245671},
    {-2.646049374696351, -0.27910216036881025, -3.3750187060501897, -0.39813783590816765, -3.645985900353253, -1.1915870385620686, -2.029321265744748, -1.5515226995176292, -1.5124846663872429, -4.036188076949636, -3.4715836028855356, -0.6348489959456178, -2.6737440594584334, -2.8727964362371394, -3.8954782766038023, -1.6100788376081674, -1.8682488804514912, -4.601702337994908, -2.777535538456682, -2.5665283893643593, -2.3184388758885164, -1.4137490617427293, 0.5716713804815693, -2.463298693056687, -1.4520168515347787, -1.969453768934113, -3.101276050166986, -0.49117841579476845, -0.26632412933906635, -1.734619443978196, -3.0416084326416857, -0.48320582305630994},
    {-1.5961129116451012, -1.4128753336679618, -1.1805703098828972, -1.2847890990178032, -1.6882680446171516, -0.9692552845308338, -3.230381535823242, -2.4767301265359505, -1.9925141506077717, -1.568410846840774, -1.3671092745057098, -2.416788153078031, -3.892562057173006, -2.124177068525756, -3.1158543987057405, -1.7150018633392634, -3.769046682323883, -1.848888213942496, -2.5113963376049138, -1.2982612173989774, -0.5067103487196475, -0.30721365957026026, -0.8697866088769459, -2.0496216879970532, 2.0122959561165397, -1.7948340209834612, -2.2231254996528715, -0.5631576749902107, -0.7402134648889751, -2.4020887058674214, -2.103915352004338, -2.8812798543619547},
    {-1.7450979237234534, -2.066407318905174, -1.4391902852417544, -5.242403472222454, -1.8984513594083934, 0.8910159944378279, -3.3074976710692225, -3.015052921126928, -2.57717501273666, -3.864952267009105, -2.4817735297373735, -0.11693345134913631, -2.6839351297897585, -3.6296764107277353, -2.729085982825338, -0.08325455375784686, -2.5969038189996847, -1.7661313542417616, -2.3878021936946605, -1.4548851820770188, -1.1579908113906074, -2.1997858971841513, 0.7537764234421159, -3.3137430289046423, 0.5253897184410236, -2.5421510145629393, -3.533347748719576, -1.5276491714237832, -3.4567659806675484, -2.564356903342677, -4.252118220715843, -3.248913737131729},
    {-2.2549792020686033, -1.5298594399396945, -3.5459792398566674, -1.8497087143778215, -0.7979900205036322, -1.6112062485513803, -2.997812880468041, -2.5479024784652893, -2.91538489871281, -1.8836268567475636, -1.992750231949308, -0.3901191576516382, -2.80216575977407, -4.054102916535339, -3.5540966642305416, -0.8529874561139335, -0.764254093755707, -2.3891523115658444, -2.796484583802155, -3.3516463282429587, -2.4327714781650847, -0.7703988188152049, -0.289136147237776, -1.898963315321604, -1.2643490919933826, -2.014605824124682, -1.536320741777644, -2.177861153251162, -1.9719419876416617, -0.7813129438267823, -1.712762321561524, -1.3712808253320568},
    {-2.0877723616445096, 0.8505828188050055, -1.2071275548409632, -2.5868813915483626, -1.497181188886162, 0.3572465002781661, -2.6453413112123427, -2.2411010273856, -2.0161643520367085, -0.30716762601918157, -3.1127674107996084, 0.12942352477333854, -2.936722202702837, -1.8525234760212406, -1.9733623333638635, -1.7972737205633058, -2.382933675957253, -2.6088264993765753, -1.3887056391990107, -2.2223160385538323, -2.3724233743787666, 0.23419318284516782, -2.2265827117117225, -1.7650945801646858, 1.9499692479586224, -0.4111402022948187, -2.743573196541372, 2.5421080047442453, -1.5816198940866348, -1.5032882964684764, -3.283297048345258, 1.3683105280769345},
    {-2.6754840278130683, -0.529092078905783, -2.4613835662213814, -2.2208710618459144, -3.7199818203348562, -1.3470317774604275, -2.268099492979421, -2.5694118635303154, -2.6598639821787087, -3.496588334029371, -1.3724991555699542, -1.3525016303407658, -2.4140135303566375, -1.428450885803889, -2.5212353322184327, -1.130990088975168, -2.8304195073335316, -3.985160786212699, -2.45654040491562, -1.7297912075833177, -1.8451874192102782, 0.29282218506080065, -0.6193303588427477, -3.1622723593423756, -1.9321251536412833, -1.856210900933717, -2.0086852026347572, -0.09060122534213828, -2.069970257080754, -2.4446932043070344, -1.5311784871442935, -1.3993960010667068},
    {-2.650958397121467, -0.5394966845803495, -2.4903731784528658, -4.535189560869436, -2.2495985840081185, 0.3749761635256113, -0.5118522017123196, -4.441331911737654, -3.004110607327371, -3.1315076750257833, -0.4171680079358842, -1.4177877791917117, 0.14115821316841576, -2.390678134608177, -2.7336771032699416, -0.4725396455007614, -2.5051873698409697, -2.8392319951909113, -4.654757808970117, -1.3889841813716661, -3.38489547694616, -1.4722747996723828, -1.6685927525587465, -1.1664239137127868, -1.629313910983502, -3.620009401023232, -6.2504865820346955, 0.5596596301522938, -2.116589393557853, -2.919254954481722, -5.031476581829919, -2.6086446569712787},
    {-3.341979478801946, -1.1926205344898184, -2.3703990693853676, -2.894799027230386, -1.5676087303600903, 0.478071484695339, -3.248275582268212, -2.5910915481546857, -1.6311027345199094, -1.9652627723361735, -2.844073195035188, -0.7623047322202086, -2.729074080929748, -2.1873335644171616, -4.320792932802751, -0.870062238921856, -4.537915922661499, -3.4744014813708852, -3.8145813080920705, -4.295235646662179, -3.151940861771473, 0.04458004202437707, -1.2133621750847636, -3.3951126624334655, -2.363390050237743, -3.770661471277411, -4.105589046374117, -0.6738469952405819, -0.553041537643373, -1.48331533429789, -2.8623494806931213, -2.0484155991699526},
    {-0.48032228215441797, 1.4225527485958585, -3.946151609783476, -2.181108829965724, -2.524726292998352, -0.020278637214341696, -4.609613781181432, -3.7329369637427914, 0.6664992143618365, -1.1606879904775773, 2.3277653761734656, 0.3812927939682349, -4.472934528690752, -2.0027183050347004, -3.9757646114485263, -0.7805208468879836, -0.34444340021422565, -3.4130996059756287, -2.529596402819764, -0.3328418540110439, -0.3237821193494276, 2.855749248623537, 2.8373177204008497, -0.10597942431942778, 1.379120266977506, -2.846763802766919, -3.400327514359945, 1.2536598550620635, -0.2091895917748216, -2.5339928236914733, -2.594894702658289, -1.2698184475240644},
    {-0.37851955652681774, 0.01241308697668094, -3.705507678123082, -0.8562701607070745, -1.530830428922332, -0.24014626613167386, -4.272109946071384, -2.0467493594038086, -1.0906597160010671, -1.5543809595749463, 0.036433104978508636, -0.881074878506871, -4.452608769356742, -2.918612882692673, -2.398316902857821, -0.35267809684155155, -0.7737626308741455, -4.057809752619618, -1.0176654666841825, -0.2018067749365141, -0.7810435462717714, 0.5557220079301963, 1.4728654643304517, 1.3609863064715098, -0.25659526256877907, 0.7762591564288007, -1.288890900628513, 1.0606250935810995, -0.8524724939318851, -2.5262011204404735, -2.469875311715774, -1.4016182867182883},
    {-1.4813945215494146, 2.2719913751937626, -2.0336959761228157, -2.116908293162727, -2.008063669828074, 2.026145571560277, -4.911231001788177, -2.3803084688725487, -1.1235076779604942, -1.3877781383493375, -0.7905144840295063, -2.026014314550284, -2.6729143617852373, -3.749175292952638, -3.135791711316839, 0.2328257437741074, -1.340934970064873, -3.1505405913486437, -0.029399207516535297, -1.5015115553697265, -3.3125257583068772, -0.09166899056510322, 0.8436207737396288, -1.3171266743281973, -0.5816774531651373, -1.75682015038417, -1.5311992301529285, 1.1644885227948392, -0.7237501457337099, -1.9008926478129995, -3.987021857159008, -3.078411089437051},
    {-2.9550076710545112, -1.349639214312219, -3.049817055864965, -2.4933661006967602, -3.170489859784322, -0.08377401373214746, -3.7116535877169436, -2.8095355059122267, -3.7628710109043224, -3.793870167393902, -1.2241595437333013, -1.2616811225534996, -3.952405314028417, -2.6742083961799303, -4.497870100820077, -1.8577827977924704, -1.6982742298992473, -3.72363335928572, -3.417752005099799, -1.9902056055030057, -3.919544254450254, -2.1363595463426757, 0.10198526266540045, -3.1894756767158974, -1.1449924323560448, -3.343671034591939, -3.5531878111583532, -0.8413258171217284, -1.7245300139934117, -3.43509529914599, -2.741473082834535, -2.2646914512607643},
    {-0.3856195061524998, -0.6572382255419885, -2.319061421330693, -0.6475125624353874, -3.398717570729516, 0.3648180733624467, -1.9875261928350925, -2.6814437586668864, -3.384675090586969, -5.121660469355413, -0.6674991523397468, -2.0712281715749024, -4.6836472097643345, -2.4214094616918636, -1.5033904313066362, 0.2410408097546924, -3.376791717093327, -1.6428065493996935, -1.2271505652315375, -0.20768594443077337, -2.9755384684897903, 0.05269495414430347, -0.4151374055885486, 0.27853236293646444, 0.4745210759360904, -0.9975091136976917, -1.3984429766925517, -1.8932332166987602, -0.8694357667148663, -2.008868733372127, -1.6715353092817777, -2.077871247171988},
    {-0.5440020877982639, -0.8918436449152277, -2.8844490627630868, -1.5053802508010206, -2.6450608954745456, 0.4190495442983415, -4.830596130222918, -1.233262202479839, -2.7229613716534775, -4.693052411605394, -1.1229357860119664, -2.1253438794747064, -2.5975903735335226, -1.9455455339869485, -3.965313251042492, -0.33562803090047993, 0.7891312597615341, -4.770840238414027, -1.4787188861297076, 0.5178584768019117, -3.8057952212465693, -1.230503375680536, -0.4910780826797605, 1.6206300986297995, -0.058536305502692634, -1.8442088324065349, -3.394079093446189, -0.09345002462520034, -1.109026675788029, -3.5959562671098073, -3.3983680841378465, 0.8614946000925532},
    {-3.9907647597046934, -0.5950628586492877, -2.3064538410607844, -0.8388632402557682, -1.0762724219770698, -0.8280565834052898, -4.699346644994117, -3.254145941684382, -4.650967834891452, -2.644852906227943, -2.438499216400274, -1.0274250370163942, -5.215750513812586, -3.5615761121107026, -3.2768956701443996, -0.9578505168177268, -0.1709122759595487, -4.821642802441215, -2.765444145447683, -1.0039805628143743, -2.677550581355895, 0.7603431640856256, -2.0216955639605283, -1.9084815516618614, 1.031977426732061, -2.674941046199387, -3.395732429851402, -0.31713098654987004, -1.5427846235770526, -1.5071834330378941, -3.7466442509171634, -1.1500441652833244},
    {-2.496895755792706, -0.0026573472290040622, -3.639481309269275, -2.2035429748618744, -1.033712083506094, 0.21870852023852838, -3.958042697746758, -2.0496577804823795, -2.2196978526720685, -4.7329681742001135, -1.9571880364536114, -3.218126314823757, -4.641761411058488, -2.613527318997683, -4.120774798513543, 0.48606782709749036, -1.3524696349020973, -6.999512914781421, -2.3004749029186597, -0.992881002331216, -2.295394078263846, 0.28660569533788255, -0.3538024209803591, -0.748944893571001, 0.5629298850128175, -4.505861342146784, -2.439650404671021, -0.2116643759734127, -1.4646467653732858, -2.8746264932875363, -3.866157364165248, -0.685087130827469},
    {-1.677055866676311, -1.2537433773737299, -2.1193369899331436, -1.183330542992595, -1.3778483957025163, -1.4451266270110614, -3.7698880580497014, -2.937639096806871, -3.071841747097921, -3.6963629476251336, -0.9583251692598524, -2.7864625821916653, -3.7068720027582747, -1.3291023817991632, -3.740293916988163, -0.12656963835127427, 0.6746007110787078, -4.917672101085672, -0.1467351569482512, -2.4646456353339516, -1.7908352646782864, -1.077412786275643, -1.1055228859331152, 0.022738682543697788, -0.49261547064468303, -1.1849513449710487, -3.7540270752687133, -0.8273379369378303, -1.0360864689648857, -1.8329688620370543, -2.124254969353973, -0.3507995870564988},
    {-2.3872541918904053, -2.0311525311242353, -1.0183261316878263, -1.077711578144387, -1.2484600679151683, 1.0521102865008827, -2.021682670099937, -1.1859304808814217, -1.4176422447531654, 1.6975537524206508, -2.330821023553832, -0.759453838981789, 1.0650049216530102, -0.6687021254393739, -0.7749661032482321, -0.02337845597799827, -2.6938941083861594, 1.2013231078461946, 0.5683874665839691, 0.14914874133742334, 0.286120511630802, -1.9774134734641926, -0.18204076543482117, 1.3357692245926749, -0.6241381530939581, -0.12455415654091015, -0.890042767031255, -1.9583266863836097, -2.571271249258119, -0.6415390800422847, -0.5924461633294926, -0.8102663660677999},
    {-0.4100949249766747, 0.9995378196715206, -2.3926803081440835, -1.4610974298881745, -1.6206401286626768, 1.5238611770594968, 2.0091773142936398, -0.07502272701374192, 0.21632711907603966, 1.9387781658215797, -3.6260934452299636, -2.9220062347622555, -0.9013257495585856, -3.7586062481008913, -2.1214143816521034, -1.631280184555011, -0.4042791243702135, 1.3065067717769505, -1.031261358306705, -1.2729749293071544, -0.8061607226054972, -3.496951942423939, -2.266299038904224, -0.11021510469667359, 1.6548824753716882, -1.7801431952319344, -0.1589367956323424, -3.3924799226222864, -1.6588878086781909, -1.2394339625836206, -2.518406211474678, -2.59720378411415},
    {-2.3153480656659395, -2.3324818143665804, -1.1604366364279808, -1.4999048772589414, -2.1271516414786364, 0.8535685843830076, -0.10628142862968155, 0.18274204127827925, -1.6223950683291477, 0.05933954080068237, -3.545762983555621, -1.3100962280052866, -2.602969137359502, -2.186648821171438, -2.2575870238564177, -1.4157667900649828, -1.015198470302891, 0.9761438982512239, 0.5722328171006027, 0.356410532678392, -1.0831647729563902, -4.296284737541247, -5.3558196046588185, 0.13466189748971816, 2.5380250466759926, 0.04989575043332364, -2.950015916108677, -2.201360630866695, -5.464830845657873, -1.6760588134388188, -4.346118658288871, -0.6488667659957982},
    {-1.3951347051483087, -2.449632444509825, -2.5918219418427344, -1.7085217877263572, -1.6431289329075554, 0.48992228939304544, -0.6086145580502877, -0.827669295463832, -1.5552710423141844, -0.09194580645833189, -1.7532200201421178, -0.8092570431517233, -0.5120986995627677, -2.237169921854696, -1.2878130596496027, 0.4665637351891981, 1.014094749173364, -0.7926141264126291, -2.1602760077374135, 1.8193979000711382, -1.2146534859274523, -3.449281235890236, -3.2700863149008033, 1.1263570927723017, 2.9310170160534352, 1.6567337867042164, 0.43838010815063316, -2.2722440080861412, -3.181362590424583, -2.3438240968990334, -4.410982611432841, -0.16407710715980564},
    {-2.276517183603663, -2.5863453706113826, -2.220076991708256, -2.204175450137216, -0.4998547283525556, -0.15826970977342011, 0.5925385583545356, -1.217649188576486, 0.22311918706740322, 1.0911251470414074, -2.1134399463902525, -0.7028307599484165, -2.7639474743913524, -2.4650635766372053, -3.1473995797906684, -0.7974690179812708, 0.5407343490803719, -1.1346006036772802, 0.12237720606435964, -0.5811001629454701, -1.70259881380691, -3.2973179838141875, -3.8000514795465734, -0.43372142616075643, 0.6194058608891757, -1.127309345966939, -0.41804756433228996, -2.598161775679388, -3.1025601228768678, -2.802139098318429, -3.283300967040938, -0.32615141885730614},
    {-1.4458019432535787, 0.36540250410631636, 0.3597806851616558, -2.7321630496592473, -2.4113378181209084, 0.40104118437004455, -2.3439504021720103, -1.313387174303738, -0.30607879952437356, 1.812273594210429, -5.0250300592580945, 0.5895613752255009, -2.4213709542493844, -4.002546310698105, -2.6249331333356736, -0.08052552505320379, -0.7271385903334057, -3.447868864152453, 0.8133982884434864, -1.1805042069798457, -2.670514074014515, -4.317953727662293, -5.114953085198019, -2.4565480961049424, 0.406643611411582, 1.2289311959686382, -0.9620851255121289, -0.3709670465257309, -5.9949414336876625, -1.8689480497238566, -3.834807133229418, -2.5579837417402116},
    {-2.25485550676152, -0.08696185192352349, -2.3496427110078835, -2.718135827748236, -2.0457759584455375, 1.5695514875740686, -1.037758469875716, 1.1276542349949865, 1.2020574134177038, -0.5482134752491407, -0.780838024725951, -2.3307038940056737, -1.4767325678596548, -3.6447801190742193, -0.986464056541546, -0.14524100664176504, -2.2504367886083623, -1.8504666634466425, 0.29979437409224424, -0.19538559909939346, -3.186931499970971, -2.9112785466350246, -4.589453632296492, -2.981393638342118, -1.6485262819941042, -0.2600535380100625, -0.639195241499632, -3.5254265165162106, -4.108021656665472, -1.9344375031593477, -2.05241385344765, -0.9344261893943817},
    {-3.0633482395025546, -0.6320549414508843, -2.8219359427000317, -2.501809964803126, -1.310966108340433, 0.9188351058108705, -0.40151018927322646, -2.2138901247632212, -0.33822855172705263, -0.7074413828476105, -2.6635065774255158, 0.7312767209886397, -0.17608565818924252, -1.0120934431098292, -1.4857655623151202, 0.8085021806329036, -1.205203171359517, -1.6040436040478054, -0.5277165419439754, 0.047799255537655704, -3.5948267068480533, -3.017089435353929, -2.7912755970185343, 0.2164939725814075, 1.7910872721276414, 0.2253366201868137, -2.1936387367572725, 1.5783661681133885, -4.053700779774562, -3.0345998928061886, -3.2554309410320843, 0.19779525192228622},
    {-2.422268300301848, -3.382360440837738, -2.5073169789294725, -2.2415309277109903, 0.05819901379477483, 1.6861042019329222, 1.8551138683054118, -2.3334404109420817, -1.3874106173455252, 1.2389367647363119, -2.976670950340144, -1.6587016083275907, -1.6896466139402537, -3.1176816743333733, -2.4480901937134534, -0.14104120736692186, -0.3229203346737178, 0.7583494527582021, 0.4892746805783007, 3.056484929541181, -0.2861439011869751, -0.7450849474323556, -2.1747909227038553, 0.4183395709530196, 3.2226961326114982, 0.002397283703782472, 0.5339935593498832, 0.1061829437104911, -3.814533195348943, -2.1725282580325613, -3.5573087916933597, -0.047080477110179},
    {-3.490438215600523, -3.489380157639261, -1.6501349196123942, -1.8828594437187909, -2.8417653393736524, 0.9525273152681829, -0.9566563294483457, -1.301652969508788, 0.7675403144824505, -1.20077507364503, -1.7067692355349575, -1.248839734928281, -1.3150075532830776, -2.967896592283874, -0.9376862795157976, -0.9528433356410207, -0.6098177248528401, 0.39863754307802507, 0.09436149791708877, 1.3410440280548208, -3.771146942025416, -2.1877267091967436, -2.3549688703158975, 0.5159567282646911, 0.8438785002166896, -1.6814898713163617, -1.2070773970514044, -1.7051344067052445, -2.902000733419443, -2.858231959857919, -3.361307070358558, -1.1006008923792043},
    {-1.0031698198121024, -2.3558903082643714, -1.2628168870423209, -3.8043011650109952, -0.7841916375514669, -0.2723440265188748, 0.2547779420288194, -0.016863078133665752, -1.357015926695171, -0.3961088780125895, -4.211222804984687, 0.21185446608547265, -2.218124088290939, -1.0578939632643256, 0.9043335434167856, 2.0047410289965977, -0.9030414570986569, -0.32168682160092976, -1.7795740223373555, -1.4894971601737343, -2.898035951065166, -2.6543658320375814, -3.5192019044135243, -0.5806406454208761, 1.5511947564410786, -1.4152317173162736, -2.607890405289145, -1.1029205445341022, -2.0202195711127704, -2.4289486476195017, -3.675703876986547, 1.1049345699240993},
    {-2.3449788852703084, -2.550158441035869, -4.254874599114057, -0.5480869611073559, -1.3180683046249297, 0.8491274352340638, 0.4723322781652001, -1.1944267417743373, -1.6753210872844362, -0.6580836629227528, -3.3643626891504153, -2.4054104007133734, -2.8344404160104046, -3.2816377890624686, -0.8395734792066049, -0.4042318301024071, -1.5214251661832308, 0.10680411211305903, -2.1928531814359538, -0.6009674154587016, -3.053291783967812, -5.16355761963504, -2.0414365132248227, 0.3245618381830786, 0.6846332380278164, 0.45488647330442716, -2.5147249411889665, -0.32431940662935593, -3.60995371424718, -2.1007645552708216, -2.2691723759210065, 1.7500336029371562},
    {-2.342868603538102, -2.161608997472211, -0.9782131962060739, -2.3074038703370725, -2.298987684936437, 0.44924323689606555, 1.682911280012893, -1.9891829681351438, -1.0849969442288818, 0.9502126834421855, -2.3935589408185898, 0.07720978037034033, 0.1707287154810463, -4.112372510741536, -1.8168768989320008, 0.6389403817193128, -1.9187034966598555, 0.6876560053070243, -1.0765763523262142, -0.9789564071763628, -2.6661893662630813, -4.355512048915301, -2.327641457266212, -0.08680769105213382, 1.5116832169031311, -0.2600376788181906, -4.03087851642366, -1.2203658167528513, -3.6264283750085857, -2.7434393141297964, -2.34284683259695, -0.282998662335027},
    {-2.4989648010858923, -3.0960950908920335, -2.3371918292696527, -0.9119445407606134, -2.8159829204298568, 0.9547774222256885, 0.12776356742120742, -1.543094040920329, -0.8881419823092237, 0.6767111491983174, -3.2911512241241856, -0.7669136096162448, -1.3444220517351657, -2.1045335364450932, -1.5732501356233801, -0.5356408704031557, -1.8112513403161088, 0.5336524731161573, 1.4512273859684697, 1.1580529661269192, -1.8001582351806351, -6.053995415867554, -3.892017740964197, -2.411532303642334, 3.6784922092464902, -0.8180233087578852, -3.7307434652683056, -1.876949343860635, -4.1533948556094575, -0.7138303426733674, -2.5978100028570688, 0.34931733764488077},
    {-2.311645724511646, -2.247193697055626, -2.4946413955902584, 0.4989551922672131, -1.8982049914025825, -0.072322523404849, 0.2621957899001171, -0.06614678447193272, -0.9043628046928406, 0.22811583604693236, -2.7962487897889488, -2.1260862060581633, -2.4654795749741516, -2.8075305275513136, 0.16115520888633994, -0.14658526365211302, -0.2747273476936689, 1.5892414324647106, -0.08304834979448271, 0.3847603270273988, -2.599752080471967, -3.0230472199253464, -2.368226823399252, 1.4677597781457894, 3.1955468062206065, -1.4316340962970808, -3.369831593719652, 0.12165578204516315, -4.009031563901132, -3.85817714533971, -2.774114107381614, 0.5414084104822314},
    {-2.4763517756228395, -3.0730891925534403, -1.237111233394477, -1.3028699800783734, -0.5541564445035247, 0.7605954980497206, -0.8017865824221391, -2.615025519083033, -0.39778669984498866, 1.8849007130301791, -2.596239355457271, -1.388244880797743, -0.2989243640491814, -1.6325366141027695, -1.6069310008800077, 0.40046142717080985, -2.6191144441626, 2.511872117121424, -0.7087479146684378, 0.3578806727200316, -2.654650908809584, -2.2831602865233593, -4.204966112690047, 1.1060782772023021, 2.8679489987668725, 0.5720574790944457, -1.2593625227432619, -0.9075009788512023, -3.8733226546528363, -3.1566643108265926, -0.537701498438043, 0.08031261140451662},
    {-2.2168325536333455, -1.3342057140765782, -3.136835618872595, -1.431077656214247, -2.2974861428495603, 1.0725309425069849, -1.6918233617112177, -1.3098852510013967, 1.778029099853496, 2.3299822819827893, -2.728651365979944, -0.7350249163042164, 1.023597168591934, -4.61875143589762, -1.064696609891444, -1.3194743503489206, -1.0065604817204543, 2.399590474705978, -0.20848421819786794, 1.806054266537291, -1.3994581035566065, -3.1643234107750478, -4.4006650449591955, -0.5125376613024192, 2.30470399633355, 2.0068342923688176, -1.1878739635204387, 0.9779182219662341, -5.114209953768747, -3.7048914267686923, -1.6286572139891862, 2.193689773169011},
    {-2.344398656644466, -0.04801835236169011, -2.300759708558352, -2.0333710195483823, -1.1724099356843347, 0.9092728051601109, -0.7459773655646273, -1.479629212071716, -1.8368868940535001, 3.143900808143193, -1.426998825906462, -1.1929690877523107, -2.3380141618145456, -3.530613020139233, -1.1257685882167918, 0.19699415543665957, -1.629249544704597, 1.1386628232758225, -1.0391714694142773, 0.1582952398837462, -1.741866797088773, -0.6666364608265787, -3.337212649878153, 0.021860499381696964, 2.3189442520843393, 1.2035814184114162, -0.07200431992724199, -0.22577936396783185, -3.5664224438357883, -1.0557020416116079, -2.107007965673093, -0.4239285633804318},
    {-2.6366435733012503, 0.5128010721882286, -1.2084867357553382, 0.1575689390010722, -4.0699991961777995, 0.15444518681075226, 1.8876481769419649, -2.6640526420099655, -1.679622421238524, -0.08033293598241846, -1.5366710501866876, -2.5456559791609052, -0.5223202151632225, -2.6840015902115804, -2.9474155882537767, -1.3817486422260006, 0.2143845299203186, -2.3992817442027214, 0.07381691247103385, -3.666962521652696, -1.3394495789718641, -2.2334660467944207, -1.3194352846523865, 0.913714405563522, 2.8832737350535123, 1.8643734827214717, -3.5825995548262752, -1.4460613502674, -3.086170152837983, -3.2518233916972488, -1.7197970071281268, -0.5850425544062594},
    {-1.556839902416112, 0.316536407368, -2.101452930755519, 0.54382180566103, -3.512595049425992, -0.29546448735808833, 0.8079123249192148, -3.0438663416501694, 0.46042436209507487, 0.959261127986851, -4.411619707381583, -1.91604320041842, -1.2155823151441376, -1.122380094977598, -2.2206410758223347, -1.3690762183411929, -1.4322019679030067, -0.06850855250877351, 0.04116612880968913, -0.8141311995740608, -0.6074268014399568, -3.102792111323304, -3.1971840992219853, 0.5622605715729743, 4.3532816944467765, 1.2892665485099353, -0.051616140580530046, -1.5245260843482762, -5.10413592827735, -2.3677505097005196, -3.3373083321826487, -0.1595056214389629},
    {-2.2752145264387793, -1.4393273511841127, -2.8785528023094766, 0.1575153659828223, -2.320005416625071, 2.309080192759633, -1.0503114242488656, 0.2862261610077966, -0.6852192177124621, 2.290722881632123, -2.397025221642839, -0.9268418567283329, -1.3778611951341182, -1.967428369696868, -2.519556497978537, 0.2867584180980967, 0.45963142880827484, 0.9012328120995632, 1.314372717834607, 0.2671254395917672, -1.8046079395995624, -3.774012301645207, -2.221521812571821, 0.69791556843537, 1.8684269339086823, 1.5025690602623067, -2.4446480444615717, -1.3867706068274779, -5.013167225595693, -1.7052767092962404, -3.446572381116727, 2.1388350445611515},
    {-3.16176144762502, -1.2357602898084175, -1.4229520370228796, 0.38000929283678087, -2.6072981564173907, -0.13053851473863382, -0.39013666419148235, -1.5613725504513112, -0.30128191460003306, -0.9897062879742615, -2.4798911549561815, -1.5023233640857812, -2.06566884527025, -5.248479962737632, -1.7863113600020242, 0.4784763704664782, -2.9856341840865124, 2.353747051829524, -0.22594037551910048, 1.5999813250290715, -2.735310786786535, -1.6196095462437023, -1.908593123909141, 1.8049647084141092, 2.7089790174706407, 2.2371860674039326, -1.4646300530764043, -0.6652855915237762, -3.6319826259959633, -4.677708993035709, -1.052856388895484, 0.9335436174937902},
    {-3.937337274971318, -2.0649308843958263, -2.343824836958171, 0.8907782714506186, -0.028086849934982675, 1.743437936666017, -0.3645239862069496, -1.790985871610112, 0.4396148805578149, -1.008650187380842, -3.650983559263797, -2.0722072387352655, -2.520971281490892, -4.73790526406785, -2.9153276684583878, 0.5050942392042254, 1.3064812119016664, 2.265102220290118, 0.37070270131921856, 2.0385665662832686, -1.9625919321300425, -2.5158943403485647, -1.5040977174331118, 2.4005706108590448, 1.1742943464746298, 1.5691765078781637, -0.7271812726442871, -0.22127535081807445, -3.9354290382315154, -2.6164233127407495, -0.38079423119122074, 0.3251341347053713},
    {-3.13639237114274, -1.6642382314416597, -1.4929021315084683, 0.12354895217559803, -2.1246502786036503, 0.8761821653856349, -0.9368114517937569, -0.9125846202368565, 3.0737694915225897, -0.16766096652203957, -2.861620220760278, 0.49358733115641235, -1.5554080668743926, -2.6692979683406874, 0.040867215210685114, -0.3193424311063567, -0.8058934810011682, -0.1403654671113944, 1.6493283433829005, 0.2022903792433106, -2.7427595438887487, -3.1578647861982634, -0.6441854148828169, -1.1292296596751432, 3.497607395820617, 0.3580286293423639, -1.9363214564775066, -0.8744882063836997, -4.3097007496830475, -1.4227053597343766, -1.561765455796081, 0.7352166713512},
    {-2.4312331386619035, 0.08441512804013254, -2.0591390302467367, -2.2772339057001636, -2.195690313611182, 0.49526129780855294, 0.32847112123556077, -1.6726120011140613, -1.1047436467822653, -1.8684452341209898, -2.925036239353408, -1.4685657166743422, 0.4333658443204564, -3.2373237676425446, 0.3574707507029613, 0.7439139985286808, 0.5543467747576484, 0.5249467045233148, 0.3218869279276233, -1.8540141308758085, -3.1804676260798024, -4.384069388639852, -3.810738657764502, -0.21183689948124845, 2.7309768873269946, 1.7697394685827164, -0.7300164125831894, 0.3566503608217911, -3.353889357891536, -3.093355341072267, -1.724444352983354, 1.9042976191660175},
    {-1.4692678584538637, 0.2070772895916039, -3.3228109318794576, 0.8870469193028975, -2.6132064261838144, 1.0722712651378399, 0.8748756343678293, -1.3882249614340285, 0.06027838637068696, -1.515265357865675, -3.771256277517523, -1.974199683247382, -1.1823025671193554, -2.5847196521273954, -1.6175929241183944, 1.4737546565985282, 1.159727827776142, 1.181513397523459, -0.4635556661859529, 1.007491754949433, -2.3403680227745403, -3.7374657696433515, -0.13242309787060566, 0.2391873833019611, 1.583607421684693, 0.3396961619635971, -3.8024226219735042, -1.026759129197548, -5.159963775738181, -3.0918362498796994, -3.1381517773083374, 1.961508357534331},
    {-4.36395343740498, -0.11446800576257031, -4.106809807033391, 0.5430905409628055, -1.8836784945024172, 0.3157350101515915, 1.7149780679424702, -1.1885225992801498, 1.7756306065115275, -0.679185541610144, -4.080560138349646, -1.8827187362549238, -1.4020921600731517, -4.305439987665958, 1.340457368431461, 0.8146294135695517, 1.8113162897836588, 1.890276745293501, 0.4318299378792527, 2.170887591138528, -0.7159161395018036, -1.4596756875158565, -1.1670024381307826, 2.0876896282032265, 1.3348693201073496, 1.1146692893152117, -3.2155971710349442, -1.7463480651300614, -4.129091779331749, -2.2939507966402926, -3.0206166207725693, -1.2553822297763262},
    {-3.0334610263602757, -0.9413830500380365, -3.4027724056934114, 0.0653347791725777, -1.991220408061135, 0.16103659708587598, 0.29770988108780827, -2.84914632420071, -0.3961576792425425, -2.311429540484736, -3.4699820238869923, -0.15674746787677982, -1.8376218515875555, -1.76080962031327, -0.3708409832335995, 0.8920261166511004, 1.3343175057710792, -1.311345441312795, 1.356332547904276, -0.3604869134466722, -2.4056950266844095, -2.972332058170039, -3.1273178506705452, 0.9763640753529194, 2.195458746932088, 2.168748208686042, -1.168778192944851, -0.6165149943041329, -4.046840412449031, -3.4820260199974946, -2.960550473449312, 0.4031248321155737},
    {-3.7685128862425734, -0.15725134176034888, -1.673640150421368, 0.7502127547361511, -1.142264411432511, 1.772449672115578, -2.3230942825630683, -0.3831211763488696, 0.9784358250474077, 0.3777109730543498, -1.9732479330189125, -0.22183279826647626, -1.3400431894147704, -3.8589904449315395, -2.427997784843463, 0.6705187094541811, 0.34787227287376415, -0.06759728277165586, -0.5125722143592807, 0.5521378673064485, -1.4368386094337495, -3.022146331119912, -1.9472903043536067, 1.7717014773973192, 1.186928241274428, 1.43974779434723, -1.9844346592837614, -0.6014335615838242, -3.578295108664881, -1.580984521236, -1.6183316452003178, -0.5298771646951352},
    {-3.980187859980856, -0.9960356385810466, -2.7665325066415076, 1.6201979439493548, -2.114741893145214, -0.05454089790195114, -0.42979908273625844, -1.012356970741012, 0.9134737770439245, -0.6582479557847438, -4.757468910442409, -0.41048533345273824, -2.459394720503106, -4.020998581248749, -0.7519667325374347, 2.015208380719916, -0.8510770644726247, 2.399452078914533, -2.589535147796023, 1.0136574822525375, -2.7554304746576688, -4.365082432935863, -3.361208937003759, 2.9817304781195593, 2.943676226348137, 2.8054833365303575, -1.1739759321989542, -0.3806420065545036, -4.444919628799751, -3.07290576427912, -2.915410912064864, 0.32125548315541125},
    {-2.4186717182896054, -0.4164222662668269, -1.0717209019162142, 1.4063723736171776, -2.9706105240658283, 1.2539256786691662, -2.4652521174985838, -1.2638846570620221, -3.183422638704252, -5.255542589695877, -1.613703757427576, -3.621421804438687, -1.5113523975547163, 0.6085643690979973, 0.6084703480435323, 0.5400126403236856, -2.0229793540240943, -2.410602975793668, 1.1068982509383452, -0.04585237586435182, -1.7079988078567594, -2.02074206078661, -3.1411044132180934, 0.31462588065889086, -3.0086419479839717, 1.8587507368658718, -3.243661947748285, -1.8045293169588759, 0.37571829402309354, -3.1975521762033194, -0.23811921026542196, -3.6300234526139077},
    {-0.1603138617461644, 0.13243643754317283, -0.9349480038178344, -0.05638055939189338, -0.7433861252224729, -2.042733638757807, -2.9099279886955616, -0.8582045668171644, -1.2611403882697236, -2.556157204036157, -0.16898798945376345, -0.19721436583944718, -1.311077472824849, -2.154882279267795, -0.18341834758811337, -0.8268397245882637, -0.8484554948632321, -1.395196142200369, -0.000626569952894363, 1.449940561926378, -0.5715100761404134, -0.4278994790875717, 0.4264663725033118, -0.7467314665011477, -1.4784060160817072, -0.14091011393153893, -1.7097153724739715, -1.0136748077758753, -0.713242700280456, -0.6069694553969921, -1.201182890986972, -2.03793305999004},
    {-0.4408699193862836, -1.0820148330422397, -0.7554702016435926, 0.06349712428698666, -2.226763394845366, -0.3067942592136246, -3.8971516294373747, -3.0013899511245317, -1.109117669290731, -1.4494175398244737, 0.8610701238742624, -1.5246556720572957, -1.0808381044796103, -4.061421235754468, -2.5093049970625607, 2.3528040868628537, -1.0715551612245688, -1.546828389304232, 0.8192770247273955, 0.9784193932104644, -0.7087297955959665, -0.5592161901456473, -0.07148195955867089, -1.4320177611155542, -1.4942696317279938, 0.33750244875979646, -1.3907037186866678, 0.7483791581942063, 0.4270895551170424, -1.0033491193396566, -2.2240650291167023, -4.433419899054437},
    {-1.8534289345418562, -2.3075414939126278, 1.5108003634689937, 1.2378093156296899, -1.2897878379314773, 0.845324384644094, 0.2910683682435485, 0.06612641322217486, -1.5239241326808346, -0.34129938905461854, 0.4555030486009599, -2.498477362155464, -0.8902528202541707, 0.2425110768894471, -0.6378247006556274, 0.07214114247024413, -0.5173580442344418, -0.34716468060742944, 0.3922500719451778, 0.705809987337189, 0.33948164624271865, 0.17319565689176505, 0.11314466649921531, -0.7128040643333132, -2.638233292484772, -0.11952414770960725, -0.9405309828349202, -0.3534746443044525, 0.1908308863226301, -0.3102393566775992, -0.30244232013662004, -0.9632442828293531},
    {-2.1378144638563032, 0.8724118953249422, -1.389400256562353, -1.5317420091253244, -0.06297956731246655, -1.6439470187415575, -3.485859429151535, -1.8932982345837228, -0.14716484639592473, -0.44867648368489554, 1.0173158057887288, -0.9429299538938622, 0.050664849398239675, -1.3082184234529688, -0.534270994499534, 0.1597538186991735, -0.43942461046303566, -1.6896863263208852, -0.17147326719429712, 1.6768841238050634, -0.471991049749777, 2.280932826952067, 0.14020703896622555, -2.7367995036915396, 0.9666491461962793, -2.0198958191831706, -1.1051452934249146, 1.1750576483184465, -0.9866165831295067, 0.11176510532887615, 1.8428486203218757, 2.129033017462542},
    {-1.0527425244239892, -0.5617909565646249, -1.196527137504831, -2.910274344274359, 0.9470807952786642, -0.3391744843753422, -2.376164884437573, -0.9557831050239841, -0.30760625679387826, 1.0057440304426797, -0.35955280623975583, -0.6245696245760723, -1.0584421511438329, -1.539423326712188, 0.5738669923795727, -0.23849091745619436, -0.26213706171464024, 0.4872551713488097, -2.624194519413213, -2.1780433345922345, -0.5500616351750718, 0.15860020478325815, 0.5353387288981203, -0.5520070089493994, 0.8265095790000857, 0.4272687467524376, -2.6209826964890315, 1.4315069732578865, -0.22396192788864197, -1.5123770142006372, 0.9272915010504137, -0.11680390479225015},
    {0.6504280690309845, 1.608251951461668, -0.07595725957461145, -0.8799928021096628, -2.4812950235612137, -0.49861996474571396, -1.4030237413395423, -5.079955696532428, -2.9303539053539054, -0.2359760024274213, 0.2855274023021837, 0.2266087737100136, -2.4796666750423597, 0.01824349536014982, -1.2396998127380199, 0.7661786954958845, -0.5601244765845823, -0.9350062406938773, 1.5869411578996264, -0.2775106057219845, 0.7793779254418314, -0.06007638449530065, -0.339761080287614, -1.994002801274679, -2.0696971338198202, -3.876387215496514, -0.670904399875562, -0.016546266301743984, -2.1513263547537376, 0.6216369073252831, -0.9524836891576217, -0.18669191376201116},
    {0.5742293831367458, 0.5453741636587246, -2.666026782475078, -0.3055888148615295, -0.5658375076679971, -0.9241175758455021, -4.011549822253658, -1.9993769478968075, 1.000661846475077, 2.57719041358766, 0.9053918869745189, -1.309871273771032, -2.471623343416059, -2.728455212852921, -1.0059899159675936, 0.05216985197677544, -1.467687248495221, -1.3789240538701149, 1.8001089716069234, -0.3005689280326315, -2.41960904330197, -1.0358804708698672, -0.6563504600822359, -2.2492453176597746, -0.3058376823996508, -2.5022868682813018, -1.8128106888089563, -2.4891724628160707, -1.6631471152083088, -1.8646962768011945, -0.9694634124286926, -0.8959416703897992},
    {-0.9672821337764654, 0.33291383429484056, -3.6056432473574946, -2.7995027740678653, -1.8035196698465892, -1.1026999750427076, -4.185240060843686, -2.554203564897312, 0.28409087160005686, 2.258667573888229, 0.9447676162741411, -1.8666786350852027, -0.6966798045513128, -1.5516736001893259, -1.4629957763077974, -0.09709084145500153, -2.8893880038098896, -2.859740998965752, -1.5369465716547746, -0.2981575951725123, -1.0656499180749994, -2.2008160590960304, -0.9860197680237455, -0.8992047528816149, -1.8085400202471815, -0.012766318411427321, -3.4111234913908652, -1.9224934862995509, -0.5740529782651643, -0.5114800937968875, -3.98040555748073, -1.3717262827831884},
    {-1.7715705485248794, 1.0016794328734986, -1.5868153618251153, -1.548584804585553, -1.4195285925375811, -1.6878710657427294, -2.375534063267711, -0.8033175971222792, -0.5925397011448373, -0.6514077611685527, -1.6098985257494005, -1.9420739725221419, -1.544242658797715, -0.8939415758967076, -2.198219356139278, -0.8832701492717195, -2.5555241041240575, -3.9185149354798057, -1.140658378855776, -2.73679245075407, -0.501999256476702, -0.1910356629305787, 1.1719980198420077, -2.6986053398950283, 0.06680652507089888, -0.46395856570093247, -3.46198430980059, -2.9651693411406237, 0.3230306717695854, -1.954941862185819, -1.0843487816290103, -0.7768646648262875},
    {-1.5815812031551464, -2.666233932009749, 0.6917297272340188, 0.27584204518502303, 0.8117845588314345, 0.2560536847019743, -0.8627682257527253, -0.316665600568423, -0.2464037082157066, -0.006499573266486625, -0.6733958953377394, -1.473335789411414, -3.121958989284496, -3.4035435425521015, 1.5766195376848262, -1.494458817926899, -1.2697680041421093, -2.9037371270034966, -1.7943407894418404, 1.5909722038497678, -2.154697770893981, 2.701909151096697, 1.8354194374574297, 2.1968899867180234, -0.7608581844707812, -0.2695356174172367, -0.3310881974519036, -0.5043700086165276, 0.7213487522320672, -0.7760843158053058, -2.1313927760990063, -1.151039768736238},
    {-1.0140201525347068, -2.7774651339580703, -0.9120125981985988, 0.30403642694619093, -1.6749765975664161, -0.45666221599859425, -2.181175326032657, -2.1328304688657873, -1.3141148944352186, -2.5183329590727936, -0.7207803015877422, 0.2536029929889042, -2.847000399126913, -2.195819202888489, -2.9831766027013686, 1.0272444282749942, -3.624015481420152, -2.6111541435345935, -1.1018487834714965, -1.1343173668097026, -2.6940013082884207, -0.897902362722415, 2.3897160334606804, -2.6285470764724437, -1.9870249191658003, -2.837144620734378, -2.1603110275130453, 0.4218017442988512, -0.42667269626164167, -2.5169359989792044, -2.0536286199938543, -0.7715549171685675},
    {-2.578435939186982, -0.6849123710179049, -2.056977616970287, 0.7153434839757914, -2.0024045535967954, -0.301902537513025, -2.8382624230631848, -3.4306150799526924, -2.8813375195490325, -4.139142984824838, -2.1954529365102498, -1.0687409422871537, -2.798685570482038, -0.15232468257414478, -1.7477714974788756, -0.2953973919510716, -1.9895587819196379, -3.1045258004968916, -0.32507570870403685, -1.435023778768952, 0.3345038462210715, 0.23062861770456042, 1.544564040786469, 0.3838356962256255, -0.7549489339831039, -1.4154192103824892, -2.107439167879772, 0.3943139782346787, -2.02791400666017, -1.8438667325206666, -0.12023524622344633, 0.19165430715884027},
    {0.757101800000441, -0.040017053598453346, -0.9944195588814496, 1.2718982984852092, -1.171726496539424, -0.5775006355536819, -2.113466131365645, -2.0945521580422013, -0.8322055820294977, -3.5787434094311186, 0.3660173628971251, -0.5400456881366231, -1.8789108555557406, -1.210767378280536, 0.04961000872957098, -1.244328796920696, 0.3797443937955671, -2.361064400091497, -0.8556812392500206, 0.32642862510216386, 0.22771343444102407, -0.9396737378541588, -0.136314097479682, -0.3794526356132659, -0.832146406908213, -1.8667036685275133, -2.295464059755806, -1.8887732204625403, -0.9555507708024956, 0.9503165013595154, -0.08431193566984124, -0.04835375847595739},
    {-1.6402838125762702, -0.7548555506921767, -1.5805151801131854, 1.1894701264490664, -0.7764313948869066, 0.5357442109877331, -2.9509472910029526, -1.8182788319442642, -2.559589774622931, -3.5399470176326804, -2.725543685367253, -1.6341007838789903, -1.364447207173579, -0.5813131675859888, -1.6512643587339386, -1.12788517105515, -0.18145312466772984, -2.1865528215844927, -0.7904879274695965, -0.007722157271380161, -1.8519459246844676, 0.7296969278868382, -2.0318898781907615, -1.4386008203553213, 0.18927965777851338, -1.4087566984914779, -1.3996073410040273, -3.0805694847287577, 0.17573057676063925, -2.2395419876367795, -0.88904492577435, 0.06712933753351269},
    {-0.5487201154525618, -0.6228969268767554, -1.33919844464324, -2.981683569999157, -1.4670229371914276, -0.10944553755334625, -1.2995414813989163, -0.5946746326903379, -2.968931814788136, -1.978381009899548, -1.6771111811739745, -1.5129519537233398, -2.291269838803835, -0.12314511722081105, -1.7520903740789255, 0.21566712863516668, -0.06374721463230466, -4.664140792078296, -0.09557856544586124, -1.3269439445165552, -3.0118322842849152, -1.4128438899332667, -0.6438653814370566, -1.5770024066913255, -0.222948475987761, -1.9941099429663423, -0.6458711452753056, -3.6880486641419465, -1.5442060796905233, -1.6584464062670499, -3.014427523875526, -2.261810247150917},
    {1.1489946222587908, -1.5455151036106816, -1.7773833647427142, 2.327400326080888, -1.8899610870444148, 1.0553347637032402, -3.7820862999263443, -2.1407181144101375, -0.8615827355549062, -2.6780373974973393, 0.5277108212203946, -1.371792161212137, -2.6252621356048618, -4.0538864959733, -2.3825374568305646, -1.0121293288235864, -0.39221605458120007, 1.3253800373804567, -0.45130816562274473, -0.5942645413719946, -2.828475666955392, -1.4063219826508593, 2.0960617973760938, 0.11029216399276637, 2.2142958775063875, -0.03176052843406933, 0.24701678702520047, -0.1008244210803254, -0.08554385749844905, -0.537997866722474, -0.5539927242391525, -3.021093422965641},
    {-1.6725496164885763, 2.5241183489779955, -2.0688809456137442, 0.7999054176926257, -1.2646800004706875, -0.8046536895749721, -4.6771251742874105, -1.6697958397939316, -1.3882200279974812, -1.5910183871430226, 0.41147238661315766, -2.2927679029010277, -1.6426134609981502, -2.689686160242218, -3.302949504499257, 1.332397614381223, 0.6599710296823086, -4.67676676839105, 0.4670995571303375, -0.17587364348206486, 0.25691682526411946, -0.5868974942841305, -1.3812239169824994, 1.4411355912147186, 0.6666416190630154, -0.04920346138705325, -1.777188751097583, 2.200652938011037, -1.04796145282867, -4.071817352172976, -0.9717713187941154, -2.6343692988669254},
    {-1.2094680935440107, -1.9906479008441307, -1.617954595389753, -0.4444093328834294, -2.1829924214898395, 1.834705219825652, -0.7674954477903277, -1.432520005515514, -3.720672708968905, -3.4423764768570213, 0.4131653465916752, -0.7753870797491877, -2.270249063285004, -0.18389192165831733, -1.7802274475909163, 0.06907980981995465, 0.8749132443586305, -3.3466942165684714, -0.8039725791519131, -0.7596760485891418, 0.05349022823406597, 0.34321801602835406, -2.0752602125159205, 0.7552037623148893, -0.8566841201810824, -0.5171110552758766, -0.008605982040496904, -0.1721969039921148, -2.040445146602314, -0.7839505700265569, -0.25996476112806055, -1.4315969233858232},
    {-1.693119336180483, -1.6508946435245104, -0.4946782744982959, -1.5683784368041185, -3.419239550043264, -1.2985668541812903, -3.56332195927274, -2.372695641204379, -3.2674223594556366, -2.5955757440032863, -1.7698052246865104, 0.9109778167483628, -1.2904331438953747, -2.6553719875430732, -2.6689820505567865, 0.1420867593212219, -1.907615337253773, -2.6477618773332043, -0.5673275071592148, 1.7340193270087518, -2.365657056673785, -1.6779177685031013, -1.490072611048836, 1.260773035582719, -0.2784399293592002, -0.4279927978850618, -0.5947550668125539, 0.40323645681884407, -3.1905552213728865, -2.382055288199568, -2.7938572037669367, -1.0650851787722173},
    {0.7120967195473675, -0.02533367043155488, -0.5243460642839889, -0.21069274894493764, -1.274411138835502, -0.38068739145391833, -3.4903990556015505, -2.2653166311665363, -3.907721156101298, -1.8701328284536562, -0.4326206929838276, -1.953967526229856, -4.861498772876817, -2.018618228404427, -0.9525888462950166, 1.9425215434875371, 0.9728096739090684, -3.2067028868135643, 2.2735852663735048, 0.6545485011930224, -1.8337842756266989, -3.185538527546892, 0.9405470319956231, -2.244632334814279, 0.8707512967535963, -2.036937187250833, -1.4480320416020895, -1.1567399550270423, -0.5978126590643726, -0.766718350428488, -5.8642571765585005, -3.1159252191674756},
    {-1.9272950638277404, 0.4762001670150858, -0.18801914810933218, 1.4951098405677459, -2.1703683543493133, -0.17084894077095253, -2.3026301920663177, -2.7077613218303815, -0.5167568252649577, -3.7822695927392322, 0.981386467620243, 0.20315748776086712, -4.412059262058083, -1.6957995825167524, -1.7545114131061, 0.26401528336953706, 3.350954545937921, -4.326937673939317, 0.1531818062061349, 1.3126147693741064, -0.0795495381870587, 1.1622523470054704, 0.5554736936933634, 1.832710706370754, 1.4233379528254415, -0.5624607447119604, -2.0080760207517807, 0.8573781602080647, 0.5625881044448906, -2.465337847646474, -1.6977903606747384, -2.110047568281281},
    {-0.5670657325809214, -0.7760242824082904, 1.9287950427922742, 2.768392788407304, -2.08372440095446, 1.3753359712240874, -3.4069395197869548, -1.605737092352912, -2.0089158724717886, -5.094444887051574, 3.1116826340992194, -3.934828570272588, -3.2187432430238165, -1.0031052574879682, -0.4236476219870941, 0.6758562627703074, 2.9577361213253064, -3.378005252843661, 1.7443331132690956, 3.0178309466680746, -0.8670265067436258, -0.11631782154742817, 0.04796802379044791, 1.8830955194357955, 1.2884299587517485, 2.517317626482748, -1.0443325525689204, 0.11854452268668027, 0.010919360566388139, -1.1626801671240825, -1.2480934504452106, -1.7616174983193102},
    {-0.8274961084145928, -0.852647078651695, -1.756170963441933, 1.0372311279135558, -0.439651320694387, -0.5832983990697573, -3.4164979348588527, 0.02082704171115028, -4.395024605086597, -2.255392719876171, 0.5327563246033954, -1.5265070298958305, -1.7291190100060565, -1.9535671124231173, -2.0503913955172326, 0.5117480114486501, 1.2512716434094668, -3.3668973897319114, 2.153583778972927, 1.3592440244334252, -1.6946188333731353, 1.8499153987802912, 1.4628488461434885, 0.7986134240651828, -0.03555608069982143, 0.8124367872705812, -1.4311669551736637, 0.5744987608798553, -0.41156454925266467, -1.866956872041277, -2.010631192562935, -3.0443443170540707},
    {-1.048392498892457, -0.28161425868319506, -0.6793714817995427, -0.5171633018152498, -2.358524039058516, 0.029301274491428303, -3.721136320620067, -2.8873101254441607, -2.6022756795176045, -1.7891092958245571, 0.3825478226652286, -2.3642353704116545, -4.773390878954329, -1.033172426686189, -3.531077132735058, 1.6374365812369698, -0.07154613779066069, -5.7761613392967615, -1.1338183460395619, 0.08722420477114061, -1.444775128496516, 1.3923720185483242, 0.2769078623212007, 2.7445189202674944, -1.294984027012935, -1.2973135936388709, -0.6277300867926038, -1.0287862710027813, -0.5541617959380054, -0.9175539516768175, -1.9972292320368898, -1.300188153127623},
    {-1.794413134746146, -0.7745650764198035, -1.047370568416719, 1.8741098409410029, -3.4640637370396545, -0.03558893855814198, -3.577031388265595, -1.1041994320007884, -2.104660815484216, -2.5342667769793144, -3.673694918300234, -3.648489773481802, -4.487907024236525, -1.8915848906882515, -0.5751958693071683, -0.08185853676968186, 1.5391857716519595, -4.038145268629637, 3.0009840406504185, 0.3887166552445728, -2.72541414636852, 0.4205024426516275, 0.47177676366237964, -0.12399909265783901, -0.1504776951167716, 0.10875652950914058, -0.06117230090255888, 0.5649051217899238, -0.31488630335836715, -2.2867412312537128, 1.3955394311759712, -1.7825281966124846},
    {-1.1514113579907703, -0.7471878781923453, -1.7963027742536601, 0.6566886537419179, -3.5207194260563663, -0.8354621257259829, -2.649351105447487, -3.28705863793301, -1.9079194568854967, -4.898667805394983, -2.144816429690822, -2.5519483692344656, -4.459363214726228, -2.0124378682309505, -2.0808118015417087, -0.04809106272375623, -1.2286223331269124, -2.9579174921561457, -0.5325081916610312, 1.2033854937568547, -1.4152970344597977, 0.5802029553358685, -1.7600818640326037, 1.3098345401641902, -2.358386329128004, -0.5527644630413697, 0.38953575721163713, -1.1341078848727522, 1.3824054208319188, -3.8706703317137525, -2.8897562782675776, -1.5873698761324457},
    {-3.5493557819668067, -0.2565289397339655, -0.4201790337798916, 1.7708133462715818, -1.8588824267856947, -0.5858124785985429, -3.5631316116774654, -3.286679893563864, -2.929497385782277, -3.805012866064674, -1.1493934474971423, -0.9717547349225656, -3.0248813389830884, -1.1965887181038917, -1.822422796473094, 0.8431122461973546, -1.187857638885984, -4.33904000194133, 0.15066606842099242, 0.8322432964354461, -1.6234551946731393, 1.2360555910275515, -0.1761493979798742, 2.24316886399094, -0.4457186372103095, 1.618674766185736, -1.9646020538486428, -0.7193853415756584, -0.851589477302278, -1.6785165108441438, -2.2161524601648357, -1.6274338386897984},
    {-1.735904648153757, -0.826543996126944, 0.5454110066076397, 1.672063123392195, -3.547757385291882, 0.33914825594802644, -4.058122919951206, -3.696372408206455, -2.8419226891128133, -5.228172997562001, -0.17990914058325622, -2.9893318656923595, -5.6838361913732784, 0.7238501132901269, -2.682595909475031, -0.8867745415627926, 1.1193477470779643, -2.9212962495006902, 1.5081675298986572, 0.9458579177284321, -0.5189857218676337, -0.18088658811422353, -1.0456630150768342, 2.082538102587024, -1.8686976411358152, 0.9960167864950855, -0.3818741093692286, 0.10007279787729802, -1.537509160067803, -3.152744013865781, -0.6334839798757111, -4.15847571426815},
    {-1.3204092235580942, -2.3059285906911673, -0.26740396578987163, 2.1505412579545053, -5.173738450615509, 0.4916583851922266, -2.9593096954488556, -1.237042870383495, -2.4902503017188895, -4.667355539142126, 0.2809909879438739, -3.495574921819236, -3.52265328904441, -3.0874947937788897, -2.159505723229811, 2.755073387914203, 1.1895166434030273, -2.2173415943822583, 1.3493684684883622, 3.4617614761974953, -0.26888820019173076, -0.8344433003731558, -1.654107372285814, 1.9400809574701423, -0.015565225880833044, 0.7542926262756705, -0.8298826887757355, -0.771253203586946, -0.39716258522242204, -2.198390387479098, -3.6810763723958853, -1.3942180102930155}
};

static const float b1[32] = {4.367632719089438, 4.9155477065547455, 4.476647630249008, 6.349390379503991, 4.003257710174526, 0.1825140904335703, 6.332390967429734, 4.700523656329217, 4.957439747847905, 5.6149596037743565, 4.894862407043652, 5.022490139714424, 4.853817092924262, 5.143007563187451, 5.591344684371282, 1.779054761908292, 6.759672132438262, 5.654143052399767, 5.82121091854153, 5.4736855590704945, 4.589519654118558, 5.670983976363229, 4.84333678193834, 6.001067774813587, 4.751756835731514, 6.491121601065895, 6.601861882190671, 5.050616699524644, 5.819415757476127, 4.073295660477674, 5.380815541459516, 4.664046884470688};

static const float w2[32][16] = {
    {-1.3890430554393107, -0.21547557914677978, 4.1383053809947175, 5.147409645651262, 4.1446774187669, 0.9782118334909952, -1.9408212374422706, -0.8203307648476016, -0.8408393652396838, -0.6654263410001486, -0.5971196002767553, -0.1348881837117385, 2.565308708945253, 0.2733492319149447, 1.138511862072442, 1.59505428137041},
    {0.6148017613787042, -0.4379228930892215, 2.842264248500976, 4.227704742817974, 5.531769176884781, -1.3744724040586453, -2.80571990405004, -0.6042824458213459, 0.35154851907391726, 0.2983018291700022, -0.3438226818935599, 0.07268117611806141, 3.135286701937444, 0.3764314750129427, -1.178586246671121, -0.7354255888947757},
    {-0.09149142684308516, 0.12661103968859147, 4.584658350854008, 4.825172392009747, 4.366681576747444, -0.7675114282745928, -0.576354150092095, -2.3298684339503692, -0.9579139190477726, -0.6624166255411569, 2.4836274649112347, -0.1446046993801043, 3.040576678683811, -0.023061903179707702, -1.8891743226527873, 1.2761787880094155},
    {-0.3993036936574426, -0.1724841016724634, 4.437367310402166, 6.569697114436589, 6.836854123260761, -0.02135657163112511, -1.1182951257287992, -1.0368645500991014, -0.31295442954306224, -0.9274442801851845, 1.814590624685092, -1.6997106776449327, 2.577738262589338, 0.5236981295007064, 0.03575859042209298, -1.2274732582730847},
    {-0.38797150976509076, -0.6401384180183831, 3.325952635985637, 4.4031532323231275, 3.7986760024696604, 0.08133150258320751, -0.9933260491275638, 0.2029635561919666, -0.5502692152567109, 0.23957565952630025, 0.23254670576740863, -0.6231823947762234, 2.33922152679495, 0.5208718724728364, 0.6991212495339018, 0.3686513631490912},
    {0.28826923299132656, -1.1938756337982332, 2.5340451629304868, 2.3399891752089164, 2.2915784626665965, -0.8358766585578745, 0.5769980802774127, 0.9274453562081622, 0.3624020375333106, 2.3841046366340155, 2.8426492647279487, -0.035149308910104725, 2.7618901056278125, -1.6840185323878796, -0.623565203853791, -0.5587454282565079},
    {-1.097390665371521, -0.571714291451087, 3.5719058826661056, 4.592578361713647, 5.780917607172618, -1.9993868239974029, -0.5647414680115987, 0.5278092379127213, -1.1241241992692004, 1.0033801463887242, 1.7090730059843853, 0.3491825764542952, 1.4962066184076135, -0.8489268443432539, -0.9332791310110896, -1.8641237267207647},
    {-1.5749002592282968, -1.1080751177723258, 3.980805799205365, 3.740630874655475, 5.129729874707895, 0.7282911994553313, -1.3903100089886604, -2.0322463590416198, 1.6052543408651876, -0.9729713611969109, 1.532636592139192, -0.32445543460833187, 2.569556004505857, -0.6855979634991779, 0.06281537171598557, -1.5979640763920033},
    {-0.9602249378900357, -1.0352196771628777, 3.2110581516501524, 4.340737238101814, 4.205698252496326, 0.4043558442977918, -0.9619645207293519, 0.2870857996212091, 0.22551306382985492, -1.36613593247249, -1.3617174618803514, -0.7489376069202759, 1.211281762787059, -1.1674668327812388, 0.01728601393574181, -0.8229298221465624},
    {-0.2534794628230635, -0.6993309667114771, 3.003426571230288, 5.139885880189904, 5.259435089950783, -0.8699610241673461, 0.20814903306981153, 0.8399189944662778, -0.1257385210450471, 0.8242906814696106, 0.6089292799388493, -1.7668058066239167, 0.2359291351298062, -1.4169334572441328, -1.0617234473858777, -1.3522455336813228},
    {-0.8581694420928735, -0.5234300993203114, 4.286278058530682, 4.126796214020577, 5.100708732326552, 1.8293454551945048, -1.692971807992992, 0.6341279960604675, 0.33299642140791724, -0.932398119378284, 1.538004778503204, 0.6976738750595545, 1.9252078815859817, -0.23045549937140594, -1.375375625535411, 0.14469585697265602},
    {-0.6829009816249934, -0.9370389212101567, 3.1399742155301316, 3.2657006588543465, 5.1391564504557605, -0.5963538661630742, -0.5695149719363973, -1.186401076223941, -0.6058120698597272, -0.722468675191504, 1.5653693948338692, -0.6013424743823066, 1.7279765571810646, -0.3205726310416481, 0.2917734708218027, -1.212057928353511},
    {0.6167861617460039, -0.38933061886082965, 3.6943304930888976, 4.465539779336428, 4.526963787237424, -0.7746465828640358, 0.4292131414327693, -0.34788642333385966, 1.4479977348629676, 0.5815168079326817, -0.6662448361648812, -0.16664011398624684, 2.1382960518580685, -0.14051212001637686, -1.5042585386364353, -0.16308609925998085},
    {0.7384443390291885, -0.13452639799284016, 5.2998460385997435, 6.1291111989847735, 6.084281878747497, -0.4669370714939426, -0.513571319214695, 1.0976028346253528, 0.19620149226188868, -0.04178950085300533, 2.8566831416913776, -0.6555501823864767, 4.129342711465148, -0.6023997982662034, -0.43037902582844995, -0.2396928445102728},
    {0.2979763990992481, 0.8841588674842079, 3.6236039711592842, 5.0056742349014876, 5.894884263410398, -0.33035210979726415, -0.7765776326739565, 0.4213125141685871, -0.29293834973091254, 1.5862664614391777, 2.357305588029925, -0.6937382940426836, 2.4946383216058265, 1.7128253416701091, 1.3165311249722988, 1.034564294528576},
    {0.8216936050427078, 0.26899401862282474, 5.6265609439349955, 2.94221358784247, 2.5978024917705724, -2.4791243749840577, -0.16200872593726734, -0.04674766595887022, -2.049452290263369, 2.127927695714937, 3.941023341547151, 0.7435587755602024, 1.381299339721798, -0.513346896585493, -0.934169483034517, -1.0434464834677457},
    {-1.9276702230032061, -1.1469732026125958, 3.6519419025311035, 6.455159707944497, 5.566695036880638, -1.4627107400198918, -0.9158630350629852, -1.8086592604995573, -0.2585278445186311, 0.4873533182322372, 0.7385241409681002, -0.4300423614680501, 3.5234088891016233, -0.5593174790061366, -1.0009115771983743, -0.5821089349376746},
    {0.043382132814509956, -0.38699574926484703, 5.52627930441658, 5.726789931095853, 4.778542450849341, -0.28232389298778326, -0.5000377333157724, -0.9394497636793778, -1.5284094903870908, -0.305301089824594, 2.362597981117865, -1.0986792806318084, 2.9745956826122795, 0.4657467489669912, -1.0534716410365925, -0.3228330120455651},
    {0.8501014496525658, -0.12549797227971907, 4.210138177952576, 4.89037763216162, 6.546011372480987, -2.5528771415872247, -0.02724421213044606, 1.9612636511546864, -1.5406027481770475, -0.016649356044657636, 2.302603622929463, 1.209894196311459, 3.9189736064655047, 0.8769557437835018, 0.1258084803022989, -2.665939616594332},
    {-0.5238127592759366, 0.8271119173812951, 3.95934706746918, 6.1473740837108, 6.852156488506902, 1.3331442116288312, -1.960384133034787, -1.7148407244048378, 1.7717951857289156, 1.2432066088646694, 2.2560232341789117, -1.5094495303297193, 1.7660453842997876, -0.8293700951286548, 0.11583541842778586, 0.6064757422697167},
    {-1.3447136797394275, -1.2473203327352715, 3.75490213097493, 4.757309653384946, 4.359114772127585, -0.09646529088169689, -1.6131980403525235, -0.8341508392713055, 0.41808729993848903, 1.0990617066922457, 0.9821222876677866, -0.9491753309081188, 2.668139889460726, -0.4542698257349786, 0.48338915178062897, -0.5577347350657487},
    {-0.20734137498822952, -1.9355310746925454, 2.5546947248124887, 5.6762787206857235, 5.6961282968769655, -1.9876717776404333, -0.9939325492638376, -0.8154293476642435, -1.335040058450542, 0.32585956011956707, 0.9023048653122795, -1.122797102355586, 2.5759668362388233, -0.3022449412408031, -0.7004814634443568, -1.321833885855433},
    {-0.44548064468728205, 0.3940411571683671, 3.482397358566012, 3.6204018727238276, 4.411977365091228, 0.10672633215281777, 0.4985053282433763, -0.5109478594486897, -0.7568534276042244, -0.16291939521093854, 0.02762927834308643, 0.8837014706872635, 1.3825362332801343, 0.19153066722827197, 1.096832215870136, 0.6557334898249657},
    {-0.5217750064364916, -0.2524237216072054, 3.6799854406988177, 5.421324164519939, 6.212218752024561, -2.1246735303686384, 0.334345266701244, 1.1857668955749179, -1.0379112743399352, 1.094859732212166, 2.6784753229379477, -0.021880329399236325, 3.5872550736520146, 0.944307151671666, -0.6491378092071348, 0.32266201150570567},
    {-0.40075430298942283, -0.192822202543732, 4.897270008096854, 4.445664208242048, 4.56434435794826, 0.40641867205922255, -0.48720249351986183, -0.1935160994307228, -1.7717856978150517, 1.3123968170321838, 2.1524801087783065, -0.7523392219448438, 3.678478612601751, -0.27894180332072016, 0.19218244537252996, -0.8597226516471047},
    {1.1749435691415584, 0.1222125225116305, 4.815950914811886, 5.045765682974158, 5.255108062572247, 0.30159136413249554, 0.3987894568832491, -1.0569778704036432, -2.4251067194960934, 1.7223694454074716, 1.6508814353720898, -0.4189831624753531, 2.730162551940166, -1.2291072061202208, -1.3289690948163773, -0.10158090597201044},
    {0.6371268346952704, 0.8089889442172519, 2.735819371650923, 5.313149892355424, 5.9555790793968, -1.9301142783092113, -0.4663449174489269, 0.11981849215306914, -0.5362323410549292, 0.39815441480910624, 0.631835790037432, -0.09502224732007492, 4.24056690138035, -0.5173235627611151, 0.07373720456505067, -1.59477501952774},
    {-0.19945988916645976, -0.8546360430790853, 2.880752355763893, 4.335807267838575, 4.385322085588997, -1.283694915026511, -0.6108723703754333, -0.5676406495302373, 0.6771930713324075, -1.137655738654375, -1.6039599812333665, -1.6977949528895577, 2.172431608751161, 0.41882269529418764, 0.43561621842243897, 0.6743518159889774},
    {-1.556534743455321, 0.3902063569662588, 3.2176258273657057, 4.74728742270927, 5.504900564871041, 0.628183798113512, 0.9078877847830654, 0.12564526364599782, 0.04582365173098064, -0.35625899287170804, 0.7571628711740139, -1.4168379313507056, 2.6191246208309518, -0.5606017504409709, -1.9587745423715894, -0.47778578790022797},
    {-1.3495376134284305, -1.5142200589299948, 3.5594981074566774, 6.067678657127845, 3.945865684804148, -2.1732772265015488, 0.7843295084817247, 0.02783810796846292, -0.9565825722223332, 0.5220441307526739, 2.3106796472943256, 0.8376796461225007, 1.5216882283857014, 0.18325101547320416, 0.5431477128781328, -1.5453047293953017},
    {-0.606752594501154, 0.15755019977178514, 3.008696516376148, 4.591719652886843, 5.373455282124611, 0.6185618748681886, -0.6167551490722339, 0.14700705571378955, 1.154160530937427, -1.1293092209280553, 0.5822149710850782, -1.1215124355826143, 2.8791525687039896, -0.7188347322221419, 0.7941305800540348, -1.1360681941762187},
    {0.3870995616020723, 0.4697449386955783, 2.631264629939858, 5.159266856916666, 4.533660562615807, 0.25197847660702144, 1.2769536286500003, -0.6545337969007846, -0.3487446705017292, -0.9373724424982965, -1.5919809699007006, 0.3789820285989769, 2.9541946010497733, -2.097837043105927, -2.071534618795547, 0.730748197878864}
};

static const float b2[16] = {-0.31031557813589034, -0.5134265059345681, 4.044883557830524, 4.589843445154446, 4.853196801120102, -0.8912282729373187, -0.8672267056014624, -0.730958743389786, -1.000121842165635, 1.1785881427998939, 1.34630938816697, -0.8505898433739155, 3.3391072696770543, -0.2531682776061872, -0.5131248716407403, -0.881452494405282};

static const float w3[16][12] = {
    {-0.9448834282598892, -0.23039766014408108, -0.25869011718293505, -1.1245511724219066, -1.6349667611973695, 0.9835067774979958, 0.09890815060352916, 0.258008475436736, -0.4121876401457202, -1.473550862931237, 0.4761051389819181, -0.7146207924856144},
    {-0.6360459824968103, -0.9511679579145812, -0.6966434815463145, -0.9419858212921083, -1.1257974944337301, -0.014899801919760878, 1.2975873236399451, -0.4456581599986929, 1.1019719805337835, -0.9306368759940978, 1.0551132512171237, 0.2166620397227542},
    {-3.7371316757071344, -2.1786489499987596, -1.369927572446741, -4.302765703463284, -3.368580612401835, -4.345266295045148, -3.608516374069456, -3.4735221326872394, -5.103995024151222, -3.4933615984845283, -4.168902059175118, -3.6118716087534577},
    {-4.006085543595623, -5.942859965763605, -4.485505093467094, -3.4528995546564185, -4.506428138832656, -3.7696225832206314, -4.260122363267466, -4.259775079848855, -4.167832806007834, -4.354271812981709, -4.748683989231449, -4.314611498186853},
    {-5.1749111162409225, -3.916489873491044, -5.542825501511746, -4.778427022737202, -4.925685891682674, -4.570995312212468, -4.925091430702982, -4.721543273482639, -4.78852105753776, -4.934815515973498, -4.252067399656086, -4.932516802359074},
    {-2.0484295190175423, -0.3664790159359106, 0.7026907103031439, -0.17967775426578217, -0.5530120702243624, -1.101453960594483, 0.403437225427393, -0.6583864667634852, -0.6051204603878004, -0.401160441445586, -0.40153158932190475, 0.2763616863818921},
    {0.22812230364357894, 0.9988144872793426, 0.8169334370522305, -0.35102601552916096, 1.0204169672886179, -0.578716357041234, 1.3019427578741192, 0.5253653004831444, 0.6679377835490411, 0.4420147492743583, 0.13129154922863373, -0.8007813904658372},
    {-0.5549900693716425, -0.6798480099905997, -1.5371347505432806, -1.1590534149186806, -2.4564326561549996, -0.8666904499996477, -1.183466771543994, 0.2854902423537693, 0.5099938222464148, -0.26899889022914697, 2.4228452861178384, 0.7018101245332261},
    {0.045678305823848804, -1.7810701340663637, 2.3105373707497625, -0.5097491343105279, -2.84559071115818, -0.7488850453051892, 1.2114561877453034, -0.282302271760723, -1.4369975920491929, 0.8303156946478382, 0.7633882920553307, -0.6385457647257744},
    {-1.0700574386471182, -1.2670853707265548, -0.31471301620579917, -1.0683601541315433, -1.8119059361277245, -1.6741786214581225, -2.752447340367395, -1.7896330789331523, -0.6334660540438934, -2.3399035694371864, -0.7905109629866066, -1.3919611860587349},
    {-1.1722005259209967, -1.716180620885917, -2.871045113079147, -1.2599335098759399, -1.5962156126756306, -1.2719512212559783, -1.6436601138782163, -1.5659783492910022, -1.711992772658706, -1.3489808890222563, -1.0870269121561313, -1.2003553923209411},
    {-0.7343300176982005, -0.1866517303289444, 0.6137692729277708, -0.8027976964470308, -1.4035130368201396, -0.4622764781514847, 0.40574443904954466, 1.3418973558576068, 0.9091579265069861, -1.7106475074181584, -1.1711449220575645, 1.8968775914661602},
    {-2.345358642344513, -3.1376363588245995, -3.221865081953278, -3.2875293507213503, -2.069893489647457, -2.9523433753290362, -2.1164151592139477, -2.8072969233692806, -0.5622809753882103, -2.2560241256422313, -2.2992718827763294, -2.3907972911867605},
    {1.0817311390083133, -0.18765657380315134, -0.33154326178401317, -0.2200366526078149, 0.46405342010725925, -1.6220174758777517, 0.13764362253387533, -0.48803784424255897, -0.7747010361019107, 0.12227487202387079, 1.6705813560519056, -0.7429137626347306},
    {-1.0585305083729297, -1.1180092030842832, -0.6277134320252395, 0.02129969472427478, -1.8170655134543419, -1.5316533901066365, 0.12651146565733046, -0.14188826792004275, -0.46740903385007343, 1.5796214512268376, -0.11297993705367632, 0.9462930491525814},
    {0.874972943908298, 0.05541787136514278, -1.3888774882688761, 0.09101545823285748, -2.6624250912640877, -2.024343459010166, 0.5432083228700985, 0.21119415036291822, -0.4914782661289383, -1.3088738262900157, 0.32504111306500216, -0.9495010735469565}
};

static const float b3[12] = {-4.249669989418314, -4.3079986880317, -3.9555393237490013, -4.404212387657849, -4.2233135363651275, -4.528478799430717, -4.058806175027539, -4.177673010696449, -4.0296384189680925, -4.237887986075985, -4.335631140822068, -4.195133084866279};

    // Input Layer 
    float z1[32];
    for (int i = 0; i < 32; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[16];
    for (int i = 0; i < 16; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 32; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Output Layer
    float z3[12];
    for (int k = 0; k < 12; k++)
    {
        z3[k] = b3[k];
        for (int j = 0; j < 16; j++)
        {
            z3[k] += z2[j] * w3[j][k];
        }
    }
    softmax(z3, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
