#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][64] = {
    {0.1620388737218745, 1.1849639907441163, 0.20948635321240236, -2.5470123240166638, 0.5903069548948054, 0.4209949610917226, -0.7741374064996208, 0.05532218240824826, -1.4938880029794472, -0.4618424791628043, -0.24535139363700348, -2.3878953077534297, -1.2777083881568403, -1.8519594696361115, -1.8194093586150513, -1.7984828882569222, -0.8598066960188531, 0.34865015150544115, 0.36535681174910084, -1.0087786806829213, -1.020275970632172, 0.6855204642222856, 0.11796928766201181, -1.8210824184649559, 0.09238202813568451, 1.2441289099081563, 1.271439507992479, -0.6610561363017106, -0.006282212440617236, 0.5581985188951044, 2.0954890027170916, 0.8401657050360928, 1.0484240002844154, 1.1233855874793088, -0.6469278750502797, 0.13247524899475147, 0.07849455182198022, 0.019555010897045245, 0.6445738604572165, -2.1774017906721617, 0.8848947943586372, 1.341866036260197, -0.06645285497856947, 0.9875695568689659, 0.5759465051992391, -2.309123431138061, -1.9532406967844278, -0.07662753386296765, -1.2028353891876027, 1.880584000934388, -0.7287806775357782, -1.9953482168770518, 3.0528035051271303, -2.78086460627017, 0.7432712103702962, -1.7077417375497392, -0.3653169486604966, 0.22924642972490186, 0.6538596166431118, -1.4731118016174918, 2.1173055301916035, 0.7959258770896923, -1.3912213253655383, 0.5591473013155567},
    {-0.7818877250018854, 2.7277593872027524, -1.6522997020467405, -0.7361350635912665, 1.4129490093779091, 0.8726790307018387, -0.754748099431149, 1.5620943554668612, -0.7471927415099792, 1.2768003261784697, 1.2502862696675299, -0.6572450318406472, -0.3657258864066097, 1.5015854221525624, 0.10303183188313644, -0.05238081648497611, -0.10798587660054616, -0.063818135659257, 0.32665102037096, -0.9378301799017393, 1.88634836492393, -0.3884753998292903, 0.7455239766297881, -0.4139705989614049, 1.8567465873462603, 1.5375131695831978, 0.26492746334135564, -0.6667035208641169, 0.8391576661087509, 0.9496481493220518, 1.191468827701519, -1.2141966796489938, 1.706444449698787, 0.625724250936889, -0.03453425723026959, 0.7112634431068888, 0.24367481158540286, 0.591661207787604, -0.4446594241015658, -3.171454743427494, -1.7447247119044382, -1.2985670734766068, -1.4260214848207513, -1.8552865851592655, 0.2949597133840577, -1.0749513757344098, 1.5310513536602792, -1.3143542302038, -1.3703115340435064, 1.7319024806796013, 1.1389050787438029, 0.10150354549023587, 1.8599112469761832, -2.244772540329432, 0.10369153772504607, 0.15808222310738465, -0.7369710616486369, -1.4071645485156674, 0.4129243872669566, 0.6197107319438638, -0.08053180566644072, -0.907868406703552, 0.682485725328486, 0.5051774245107092},
    {0.8249878693742364, 0.13604322718583203, -1.7521468025265514, -1.3342717456919306, 0.11464066395958741, -0.7088629585883119, 0.3414110020652041, 2.1371234364003118, -2.3644454334944207, 1.0806392111466667, 1.3093921534057522, 0.36287233772545563, 0.142506816411321, -1.8510353804167068, 1.2152925234964216, -1.9417676207008592, 0.3575188496061867, 2.196223938410441, -0.31405494649266746, 0.3026985548503411, -0.14769485350560563, 1.714049218641888, 1.8592613983997213, 0.3841402905720948, 1.3449663805091103, 0.9409961130279517, 2.079176173030359, -1.6190363023147802, 1.5257447162231093, 0.0678981326024341, 1.8392735588070916, 1.3896671335323854, 0.3218183441242156, 1.4184233212410668, -0.42490953770200407, 0.428916721111889, -0.28629228358048575, 0.06910342433455989, 1.6626023793729794, -1.4334755062148108, 0.26915668638299967, -0.22593032763903992, 0.10508227984905658, -0.13947741285543083, -0.7439349850855458, -0.5184949306511982, -0.3641097078876089, 1.4347366007507818, -2.659452332936253, 0.5222344027001535, 0.9899078959541645, -0.4700518438600632, 3.036840349479427, -1.1136765583351949, -1.9289661095589765, -0.1468999614824418, 1.366240846779617, 1.5859010029905498, -0.9903499616501568, -1.337969505570314, -2.037339721055317, -1.1652501573561076, -3.141967495233418, 1.5660653564992963},
    {1.515281233595333, 0.07544816007625711, -0.8311829828855417, -2.5669220647560556, 0.7133024006258547, -0.5987500498468833, -1.4077016453168518, 1.1155799677443197, -2.0817687965209104, 1.2424214598525445, 1.4958893661247294, -3.780912418276536, -2.1711025193407907, -2.4721384593680935, 0.35705440180828785, -0.5548237684906351, -1.2717950971058425, 2.0591205091995826, 0.7541835536811573, -0.8089842858261838, 0.9113798292664131, 2.1241007620529415, 1.5785668919269842, -0.05834844511508384, -0.4624234321884429, 3.7385944822300603, 0.06606857471614383, -2.6141042704753246, 1.6806336965815258, 0.19403535515662837, 3.0141439300593853, 0.28820773439639863, 1.3811617109446732, -0.32457471105587515, -1.014883800181523, 3.1034463394653753, 2.7651616752431907, -0.617868754501943, -1.0440955636269516, -2.4384849246913305, 0.6238821306625324, -0.9435129787249396, -0.3308538237924943, -0.007780521024964066, 0.8598338466188732, 0.847107245002444, 2.6263113481024556, 2.268186394209818, -2.0379018070646557, 2.1452341884315946, 0.2754835356672797, -2.533880657516545, 1.7829831446167907, -0.11396999069027844, 0.18694327426986682, -1.5684985589159521, 2.0381121253382344, -1.8981064754177301, 0.4944084233825643, 1.52053383994981, -0.35989022017326894, -1.1584461428099195, -1.2204027697420654, 0.9462357891260219},
    {1.8816626651443666, 0.37167364641654027, -1.3931168849934743, -1.4643622060232624, 0.6528408664447265, 0.16611807688339317, 1.5888637662510383, 0.5241265905282443, -0.45021355470108737, 0.0638263413832578, -0.44692934053344024, -1.3306152917923955, -1.9534344334945597, -1.9716757636414557, -0.6064767678858578, -2.493064552929831, -1.613729946299624, -0.21424895462840754, -1.6411062851633316, -0.4903771344231482, -0.8699014295135697, 1.700079036570544, 1.2110416501725165, -1.7705503688988942, -0.3812594368178248, -0.3580414118245667, -0.14920447771081824, -2.2823418350032947, 3.8011116352105825, 0.2629129798595637, 0.6878941202221147, 0.6665532188778236, 0.13203032249048813, -0.15648608800186, -1.2335837459500365, 1.0109413307939288, 0.10580931560344448, -0.38517900200034433, 1.0573078703158492, -1.2133260727739696, 1.643322742823412, -0.5518860401250156, -1.385125527970127, -1.1149399156636801, -0.9719936945025772, 0.6485967724350085, -1.2751487223308777, 2.180755511000562, -1.065736433109503, 0.742365107989612, 1.0230322812029606, -0.5130124833915144, -0.8185394316486648, -1.7472354904725054, -1.3644886243362715, -3.0997100252122096, -0.20144609149328144, -3.042203329666085, -0.9237310517061301, 1.2601921885486667, -0.7910917408102659, -3.3613719987511486, -1.2476034049441578, 0.39110133255482604},
    {-0.9192359086117247, -0.15610339113893046, -1.6170651129304818, -2.8812110563361517, 1.2463591110814545, -1.494091542549105, 1.9718854769399483, 0.8865181264471521, 0.8362507308275077, 1.6576766962164928, 2.0055004275949555, 0.5277429834118911, 0.14786606906339514, -1.5292455490100902, 0.25810882164031973, -2.4570093228303693, 1.131808480447242, 0.7864936038294401, -1.631263451345736, 0.03538904357113108, -1.6747299962910482, 2.1196329558198257, 1.0945264753147568, -1.438097961263289, -2.9246583054950372, 0.5515402152391422, -0.7433463477412255, -1.906705331565129, -0.3658260817541007, 0.8635289465423738, 1.155021317548208, 0.7621899944002333, -1.217599879254708, -0.4186266144366071, -1.3704991990196245, -1.149629515308813, 0.8779174923684409, 1.0902801088814813, 3.1555772865212894, -0.5957519129804966, 0.5950712173424106, -2.089834374093738, -2.6774167926653103, -1.685524395995291, 0.7857812235259356, 0.7513259080633093, 1.2714626546347687, 2.4936752119908254, -2.7941326433310865, 0.3033798239095071, 0.21720361884524525, -0.7895606685676876, 0.9840027602474598, -1.1948942628475594, -2.18053599614783, -1.4408916441670452, 1.4380103658214556, -2.148743843713908, 0.6882179418321751, -0.4407096646391125, 1.3671660839130937, -0.9496998463406999, -1.9898704551576087, 1.0236590160443675},
    {1.0012039818010947, -0.20429129727694792, -2.28642733614953, -1.6830622410130611, 1.1795434150407234, -1.2762392773376927, 0.6998046409428911, -0.5113971294915585, -1.7614130868866036, 1.2622228563711615, 1.4964554217827621, -0.4621037008820481, -4.589480146780206, -1.1974039324792283, -1.6055275977253403, -1.7119283187740384, -0.46245356197631243, 0.6975321804095982, 0.374442684556859, -0.8107924596303462, -1.2894914619469087, 0.9773747613750422, 1.5593829338697067, -1.0970832668065547, -0.1057693231836238, -0.8548371463323389, 1.3867192243964932, -1.3172464372940624, 1.9576770754032349, -1.1163974176717162, 1.726931805951739, 0.8589975337850692, 0.23338493840996066, -1.0804283147090383, -0.3159951495620792, 0.7064422746532839, 1.0458325515666433, -0.9349174111235208, 0.155388290620085, -1.2943603664734364, 0.5992047306864674, -1.965983428665377, -0.2627458954651757, -0.8391484990863893, 2.083843030959251, -0.1417110962547821, -1.3423795762766462, -0.5409369978329182, -0.5047950811934986, 1.662450258362646, 0.7742285437256463, -1.1480931151736218, 1.6083424774432236, -3.1453992273884026, -0.17563048944840962, 1.4272858306636744, 1.2780467055907123, -0.9146177523705659, -0.11469499421892629, 0.8481155920562511, -0.5235363722146752, -1.8216624549566605, -0.6597367871101351, -0.44334238506586815},
    {0.7399863788007918, -3.0783813403459668, -1.8586546607764802, -2.3057448832632628, 2.834831069617657, 0.8397195085301452, 0.18400326137649578, -0.43351349777206477, -1.4748880373312203, 0.7231596446560452, 0.7969454212882255, -0.60785359840059, -1.313316230418449, -1.3505001437073931, 1.123813780507961, -0.129879290969373, -2.4535385294777474, -0.30794194895887406, -0.2863590728632223, -0.1725941487442193, -0.9304312250892512, 2.2172080149084676, 0.08590764259358884, -1.1191214552094961, -0.8861947626310884, 1.1370189007048532, 1.4579667116880053, -3.4747552327421034, 0.36619029106949047, 0.8370049602634417, 0.1462272984625918, 0.603542793408227, -1.306266321226757, -1.1792254176294306, -0.883081554263568, -0.26127533377386414, 1.7479136482975408, -1.6646570219707053, 0.609133957727729, -2.012989586207049, 1.9180300172637703, 1.4147868871547902, -1.622541081965695, -0.6571513904098125, 0.3420185921191606, 0.7726033251845874, 1.0909621083096783, 1.5477058138847055, -1.5840796785671034, 1.060430256429886, 3.318386957402809, -2.1436980907454415, -0.13934081183587438, -1.8803260707048963, 0.1607318917874446, -1.7076271796910778, 0.9094809913639823, -1.946328358465895, 1.5785000045422206, 1.0049316893424904, 0.8226960421556839, -1.8364519191099133, -3.905123033461447, -0.018814918360767863},
    {2.608706239600207, -0.7904787647286995, -0.14209569820841542, -1.8082854371996393, 2.4598351894178587, -1.6354554540885662, 0.42222550097957584, 0.7912446067354953, -0.6887083300738334, 0.7626085841106937, 1.56038887179614, -2.1645547102673537, -0.6411198540771962, -0.89695229718196, -0.5404103740613599, -1.050138462530254, -0.10221766974575922, -0.08386898640201403, 0.17936630894067251, 0.4624501344092843, -0.6348475093301301, 1.7592576463762464, 0.5389425909622686, -0.9981654568235258, -1.1187586657547972, -1.0335466502263286, -1.2087241095081291, -2.849698654042752, 1.8757851045061416, 0.46753247630983213, 1.2729749108171684, -0.15374305188410212, 2.085504947636167, -1.1891932551296787, -1.6179020552116834, 0.6960877843654102, 1.6734370997324284, -1.6725803906287104, 0.4114905456457866, -1.4181146396485722, 1.366624066493088, -0.89714461640216, -0.509974537986922, -0.6619714336005283, -0.22636614808152536, 1.3538984203766566, 1.1582190231023664, 1.4396246004277606, 0.4969223176456402, 1.2760499858284804, 1.8946597935412974, -1.519371436215448, 2.272951449217564, -0.6253335049812435, -1.3229400950986363, -0.20462082293387704, 0.8096553185928641, -0.5915758978603288, -1.063811314934393, -0.20441184785957325, -2.8679964564741405, -2.389998497464718, -1.2431074335563264, -0.4888872408611191},
    {1.0287757012517578, 0.03699934754494058, -0.5421835042236883, -3.2623962543339173, 2.4511805562969133, 0.12332406259385968, -2.071216916038864, -2.01452908728791, -1.8116205612914575, -1.2980956414713203, 2.2014805252433147, -2.787495888988391, -3.3095139067115094, -1.6628192159039092, -1.0947029433748028, -1.5609437774043189, 0.31297632679675813, -1.0931614526346403, 0.3208957954918635, 0.4329357022042852, 0.46073743073993834, -0.7651666788934094, 2.5265180715019473, -0.9969981689448947, -1.297152598537493, 0.7701153683980095, -1.0109447841036887, -1.4621242252683417, 0.37354316624789297, -0.4287116221267873, 1.3045030749103472, 1.7057810805145246, 0.1670707723072213, 1.7151597298683652, -0.572719876746313, 0.24884868831565718, -0.3201962564621902, 0.20310595849332377, -0.3099917369348238, -0.23449570455606975, -0.09014078890883374, -1.4304691693121594, -0.6481428805815108, -0.05987963342475013, 1.5996497947921726, 0.22279085657822925, -0.39846376556997, 1.1251349455922113, -0.9561210481531439, 2.0846256943537367, 0.9873218344488129, -1.2583330853640766, 0.0695398232243735, -2.1405123524013194, -1.0362411390130193, -1.9340454932814586, 0.7008547064190197, -1.259806967864472, -0.5468686963752709, -0.5191211136556404, -0.16223318791067473, -2.2848846009851607, -2.444827202240173, -0.4652792594225938},
    {0.9313108416755864, -0.4880021084883186, -0.4995892997213905, -1.6623292427228449, 0.41333536295453327, -0.19022817058764244, 0.4509682174299777, -0.06391649767245185, -0.7050489409962596, -0.9686899802832356, 0.24665761015311563, -1.8295532678947983, -2.4885543652465634, -1.0236557724466067, -2.7787132462820314, -1.9697220679183534, 2.0122859444132186, -0.05396564427800371, -0.1166984970470763, -0.8649519401277709, -1.561802470684729, 0.6354121655909114, 0.7008056272843118, -1.111360631926551, -1.8865481178958217, -0.016497103502077882, -0.7047249362000364, -2.5222926621863486, -0.17716536114656345, -0.4681935580930908, 1.1047945869838451, 0.435282219608198, 1.5735108266138227, 0.16329677068066825, -2.2034119277163398, -1.041936201182244, -1.0388819388168178, 1.5289979580063386, -0.9593197767505067, 0.022074074507240745, -0.5084559080857165, -1.3619428655686274, -0.9228033565537652, -0.20179035759086025, 1.0058383635905421, -0.1537650516073362, 0.06054363332092176, 0.5908294083717006, -0.8916413305781146, 0.07907354950151603, 0.3645806264085604, 0.23380151277923406, -0.7009843102949036, -2.071443008818276, -3.216783170682179, -1.2754797382070528, -0.929512471539419, -0.16822042050412178, 0.40675063484536156, -3.036795309084718, 2.329072650594205, -0.6379199548171502, -1.49754200782946, -0.868416417429491},
    {0.04953598306795837, 1.426254510830731, -1.0646005320909095, 0.3647081504864333, 1.5263499317312068, -1.4251145384005934, -2.098654999514427, 0.0641603403137411, -1.365931718922158, -0.11285444570668157, -1.2311294830150172, -2.0671440255339393, -1.6706400127971914, -1.1026157275773523, 0.2692399415905628, 0.05006409258962755, 1.659774307981813, -0.0017199227983253167, 1.599775382799193, -1.1363732883144495, 0.5589425947646447, -0.0972236427673524, -0.5215725510561859, 0.5876076530452782, -0.49996099417618534, 0.7367723281364259, -0.5284213096227067, 0.20116458547545843, 2.0645277940065734, 0.7851813392233155, 1.2087101535448235, -0.4091891339666316, 1.4011331722494882, 0.11714882322527875, -0.6419570978950426, 1.8297586659429061, 0.4502053347796812, 0.042141180658482345, -0.006627455937627718, -0.7371780420601534, -0.09724255756753017, -0.6265976818055135, -1.13285387095531, 0.29755283709202757, -0.39969350506981405, 1.9485567496839749, -1.1386226584749728, 0.8418256036055918, -1.09258628157214, 1.3769888221488489, -0.569800286754972, -0.8200432355597196, -0.6828223050890436, -0.9518247108593643, -2.469218659905659, -3.9026460085102648, 1.4235442296251737, -0.6307713803150723, 1.0398085645837958, -0.11867616569745273, -0.352239787169782, -0.20887161770153967, -0.2925051427021811, -1.8691979363166258},
    {0.13670967983317797, -1.6059243561509546, -2.0588779376175594, -0.8537203782544014, 2.9596191403376757, -0.7179540923429455, -2.2411538356361707, -0.6057754218568655, -0.4958293016894824, 0.6136299434435001, 0.2977704264717118, -1.673626341502093, -1.2287717414513821, 0.7732868574672963, -1.083003745143139, -0.9723866596222254, 1.2671661446737477, 2.1970121499980575, 0.2962169195420194, -0.9328914073174845, -1.119506492885016, -0.42540023564603474, 1.7198968349010444, -0.935667844921902, -0.953225052931127, -0.2540513398240677, -1.6209659242018468, -3.1569898924766435, 1.3835946052530412, -0.5841756900054856, 0.732571461642613, -0.48310688037955496, 1.464911083648773, -1.225181935945445, -1.3784353593357201, 0.20196791139432496, 1.2302973239958346, 0.4586333434207655, -0.034710339135336, -1.0869966570617577, -0.14506223399483462, -2.8997274374680675, 0.6402039524739306, -0.5566156281705009, -1.080045485352457, 0.15964056044392805, -1.5732584518551118, 1.3541408021410932, -3.340682074506567, -1.5855259595769853, 2.6637454772168936, -1.8340876910935382, -0.3422554355324536, -2.458766026303808, -2.9973174619369614, -0.2606474243447072, 1.2744354606480088, -1.184485571821829, 1.8209664518166968, 0.08221313504917785, -0.007823036913802022, -2.9661458214742513, -2.1125555843217283, -0.4270035047131811},
    {-0.3515021309988222, -1.058166938359676, -2.572659755049526, -1.4506321490252199, 1.9484478309200841, -0.3899081281329282, -2.9146368488234033, -0.045588444993717614, -1.1733483542481582, 0.8903672820924511, 0.8393452972390845, -1.551802310850286, -2.681967902740563, -1.557212358312383, -0.7647999664194237, -1.1939224435270674, -1.082129146091019, 1.0347753584398847, 1.194202978093286, -1.5532088763616771, -0.6472891431601357, 0.5037024421937396, 1.5292281221424424, -2.6368739139970137, 0.8273899954989694, 2.519964698534244, 1.0075804717467352, -0.251868699388053, 0.16217993308195616, 0.1646911549058104, -0.1924918200314779, 2.2808313233557174, -1.2003873204831554, -1.6151889298550512, -1.4086376912769243, -1.6250277835626066, 1.0284290586941967, 0.7993431796567143, -0.2896989911956791, -1.137280700917778, 1.2301890040622174, -0.010898654858438616, -1.2591185507304707, 0.4461041361727832, -0.5296148436139212, -0.78609464574635, -0.6347897237278997, -0.3341479006693494, -3.0164529146581627, 0.2948966810464888, 0.41346476520338676, -1.856654662056062, 0.5844585530432764, -3.3841977555622957, -4.07820874860062, -1.9979831392788883, -0.0495284666239732, -1.1732837387232027, -0.6910208068991287, -0.7170803098950437, 0.2950207388297558, -0.19064851991278578, -1.6724749794034413, -0.29327116468998693},
    {2.1856555405601434, -1.533605338209561, -2.2063565143711608, -1.006488272970447, 0.8960336850181932, -1.0372397866625902, -0.847119888716691, 0.10917295334668481, -0.7679964943860982, 0.5810653120331818, 2.05256208660029, -0.7435903433154032, -2.35534881389156, -0.8573439622691302, -1.8397699460322225, 0.7711133149675018, -1.0674109700963406, -0.9662035780788503, 0.2513592723144423, -0.153053899780636, 1.8367112636820213, -1.5715285641043626, 0.45711047118915116, -1.2486849157411875, -1.9528628659131002, 0.1934567402274787, 1.3972226397065304, -1.2527675322470775, 0.9164002063529078, 1.088307827038499, 1.1262266420742846, 0.6884768001128676, -0.23637579677832354, -0.7373915066452243, -1.3911737581605, 0.35994338786771274, 1.9541160675635263, -0.9598848607417247, 0.4993838090791958, -2.1886189493397565, 1.4525351468497292, 1.3425757546890236, -1.05590618556098, 0.8077525216387061, -0.4026862664911614, -0.4752656082972608, -0.41492359937662965, 0.21234338962094396, -2.6607093432633993, 1.7298181428745247, 1.7724021298683146, -0.8558319747841328, 0.06951982150244526, -1.6538632119053798, -1.7439012316146203, 0.9436791975663774, -1.1006913820285251, -1.6486966654686075, -0.882133238792161, -0.5971017503893945, -0.09928849297034113, 0.9653779657746425, -1.0674577643248961, -1.7896199550581084},
    {2.2579199301278603, -1.1990699256257267, 1.3261414791120483, -1.8754534225180322, -0.7559159841211792, -2.3424835938828057, -0.6131482600969683, -1.6312007049326915, -1.060029250015592, -2.014276938762788, 1.6929779654808905, -2.0596534833621605, -1.8415884446070285, -1.0693439687088513, -0.7211654760515245, -0.5946386616479388, -0.2549119045169696, 1.209471855683852, -0.5088884935481028, -1.3610945930968996, 0.3074992338329295, 0.14302243058804137, 1.700360817110077, 0.657505954080768, -0.6857038659490979, 0.6758062125245884, -0.40222941579858046, -1.2892989496959333, 1.2088369625143929, 0.8820766048363524, 0.9986199649204255, 0.02488842894412243, 0.294275871264373, 0.1229320186854387, 0.1902452133694354, 0.22833412736315398, 0.13279949294385102, -0.15252389051362045, -2.0335363294202913, -2.581219516593998, -0.978490773196938, -1.600307584105047, 0.27433190419345566, -0.08707406380409802, -0.35105372202234003, 1.5084256660328852, -0.14810482541963585, -1.8002477841480675, -1.8049464736227223, 1.692146611613914, 0.6396458754359122, -0.41328975118679057, 2.6144564572273774, -0.6215572131914919, -0.9710344072534074, -2.7724175223648437, 2.4498371738541223, -1.617726431252541, 0.7956236926312529, 0.6387088885141249, 0.08892287533923415, -0.38266740479617034, -1.4921492898118407, -0.10408869208461614},
    {2.7408655110263362, 0.1493045146771289, -0.27769224471243387, -1.9758082348920363, -0.05721637494827531, -1.0630928335912861, 0.12804643279836245, -0.36320773878135215, -0.5094166839023121, -1.3750730038325019, 1.5174050655949833, -1.061667044389361, -1.311710790113426, -0.4792082273636646, -1.4561381606717156, -3.069554319885791, 2.4807362920544547, 1.4508910180886525, 1.012063904897464, 1.0192804209104456, 2.2352228014415663, 0.9180187065345699, 1.0050095392462322, -2.8785082690733157, -0.5003845950845869, 2.492222592653362, 0.142059758128791, 0.2748729196971992, 0.6761897140098574, 1.118031134829503, -0.21803067161778591, 0.3318670510499425, -0.3108588579190053, 1.1449138663433562, 0.4519348994774483, -0.5514193179682232, 0.9171972920179107, 0.2139582068084162, 2.0304779966012703, 0.5303549827128068, 0.5082285572450774, -0.14057646053426823, 0.631410392986483, -0.10095971939700957, -0.7725176742992318, -0.699307735640513, 0.05649932920153749, -0.699860798373141, 0.42806630527630685, 0.6174085952321319, 2.392459714654134, -2.1562914177755816, 2.7279657716998855, -1.8245094512127318, -1.433606777234878, -1.8747250080903333, 0.9184111091140186, -1.4217210221950494, -0.01547335005741855, 0.6106523684370848, -1.5688802576021752, 1.4648068438312278, -1.7454036366960965, 0.7736177043642979},
    {0.6114459008611254, 0.529946336081854, -0.6129595997377106, -1.806900933198188, 1.433773681121792, -0.5954117903791672, 0.8019678758446457, 2.6162370958950567, -1.1054558479818886, 0.7352338444393883, 0.3433446895910317, -0.37384914823123994, -3.5376373645463413, -0.47884677116804064, 0.29083885313154123, -0.9037473417530117, 1.037241912993042, 1.7758814985492615, -0.9987044301201067, -0.7771369347213809, 1.099016306299262, 1.3404702069766306, 0.6202710339808569, -0.26434614120240674, -1.9707692114050857, 1.5343059480458816, -1.3928331600490422, 1.4422238741296676, 2.3983531805849534, -0.9043697749880427, 1.058702190256496, 0.9892167875069499, 0.8175494825875079, 0.055872533176620054, 0.4264015900364043, 1.0995691815416813, -0.4599417103138076, 2.1409841179461426, 0.9746700323585866, -0.8806764468941314, 0.18081780206631476, -2.0017154666867425, -0.2694676115714904, -0.7007423116603415, 0.9549530410965248, 1.0437989820449134, -0.8600923998405693, 0.28525409807278745, -0.5285520446295535, 1.476046362477944, 0.842011355006074, -2.1360745265218113, 1.3114278076138737, -2.493159761546818, -0.658336105911307, -0.4552838371050285, 1.3801611406606218, -0.8586885882893711, -0.45673785185995375, -0.2114023369198884, -0.3380945967884663, 0.7539806630590623, -1.7717527907609998, 1.236648369133331},
    {0.167433336594573, -0.014060816589604612, -1.2800981414684913, -0.9214179805927211, 1.4997842165336672, -3.1915031612810094, -0.5264660810280989, 2.094119971479311, -0.9696710849620176, 0.858071124374251, 0.9569095754961563, -0.489558314114458, -1.5337691736237213, -0.2914038498993838, 0.782051377728458, -1.8744657294973792, 0.273925857965491, 0.6234110634019769, 0.11016897256624526, 1.8460651948756288, -1.389424156300617, 1.7380231497505307, 3.638128118722518, -1.8545471698827452, -0.7866212017033063, -1.452336057562643, 0.8237910488920147, -1.0806976040502247, 0.6470213176760423, -1.0885069810670334, 0.2279920689927638, 1.6463744983691477, 0.38965981580280373, -0.3059739312705581, -1.4813804003383209, -0.08963015516351326, -0.604718936333849, 0.42795370000566496, -0.6879930069790527, -1.3564244749786938, -0.5083798540072162, -0.9352599817961755, -0.3760956184792672, -1.3081467540571796, 0.4547464662163352, 0.9258089799690005, 0.194483557086112, 1.4788198505163423, -0.3668758822999215, 0.10946127403535774, 3.704472725233146, -0.4292503970497026, 0.2818423073064846, -0.18614921217785865, 0.4636817346159717, -0.314565173226124, 1.4801874609638728, -0.4228438271979278, 0.025818480600271934, -0.862065846717562, 0.0496739801614337, -1.3967410006705199, 0.2633566274992642, -1.5930427079177283},
    {1.5639363735043736, 0.6051833402993677, -1.8453036860888337, -0.3543350712631147, 1.0397348781352636, -1.0090170699775973, -1.2075628187920535, 1.7770901606849077, -1.595959208031391, 1.171888298165331, -0.014331065828837855, -1.733746675690589, -1.990704566325293, -1.7154013935370909, -1.5321484136962515, -1.2808465931871735, -0.8287527750882997, 2.409899292675467, -0.9797501582027454, 0.9967897289315127, -0.5913357690573547, 0.6707454746270141, 1.3601946442928237, -0.06447810673274894, -0.4195295442915566, 0.5790024926133687, -0.8815173236099275, -2.060991800428471, 2.766202843604338, -0.3085773437565158, 0.5596021415508553, 0.07665817331705709, -1.0694992549234366, -2.3733993731353205, -0.3228571427319297, 1.5883662248786796, 2.0210633259561614, 2.012754884696893, 0.26115148797236726, -1.5624975952076758, 0.4348066968924402, -3.6556393831306644, -1.9789120546961232, 1.231968866380911, 1.2510142048831925, -0.378029586014412, -0.25518142154091544, -0.4201902469919064, -3.9885943947090032, 1.1816596668195605, 1.01935670676376, -0.17161914776362855, -0.009782730827031481, 0.6006469192721673, -1.7257254927520138, -1.8396987924483748, 2.2829908819963403, -0.4382140491503064, 0.19552774533486117, -2.996992360318392, 0.20515820521172548, -1.8899285517345776, -0.7734205309879225, 0.07773372178286315},
    {1.6972237770328407, -1.0280534887932458, -3.284202510903485, -0.8592298749355209, -0.5987503746997762, -0.5137804027344403, -0.19708798692411086, 1.076587340363858, -1.4334768242136329, 1.2520553255457505, 2.488870425781669, -0.9240844818512282, -1.405384830688795, -3.381585673044034, -2.298510922309242, 0.4725031056500415, -0.2002364517395485, 1.676083687519772, 2.538776285795894, -0.3189567692050816, -0.9593560791374492, 0.6099154317064923, -0.35812626429181593, 0.09777612725019189, -0.41825067772815083, -0.6231465681605719, 0.9178324303007855, -2.7153552380383714, 2.320895740237251, 1.2414500895516984, 0.5148289563194242, 0.8850201782243274, -2.1440586804488984, -0.8805506061939956, -0.703674928830101, -0.19385880889552548, 0.6752338083724652, 1.8574903020713514, -0.3263631243277875, -0.5744868280040256, 1.624997986469592, -1.3508033536434165, 0.28505430873499243, -0.1911684063906886, 0.37803773034284166, 0.6963601078731999, -1.5381601313356494, 1.9461166855062473, -0.13732976590179752, 2.97298781783333, 1.6767891384450793, -2.940136302299651, 1.4490737301738594, -1.208049020825936, -1.8048606873339734, -0.9752628798280764, 1.748665671067615, 0.2816189330008375, 0.5442227123092789, -2.0647218287491556, 0.48768977400680513, -1.4169508373349748, -3.021228089855151, 0.10905210630041483},
    {0.2733444521463965, -0.3833100456814208, -3.31845475361869, -0.8146121893553233, 0.5087598673057402, -2.1251909772154596, -1.57710247362372, 1.3418742926849052, -2.265900040295268, -0.28949280041789505, 0.5040226417926122, -0.6586299215625364, 0.09921459303393475, -1.1616309013509276, -1.113997522968016, -1.4236731913932126, -0.06745749735529089, 1.2371120458540863, 0.011786531019730128, -0.7833526462274798, 0.6356851725325862, -0.014569056223379562, 1.16460107968755, -2.6576984577224234, -1.337849083611672, 2.793954995722398, -1.0743081888238775, -1.2374705878863108, -0.3318868131464418, 0.9009484615102861, 0.26121859166557054, 1.8028053007828333, 2.7816929499685936, -0.07376758522535556, -2.1604460242131887, -0.8727842849242895, 1.665362329991825, -1.150708303330847, -0.820758751246052, -1.727282216197456, 1.0591154731702843, -1.4402113361634405, -0.5235842066498665, 0.9467994405568596, -0.5850712181459795, 0.5593612049931819, -1.8604569788683027, 1.1241457875541117, -2.393732323212315, 1.895680932536545, 1.7519881858425463, -2.481920557378544, 1.9565808739634265, -1.037780588398424, 0.09305040388351854, -1.4570483538353802, 2.1562716107266904, -0.12322507399291575, -0.549869025525072, -2.2425012285837758, -1.144127375454875, -1.024336990318271, -1.8919413031700276, 0.25148724514350357},
    {-0.6912413720130843, -0.6615513335779116, -0.2075715724953035, -0.6894517801977802, -0.03683780283847461, 0.13305359448469012, -0.8073893180179103, 1.6397897992896098, -2.7043829271748017, -0.8655687869721503, 0.5475786705223484, -1.4950802487937596, -3.288338529360209, -0.012220882465160537, 0.7082461520152966, -2.8060558779501696, -1.3974827216878445, 1.3310437526732914, 0.9220911501400068, 0.40557742954838194, 1.4680192679086734, 1.617534193774576, 2.1731890449853357, -0.35637223178829786, 0.1345621694490005, 2.310522370114545, -0.827231455305079, -0.9151933260240563, 0.9777363337026217, 2.4815780873343143, 0.5894431451551968, 2.5166592896898847, 1.3331336199388304, 1.2307089659398, -0.8400451844125956, -0.17698040518678085, 0.3382229027871073, 2.1779454885841725, 0.4850185473697494, -0.8672104537823744, 1.5879910733031644, -1.9322074119167931, 0.41631335020345367, -0.1285270196463284, -0.6577661388009121, -0.07726806910059146, -0.10049131433959681, 1.102877818405632, -0.13355147024058167, 0.20821842754005754, 1.499397302805377, -0.18498422406630446, 0.8995071932491363, -1.7287142445429455, -1.090516123830983, -0.719189354317183, 1.6865248273765694, -2.9557984318865462, -0.8767814327298856, -2.421784823870121, 0.3114842250033581, -0.9623360369037294, -1.3138536492340305, 1.53336997874905},
    {1.6410102696213198, 0.6122160058805148, -2.517687644453324, -1.5495341070126458, 0.8599561437376856, -0.8171838753887879, -1.3104419401838596, 1.5393421319524858, -1.2973697381810148, 0.02566912485886665, -0.20777958074449535, -2.075767086968232, -1.4114446489186945, -0.780528643754842, -1.9438437444804118, 1.050089724484572, 2.956916264042789, -0.24755311520244408, -0.7778085747881127, 1.0848378653071273, -0.9797024201785384, 1.0423444582511456, 1.7524405572020239, -1.283881507916863, 0.36702813427531483, 1.6267673253077106, 1.8331334278692322, -0.5253209818637485, -0.7710955309108222, 0.3208286736509857, -0.6958618444164355, 0.6738721027431562, 0.33237908880571504, -2.1152177139092556, 1.436650402609637, 0.8064786444779477, 0.7770073078442644, 0.6851035988777325, 1.6807516783935244, -2.4374165734466327, 0.7050780003218717, -0.21152501644568825, -0.9311090487122579, -0.8779004089579551, 0.7310827842476929, 0.6170378355959459, 0.6673581118471851, 0.43728443090476327, -0.3440133106287061, 0.5438119924111229, 1.6980984347508685, -2.896387298356688, 1.397533269917896, 0.1516360483050483, -2.386091689442423, -0.3235192809775527, 0.8695869118866387, -0.3712368351317912, -1.6865154924528325, 2.9417654999857326, 1.09575853584997, 0.7760271532873364, -0.27983533221320606, 0.017629523047310032},
    {0.3157383626221786, 1.495015217427459, -2.2819870147317465, 0.6836249403375628, 1.3239499957728793, -0.9775163400919685, 0.040574511733370545, -0.5137017354818733, 0.30056166411579066, 0.05188481555495927, 2.597586762789081, -1.034198930581406, -3.095099936793774, -1.7441903006593662, -2.3120099135522896, -0.3560695488231731, 2.5949953439886473, 1.3121879225833426, -0.3278114429506054, 0.3436146093464935, 0.15602361160207764, 0.5957002008777933, 1.6270617769122224, -0.07901872144488126, -1.0329033215164223, 1.386986382976317, 0.15122884820417826, -2.473535529117401, 2.1831168607966207, 0.8153015500526788, -0.20070212290712422, -1.2314221651378978, -0.46726884641217953, 0.886639109732198, -0.5589765685979818, 0.01809146073101248, 0.11563730432340001, 3.055545876645344, -0.03211325304076013, -0.3174151852337699, -1.0197896217123692, -1.705213032296297, -0.024949929259444066, -1.5169107962736663, 0.7030320471688408, 0.7863632010262089, -0.6929071953430682, -0.5980435278939591, -1.0845539664093997, 0.8063711604619598, 0.006455829111486231, -1.368709381087974, 0.11300967640805937, -2.148947475616353, -1.4980270710128216, -1.1873841597138395, 0.21351161432191545, -0.11572291667579397, 0.5454421493958148, -1.1886480099692325, 0.027757749327484173, 0.27118982260251373, -0.996794376192564, -1.3460927925983595},
    {0.3977942235258747, -0.9662837669499957, -1.2110458083644764, -0.9135382000073538, 0.6878216286277327, 0.6676266195561579, -3.030827940907973, -1.2378270601702464, -0.5305882278011899, 0.8465186626664151, 0.9745303539090189, -1.0597840845361182, -2.483294127139448, -0.5614840353759414, -2.4072706057690896, -1.7118432928493141, -1.6039244870851506, 0.9522187918297165, 0.6331069565839895, -0.6212157473848066, -1.638965068785809, 2.581282866561174, 1.4950277598354436, -1.8306796773957377, 0.5859121205581022, 1.0329991974216337, -0.30248428432125557, -0.4641211798317585, 2.3388224216926603, 2.0539124331346246, 0.8866033327479381, 1.6761853679059604, 0.4257728205748504, -1.056332871129309, 1.661578243136739, 0.8822582060001388, 0.15209332682387292, 0.623354696019773, 0.1868279769019133, -0.9252253544763029, -1.107120667991514, -0.283073990819114, -0.4877732458069743, -2.2131911958196415, 0.03257917781021721, 0.025426260329724535, -0.27833104714212964, 2.0031508139067067, -2.8379044540640948, 0.4392268521780782, 2.2254991241468534, -2.2960633050947576, 0.060037276332330365, -1.6207867000093499, -0.5045307382340383, -0.22605212252317936, 0.7677075063108434, -1.4298471985729366, 0.5993089433051372, 0.7341529086671422, -0.06999924505972942, -0.08488772238855895, -0.8216223264855319, -0.4269198379569577},
    {0.7407600393960867, -1.093862751543129, -0.24244483703272968, -1.220149738747094, 1.597269490768779, -0.1778199493983189, -0.48725553153741646, 1.196920770893127, -0.285997729904231, -0.5661163161525639, 2.6636554758820625, -1.7243079379171802, -3.182022902906999, -0.6249786526204787, -2.1257337545570705, -0.8651269509859588, -1.2640906249246273, 0.25741370683627135, -0.9166982927942833, 0.7667994377080722, -1.7856904522481436, 1.2160245345798744, 1.1006600178563093, -1.4441807908552602, -2.664746043409255, -0.32898211968156715, 0.9423572133614432, 0.35697211690475783, 0.7901600214639095, 0.6798060971960036, 1.056018239735665, -0.06588940415924562, 1.478706767907987, -2.1112585261426413, -1.969438630397905, 0.8617979919723578, 1.7357328794062215, 0.7282951424142647, -0.27758369165395125, -0.8671631662657177, 0.2204045087080533, 0.07272535681329481, 1.2583251100293715, 0.4428601002330697, -1.1695028943225843, 1.1785562922358872, -0.9562609775643747, 0.38650155847567796, -1.3387704696219367, 0.19987801109562203, 3.2515519740538656, 0.0360911484419852, -0.004486591926854109, -0.6607140773944153, -0.3101404697847518, -1.5209238259678073, 1.7549608125663834, 0.1075323624996726, -1.2392308900491982, -1.0907188409983757, 0.4133284342254379, -1.6630380112094885, -2.6534452662103725, -1.3968021576917617},
    {0.4342210683292949, -2.8017612680423056, -1.8208301167865426, -1.509940898890016, 1.4017057788465714, -0.850511121006469, -1.9593511850692105, 0.09103591192789758, -0.9119726768135216, 0.9060535069712943, 1.6954656934597778, -3.0669339200656998, -1.1377828195193693, -1.042248148508626, -0.3348931968712666, -3.007984172389496, -0.6277189903788287, 1.3916837074136001, 0.5446686215685641, 1.703745980852924, -0.7995262492359524, 1.576141716428754, 1.4533820848278496, -1.8509164275428667, -1.624439075932958, 1.6351353953918637, -0.9933125911075932, -1.9166392013386144, -0.3225535528636198, 0.02006445591702971, 2.138924961781182, 0.4616866447855706, 0.4761818322818871, -0.3648015014833493, -0.4547109556789793, -0.4032415593699737, -0.8052407355953884, -1.3099198525229259, 1.1231214594981602, -2.39210833061706, 1.4739391395016495, -0.2538763152895244, 0.06521461205923172, 2.206991127438362, -0.5235355469873229, 0.868125900351641, -1.04247760613072, 3.1416304184136368, -2.342124741720209, 2.4737068377003686, 1.7357396054663126, 1.1414345680450866, 1.0844823937894605, -0.9950106567497795, -1.4617395443605508, -3.274866772721351, 2.7702424181181473, -2.0030992430799452, -0.09321131493815461, -0.19984365673785778, 0.971924731319357, -1.043760975881594, -0.2405673412483056, -1.4844575670895541},
    {0.8117725396152339, -1.4524477004678684, -2.8836185170446407, -1.0258995180088764, 1.0468458743951996, -0.610664736693499, 0.3972448446451905, -0.05414094284655851, -0.14882958798283652, 0.7924632919906229, 0.2583642430185126, -1.0533446517438088, -0.683909692046971, -0.5121696522700897, -0.047814889744536744, 0.12157125567262603, 0.14074173830881798, 0.33953254269236977, -1.279099325226376, 0.3271022012528501, 0.48727504184909237, 0.6726015104182248, 1.2119227273243618, 0.315920969329978, -0.23731207097296364, -0.17194870899447345, -0.24320266569317311, -3.114613445329604, 1.8351210437676553, 2.0657280422029896, -0.29738442691679257, 0.623311615788372, -0.40181488141634814, 1.1663782252831019, -0.5033261473052498, 1.2769897980234794, -1.9132873920108737, 0.7402819781717771, 0.35545434608545884, -1.1782172801576438, -0.08652212410182157, -2.8832759916892017, -1.3022947268624878, 0.2921489705029215, 0.22091851833728288, 0.9734614853344401, -0.6518458114656279, -0.5915208105262273, -0.4913614544715127, 0.3468764866646792, 0.13199301049553705, -2.4935335484166132, 0.6716613502348374, -2.4486940161067663, -2.072818278682349, -3.3093501133108627, 1.1312974562252176, 0.4462835090593927, -0.61101980418891, 0.1617959482215479, 1.4580796859558536, -0.5226508213862531, 1.4835432114305398, -1.789343626757983},
    {1.1816496127018299, -0.007530191900231151, -2.190518624169405, -0.43544160795720777, 1.69173205970789, 0.77688276759843, -1.4406723448363765, 0.14342685942423516, -1.1866804174893875, 0.019094595584338864, 0.2649334789588023, -1.0990724285921771, -0.019825390583323933, -2.220329178434133, -1.014390989997958, -0.9383539994872645, -0.44511815208540134, 1.0417071289172812, 0.276756917582262, 0.4552542612788711, 1.3502144812378816, 0.4544442643908331, 1.655131007539445, 0.43966249338166874, -0.19833474349577457, -1.068268232846918, -0.3931039229230323, -2.3470676197667633, 0.8914381094033867, 1.2389404206682983, 1.056830344208759, 1.208510992317231, -0.8049133796654007, -1.220867931391995, 1.1357417239502743, -0.4237378791504583, 1.8729692479737166, -1.2894728757667306, 1.833258025957302, -2.0158490880753672, -1.657884186313087, 0.1945796591822055, -0.14615525306300892, -0.7256569267447708, 0.7419561253173163, 1.746891342586635, -2.438485911663636, 0.9144481871810283, -2.3309081382419423, 1.6760719364213896, -1.394601520476494, -0.8114231120148543, 0.5063797522471924, -2.0306779529928063, -0.17189733742100555, -0.6038280719328766, 2.6609982346191083, -0.12795809720794743, 0.9169658878544192, 1.9274343548905708, 0.5409036889250568, -0.8528401360409541, -1.6207883998862558, -0.45992278089506017},
    {0.5756399935945958, 0.23594572702726807, -0.12630549243117298, -1.2296026619521772, -2.382967996799974, -0.6589178566847199, -1.156729328837706, -0.9756899622432355, 0.04865811625512036, -1.859978363292152, 0.04827602727872923, 0.975791075904255, -0.16698156139788434, 1.7849080890717013, -2.219201423163272, 0.5665541196469458, -0.17342448857936138, 1.4855185583926438, -1.2186022530437237, 0.1886611081260428, 0.9755905277516633, -1.7666954594062818, 0.8088654684088878, 0.5679619483677458, -1.1067427566013281, -1.3236281866623807, -0.9314784786348571, 0.9700336616140163, -0.38537917447703485, 0.09311809724876716, -0.7377825535494325, -1.848976584782937, -1.3562537788250877, 0.7428122290169906, 0.11378528647723529, 1.9488523440609333, 1.1055835183620673, 0.4892410308383137, 1.7309214036891645, -0.05634801896285678, 1.0333243100573424, 0.34211191942218483, 0.3215631705812571, -1.1647496785643336, 0.035081394547864755, -0.5425407799044767, -1.1602243507280414, -0.19694479831139938, -1.2843474322595054, 0.8492483845252057, -0.3798078046555362, 1.225054740578901, -1.877375746735111, 0.07675302757209942, 0.5971339466248486, -0.09124675839117717, -0.9789662241080818, -0.5332410552615455, -0.03587517888516728, 1.1627333990690423, 1.1068684165739984, 1.1241025601751933, 0.35559413183636573, -1.3861816891252154},
    {-0.5442713215988995, 0.5935702994020066, -0.6280734616676626, -1.4373552609032412, 0.7961169874104898, -1.8333159098861322, 1.1980730807202058, -0.1971144378452737, -0.9401594484987993, 1.2523269411917504, -0.45909205703549777, -1.9345956630465435, -0.17378708357583447, 0.7217131080578796, -2.1060807216697643, -0.7555876956034973, -0.13012918602775728, -1.2396444034804446, -0.4115874422097899, -2.096833674751279, 0.3188570818934643, 0.12380199341320312, -0.23831176911328267, -0.5551695562319982, 0.6182196587385439, -0.6489386987166792, 0.16902302249181123, -1.9015588014644182, 3.1946773171965743, -1.0315710189767606, 0.13621861078901296, 0.8554496104100479, -0.7464976798939779, -0.637002173013395, 0.6945806466106407, -0.4413060428835775, -0.07453493453832984, 1.522152853402066, 1.8171073041984653, -1.3972305779360774, 1.0788168231375133, -0.9906776398658349, 1.2591712655546643, 1.2177083552055876, 2.3380635310289923, 0.778556277259639, 0.5175371008054865, -1.0263995322284343, -1.7009184030021758, -0.8402830984724681, 0.3505120060809543, -0.02009599852272907, -0.3442135623689335, -1.3589416389515716, -2.903375806855424, -0.8200035317608895, 0.7133463506180274, 0.5725544237928588, -0.5491762826498463, 1.3363851782677998, -1.3252454732933667, -2.8336123511236155, -1.0494869565335994, 0.9112297043696193},
    {0.711793667909608, -0.6108434111110782, 0.6644089471842292, -0.2551145036647858, -1.8583744872527983, -1.9956069930746287, -1.1059959849099554, -0.49031884232405515, -0.14850620223243813, 0.32424170305042543, -0.1311543271721877, -0.4863884230531335, 1.2602439410272248, -1.673702703844558, -3.5673917315570782, -1.1346679839137406, 0.1851897049048777, 0.9406167562557155, -1.54464640560838, 0.603886101022074, 1.1899694347964294, 1.770524526688027, -0.5431396560627274, -1.5286379532414385, 0.3221645729252659, -0.4807012783160397, 0.2117531518110329, 0.36629931041710856, 0.630786271888591, -0.6186269349764916, -1.9615904441344056, 1.8189197163382513, -2.6849255048362077, -1.6375624314051425, -3.255905116343462, 0.7225704400841122, -1.3079219797125725, 0.6239996369907069, 0.2967493342828578, 1.4520548739989751, -0.017609459242648198, -0.7944110898604512, -1.0340878176133312, 1.9826982796384724, -0.025946575917698767, -2.2523132737754743, -0.41564420407745606, 0.16497919399598596, 0.3596300108786605, -1.2685645551212155, 1.063921848557683, -0.21497710590220126, 0.7556431209392951, -0.8006769950416389, 1.4782331056242348, -0.8564974041903614, 1.4896871646610448, -0.37655550057736986, -0.6626135337448128, 0.6243878833353832, 2.352325923513205, 0.5543312603795001, -0.39087440241400334, 0.5889177785744873},
    {-0.9060778342407327, -0.7709602656406035, 1.2990984358442368, -3.1960720357947796, -1.0877575556259755, -1.2926350383704035, -0.9171934011172961, 1.120593912511328, -0.3589534979347232, 0.031144274421102805, -2.10181600720705, 0.4079845667512395, -1.9095154456640167, -1.0020517511169744, 0.7556286047981384, -0.16580717828024316, 0.740509942487727, -0.8379099696303114, -0.5055168750511223, -1.4092590475314084, 1.331844816970949, -0.8319349370010612, -0.630201646292458, -1.3425329942981983, -1.0498629040433924, -1.1369045553716064, -0.028118926835373426, 0.669055416962874, 1.73916585738087, -0.29256208281939466, -1.3293917604566945, 1.1450237045479617, -0.6006499114967977, -0.6716999102954109, -0.7029164960817942, -0.3060263007339994, -0.25855662967185117, -1.5482839318049766, -0.10155901445334159, -0.3086215979898128, -0.22134792440558654, 0.706280752836346, 0.7816888432027779, 0.533006246274114, 0.6881917913152134, -0.7919923264771872, -1.6869768538982863, 0.2173886268954014, -1.720192570106683, -0.4103422725881192, 1.779233896725015, -1.0366363486559789, -2.4979877907852623, 0.8392707495169613, -2.308701560092264, 0.007990225102961422, -0.5373761000278313, 0.3298207120109232, -1.3927332805418975, -1.0975692679355633, 0.04085603692842548, -0.6269334453981084, -0.33594742663046523, -1.5591053443620333},
    {-1.9982967304248993, 0.19102141000889958, -0.21095643942284892, -0.6942816220402311, 0.1859918386029879, -0.10091079196246983, -1.6062743493380327, 0.034333223784267744, -1.4715558173001528, -0.5939844244286028, 0.29619826813968814, -0.5743837024115351, -1.1707890617733345, -0.943457633016224, -1.6695036249676094, -2.0717035521909715, 0.8045223279598247, -1.7225216102374417, -2.8309444183048558, 0.11994518024653195, -1.5248240380796514, -0.18633490426714067, 1.18956667218577, -0.520017035531367, -1.8055104969758402, -1.0153162649738983, -0.5260424528806006, -1.027099050966971, -1.1950162304585903, 1.7921342901310995, -1.3704077392962588, -1.879783704871475, 1.9955283033894866, -0.5341576199638575, -1.92527030097547, 0.6093491063292801, 0.9222383650157857, -2.489800137107939, -0.09565279625493915, 0.8444372290001045, -0.13243984758854804, -2.091329896233215, 0.6726363797066397, 0.29073275516438973, -0.43787185745488866, -0.031199131756138008, -1.3527639507510296, 2.259989736170371, 0.041204314292006966, 0.4618983343208264, 1.7159146380309287, 0.8694704855585232, -0.6269386682764437, -1.1168345691145738, -0.4488009075399915, -1.8514013147178194, 0.15459278820936748, -0.9383789339556691, 0.14499761956307794, -1.067691670185052, 0.7358756013688946, -0.6551731327935961, -1.5000259279734933, -0.3025366090837729},
    {-1.1916647506944191, 0.46127140441434455, -1.09072847560388, -0.9138017222119245, -0.8880708245705894, -1.5943659084012851, 0.006158449685273969, 0.4403697944532355, -0.5433306497464601, 0.42263811193963635, -1.0107327565197526, -1.3500356866795622, -0.2757711783754714, -0.1743717950673545, -1.3064824732167446, -3.27306807018431, -1.1546035505670937, -0.9713044825539481, -0.5479846325608059, -0.8199007065358173, -2.4701931750879322, -0.1505069480259661, -0.7530124339495776, -1.3462462965228446, -0.3764469422991887, -1.0603917449933138, 0.21090389851633784, -0.9397453421792848, -1.9178827742728168, 0.4103089556709059, -0.7591761136709189, 0.017974091616991004, -1.877297364568341, -0.7829396544647467, 0.22646483600956163, -1.3120493061958483, -0.6197323553563241, -0.8575232246729668, -0.9852333959353191, -0.20968119307725788, -0.13603118855307958, -3.7114820321954785, -1.7800673714529134, -0.2302317948380947, 0.3747882309860834, -1.3545113159196118, -1.3566442541267874, 1.053634484721194, -1.5124488279121184, -0.5277796554960474, 0.568197578597276, -0.5402854463775708, -0.10364386569346029, -0.6175577508166705, -0.20123397520874306, -1.170493380106234, 0.6746168764457827, 1.990875404820521, -1.2339514571694907, -0.23889193931405175, -1.2587644152723243, -1.2379315191581695, -0.012317604277848327, 0.7350028537329644},
    {1.8035189811918237, -1.1703464200639722, 0.9192047643140787, -0.9974930710624299, 1.49705694917165, -0.4897846385088794, 0.8918523406817475, -1.6110761019208024, -0.6369384568205712, 0.47547107340724665, -0.4054588049851117, -1.4908319359336228, 0.41890975328821417, -1.7353435636642367, 1.1444902358423905, -1.630826576579403, -2.0744076751910585, -1.374356323487317, -2.250115472988734, 0.095550577945909, -1.9241171777858113, -0.8258097473324078, -0.545292313920851, 0.8623853401974733, -0.8891766049213276, -1.683958330621732, -1.726913968810537, -2.194098880199, 0.5763276271815008, 0.8220837896584207, 1.0610955503473891, -1.392322222078479, -2.166525753107757, -1.4328235875759794, 0.650000200987973, 0.21491376113349056, -0.37207430509750805, 0.7078288459748288, -1.2986341881899683, 1.5461704614401905, 0.3830334472478321, -1.9796939806114315, -0.09333340078451591, -1.1097275874288388, -2.32426832070012, -1.1805153697624877, 0.2475202564382259, -0.10867937786276426, 0.00897942924273483, 0.20674798395739327, -0.24226006933296174, -0.9683597478800016, -0.7479623449796526, 0.11530252907330557, 1.1995086683563472, -2.950655475779916, 0.010358628066894651, -0.8362189765908918, -0.781355570617429, -1.2226229939073983, -0.6692507533032448, -3.0450125071348726, -0.983738692060543, -0.20131270463397366},
    {-0.3313307402931797, -0.7147813453602722, -0.7683348959594886, 0.7410820519813082, -1.3365805329183764, 0.017322416693931805, -0.09921745540309045, -0.9866417353847052, -2.382848869489116, 1.5134141653870408, -0.48965586212230156, -0.4683089651769908, -1.6656258306616822, -0.3222616934586178, -0.5240938521145125, -0.7174675111407975, -1.565005546127419, -2.5792957603336664, -0.5014542224230791, -0.34613277375215723, -0.20946273572258106, -1.2030794452816114, -0.8620652096774755, -0.7075111310689703, 0.19186731364868229, 0.23897497386284847, -2.2284566466063667, 0.39925651616781443, 0.4727510545108001, -1.1888543041721387, 1.5044213439088632, -0.7218251286934523, -0.8457862943959282, 0.9687488884073009, 1.7059333512878079, -1.8420888751103495, -0.9182240771090189, 0.26589068888558015, 0.2281783356636007, 0.32628761365187153, 0.9693472342335814, -2.615928465506976, 0.2907799875330544, -0.6513278577073395, 0.09355645075761812, -0.9503696365310546, 0.4942468880987034, 0.3079855846135442, 0.5196862579249711, 2.083895397300045, -0.1615136651065613, -3.051293624042762, 0.23577892254882596, -1.5514765305146165, -2.150688688082907, -0.7378840043770207, 0.947470031605657, 0.2511621152237753, 0.6785812480160162, -1.103736425347911, 0.695807576724476, 0.4272508550407568, -2.3844403092045465, -1.4032867269030318},
    {-0.3594721353074626, -1.2419924981351034, -1.0650984437447149, 0.4476057885591047, -0.4347151958082929, 0.5375474760047925, -1.5231725286614026, -0.58748628190445, -2.2317195467483595, 1.3794991561039498, -0.05678577295384144, -0.6072452863635538, 0.4036077757890487, -0.16950111730718298, 0.23160751859672418, -2.609898195330538, -2.03783648943326, -1.1069358284373496, 0.3545261353957315, -1.2505197453123893, -0.7976485480081689, 0.4364659139734597, -2.16033911155384, -3.093594717123045, -0.12935590080052875, -1.812958505425275, -0.43257645639014225, -0.06529057151935722, -1.2237461593858443, 1.4304977341220217, -1.6136156982657848, 0.2659392572938754, -0.6032677265686078, -1.5482152023133406, -1.070410502964341, -1.3340732737211571, 0.49588324766697295, -2.2331851713516753, -0.6576936142579269, -0.5047808599127852, 1.0818289634784097, -0.634747317535098, 0.4035551663514259, 1.7574477517731164, -2.105468020636407, -2.161112049093279, 0.08610381423477023, 1.518645885696478, -0.7508102993331378, -0.09144992659890708, 1.7213464119956479, -1.6373998479124878, 1.3791526641430956, 1.421040407479665, -0.6292497822189009, -0.3424261120652175, 1.9443944101501613, -1.7940363425828192, 1.439618452270603, -0.8812873394978937, 0.63105355429092, -1.5728748827462415, -2.0277768319847005, -2.5158604301340026},
    {1.0034115540993889, 0.760055822712074, -1.2274432298430997, -1.5700170892526135, 2.2493252615246173, -1.6223513425077822, -2.287441570042196, -1.850987229130958, -0.892898824993437, -0.4117759539973615, -1.4514872657193907, -0.8759036863968456, -1.4817693941014565, -2.766204141729265, -0.8724783155933803, -1.2403614747802896, -1.0942021142650786, -1.469353643513057, -2.038521771465333, -0.022646424602443992, 1.1860317293793237, -0.0835027524541208, -1.2863815350378773, -1.2773698409134722, -1.4983926788767663, 0.49023539156174334, -0.6107251150045675, 0.4590584443700689, -0.8098017740503064, 1.5994388519741964, -1.9167454463052842, -0.794603191568693, 0.05630383984723331, -2.60915080773613, -1.6336132766251363, -2.3189086763252935, 0.2522974264942303, 0.3862194880637167, 1.6242495724833552, -1.1512679904834886, -0.3194896888293088, -0.4005641065773293, 0.6155796123742926, -0.6097680262569065, -1.7136675880093195, -1.9386875752629236, -1.068979936028461, -1.6808668128369424, 0.1428615346795537, -0.38524694409637184, -0.7458333564124529, -0.8501647549054606, -1.1475579575544879, -1.11824694520452, 0.15481574225346045, -1.9862642726271056, 1.9529758822957293, -0.4912997226170754, -0.06611016468724044, -0.5880753991145222, 1.3639922313454023, -0.9011614097827405, -2.9672364955314463, -0.6712347862184456},
    {0.10831419044891989, -0.8795600192042384, -0.8861192664326438, -0.8020706818724332, 2.6816111080329996, -2.040876100243649, -1.356657333683812, -0.17880075851468857, 1.4280565433244854, -0.06899377504529276, -1.276279051627785, 0.1329630288135176, 0.15933524780104016, -2.843917284227187, -1.4953944835682051, -2.140312817890506, -0.49361439649910416, 1.7889799287313126, -1.6709938118093124, 0.9050754160050587, 0.1632976646844883, 0.40226969668221174, -1.1616214965480185, 0.37441096901972515, -2.073091210446615, -0.32381853185889264, -0.04499894849505077, -0.15397853639263842, 0.11824648007177727, 0.20999439388010638, -1.2280432849954925, -0.22128833607480838, -0.9419308992176499, -0.9225831620544884, 0.20223161416379395, -1.5236343134711345, 2.557009722669235, -0.28397488779049684, -2.0042600012720264, 0.47858069231904526, 0.6934175292426373, -0.2626305389441179, -0.14580979003073802, -0.239892538580919, -1.0933464680781368, -1.3306716471910858, 1.5019454045510328, 0.8836958281764066, -1.7909145365389523, -0.9412136258290911, -0.6446453211688313, -1.4050846724402957, 1.1879262283281184, -1.0912460255405751, -1.3269894944681864, -0.36347046527297316, 0.5295781995761124, 0.9126663514664083, -0.03969950247082515, -0.5537408580308033, 0.9390547907342455, -1.3053922473083797, -1.3170201663617893, 0.38063350243994426},
    {0.8477895543034306, -2.9436843555062104, -0.16510120250368393, 0.04664833142839568, -1.566833610103664, -2.6586325847924366, -0.31214109810624735, -0.5370173589531598, -0.023191812781280775, 0.17613831207018146, 2.4679711842831686, -0.18070084994534424, 0.24669389111040851, -1.0367099344500244, -2.2804669761253784, -0.4424343809618157, -1.3104615809942166, -1.3047777184317673, -0.6480371287794213, -0.04287564573096098, 1.0764384481209763, 0.8974600165437187, -0.2617304758622849, -1.5652827592083833, 0.7930903942899924, -0.8452370126410129, 0.42472405320022455, -2.2272860023564616, -0.21698129965089127, 0.6003372151195534, 1.158539356246325, -0.49460564722168787, -2.2150316813972464, 1.3162387808815246, 0.30369512007199423, -0.8090705515087943, 0.2012715002227785, 0.0526757633086519, -0.3931697933844925, -0.48211205175837757, 0.9222520901661982, -2.607535358143636, 0.8950756422950872, -0.6894437078997271, -0.1221995845739033, 0.6426718787789913, 2.495714284308198, 0.5070781519106237, 0.5442851777829281, -0.2423551805339495, 0.7773216292394682, -1.4277439685171738, -0.6068746996996283, 0.35119007958720033, -0.39116064590891164, 0.15569602318623607, 1.4667863964055126, 0.2670607988148155, 0.18474895071762246, 1.3947368128542208, 0.7315996977417231, -0.19962205447789552, -0.3422991805234346, -1.2635500980701737},
    {0.057209246867416345, -0.7518655242145703, -1.8618980871745, -0.8296093907337976, -1.0405763573414482, -1.8964503631704672, -0.34375621052205796, 0.8697430170756905, 0.7168311858831878, -1.3696850096742763, 0.020474899741464585, -1.2651443963620574, -1.1221857255078465, -2.4060381907312274, -0.3588431564371775, -2.1396226782321834, -1.9820304976615801, -0.31353899148259395, -3.344258091864689, 0.6452747250246653, 1.4548133198115694, 0.40899255391557415, 0.9391793402528463, 0.1588634456062865, -1.5316496148633145, -0.4386177892889289, 2.385239275917559, -1.4720738761158991, 2.1625233871080116, -1.1658688619977255, -0.38162501276201655, -0.041749802327057925, 0.793418033422965, -0.4425536004468416, -0.4429924899184934, 0.49528516533920003, 1.3874274649585419, 0.14879064590517885, 0.102844885067662, 1.7871727576073608, 0.7203287684018018, 1.1544746072921872, 0.24949517482167938, -0.7784342952406288, -0.4207154939820735, 0.37480486581940325, -2.191535014698901, -0.5454799421138551, 1.5064852066341683, -0.14559504162413275, 0.1797685048640617, 0.44239795141784566, 0.378905722667345, -0.3765510738836298, -0.3318496334104876, -2.212595872110561, -0.5075591191265268, -1.2155974998726848, -0.4252237546817195, -1.022336231076027, -0.7566424273595771, -1.3116241324415292, -1.0708454760167128, -0.4562882884328315},
    {-1.1519437469143368, -1.1105743976637095, -0.9736580727100601, 0.48856125420817004, 0.024768674524680397, -0.6760197975408558, -2.5283484124117392, -0.01286478355297799, -0.4242042002929205, 0.34271759760328613, 1.2498050267009024, 0.9818542525409817, -1.0377562274380199, 0.011894162929974509, -1.6152585086036475, -2.039100679311591, -1.8497715069408027, -1.3703874288849744, -1.6437034320357216, 0.7158151070663921, -0.8848077619116469, -0.6005920333221753, 0.3708382621386882, -0.05742707170082809, -0.7690120899493051, -3.1661690093319272, -1.4591887360301892, -0.4646847543744837, -0.2714555427324808, 0.7284126895367489, -0.3599727061733513, -0.3140259657310114, -0.2713995101702093, -0.46492896773663417, -1.0414965505124396, -1.7373165074321963, 0.04444613147749562, -0.8891552828031144, 1.327203175695749, -0.5534169479118676, 0.08207406079467272, -2.0703454248200956, -1.0829998347538434, -0.306001585112793, -1.1660386389591817, -0.7750815682120077, 1.6551465482540413, 0.41407436907181877, -1.6512324200511295, 1.0709383656558586, -1.9954201860951934, -1.572184449024832, -0.5510783852349239, 0.26233728385336585, -1.349086250553832, 0.25420947577182734, 3.118339130831521, 0.5898383912919969, -0.9086970145122928, -1.7945185859239847, -0.1211240096614912, -2.176645096349367, -0.5578447675335595, 2.104097298493354},
    {-1.6888318902041155, -1.120722282244428, -2.315741478806376, -0.0844635322287253, -2.256105718716122, -2.1463094722147384, 0.010975717765481355, 1.1821088621015876, 0.6831831200816925, -0.43815151855244, 0.2161756602700128, -1.5360729075134825, 0.1089110704771729, -1.5423230525198273, -0.5676112124990464, -0.8379427167600493, 0.11423451759519221, 0.5804620707146564, -0.8070428579802522, 1.3186171728130962, -1.704670007606597, 1.7780010304715002, -0.2622463250312961, -0.9546612416747544, -1.0138309194610622, -0.6706830531085509, 0.7848101175858168, -1.1368928823653095, -0.03092363748700776, 0.46559291906911476, 1.9593609655735915, 0.7718432507963502, 2.0698049329346735, -0.35724305648584587, 0.08967412851638908, -1.5074184145704956, 0.9619783552067984, -2.2216754515441024, 0.6398548980790549, -1.0110769037298812, -1.2228101858753204, -1.2517918270727117, -0.6142404233052177, 0.41402506833053, 0.15868959384361075, -1.0349533834243891, 0.4850873574728712, -0.34834168004177024, -0.12072918219854953, 1.3006256300342942, -0.005309160034019986, -1.2027867294492756, -0.5255513169242843, 0.9138643903694306, -0.23494478251574422, -1.9293775582291546, 1.150916565746791, 0.7613642526548116, 0.391249902987015, -0.8070445877194751, 2.1264655605290406, -1.399467909884002, -2.79610341827583, 0.10907387084304025},
    {-1.7560540417153852, -1.1469246369945174, 0.19890898695872694, -0.7777822577422977, -1.9881615188384631, -1.1391682738480011, -4.148283537942457, 0.5121764399770877, 0.17786682143559668, 2.2023648749402516, -1.2497986829820797, -0.8009490616586333, -0.28846191702981383, -2.2021351816792314, -1.2011405415115677, -0.45691967901817127, -1.017206936194999, 0.8360863713514034, -1.7669580028642635, 0.8878375309287998, -0.927523795322086, -0.7004976759193157, 0.944983114146166, -0.6480199717328962, -0.3475226938740087, -1.8383116228133163, 0.7858962478514318, 0.230216592165357, 0.604168367668936, -1.2986130791312014, -0.3247680249488555, -0.5083593685727616, -1.0257162972108844, -0.047944534744688294, -0.5684572468743395, -2.9473918428521424, 0.8085982122058114, -1.4468371218859155, 1.884292341737469, -1.3939795450833723, -1.735518856544868, 0.32097768629707357, 0.35529720019438227, 0.9165042620822538, -0.7996855442639097, -1.2324862588716823, 0.6971020579954624, -0.4149673386218071, 0.9702967387241745, -0.6042832935133412, -0.5876797792697092, -0.10715064728229377, 0.8444123344653509, -1.7533539574302004, 0.7152035651260914, -0.24271741460215618, 0.0633497051139721, -0.6512563347033448, 0.7683163269845649, 0.5135468827543255, 1.7490198462386675, -2.6631997303720705, -0.7752407790125428, 0.3118988773643441},
    {-0.9586325244164938, 0.410639610587726, 0.17744719529355962, 0.700905785785618, -0.3835262101716129, -2.540812240127681, -0.9808642179284421, 0.9074648253941128, 1.4921806126992367, 0.31676447726577445, 1.3145633973764737, 0.32412328566974447, -3.9393804372555623, -0.6135411268486, -1.3270624615206992, 0.09924003015163424, -4.618816482791585, 1.7546634625649706, -0.39358860017913894, -0.863252114133101, -0.9132657090445504, 0.36062921657506564, -1.412811135159146, -1.287263908983479, -0.7288801325453108, -1.4230354938345804, -0.9506819325465894, 1.0652909631469298, 0.26497353914002036, 0.9020256636569979, -1.2974031189001858, -1.5130842331482124, -1.7803717078408676, -2.8187856282069133, -1.674756352564072, -1.2879398781887526, 0.42977482982291887, -0.6845241195327527, 0.13536126884291047, -0.45692608432291687, -0.12275060016887374, 1.3934358898311003, -0.030386551870811532, -0.4294648874737015, 1.344485512687236, -0.06518008873138921, -1.2316638411176748, -0.6581847220792633, -0.9880598045126886, -0.8935268913228493, -0.6506717141347347, -1.4641925429145795, -1.164249403008526, -0.5250520984605562, 2.0633015608954914, -2.7542462718118697, 0.7367689888292158, 2.0549324940294755, 0.9316075154395109, -2.267441356529441, -0.2942922681337083, -2.0963643177885425, -1.481974662934856, 0.4598190263027739},
    {-0.440772033100569, 0.3827162157350841, -0.21089379637004488, -2.474062065694398, 0.06648869866932022, -2.7358992205252517, -2.18156312095999, 0.11476884732434113, -0.7802295082279015, 0.0189767659421581, 1.1760808258376847, -0.6956088631462984, 0.008778530564236884, -1.1145151032889566, 1.4068315355767282, -2.145551213467791, -2.318432683331591, 2.776104096237834, -1.495685263020173, 1.1094564407904477, -1.0256878541819823, -0.046307668302174816, -2.0635779225896775, -0.7649866388747714, 1.6118359648290024, -0.16413534556674741, 0.14823744627500599, -0.6165721757883438, -0.49417303862122, 0.38649301954888166, 1.682019905991476, 1.7784005385481532, 0.020907117380370634, -0.22779429802911805, 0.5849068596233652, -0.7045281065231207, 0.16169419442618008, -0.13117522380043775, -1.9001780399680162, -1.8280277732132073, 1.0339355781288695, -0.3662211976985965, -0.7071527929557889, -0.16384821874800254, -1.3754833995731126, -1.1034307885999486, 1.2000904813689117, -1.1044920471980242, -2.045442299630542, 0.26524142790159266, -0.6330045085857865, 0.9130417110349152, 1.6746617994572244, 1.1586056310692254, 0.33861022690840026, -0.2414282651448166, -0.8880520466530196, -0.7016741426349136, 0.15004655386924218, -0.4233551328554348, 0.9825887956704923, -1.1769322290067603, -0.7689692804261333, -0.46360459621609706},
    {-1.345372844772469, -1.785226432370212, 0.8959607831709245, -1.7043813338071119, 0.4133089374542752, -1.5709900273101542, -3.6810107488667607, -0.8861210193125744, -0.47657027984043265, 0.13359430243570858, 0.4316928533023373, -2.0468798925305762, 0.08759561484378484, -0.18551062349314096, -0.8596737332645426, 0.8117508583809937, -0.7185476816882158, 0.22718126224767615, -0.7808440717415464, -0.7267244785791305, -1.6000713320363678, -0.6523737585453079, -1.9892394740053265, -1.6624221435411455, -0.6992858958035892, -1.3840673007953705, -0.37248560859138696, 0.9771839871468051, 0.382384448975846, -0.6359669978141083, 0.7645488035182774, 1.4406449198417544, -2.0048435438027092, -0.04969264426329368, -1.052959554735485, -2.583029094800732, 0.29352279989695634, -0.5513136429749954, -1.4943180747001732, -1.657582184136219, 0.8050360585313509, 2.159867323334015, -0.6521233692151146, -0.28618391486514716, 1.4815485344617803, -2.6564970453029257, 1.8236715736299884, -2.8993660560706105, -1.2421082945860946, -0.7477978952399188, -0.7461698554194539, -0.998729084447859, -0.6654090750754549, 0.7407523050454606, -0.11133445550527706, 0.309955794793632, 1.239589277383838, -0.8727211261522448, 0.008304115608532607, -0.8134068512807159, -0.010603981299291916, -1.921106794866917, -0.7110670568411277, -1.1902019979178156},
    {-0.35297168777040516, -1.041068150275201, -0.4844973005964763, -1.0733141904653554, -0.5181744318577747, -0.4305137820067771, -0.0625507615031273, 0.12000653908145849, 0.09292416347959143, -1.216616361593161, 0.8976751212142544, -0.3313545599693142, 1.132890968494211, -0.10753241479145681, -1.4165894229886546, -1.427398464597564, -1.4852445403613135, -0.7782996653744582, 1.5531077056913167, -0.6367953617026625, 0.532596344756523, -1.2147984298154832, 0.4923421678843664, -2.7597889898456094, 0.25924738437629324, -0.6913750061290216, -0.49001548279262863, -1.161203126481921, -0.5420759017782637, 0.03219127688652116, 0.9213771147419385, -0.6654252529838143, -1.747237570707002, -1.5859048504681181, -2.094128919795905, -1.8706813648534029, -0.5629177977559479, -1.9988850018192361, 1.475218034354969, -0.5707200841341101, -0.25489571139421546, 1.1227502936225269, -0.3409663432088698, 0.931639144765244, -0.0882820974472041, -0.799757963497095, -0.17011804886569568, -0.7036534390087663, -1.6258947504515886, -0.8773721890365959, 0.43745678349712785, -0.5665383084991752, -0.2615930470875352, -2.739979337846205, -1.500394526021445, -2.799483611830852, -1.635455682379457, -0.2501068905877866, -1.2844721770037235, -1.4596014764417722, -0.3987207987462286, -0.8814246125277149, -0.33710520356743384, -0.8629444258481673},
    {-0.13907799444183258, 0.36669371488734875, -1.9878127022897503, 0.48224826650860086, 0.4096607046991944, -1.9498612462785996, -0.38759712925792694, 1.0698334416472821, -2.347082662497058, 0.8739423385766653, 0.05492089820755387, -2.3823588253497068, -1.0018434294282563, -0.9692201821245755, -1.1878560494108372, -1.0894887372509863, -0.30989638189658913, 2.743705300475834, -0.13840435126596193, 1.242579739259286, -1.4228611395504527, -0.58387241434501, 0.5324175253874144, -1.8751810221583567, -3.132231529769445, 0.2911078872503225, -0.05610604233865231, 0.1675749355029616, 2.311707615770065, 1.2285098549359914, -0.5862809649628666, -0.20211419572201827, -0.4211067990307065, 0.7562192415597286, -1.8653144293520694, 2.2975373696957138, -0.3401230157881992, 0.9660039765224149, 1.0604554757299547, 0.43816624114561736, -0.590164767112913, -1.8088780813214038, -0.3489758997923203, 0.4043077373007193, -0.6474470776042149, -3.604882838340395, 1.1632133942511138, 1.203369511496418, -2.014433921890766, -1.5743269341565265, 0.6009925318626216, -0.5199050724926916, 1.8087013284195512, -2.352725330204803, -0.5013404049166421, -0.6153776493018571, 0.25569394501150877, -0.19918042385602688, 0.5542231780024783, -2.266926321721669, -0.017471210422561376, -1.16606758747064, -0.8923070941099528, -1.3130416897506114},
    {-0.21418078155821052, -1.749810548392562, -0.3216853984317707, -1.6833238323550783, 0.7640177643527603, -1.3656096436016143, -3.615406399199415, 0.3914485529591197, -0.7730966376634656, 0.9182448878746154, 1.5710358180470165, 0.5230907539082724, 0.7359193758539525, -0.46710643340966107, -0.9620559184881637, 0.4280944460710859, -0.919196957230561, -0.6534379500660417, -0.18409549486481988, 0.8500170494022717, -2.2015967048835483, 2.332599205817457, -1.2478847238314863, -0.42910448004901725, -0.7348524625270131, -0.9648202926689302, -0.5866619827319132, 0.5959661206374051, 1.425307126547858, 0.8213550660115602, 0.13991074501801723, 0.10281461655392896, 1.5384509307437684, -0.8469640955968692, -2.00338692146015, -2.119287582453991, -0.07160598947152255, -0.8355947169272288, 1.9222658821099479, -2.141141490841036, 1.6591291576841145, -0.5048821855393518, -1.1769200817729075, 0.11911945220078707, 0.4624387918477496, -1.3326148134303533, 1.6957880690797218, 0.19842338951408467, -0.5436689633028186, 0.9883587209439778, -1.0032341350251066, 0.07860362615852588, 1.368071696925974, 0.0285951128486276, 0.3082462901516815, -1.4413042578406372, -0.47815136951706905, -0.8986609354409358, -2.460900917999775, 0.9206627780603601, 1.0501665673225258, 0.31050631817609975, -2.9519667986710783, 1.0537249662270405},
    {2.723594667420442, -1.9993780837803148, 0.12065098924445307, 0.6074491298532004, 0.3549748242897345, -1.4324301803040986, -3.5663547178155914, 0.7706126347307856, -0.05228947180012032, 0.6822839568084199, 2.336449996151806, 0.9596598503092542, -1.2660793473132401, -0.4001786471443514, -1.0193472249561137, -1.8207172783109875, -2.6134124239439354, -0.7939417290771603, -0.3306332088111925, 0.7218481785042594, -1.4950904649240293, 0.06964771350295303, -0.7197069009590155, -0.14618702917838639, -0.34272258607149225, -0.5285321543501869, 1.3200750966205024, 0.2152207515325574, 2.2838025523549903, 0.4275430884027379, 1.6721941990235187, 1.5129709428609315, -3.0220887660799627, -1.110777581808952, -0.8341798158430599, -1.6170424213936312, -2.356449986816746, -2.109476024611372, 0.6490993112805604, -2.8963838947815033, 0.2911054439544462, 0.0372418759742302, 0.5323257489135566, 1.1928418292506673, -0.5801472251084024, -0.4922429246529053, 0.18732244609386384, 2.307666362198116, -1.092956902210837, -1.658114591109726, 1.110612176974381, 1.1833808696996297, 1.13382571879, -0.3651428760040409, -0.32291420331406434, 0.07261586281802851, 0.43271793007079196, -2.071561332107141, 0.42533453165880675, -0.5293341153825535, 0.788792293210271, -0.587712141022559, -0.8941139213249838, -0.7574713336386405},
    {0.3959823672273265, -0.8898010307193644, -0.643052382799237, -1.0568948539334564, 1.044794100984053, -1.4619733876777388, 0.13616653550746602, 0.9189416743025584, -0.3138055175550703, 2.3351562722983807, 2.172208828403765, -0.546979872766606, 1.5038813227674965, -0.056932679735425394, -1.1230844262007083, -0.4868314455458758, -2.64728427441298, 1.4480605882999669, -2.246812461023787, 0.8472631879067429, -0.6789097198339189, -0.3300961161067706, -1.1784706579153426, -1.4115590368383484, -1.358059878464409, -2.594801064276482, 1.2192845059240938, -0.6429574673031376, 0.08621585493532656, 0.7299804901262503, 1.4477421520457012, 0.40577073985090284, -0.5752653799419333, -2.613571417387234, -1.2878451259785872, 0.32200198684589226, -0.1196301258667432, -2.018934922913526, -1.359950480797158, -1.4755838409437707, -0.4708284812272536, 2.435794799051535, -0.314117271760907, -0.3919616862825033, 0.1922641070962441, -0.3999756885002293, 0.7672681272220635, -1.7388888827437758, -1.0825049975683523, -0.7094182018377952, -0.8929349006497997, -0.8887801948142038, -0.37711235118992864, 0.6441550398369154, -0.5598830561341162, -0.3835302653683642, 0.028350795671429688, -0.4446319741815464, -1.3993313430919911, -0.34225567231893683, 1.8559091261321847, -1.0341211098143546, -1.94727784490163, -0.01969771531727503},
    {2.6060466045371844, 0.022080515772153593, -1.584579473825667, -2.6906708712508185, -1.437396494672806, -3.28386639775433, -1.3600002144674543, 0.1004961664640766, -0.2276285186668931, -0.8854075796731398, -0.13100542953586322, -0.37485186635857876, -2.4575852206405058, -2.4591951550881848, -1.6938128127527463, -0.8160232949820283, -0.6384083268749171, -0.5614519355341636, -0.8488753458434105, 0.5304803052537143, -0.16562888328826803, 1.92225402021243, -1.234401967265988, -1.0840472249769266, -1.1185118183456242, -1.8691723208551345, 1.0545205956412775, -1.0901499164283441, -1.9524670842001532, -0.973788094986885, 0.10855597798387795, -0.47810021258513, -1.4002280982145139, -2.8104709547229487, -0.7099125387951228, 1.1198916036483584, 0.47440207451201744, -2.8168267159568665, 0.6976600505540876, -1.2401469199444402, 1.3252336658983426, 0.6287852791452679, -0.5742089144461845, 1.6537736148943702, -1.0899052348862441, -0.9917547132141442, -0.4452109968762301, -0.2919844413370923, -1.2210825177634572, -0.283145814959321, -1.0150063266326506, 1.5658197700791086, 0.11217488454108031, -1.0384089229277864, -0.2981056700487567, -2.184880838783823, -0.7290846855580124, -2.652269433039809, 1.415718450876542, -2.202755291760693, 1.3658733452751592, -2.4937093146059377, 0.1933874740311917, -0.3086719743064883},
    {-1.4851492688604135, 0.17496906256237704, -1.6526860930234109, -1.460348164163265, 0.4563956527544712, -0.6541734634742269, -0.24518523810568227, 1.2988958772391983, 0.14578919664607695, 2.111593593113047, -1.2009647959279295, 1.4285504514446696, -0.19777640889519266, -0.6864016483189819, -0.8982696227228475, -1.1496924819538066, -3.7605960938281995, -0.5799695934225266, 1.1208872500547662, 0.9845254932691752, 0.5063404356578456, 1.8303638243466391, -0.8316135383396469, -0.8944022678307705, 0.1966383086395786, -0.8435093925433967, 0.7929933085941322, 0.05218716077972429, -0.13786782665204633, -0.035704416008224174, 0.7312517973699628, 0.38881195814518993, -0.9693032305301292, -1.3607651392112334, 0.8061719152738701, -1.0828808979085152, 0.9723481295833509, -0.5845939055168308, 0.20446447003390839, -0.01483505350351939, -0.3579674522881639, 2.5348300142423947, -0.9177466257223118, -0.07009881063502807, -0.9832441915878751, 0.1380896678593677, 0.17491780506051316, 3.0843962222712973, -0.3035107683329428, -1.4342134126999528, -1.3026713961191185, -0.25034876381815635, -0.6666819040443646, 0.49921058711009053, -0.5880300872070703, 0.7348381664726693, -0.10302490411694384, 0.9190224276250871, 0.781170317447592, -2.185579963980326, 0.27723510549035185, 0.40080452323752513, 0.1503032655634583, -0.6365758040598744},
    {2.246095143704689, -2.2833951152699115, -1.2193174701874647, -3.553341917525492, 0.5362160604408002, -2.7350360437614167, 1.6531039903535332, 2.27172657256076, -2.203690467801199, 0.845999127123172, 1.6341070230174357, 0.7428793246368165, -0.8866937839463178, -0.29718966566910976, -1.2706778859898835, -0.6463174807929695, -1.3889632627872814, -0.002680383726210087, -0.6257677981157309, 0.5911831135326263, -0.6002930371902084, 0.4837583069422142, 0.5132284107367949, -0.5721765896840701, -1.771081052803254, -0.5299382267004639, 0.9979787563157201, 0.3391812043944127, 0.5814020635972524, 1.6874518175081232, 0.9138458342407826, 0.30429564621143945, 1.670333015552014, -0.3550392168613629, -0.4591312875276072, -1.8687589048090414, -0.8635764039187346, 0.3721664369141829, 0.331311992413793, -1.6753365428177422, 1.8201949198951726, 1.2608157733660326, 0.055348171491750565, 2.324497002038797, 1.4010916698094624, -1.771914208003006, 0.4884985116791357, 0.011274261155166792, -0.3919229649827918, 0.23422183737077779, -1.5450712063737182, 0.9334498046851754, 0.7318811962412533, -0.43694584732128317, -0.5792109586982149, -1.2037422600062209, -0.474357703220432, -0.8507793061600664, -0.20484277781981333, -1.3796276089228086, -0.662287578763225, -1.7728465385080636, -1.2055350004810361, -1.5624650420422048},
    {-1.2735529157124674, -1.3163386463434403, -1.5868668296347073, -0.9278665723670932, -0.1730210194102795, -1.2129758196517668, -2.2993008639228916, 0.5017465528002153, -1.441376644810255, -0.12567477051594103, 0.7215839795635651, -1.7842524300487401, -1.2166895301824825, -1.4630109163940421, -1.5446438371298983, -0.897725545161224, -1.534712810147263, -1.3921041730839316, -1.843248655452534, 0.9513628053183857, -1.1645388951324185, 0.14885813495076908, -0.002113057039040929, -1.280705031158425, -1.5616354070785492, -0.43820824454914453, 0.12081769044580133, -0.44887264147530176, 0.027586662887417127, -0.6432890423405783, 0.7572119663544455, 1.6811029657795598, 0.7072981710522108, -1.563571841045878, -0.7916195335910867, -0.40325019998080736, 0.36704011506407797, 0.7267877519110257, 0.5564671537048506, -1.0660661982068342, -1.0677984759094212, 1.5139850163692823, -1.1678208033511968, -0.30121459964914776, -1.9951304153505924, -1.6413531988078707, 1.1421960453805307, 0.47289694002801086, -1.966778970247921, -0.8897311312736227, -0.6968715582659838, -0.9754744233520035, 1.0084232187371267, -0.9962485310399046, 2.271437843687787, -1.0641971923653741, -0.18444320146711946, -1.724282051620276, 0.189094845560107, -1.4745276430154846, 0.47963178421035396, 0.3688228151547517, -0.7701051524970101, 0.9959272700590563},
    {-0.7850718795304804, -0.5370839221367996, 0.4225131295361132, -0.5349109495774232, -0.4538725354952781, -1.1422297845249865, -1.452029865083324, -0.7075547399824594, -1.9492386978221306, -0.279010958281234, -0.7104952489764587, 2.036514107976899, 0.6527765655148746, 0.055541535315472026, -0.9734279672493754, -1.0731364416844336, -1.8801530954508532, 0.6481714541636119, -3.1795839735085685, 0.11890002794452338, -0.5411049917782363, 0.9355397721792338, 1.5147680260497651, -0.7784728264651691, -0.25045472062148827, -1.7492210099079426, 1.1449339408265757, -0.3668402266877964, 1.48296514939166, 2.8582178246260224, 0.15515475319635935, 0.24733653622448631, -0.23073019066085163, -1.7374088955146043, -0.0380236873532966, -1.8372054231094839, -0.21838774270322925, -0.9971548900694637, 0.26537827622885607, -2.5075609574044413, 0.2980770724774104, 0.8615502332611006, 0.29110899704110854, -1.8193957857565344, 0.7677798825242906, -0.3180285937182533, 0.6746725728540169, 0.35561260731765915, -0.4005883136503544, -0.7932578992533631, -1.2402020410026593, -0.43614854687397836, -1.4200585669696593, 0.4441411754514216, -0.4062421077714525, 0.9552150006460467, 0.35295347098737395, -0.9058744814014141, 0.7129906508648135, 0.5300901552077094, 1.758595492671855, -0.46540642963321804, -1.9090662742214328, -1.519503549434203},
    {0.5359499137704146, -0.2987064707441716, -0.46646367027711816, -2.3900301672043494, 0.3735603667974211, -2.0650247553197505, -1.1418881116160946, -1.229912461641062, -0.8650082841009507, -0.4931877951919093, 0.07456773831871474, -1.2364674814775807, -0.2962490332550147, 1.1628659167981827, -1.4887670355261629, -0.3369421522548426, -1.3791064556370436, 0.26392689254724777, 0.25625205733308937, 0.1749085002449944, -0.4067355824440294, -0.6268298113321468, -2.2182916958942696, -1.2308231545790258, -0.6460815066824054, -0.3058914642394612, 1.852367324412726, -0.12482690931248726, 1.249333343211478, 0.6338843970112048, 1.2681777699171712, -0.5040175414867679, -0.7731647227069621, -1.49574797042519, -0.4822457402331915, 0.7249363959645222, -0.17347844612280852, -1.1012620421329238, 2.284028320985438, -2.1554811320463236, 1.6886036612725888, 1.179359908136126, -0.3052644117198905, -0.37293799406895756, 0.716402628139153, -1.4039907851530222, -0.7539129905704987, 0.36786046868464833, -1.0754240507714592, -0.12740389015904133, 0.3114548724331313, -1.7427453094749465, 0.5610034609283527, -1.981493791152351, -0.9599175670478984, -2.8459312218027057, -0.7104644177975924, -0.7937445224658672, 1.0904017873277587, 0.3294278065123808, 3.426907306050057, 0.3432063224209336, -0.8461824760755522, 0.2303348312810493},
    {0.5918681729114147, -1.3310787325590896, 1.5134545760111902, -0.46245092827488576, -1.350818576156992, -0.1310474964094846, -1.420770396375077, -0.9765582398408594, 1.5869634339245895, -2.2870029450317917, -0.2794802635520337, 0.054423252717589465, -0.6457797191961141, 1.1139754675086602, -1.4965660760438375, 1.0777121141506156, 0.379962864277304, -0.7542938164971071, -1.2061668847867237, 0.5437285430752908, 0.9880908005631698, -0.845450438609928, 0.1960373405817469, -0.8863673318723436, -0.4113365891589035, -1.0889067466087, -1.0660079847193364, 1.7555269668367577, 0.9217394921851066, -0.3347667596552022, -0.9172967020506683, 1.332104369728242, -0.7655326425218265, 1.7220535518511455, -1.8184001642154901, -0.2420927339897908, -0.3823651032211967, 0.5775338815086936, -0.6882273653908044, -1.4991486537781111, 1.0490662326338698, -1.3681082284242005, 2.018634308830588, 0.6113625091165129, -0.015864813058260457, -0.7988115954188713, -0.5467085331898699, 0.6857395515347643, 0.18411304182720936, 0.043095540938151246, 1.0250841459969313, -0.5077887242490392, -1.0090523961476918, 0.4164686703962196, -0.6514042816607983, 0.6645991817383445, 0.4179668720482282, 0.7772976104040199, -0.7709857105344566, -1.631753159727778, 0.9752554533891817, -1.434572180881316, -3.202161681223229, 0.1731083305830188},
    {0.23043795768118547, -3.6440499602190703, 0.6051061378900346, 0.2821715336376125, 0.5768245219270325, -0.4474438931360401, -0.722738733467991, -1.2836102717678655, 1.1325482939430445, 1.6176006838023125, 0.5990024685895506, -0.5397488798904886, -0.9856650538604688, 0.6315664366548405, -0.05695823512211882, -0.5381912709347031, 2.579148922973609, 0.9503425909005773, -0.014378850740425124, -0.4921060684065966, 0.8804911017464592, 0.6391483804570477, -0.9067367443928683, -0.15757977966877143, 2.1022700767659654, -0.17953396994872373, -0.6090333211948724, 0.1793281045772679, 0.9942925348738428, 0.5903087948368678, -0.6769510342195885, 0.08173452910941713, 1.0565788122736581, 0.8498696188999654, -1.7462918672259997, 2.395150131272524, 0.624406975691199, -3.0871921960223556, 1.0735403751740467, -1.7263980542154063, -2.009027759330218, 0.39400127736050006, 1.9903114892479863, -0.24664530319974953, -1.7522749088154446, 0.3892314912089775, -2.0918570941820955, -0.02586111942136493, 1.1528072686432935, -0.21767215135903295, -0.8978692569481008, 0.19644110129412076, 1.9524175405140491, -0.3235699878482307, -1.053792011584437, 0.6080930820504054, 1.3409720586569267, 2.772520422240802, -1.926855450047094, -1.722850652914523, 3.027837871485423, 0.1846271351809315, -0.08102304246980617, -0.29083947193465626},
    {2.0809434445452903, -0.9463887071880436, 1.393384735070585, 0.9182279533184329, -0.8519045993270292, -0.7834354804630121, -0.6926026381672558, -1.1721647409674039, 1.4876882083419647, 1.2752621545610159, 0.9214220740431839, 0.6272725835552814, -0.9156843094275913, 1.1197091719647847, -0.4022104458455587, -1.4698620263364641, 0.3966439329044791, 1.437810786077501, -1.5673187830799944, -2.344539729737751, -0.6090067389973295, -2.0643287419195326, -1.497465854827634, -0.31301012235503695, 1.3783266021586569, 0.8894923751705115, 1.4358052430342307, -0.3614015387387535, -1.916822461043259, 0.705427249617387, -0.6101471682898971, -0.032892770918232526, 0.6566505750946263, -0.7634156451876807, -1.7458106817815406, -1.0219864465875395, -0.9201428709336872, -1.8453377186215842, 2.0358910633746934, 2.251240991496284, -0.47096099957839166, 2.450989125082699, 2.689347920862465, 0.4071397421116238, 1.6904630010939141, 1.138991566886093, -1.9764200731072985, 0.6076267865440412, -0.9260422435753479, 0.14784987356006998, -1.082248138352931, -1.6449695031113485, 1.6445876346962525, 1.0190095818882814, -1.8172679253428459, -0.3026754410908529, 0.4806740342655032, 3.1155613967771925, 1.1686248095726823, -1.663781223811862, -1.5222017060933233, 0.900854812463566, -0.19604901149347215, 0.6229594449088764},
    {2.181382191895912, -1.5171739083115956, 0.8129377271642994, 0.17874968397859056, -0.13391215514993265, 1.1397190645425423, -1.4023689774990022, -0.9617540700530414, 0.14706192393677675, -0.8197467341295958, 0.5415575059943307, -1.7910608784699313, -2.353251440121047, -0.07645926371854217, 0.07760398146765403, -0.5468026351795899, 0.5826223997551092, -1.8662080375364576, -1.4239364132347738, -0.02896394056744858, 0.011759140723516413, 0.4146214698403641, 0.9896606202358289, 1.5291353893845019, 2.484064741379019, 1.1835128334955483, -0.24082902056577016, 1.1192567692401127, -0.3899374550050096, -0.6975179985462049, 0.6396615707407589, 1.8203624563228946, 1.5141822779926115, -0.7108414913737208, -2.4812272355521032, 1.1035945481384795, 1.2835964539801492, -1.2150088502114267, -0.9449367167552899, 1.6830358474371967, -0.6423028819969707, -0.027237715984599835, 1.5205719966361408, 2.96523667031421, 1.9522528248560418, 0.025197729486368548, -0.5357295637636066, -1.5522498541229763, 1.1558722281392886, -0.37910812084748, -0.34399729962357756, 1.2351205784175683, -0.5012625240496491, 0.6524358080669481, -0.6485960158050754, 0.5041063033559365, -1.6864213703721709, 1.6489162053640232, -0.5796634707648552, 2.216279363879863, -2.2786985522100154, 0.5845755959824507, 0.13602355500479238, -0.3074226084778816},
    {0.6642995619838457, -0.5754203577706173, 0.5900935867743711, 0.14220343815322217, -0.43616422110848635, -3.4782218100611777, -0.3139711507267357, 1.1537626225908388, 0.6850910305913344, 0.5192510197793622, -0.22234607157415082, 0.0019008876591236575, -1.0569275586195583, 0.13005664751263965, -1.4976514011761661, 0.8269307225292134, -1.376278390548618, -2.5920169672388567, -1.3395413908108704, -1.2193910038006512, 1.3620085820045333, 1.3487498067608799, 0.35974413284145335, 3.00604867601904, 1.1536185065599904, -1.1924540260059868, 0.702016181363557, -1.3719563123504444, -1.3646563380451433, -0.7879925215282939, -1.2501399332566678, 0.8607126095045682, -0.609266041140736, -1.4025633624235294, -0.24485346152154275, 0.42078799389704247, 0.6876360623927124, -2.309136757591486, 2.047158044259662, 1.2218055558008245, 0.7596512650252236, -0.04107240416800631, 1.4356745468030192, 1.2824120740270462, 2.0755821850073306, -0.44442173731180273, -0.5042862678427299, 0.6204879151629353, 1.902037888516352, -0.010251137667884791, -0.9292297881923575, -2.7276432497912793, 0.4112078348921344, 0.2471801159046082, -2.3897327272654048, 1.3582000515979826, 1.1250754429774172, -0.12400623859879908, -1.7075882838636829, -0.22323082930061378, -1.0909591352409354, -0.06106409387664476, 0.8205671465713271, 1.844900498058977},
    {-0.2834039328535531, -1.7237650913831295, -0.13734504117906152, 1.4453783470051564, 1.006362108829835, -1.556397386424315, -0.44234685310863664, -2.220489162447124, -0.38381868342683445, -0.24936701665907104, -0.15713591197687515, -1.2952820778890832, 2.1769097218709343, -0.2437249650768764, -0.4614402296783501, 0.6886994420952053, 0.4931677770311951, -0.8986595500272064, -0.3774816343079906, -0.8007516818970978, -0.13882453799490427, -0.33106807974958197, -1.164553991982917, 2.3376982512527227, 0.6961871324979569, 0.34931149705632825, -0.7281718399104156, 2.2673574285537397, -1.489006494380919, 2.321752153561971, -0.6962603069223482, -0.5738824341995443, 0.4843404671330669, 1.6528567302272679, 1.3545773894440585, 2.6720145799139803, 0.11594922159700911, 0.08794426055952442, -1.880779518441788, 1.353125508146304, 0.6569007505900896, 1.5283012551678272, 1.7184821824471845, -0.26053335322629484, 3.0938882036854722, -2.2583378798425504, -2.3862145983779746, 0.16049465262738916, 1.312881667502475, 2.252275781693796, -0.08062900249835818, -1.509809060145224, -0.6037002994843069, 0.9590678976417489, -1.5329327936969577, 0.07020871793021806, -1.3108638783242392, 0.13148388155887092, 0.5184453434823175, -0.49790482813207665, -1.1483365708787372, -0.687387860320987, 2.202313214445577, -0.5561170769943575},
    {1.7482643888730829, -1.8641452803705505, 0.2735415577345447, -1.5273335286637721, 0.2441385796659325, -2.682975442110361, -1.871080532069369, 1.8529800796624512, -1.2700837542438221, -0.4454452080121122, -0.7666952020880371, -3.184702873638801, -1.8424486224116807, 0.08214881119184336, 1.309197173018989, 0.622981983615607, -1.6608034026931595, -1.1716082412182025, -0.5604065930576183, -0.7319375812481956, 0.9386334305366986, -1.1972259215292065, -0.4707294999912683, 1.6705813450445268, 0.7601977623079622, 0.4400256218340499, -3.147232285222563, 1.4918832220963054, -2.57197178829951, -0.1628173774196605, -2.0732581016357807, 0.2743888832921416, 0.2520453436072606, -1.4845290512904175, -0.9101373298137853, 0.4888192733607959, 1.3975782161125598, -1.3649534226044873, -0.28398472309350437, 1.3273899182171742, -0.7995510755904691, 1.9945324343644, 1.2478755552216778, 0.33547379467571364, 1.6556130837795868, -1.023148046765781, -1.7076826304693626, 1.2861580933408183, 1.1171965685291236, -0.38753906454224546, -0.7736170191610828, -1.210094150937982, 0.5793176574007572, -1.7052008915565664, 1.635696444229769, -0.536115926960046, -0.5902680158870042, 0.23707596860553393, 1.444552349977747, -1.7152221780741777, -1.565214819162609, 1.2488052091335278, -0.34419533684186315, -0.22006822251241656},
    {2.1364141082014254, -0.7373972721280246, 1.749709756498614, 0.06669270480076693, -0.3227918310811072, -0.25301755138809395, -0.18047021175238837, 1.3241795981310465, -0.345243128166928, 0.3984031609819637, 0.24462204316098185, -0.4764624546685319, -0.12016522301083943, 0.8371723627000129, -0.19694865651154403, -0.8076623417783714, -2.08336983835316, -1.4751283533559474, 0.988063722850783, -3.8792149310434154, 0.12235168585254982, -3.514494173775407, 1.02779621696071, -0.6324067015891093, -0.21271720262510999, -0.24571844965359044, -0.569325509858005, 0.038590688992248795, -1.7303355328886962, -0.16513094946110868, 0.621015554367819, -0.8394136071173949, -0.14277024285071108, 0.24927058985443692, -1.6097043326133087, 1.2937377013869202, 1.637016961742172, -0.43627563548953807, 0.7254666627811741, -0.6711912552504227, 1.1136671032638477, 1.2284022244681496, 2.4345676399148206, 0.9933363746438506, 0.4262097789466213, -1.3784791788241677, -0.5818180462457471, 0.0938212739349175, 0.38938868140038024, -1.5893728135691583, -1.743448442148062, -0.3562329200388882, -2.5929333742387515, 0.6334763294063206, -1.0698471893192734, -1.2118503416406698, -0.550837074519663, -0.7588767247758583, -0.32409104239849656, -1.507785649751703, 0.9990684047539108, 2.5453572979777324, 0.4167607886702075, -2.8592690326239474},
    {1.1066489047632146, -1.053344851322734, 1.8389605597968957, 1.0019143524330665, -0.7245575407255106, 0.19018422401086035, 0.6758067633290348, 0.6491287571773448, 1.0489971310024924, 1.039816620207608, -0.6868976426559503, -1.3310563198146947, 0.7846007123694645, 1.6118488925243046, 2.2865224042039185, -0.37020784991936573, -1.107202916619328, -2.064877622958155, -0.5497041506926437, 1.299423762774454, -0.12931020012997949, -0.6925885590652318, 0.45714125884797363, -1.0282778490561906, 0.23935279924570818, 1.0588602198784491, -1.4859270640332092, -1.002917566556916, -0.848006432644589, 0.07542236876364578, -0.898684728362696, 0.03167955923066358, -3.0137432270876268, -1.577540777952925, 0.14675111219967607, -0.9028489838771354, 0.49358934405588195, -1.347801954943329, -1.2931742838612144, 0.2939839372657297, -0.23239041605508545, 0.25590439652213737, 0.450927891520087, 2.1159809103652583, 2.2213484424089813, -0.892070037456798, -2.048101032933671, -1.7447736798115525, 0.8208393634172932, 0.5255378330789098, -1.5985684045115063, -1.045490551641859, -1.0726524283534065, -0.41575283316594785, -0.05015813172570913, -0.9902321894589624, 0.2218847136846073, 1.6382017036078198, -0.02478362433661755, -0.6131269727642531, -0.6390203280825109, -1.167880707175862, 1.045515280898617, -0.24321232846540422},
    {-0.08227625903519831, -0.07969659400542066, -0.332985076681836, -0.2507330865760159, -1.5231714054403438, 1.087566768168696, 0.3371998548757055, 1.2466340586278193, -0.37518475408742785, -0.19720090441330512, -1.2161002944938426, -1.9432677081773209, -0.8006560654687703, 2.3488610211921004, 0.9158550282963756, 0.6772682513010312, -1.4799244567495475, 1.0525750810339427, -1.6463216173691269, -0.9457571762587309, 1.1378276765651887, 0.3612484195216123, 2.1605354339286866, -1.4253902430466157, 0.05974507869254211, -2.0708067566519497, -0.9942432109469069, 1.595964381168814, 0.35728405877578767, 0.9104707931334421, -0.4774580815484604, -0.07443491371907383, -0.34465043454401445, 3.181115814519736, -0.24506574449131371, -0.4342906645596448, -1.2689433806816592, -2.6862237330517087, -0.591838459548566, -0.08241505290843043, -0.8663759257094141, -0.134275141977719, 1.2177163815168957, 2.4637193490777105, 1.6825022337089082, -1.7651083335078765, -1.0589474667265704, 0.2033760668032027, -2.0491058761947114, -0.15949560619139047, -0.7681748530501186, 0.273201629475864, 0.3243360740249471, 0.35574811996267947, -1.0820974899759903, -0.7907832182115105, -1.1768109403547937, 1.861171226970424, 0.6896399563325423, 0.35028495026550077, -1.5416779478922547, -0.44500284535072226, 1.6290961128669854, -0.6632055899481298},
    {0.34732981236190935, -0.2509856523308306, 1.4492666606983988, -0.05545911314744679, -1.0389391100210041, 0.3816464425115006, -0.10460140230496164, -1.1481452477235934, 0.04837323532771185, 0.9957125547419924, 0.05811113302671919, -1.637295815651424, -1.9884469261659081, 1.0872434564613644, 0.992111341351491, 1.958623309806631, 0.3528209614075316, 1.4064201247456714, -0.8875363671189868, -1.8959953512872754, 1.2750970643642883, -0.16922555399173397, 0.9615372205415476, 1.5907307617146362, 2.452611687887202, -1.6775004647486553, -0.5939334551330654, -1.338771382662192, -0.13739404645011408, -0.5141807851913286, -1.7923754850918228, 1.0848099219148193, 0.011395159512279873, 0.33534526803546383, -0.3301910948803865, -0.18050174302387184, -2.9706120838386783, -0.1973630258726983, -0.32274364971994585, 1.2125822946402525, 0.3360070983770397, 0.9735741278403622, 0.01955424752117609, 1.7712889449381855, 1.5230481836102014, -1.4393046015329403, -0.6454517325715253, 0.7726496120790858, -0.7351393753548644, 0.07144950034606215, -1.225010946282052, -0.37067568143154844, 0.6962177884076547, -0.47637153442391755, -1.429810206283042, 0.13991993272402198, 0.30776713857885923, 1.4279338940883644, -2.0986085735732516, 0.718282796324173, -0.3619388589856333, 1.7822717781338413, -0.6237904021959251, -0.20039889358350987},
    {0.20627638883632513, 1.4255370519857957, 0.16817591056355302, 1.6364031397229837, 0.12922105028659595, 0.34596700861443164, -1.0545969989651702, -1.3233592176364237, 0.7743838496088565, -1.4789110334156508, -0.8022614830804604, -1.651000053357891, -2.0526825212555773, 0.8637658149279183, 1.074905084818356, 0.5264486785650342, -1.0673498225257256, 0.5309582407394544, -1.362071020158251, -1.180051789833736, 3.7489581800554865, 0.8685200592439132, -0.25024056664163, 2.5030310340028197, 1.3222209213090645, -2.0235778844335766, -0.7365861612941109, -1.3549010053026747, -0.15977716745551504, -0.6995305711223369, -1.217824160589768, 0.41829012778565683, -1.7096907929636893, 0.14672759468839464, -1.8174370348798135, 0.16303230378831055, -0.20310451393353665, -0.8313270698240768, -0.4218989987738356, -0.32777160297258456, 1.3490622547665898, -0.5644761343800544, 2.206198369737464, 1.5090799290721557, 1.5058260132736259, -1.914203125778826, 0.4580114432012669, 2.283266581447206, -0.7090075089173731, 0.330568940099965, 0.2832003622285514, -0.7113650356952168, -2.1655873527174756, -0.5803427462357702, -3.3286788986276026, 0.1341218910273183, -0.9158589852625438, 0.8816250599942596, 0.6595637682410904, -0.6972590126922137, 0.07891020600419085, 1.8489221899236976, -0.30449048131151096, -2.154040477333616},
    {1.4080463228572082, -0.443553372955725, 0.2111350465167731, -0.33235466688287263, 0.3620522434683976, -0.08480220241917617, -0.4016303870820198, 2.11461869456779, 1.0911858763520719, -0.886708664532094, 0.29587339282530517, -0.8867238805417054, 0.9701786398024042, 0.8049115240505587, 1.0651756020166085, -0.13783246840287758, -1.1973171691837616, -0.6495086350386194, -1.3395179133855373, -1.5490398972461232, 0.8786418565322985, -0.32674541682122366, -0.7204250365465391, 1.231158481379729, 1.1291949361028928, -0.8388647235956946, 0.0705389473853442, 1.0484352813228828, 0.22884528292766265, -2.6189102150950827, -2.4355028163569408, -1.5517236428536234, -2.1366982760892843, -0.12576770743794266, 0.48455576955111107, 1.0450613150026347, -1.9257926931373428, -3.630593376960651, -0.9647867901694629, 3.7191083790980524, 0.0281116751769708, 1.7351997706028088, 2.185442009891966, 2.0472520087693846, 0.5018843978063009, -0.4292686145098329, -1.9375335952490442, -0.7760253652858602, 0.9493095715754368, -1.530365813792377, 0.1977101787446051, 0.4568631915371805, -0.8609817392896683, 0.8315283762689565, -0.9515851961849286, 1.3176787836382187, 1.8103551513382978, 0.463665583527251, -0.739109025472364, 0.08108729919221715, -2.3063206847463404, -0.22789800454388381, 0.5740729855598861, -0.6111059418712251},
    {1.695012607692816, -1.1556025311738913, 1.5147476532624349, -1.7519457998473744, 1.0241913316284181, -1.9421455353328443, -0.4078316424878844, -0.7126622449750528, 0.09684918176338532, -0.33602063335362, 0.7484808333250708, -0.13267524910867987, 1.0543720440039248, 0.016106553959142254, 1.7060331277217995, 1.158331189436275, -2.265042640669678, -2.4458068739887557, -1.5142580070285285, 0.6211686366397857, 1.1039135378895055, 0.33133620276864306, 2.409981983540488, 1.8746969413733539, 1.363078106927525, 0.8387636362887735, 2.5395521187278645, 0.35868575542283865, -0.03247817069708706, -1.0429227644289425, 0.4287706925254075, -0.7589296478577402, -0.826893855835981, -0.5636707240938845, 1.6811117168139094, -1.8733543620067103, 0.09157170762077332, 0.8517739010879454, -1.0655758587264623, 0.5293634989567486, 0.6341947461339598, 1.2635266622160677, 0.8745828218928259, -1.0533829126253007, 1.1331918828674876, -0.46706561455742646, -2.640231732965059, 1.6598611302356068, -0.7575555598507487, -3.0882481904082564, 2.2761219905968137, 0.9656902714000603, -1.446832874011547, -0.5154319572779674, 0.11981480903653205, -0.8766882990866801, -1.8293887393169472, 1.9886790351212222, -0.04281254064206865, -1.3548210593770027, -0.6881888241276334, -0.5676339749992956, 2.1562098000935364, -0.6071340157298015},
    {-0.1530569171203168, -1.3487542209529957, 2.332035775532989, -1.6094821367495036, 0.7841617467368172, -0.24011609670398923, -0.46087471305502065, -1.3514819047737938, 0.9597752576755905, 0.479523701410414, -0.6811761807409407, 1.5585666680288217, 0.46561824953993114, 0.5765658553751992, 0.7863355361198858, -2.3881023340264336, -1.7089058336252319, -1.117868119836259, -0.2556959997787953, 0.8999757527802886, -1.077573465047525, -0.4089619218882814, -0.41431765987327274, 1.0321379441254226, 2.259258188225901, -0.04023842380381624, 0.007724201721374567, -1.1266901071230226, 0.6760603181469774, 0.5357918468161316, -1.4172113038679084, -0.3526790961116547, -2.390176362585238, -1.2629479033403104, -0.5524122602331307, -0.7529980405865544, 0.24790431584321368, 0.36443039363244983, -1.4989274567505302, 0.1987038125148054, 1.0793412970116674, -0.07511266200416251, 0.7586558570353767, 0.2999752205339776, 0.2727830929122501, -0.9858657931946851, -1.0754246065217363, 0.27676317541899864, -1.0642640163452717, -2.5478447496152103, 0.4067013659292533, -0.25876079957528947, -1.6083155474239834, -0.005525706297677181, -0.30680476118291256, 0.6251518508910621, -2.3533532613300907, -1.6463631038945215, 0.2892663847356153, -0.8363517191995473, -0.2553823447055533, 1.0148241854334636, -0.8018186311793932, -2.9455727337980657},
    {0.2902902901346156, 0.09793591554200314, 0.7075982357210816, 0.523340680129343, 0.4407441903971071, 0.10038995761201838, -0.7086686518934228, -0.7508561511035252, 1.7151706911820914, 0.6776286924662414, 1.535265017583983, 0.11198538755221232, -1.9077960618065024, 1.4530042641819205, 1.3504662852415306, -1.170730505168518, -1.0985867984761262, -0.052267859381092685, -0.2830792013127668, -0.7458303634372053, -2.545293396982337, -0.5712723532938855, 0.055453546855988425, 0.12468505710286143, 1.614518319701831, 0.4991720589016588, 0.45052766372171893, 0.2648900705743032, -1.9785428033535548, -1.4765819385872787, -1.1868695564631133, 0.25328196221895083, 1.0159254547520224, 1.1167280620752644, -0.6924493313594215, -0.7300385541154473, -1.8337498421876943, 1.4593036386407565, -1.568477581959691, 0.16448902806759555, 0.4834226147000739, -0.2805559404963397, 0.5439026210435947, 0.14522105283152406, 2.2027371326535836, -0.5801714675779204, -1.4650470582643678, 0.7190306233871331, 1.7585281153862184, -0.21673576965371763, -2.1528405840934868, 0.3376535123294524, -0.8765985691793892, 0.9588824210706218, -0.3267275531083233, 0.41968425821123967, -1.4108683730630445, 1.735652867483122, 1.6528498173444077, -0.7600051918391224, -1.4297272039406446, -0.5485677579387865, -0.6901983316217671, -1.0302628854778972},
    {4.834877949828018, -0.9152775994741207, 1.0989660800920953, -0.3581438411677437, 1.3708773494020763, -0.6254026380477218, -0.48948112195066135, -0.649566389969885, 1.536968051808195, -0.38602913394883187, 1.7974775043733413, -0.8583807099136093, 2.092246312206405, 1.4339833707821013, 0.0967264402899633, 0.09481446058005846, -0.599667421833497, -0.37257014077678713, -0.6833067477004989, -0.1568895698370785, -0.43374352098388846, -0.09339718052249335, 0.24991062182198123, 0.6872608482988075, 0.6823373248465875, -0.5595349997972355, 0.12499643401244867, -1.4430303529473012, 0.4978489951316098, -1.4342787531105465, -1.3537937047398654, 1.221593966704382, -0.5411909849962208, -2.319390839743039, -0.5428460218266064, -0.09734886750627847, -0.8978137928251414, -0.4652751339001159, -2.4801311785906366, 1.2992766406891703, -0.4611024788551619, -0.6702550533951123, 1.323230725500166, 2.8645760172682095, 1.1416713042833004, -1.427409450470331, -0.8272796081409697, -0.1754191415757955, 0.41800856191994906, 0.9612370108548681, -0.644362744654253, -1.1962649715567002, -0.9699925414830504, 0.24950713137979727, -1.9107215529550534, 1.3466230762748754, -0.8708520048399656, 0.6319513443069139, -1.0771172861029372, -2.2694694486047737, -1.0401033735159815, -0.7304841894830092, -1.651260371453708, -1.0679452464473373},
    {1.2391055276658878, 0.8464776595536735, 1.1671509957247805, 1.2266898008041427, 1.9008804730885167, -0.8813457353149969, 0.9536927129194979, -0.896561840143961, 0.4469383522805059, -0.3575583364164538, -0.30951294031275667, -0.7316513399352295, 0.18319650443589355, 0.7964807062032424, 1.4393689160748482, 1.387235134956436, -1.4298740118239768, -1.491825090778417, -3.155812326973044, 0.8076466491159265, -0.16787379072207737, -1.6866796820535295, 0.534983767504699, 0.07584458957928816, 1.358235001895091, -0.5884790309159288, -1.5645293531996505, -0.18418977488200428, -0.5692368252178794, -1.7617083994510279, -1.0479481035449199, 0.6797433965119948, -0.02383989526341945, -1.1126560314681695, -0.5086210321846785, -1.227639368300449, -0.32058001399652963, -0.5203948301592219, 0.8082209214075375, -0.3537546715918838, -1.1704217757635045, 1.072253346995756, 0.7774430445433086, 1.4165952692328485, 0.4999945431118374, -0.10705396744550429, -0.2640456943535466, -0.5932756128774919, 0.19020241390479115, -0.9310677196942774, 0.5816174415046631, -1.980801531642178, 1.175207043409135, 0.2895582067731558, -3.4464892591951823, 0.8693386420195555, -1.1557626666818255, -0.05574382224292281, 1.9827939654314657, -0.47778948602048626, -1.8584804153743808, 0.6116560677999225, 1.4257022434763065, -0.4604365285047066},
    {1.691599402013697, -1.008180746035265, -0.01648272262266531, 0.3582717528838023, 2.254718787999715, -0.8697139298894043, -0.8152322607652622, 1.4686101269264877, 0.5041705623984919, -1.0425652993554089, -0.05635485109675328, -1.1907523588180273, -0.76640364308834, 1.0481494162422849, 1.2820506596023145, 0.8124421869975093, -0.8539225079938607, 0.09281225036150868, -0.7827075336347475, 0.7625885180747235, 0.2735340378068768, -1.09250031647249, -0.33636728218883344, -2.6034748085373107, -0.4847935889694949, -0.3808792476450892, -0.49330355767536954, 0.8348516019541418, 1.0719375835479343, 0.6456435026530433, -1.0421264821878717, 0.14801235293497325, 1.4528298678938227, -2.1171385242510965, -1.1404501021832458, -0.06422805044564465, -0.6564716166558539, 0.42557189108587334, -0.44865834296398277, -0.1270856531877559, -0.6733178240066418, -1.1216832331305304, 1.4464467450154948, -0.512774848049125, 1.9918421831871551, -1.6504757869385087, -0.07403512609469648, -1.0491752000585115, -0.9847556101764395, -1.2342310342409328, 1.3989855571809857, 0.39064930483391147, -1.595671850009378, -0.25505532916379653, -0.36313650470786135, -0.6937224085870975, 0.3538235021588373, 0.7723894745734764, 2.6176716244577443, 0.14522028312275584, -0.43333861820675, -1.3232299166533708, -0.22433378610922608, -2.4431258250506933},
    {0.372211128833465, -1.700345848273234, -1.1937954810879368, 1.7568843520585125, -0.7782314633536158, 2.2334364624386374, -0.966965143556708, -0.2968230696473004, -0.9450302537234413, -0.9113539062330065, -1.5811447425293093, -0.025659029597614638, -1.4554916781077711, 1.3315143431219412, 1.4255271254289672, 1.3528196301845583, 1.255115376991934, -1.7679863062173453, -0.5228429559481692, -1.384113213227166, 0.15993301838672158, 0.3331874028751531, -1.1048822168755463, 0.807249838458226, 0.4547655493109832, 0.7431978002020427, 0.30130936815165116, -0.21373800398540588, 0.6355842595444697, -0.2098304149104551, -0.6861545292643414, -1.0603630850068624, -0.46280027160951176, -0.7202591172914378, -1.6271235442156888, 0.13580864963864944, -0.3023726572525923, -1.9692421163138991, -0.944536329093583, 0.7296775405682573, 0.3906920590650932, -1.2403252569460463, 2.16455953920227, -0.2204121349094853, 2.0948413947222617, 0.43612562387083337, 0.6162999475882364, 0.017578096912408636, 0.796368795805903, -0.12689841526021975, 1.5069049052143717, -1.8357444275672468, -0.8639059539041541, -1.9946946752471264, -0.6819740134926412, 0.6537808622171762, 1.577818275932915, 1.6846796889553624, 2.1608202865517856, -0.4691671659462759, -1.4790081851480599, 2.4466431963423507, -0.7843879573435087, -2.0383701660601314},
    {-1.6642325169422394, -3.115764218336822, -0.6331321049140834, 2.042557559394519, 0.9604720789870252, -1.3532886658070693, 0.4439896316545981, -1.2852146639238007, 0.11225346754390966, -1.2083400436601537, -2.1323904167082812, -0.7625986646571712, -0.3262185101199547, -0.9756286048059911, 2.4268167854434752, 1.3195311278843316, 0.4743782941754699, 1.3844477227882828, -0.10274501363254851, -1.7867067138445036, 1.5236860152947702, -0.6503172604219558, -0.5453471549933665, -0.023814184424288874, 1.6210051518399589, -0.06859473557046815, -0.42569509164350267, -0.12804938095049484, -0.2607889795299034, 0.845864911794496, -2.3660893808661507, -1.0035807509761698, -0.5908679425210465, -0.9579678592201853, -0.415701202914832, 1.7221040382538417, 1.780848163479068, -0.9316041854633768, -0.7428560219080699, -1.202776691112366, -0.9412824068454214, -2.058459462581635, 0.5335021565783407, 0.24838425968347044, 2.969328517255989, -0.2933617726441382, 0.3666950046661048, 0.39516431780796685, 1.099539458446713, 1.050592666241976, -0.6600530333156988, 0.430188598509281, -0.866400866992731, -1.7179116702433155, -0.7115175608800366, 0.06678189146915402, 0.09046741889256324, 0.3017484093142248, 0.3120508724889217, -1.6775606886783465, 1.381018533779882, 0.255954078401744, -0.8146248356047426, -1.756795338643335},
    {0.808838332934837, -3.054077405103369, 1.8377684666503094, 0.3377532510272577, 1.2945906277705583, -1.2618482552159784, -0.47156891703358056, -0.7972153715695014, 1.2367445870669767, 0.0752143898160029, -0.6863018655890979, -1.3083276819458896, 0.6885352202908303, 1.2556110322511294, 1.0384753012702268, 1.0867537942135856, -0.2679186242295063, -1.0433647485021094, -3.38279107764711, -2.182213323453385, 0.9755240998514721, -1.441150979251858, -2.304942515861377, 0.7436446017847758, -0.27060417135580067, 0.7565894905935987, -0.7630502811276145, -1.5282090147985594, 0.3874134783944004, -0.559336677307685, 0.20912108543788097, -0.5779174748861501, 0.3093417952733833, 1.829883271624142, -2.7859882739864026, 2.1958811649392276, -0.37270520737662155, -1.1752272127961105, -1.0845502383905286, -1.8744317447935728, 0.187557302823406, 0.9865206463509953, 0.2686219611866685, 3.1909679134898035, 2.4327873570712293, -2.4162208059618133, 0.5220216231745098, 1.4175129264836284, 0.581871713470315, -1.2687963026933045, -1.8223631120500765, -1.0066848701281743, -0.9460224228087445, -0.741386731967619, -2.735150376912112, 0.23443846528221457, 0.16730678571256175, 1.3142318808007063, -0.648476646217921, 0.3955960797242638, 0.8045241623643653, 1.6275499570378227, -0.9969427542255347, -0.6840083710102902},
    {0.27677331829160845, -1.4005603915827796, 2.3018921397715144, 1.3439217566671486, -0.22341583580055727, 0.08107445854681677, -1.2926995674047592, -3.032420387963377, -0.03002133836639659, -0.1583649896231289, 0.7791956433944129, -0.6149730381092214, -0.9762959323019281, 2.6716314809266106, 1.2523921529437245, 0.9763523452439812, -1.7427587855093005, -1.1670724283961045, -0.5409032824784108, 1.814883538475616, -0.06869347598789938, 0.3488050322970737, -0.7724167548611798, -0.30960008180368115, 1.5857457902596022, 0.45883941181358995, 1.152334422682493, 1.1034372066658056, -0.3793263287531869, 0.9527670001295652, 1.903492695487147, -2.742610116416973, -1.1945274361255707, 1.3970607151954462, 0.1734838407700381, -2.115965141807213, -0.3578071029814057, 0.9282276547316748, -4.258464258590369, -0.6153888402080787, -0.5115846292415386, 1.1155827770412376, 1.2966993941888354, 1.0001568080645924, 1.621237847963108, -0.2994610567740395, -0.19575111617495367, 0.1457037747634993, 0.9507727675053378, -0.010045579204883436, -0.5481468222677085, -0.6712223960830467, -0.1867925963943026, 0.7473356927612269, -1.514647458011369, 0.21314317136053945, -0.6294047813649127, -0.06599094867410452, -0.3219561336690331, -1.570125757589286, -0.7788676342228871, -2.7714908363941464, 1.3195231144096173, -1.4463641173490978},
    {1.968394716025341, -0.6761089591349568, 1.5143339354505894, -0.12985743164342745, 1.1014968863482824, -1.3499610813676273, 1.2383618555698466, -1.3099330144494843, 0.35424571692296425, -0.4629893763476766, 0.40136608433862675, -1.6986429644820953, -2.1627138338898844, 0.8273646724099538, 0.1246865707240955, -1.565253911408624, -1.4489529838926158, -0.8856883585865597, 0.40762886001076887, -0.9620808897380252, 2.142116524687079, -1.2926159321869752, -2.342936440273439, 0.7732462507449965, 1.8984660139338017, -0.4038487284074323, -1.0306750993004032, -0.2760599926390791, 0.09657159201466015, -0.5953414259525117, -1.2032812556016945, 0.18959068193548775, -2.0722670786850754, -2.1503629668518274, -1.1952507754254214, 0.7237124905223382, -0.6925932407747993, -1.2937480681327598, -0.24862941210022793, -0.05054618658438597, 0.8241022670040328, 1.0075433353236405, 0.3962537438184468, 2.0811298371113334, 2.369147979777697, -1.5864436283943326, 0.5015281206246657, -2.1126068005674146, -0.7085054550947041, -1.7232932307640918, -0.9784551747385262, 0.18852889962508906, -0.36281764203735056, -0.2718121183033582, -2.3498828900312567, 0.17630157408191038, -1.6022200103894928, 1.926893752622261, 1.2532086063751928, -1.13078403007423, -1.4915131483581114, 0.7782427148769174, 0.6265987657306373, 0.8841406373089318},
    {1.9205850613937494, -1.0041954660600343, 1.1375454599471366, 0.7514052803661175, 1.3157685448250382, -0.2231285718097515, 0.9411817803914035, -1.249250650741353, -0.8006338284504413, -1.3878087626931097, 1.248630856789886, -0.17653695223012456, -0.061082698943358306, -0.9118756164851176, 2.7218283807644523, -0.4336730056925638, -1.3397984705214367, -1.3547940081242833, 0.7027672041484837, 1.193815232128232, 1.1760524800298935, -1.9631099030335069, -0.7199053964339084, -0.28405958012049776, 1.2657869060842921, 0.47061215322762207, 0.4219371701632136, -0.47185241274062156, -0.510956077076998, -1.6266824716750068, -0.39162621543795995, 1.2300900045144494, -0.1316463634514487, 0.5510021086293613, -2.8584346905996423, -1.1942826336256274, -1.4715247480681635, -1.7971621452844537, -0.8396187072915496, 2.0195227624138097, -1.2048857011808793, 0.4666945417905878, 1.7053151710204115, 1.119554112003239, 1.1134094988348329, -2.300407562404693, -1.1864707987930603, -0.7551153203901106, 1.8473693862312215, 0.32286990484920897, 0.6483891974401205, -1.1106384894315575, -1.0262554373474577, -0.7160670944278129, -1.8154815695941051, -0.3425811365238732, -2.5517582832293946, -0.06028909347727863, -0.27994441820300486, -1.149312552456635, 0.1514504153350562, 0.3919337438831672, -1.3970929783757209, -1.713043359167219},
    {1.232811853041342, -0.48713454631269004, 0.6537103517071599, -2.1103716269992754, 0.9409047323968925, -0.4753850269291267, -0.12013650682865316, -1.6269455427251267, 0.5746047594437618, -0.6353375211313531, -0.5686698818965482, -0.5868894043270025, -0.6019506809315499, 1.3476772671565542, -0.528973220712627, -0.09750798111586854, -0.8599533136079862, -0.5169290788920337, -1.0927496932889762, 0.2601270124434448, 2.0039419765043673, -2.4299577665620995, 0.10912873335553798, -1.7765337982808915, 1.5575948616435615, 0.3560794393114293, 0.4241116419710009, -0.6647530777691054, -1.9965527267058107, 0.6350501687478329, -1.8177736326714384, -1.2503358383296979, -1.1258177753077139, -1.709677401509507, -2.0787898136685805, 0.36711696576699304, -1.2598602489551038, -0.17440647751039415, -1.030883410173585, 0.7409991221047559, 0.8927529140807675, -1.7471799481990915, 2.5699834137246613, 1.1061183621884012, 1.2900445929080684, -0.9186707752707609, -1.3194427133701656, 0.8676920392766503, 1.0507044258164249, 0.17900664321045678, -0.4110688474717422, -0.9202977358654666, 1.1876395928944892, -3.027361907236205, -1.8307597959465343, 0.48409896778636713, -0.8186483902449448, 1.0873886011435325, -0.14635124542862954, -0.6438231208044625, -0.18254651138585906, -0.7418994729795715, 0.9784190902274031, -0.5192414820808078},
    {0.5590346190364931, 1.2080672393905143, 1.6695497079155086, -0.5535783139051444, 0.274843024480945, 0.5211402553389709, -0.4299466742791924, -0.7065724935916374, 2.1573596819961245, 0.7826057316748376, -0.3433349116219937, 0.8755194495611363, -1.4503281066092204, 0.5864361469964067, 2.249885737264816, -0.3562488979584911, 1.0155515461154687, -1.4301631457143904, -0.232239564362139, -0.4272603050963207, 0.9775100526280234, -0.42174371228897867, -0.6681663230015631, -0.5670877026783963, 2.559303220983923, 0.11264122014360081, 0.3479238466218379, 0.0901696628656658, 1.888177607878503, 0.07561793944965946, -0.43205870312900696, -1.6138009401988458, -0.8668532274050132, -1.5615996042897287, 0.15358292065897974, -0.09207751429820954, -2.2263142298677283, -0.6871277426148564, -1.9691797701360472, 0.5940845561605244, -0.8135852165490609, 0.41364964132274756, 0.9727270572954008, 2.566507865305555, 2.0930590627104775, 0.11854265630399556, -0.9100096887072315, 1.0576991621363578, 1.0823487048702434, -0.9049623492848778, 0.7162476354049434, -1.8566795924659965, -0.09367383682458127, -1.2041430601969494, -1.2523496039570543, -1.4402662122254095, -0.5962847663283953, 1.2773942036027042, -0.005692715594254023, 0.4466660381446697, -0.7282817364516336, 2.3413757419561523, 0.9209773408277903, -1.045707141389945},
    {2.2691785889847176, -2.0041767267979003, 1.4161590413888867, -0.8548601163178956, -1.1814441092763022, -0.31014373391968547, -0.12665691089813227, 0.4568870261097041, 0.3586540033501466, 1.4036483441428913, -0.09656120490255114, -0.4304009278210443, 0.8897120984154913, 0.47923425352520277, 0.2771936645949373, -0.30172930240198753, -0.8333016949462104, -0.8817090103287105, -1.0191241654241383, 0.22247832773828946, 0.16876129712373547, -1.6367601648759718, -0.522529402784386, -1.3179246559393978, 0.6409535492389024, -1.6871087677491126, 0.13758209481585187, -0.4500075314625203, 0.17362682032964757, -0.2850932627583322, 0.15948963329412835, 0.5875238530582686, -0.5607113549539817, 0.7429740471597165, 0.5431258210482691, -1.840221815439272, -0.3180939408792159, -1.407152318706669, -1.528606813161282, -0.350668343716529, -1.139515496827995, 0.26170298172257994, 2.417672020173313, 1.8035000674680026, 1.272179705297357, 0.8091626448741602, 0.6608318026173905, 1.7545798099996064, -0.308301009184432, -2.3348145247260508, -1.2114483910640685, -1.3688512759291391, 0.64088392843556, 0.354131911310846, -1.2797016072051257, -0.9889829188635026, 0.6339710128653665, 0.4728777012451491, 1.949903146155762, -0.3390177129679481, 0.20713502062301153, 0.7587264590612829, -1.975187798266735, -1.3903429731266144},
    {-1.2441075212337678, 0.07677371237266617, 2.3596406125983465, -0.3133184008656394, -0.49636316204979375, -0.48459676419112907, -0.8106511055329237, 0.2300146008129951, -0.7452345298271593, -0.026653929604505473, -3.5581132391351282, -0.3919825362090975, -2.5979762531167787, 1.9789936854256034, 0.5194995811222539, -1.2973452403488923, -0.9027961462121167, -1.0483821928144228, -2.052144104371817, -0.9684537260976233, 0.1705334641100922, -0.20499463441039825, 0.29433453109350294, 2.05800473012844, 0.5329147215197828, 1.1107726918511358, 0.3010923237685295, 0.2550861683990911, 0.21450206879659794, -0.10321993816532585, 0.0960371320673841, -0.6170679868224134, 0.013298653718141824, -1.332339495312187, -1.9054702716708756, -0.7588103058370845, -1.1169730195107528, -1.2633522410257085, -0.5331395256778448, -1.1368899388698737, -1.2920360122703485, -1.2818956850607681, 1.928397446346525, 2.1518835125917923, 1.1287290509128394, -3.7506854716934455, -2.673131193268315, 2.4185589822266387, 1.8954818229277675, -1.6755747432827268, 0.09285691834219403, -2.692554327955934, -0.05312520990055584, 0.14131365587511718, -1.5409884674507752, 0.41026334408822435, 0.8620848852973516, 2.3848894050468488, 0.37612792878783685, -1.0213316381523234, -3.0812369749830535, 1.1551027965697453, -0.30486220167782896, -1.857944387164708},
    {-0.11025189046841052, -1.6201991351456748, 0.30168632974399723, -0.7454295931994103, -0.0025920452744070967, 1.2724459830962151, -1.0303407041191122, 0.09346515222211213, 0.3436753383943504, -0.33941516208589756, 1.5626798699706397, -0.9308816159486599, 0.4695656283497335, 0.7349820009071769, 0.657882728789547, -0.4678996024606627, 0.6240628696906744, -1.7964445331132886, 0.5813344498300284, -1.645076695857323, 1.32074267749568, 0.6966500530125426, -1.6931818248474582, -2.0876157800397412, 0.7194779426919387, 0.5063342525374426, 0.08088620575803963, -1.1035531185555443, -0.9328666641778165, 0.8443851307725637, 0.3453468408606134, -4.620813193558906, -1.7244518479474287, 0.44515795984293394, -2.2684174314702226, -2.77931985195583, -1.1556757976141638, -2.3497183233015706, -2.7951367867550156, -0.264889762884135, 1.3838715577466216, -0.6327213745426857, 1.868291541192605, 1.1735638131433463, 1.476848814718374, -1.8900073919778448, 1.02162777114939, 0.8973995881122346, 0.007142427777977889, -0.20379258553793214, -3.4001327056683524, -0.022203711258612036, 0.16153569469558982, -1.042776811209209, -0.6893510190790679, 0.5997556198706286, -0.4029598099377006, -0.6252795410364826, 0.34275142641005407, 1.5494830465940024, -2.2073921065190167, 0.3820733018696883, -1.6686987927905181, -2.568858172532382},
    {1.306347731036342, -1.076459197517134, -1.7202423233769448, 2.3246725204114167, -2.0933959830010016, 0.2174159071102077, 2.2110927469044994, 1.8594410774499865, 0.3215865242419872, -0.35679847578887924, -0.14787569473329962, 0.5299164141369737, -0.9690062527700766, 1.0433207035178391, -0.5526690233176527, 0.4227141971058981, -1.3354600543786288, 1.492907843886323, -0.6820822691705417, 1.5845467405602824, 0.46866230447051077, -0.9080601928493798, -1.3111198357779146, 1.6136257587578287, -3.2199190798805466, -0.9890658404045949, -0.5041053695864786, 0.6265413867681108, 1.7421132509943777, 0.0007881038286213972, 1.7473576844479113, -0.5487159097070358, 0.10557585446245007, -1.4971713116195278, 0.37748274396894266, 2.0865843063037923, 0.11439828917651483, -0.3863895976055087, 1.9918457925894328, -0.824991598541822, 1.3842759900171733, -0.648812927519909, 1.4373020369857454, 1.0659172193748654, -0.7461009620511984, -0.7780610995341365, -0.9415935272758736, -0.8720507792803412, -0.7529003352981365, -2.9507751816607515, -0.9569387603786579, -0.220468101397003, 0.11794242052157304, 2.5099469934807908, 1.0888405566325337, 0.8277765493726453, -0.4239061693539885, 0.5683573241971119, -0.6453184130685189, -1.1222012032064843, 1.07713915266559, 0.896394682536208, -0.8871102762257831, -1.4299380244861077},
    {-2.179010198892782, -0.6353445455918943, -1.2456496329614626, 0.9805918948547636, 0.48645909561283057, -1.0525764395148522, 1.9434407815114314, -1.066572196843616, 1.4624129852678738, -0.1715470940103254, 2.01705776876721, -3.430885550850108, -1.536838106203695, 1.0025361110671287, -0.461596444869701, 0.3778250122301387, 0.3297014296253849, 0.3776424227785013, -0.147963710610244, -0.43704119163575655, -0.43268494688680326, 3.1734532094959347, -0.25849226336223513, 1.8248661332021856, 0.524447832372314, 0.9622369212809018, 1.5365888328082007, -0.7613346401000599, 0.05261231954411621, -0.12806725355311177, 0.4366821095126352, 2.6214142128024664, -1.3699792376733704, -0.7045800871428872, -1.1203678765566847, 1.900666050239842, -2.119186721079281, -0.9202615243462586, 0.9403063252965924, -0.27214331287113025, -0.43616366541287466, -1.5288589833778883, 1.8731405845128164, -0.3798992906752518, 0.15347217283746564, -0.9185675901613503, 0.7269923220908868, 0.7900123500572063, -1.2999649483741103, 0.7225769601603147, -1.396162011965875, 1.0624697635042895, 0.18587672743749348, 0.15403925218009373, -0.4638310518797396, 1.8217996247537047, 0.42054243523452606, 0.5754277942421904, -0.5948558622694134, 1.1064347570081483, 0.9364332822725182, -0.9369957735183306, 0.3270190470057874, 0.5391522395366223},
    {0.18435921145626635, -1.9750548924595293, 0.010064539845281188, -3.002119137738685, -0.11170843372487316, -1.092292130579313, -1.417764867800152, -2.878392749865921, 1.3281677808645247, 0.5482873506811079, 2.7091934838025233, -0.7179723247711252, -0.7213284955019726, -2.002500727157977, -0.29745914876256513, -0.6426500627500873, -1.4642757990167838, -0.6392732637756585, -2.2580554144414644, -0.5311806545011291, -0.640146583772291, 0.08878332951853997, -0.06703242149051167, -1.9584366024349797, 0.8399605808848201, -1.1453877933817347, -1.730836359640169, -1.5778733967388465, 1.331837651442099, -0.506255050995193, -0.31663200784869777, 0.9404942214288782, -0.8424557365760501, 0.32908198400020194, -0.6930687115986469, -0.378933866277418, 0.5846774530110151, 0.6307250964178257, -0.20489080202958962, 0.7584034773750218, 1.1066102406991831, -1.4880040792200144, -1.2370484006053695, 1.378111207682887, -1.0460461769860558, 0.18396538693126124, -1.2363358027176383, -0.2992771347415971, -0.39915417301603545, 0.4238707873343496, 2.139036399617647, -1.2988726237448471, -0.5259419677431929, -1.6126206228857103, 0.8817087514202515, -0.7127176087107864, 1.1678385970571674, 1.2124010139439358, 0.5045785480547986, -0.03156167977353129, 1.576866024203911, -0.011403144743808335, -1.430221826539486, -2.1467854782480438},
    {0.8398584435666502, 0.9825751391354789, -0.07881746750425388, -0.7706185887297138, -1.557571804933928, -2.846300500872933, -1.5725715135029155, -0.1622575052603631, -0.640214448764604, 0.28292768482182723, -0.5601717177651535, 0.4392199003982099, -0.6966402049325828, 0.23446785341513407, -1.975376507635244, 1.0938678390819643, -0.14843978867667057, 2.0561401638944887, -1.1997848161672282, 0.797640973288625, 0.04852869935018427, 1.0815391138302723, -0.5014694958681054, 0.34976780117390155, 1.1563258894764425, 0.28662380489390576, -0.6274038970974188, -1.428267058588312, 0.16324622687906504, 0.6177951856867745, -1.7274215926013332, -1.438692144744986, -0.7414836004109221, -0.23707048436396683, -0.6254782613610301, -0.1202722014014884, 2.090771171030123, -0.02994572383385158, -1.1598625164290275, 1.4696010017894723, 0.6604930017504426, 2.42992155408904, -0.7644818351558909, -2.1698789671585046, 0.4040767512649148, 0.9450923670197301, -0.5722184309778156, 0.8556332181891281, -1.8279686845070122, 0.5560052473953685, -0.9498745412319014, 0.7381488548301356, 1.5867932772944573, -0.4884828933718534, 0.16371394731135644, 1.7483788201082635, 1.1822626695931047, 0.7208657393599555, 0.4781409898110104, -1.4552294185335415, 1.8114116891450436, 0.5568693461303057, 0.7511323651278101, -1.2358682397358431},
    {0.05939419896336269, -1.3052800847891142, 0.020896478634136243, -0.2275705116596935, 0.5714164921770845, -0.7228098887243288, -0.577497200378927, 2.8579915195672396, 1.4106575693003653, -0.10140321093493994, 0.5426105846083176, 1.8481880530809476, -1.406671581821332, -0.0731567492289005, 0.6049266604804594, -0.8797510230742414, 1.0611894578268508, 0.19004298975198258, -0.7066667676860668, -1.4736189489546725, -1.3141909207561084, 0.7174707240469288, -0.619843340222087, 0.7054445635355459, -2.171771849161191, 0.42471278791850514, 0.915299484554566, -1.9308344091276322, 0.9213640717051514, 2.411598163007728, -0.4440522423870493, -0.05274601819917638, 0.7175895763877486, -1.4721728951951876, -1.3990654974968582, 3.2377028707456366, -0.3058554011634792, -0.17256579135990358, 0.5333469973746539, -0.4901425183092548, 0.05274025941613581, -0.04011833000879981, 0.5845991232185042, 0.7561041588545961, -0.8033045999327728, -1.8834082035951263, 0.2501320290944118, 0.18722886764219038, 0.566865064996407, 0.9158375799321439, 0.520451943353782, -0.4774500211179645, -0.5115984341348737, -1.2089465599802662, 1.1979096689633844, -0.8192468696261993, 1.6078069578998608, -0.5471030801132098, 0.9194484061106009, 0.4632270127509794, 0.764105825252063, -0.8728911699848649, -1.182835510684697, 1.401530848287333},
    {-0.4283187498995033, -1.436160003481501, 0.8142351900477719, 0.37398324064593225, 0.04996039513601036, -1.2908747892141177, 0.46781076362877083, 0.20326177223641764, 1.193974749938615, -0.596842714247963, -0.1679985648336395, 0.3287284681522729, -2.0459605429320455, -0.02642755015506495, 0.5171523762070367, -1.0344262950772567, -1.5152470208329687, -2.8205042139711582, -0.1835813746155231, -0.3322216236644944, -2.7121132011550335, 0.6181410867198303, 0.11918211754989237, 1.0129212693535885, -0.28971319538242946, -0.06399784379964296, -0.14439157232926744, -0.3376044977006434, -1.078217327505879, -1.0932925635460418, 1.9050569289804782, 2.0089195503553605, -0.2910013251903101, -1.6043167266235177, 1.902829665574501, 0.39765983340839006, 0.06463988127468834, 0.2682541396040633, -0.9706876248405141, -1.4045024927182954, 0.215253578019895, -0.5003884553205868, 0.7817980316226446, -1.372765976298762, -2.4246525346681747, 0.027726813294128596, 1.8957698659902027, -0.06400366667498229, -0.9448333127294042, -0.979385784276803, -1.537042498251278, 0.6373624509375528, -0.7291905446682507, 0.5388087865925402, -0.18027983737338876, -0.920684188064959, 1.0370419584073514, -0.731424370472091, 0.3727953163733883, -0.998822134509748, 0.3516921141217593, -2.0332867205423963, -0.20174282385911063, 0.2969250417973335},
    {-0.8794857670922978, -0.46614919448551034, 0.6979656253664202, -0.17963478082868706, -1.2068129607037237, 0.21379583402792451, 0.686904749138964, -0.40446317571964796, -1.599179810550397, -1.391152136491267, 0.5724078646285743, -0.8351759057993665, 0.5656888586196464, -0.26519000637062246, -0.2241675164074444, -0.1837380369861208, 0.99075440916752, 1.1476822879211517, -0.4045542388269619, 0.8204309202346556, -0.915952440943556, 0.8173252965227857, 1.572070055651873, -0.608638473942037, -2.370292281527622, -0.323021502155316, -0.816838991509014, -2.972496566864567, 0.30877950386570585, -0.5210750792995932, 0.31312901295774087, 2.0018787078433795, 0.6919652972267898, -2.026134808332825, -0.8456558012126927, -0.18029898569523556, -1.3839989632984306, -0.6704186677797795, 1.3065648148766515, -0.5902741523228421, 1.1235309978722756, -1.1907799836159132, -1.3764756719463849, -0.5433965926255907, 0.30697529141389385, -0.21600968319806788, 0.018217580234364546, -0.24550956847060532, -1.6483924881302838, -1.4738018476863775, -0.9353532470376669, -0.7529501833319958, -0.9204031611765727, 0.15736528946069422, -3.4159184962187257, 0.28138584775646636, 0.22254574780308453, -1.3943602949888807, 0.4848058684264662, -1.453599739919594, -1.1290706006589275, -2.228376516707669, 0.15901419813822176, -2.6774838559529828},
    {-0.04623155060400877, -2.3303001175283224, -1.1885419905017098, -1.1712890284886488, 1.794186469982293, -0.3891546160331645, 1.436988474049981, -0.8723012632569056, -0.3683517054933618, -0.0612998678162895, 2.3627173716991194, -0.44496687411600006, -0.3783728301757614, 0.8624703643358796, 0.27664071049608474, -0.686356030795789, -1.0428280657775972, 0.38580279070061685, -0.5936995899547564, 0.8663594257160345, 1.0812348278320367, 1.8050049351379966, -0.21912850509415063, -0.7366900696881815, -2.296726319615726, -1.3497047817555516, -1.021925564986552, -1.0407043630761628, -1.2385083169486826, 0.2710085960239742, 0.4950675864828057, 0.8068618743620436, -1.9038619128829237, 0.11275426808006615, 1.7794382650591316, -0.45100391320187583, 1.9749830112455278, -2.5425736336848095, -0.36476265594168295, 0.6651591442125673, -0.3604135849426856, -1.6979819846929054, -0.010249527589421617, 0.8133064501642866, -1.503801231400329, 1.0662858321364383, 0.7110740841642565, 2.364368168997262, -0.5463286391629135, -1.9560187516116703, -0.600781357573615, -0.3504251597631546, -0.48666709039687517, -0.2280795286925226, -0.9638149922295959, -2.9674212097428603, -2.1088650633419044, -0.6935079173559386, -0.07072390006692107, 0.08818801005772788, 0.047539384528723694, 0.11448205683209747, 0.5702916346127778, -0.21999071692714778},
    {0.4178870694527211, 0.8471507978081055, -0.6047215611964981, -3.2554603571059126, 0.8718494101105384, 0.047382036053966174, 2.648587653031164, -0.9811178337016581, -0.5922382546921433, 0.27832075925371597, -0.03314272187190561, -1.5718146911562976, 1.598627340254727, 0.3006445429821416, -0.44816794154098644, -2.5833207560934524, 0.1543148763300666, -0.7674312523896412, -0.5755638107461893, -0.8983953065279879, -1.425963166977682, 0.5866173600906011, 0.19348959911187014, -0.020813088085687086, -0.8982556873576111, -3.153402040445071, -0.30674080442250895, -1.467850070948599, -0.15369136636584443, -0.7120285780962429, 2.2666806682773872, -0.6812450219180421, -0.6679842176254599, -1.554057588103324, 1.104102876572876, -1.1136801486873924, 1.9518611898513696, -1.1149816842193419, -0.35783356058000104, 1.590074984835448, 1.6394161187863376, -0.6550797041572234, -1.2822378216278998, -0.7768840079311001, 0.4559029237769023, -1.3457672508334517, -0.48639637537063635, -0.2647236957101162, -0.628818690604642, 0.30628098539523213, 0.5140209078612729, 0.11943884891836413, -0.13369370288183116, 0.32118358823615933, 0.3612771094440404, 1.39560065406088, 0.835758862167107, 0.02255127927045829, -0.7430749662802008, -1.8063682491966047, 1.779155238068279, -2.1566550774298996, 1.8029345398494525, -0.7317192845353367},
    {1.7012895722658183, -0.8704226996471195, 0.026191052451646046, 0.9550251323715239, -0.18197552043867513, -2.1639423211336433, -0.4386672301362001, -1.3093854772492108, -0.7670144548416378, -0.3725667738084969, 0.049566587476616346, -1.747397698325318, 1.8297747697016085, -1.2572549789625096, -0.7877999847012808, -1.1480411714014231, -1.6673687667341568, 0.5711749619791168, -1.319055775749572, -0.9682731045469357, -0.5538442727825031, 0.5281080583473597, -0.11952924210627615, -0.6684350691575555, 0.5653897779295954, -1.0509801427860266, 0.30387802455613644, 1.564278989794379, 0.9664138783019309, -0.6618290509835864, -0.22121942768197703, -0.12457821488771555, 1.7315145437618034, -1.985633089961385, 1.1154964548625665, -2.496847015481454, -1.7521268759578283, -0.4618407449455037, -1.3566280059940727, 0.8636911688560149, 0.23485869241021307, 0.08406498988068946, -1.3453453225447596, -1.9704033767364, -0.9822888305472374, -0.5548270947073722, -0.29995492472405505, 0.6407879402004545, -0.1844323156236139, -0.2684344220271235, -0.2035818808471123, -2.4553442289877077, -1.4445183332122973, 0.645788664783931, -0.283937167595194, -0.5526684924881361, -0.4212615906224105, 0.15629503797532762, 0.6815445159383239, -2.2030624222971644, 0.9227622919023626, 0.18067256679701754, 0.10422190822691066, 1.0174285026770569},
    {0.670777706727658, 0.3698321507638192, 0.5055214260876277, 0.9686554165524605, 0.762868804670718, 0.9332001099608019, -1.1769166058951428, -2.2093191924723024, -0.15350985293277677, 0.6958798465464386, 1.2407488178633725, 1.3249276854905965, 1.4560004672327789, -1.2292771662266488, -1.2213623349542586, 0.09086817114365929, -1.1251844677094665, -0.6718745765263806, -1.9056201814284202, -0.5227394022893935, -2.0877717124697908, -1.0498539011293178, 0.21686382856887873, -0.5649711555107165, -0.29769705633570137, -1.7942521129302185, -1.2269469348393662, -0.5524726746522253, -2.0177420218982833, 0.36598012928840196, 1.3271492840408017, 1.0108686525266428, 0.5824512982867679, -2.4908094395153966, -1.8864011342836524, -1.250876675796197, -1.1384331868721558, -1.4757026131044408, -0.18664441762040254, -1.3797864763012506, 2.2608968634444406, -1.7757443139370164, -0.17119595184517425, -1.2539385457786192, 0.8989547863354143, 0.8719177275904149, 2.5376143867474807, 0.5918003317155556, -0.4944803972138675, 0.005176083695842916, -0.30504192067166724, -0.11253405360969979, -0.5117174223236862, -0.037418231008712166, -2.3790622583856584, 1.6824246598523043, -0.05011205616114691, 2.103391283256921, -0.40712195114361227, 1.590808257923507, 0.28356911095059106, -1.177693125448959, 0.08033993931844054, -2.4302211945733165},
    {0.13585852159983858, -0.8161054128084478, -0.06950150483056679, -0.888129867427996, 0.8052551550525862, -0.8594957961470058, 0.37268969325735374, 0.7814932951757593, 0.7616592407327789, 0.9045998244597884, -1.531947936060329, 0.4696762524487975, -1.8382524212749185, -1.6741419769692096, -0.4411797439522259, -1.390676485970032, -0.30053064472669183, 0.0049052468529863285, -0.9187320995383698, 0.7470013287279171, 0.625341202893369, -1.2625973460434528, 0.8346766450246719, -0.9639440806624864, -2.9200688922451694, -0.4084621014034905, -0.5912820798263523, 1.761259616800631, 0.2289355689497712, -0.31726762391680136, 0.7070079248393956, -0.26724940243285344, -1.936707861044161, 1.7487925065908658, -0.9099167495586212, -0.8945431596478828, 0.553531638953391, -1.0868340428857166, -0.3199815561959803, 0.22063755641297908, 0.6365896646031106, -0.0007387902431097282, -0.19554851490571695, -2.3062181258572383, 1.0602524801733926, -0.29108582180480896, 0.7940398541445898, 1.2628159460353348, 0.5180782098922249, -0.46782007347321736, -0.10769042579760643, -2.0096197663580524, -0.1728205279278654, -1.0645169393146825, -0.708688660498363, 1.4529246357978731, -0.4847626231665063, 0.5796230378468176, 0.76758976155055, 0.7631665040079698, 2.6328704744377225, -1.8426871555592472, -0.8947841936963137, -0.9118629840893386},
    {1.8610601561718723, 0.24858605031959857, -1.097608216755841, -0.31454324264778466, -0.8969404475775057, 0.08344384114257375, -3.528046833785291, 0.7094503324073111, -0.07268853910740757, -0.0869573222979743, -0.7080293988845098, -0.4430674600162987, 1.8470855868647826, -0.1520401617374311, -0.8032489305153562, 0.07440321629497312, -2.188874234444173, -1.2371579642423953, 0.23176946597014206, 0.31276017082218727, -0.3179012903593989, -1.6264789606100258, -0.05964788980547041, 2.6207607253327114, -1.3172368169732445, 0.8575710091648499, 0.08323053116396477, -2.394286811632146, 0.20222366790767, -0.231677628656317, -0.20781120224772007, -1.0675127426427018, -0.011668533473769864, -0.11861690156730251, -0.4420142031271432, 2.9614379873783183, -0.08041942601625535, -1.3696295155619038, -0.2223715255754611, -0.21898494941919694, -0.8163893691171589, -0.10846004074935887, 0.032734520378044155, -1.0421022126935726, 0.17597988408636842, -0.19862262569642347, -0.4796538267989744, -0.5387199319516454, 0.0325294536424954, 0.6716656588754953, 0.21321221254911743, -0.3928004350985292, -0.7635676257486769, -1.3957353069761949, -0.08395285983451622, -0.7427156895243315, 0.9062145473672479, -0.9261150260508969, -0.3375440458975152, -1.2098702311068457, 0.6191110898671803, -1.7343274825176658, 0.5223872088932713, -1.9477936404043754},
    {-0.6025848356048298, 0.21201973948709718, -0.19705241959057399, -0.18745129323125012, -1.9906941781470517, -2.2214323388254673, -1.8375046429179218, -0.12895593249678658, -1.5142016400921416, 1.3347995500553826, -0.20006734873898718, 0.005538735005231473, 0.5460967090939948, -0.47572695957797567, 0.6372811701820721, -1.6562836409454496, -0.7355762440478236, -0.9027295931400661, -1.7113597346492293, -0.33651226992895883, -1.2983223124309995, -0.530329380869487, 0.1945710274691216, -0.5462139482080703, 0.16268372976004872, -0.7285156621007521, 1.790889026182652, 0.7606984782136461, 0.222151772593549, -0.05778397362619898, 0.1729499665645636, -2.962920242681163, -2.0523992972933245, -0.48140448067994535, -0.442556379962171, -1.5059800391591933, 0.6351325872989397, -0.7606657160741388, 2.010767895657499, -0.8001481096809101, 0.06027180019978676, 0.19426549889567654, -2.4236794357209455, -0.5342086707011008, -0.7998803882704485, -2.0041040336002967, 0.6290938715911936, 1.2739831608451686, -0.03978002618103473, -1.4995956200405782, -1.4238912511118071, -0.42288205433065873, -0.6352624419566669, 0.23288826545096428, -0.10311626067013031, 0.1315263128153577, 0.8567712605075262, -0.7400441302049185, -0.7786602804488049, -1.349789860074509, 1.456860582177603, -0.004542795178112588, 0.4036707274944247, -0.9536029734856722},
    {-0.2411986393896877, -0.8556049789119486, -0.43414665295400223, -0.8932226331316381, 0.6685871066011958, -1.553329650677149, -0.29325547097146043, 0.3073905227672449, 1.9200398428281025, 0.6334647262508724, -0.39240429596867366, -0.08785710003271352, 1.87246067074204, 0.7087631360678971, -0.9544698441030098, -1.0714940147465741, -1.8292632040192147, -1.2965268218913688, -1.041406705209753, 1.1701437431347392, -0.540473569239582, -1.1071499145563264, -0.952594845140872, -1.3040047157824928, 0.5140528079373775, -1.8105537557774394, 1.8878831273393537, 0.3730161249093913, 0.7513973056685618, -0.9620772991572646, -1.3285214511490613, 0.06138494536784681, -0.28321020366794425, -0.531658013277858, -1.2388807622364282, -0.9396593575015884, 0.2786892740280159, -0.09070491939383958, -0.8950588314625219, -0.5166860634794481, -0.49693685610861726, 0.8416678832056659, -0.8683858990621561, 0.6132464757281337, -0.5579006959528808, -1.3713012986298092, 0.8124033588271323, -1.225511168729935, 0.726981391637752, 1.6640268882773583, -0.09854514157923189, -2.4099738517609053, 0.41540162614517007, -0.14881317357224255, -0.4781739840994995, 0.8013155881528177, 0.7693767392347711, -1.8458780800563348, 0.277372306440941, -1.215156994148355, 0.5937493036052156, -2.9248080935500465, -1.7787015097994694, 1.0112668759014085},
    {-0.984714756274338, -1.0114907151212646, 0.9588596022284753, -0.23920668499973377, 0.4624696473348272, -1.6584135960914281, -1.1747907091460226, -0.7794303089939643, -0.16822281664650315, 0.2029989162320992, 0.3916061921157355, -0.04012442296544428, -1.4160907597022132, 0.7570560239712388, 0.4532707390423354, -0.33141903420678, -2.847799920295028, -2.725201695351912, -1.0027235540922335, -0.8464794540180671, -0.8140947703084086, 0.1880243261441272, 0.00782089799058515, -0.18429479698470205, 1.2682194813080803, -1.3138867468156996, 0.12106005551066835, 0.8397582079267121, 1.016106935604947, 0.055600604226080194, 1.0843968274834463, 0.14204607461586582, -1.633636305734865, -2.228733178956164, -1.521143445236179, -1.509738020145546, -1.1072438452666407, 1.0558733309602462, -0.7366681878845431, -0.08072289093634348, -0.5350038911772002, 1.36355643651742, 0.7332527188099589, -0.7883729326611145, -0.9749414591241877, -0.3300375494830078, -1.667535830303134, -0.33965296081388135, -0.07292137217014592, -0.7749445042597665, -0.984994344926546, -1.03344712478006, -0.8034064304621152, -0.34626919766685105, 1.4602938846088376, -2.520573420673275, -2.511238686186446, 0.31911323440014383, 0.09210994882945268, 0.3015356265803707, -0.37147511635987535, -0.36099579258516007, 0.5086571274863617, 0.6197236843168402},
    {-1.4723467250162354, -2.5528473729826637, 0.7452664374068674, -1.902475427589537, -0.2521430383001714, -1.4306682783167555, -0.870226400784304, -0.44556283793286594, 0.38845345274592497, -0.5643159063918957, -1.0599539924882144, -0.8817265085192095, -0.5120037045119213, -1.842289343267293, 0.5826237961522711, -1.3295361968637356, -0.757551475135526, -1.0637662684174614, -0.2034583788412027, -0.5969020565653124, 0.6347860073085386, 1.0320473424884757, -0.7664416406866666, -0.6881753412925996, -0.4205854409524087, -0.48170394545936474, 0.038189942876287734, 0.09349759698966771, -0.0947621221123213, 0.09456239747378425, 1.3601189904889321, 0.9777883396175783, -1.0192897234771776, -0.9243191461940085, -0.7556220435913557, -0.17147286318208407, -0.06560415885595369, 0.2997934632705985, 0.5531749577780924, 0.018253111833923016, -0.5956513908815396, 0.30451519238820596, -0.5597593883976327, 1.2672074811251979, -0.11873349426670009, -1.2767963547215424, 1.078557416195847, 1.0730165807319072, 0.5545260739657356, -1.1699040584463405, -0.11996084069622735, -0.5133062484251755, -0.019721707355096544, 1.1465476368660477, -0.2394673119366953, -0.9752749245336343, -0.25700033641919845, -0.43985206530738774, 0.6868938370170207, -1.2590301272828017, -1.1135663553770765, -1.209468250665345, -0.28741971793091625, 0.30521113277964285},
    {1.8928421013322485, -2.846263896495682, 0.9751437386149782, -2.2919340729312356, 0.402301898392018, -2.4708621589861344, 0.6132733015819319, 1.056087261998057, -0.6789456870594932, 0.4959129580319896, -0.2899999799563132, -1.0424577140603863, -0.8485128409614596, -0.8263608103363334, 1.0425040060625812, -2.8372992015628684, -3.7169186593790675, 1.084714155485074, 0.5684194499343753, 0.1855237986647523, -0.7368857493946909, -1.8992294386551065, 0.36061542296034566, -0.9219141440037399, -2.0200219174921115, -0.31127205695720644, 1.3569441969831932, -0.34870859046127234, 2.0712125303846425, 1.1577456797911039, -0.3275008417597085, 1.1777328566329508, -1.514052201438649, 0.03178321099668008, -1.1189532775137956, -0.8958020356186436, 0.3538013610678824, -1.2378948554920952, -0.1477426372600711, 1.8437627209623106, -0.7096900730828326, 0.13649364122966257, 1.140871792083337, -1.829441401199781, -0.15481085010823084, -0.4506113739320766, 0.04964518207625186, 0.8496447691595985, 1.6197039188606992, -0.5468821620229039, 0.8735111198740937, 0.9144442924303111, 0.2557949723154633, 0.9375558187254713, 1.6103834697898765, -1.887989660360029, -0.22556207948008972, 0.7779741358239854, 1.7238113272632178, 0.1733648546952098, -0.1699937897115266, -0.07658428978395877, 0.9618516312424945, -1.9248127017133603},
    {-0.6032064825245276, -2.6270658363912354, -1.0373552152783747, -0.6501704493174791, 0.6271040733492856, -1.6806585630846498, -0.30813670404031807, 0.4370552175366701, -0.07672758974041984, 1.116062108684569, -1.1931859749901343, -0.20884703378410427, -0.36404416640841286, -0.17433074851883018, -1.5927412900467408, -0.7959081618371617, 0.12057055188909761, -0.7434446732501107, -0.504807831602396, 0.704900609206093, -0.9491716541644095, 1.2394302424314745, -0.6412572771075729, -0.12972286518349013, -0.18729489264610552, -1.0564837258238682, 1.0358006356461167, -1.1070987927313738, 0.7873453822573102, 1.7014279516765278, -0.37094334413373553, -0.36718784319675174, -0.15755620143847313, -1.0784429070243873, -0.13081344802226055, -2.46057984354714, 0.8900976117901784, -2.8477430488763202, -0.14037515123218808, 2.1757996118627885, -0.26006911393554416, 0.7413775457081595, 0.1872576881552031, -0.16306857234856334, -0.8594661297603542, -1.8632189150429443, 1.2147517866756046, -1.9737494621044893, -0.41327258419525137, -0.11527833570310114, 0.8869125951235025, -0.952550864163329, 1.1019972676861034, 2.5386831761191755, 0.4527969649171414, -2.363279484184842, 0.022013431387251065, 2.586942286813213, 0.3984069906132706, 1.9769337466777335, 0.26978422231351484, -0.4527955666242556, 1.0709059800383878, 0.4858256042990003},
    {1.5047575456031983, -1.6056201488583708, 1.1507248075616612, -0.07807186534561374, -1.1413833827349746, -0.6950008209114918, -1.2242216105770476, 0.07304400867032293, -0.5315699462479326, 0.6353387279531975, 0.7511806791361901, 0.6922057200482, -1.3857408993158027, -1.3268887051323388, -0.8690461479575793, -0.0081033181474481, -1.8074790294216723, -0.29223710909738293, -1.0330482625093305, 1.2299709091318562, -0.5404845615607878, 0.04127987090907581, -2.7904584582754444, -0.9077523080737127, -0.4859263573614534, -1.6558622069410402, 1.5627070356493356, -1.6522399903239295, -0.8595486507836912, 0.9166129398563697, -0.5027840209097212, 0.08179779861663856, -0.45749045447266373, -0.0957368294105987, -0.10378432584838822, -2.645410719326541, 0.057058656238105555, -1.9073633229527072, 0.700739213565656, -1.0564997663347575, 2.0498430320223293, -1.5077108929609802, 0.9236105384889934, -1.8011553057716265, -0.5173421950412421, -0.6659516673483141, -0.6617693459542822, -0.05008510860361669, -0.7196419129807076, 0.34589699903897375, -0.7950578761704157, -2.6457825165195743, -0.05985857160923058, 1.2187574538118737, 0.038304237593584194, -0.8196141456195296, -0.01377339284756099, 1.051472261929052, 0.932599630912693, -2.1424747365586034, 0.5211599013765913, -0.4591589957392052, -0.789193508421183, -0.8133060736874181},
    {-0.13680527346576374, -1.8049051302205192, -0.6637196473730059, -0.474676442252939, -2.659683706774266, -2.191426359726657, -2.5546273283602257, 0.385177903415099, -0.5685798098462707, 1.2095478633682493, -0.260758064525985, -0.7548221255586819, 1.7491445785412325, 0.22182165971169746, 0.22421249220206574, 1.0902262591068945, -1.0468992518338573, -2.8702214155224293, -0.5476340053761938, 0.503853996159853, -0.8216340570270065, -0.6346237798634398, -0.11158663571292071, -2.9590466568873564, 0.7731656440792365, -0.4170465915959576, 2.216339567502545, -0.6871898602791162, 0.47544752699507503, -1.8804094910203095, 1.3148015178678027, 1.7231275193115076, -0.7401300830022851, -1.7974154410680647, 1.8039595499148617, -1.4055504340465694, 0.2599485450663797, 1.2222396947413097, 1.0831104857664777, 0.43060706619670486, -0.11013298467583836, 1.6602395886395112, 0.40909885214640096, 1.3563497579228105, -1.071376075620258, -2.8335523653686345, 2.425537365616773, 2.705738435058294, 0.10547576746696237, -0.6975380862848596, -0.29401477730032327, -0.9164765252720665, -0.15826887345696858, 0.7075129171126566, -0.5285172912487073, -0.5168006187457727, 0.8548268481082683, 0.11669467105903156, 1.7846799745801598, -1.7999026315532072, 1.59961367815825, -0.1472659742569111, -0.4989525871344031, -0.5156395333120318},
    {0.39690809019987827, 0.45980354091597325, -1.0468580650935497, 0.37194555623664743, -0.607049486549971, -2.1387646770530715, -1.1259614412904062, -1.1543155047440425, 0.43970540422874554, 0.3145585785130105, 1.933842309785671, 0.05363172487377994, -0.6963788565813757, -1.2893653115627655, -1.761401761743094, -0.2147195505699215, -2.1846641851424513, -2.2999441207697817, -1.607863339157407, -1.0292968209234918, -0.42918127074293816, 2.233931074988203, -1.9829975162035358, -1.8550921308634458, -1.2683597634751984, 0.2972129867869996, 1.3409458634502873, -0.19091493400219936, 0.7981449925133827, -0.37169978678369947, 0.8917166325213005, 0.6891888339087929, -0.13123961069238618, -0.650422802849632, -0.6463545651678709, 0.00020093194781353342, 0.3191153490675482, 0.3816080130935621, -0.013644940838533947, -1.8087795859303146, 0.09951422672511356, 1.7301459455995565, -0.625300108935826, 1.0360153696861436, 1.6293503710367163, 0.6254270557897011, -1.1272421964690116, 1.934594036021113, -1.9846433311239973, 0.544173367328654, -1.0215563310889657, 1.2045229610851151, 1.026667578591535, -0.1011488759476373, 0.8057055151809049, -0.7112040600200261, 0.976102549179834, -1.057619886755945, 0.3673957203340619, -0.20860928003766685, 1.4913284518342091, -0.07974183657134627, -1.0294741299499115, -0.4324099761287568},
    {-0.29033364796668387, -0.0759559695656778, 1.9448756953805872, 0.5656702467118399, -1.1885303274524535, -1.4268739275989872, 1.9072714999021427, 0.7383879314211568, 2.997634988242378, 0.8734175169551736, -0.5934116563639402, -0.4438836176675924, 1.692435042485504, 0.531483925631685, -0.6992097189472659, 0.43207922302327645, -1.9757301385956085, -0.5587226903777253, -1.3627774070651957, 1.8983786747803195, -2.563286171230333, -0.06467562533222457, -0.590461983563485, -2.016423267505066, -0.3426623830817887, -1.5449852257878591, 1.5673310560609615, 1.1120963647844366, 1.4123110020815857, 0.27817365404088673, -1.6370906239093714, 1.2863737959563772, 1.1877652096352165, -1.8741114411915751, -0.9527262845836482, 0.3185850664326963, 0.8659568018945877, -1.2131842206506782, -0.6209024663541193, -0.2423089518844252, 2.7430963894373637, -0.2264695104417321, 0.44740694929197605, -1.2875952439811222, -0.3729258358433738, -2.263834041085223, 0.6336047100634961, 1.603961502718846, 0.20793763007559726, -1.2899020972916064, 0.18421134737607048, 0.911137348977427, -1.802328343294913, 1.0249881479194718, -1.0322842869114142, -0.300309242492676, -0.4393342592839035, -0.5121882905764011, 0.1129777202192272, 0.012043547609610602, -0.1622477810300377, -0.2984835758619529, -0.44225423761562616, 1.3437057108460562},
    {1.6747402922234755, -0.43828599801444273, -3.041826236286561, -2.824637231084236, 0.10615630864257425, -1.8538706032814711, -1.1474968807761678, 0.8113177834115233, -0.6122795814353776, -2.1573411818166166, 0.4273866949384665, -0.4525156870124858, -0.3192370956661198, 1.6568461825398049, -0.19258423760034107, -0.5554732593146379, -3.098237518487411, -0.5855484305881189, -1.3421326764205388, 0.7718243016220183, 0.32577567712020394, 0.9425984573845594, -1.2353325103842918, -1.6719455750383314, -1.7595697661121785, -2.754391666710034, 2.097565769474772, -1.0770258585024857, 2.4278226639947285, -0.3740841281038075, -1.2938007458995333, -0.4179671864762583, -1.3439652631110603, -0.42361743061843427, -2.223582436335283, 0.37189047305267603, -0.3560426023369927, -0.4634732913359528, 0.3353504318240885, -1.2601242196263178, 1.761317071230272, 0.6480135459995603, -0.5451433309313906, 1.6841690655134716, -0.38842774638681443, -1.883695033492241, 1.3668259917507442, -0.9060570083263381, -0.6501158087846781, -1.5489011442090626, -1.6069244197419723, 1.487975828964903, 0.43461259868146646, 1.6327552928890987, 0.09025660277971798, 0.28075844818664963, 0.4366983939639647, -0.09783519371249805, -0.04050514734984945, 0.5532991813621682, -1.2563322307391096, -0.43149615867744695, -0.428892105989698, -0.2227125281028503},
    {0.8475105846889215, 1.246673153374947, -0.14969027035870075, -0.0014234152283889765, -0.31829156259209535, -2.521278105671347, -0.7821362646227068, 1.4413336210402117, 0.1667295165314992, 1.8981409338046304, 0.08018337707101737, -1.518766344233355, -0.28988256773211296, -2.7469911062628323, 0.6276958425778228, 0.41931561282684343, -0.6381087823155854, 0.8261589645411479, -0.10111940836699362, 1.1650946409441432, -1.1988800994248623, 1.5133590403216897, -0.9460368515503719, -2.3559942489612578, -0.9096281426880132, -1.1161761130014185, 0.38652248997331456, -1.2773661390600397, 0.2490065831719729, -0.6147337821129092, -0.1331225939597835, -0.5023196193244588, -0.5290032877759676, -0.3258274725596602, -0.5506489031019863, 0.32387259320696243, -1.1637995904058938, -0.21221903802633854, 0.9795058477649937, 0.06281380938860891, 0.09500859743262655, 0.00639667687536513, -2.8800707137965507, -0.5231125259586993, 1.0126587413617798, -1.7852505400682843, 0.06347397382758631, -1.3995698147707827, 0.07545450157739067, 0.7376471583864741, -1.332687605515361, -0.0486862074677491, 0.2644121402332214, 0.12724105867925928, 0.2559876193045987, -1.4566829450956904, -0.51555726557311, -0.08581387740516336, 1.1557619657060787, -1.1325008271822259, 0.9785626293832349, -2.5592419083484486, -0.7650342598442662, -0.6464992824356747},
    {-0.9783649697517417, -0.6850906934240221, 0.4903118117218007, -1.6186651695062535, -2.2615269238143045, 0.6313255232003272, -0.586537376179784, 0.43051240516346806, 0.07957239025591516, 0.4660425726504482, 0.2730521605763394, 0.4997851436212495, -0.14963951237366901, 0.3121790869528568, 0.8250013332048434, 1.0793702982168718, -2.1039769698929023, 0.7856885843005456, -1.8833304255704688, 0.385378608460329, 0.08862340877207331, 1.745449413977653, -0.7165776874483198, -2.2946292127165573, -2.994720561307001, -3.4511901489035073, 2.4222445120341907, -0.34052479803519675, 0.03444066389591452, 0.24532528732275177, -0.3135822195943945, 2.0875850819485278, -0.3898992483647103, 1.082075073056465, 1.1129666150272943, -1.1445550076944913, -0.15973674130175758, -0.4176671787119159, -0.17110764316477123, -1.8660415199617346, 0.659613451867189, 1.7553168520953502, -1.18575528930895, 0.9575916827171057, 0.9677120485878131, -0.5560361915798889, -0.4567878811322892, 1.571914697346574, 0.8409130293050724, -2.070544176867286, -0.261698807727664, 0.031146867851874267, -0.7464987381744619, 0.19328515387890854, 1.2843114846700714, -1.4952310141175953, -0.7673639000536226, -0.3119681210639504, 0.08409359733315522, 1.1513303558099508, 0.11471226913126324, 0.3213560931639828, 0.47874478459230413, -1.1367895333097895},
    {0.6960795417829873, 1.4337330843736253, 0.257934529549988, -0.21069188861274335, -0.8554723684540602, -1.0003326554332472, 0.8383021356971759, -1.2114823985657508, 1.1811311046434374, 0.44912135890663074, 2.1064547520444648, 2.715422107535723, -0.5256583810847747, -1.6626569232070167, -2.0692598888832974, -0.3750940334724458, -0.38092858169207355, -0.06405336133303399, -0.607639761738115, 0.9533267545752759, 0.0918062414014064, 0.15623830677292444, -0.07778825465984496, 0.09558367826614299, -2.066087944703326, -1.9879137319684563, 1.0675700815973783, 2.5483411206100537, 2.425158572814266, 0.28595426453293404, 0.786067897796108, 1.4335184653980553, -0.7089423499898055, -0.9475698427122278, -0.6466924938015572, 0.4808179163916866, 0.85718858520798, -2.133900671439172, 0.0037400156669062314, -1.3129586202890449, 0.7750868091944927, 1.7082544709846956, -1.168147021580906, 0.5867545297102889, 0.36829011953241236, -0.7202142301380616, -0.3455221565250134, -0.5355016820122275, -0.8613440086137584, -2.4614923332177554, 0.3199766326501151, -1.1048370801909473, -1.6930469841894007, 1.5810526065517079, -1.2997086099036126, -0.9357366621173374, 0.1596695490565685, -1.1460691999679558, -0.04639019362635364, 0.6351918987636151, 1.2726058273579588, 0.5885064043259544, -0.7158487813375338, -1.6136598856684548},
    {-0.7672871131204507, -3.427584809592629, -0.8340337263898034, 0.25897073514474783, -0.9655657325975028, -0.053310338916920406, -1.7370966580740912, -0.10819884561591027, 1.9070933926567155, -0.4225440415221752, 1.1237362803805615, -0.9038890883882839, 0.03991910326681694, -0.10886072922368593, -1.209199949488549, -0.5936509804220821, -1.6561665330997575, 0.20261186645477378, -0.14851448210315055, 0.7125026916263875, -0.4984744299318305, 0.6071352122244786, -0.8518746593113081, -1.8394608060440765, -1.924133941344055, 0.3771815698518044, 1.4189411537701848, 1.2401242831943011, 2.5692266834524924, 0.9257191928378876, -2.438635985936119, 0.37714532466774986, -1.1565037856239466, -1.6652337725323811, -1.2589099581933387, 0.21500023540091123, -1.0353764071156721, -0.7341781114497999, 1.0525713290752114, -2.020713302482212, -0.8743958530946135, -0.9114108199422406, 0.8481445395203345, 1.8825746149092468, -0.6076201303437834, -1.1837084611211184, 2.2047331541629296, -1.8681382245968368, 0.5694770134885763, 1.5850869189137855, 0.41502632354297236, 0.9156948800333222, -0.7727823000651067, 0.9049502729074161, 0.7548062911704406, -0.48280274218591257, -1.3731937482401617, 0.26125453950022126, 1.0948971604247144, -0.5792088737692018, 1.830219784998156, -0.3449338297647446, 0.8722940943545479, -1.9043956895557927},
    {0.187934886402522, 1.0324905542174005, 0.14135682822084936, -0.11877005654017689, -1.4080749540778463, -1.1937585906363497, 1.5902907764650407, 0.47040974333564983, -1.3652868111731875, -0.23764630017424004, -0.5047391948392163, -0.9316730687876333, -0.8777882018913513, 0.7061957104096755, -2.763132154635045, -1.2063310248073038, -1.0390246537070804, -1.2829792005744114, -1.7081550654128894, -0.23814089277394657, -1.2484082697216856, 1.017085279134471, -0.6836195127084809, -0.031718704063429956, -1.7896652476874464, -0.9582433967522398, 2.0898863423081924, 1.2219608230241754, -0.09410204561980348, 1.4042989000971449, -1.1978059949051008, 1.8315851966035501, -1.6457349007486746, 0.7299070196902596, 0.5994338041989701, -1.6341728318338213, -0.13385113634819865, -0.8710600910176639, -0.7217866748790357, 1.0976132788132458, 2.4079452021872165, 1.7107519256740449, 0.9243593313172422, 1.606295640706005, 1.0398511747630614, -0.5577012624967274, 0.7031249017240699, 0.305268330876688, 0.5761843395986631, -1.4522892603078068, -2.1770827572550857, 0.5537320272787349, -0.8731242934401937, 2.921818596630137, -0.24848186513159698, 0.9901418969970827, 1.8432949806989685, 0.22975861736293, 0.7321207049619803, -0.8862054709471342, 0.9089644520414092, -0.28225288799933496, -0.7295977340873662, -0.07285969504922184},
    {-0.011740346595503569, -2.5903015581807676, -0.5224565193488767, -2.5021679074613328, 0.8294659966828842, -0.1484115805480121, 0.17451706813177936, -0.32985133449394244, -1.266255205837292, 0.525906396677892, -1.4751483247939428, -1.6968252978531266, 0.7028057725787311, -1.0285168271648197, 0.9209480696760424, 1.6219087068175368, -2.488099337084202, -2.637289874066202, -0.18056565865401875, -0.836746201425512, -0.3104568963319014, 0.05005030683311871, -1.0806558827022594, -0.9701178028897222, -0.3533088468001354, -1.6462465173299978, 1.987460048515875, 1.0853905682155671, 0.611067991878146, -0.31121335294955427, -0.2213255543881816, -0.006594274646946065, -0.07840655337482182, -1.3862868686039864, 1.0550029436233481, -1.1709775440919186, -1.3062650383542884, -0.9014339423151945, -0.22264590878412727, -0.6190273125406034, 0.4873479860394364, -0.5707061100840443, -0.9858516066701927, 0.19445911100788862, 0.7133315584391838, -0.26468808879357747, 0.29619614079399287, 0.24995041537220097, 0.8556970781506894, 0.20746052306046675, -0.4061497696189485, 0.6620396429955626, 1.1770829244222096, -0.1095414438334312, 1.4605395383220672, -1.7961842021175933, -1.4977087152238278, -0.7560788804934134, 1.446414392552502, -0.42319552855307213, 1.5475786500065827, -0.9994092827038271, -1.5909922651608666, -0.9460930157586819}
};

static const float b1[64] = {2.050889174809173, 2.067404549471607, 1.6871049894189407, 2.0753927095427596, 1.6851354395802962, 1.6038724893758718, 2.1459987735619537, 1.0079708418188709, 1.0313771627201052, 0.15582790737835733, 1.414664401458634, 1.9536324331323907, 1.993226302777134, 1.61601105634682, 1.6274768984129955, 1.817894069806681, 2.102258418988464, 1.8298243058654238, 1.7524614983098015, 0.6159798139207986, 1.8704004572238264, 1.6890641437541336, 1.7159887091791415, 1.843308211735264, 2.2018040093734914, 1.9721232673560747, 1.5007811992629025, 2.2289029549619266, 1.665251120663757, 0.3832137454795777, 1.1605908648042766, 1.7870370877579218, 1.3545925007240647, 1.33489527458369, 1.7547420525352544, 1.8533270351316888, 0.975714143157028, 1.625229295515934, 1.148602592467692, 1.7563985287675004, 0.3730758288084461, 1.767352924901917, 1.896084875831107, 1.199881438355693, 2.048818483589706, 1.5920715596373876, 0.9121098257539108, 1.8955272772386407, 1.948908673692322, 1.6876963667499394, 1.5207218122659545, 1.941760052060664, 1.7533393826698382, 1.6196975861294007, 1.8408990776896963, 1.7617622934043407, 1.5139305577897173, 1.5750507797072795, -0.14002683436682423, 1.4295453492665506, 1.7049595992431985, 2.096504985335789, 2.0182314622834334, 1.8726761189303518};

static const float w2[64][32] = {
    {0.39869850606239704, 2.3111115856338964, 0.46489071984734043, 1.3928483604597741, 1.7194336149565443, 1.619064051930369, -1.0196417812429497, -0.7516356372152113, 0.44780943342292684, -0.4705816722799929, -0.20560359058632066, -1.3810982310834483, 2.7854833033803517, -0.6738206099909917, -1.6142793096798516, -1.0559708142080106, 2.6667268714285175, 1.9808702206653803, -0.2560297439242835, 1.3783204793170847, -0.46216616736198995, 2.4626724343434088, 0.5559251730872299, 0.30544253989438735, 1.967725520545512, 1.1885910525567949, 2.3468244934240534, 1.2009416690850019, 0.8455456877971059, 0.6801966928943691, 0.04631635772600782, 1.4958918048645449},
    {-1.3399820249691454, 2.7050011899437973, 1.981285757403613, 1.728951199965508, -0.8785686317238066, 2.263426169418339, 1.2400734191355007, 1.3986050834038566, 0.0004110388732256586, 1.3517254048763947, 0.7977194585184961, 1.1504195930375918, 0.7638224448812049, 0.6410171991866543, 0.6088681712425522, 0.0935533348378822, 2.083689339486592, 2.9565170828132015, -1.836367964869353, 3.328587300063027, 0.8572378764137295, 1.5661279737352483, 2.664248680931089, -2.1281091305872857, 2.0478413206235286, 1.0699049315688605, 1.388997137376856, 0.6061317017117294, 1.0599343522818554, 1.3425406206022408, 0.8925756254273428, 1.418069370454881},
    {-0.05232333353305449, 1.5058856584017153, 1.6916648654869142, 0.22730858483330668, 1.839347335795803, 0.9399357735652446, 1.7404685863162577, 0.08403794953942217, -1.6950788395026288, 1.8837605470751249, 0.03837614067969687, 2.9361154974350163, 2.3513391706074147, 0.6585695877378211, -0.9459708665435536, 0.7500411447269675, 0.24450594243774407, 1.5166433403878925, 0.4557606893644253, 0.8348136216728118, -1.1685241145635508, 1.9438374135099188, 0.9009774056868869, -0.04111828604405734, 1.5593230106183993, 1.3475969473412825, 1.8171664060651658, -0.7905681604502257, -1.8472981872661982, 1.0694333671898661, 0.16606537118382206, 1.3755567090725946},
    {1.6630584035501885, 2.7647821609717047, 0.23745096222990128, 2.9092216276234795, 0.976614478093917, 1.0003969300108644, 1.8602999529106736, -0.7365014229443501, 1.394062947775584, 1.8769883007792356, -0.6716571970215057, 0.21446688620162419, 2.233186415642762, -1.1358438943192488, 1.5326685530809385, -2.200500861720208, -0.8774820281636616, 1.4289026960575864, -0.41708357480684544, 2.4026377046974967, -0.01764061135942274, 2.5838265519160455, 0.8899009578100235, 0.7527723370003727, 1.8249549528238225, -0.02078869724907775, 1.3063197492968226, 0.8137725166465991, -0.5287322157032343, 0.3287760451583195, 1.229780417096409, 2.1512484939991525},
    {0.6412554323572844, 1.4787943708579363, 1.5982715869136528, 1.6967543991689125, 2.54688622116912, 0.9245545199338521, 2.7488078607528674, 0.919254863833712, -1.7791807606531658, 2.1145561537344095, 0.7137279863699496, 1.7627510301469702, 0.8939405668908051, 0.05032006521012599, 0.7044068705418233, -2.107110173042721, -0.5463540962702647, 1.5388115246428502, -1.7858458159485502, 1.5504813561002952, 0.3022311353529955, 2.199267142722228, 1.982735131358287, 1.0771235805597548, 1.066390135078271, 1.8232385602525634, -0.6172461318338753, -1.2227935029132277, -0.8915442013200884, 0.5664287483154746, 0.3816611198378661, 2.8687697950873443},
    {0.567696204391768, 2.119987018511642, 1.0372670144847689, 1.9990564306162657, 1.9603584830367484, -0.30065484653568014, 2.5467791243987365, -0.2889842099317572, 0.3442273871173023, 3.2323215823586855, 0.0060529489834084006, 0.91813082629464, 0.760688585537465, -0.6654091165643718, 2.0456787545998822, -0.8699077234054655, 2.000709810481494, 1.8237037105533975, 0.1341199095308384, 1.0479883864277841, 0.4256904096676145, 0.9522478458050447, 3.4888999831067173, 1.0134666644632746, 1.6639568071977406, 1.0569735092747787, 2.9732374008360956, 0.5026590940077165, -0.9429667932982085, 0.4175108796385899, -0.5030887918106204, 0.91929477676307},
    {-2.4924251489405607, 2.173382638438921, 0.1409935772238296, 0.8086998921998448, 1.8745489735170966, 1.2603755132622774, 1.1953704051141718, -0.2836775722365735, 0.05835565531565335, 2.744630306361158, 0.13671387506568797, 1.709975917000812, 1.8983600055076522, -1.2368739414247314, 0.7908319040247764, -0.7538513662383579, 1.952429183105801, 1.0216468915395658, -0.736189370703363, 2.680639505319891, -0.20163294392010694, 2.3404776484627234, 3.024197711833768, 0.13636372533335914, 0.9228093598266394, 2.243403516965868, 0.9354319888800168, 0.12474232862259477, 0.17090569153541119, -0.392910359670424, -0.8033574973761421, 4.217492743128034},
    {0.16347214364517806, 1.3763953155994693, 1.5881487555326481, 1.8129299717411453, 0.05411564954338985, 0.5306735587539019, 2.400697678332619, -1.8296919352035312, -1.1414628415582508, 1.8550506595445602, 0.2031285967504557, 0.7901767420097666, 1.7040838393956024, -0.3686749539870097, 1.4467404234056571, -0.2861252677332439, -0.6862499363131596, 2.11323828145002, 0.5863934480376292, 0.6237497605667192, 0.7526804418531261, 1.1418897647281334, 0.9892578350000348, -0.9048223170414468, 0.44279740546196433, 2.2064526450251503, 0.5054742364032012, 0.4402717275947646, -2.0135598286576863, 2.613736653521251, 1.0857589527309224, 1.6654281022969906},
    {0.4000434212232785, 3.970349469936011, 0.9413481177645718, -1.3581465800328183, 1.9374990830262426, 1.3030521405004487, 1.4045031452689376, 0.9402425151576983, -0.8037727225941784, 1.3857487110738986, -0.2916759401025115, 1.2015433605246213, 1.6413864016664053, 0.035543720534198665, 1.1702263287233363, 1.6885325177263317, 1.5837118554424037, -0.8894182598537503, -1.429766577060969, 1.7931111748741881, 1.5218660192703508, -0.3175923464767546, 1.2503553630077848, 0.19457726690241753, 2.6101488183721093, -0.8341366364149916, 2.2144261599833848, -1.8442347166993516, -2.342008002524841, 2.346810209551555, 0.5590073861433733, 0.5601311642090411},
    {0.135825863249979, 0.7722510855163148, -0.23961965232685814, -0.3363198216529165, 1.6821644104831512, 1.4160227554863654, -0.04518877258862451, -0.46323957889135736, -0.10557806288998496, 0.9848401188867765, 1.3868850785903073, 1.7805911283324474, 0.890136973237266, 0.12014104014547812, 0.6559133046152775, -0.005420690356440972, 2.4195118086977803, 0.824244361337178, -0.5695972534520362, -0.3011861327015447, -0.9491283423912096, 0.0036287802602545717, 2.5267458473230415, 0.5122048748502698, 0.532929903604846, -0.04294188542290022, -0.8342137339467749, 0.12892052695381767, -1.725920190444224, 0.9090200212247072, 2.087005404313883, 2.2156025736506173},
    {-1.0379456072379347, 0.4106197775222184, 0.7824882844205112, 0.2615647925893845, 1.1521205965222663, 2.975820596746274, 2.214425567669577, -0.05676847614047645, 0.3204764062222914, -0.14049940738157338, -0.5727999168492486, 1.443207101744085, 2.134139136753393, 0.7754699660833513, -0.8892429411156241, -0.3481473783347274, 0.2674576852391716, 1.6853072843891839, -0.3754796004193904, 0.007311636278930194, 1.09914252547344, 1.8311916389750231, 1.3638795826407188, -1.9404305461991183, 1.3498658158895, 0.9908702378148054, 1.8299740869003427, 0.5227567879685193, 0.30958910000952916, -0.045962410395924004, 1.694885029402348, 1.0131613229520378},
    {-0.23596331499745007, 2.255085788493636, -0.2780513148773001, 1.2860530463436106, 2.424978937797208, -0.016021829274424575, -0.29006698479197385, -1.5078546077359989, 0.6131847231273112, 1.2566886601376592, 1.1261193503520215, 1.6329204384432228, -0.12537387329717056, -0.21247143014418762, 1.2305483720085495, -0.5249539456073206, 0.5853102432147899, 2.1221779857894463, -1.3067938932304912, 2.9909940577301315, -0.2705336182221622, 1.9717956600536843, 0.9868344147941981, -1.16429556312618, 2.6578714697887835, 0.8396783456973306, 1.2671513808348178, -0.37010178846079667, 0.41937207206794486, 0.2601714250067739, 3.1564929097402397, 3.4798245469067224},
    {-0.9331332071980444, 1.2228994962035509, 0.8577931848445215, 1.7455469716957448, 0.7241641195131991, 2.4428275333929355, 1.9530854864830645, -0.2921476439792546, -1.4966350793023373, 1.6593575940675267, 0.3468482519153516, 0.602410980357341, 1.4784223665872198, -1.3989760343833144, 1.5511624643893451, -1.0121419954178958, 1.38958722609835, 2.197101401786386, 0.08923777630595721, 1.2680739866239232, 0.23745999057567213, 2.8690960172048174, 2.325727485552942, -0.14004824825853424, 2.6158062916756144, -0.07070931571850281, 4.448166624557379, -0.6692515344036303, -0.8057933973837554, 1.0497181001295142, 0.31746602109868743, 1.2259694568201915},
    {0.13038416270945222, 1.6953967057517692, 3.3714174918131374, 0.5842875451103569, 1.9823096073906652, 1.6728571021880678, 1.1455330678891849, -1.081159393801042, -2.6770024699615966, 1.7925411404482678, -0.1401389170600114, 3.690165458912412, -0.05184092933291636, -0.2097736512562616, 2.3658617774955544, -0.20129826904357737, 2.023161373433578, 1.3192299346088519, 0.6642618882812207, 2.5695878796802445, 0.2265498931066862, 0.7186255018382536, 1.7528910942762121, -0.15705675584527903, 3.2309800485678823, -1.0222059417198064, 1.999256582402255, -0.6511610515684414, 0.19066091597771678, -0.4515956926847914, 1.8224520541477551, 0.9900813463386664},
    {-1.3521635290645089, 2.7464661140974305, 1.0297805200526398, 0.8714185347801594, 1.795071385884504, 0.7004200031081489, 2.8206672439028835, -1.7477832554916122, -0.6726092536543494, 0.11067354485731559, -1.052591601092713, 3.1475335286525294, 1.030925105003235, 0.8663753522625367, 2.013543711065423, -0.11764631966249955, 1.0343919568183622, 2.399054205243553, 0.7162722284922559, 1.3987784963309964, 0.6459138115762415, 2.123199229503389, 3.531052292497204, -0.593231450104792, 1.4868556818955778, 0.10029430189969277, 1.8929334277854644, -1.543870576573362, -0.4046934082374341, 2.0131347305725087, 0.6152774771871743, -0.11311180484520474},
    {-0.19370498240286216, 1.803523807580308, 0.3848118807905521, 1.6376526236137232, 1.2729153504830446, 2.1271316620348775, 2.3973693630901107, 0.8815882494607358, 0.9335003933759393, 1.3372909346376927, 0.9139359760513716, 1.4721317437167216, 1.9824175594990447, 0.23618066118479383, 1.8734900499202962, 0.7155320429886853, 1.9498787381152554, 2.1948851392331523, -0.9391908259944312, 0.9225720398969101, -1.3977948776941655, 2.8280281106068834, 0.5124518298198052, -0.37880789630997563, 2.8285484356142843, 0.6252634932780023, 2.4917442505810654, -1.321819967587382, 1.533790266417236, 1.0531308421612653, 0.23983467885344423, 2.8028418352703595},
    {-0.8634403351832619, 3.0209972038062904, 1.60301386417937, 2.7458816926529153, 1.070177654308594, -0.35527444679557235, 1.1064151475354724, -0.8874509590345938, -0.7244340031157581, 1.925730789926422, -0.8446166949758774, 0.28016950594829004, 2.952304315998918, -0.6983537271640029, 1.28731114889884, -0.42153703161011985, 2.2001638566276887, 1.0901760613676061, -0.23677800069143448, 0.06140053878473408, -0.006630355179582297, 3.2247385957659054, 2.3513642611566494, -0.9688485217804357, 2.883614386180082, 0.983140938447038, 1.6328967506730672, 1.271614312975579, -1.2944712939714436, 1.4741359139406973, 1.4773991340578596, 1.6194892112428028},
    {-0.26749107852789517, 1.0993276280855393, 0.594341285608758, 2.0308550774919545, 0.7627865397343492, 2.7665420831057994, 1.1533459467748783, 1.7252532899554094, -0.46392638962255295, 0.23105925109118716, -0.3191028807883255, 2.2539714576392873, 1.0741822112514126, -0.006392816057376776, 1.899152990568384, 1.1526395695885856, 1.931351128760414, 1.2805842031705126, 0.34576526884410164, 1.7183980271552732, -2.325075776890672, 1.7883962683618229, 2.344832971472204, 0.8124344322759126, 2.0802435354875817, 1.0261717025436683, 2.8866465874576406, 2.0897584389310593, -0.8244303336543805, 0.8770636266321609, 0.12397530911324635, 1.3464184774257946},
    {-0.19847304333651383, 1.3375872428020363, 2.172665862361076, 0.8680837115625126, 2.567668640775881, 2.858368002928313, 1.0769014207001981, -0.38137189008508937, -0.5078122783403147, 2.69780318697196, 0.03309370343961518, 2.761271402524558, 1.5818617314199626, -0.38894750693797353, 2.094920642644784, -2.111946798707019, 2.1338824171125705, 2.809712360262615, -0.4217753213889188, 1.7242964954540267, 0.6102325866109662, 0.9015421764760454, 1.7190160493505209, 0.7593420096833754, 1.3234781143160266, 1.0388540219390396, 1.3933454002845638, 0.8445067003848562, -1.173939312989126, 1.9405087154877183, 1.0934908252505209, 0.9817547222514094},
    {-2.4052711739188486, -0.7747672525791971, 0.9893194289597085, -0.5453349871152116, -0.10593069580950384, 0.23007076920413197, 1.576791254948588, -0.3996518574653508, -0.9598122782640753, 1.226761071505149, -0.9513779598576623, -1.5013794680662795, 2.42727142235419, 0.2869407836424872, 0.8963671527239254, -2.7283097320338183, 0.27213755197260425, 1.370017933535591, 0.9050892316203712, 2.2956159898801674, 1.318949706765705, 0.8018551235718804, 1.7347870131772596, -1.5049694030133476, 1.227066307760576, -0.23763814929832858, 1.236579756563004, -3.514683367836336, 0.9177826945949135, 0.7734645101952988, 0.7256598312110181, 0.19058932432976647},
    {-1.8819089780802873, 1.3084325644408956, 1.175277954208959, 1.6746764544144208, 2.154441813698331, 0.4854000481509346, 2.872576864239668, -1.0141593837276661, -1.0939223983753597, 0.73754447630257, 1.400363624240126, 3.138766140773424, 2.1334742893956213, 0.07012651942810622, -0.1368838864316165, 0.06481450369935268, 0.37917080975773393, 2.2358418831047224, -0.38625263848988173, 1.017326353276255, 0.09677075487657452, 1.7523315925616456, 2.9484905127804226, -3.1020421595584415, 1.7906234024017282, 1.4946624129995294, 1.1034032948744565, 1.4258766927439475, -0.9711025220272619, 1.6909478089790433, 2.3230168802857065, 1.5418284634681667},
    {-0.9557321717587424, 1.31690912886663, 1.098062870016983, 0.9884758683672948, 0.9564854726828389, 0.9344738312187655, 1.4697569953610095, -0.04744746304434344, -1.370946197878968, 2.446938536185163, 0.9703148658658882, 0.2207753203712038, 2.2623417147820972, 0.3948144666936156, 0.02126651802698836, -0.7116236850543646, 1.9383036780264835, 1.233117572938046, -0.9276427182851615, 1.5964963189644479, 0.369452192391873, 1.7099628582024216, 1.1349364819375285, 0.21285551272848782, 1.597302938825874, 2.2597524600874523, 0.9106217654575417, 0.6598715951052709, -1.1414769357775558, 0.5080490001694085, -0.9085691266695519, 2.655595238601557},
    {-0.1468833309682385, 3.18556862321055, 1.985132811826981, -0.21157343138264828, 1.2016312635040836, 1.1783551527237797, 2.026863535907629, -0.9611599641378322, -0.12565273709135205, 1.4312009548316094, -0.2525458302907822, 0.8555298141496297, 3.2611498623929513, -1.328424787843897, 1.4040316656173515, -1.8336171434432345, 0.2757157463929785, 2.771551927241931, 1.2229402314858868, 2.3111197788002107, -3.4630511058926876, 2.222572065071153, 1.0266300962124437, -0.20130079517697502, 1.7996487361934692, 0.7005937052208497, 0.7086070192247533, -1.229888406665758, -1.8727079669659856, 1.6723480969860671, 0.7819200425033813, 1.9414243974454026},
    {-0.994283911301422, 2.6756335128631625, 1.7769582884361772, 1.5153841391374776, 2.779840769657495, 2.161824362040843, 0.08660159141869841, 0.7582659356690101, -0.128581296160419, 1.4885177311052122, 0.24951561143508616, 3.5973592011853768, -0.2671941218776781, -0.6586356048369116, 1.5319414302764671, 0.472904036664436, 0.02500673734618555, 0.9564061301524448, -1.5457148118881996, 3.743489768030956, -0.6471342977035521, 2.097725628411262, 1.6568970756837464, 1.4944940407027367, 1.5681540617369272, -1.6413191446721063, 1.9112956121423306, -0.6284187177907499, 0.6889670551844043, 0.7221566805363493, 2.705927558244882, 0.9370576162793899},
    {-0.35898019676258863, 2.8749055326953146, 0.8758519718880576, -0.3120116141156448, 2.9310043698751316, 0.3177665531667848, 1.9748976488749364, 0.26293361205273563, 0.8750492067284769, 0.34843113174410983, -0.10082163966161123, 2.0399974411651565, 0.22825238401616557, -0.9786684563343773, -0.5593324524339943, -0.5744410063161881, 1.9797391113209868, 3.092709497778575, -0.6782101590694602, 2.7688611729533763, -0.20635485194449585, 2.868484873459871, 2.310537033323786, -0.5417508502350041, 2.849873120576729, 0.18646605555936566, 0.7237628635540848, 0.8715062916450761, -0.6496690449415657, 0.3711434308529412, 0.21930093138267645, 1.4457224333574625},
    {-1.6059837600140703, 2.050104208134355, 0.4353099865827301, 0.22790827881304965, 2.3704030655400024, 1.858770856975667, 1.9560501027683999, 0.7993875881187084, -1.0105035339931907, 0.18282117987276789, 0.5560807507018775, 1.756182195167775, 2.1803126941032893, 1.6187265754182696, 0.8276064064146174, -1.270512212781648, 1.9391362153416083, 2.3601344968949394, -0.8961247263984405, 1.1671251269069913, -0.49800292496545306, 1.350684466195889, 1.0691920359553357, -1.2704500529725782, 2.364798629958458, -0.06608901986782822, 0.7413211630740221, -0.8839329069325508, -0.43098900740231466, 2.114135722478067, 0.7920362183277887, 1.1466539004513305},
    {-1.1792493340994528, -0.455134301950934, 0.10804210392655966, 2.065994260896557, 2.1163957329970735, 2.204160822785993, 1.7479655996348504, 0.13833962668182234, -2.1106449206519837, -0.0022068542837894068, -1.4310309679409212, 2.0651662234543546, 1.7220973337379366, -1.1183610246942282, 1.2105786008493873, -1.6066178697607985, 1.2972499753621536, 1.1135452214978876, 0.4037499004376737, 1.1434630760074227, -1.5088074820455286, 0.9457016394484821, 1.5202831825869434, 1.6213130153680202, 1.099670438354182, 1.7676122400487535, 0.8945824499068182, -1.7599788681664628, 0.40558550358437295, 1.9811443904724366, 0.23905860446974622, 0.9925338138201562},
    {-0.9745777843906457, 1.7662170693491144, -0.1614006216677455, 1.7525743920251273, 1.841986579697282, 1.4447342650396313, 1.6276471426714654, -1.174242841944665, -1.7674085623605407, 1.6301200389738704, 0.05263134458614779, 1.4996069722162895, 1.6966324101250287, -0.042609060853477876, -0.6079760284614647, 0.602600830787177, 0.583206162181338, 2.42490159085754, 0.3550566986169964, 3.4371145067528985, -1.5080509500692674, 2.2529261185872644, 1.3302707772746074, -0.8327132159447158, 0.6540583864557633, 1.1933764423582858, 1.541408260208771, 1.3015644590262996, -0.6390946081856727, -0.7729986042425173, 0.6093919751189688, 1.4941257520166653},
    {-0.8890280203468466, 1.0244816653253328, 2.6548547101403286, -0.06088649710170932, 0.8531394948601481, 3.0125124079988166, 0.635023685743192, -0.6520917867304068, 0.3885653387467228, 0.6892098820059732, 0.6614724090343531, 3.4796967779292807, 0.46722704736141074, 1.7162159324422281, -0.7746719702457083, 0.7793512709745413, 1.3526880975745836, 1.2884677106863767, -1.3064241497082618, 2.151942281919024, 1.1735976909971755, 3.1964368297644135, 1.1252802187998692, 0.20027649431223501, 2.745327554013104, 2.809667626088454, -0.059937375692634395, -0.9366235477888218, -1.7130040267843059, 0.7784214974232806, 2.846686127064905, 2.4541628317012063},
    {-0.9064152879657563, 0.4481033164408358, 1.8238149669905064, 0.9707899018081271, 1.6174731367852166, 0.259745223998696, 0.9342348761156002, -0.9304428857248973, -0.08391140754756207, 0.8680547599132855, 0.08751422077977694, 1.4521026115877704, 1.4089488602443663, -0.15243427819826097, 0.20014567501371516, -0.18003911217192223, 0.19394821755398267, 1.3696521236983907, -0.7297786864497553, 0.6503184567542658, 1.3125322398621582, 0.3186293451742939, -0.08968770408025613, -1.052391715788098, 0.2529874865303248, 1.0082905297523665, 0.17061087712423054, -0.5200042098075541, 0.9496351562444183, 2.1430560121114515, 0.33303438237036004, 1.1799079487551487},
    {0.7508208188856489, 3.8551183233147235, 0.8834332390048201, 1.1057787808941166, 0.9708240105785072, -0.1341645388599181, 3.0031652385704555, -2.3277094882824647, -1.1998689866568295, -0.6644588364007344, -0.9375180643293521, 0.9284944976466357, 0.9247635968011356, -1.0428519045169036, 2.6337502182864143, 0.37839455519812465, -0.3536167213252621, 1.5530365417657497, -2.204728702707381, -0.13746196349137488, -0.14348793929267803, 0.6791868072091771, 1.3787421521177992, 0.5616468388241153, -0.5977874236877213, 1.2463564443394524, 2.2862950264320396, 0.2948853496599722, -0.4829842976280415, 0.5525541753167554, 0.4159615104469392, 0.6804983598141484},
    {-0.6167009796685035, -0.912856235245517, 2.1514548601982497, 0.8566393127965477, 2.684408201360422, 0.9548302644768636, 1.0513019172278355, -2.3808030393522848, 1.047049380405669, -0.23377067052647182, -0.30704527006804594, -0.19104523924437666, -0.9874346775741886, -1.2136170788675835, 1.153945410669319, -0.24711733599853472, 1.0151697192780795, 2.008638288175421, -0.4559848928409844, 1.5737372284145503, 0.5576912879909314, 1.879677485836491, 2.1598124059482045, -1.0834983192120518, 1.482290239124794, 2.4270072396451856, 2.2687347949166634, -0.8842408554563101, -0.31769284044205487, 1.0635472924768068, 0.013436823531336422, -0.13687725416592464},
    {-1.1486983809860878, 1.2614835753076876, 1.906240310273237, 2.2651052963169307, 1.0736422700521244, 1.5038366326838999, 3.2788849586652393, 1.111771358278841, -1.0965761653518205, 1.9841039539719532, -0.6389594801227019, 0.2545524173705646, 0.7421014959767134, 0.9875195798999459, 2.021686733032083, 0.533361332547782, 1.9909579413449097, 0.7808626443286514, -1.0325100491810677, 2.1385125012469945, -0.7930985721339239, 1.8300451388046641, 0.148393704265958, -0.5994070956540026, 0.12789592964915883, 0.16771318541105407, 1.595275047948618, -0.47880247457056524, 0.756696425865709, -0.7360054027992714, 1.384198654304416, 2.582098335837184},
    {1.4862550050033165, 0.23029226468225236, 3.725310380113412, -0.11762425757661346, 2.0926635049716853, 3.2127669508283585, 1.5132492795755705, -1.5494466645034746, 1.2975588357411643, 2.240220054097562, -0.6267453678832419, 1.5420220539813516, 1.8528506752593605, 0.6868390911494501, 1.267519097265596, -0.7756167342731647, 1.1751895555029261, 0.673202573935404, 1.7341816211472354, 1.8405516092516656, 1.6281022012241169, 1.7659030568096625, 1.0866669238356554, -0.9737352621612634, 2.1269498885471285, -0.3686359466855709, 1.5680050142839794, 0.684700261255045, 0.5477527900747818, 1.3901854044589954, 0.02087849680270458, 2.818329396264438},
    {0.5445289381836946, 2.256893480720365, 0.7727953558926831, 0.858472747974638, 2.554008233858324, 0.28769149288646473, 2.3889624172246253, -0.1542771353783492, 0.5672683092386114, 1.083373835530678, -1.7639911102971675, 1.6074540602134801, 1.779068746444099, -1.1938370187747853, 1.477427661582128, -2.334538636934108, 1.0520629047726664, 3.111085180789689, -0.1268773755224058, 0.5105593954555158, -1.5818657156109195, 1.5489730926226128, 0.980963028755404, -2.8661410266027323, 2.2925986988421325, -0.7003291284025732, -0.1693022649389113, -0.09065716641842107, 0.2742229906069816, 1.6947460474952434, 2.959199794250311, 0.6444959112541775},
    {-0.4479547475684579, 2.1586436042786845, 1.3640460106439343, 1.8842846929166874, -0.14811012145747798, 2.172241765154328, 1.954393950251888, -1.3328460066751358, -0.011823908928760589, 2.885501091377679, -2.0422327203484567, 1.6025154467018388, 2.5364285259164774, -0.13443357997529018, 1.2772407741015794, 0.5074917356501416, 2.09748303880593, 2.2577857292660406, 0.2443631754981256, 3.036491512932359, 0.2736365532616939, 1.4914999167983014, 0.778309011005233, 1.5423365935104958, 4.009126552865747, -0.5337400437390125, 2.5335044568326963, -0.917436419601566, -1.5210212251191695, 1.6812939101764346, 1.6149380566745921, 2.235145530413503},
    {0.24754180718827073, 2.198479857020269, 1.322611277707327, 1.7640701645166055, 0.10706640734356888, 1.220433456490447, 0.8459700493515794, -1.49787967577531, 1.513234501948771, 1.710801010476538, 0.28503057261005316, -1.9261768097427667, 0.9215115983284499, 1.6899340284124422, 1.8209972042043268, 0.3807703929566145, 1.9660253927062858, 2.187121659205371, 0.11311801474128055, 1.2481712746282032, 0.03707165051808677, 1.0943965322695894, -0.15928436660063722, -0.07165828922870919, 2.5336699058910805, 0.40012703187949583, 0.09370535045725106, -0.21821657068512618, 0.3598004227593291, 1.0178673623073617, 1.0421783456425782, 1.4116783622382427},
    {-0.6802799023184145, 1.055207523532492, -0.5681716431820338, 0.7320930403668489, 0.5140925073379091, 1.5449111219542915, 1.043529400379392, 0.24524144113556223, -0.6395085701099549, 2.5015427376525845, -0.477700091041225, 2.714180120076036, -0.1357804712930416, -0.9475241939221023, -1.543604786837202, 0.38494163054485836, 0.2161736051570775, 1.5900436732349374, 0.004399974919442268, 1.218417179894318, -1.02803152122645, 0.8750581301226495, 1.5030876099258736, -0.3129365496060059, 2.504093940374852, -1.352242561272494, 2.0703135554592556, 1.126513537497228, -0.40369528128510573, -1.3927516538546822, 1.175355030427943, 3.3827477095542213},
    {1.7116109450505028, 0.27664404652964275, -0.6705959771758884, 4.004850016923172, -0.18551951068925496, 2.1815629805907277, 1.2371907042685195, -0.20502356830263338, -0.32354563163565286, 1.1570793365225116, 1.5226472602197223, 2.139091005422418, 1.0088257943728243, 1.6261615435841366, 2.10198307059172, 1.2756729270275877, 3.2836028308019567, 3.116500527228524, -0.23727487719031212, 1.536138493033034, 0.726404141688672, 1.2572170872562973, 0.6714655118750893, -1.5951886577451484, 0.6312612446865871, 0.34126616993314013, 1.983310771531835, 0.35476163400101746, 0.2544988736763819, 1.1253090545722777, 1.8427258705651424, 0.8950053677179821},
    {-0.6519476448653128, 2.081473560373828, 0.08071788312594504, 1.4052094521310674, 0.6977103366921594, 2.326385622973367, 0.7506646248774194, -1.7638394572446017, 0.35843894023716677, 0.8023162778751798, 0.2838418275674383, 0.1627296334127626, 0.5947039793114696, -0.012721535189904763, 3.1364096532946606, 0.8695596208902767, 1.0083584907562204, 1.7231491730742161, -0.6988742921047612, 1.4324885657721649, 0.4393395346249638, 1.6011797229016909, 1.6538433888513138, -0.283348611039326, 2.077894301043842, 2.0440092025700376, 2.367265176240639, 0.7427814014399144, -0.21930562665727016, -0.05471818034229037, 0.2040240735355609, 3.40577331069354},
    {-0.7731290692133446, 1.1727446571310272, 0.4499804244704851, 0.344185491819092, -0.6227853866979406, 1.5553127189977962, 1.2142052928476437, 1.2483217611892845, -0.08941518294662082, 0.7677636458338741, 0.2631787780916417, 2.4659139642418246, 1.0228211801591365, -0.7741523948720062, 1.1104796271057489, -0.6417242017384357, 1.4233537712341993, -0.8237596495144767, 1.2603781471165507, 0.33097594151139587, 0.5042020933767125, 0.401088272748485, -0.745632050849004, -1.7537663088880933, 1.5035096830026522, 2.905925631798693, 2.561612409002991, -0.2824355680935986, -0.15852447595902483, 1.3995139040686466, 1.5293068676648527, 2.5261024879295593},
    {-0.45616098141245237, 1.7321676520314768, 1.5877411154536518, 1.8178775601796056, 0.6995706485063339, 0.9179485941474033, 2.5281586786856103, -0.750800029873773, 0.5211036812322811, 2.309231814870588, -0.9138723832749184, 1.3315923570515902, 0.2548687211330389, -0.13383360738275998, 2.1854230076926773, -0.6165862885062735, 0.4742257623672877, 1.5175501036402794, -1.3807970776691891, 0.40968752932885005, -1.0531011642532309, 3.1474902243578886, 2.571210176313289, -0.9386221025965548, 0.7425694142618002, -0.44222175758123716, 2.424389272774953, 0.2957986584375987, 1.074526158717141, 0.21643246096311927, 0.7448021513748594, 0.41770014081695145},
    {-0.1400584274844218, 4.106803373084218, 1.036694635789081, -0.699907530450278, 1.2608452794411638, 1.5416902873289244, 0.6410080993508341, 0.9005174092880933, 0.48178594983027007, 2.790094788334718, 0.11476562294952, 1.0406281612454946, 0.05144065430382528, -0.13926313065587054, 2.472779956733239, -1.297697623405095, 0.4794583479893433, 2.3820118300063973, -2.811423168017276, 1.3975138573583483, -1.7425657677890696, 0.9630038398694029, 0.9605485975069493, -1.8453723287351882, 2.7489407841841587, -0.10107049854783927, 1.9294444602283154, -0.4422729248225418, 0.4350286247634221, 0.7393598954774917, -0.3352050213577445, 1.6180741146196185},
    {-1.0655169674683913, 0.9181430236936625, 2.362300521636574, 0.04395041129207967, 1.028869196842151, 1.235965961120768, 1.6409691379427707, -0.8999617672160511, -0.016932386969977703, 0.7244632290311174, -1.6752638009301308, 1.4928031999425344, 2.944252369994204, -0.02594897866644911, 0.2911184161544852, 1.2113330186448454, 0.7555843464689102, 0.21676243001425177, -0.6010641633579632, 2.5246744615726406, 1.7072313107198764, 1.0980679819327537, -1.5339102173031738, 0.6792618600419073, 2.296830636041235, 2.7927629098570224, 2.3871071617784243, 0.45096421264402775, 0.45322301105450596, 0.05916900442678565, 0.5165822520041572, 1.9290636201490392},
    {0.6882309806888706, 1.763739348745821, 1.491312060139001, 1.1624704839525575, 1.452799690711772, 2.9390958849709334, 1.6454075304078886, -0.5440486393537409, 0.1632850343863035, 2.5314399072987164, -1.3487698541386153, 1.6427758150371319, -0.07284806371589424, 0.07087740652853924, 1.176254610003872, 0.09094582173752029, 1.9498601563633278, 1.589548863364932, 0.08052007830533565, 4.119666598776927, -0.4804252484550031, 2.7833302595035128, 1.9770984938237257, -0.48104771608831276, 2.7612728018359145, 1.090890317147238, 1.6994223480926947, -0.1811959660584561, -2.07232700575532, 2.526074111167072, 2.1132684276019096, 1.9011183107007774},
    {-0.06236868735259388, 2.120499933355795, 2.8050513991612247, 3.085854381434724, 2.25454968824735, 1.7909308748670913, 1.4265001417078957, -0.2988160798835426, -1.6890222997889124, 2.327293500024605, 1.1543351411372411, 1.8336019445847134, 1.8431930956208256, -1.4246941979871945, 2.4557319703374962, 1.154711515079749, 3.0656353612991833, 1.282440293070825, 0.15675311819396312, 0.948178675614754, -0.5813718079092098, 3.4777959974012465, -0.7680943550247108, -0.7271988173808314, 3.1882552567982656, -0.6610981317511645, 2.174480710873951, -1.1543045422304026, -0.6503355253893777, 1.3666734489123387, 2.600204405057911, 1.7617421648606646},
    {1.4457454620025805, 2.4414912064466905, 1.203252511800798, 2.1160478173997572, 1.04134145127393, -0.40661883385620295, 2.055091389515361, -0.41838032652169727, -1.653432547778837, 2.3474536257540075, 0.059749993058988995, 1.5154823854311332, 2.248928816243206, 0.007308515331561306, -0.3761145785339377, 0.613131518360937, 1.1548610328577675, 0.768178708570892, 0.11247168343445442, -0.22420707651435573, -0.5343643270798352, 1.248613130361172, 1.6382374263516832, 0.11094736479464193, 0.7153995221574079, 0.5382589090449076, 0.6620619560495133, -0.06366447589342493, -1.2021581056871187, 0.28638056012170837, 0.22756161162145871, 0.7928748349628956},
    {-0.8556324745449101, 1.7171324613978098, 1.060455269221803, 1.7907523976279136, 1.2796149170257132, 0.7485854149936635, 1.58168425675184, -0.04994937279904948, 0.46540952186603624, 1.1042909903750078, -1.525207480112805, 1.8939984975186397, 1.5444857548805915, -0.0945839248610344, -0.6733743852576711, 0.641204759665443, 1.5327948224211958, 1.01255724290699, -0.45748750959150336, 2.2921082768364394, 0.4963249473486338, 2.964178944080562, 2.942485639290232, -0.9807332029836884, 0.963260131295585, 1.4234706418170318, 1.5753855048665526, -1.2885142398469906, -0.7172401459047371, 1.9321194055335216, 1.728343563116082, 0.5196249937448135},
    {-0.47149682496000656, 2.056002858942906, 1.579395028595249, 1.3970901178812072, 0.6473533802814573, 1.6299879557158088, 2.763949976264971, -1.2343514145390728, 0.2564260818283245, 3.116508970449322, -0.5574261853139164, 1.8709275678859902, 1.2529341526724045, -2.069135039968232, 0.28710356634338885, 0.15155969062827837, 1.2858438252566722, 2.338757499904505, -1.0015146768490013, 3.71538279133759, 1.9954011162045275, 1.5942003807224636, 2.4735275778443517, 0.8871258663092214, 2.799878078259372, -1.9125327244228587, 0.9779033761956487, 0.5650189797979477, 0.2605042515723882, 0.19814721564698654, 4.005492401239142, 1.0284978270569665},
    {-1.2766864800178828, 1.114800944167676, 1.6485641659591879, 0.7107599792362679, 0.6211076847657034, 2.429569697275171, 0.80710231672371, -1.4703512492108168, -0.9161140608643823, 1.1983664634100861, 0.6196509164665905, 2.8393204586460645, 1.8408961403648394, -1.201076365217477, 0.8121141199014034, 0.9532985338856985, 0.6928090635328851, 1.6032135380812624, -1.4289209692121372, 1.6044769973177964, -1.473929875862252, 1.7929987236492797, 4.2165864286246215, 0.7571292592102449, 1.5125961937733117, 2.6579418006517557, 0.3080166314778108, -2.0597154497238717, 0.10663186720599462, 4.36310372289573, 0.20217681845121058, 1.076333668476087},
    {-0.5022970203641237, 0.07093884441277219, 0.9754531515436462, 0.8660762471446153, 0.7960331500430835, 0.778097242424572, 1.7976100361852567, -0.21027680121738299, -0.8352214501554897, 1.9322084871163863, -1.5475854473762964, 3.119034186867358, 2.2310205305655937, -0.8561954308162739, 0.7255466149782179, 0.09483809737507268, 0.8680498472807289, 1.5053875370113028, 1.301245606796982, 1.5370335110335043, -0.697803750813756, 1.5003479626906666, 1.1974603885344526, 0.5163838371248871, 1.660261801187463, 1.2351972928985333, 1.4437841622275585, -0.516980940941213, -0.7349741281639312, 0.6960684171541632, 0.5343241707898297, 0.5478284672501469},
    {1.1139559633320812, 2.0788522456176404, 0.8698365606082298, 1.0530751209859037, 0.3256366708967896, -0.6717145221176279, 1.2009452945550123, 0.43827995086381094, 0.49296609831560545, 2.082936116948424, 0.8732531771518531, 0.1779282168734414, 2.528392392205911, -0.21691153550965891, 1.2545386291902667, 0.5960618433993006, 1.4435664474703322, 2.5268725117744464, -0.2679261470214239, 3.151627183769811, 0.4238464328517514, 0.546602551844539, 2.160498399059922, -0.7354075132872704, 1.5847366891355341, 0.9942551214301747, 2.80158893176615, 0.48527294463995047, -1.2441744238412435, 0.5195775768616284, 1.0611401993018115, 3.6399277877027396},
    {-0.4718786360041699, 1.6496311971057893, -0.7495528587937049, 1.3624860203896465, 0.6386380460119855, 0.8779388485810051, 1.5605991452650352, 0.34903508450609055, -2.0207899090779162, 1.9404842792486021, -0.3422588198955029, 1.8355037314843197, 1.0877063325112513, -1.230143248756801, 0.7503490682105093, 0.37783469568325345, 1.643035227047451, 2.3371958330916645, -0.016618702386064898, 2.700782304598675, -0.2644357483963398, 1.5192189080263498, 0.6168152380963637, -0.17654196830453192, 1.0991953816673485, 1.8465886659829662, -0.42060653646399093, -0.9396242582549821, -1.1047488130872618, 1.2386081601355, 0.588344825775134, 1.2047188120816186},
    {1.6512476202129287, 0.9307905572121842, 1.3876506380331874, 1.0471579856575868, 2.8538216994632215, 0.2863478076969109, 1.5266521424620516, 0.13146518616837213, -0.6592270854861726, 2.074251591704993, -1.6576746405275682, 0.8153125363055838, 0.8386211901719377, 0.35411935787247056, -0.9989310260702853, 0.8929627519387675, 2.2403847897953617, 3.8469245619864454, 1.1427949523399326, 1.1746341995396148, -2.282195389025773, 0.5130057052084703, 3.15774860362033, -0.14761744153122783, 0.765362161947847, 2.632389855445357, 2.9565688805454267, -0.7397658912699194, -0.05094512758432915, -0.16156758567991927, 2.3764187000980592, 0.43106432113835236},
    {-0.08800776394969996, 1.9801555404024345, -0.06403944221093158, 1.8662326480449767, 0.28273967614246304, 1.1001373869828635, 2.4627407066359654, 1.2224533106439637, -0.5761960674482529, 2.2110299693915927, -0.7676580779275061, 2.8520647075651233, 1.223478634041853, -0.6445085741417523, 2.9629644133081, 0.4758278613345385, 0.6120014690992217, 0.7796090894249962, -0.2627163867908429, 2.407080857353573, 0.8743400719905504, 2.961256933120897, 1.500458734113139, -0.3926127686099849, 1.4607880751148457, 1.0170377412034246, 1.3832717430625032, 0.916181988452636, 1.1634853537021885, 2.2880214641105736, 1.2132915397947395, 0.8084439098683845},
    {-0.00046539293657197185, 2.938544971443099, 0.9477907439255135, 0.6522195841961352, 1.7559807415695754, -0.02437914350322384, 0.7586925720576698, -0.04230433043586918, 1.3676290854044297, 1.3267377490810277, -3.031047782617484, 2.4614882484572527, 2.730276776356138, 0.8238903642001858, 0.9951514349044174, 0.577619020330239, 0.9139635809149661, 1.540785838342172, -0.24583790342676745, 1.2756511801867576, -0.26461771731590505, 1.7981482610527422, 0.5448180234993341, 0.5383367905509553, 3.439274041254028, -0.44294600454101984, 1.8431509388774499, -1.0644747388865612, 0.26444702739118525, 0.9066510588264687, 0.555923120976222, 0.4237907363970755},
    {0.08279127016123364, 1.2493476442984903, 1.2211845468317368, 2.2432262380561236, -1.3006381844169286, 1.9387340586115418, 2.3203467753392015, -0.5426904085697507, -0.56723232555383, 0.9272329320210877, -0.3529320527465422, -0.26289661993697516, 3.212926004875513, -0.5513556768746888, 1.5192819817563066, -1.2383497736949973, 1.1089848911253843, 2.002449084270788, 0.060288649136322765, 1.3068851609883883, -0.49802800419495913, 0.436948451621866, 0.49957768210758613, 0.12357944565477691, 2.8719538010408288, 0.7925354703569827, 1.8711612171919703, 0.9332556180974866, 0.0664012855833868, 1.6819660771573923, 0.03529824581870717, 0.8560139787913554},
    {-0.3377344092980213, 0.7993908820211204, 0.26763717585203484, 2.2406979739023494, 0.40187007690100013, 2.4880764999639426, 1.969565143872773, -1.2313219005475922, -0.16667644890327743, 1.8393878705840847, 1.3733350653603114, 0.24107812528558464, 1.5207336445579611, -1.1748041365057447, 0.6554955146339858, -1.5378398319521762, 0.9863674128377744, 2.938674244632883, 0.7090092760244524, 1.737786566584118, -0.5348223683839523, 0.6510377311651614, 1.608214068956697, 0.32849413365387997, 2.9361333613452563, 0.4864558313242268, -0.6246818704303629, -0.24260424221704452, 1.3830740055371709, 0.6380111415349385, 2.550882011376887, 1.5864987993774256},
    {0.38974324438045127, -0.6467948896792464, 1.7581936701605074, 2.4089922889622075, 1.7078232019942108, 1.4694796041477196, 1.6856190325743496, 0.43920542018936637, -0.04745115879052629, 1.154665106042638, -1.379212747727737, 0.2918277349473259, 2.2566372975137816, -1.9712083516671344, -0.33806386270925065, -0.04330729801349563, -0.8616810548140608, -0.45014154860927597, 0.929731109647401, 0.056360044275418575, 1.6137870316387495, 0.32415753189872143, -0.3685541065409797, 1.576638991204575, 0.4891559620217169, -0.011765628495849223, 1.331581717350507, 0.7168705491834196, 0.962867814488965, -1.9828087064655444, 1.7691244183101942, 0.9871493364916628},
    {0.22396346122439018, 2.1409413012058187, 1.7430062680993184, -0.11748617476365875, 0.4651115857238332, 2.4239283947072594, 1.6337095032364988, -0.5927214793229043, -0.4011909337805616, 1.7825075746003116, -1.0877936621303606, 0.9185151129066536, 2.720132997047342, -0.34831831205314756, 2.077069291859804, -1.2871783420028144, 4.195518048464937, 0.648067199707438, -0.2353457899520656, 2.3631495097603477, 1.1762558467709638, 1.7211754339849261, 1.030142448655786, 0.4527828311577837, 0.4020305106528448, 2.400877670634086, 1.9905833226542846, -0.05138371198749314, 1.3907303515103449, 0.16695048406716267, 2.4984587809025784, 1.2193342304513852},
    {-0.3057515253943884, 0.7084844060808323, -0.4381141800573931, 1.9626197825175757, 1.1518938307297413, 1.727675300526593, 1.4733407155254885, -1.1502228634140712, -1.1558480037694605, 1.3575190341275662, -1.5921822771896115, 2.277828322029872, 1.201903739183849, -1.8414741442980689, 0.4280067160170896, -0.2289110899738394, 0.6212399314713513, 1.4801847206739072, 0.28603768793576984, 1.8422166572806133, -1.6350515633147655, 1.887261871431742, 3.0257576838775653, -1.0929570505385455, -0.7133455094933312, -0.676580245031078, 2.4729905030338384, 0.5673697622081791, -0.4870377067648223, 1.7641815984353586, 1.432938571409006, 0.4445007505793194},
    {0.3384783377275992, 2.1712593420453548, 1.3680085925998986, 1.0452829353938, 1.8656453763819554, 1.2592117900141633, 2.744649435643221, 0.11781500330538838, -0.24535335612126621, 1.8124973778487201, 0.22828882451553778, 2.124592368980961, 1.153742143574365, -0.9878546239777773, 2.321190075949258, -0.8444495473936219, 2.7783821077318387, 2.1289419409801185, -0.07701879342325924, 3.3022812138925084, -0.8244373873494113, 2.76240009196312, 2.8748908349748152, 0.010035689080290231, 3.4741294577816957, 0.07058568828397285, 0.7689473516307519, -0.8001503331405326, -2.8482797847965076, 2.051477442333745, 0.16729960022631207, 1.4640384885399125},
    {-0.4288299477775057, 1.3017850821906911, 1.2831201408088357, 1.956664595418301, 3.461964816777059, 0.4016507268919823, 1.7672739567875102, 0.20559466171825663, 0.25065415852912776, -0.0013451809505279765, 1.0563105443087808, 0.5856501089802159, 1.5458205303937465, 0.8362796540274245, -0.09415200668313826, 1.0209423869137852, 1.6462441107743342, 1.7762050001465999, -0.6255345545842185, 1.2708960296854876, -1.3294159743347265, 3.3298968710400376, 0.7919072127541263, -0.20014936944219205, 1.9054426168508043, 0.6577863882235998, 3.0343571528409248, -0.21204144512388992, -0.6644162583287919, 1.5766310138080553, 0.46906944181080773, 2.6954564601682955},
    {-0.4056955711214399, 1.3864310801456343, 1.916403735798716, 1.9088410202126667, 2.1816662345489157, 2.1833529445594624, 0.7890024975200247, -0.9817317666040883, -1.2762762263937957, 0.9812325698673532, -0.48998613067375385, 3.2116674918837385, 1.8485077670218628, 0.287780586688302, 0.7032738390575868, -0.2611003761673649, 0.6162982106667408, -0.21047308821601654, 1.4904508220340038, 2.630907256055701, -0.5197469800455982, 2.954356672240292, 1.6290443246726636, -0.6559530207082138, 1.2869785645143472, 0.3688697261968096, 2.057142730761306, -1.059004259106408, -0.5416504913917763, 1.1059835573445256, 1.8724437078107368, 2.792489041558826}
};

static const float b2[32] = {-0.5355322428201136, 2.0854523563815786, 1.501504680246419, 1.5894189280541948, 1.6297604074780692, 1.70265727139449, 1.9068174447177235, -0.30725795861115784, -0.41216904193715703, 1.4578464268640987, -0.42545251074399204, 1.599288239387763, 1.7079718462052647, -0.3436581733026535, 1.0347237238212597, -0.5833338712414194, 1.4596274421088702, 1.8895590815471897, -0.294075297171602, 2.0761218513952455, -0.5517317710406093, 2.118343936402344, 1.7776090128907898, -0.46413502326615547, 1.9646596528596414, 1.2166898152165073, 1.721577798619283, -0.18144249243391283, -0.33422197476647514, 1.2072976323660705, 1.2628613862749016, 1.8337377552223646};

static const float w3[32][16] = {
    {0.2833071515179997, 0.4773984082983531, 0.8887540634770951, 0.3367930623591474, -0.7699584304492707, 0.053762117878835676, 0.5974809223730496, -0.8164884239257684, 0.9174827818598148, -0.12852082189075645, 0.9666839294247294, -1.2956227706235504, -2.079417860973524, -0.89903493170909, 0.5723017241103046, -0.9573786937258719},
    {-2.1960597513924403, -1.9035531865092254, 0.1968583629813284, -0.02359908324647279, 0.46677196935600834, 2.350370369542454, -0.2830588019972719, -1.4638399523707943, -0.5030286324264817, -0.6140779163916668, 1.322372879296416, 0.4362977351167838, 0.596094673987554, -0.9927418709858843, -0.9598122460634674, 2.594587147964557},
    {0.18047987981360378, 0.6849287659080412, 0.1756815881412608, 0.7439504312798038, 0.9321294683233107, 1.4968028814991867, -0.60473497502404, 1.124963077901267, -0.8043036610737478, 0.07931584231787084, 0.03617224702339132, 0.4143037354418143, 0.08690527324165001, -2.279479400396404, -0.0919783409138542, 2.1624758836859823},
    {-0.5757463151910378, -0.011096582242116307, 0.4868588523513296, -1.0283681157797844, 1.6726655539934714, 1.6152489269574302, 0.29074016271363273, -0.413734832837076, 0.7649711412731248, -0.45968383425111264, -0.18731556855522596, 0.9969844938687051, -1.1550801864906242, 0.0880249745349499, 0.08768542099493318, 3.2688305388268395},
    {-0.010142911380458766, 0.5947394157243447, -1.3072156533672659, 0.08086337107891174, 0.8194742342235544, 2.0694283955060992, -0.5847612712591748, 1.8098127710076575, 0.045318891804695366, -0.842759598346977, 0.710731808782805, -0.5194867551115809, -1.2475487201258006, 1.9729453889883328, -0.20179932975134687, 3.955406794568655},
    {0.5501264460822312, -0.46031312049787326, -1.6395307917660853, -1.1346664479192345, 0.4667210170867587, 3.3389133262318778, -0.15498675369240442, 0.6419720629189231, -0.3381167152189576, -0.31873452807930647, -0.49470207784782305, -0.8135067862182946, -0.2718919535938909, -1.8874958008031308, -1.01741779280947, 1.5473610416989232},
    {0.3949060089163088, 0.21103300491996507, -0.45169905639118824, 0.4425489655108063, -0.7059816746067764, 1.9662224657924323, -1.1662148432602566, -0.3635432231127266, -0.21937133913278545, -0.3650719295444645, -0.3498374365462652, -0.661230259554422, 0.2051638016139844, -0.7084491097920672, 0.412859299590671, 2.28065584630392},
    {0.7447684110769637, -0.023512591046524634, 0.9624671729432835, -0.42461299560493715, -0.19641153195048935, -0.1987308291021348, 1.497389714358885, 0.03229040475257145, 0.9127853649363482, -0.09807124089132128, 0.9329161081849678, -0.13520306565577506, 0.7556294784406223, 0.3437525820826559, -0.028980717831689283, -1.6418843516596433},
    {0.46626238687037147, -0.4165837102340677, -1.3204787706462093, -0.04828486993480177, -0.1376355784568031, 0.0798274585137096, 0.19983483801280438, -0.28664050754574744, 1.1050718297380244, -0.27175226743466974, 0.5128470691772795, -1.9109020144231286, 0.6829193665662215, -0.47721600362473665, 1.9032670276224009, -0.5093232637122801},
    {0.3506425818687788, 1.3966555359108692, 1.7561047886480798, -1.4642333340115699, 0.44041324686136674, 2.0975261139150754, -0.20356371891220174, -1.1273652038556405, 1.0921046997682466, 0.4307661337439676, -0.6198548694472674, 1.5267998199875241, 0.2150431641747966, -1.9692079812768415, -1.0152445659555616, 1.7499892129749262},
    {1.2808668640322467, -0.3548561349019097, -0.012712601544011522, -0.4880167864368446, -0.39978758375963186, -1.2504871314952257, -1.6573864861147427, -1.1358342631731941, -1.2596430716184615, 0.4335664042054038, 0.3720248677579722, 0.608938620312995, -0.994978852047441, -0.32312501477886746, -1.0931603629834037, -0.6563786528940078},
    {-0.504236065843773, 1.320873734330286, 1.1537720204064121, 0.20735228550323118, 0.7353316316375696, 1.9556037013580723, 0.3951639367271958, 0.562015411827221, -0.09945622571324621, -0.018494206177269268, 0.8545899837947206, 1.0738933386771472, 1.0872962318892359, 0.897914122223965, -2.567791000064249, 2.644146032988972},
    {0.521036589635939, 0.2890011774814269, -0.4571917727062561, -1.096540645165284, -2.2100005387928436, 2.4104235289607288, -0.339350162622065, -0.6073407027346706, -0.5150548577318989, 0.040919402149916476, -1.7770257789590624, -0.7738955148071345, -0.33073956089821344, 1.2185798750601455, -0.008151194849997996, 1.539963921982255},
    {0.44801977455737757, 0.87447120590943, -1.3690085401389318, 1.7411884630654055, -0.3741452502576364, 0.09011274939695176, 0.7131772272000659, -1.8764557326745424, -0.27278756699188933, -1.150431717383632, -0.841998352690128, -0.7321123528748799, -0.1321285819420875, -0.6442302160585001, 0.6343927726096187, -1.175970302456586},
    {0.15138520481717802, -0.6871424184255656, -1.6070336717983573, 1.268476297641669, -0.5081594093468986, 3.320340607607683, -0.03424171786483082, -1.1580285666749424, 0.9645960233761016, -0.3541925956696586, -0.999333827585116, -1.1776928404703766, 0.922488397881195, 2.5960051376847826, -0.7989172499943716, 0.5520155936766},
    {0.9065375336929061, 0.28589784447351035, -1.936303550983051, 0.05882468373406426, 1.0097479386824333, 0.5298809866168258, -0.27178949830489607, 0.12242426235632727, -1.7580622156747647, -0.6289045949752103, -0.6761562096152417, -1.3012300783614965, 0.5504700384414193, -1.2075120327804014, 0.28036410781806187, -0.5939457354264666},
    {-0.6075227051339663, 2.056445348082879, -1.4393139983425587, -0.10335129915561486, 0.5566243236420231, 2.5009647118799485, 1.1488241659950307, -1.3332003523239884, -0.46851334276722845, -0.9555895316653452, 0.6863942241849857, -2.5694464274827444, 0.36701079354755317, 0.6833400127373843, 0.6484718489139996, 1.8443412501796685},
    {-0.3169765603687881, 0.4572965636443402, -0.6978770786177997, 0.2319980008748906, -0.7967596432888471, 3.3472001786888734, -0.3799810365519543, -1.4621284874951692, -0.18636331275857695, -0.6824701055643554, -1.2743478570623656, 1.1819790744285699, 0.8821119357188438, -1.9680738393037487, -0.9383492827043497, 2.781002388911138},
    {-0.14262416888908, 1.6052517271139721, 0.1217745059595996, -0.11890987496767524, 1.420834833120974, 1.0379789940608541, -1.0292469462541096, -0.41443747091593425, 0.1250296086010562, -0.002003570696421266, 0.7157235451540955, -0.29510288716385535, 0.5119005212202532, -0.6991905289268132, -0.21511732763141717, -1.6837788218990588},
    {-0.2156998464951654, -1.5494815777212503, -1.0418230580315084, -0.7182819750504582, -1.6556498278993053, 3.572696417213381, 0.047353936188911865, 1.3450976744930179, -1.5690931284304344, 0.5471757574133872, -0.9401154676784728, -0.22441322453171, -1.2804635718557145, -0.8557557818068614, -0.668040411075072, 3.06490401547821},
    {-0.4536407710885365, -1.278582929080131, -0.934231813218871, -0.4039078809101432, 1.0825602300834862, -1.7825026295721822, -1.4329267490314144, 1.4721371424890606, -0.57224723889753, -0.6477512699468069, 0.2914646681331925, -2.0332191222399145, -0.7201249803752988, -0.7396850131266941, -0.36007104794245776, -0.5794735903335888},
    {-1.6864094928774962, -1.3310795425641206, -0.21521901501305613, -1.0866393177967986, -2.020741691719758, 2.150425087527631, -0.03942363157261443, 0.9702771940370563, 0.08542700063473935, 0.7996843053647198, 0.2714609057556685, 0.06329863611485385, -0.49996237414683903, -0.7632278626304676, 0.6641766252186119, 3.0826438714614164},
    {0.977712543529732, -0.8885851254251041, 0.2663517290140391, 0.3607586761562002, -1.1129185187159731, 2.8834451384609445, 0.20075889786396214, -0.24612492612498432, -1.133842233935912, 0.9055412730264756, 0.9014907815829483, 0.8447675651609251, 0.03485042423554135, 0.2636863011962303, -2.680475880159408, 2.4747958223974202},
    {-0.6782429438835753, 0.6875426704101968, -0.258240296665268, -0.11783280807766999, -1.3903523005113496, -1.2324579429913354, -0.16135093320051272, -0.8723225988825876, 0.05421158123234208, -0.6827734015017498, -1.5015394080885223, -0.8559181558294673, 0.735842669788432, -0.21401870325294334, -1.0226880038469353, -0.04243303449930108},
    {0.21420996571120696, -0.4334904662287813, -0.590864487999876, -0.16571493366398346, -0.8415791943651518, 2.498638960293043, -2.092614409186921, -1.971554002208465, 0.34017615501306436, 0.2830606094571526, -1.0335776196769302, -0.7915597102240507, -0.3005731848068052, -0.6595713728062756, -0.1846404856031709, 1.9617181471267826},
    {0.6320559417680308, -0.6246723429745759, -0.4954402402190926, -1.1322489589682738, -0.34368117607714066, 1.9667265766919508, -1.1684871020145737, 2.414373138005991, -0.3750106923899644, 0.4478415845749994, -0.9998556699828497, 0.33483661433863926, 0.6198420908118252, 0.23984422467126829, -0.5018401392326391, 0.93675377491039},
    {-0.2897595077595741, 0.2644014354724256, -0.39411469865428084, 0.2433600790376834, -0.5152723943071017, 3.0606892636066245, 0.18992886849429264, -0.952315665262155, -0.8099674299468641, -1.6774059628680311, -2.553981216578766, -0.9539889517848688, -0.15959224962084942, 1.1788655655989813, 1.5346090480504686, 2.6889553762033236},
    {-2.524098504820538, -0.3157795330823205, -0.6913458467969353, -0.2290825833201202, -2.7249193391085744, -0.35327378168931595, -0.28130501778503475, -0.5533410362467808, -1.4531103977567679, -1.3407721858090997, -0.42499691642925946, -2.180448884404234, -1.2543348549386741, -0.15178763585650804, -0.30039138418237, 0.24469442845629968},
    {0.6984518481429889, -0.6985720095449925, -1.3015128469685684, 1.7329862767563942, -1.7314784937564378, -0.40641607784240624, -0.9815876076662126, 0.18028649487136175, 1.582206273906878, -1.2121771023363506, 0.6473407638857507, 0.6979604453058387, -0.423007815198229, 1.591397858419596, 0.04896963068425558, -0.0052135235307584436},
    {-1.0845028241379333, 0.0770457421317403, -0.02543387715815332, -0.3417834672782562, 0.2909126737403635, 0.011812323411997986, 0.1007824708968349, -1.2667048234948612, -0.20259590554320758, -0.9211051988550405, -0.23049775531830405, -0.8467465548155618, -1.5077312394352813, -0.3849571941077692, 0.8361701251193374, 3.1663649526599524},
    {0.1472175992556234, 0.6714396747626147, 1.1898859004138274, -0.7468323425077231, 0.6464246480393435, 3.1501733708621558, -0.06536569335605047, -0.061834220958516206, 0.8085215726975699, 1.9523481875047182, 0.19153733391268726, -1.5388885320994443, 0.1850165332439577, 2.225602285437147, -0.442519299637908, 0.9612212360594755},
    {-0.7686424432370929, -0.779028454397481, 0.12075169621095329, -0.21806502177590406, -0.5311040330978571, 2.2149293389406655, 1.492950949915856, -1.085479294126965, 0.9142790848256482, -2.573852468337514, -2.1530798458386196, -1.5269278995855866, -0.21483691063295982, 0.4589546374400634, -1.4033839980439993, 1.430233319988277}
};

static const float b3[16] = {-0.25879758520778545, -0.35739313265373257, -0.1493541009558549, -0.3116572213271386, -0.1924441973934741, 1.3032225522387277, -0.07164563054967918, -0.18825392629300694, -0.22894677619528744, -0.1744388068854595, -0.2994678081910182, -0.2753628428426413, -0.3403283194014172, -0.23820569111242498, -0.35041107919897707, 1.516632268073559};

static const float w4[16][12] = {
    {-0.7168117845208256, 0.6959046217122093, -0.11091289207161888, 1.9403365007871691, -1.039758946979475, 0.5383028610212267, 1.7768490385214788, -0.5525271703595064, -0.7889414849647645, 0.26054487491110145, 0.19073792648602086, 0.6501287194933895},
    {-0.12524860343232666, -1.160838765930674, 1.279396531779934, -2.81332426620803, -0.6245607179453941, -0.6104384625877666, -1.4332309908162513, 0.21947109439928428, 1.0196667451099026, 1.6165221766164328, 0.5851777324108018, -0.05953164373793395},
    {-1.5897167866810484, 2.2558278789063997, -1.1407302351864874, -1.255872968968796, 0.6990920101963837, -0.5811384191674164, -1.279978805346607, -1.0539150468216332, 1.0944134287944642, 0.9760670505775225, -0.2936308588016689, -0.39627317183434974},
    {0.978530146120734, 1.5277995599466985, 0.8954677313051749, 0.3055236557464291, -0.10701391706305614, -1.9308567752730472, -0.9309858503094539, 1.1515703220383458, 0.7054497327092795, 1.3056796327370352, -0.35293127085170484, -1.0409767673509882},
    {0.2657080932513043, 0.2070124827336813, 1.7187248094042578, 0.7301857443712882, -0.3923091674663053, -0.39503988920358735, -1.9012159044977555, -1.0212615371496376, 1.468839296094243, 0.9441017502100904, 0.7117202647582742, -2.0291309342917705},
    {-1.3011045837808246, -1.0608841323603486, -2.046926737628122, -1.3359359910095707, -1.6186586595416017, -1.5535685118902012, -2.6122003109167657, -0.8588332676413412, -2.010792535830603, -1.2261348445017781, -0.6751135647274656, -1.8894212463607478},
    {-1.0923907974118336, -2.030654542563389, 0.8726035801820831, 0.8903455860954431, 0.13082755168109078, 0.49744105882386885, -1.8387902237983156, -0.07634719511356543, -0.48768246543518806, 0.3494044771813758, 2.286372821768186, -0.018639307526055863},
    {-0.4126700424343442, -0.18954335816885462, -1.5723285346689189, -0.9788483914602781, -1.7566373219573477, -0.1954113318245933, -1.211399053023902, -0.2915709591153595, 2.0085509259509213, -0.7960587748149378, -0.7752659065721733, -0.016626046722687384},
    {-0.814366907219593, 0.6309770887802425, -0.08913048539149257, 0.026246661353696805, 0.4256697632663992, 0.9720288702625186, -0.15313543684387856, 0.9926519800447379, 1.4333318236580108, 0.5456649818595694, 1.0047956073884474, 0.9180435427254277},
    {0.9932439129433913, 0.6391712626520453, 0.6254751482164014, 1.3331030788369211, 1.4552986525017875, -0.16226787455731848, 0.5834953692980859, -0.3300449778877207, -0.3372460998317309, 1.4064626563323817, -1.5503827259214278, 2.104910371072117},
    {-0.9654781468742819, 0.6819161750743091, -0.9100960273523957, 1.0404267043476165, -1.3558475234226133, 2.4800776521043386, -0.1269766311767387, -2.3598933816511405, -0.4787370524329104, 1.0885431313899092, 0.5136804144787817, 0.11983021775754313},
    {1.2208443935063706, 0.8522973598150108, -0.8177814904553674, -1.4963191814238308, -0.3993161738187645, 1.3269873848675553, 0.3115134619794305, 0.911174180240504, 0.36573338018032464, -1.2008888024844881, 0.3886181550974027, 0.3955947253137028},
    {-0.045078980191362014, -0.47775568859786177, 0.6310246437074788, 0.597902433618244, -2.0043608220050557, 1.0781028245308768, 0.11172442245362502, 0.3180177067955346, -0.6801659496803099, -0.0019723509867327826, 0.58508833421358, 0.9842828096946297},
    {0.2974664755318976, 0.18871679201959504, -1.8265098483935185, 1.7834316056555248, -0.6260767148432411, -0.5752083264096309, 1.6511408355399304, -0.06747035174830662, -0.4417561629656653, 0.7657276206695685, -0.3039545458534833, 1.3615392317349444},
    {1.5889591050602496, 0.920040158717086, -0.018406895422261642, -0.1837372200446675, -0.22032473607366015, 0.4603207569200144, -0.4196122103202869, 0.22437439672833928, -0.7034932386936258, -0.042594861315679404, 0.22069798778666386, -0.3544554707791282},
    {-2.0954690959121356, -2.35844688598703, -1.2908153810069456, -2.0414613276468048, -1.7361657051175112, -1.780657253803403, -0.7138459607160393, -2.547203159833948, -1.3283489990275208, -2.170389024259229, -2.7486735231081814, -1.452657589362531}
};

static const float b4[12] = {-6.67386842263797, -6.771003940319667, -6.710355730257336, -6.66844684243719, -6.7043065656457825, -6.703282148939881, -6.6888496150888, -6.627780780854552, -6.801067372432813, -6.618450242371017, -6.748814586746854, -6.727343152824517};

    // Input Layer 
    float z1[64];
    for (int i = 0; i < 64; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[32];
    for (int i = 0; i < 32; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 64; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Hidden Layers 
    float z3[16];
    for (int i = 0; i < 16; i++)
    {
        z3[i] = b3[i];
        for (int j = 0; j < 32; j++)
        {
            z3[i] += z2[j] * w3[j][i];
        }
        z3[i] = relu(z3[i]);
    }

    // Output Layer
    float z4[12];
    for (int k = 0; k < 12; k++)
    {
        z4[k] = b4[k];
        for (int j = 0; j < 16; j++)
        {
            z4[k] += z3[j] * w4[j][k];
        }
    }
    softmax(z4, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
