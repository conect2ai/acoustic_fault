#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][32] = {
    {2.770106375686035, 0.5628638987245872, 3.608553934118669, -0.30362196141324205, 0.007127290853550115, 2.716635734807399, 1.0261519850574412, 1.559602013754199, 0.42912583831759565, 3.40673941728174, 1.2225739290604822, 1.0429428396145053, 0.04520596953229755, 0.12076607776058512, 2.047801828506584, 0.17557620956812128, 1.1701642856669299, -0.41577531087292185, -0.8009817340727132, 1.3651935401758892, 1.3201974170130524, 3.9523135573640458, 0.9369191002675602, 1.793071714292836, -0.1477331079228646, -0.21426470170722284, 3.364837857737974, 0.303375719906977, 1.0560087361574035, -0.24891910988637192, 0.24267714911533395, 0.0355708923140574},
    {3.5768178281816105, 0.6260412171548325, 3.7044788006528275, -1.3195400574074414, -2.746783587458203, 1.3524157301471322, 1.2096108263773035, 1.1446280190513802, 1.231022267356403, 3.631777158489421, 1.96816238156684, 1.1246479096560378, -0.7427995272246589, -1.8341561602119985, 2.946233018065012, -2.1563865490911582, 1.669612898524905, -2.775428551428464, -2.800743461511193, 2.420833383897898, 0.16305319781354985, 0.7343611860003781, 1.8444014919891465, 2.367828623346445, -0.8647715770429422, -0.07820638521212682, 3.410102615157665, -1.2003713959767421, 1.7726465335938075, -1.7090170254176558, 0.19556109037483924, -0.6270031000396761},
    {3.8530717288092053, -0.5454760644013645, 4.091464308971176, -2.3642332614907815, -2.90042494400138, 0.947826168390008, 0.7313308132919, 0.9364795264641869, -0.11708498797317093, 4.341778382622708, 1.519749763836948, -0.13332905924950036, -2.6002710234448174, -2.1955430281495167, 2.6202896271630127, -2.2916260664990045, 1.490776773725116, -2.9099340086518906, -2.991459058350291, 2.126834014948779, -0.04488847144077095, 1.8379919683367985, 1.103002880060923, 2.2891981000001977, -2.8229590423694564, -1.9263356959120652, 3.8115373918754947, -2.9614492419321072, 0.6925646688092656, -2.8730090132336557, -1.416603564634966, -1.6651969455775235},
    {3.2334154264394788, -1.6968971083133961, 3.8563884253384138, -3.4722079049154067, -3.4000407266683412, -0.6856610860700778, -0.024202729420544352, 0.8007001393392666, -1.0591140832752697, 4.018302101803742, 0.6521470274568953, -1.5801294635348917, -3.083355257124709, -3.1621293579730345, 2.4191975307982156, -3.094051071638831, 1.101940173781767, -3.22003141923669, -3.556167377488947, 1.572335943996469, -0.9153582906325098, 1.3233652980678456, 0.04516521917668773, 1.70087672298901, -3.6596342079940247, -2.9731570942261873, 3.6089915703835174, -3.6683730674034947, -0.5610908804014837, -3.3424642238188227, -2.720144378039789, -2.6590028664931378},
    {1.8683465152490073, -2.6127656021763426, 3.219044984602402, -3.9776517312342605, -3.5637552239604293, -1.6766509475481142, -1.5169382371838738, -0.15540295453308053, -2.4154688582150037, 3.2337240367165556, -0.7018770993533405, -2.710531385744046, -3.9402102631960396, -3.804908931678036, 0.9492056624074698, -3.3350362274692804, -0.274600911718476, -3.3992981506421156, -3.501131224510471, 0.3111097884874031, -1.635348520066813, 0.691679669796423, -1.1913797380651405, 0.38349878103488044, -4.044837211622665, -3.5893624911554425, 2.9201064143034277, -4.353013852003605, -2.034093385996507, -3.829565365316005, -3.815487529592587, -3.283584516813365},
    {1.0184638524483516, -3.088691665748491, 2.6131557289131475, -3.977076081264584, -3.7645401345188882, -1.7648318261993396, -2.0366263128757813, -0.7832248085074409, -2.5741754808559842, 2.0948881948087266, -1.334107336314357, -2.9820507775797904, -4.173045252060719, -3.590760356265373, 0.26157838836139896, -3.259853676685761, -0.8972950466186638, -3.3683055863731637, -3.2437473645301513, -0.3304459013705029, -2.011927064111869, 0.4846647140388887, -1.657536030981273, -0.15395904337413965, -4.287978577792016, -3.4454385366609843, 1.8403320174505045, -4.394394716871324, -2.3549504607986305, -4.231539706381781, -3.832254765143051, -3.541317762986103},
    {0.6463307961522521, -3.0306061475736388, 1.9430773576701594, -3.595753343271039, -3.6685138310709786, -1.902240067202623, -2.0973558244544583, -1.2644051038381943, -2.4331836599825065, 1.8554580591314942, -1.4597421926802072, -2.8633909075993103, -3.7661831355924615, -3.8259350995715713, -0.03828900481235784, -3.5935145217629683, -1.010047908886887, -3.801613686561066, -3.701084790172353, -0.6744244990659392, -2.126037746125523, 0.22472359014999665, -1.7039837003065104, -0.64340154510547, -3.894671302598022, -3.188607817218534, 1.4046840220092085, -3.8091177010868114, -2.423389880867453, -4.0144564629041, -3.4892726644250747, -3.5240511993096124},
    {0.5995271219445292, -2.9655426556331728, 2.1308817255622676, -4.084794850801865, -3.8629115704583104, -2.0974886433797293, -1.9974460776949294, -0.8720628400020101, -2.5560381586988434, 1.9219280455746184, -1.280347649911959, -2.9780844524207, -4.189979895735074, -3.9831559677203967, 0.07503456609300709, -3.4912667260828, -0.9590939955459737, -3.94699048797024, -3.577047974066109, -0.7731902885737691, -2.2361537153995417, 0.4322628065337379, -1.775630221796543, -0.6936476920377935, -4.146612844386618, -3.424899870973399, 1.4182760309776865, -4.042588112771941, -2.169169912793154, -3.974629327040625, -3.604587036541765, -3.707090567368317},
    {1.3778226511083405, -2.3389443186303964, 2.70127721785542, -3.9132748133192345, -3.9408342825880225, -2.459601067738208, -1.6452357491721212, -0.4507151248635945, -2.2166797948338446, 2.5093119150187224, -1.0628816169109876, -2.907918908295776, -4.123981244309439, -3.8278826959661707, 0.5454202665401553, -3.77314688807681, -0.6304432130256177, -3.7303322796455842, -3.4510218408640303, -0.2344133999891089, -1.307268182240806, -0.009338519327111284, -1.6067376082808382, 0.05361526095830875, -4.164588382931394, -3.576127360717314, 2.3010558642225716, -4.155534118350402, -2.013356041500483, -4.061967022080805, -3.676377598937241, -3.4108993143134025},
    {2.6289121026091022, -1.9720802706052443, 3.3358719181956027, -3.949762473847968, -4.060223137571957, -2.1011425313423913, -0.9448468960088103, 0.07119428215262104, -1.3196285175659952, 3.2911359838386476, -0.11573832210891775, -2.111044989757837, -3.730892519091566, -3.7856799176353504, 1.052640583195584, -3.7743648345611946, 0.16234034899199912, -3.8970009852197447, -3.8065509765267955, 0.5071454865324363, -1.0713071595303505, -0.26573000363956123, -0.9191225352498804, 0.9082042755250246, -3.804939867561113, -3.220268518322223, 3.134223288466939, -3.907370209320807, -1.4294066777945995, -3.8968441159670744, -3.3242244708265374, -3.1357651170719203},
    {2.5536668053860474, -1.906673580213685, 2.7881691905065242, -3.5981027586668555, -4.209255306468022, -2.4543484907782385, -1.3178386646718594, -0.844095180337339, -1.3861259352702497, 2.889233517760491, -0.17791796515401906, -2.2001189957644227, -3.377525654596095, -3.9259263870101035, 0.6987027955653566, -3.8636487363101093, 0.2560281797809884, -3.8463964642170287, -3.842792190239704, 0.25806685864051376, -1.8040514079050378, -1.4437739091397304, -0.9130025031193518, 0.8226169804253862, -3.4075150495078477, -3.0571034333327844, 2.6446161027559976, -3.4376674989536697, -1.2135577227202061, -3.588194657341816, -3.2514867256432187, -3.073799164910984},
    {1.6680067786084567, -2.162304458870537, 2.112380353553372, -3.650285119756615, -3.8525583132927923, -2.3711217787978476, -1.444819657763933, -1.0858543690122577, -1.9164712469858396, 2.3627677975823174, -1.0112345878673528, -2.788143305300974, -3.6397820160656957, -3.8190568941346097, 0.4330134495681387, -3.809442661643867, -0.5380498214951678, -3.9820680231721375, -3.7827493958786627, -0.3948404754761524, -2.1413776433170013, -1.5258870850721344, -1.4226775763967638, -0.19854115852223822, -3.7272415502013683, -3.0225963844649866, 2.3236787683971407, -3.656764508260285, -1.8851437355811558, -3.5837135905784936, -3.3392518439715215, -3.508069462776792},
    {1.8947861763297096, -2.289076452008327, 2.4127531611969375, -3.7671820381602186, -3.881570813134832, -2.0135031662799343, -1.5087010265107763, -1.372134992972962, -1.7325009181606885, 2.744343058966504, -0.7417956223180314, -2.376079988916517, -3.720464499913988, -3.791098546412827, 0.8228227813440909, -3.808632408855251, -0.5425124001901376, -4.140061679067755, -3.915896137091863, -0.2173770320531923, -2.1973342270969165, -1.3874270594243787, -1.4558244485869432, -0.15068381298399192, -3.4287350039948508, -2.9653542420390404, 2.5694716264456168, -3.5914268360902675, -1.6771243714332473, -3.7356920692001325, -3.0525799409518277, -3.408604924566424},
    {1.929539974324179, -2.309214734777908, 2.3116006296398033, -3.9090049996027183, -4.2977652912133, -2.226015401095668, -1.5937281529591287, -1.1287990502069325, -1.505723261230588, 2.720582174830261, -1.0007363825640447, -2.730907476565441, -3.6290221214932465, -3.9254669464761074, 0.7546678241921039, -3.971991433543934, -0.644767496881762, -4.265466659234723, -4.046854166019842, -0.23849266425281918, -2.6265911112004057, -1.5454625378458051, -1.5408986590266507, -0.08060722106927078, -3.7380041352529507, -2.9262162448554196, 2.5128786871732847, -3.7791158904269784, -1.801631662579174, -3.7700358462477666, -3.477838813390849, -3.521947119666513},
    {2.3545391482344056, -2.016642130581139, 2.995027807117495, -3.6881083181655514, -3.844572259428111, -1.6513293087580747, -1.5166666481640894, -0.6992533441016423, -1.2617094897420922, 3.324856517192634, -0.6503253462034047, -2.3616104594592824, -3.5850760522409373, -3.786728787608949, 1.079884906001367, -3.9480411301596745, -0.12246101364094233, -3.7925967774209473, -4.025379024243032, -0.009422985223106892, -1.9455221916554961, -0.4866776768591019, -1.1930702226252274, 0.5078401565651031, -3.591617136116531, -2.8196364412101884, 3.099854202436362, -3.4603042786985183, -1.1750364888230886, -3.6418474710277597, -3.2837998234495283, -3.445885037379706},
    {2.7845322389555744, -2.0127653585087364, 3.3234954378855166, -3.8786806582370983, -3.8665646637954647, -1.5401872243427421, -1.0788633244557724, -0.0516822437954561, -1.2475274339867768, 3.2019339293312052, -0.2636040057213522, -1.8487620205244248, -3.791125919807674, -3.951571705486785, 1.5346670986067534, -3.780532017695121, -0.06687213969895493, -4.049707746881161, -3.93476213168128, 0.3863202857799171, -1.546072101851745, -0.3525123277562802, -0.4202969798210044, 1.0020515446685472, -3.864249018663633, -2.8108905367805064, 3.1288963588641012, -4.089574787667239, -1.2477304470827122, -3.896813514195134, -3.1237372870903304, -3.3695247721554082},
    {3.3854112748279803, -1.2898053871995447, 3.3722415602246887, -3.469673892369647, -3.5611862033736594, -0.9301705290151249, -0.5042283874775818, 0.42929324464899155, -0.9644547709853983, 3.7502990036730393, 0.2741163768856676, -1.765679021218816, -3.298325899912641, -3.544237142365649, 2.049817778232328, -3.3966109010561185, 0.6510768851873022, -3.6992846573351503, -3.791906986606061, 0.9924433661619853, -1.1951456289541844, 0.6339649676846952, -0.1835883404007922, 1.5509733803875265, -3.827795577264344, -2.697321722715067, 3.294154369220799, -3.7480454225007405, -0.7642538575079058, -3.4484517958171823, -3.2332253677825564, -2.9598036946228397},
    {3.914816794375756, -1.2480541664079654, 3.8757773771972652, -2.88571467034652, -3.2465890526507333, 0.6548814864293805, 0.013045797613452974, 0.5752758372561628, -0.46806022119542773, 4.198886883314202, 0.7968141113713251, -1.476153545826123, -2.8378490128864935, -2.6646757309337996, 2.306473275814092, -2.646706237928632, 1.0974238745032443, -2.951455455802716, -3.042245830246144, 1.2730294914841918, -0.7554814238313986, 1.868728193525142, 0.04550831074884516, 1.882155364025968, -3.005241122085413, -2.533485588221112, 3.8368008139051404, -3.14071289689802, -0.2583588074749794, -3.212660221919369, -2.7174945606959726, -2.5655874471521516},
    {3.4418273377739124, -1.974983435539949, 3.843133869010138, -3.2311919679601866, -3.386696261210111, -0.012578652634757345, -0.8135760645985248, 0.1589741732118318, -1.229325686124274, 4.095955638989401, -0.22505694900680864, -2.0035849162427395, -3.2446751295579217, -2.7818820078123294, 1.7088540659927696, -2.8049252705273418, 0.019525644967334756, -3.043416024857242, -3.367186098423281, 0.5849014823869854, -1.4373782860080706, 1.6720570494943128, -0.9164011922854056, 1.1443673590471253, -3.4579037679233373, -2.7676699247058094, 3.644898051630277, -3.5017447427357973, -1.1421252629771212, -3.445545224593151, -2.855578843161579, -2.6445312717308838},
    {3.4237244388442436, -2.1198854711334407, 3.742839443552854, -3.662578817064792, -3.7505962351048456, -0.8174539849173414, -0.7250055068487472, -0.2582201347246531, -1.191807350298697, 4.0757538788914305, -0.03188826668239236, -2.098557811832487, -3.7413231798644646, -3.335674086248392, 1.8457960135279208, -3.1684326123706237, 0.3250022159026788, -3.794517114516252, -3.833976933269354, 0.9471103706449028, -1.5842986143666062, 0.6822044247339755, -0.6109865507674019, 1.155982941848833, -3.5734818022979424, -3.001261623991233, 3.754020254201557, -3.707807182592906, -1.0060854760875102, -3.494992460851542, -2.928724757843899, -2.8928616561397664},
    {3.3960385689278194, -1.1152217369027104, 3.635998530696421, -3.4286779367920324, -3.8732976436988853, -0.4787954540545298, -0.27015791144619117, 0.01894765948306408, -0.5297614611402107, 4.075129283772344, 0.7918513122335061, -1.5824390037215101, -3.296457858339947, -3.2944853519434356, 2.2120835116707847, -3.3568143339023764, 0.8735614447051617, -3.899901929377985, -3.742500406008085, 1.4223245044405606, -1.212174549727619, 0.12491499788033139, -0.0041188105540141615, 1.5064384928659835, -3.5101746578866075, -2.4438028482274006, 3.550859561643171, -3.61399743352454, -0.23852335164390198, -3.2989077013835946, -2.88503374392214, -2.653695139515399},
    {3.9658757805913014, -0.519888846797856, 4.321713256323508, -2.6673846043729466, -3.277582843069367, 1.3655773983502975, 0.4590032486239271, 0.6837292424753801, 0.09584005280074395, 4.4730094659803665, 1.3026560248678682, -0.8444948485794654, -2.3388776148482657, -2.7647314373238596, 2.850315084625053, -2.5857176795218164, 1.4205202145291136, -2.9470626614090563, -3.333888523281108, 2.121895465258166, -0.41146977507240845, 2.1852082528830303, 0.8608619378441783, 2.3097675133477513, -2.596771334999967, -2.0268204304561315, 4.196422394582725, -2.720207797302457, 0.4965273382742758, -2.894995001581454, -2.0402422796682855, -1.8981496261880066},
    {4.184822906304959, -0.14535351730190918, 4.231395790298794, -2.2799144965569087, -2.693034039813457, 1.819110886792593, 0.5626691247662124, 1.3886404442144793, 0.5248480224043109, 4.6195674111627625, 1.3863587934542134, -0.09137585016894643, -1.4922270134109392, -1.8902485746054862, 2.823507178435955, -1.944786952118166, 1.7507955320000999, -2.3865976983693806, -2.7193328497185747, 2.3526480582541014, 0.20166277622743636, 3.1451379345533605, 1.1092223502680705, 2.4774538710706344, -2.0998798975765838, -1.529206587135559, 4.1500354302733236, -1.8225681126623823, 0.6378869041150289, -1.857872195433302, -1.3998151105809062, -1.3164103793214046},
    {3.989902770198587, -0.4043382669422371, 4.266476478347783, -3.0297035497363285, -3.1990046780239005, 1.2126795496542475, 0.2824454871996654, 0.7675669125648373, 0.04858694451454876, 4.280506562700411, 1.279418197192027, -0.702653268528297, -2.1813581302688827, -2.7069116992530318, 2.8724679122033754, -2.5375714425682014, 1.475606943959922, -3.2086028143447742, -3.4167280276559557, 2.1550161836834465, -0.2806198150534189, 1.8724491662882181, 0.8786602292092356, 2.157891891447367, -2.54467599391516, -1.959599117835517, 3.97075869274438, -2.847085966908237, 0.5503582006415869, -2.596201930054186, -2.043631601180259, -2.159058079128947},
    {3.956847134455511, -0.3931888901512662, 3.93184717597581, -3.0449770173517066, -3.5824045140802205, 0.20710087450430997, 0.33177054154923713, 0.8130159410351396, 0.17554731588314287, 4.007867670569273, 1.6646842625981937, -0.5196513373945922, -2.3717924426879775, -3.002293806560825, 2.521055090528334, -2.9270187432390284, 1.7374873909824144, -3.523097173959724, -3.7079911408461497, 2.2736902782115616, -0.5590895401998646, 0.23674578839795488, 1.1725108677270988, 2.2834356378340006, -2.9369332305795255, -2.130992814680973, 3.717936571581861, -3.1630211544760733, 0.5289685551335378, -2.7414329835747364, -2.0215363218822597, -2.1337525035874423},
    {3.451064020314975, -0.5917003560779109, 3.714574886494594, -3.072875877413447, -3.123824966815657, 0.5855257444049922, -0.21655069831284893, 0.16838691618554671, -0.38667409483351817, 4.115702052156226, 0.8918039958193316, -1.1437878775705879, -2.600695890370141, -2.762952599189951, 2.2096786000870954, -2.6150618842746383, 0.9330782123958363, -3.180377333720866, -3.227653798246421, 1.2644362341892539, -0.6460573278801622, 1.0722193546827743, 0.32410784459333813, 1.5354295256908181, -2.60289824325804, -2.2351883975122258, 4.013487888135897, -3.0150527627356594, -0.185244188059231, -2.669004958144104, -2.2633929876061045, -2.3311880058744445},
    {4.177614716794902, -0.7155763872019334, 4.23076197369828, -2.928127260805568, -3.454131879875602, 0.8564267023015503, 0.269469997355183, 0.4976139926876739, -0.13364345118870913, 4.336502063042588, 1.3481911985090889, -0.8541841653805547, -2.625915514727854, -2.727566702854843, 2.7100949920690955, -3.0226481213978404, 1.4966382073390996, -3.127788705682383, -3.4959711894984116, 1.8476042392160141, -0.7560039790313734, 1.4104786289237843, 0.7191733376542505, 1.8980591909203743, -3.0745785469388074, -2.1961142308777535, 4.210108119196772, -2.859006760185866, 0.03694602504596871, -3.1880498070183396, -2.320977993903669, -2.2876126470604325},
    {3.9417931215164135, -0.7114018620287339, 3.9362927690046923, -3.0939611790409325, -3.4189775160171574, 1.0194557306304912, 0.2191137026968157, 0.7504268023939606, 0.06790329002661692, 4.285854110565649, 1.5398840438599921, -0.7434285984293448, -2.6108593090417167, -2.8201646711476513, 2.8295608234580465, -3.148232705865624, 1.4624716203613883, -3.4246527223371217, -3.7612141567228936, 2.118255840782002, -0.8092510541433763, 1.4385626845436477, 0.6984465585077303, 2.18254307025316, -2.7374016351188506, -2.0731171463114486, 4.112864665533601, -3.0868429624237628, 0.2557996816112367, -2.9725978926842136, -2.277242026478005, -2.1979005865113366},
    {4.041038644586001, -0.5039921068108357, 4.1796749845311085, -3.1194584160239813, -3.4949580757178804, 0.6967329235230252, 0.3720817333096913, 0.8283373995603233, 0.39159489775034295, 4.088701358741163, 1.4689126892343838, -0.46372328382719746, -2.591504358131052, -2.8871983462469486, 2.645025749096861, -2.8555416201214134, 1.7250454123284253, -3.473020843635875, -3.7016703473936414, 2.187650641237121, -0.667272872650088, 0.8026139646906093, 0.9120171798125921, 2.338705946268423, -2.765324318966313, -2.0864788156561302, 3.9669453752980863, -3.052199426508969, 0.5453826118334238, -3.099699556134068, -2.144340722995154, -2.2149848138928174},
    {3.7326463190763532, 0.24385287152719645, 3.699568830682321, -2.428748739816161, -3.1877000663486035, 1.067452785584314, 0.9586448465043516, 0.964323974469977, 0.9249247370863658, 3.8648968392202963, 1.7135936207760916, 0.03968102364209291, -1.814218592846971, -2.2162548623692975, 2.8567260885795007, -2.542425761999539, 1.9330454411613909, -2.979618799014234, -3.5675946588396097, 2.3928304464587313, 0.16818569263866476, 0.9705466821794883, 1.6047009642886814, 2.5157526006229975, -2.208280012971215, -1.3142186602846968, 3.941376208688757, -2.217064187347275, 1.1325992796655613, -2.469608909432346, -1.1761082520074941, -1.5474635070481517},
    {-1.4416212351780417, -0.41474738484451557, -1.291891033445332, 0.6475801791102869, -0.28784545249551735, -0.08182905026108518, -1.281110695791132, -1.465239131241246, -0.9407236741066417, -1.362381079272222, -0.9965643977934368, -0.9990376093016898, -0.5811066288803021, 0.2857741637477146, -1.4712492582313548, 0.23311093626289991, -1.053383780926615, -0.1778908230831032, 0.4292092365767644, -1.4679963926815331, -0.9030850642999687, -1.133838987713979, -1.6213722889699198, -1.4535245065539895, 0.5359348305327482, -0.04291037442397612, -1.7486425494676126, -0.1602142041277384, -1.158645078659658, 0.34551141609508634, -0.5128667223124413, -0.1997671058899655},
    {1.2442263049854019, -0.9004888602470537, 1.9071110868794414, -1.0595732882700013, -1.5402313834159476, 0.6250702742815054, -0.7050745117959485, 0.0488542422685583, -0.8006353839850382, 1.8898396489474831, 0.1239508556862194, -0.3611314525828351, -1.423569543123625, -1.2874614066936918, 0.5304996697160855, -1.4526092014313459, -0.0345425649789708, -1.9061406731669184, -2.044057069811537, 0.5539803579180329, -0.7384585861202758, 2.1090910803413228, 0.1734568373769691, 0.8155880492185758, -1.4153010946833926, -1.4214871683729904, 1.38867919290085, -1.162165243920164, -0.6055479744405574, -1.261146245840697, -1.212952180366281, -1.4904876146523018},
    {-2.6756028766295015, -2.793510666544224, -1.9873624998293156, -2.3693410036615146, -1.1955592783893048, -0.5281149128157714, -2.809087055282605, -2.595018961870853, -3.068139967734321, -2.394313342694875, -2.7151802397951483, -2.938125859431471, -2.7923098435082974, -1.8631517583700905, -2.6659568162245755, -1.459362764588863, -2.8588227825216537, -1.3474379691128027, -0.692734801572811, -3.0586497433784765, -2.5275372861846277, 1.313237108918106, -2.986710372246335, -2.867931920855454, -2.646277819327543, -2.577853727009322, -1.84168265603698, -2.104954903468154, -2.725548502391475, -2.3417302629433028, -2.4398783814663236, -2.4470532869742025},
    {-1.9024750114710645, -2.3962424620528244, -1.1935084796476412, -2.1012473537540926, -1.535013704301325, -0.7196614568519794, -2.1993031418557565, -2.487841297173276, -2.474364970497526, -1.8645653270579865, -2.0996684596901884, -2.5218599314758197, -1.867842129261303, -1.9500485066360251, -2.0253667932073496, -1.7569318869926318, -2.5877649706265893, -1.58651233865139, -1.5474761458082051, -2.6786539270772667, -2.7108165022802266, 0.6583625957765987, -2.486875356086903, -2.537860993798868, -1.6540056325935513, -2.0168852273108917, -1.3522936008903734, -1.0566718024777064, -2.2965493163630573, -1.7997070427626267, -1.9709173059233231, -2.0374642953661715},
    {-0.3745163011924505, -2.5191360531014104, 0.21084073162244385, -2.6022002097750514, -2.5324312059235554, -1.105257203442114, -2.4898027895180497, -2.181682271424487, -2.177972077446036, -0.2192797721666342, -1.7676491623715695, -2.497285245874124, -2.7704689417325734, -2.806298728873579, -1.4142032992091338, -2.79794921645973, -1.567057413697868, -2.870318558206766, -2.313552384141692, -1.6429078309178435, -2.2920297365463433, 0.6494291099182267, -1.9133121581590937, -1.5242546485280972, -2.622510865883119, -2.6527545073929297, -0.25733702543843573, -2.81894681320334, -2.0312765371500734, -2.966636527198655, -2.6866416631893646, -2.904785421433293},
    {-1.0991657725507327, -2.482265786858719, 0.2117015020365658, -2.906119864062066, -2.094234037292175, -1.0170480659586998, -2.3589297039859747, -1.6488438083849042, -2.454078816217241, -0.5965840247520996, -1.8392625259415116, -2.8342795769218196, -2.7048844476244627, -2.6816814791497348, -1.4663480312152881, -2.570678215193239, -2.214645284368267, -2.1608305500115463, -1.5380976590462232, -1.765266331588714, -2.4755981357311514, 1.3392967018871633, -2.3971728929151968, -1.6175967753360707, -2.6911987676885687, -2.521337775450228, -0.7502577088082862, -2.256982529429019, -2.1932588725394275, -2.691073580858783, -2.688357602338897, -2.417373445034303},
    {-1.292466354794817, -2.4761503657129866, -0.11545135328353585, -2.472053155055898, -2.500382979795217, -1.6722752791378033, -2.3622000988884055, -1.9657736659982785, -2.689506440796473, -0.589763021347445, -2.077692074996778, -2.703764992635122, -2.751292423105434, -2.596506433702965, -1.9192305071524085, -2.4222575791146443, -2.1900250736908435, -2.325123622202095, -1.8162298042669385, -2.0650980318607046, -2.2089148804711587, 1.1315022146018574, -2.5465053178346237, -1.9786281514545279, -2.6544212090283037, -2.3562601509546197, -0.7028715903074575, -2.4324748853867657, -2.6922442921899656, -2.638560356013891, -2.7676146904269667, -2.463446369752007},
    {-0.8739050335531792, -2.041745518995092, 0.3065413141368404, -2.2796431108822093, -2.35320343864015, -1.1800822698974553, -2.210550763940052, -1.8908340005889228, -2.4525313970202576, 0.08317431668437533, -1.8937624930108592, -2.5611893651134805, -2.145030779652785, -2.4981572146674837, -1.51200750375534, -2.5436425555827045, -1.6943732741894892, -2.52176975545116, -2.275362079156487, -1.3259802429005358, -2.352755067149823, 1.248829088259179, -2.0710063246506416, -1.3229403062151486, -2.3250706668681813, -2.06646983740571, 0.33022895615798625, -1.9228513086310002, -2.5297279679163616, -2.4723877664732705, -2.3817602027895597, -2.731477755327728},
    {-1.025487342284125, -2.639199298796884, -0.024809848728593795, -2.8024187651443135, -2.3104320404614804, -1.5372178448277372, -2.4093370733914186, -1.7574844153347984, -2.9900023209134403, -0.3542852032401341, -2.5680886548693524, -3.107503625851035, -3.0486512476487193, -2.859914127439481, -1.9137383778807897, -2.365482034036237, -2.2602029645066053, -2.2762657814582616, -2.018539834727485, -2.154437548847856, -1.9620543105343677, 1.0048976990417189, -2.413170208147734, -1.8537238663292959, -2.778774634710023, -2.5991639734404632, -0.0989658072844493, -2.42780867933591, -2.949377593842004, -2.8450111309803336, -2.5756293363812777, -2.8417933709068213},
    {-1.3002973629801138, -2.698912494670669, 0.6423291453983936, -2.894794572429786, -2.7496372670232896, -0.7699043289650684, -2.7727566316597616, -2.126302147535155, -2.7960487753457848, 0.20530648931749962, -2.176619236562066, -3.0310543342374188, -2.9083665082954395, -3.02361668524909, -1.8107210622393857, -2.79924008311507, -2.619927982622902, -2.6427109388035714, -2.401259830204721, -2.4697440644297184, -2.4453012414329565, 1.172967315481205, -2.4718823804963743, -2.2635211404815974, -2.9208414339565483, -2.7147328628508234, 0.18090403992828916, -2.742235544555197, -2.4246809542981813, -2.9610456689860585, -2.585112645713898, -2.6276996792755773},
    {-1.7299048834940742, -2.3263092259144655, -0.8914813353154434, -2.458424582683836, -2.7047900151902846, -1.3628736069338012, -2.937219708970087, -2.7355047877669074, -2.3472318291092096, -1.4737422466879644, -1.9117827229544369, -2.4497730711627392, -2.2560594703594465, -2.3786860526562372, -2.2011824996813987, -2.505383315317603, -2.6095776176821133, -2.680744548585149, -2.1515970933368167, -2.638280791946703, -2.688962312805173, 0.6056826727871736, -2.5699069332885327, -2.273588596698711, -2.4899972666337744, -2.2424977188831736, -1.1862987579853663, -2.1971844392207918, -2.1811484828459076, -2.2174638986178667, -2.431023688385032, -2.289186242938568},
    {-1.7074855620565996, -2.858045400120096, -0.5695961358931684, -2.979111855419304, -2.7867237416216035, -1.4621957545794595, -2.782255792294551, -2.3608493825128525, -2.5395509501830458, -1.2607772323524578, -2.5588434048887696, -2.6705834892769036, -2.6962171633630656, -2.933598630161876, -1.9984541191808503, -2.807712469004751, -2.542463599095439, -2.4057419932294533, -2.1314946253814044, -2.787503117293398, -2.8302384152864257, 0.9975712288180756, -2.7470283053331337, -2.251948799362666, -2.8501648021923893, -2.3800151985217126, -1.3228405213158325, -2.476191008171938, -2.8310634720241064, -2.793880895810951, -2.4927769288295547, -2.879771923715522},
    {-1.8129915889556252, -2.7161404102063913, -0.3258898920848242, -2.744999446850463, -2.818801868326063, -0.9415108725684644, -2.9517620106597815, -2.7489567256093888, -2.8715757347399404, -0.6370060636006649, -2.51477049635395, -2.7077503706205706, -3.0548998450065836, -2.767987203887534, -1.5312007767036564, -2.9528101256768218, -2.5172831063983705, -2.725991335472166, -2.6290699722384634, -2.8366493535106594, -2.9551758678947397, 0.967260549686716, -2.576828484939282, -2.497518719507726, -2.907235797703146, -2.594427639373874, -0.8584250960090412, -2.7677891900793385, -2.7975883137876068, -2.741532941277254, -2.784771748128313, -3.0415794733661294},
    {-1.9572279849211878, -3.1753566469681136, -0.6161135709040108, -2.974153404446139, -2.7747271307454806, -1.2601828735739626, -3.1674292352652382, -3.1527814315486746, -3.183454891397474, -1.1947048092507297, -3.1296354769325534, -3.30106218470338, -3.191540115377066, -2.7136409577941834, -2.3553136938471466, -2.565101647122523, -3.172829817981998, -2.468616230695429, -2.4284596307803916, -2.8618852055697404, -2.945472287789626, 0.6890110724327245, -2.985283184597359, -2.744700668388493, -2.8879885760423214, -2.808045733611939, -0.8404234056011299, -2.815521442162749, -3.033603855422377, -3.015309759017227, -2.767314308001252, -3.1240089273576452},
    {-2.046451435114969, -3.0099469422947567, -0.42401048744860015, -2.606604498080163, -2.385972416943346, -0.5732443139767733, -2.9646413817314414, -2.367258991321424, -3.0567294001926055, -1.1059247078373309, -2.979257892841376, -2.9586901382934734, -2.868372829138013, -2.8181488039868863, -2.1700067519249795, -2.2926473754881265, -3.116241739153912, -2.4794356097416026, -2.134044037049732, -2.7240668343975476, -2.4095501076375965, 1.9006737044724185, -2.9136866267257404, -2.6539386598790635, -2.9998267798331777, -2.7534079345925333, -0.9731297643189435, -3.009101967670294, -2.9969293600523335, -2.976949184535199, -2.8056701621430506, -2.773228870846264},
    {-2.6981810845341947, -2.9114068347923, -0.9825865835609008, -2.5271320463485702, -1.8486907411660496, -1.1005968512163777, -2.940834847591923, -2.5688509116258476, -3.441338271836444, -1.7378757375320233, -3.3065041491040668, -2.9681050020526905, -2.972016245348503, -2.317111962733679, -2.6128751400251393, -1.9596801718678523, -3.238088357013251, -1.8800831905104003, -1.4768039761685108, -3.0774672841702113, -2.6304496060227387, 1.4121543978113285, -3.345231247293102, -2.859130401252089, -2.907188413683396, -2.72802798088517, -1.6926409618805978, -3.05705378719882, -2.9669235462503085, -3.0124397536348813, -2.85000418014826, -2.5809519470064437},
    {-2.1230854644778363, -2.703086042729411, -0.718433733770859, -2.6334676427791948, -2.040085768131182, -0.25948100566976673, -2.955335468172836, -2.796451202767346, -2.8722226230895997, -1.5362627984540445, -2.7661041394323242, -2.9532681033422077, -2.500386873224643, -2.5699784393362544, -2.087771357577088, -2.2178249084026493, -2.9256993187869593, -2.190889830228431, -1.5319518498546452, -2.937479130204288, -2.877675497951477, 1.6273553315426816, -2.687107381219009, -2.654694413874665, -2.6504090914733913, -2.4536930495254774, -1.2488278652561233, -2.0796450744863644, -2.9320530639360283, -2.703480433982622, -2.703987582135128, -2.6390101440862277},
    {-1.203168394689524, -2.0865631615359415, 0.08083231326632448, -2.2149071342166975, -1.5704459947465188, -0.07152982985595369, -2.299829438233543, -1.989961219110428, -2.5233677358346025, -0.15200913756930143, -2.564519899816645, -2.5892053257312106, -2.5120065798594413, -1.8100321750405683, -1.3700808253349472, -1.8677738548201375, -2.2258809888734588, -1.5780897929877469, -1.578218733062481, -2.314041573645168, -2.0865472552162267, 1.9338471497945173, -2.3556943198171347, -2.109871042232657, -2.258097264965479, -2.4902149270813325, -0.23148510775939218, -2.2814420317518826, -2.3040537191204673, -2.3468217840465226, -2.3691233977357142, -2.3380478059909744},
    {-2.431183223221544, -3.30704033589687, -1.3229633207156009, -2.594944288362656, -2.0271841540805324, -1.0432806668858456, -3.2786370016408126, -3.12205631919718, -3.4212826609479494, -2.0048204824113967, -3.2498665414848302, -3.4568802844472586, -2.955387345249848, -2.304210310299142, -2.7696225087048365, -2.502640183031233, -3.159390173773889, -1.8183612563589513, -1.7898819357211462, -3.4484174195021113, -3.057048831641796, 1.3107285903397057, -3.149607370096451, -2.848770843907471, -2.831856748772541, -2.8055256587036292, -2.081658851309946, -2.773399356832507, -3.28037426449624, -2.9273706753716553, -2.84687327150189, -2.677394392424512},
    {-2.789178159175499, -3.4777078843644853, -0.9826472273990596, -3.015306188992808, -2.2524658714930914, -1.2305331286465244, -3.654724285248726, -3.221529434166744, -3.532518906042304, -2.141097427383418, -3.310185506780749, -3.6804796242216407, -3.5687254106091415, -3.019517157943307, -2.7105035666852997, -2.884650320173592, -3.552199306744035, -2.376198324600361, -2.1553738587426645, -3.2597175878849933, -3.2228191832907123, 1.335481408326267, -3.164466978251428, -3.190273740230088, -3.661738056884659, -3.1694282182323694, -1.8771755748140544, -3.31531312113156, -3.2363906469656034, -3.423807229527287, -3.2007162302666665, -3.201618231976642},
    {-2.107039952437449, -3.5841653418728696, -0.6106716140937746, -3.3060166261342148, -3.069267467515841, -1.005741535376217, -3.4186344312998744, -3.0682540643036127, -3.2326243047082595, -1.2372191413974756, -2.882743168374583, -3.5296109902815243, -3.389479314245172, -3.434959994966697, -1.9600367393971305, -3.1767305414223075, -2.9171246808243327, -2.9004324237876054, -2.452275689376626, -2.8817053811646445, -3.3857076258821777, 1.0482086389545289, -2.906116886482168, -2.9444998452039624, -3.4530490285406814, -3.2488325417116366, -1.1400363681733088, -3.4600554889632638, -3.0305352120326527, -3.52887100392679, -3.1245510714666707, -3.3207716388023547},
    {-0.8229084610775604, -2.9304998161787936, 1.7553574126712743, -2.0629483613145334, -1.619033117399006, 1.3726591287172139, -2.3736500862461667, -2.11628144137115, -3.1201337744810687, 0.9539455050947679, -2.436428305498935, -2.6990690582495067, -2.821118255535908, -1.8893661070313394, -0.7170151309548912, -1.5190623862659511, -2.615562824214129, -1.3776663445891044, -1.150706599835449, -2.387852382518773, -1.9086459083839704, 3.6148224818958004, -2.543956617569294, -2.2851466450888105, -2.746825178113631, -2.996547334444949, 0.7686730611455036, -2.7608968519818884, -2.650314389122813, -2.4576398836217046, -2.5914865153033086, -2.5251359677588243},
    {-2.6687542646206914, -2.985030013355441, 0.17745862175482924, -1.3747191200428797, -0.017219823703344843, 1.921760982720493, -2.820774419294433, -2.0291946404150742, -3.2872247359949114, -1.1710180030587296, -3.389032191292797, -3.0771169228286555, -2.6008632184667606, -1.039960022358494, -2.2051261940102047, -0.7347087279515255, -3.3367536622578524, -0.24842300319465974, 0.31997987379679793, -3.2765202831598916, -1.942092314926029, 4.009993090228669, -3.4938871370244953, -3.10013236015837, -2.19626333073025, -2.8655220806746513, -1.221378257532111, -2.248309635047695, -3.3113260944555702, -2.2777829938708836, -2.368305931392106, -1.8885947590200889},
    {-3.197364592254283, -3.3960086260780007, -1.0629977820559275, -2.46086465579323, -1.120794049843909, 0.4859258369716487, -3.356279397002931, -2.9113261805493558, -3.699101013007261, -2.199828715814917, -3.6049214295107164, -3.4252784938839422, -3.1893152317965674, -1.8974121699420208, -2.922660630380695, -1.694096065431687, -3.5390590688335197, -1.5353968507440305, -0.8114501391804823, -3.787771503830702, -2.667182743726207, 3.067623074009458, -3.515869899562834, -3.5429143297548915, -3.05867983823503, -3.4063422301180046, -1.9264037696353926, -3.12370830737362, -3.626398336231003, -2.871410784751055, -3.0560476564821353, -2.8264520404028985},
    {-2.6192477398505654, -3.620755730732396, -0.7972100692210826, -3.1967976073663724, -2.6910651867521596, -0.39305569817819114, -3.236765726943206, -3.224995266299366, -3.3449524156738786, -1.920308783312934, -3.2679781348567016, -3.7339285749993065, -3.5096565102078636, -2.9158965956167933, -2.49270131650829, -2.7016111644640994, -3.4164431566126092, -2.445561723632646, -2.1542241615725866, -3.3119473590471604, -3.3908317796087015, 1.6703226300310752, -3.437561652630225, -3.0270686170382537, -3.351867017691452, -3.021748239373196, -1.576762224766723, -3.15432609324294, -3.420573811279602, -3.2324057426892776, -3.065667527499915, -3.437359732996871},
    {-3.3386986955241307, -3.2924752382434064, -1.381388886876069, -2.111350657488948, -0.7979477434124755, 0.38238679438950574, -3.4295263367219144, -2.7484075131902923, -3.713022313086302, -2.733955636329273, -3.5423795680112495, -3.7673613459001447, -3.00611923039445, -1.4596340916524182, -2.756373551465968, -1.4958505410895189, -3.4966513814391327, -0.8236812334491551, 0.03327384745679866, -3.9417210178564934, -2.530862910489333, 3.0156654345583522, -3.8346001381872115, -3.828224567236631, -2.5025436312554588, -3.1959400361121846, -2.191322020438669, -2.44441847268906, -3.7294051593275674, -2.682636070566609, -2.9360717203432074, -2.792567831575139},
    {-2.705090243362591, -3.2769902444811296, 0.05263220339812452, -2.455321753581988, -1.4352783902844075, 0.8402633421553408, -3.0804916794432993, -2.9849106674182337, -3.425899988219797, -1.5933354498322876, -3.4762349964769763, -3.5714691400688583, -3.1714106254270322, -1.7255125231725277, -2.230284994657976, -1.7426105277586368, -3.2781487954688733, -1.6048041039435388, -0.8167613978714289, -3.467636066266146, -2.491723971585089, 2.994930685562383, -3.604675398937723, -3.302341106286102, -2.9648742531522903, -3.0702285807735623, -1.1054491201784737, -2.879478322927163, -3.253216233449435, -2.7377011909477478, -3.0352884807165488, -2.665416730500318},
    {-3.2089268901150994, -3.2961769232029967, -0.24316097262138217, -2.632613191514765, -1.7341745101622301, 0.4768456725889893, -3.4829364950406, -3.073577114708008, -3.472486056194448, -1.7416626342588013, -3.461325682303327, -3.3863524841202413, -3.098540865793866, -2.0239752421176394, -2.5229274050281574, -1.9662941251395745, -3.6045978201475495, -1.4927853043790331, -1.4089377440796205, -3.418196745391102, -2.832543436631536, 2.4541102793896044, -3.4318628766655643, -3.435700507893358, -2.839228271823545, -3.1659215515078833, -1.2268555658297577, -2.9687581264181784, -3.26573151488255, -2.8760533088148286, -2.8978967053323035, -2.8724443753283966},
    {-3.415025465063158, -3.3860388383961846, -0.5650790949355747, -2.498265473089938, -1.2786860694540503, 0.6507803329779587, -3.0476011223314567, -2.7616801524892223, -3.68141850418103, -2.394187490191713, -3.878301549197717, -3.602473679488821, -3.0375958022672602, -1.7621759329165505, -2.94761836604643, -1.7134495715844398, -3.6335939630334884, -1.3223268124211895, -0.9572830024221287, -3.7302096382935126, -2.7169114973338773, 2.79748888105991, -3.607459826251023, -3.4161236542163596, -2.6403380949036337, -2.9703451829449525, -1.936303988409446, -2.777831896304425, -3.7204556357158447, -2.80932666847643, -3.1924517326935677, -2.7333816335029057},
    {-3.0021782514718702, -2.834931369651493, 0.2929610262100365, -1.6573246269618656, -0.6432776567793418, 1.5667401564095127, -2.975492847295604, -2.4047529995092245, -3.203852042173488, -1.6053009232357702, -3.3669239665399213, -2.9016284983521468, -2.4151817650812033, -1.0873995619780892, -2.0761832223303824, -1.0168676410224027, -3.2266896733247235, -0.741019680968351, -0.20471418190241367, -3.4263401931936346, -2.1819424922560806, 3.5797552794873466, -3.2350631377773054, -3.373554146896748, -2.4044244015828777, -2.6131116264687115, -1.0782170353179148, -2.293016923688784, -3.336931644381593, -2.266971658057832, -2.429885346806058, -2.278768673293027},
    {-0.38751324391554726, 0.7140101446604896, -1.828471742871992, 0.8102226488060545, 1.194928220832321, -2.2609043013107732, 0.9174605332825471, 1.5182609832084841, -0.15126450224130347, -0.5844090197372724, -0.22810506470940423, 0.8367403962761906, 0.017668587480027635, 1.350951692944664, -2.103644132355422, 1.5230782604892652, 0.2450225478282229, 1.2649121595611565, 1.1851151620496636, -0.22414167347004088, 1.7523982703886314, -1.0227951856863422, 0.5658702784108438, 0.036768119819971475, -0.15948815590885593, -1.4776139847427554, -1.5001027142371828, -0.5097705378336587, 0.046461233775173645, 0.7006237081159605, -1.4475358491522607, 0.9473359887518088},
    {0.04570787048473548, 1.3143336924124402, -1.2475827807885305, 1.3929713964684596, 1.403308014488218, -2.074509640033513, 1.6109086074999626, 2.197932815394975, 0.3816876562464055, -0.3640485700544704, 0.6397888048854471, 1.2055433711022383, 0.39035802225059785, 2.024284298134764, -2.0891007528002503, 1.8188429261632666, 1.1627389945667785, 1.5300544045327626, 1.6964433515187942, 0.6440121864913272, 1.71858834999, -0.6228861205878153, 1.0781319761581032, 0.6268033476424475, 0.46560308115850635, -1.0580640308307456, -1.501321834108069, 0.3510832970875246, 0.8803346857597298, 1.0453985326205095, -0.9932156653025322, 1.5196835539795703},
    {-0.7186848631290172, 1.310411376169851, -1.8018722323402443, 1.7530857418301464, 2.2851024053112687, -2.5831845459165543, 1.9324725198078354, 2.285872098425299, -0.12740198439179984, -1.2575259383867425, 0.25429932283118933, 0.8067447057525519, -0.2786436875808021, 2.3533741878441297, -3.016420281437868, 2.156520164237845, 0.9043777990964789, 1.93413189127828, 2.085569686887174, 0.5566602177974614, 2.057928166078268, -0.8440129632129127, 0.6237450965007988, 0.43400206516395246, -0.10950833988660065, -1.580146329028542, -2.151328409284355, -0.30529544226670924, 0.14549943285104847, 0.9922573542508195, -1.8106755425633458, 1.5619571450079934},
    {-0.28972679742770063, 1.6097745076992955, -0.9413966260167657, 1.6221946324938241, 2.1655122204690493, -2.6306207747942696, 2.1447871949616797, 2.1726416828994646, 0.31782306135945054, -0.5072628611734076, 0.53570513076829, 1.005012447095746, 0.21208138737313384, 2.427603701407146, -2.6277169402179723, 2.4067811039954385, 1.3952207047288034, 2.276776881101468, 1.9652981797045492, 0.8277921828940584, 2.307195700593768, -0.7089941917402482, 1.091738477089182, 0.9136759217698143, 0.6848983529484506, -1.1736151466089482, -1.765841340355449, 0.06337359326239665, 0.7596652215396618, 1.3187041912008468, -1.8137404955322467, 1.9255198781354228},
    {-0.19124242832110977, 1.4019565117410675, -0.7548091110661048, 1.2901059333908251, 1.6652283449026304, -2.7867120065484037, 1.95023732005681, 2.3474096709936734, 0.27735832656408516, -0.2639237149832374, 0.39392042974155395, 0.9134315064499052, 0.4047534423878746, 2.0567701508685095, -2.3755617717955624, 1.9412936800545322, 1.0082232248803957, 1.3612384682295056, 1.274157897247234, 0.758413465248758, 2.221657418490857, -1.035849432706433, 1.0611219848583215, 0.6905666535699947, 0.6975529069484124, -1.1100017295462776, -1.6180290094742384, 0.0468107032901425, 0.7325918255426759, 1.2592863684575004, -1.467410784229517, 1.877461279424337},
    {-0.7962215926859051, 1.2137997654842934, -1.1631445231966668, 1.3498703361347217, 1.6314126485464644, -3.133977395380047, 1.6417730181471397, 2.07803891449576, -0.43703009117861763, -0.6839521431335719, 0.12320076434421079, 0.47751630332884387, 0.025249284647202018, 2.165480281587412, -2.5751387890921182, 1.9351248090040043, 0.7010019925957507, 1.6938056179391927, 1.7377801858370572, 0.8153776867612171, 2.0151184188836364, -1.1390706322638557, 0.8076132354045438, 0.6428223443488212, 0.34077283412703707, -1.5471075374440153, -1.2257369920816343, -0.10612421666032898, 0.3236378447484882, 1.1443781494687801, -1.8673374911006726, 1.359654378429541},
    {-0.8733932938104286, 0.8981843765497616, -1.3514784461778264, 1.4986667170734294, 1.9945014357917603, -3.172585280409059, 1.548355373309542, 2.012700480004903, -0.9631977945751123, -1.003443737254573, -0.225930055239041, 0.28838813795986973, -0.2669597933642867, 1.9620981309671968, -3.068546726912773, 1.836481314512833, 0.29046344751350334, 1.6612055852704009, 1.9854157765464895, 0.40434063900783584, 1.9432698905491035, -0.8948234653589838, 0.08433795767626985, 0.3240090632220114, -0.20022824823315444, -1.8342522625266617, -1.5166014308738354, -0.31553689798521756, -0.38289656814983203, 1.0566716455968348, -1.9770346530089427, 1.3075142186363813},
    {-0.4341240739354656, 1.141378354234976, -1.6273332149720083, 1.6121719219861284, 2.1464667635485912, -3.034535474349773, 1.8582009496574796, 2.2036700355686083, -0.3344944041145764, -1.1781630038113133, 0.24611527699603666, 0.3897383883709361, -0.220615050300352, 2.304970338636612, -2.7195075290860045, 2.227343491912827, 0.9761559828727816, 2.0605385014304165, 1.9338906712375972, 0.7348878699302873, 2.2063688587866475, -0.9560366207530933, 0.5267044837807514, 0.4824067997409055, -0.13902126495174588, -1.9784745071778749, -1.8663606509739832, -0.5315416401959463, 0.029034680197550018, 1.2121320940737104, -1.559964962302234, 1.799441787043152},
    {-0.3282371454316069, 1.3004315321874143, -1.5450042672343174, 1.92097580837514, 2.4007100759285587, -3.1877546968836294, 1.7540873590970734, 2.5829768265250515, 0.1698675489523128, -0.9306232241007427, 0.10086491189828889, 0.8205580917839548, -0.0938579865367163, 2.4293075101218924, -2.716334832097311, 2.5393044692889415, 1.0318137101135962, 2.1778266469502374, 2.2843684415509786, 0.8658311804163549, 2.4625041935403646, -0.5960358774575175, 0.6803021547327831, 0.5481771422258235, -0.0336132108890938, -1.8883669997914467, -2.0048100844043426, -0.447220564938331, 0.20742075274369967, 0.9775270494796954, -1.8095483767904321, 1.830694762948521},
    {-0.6917570063740484, 1.0883432759774827, -1.4093929029951784, 1.6906073237376409, 2.368034100379954, -3.1392884240865295, 1.4604976104811527, 2.378504427137286, -0.19302783859039468, -1.089777776366608, -0.2501024454743541, 0.30831605298775094, -0.2465384565474964, 2.469400587638877, -2.9762388068383436, 2.2603622359361486, 0.9962971664221316, 2.2259243484184243, 2.513216081870595, 0.3912738406400717, 2.123122126169343, -0.47073039862192134, 0.46469974699450417, 0.25175551659699946, 0.12184920058484526, -1.8713733475922067, -1.8487452477683315, -0.21154051277400454, -0.27777148903618354, 1.222970602801054, -1.85469279571568, 1.8452811730227796},
    {-0.7181304093238242, 1.2396378277885804, -1.2254456507231162, 1.9359803437329814, 2.306864490486544, -2.8669758987881546, 1.3751952570129204, 2.054537304755281, -0.3271668551930085, -0.938285672957316, -0.36334312990520545, 0.550690114458345, 0.11336817817208657, 2.0715388910453227, -2.5940667671891524, 2.324231293492396, 0.6529729650901582, 2.5243989426345284, 2.082998945432476, 0.20613052350358024, 2.212662799383884, -0.5447780876382128, 0.3465344764839491, 0.3199405174178501, 0.44808859360572245, -1.4673219753834192, -1.363996028458075, -0.20877090274436425, 0.020668034097839728, 0.9445594855796278, -1.7132575437531647, 1.7940005937833219},
    {-0.5296484874666365, 1.1119665628365343, -1.8551263003834741, 1.9699348446663227, 2.2546858524809728, -3.397921196080094, 1.8207846279517415, 2.3687937475407366, -0.0857346074085673, -0.9663572077513116, 0.23614025907996972, 0.6074158283287724, -0.18604047755265804, 2.3182442340698075, -2.765514828209865, 2.2092450207566765, 1.026845871595706, 2.562350649068405, 2.2190310010616243, 0.7975217609754898, 2.219689724724503, -1.2720496521186535, 0.5864998611426941, 0.7461985094204951, 0.46036462710916404, -2.2167436844982262, -1.8667108634097311, -0.6517765591989709, 0.6278789791694465, 1.3172108902697985, -1.761359467048771, 1.9371416846901233},
    {-0.7087051931169475, 1.1605084900849754, -1.8376999892435257, 2.118202876153905, 2.5787428338262464, -3.2713574259782425, 1.8899765765025158, 2.0725811832211463, -0.4406782222909742, -1.2709049407903232, -0.1502854994502542, 0.26131434324213654, -0.08286685484309789, 1.9376950802508208, -2.544997130676802, 2.4725717990084544, 0.5621295431247453, 2.428857710436125, 2.1465610871400904, 0.17326819318145228, 2.4866686478221154, -0.9340661477380593, 0.20707706765332282, 0.3654415498022439, 0.07856184238022637, -2.238497044979961, -1.8582863565845746, -0.5355440568467411, 0.3922082590139572, 1.1824910920800884, -2.2453254207608246, 1.657117340375021},
    {-0.5507872965223434, 1.2897623146340316, -1.9823578222134046, 2.1178412318612034, 2.2808941507205662, -2.733608923740362, 1.8741985974995963, 2.136659035252274, -0.46107885335821175, -1.4635865199084106, -0.2445951096549024, 0.38482246958155536, 0.0019320465312725901, 1.988566049845827, -2.506391832758863, 2.5129836609041534, 0.6337204631748468, 2.422713933900692, 2.3716779576957316, 0.12051931899401643, 2.4093398735010023, -0.513219257904527, 0.019842876492827392, 0.5562808602337321, 0.18387918215850557, -2.0013477147180296, -1.4852924285666333, -0.2963247378565961, 0.33902181981158747, 1.3992496223410475, -1.9116539561838861, 1.7505166112146384},
    {-1.1543540049209422, 1.1576420928140896, -2.189543939029137, 1.7897787523406796, 2.2748026382266966, -3.08529817825271, 1.7978180109965531, 2.3342846425664097, -0.8910157146436753, -1.6934474550339682, -0.23077798355062779, 0.36010507621316373, 0.10728876730018055, 2.16327315820088, -3.0420407765530837, 2.2881356808434763, 0.9037198764268678, 2.4386667247598095, 2.5657330640454576, -0.0133926796672698, 2.1053952693165185, -0.1858250005282778, -0.2980972863929943, 0.023445039360869526, -0.19454818433958368, -2.254964910650981, -2.258086773808593, -0.5350456874137172, -0.16087455581030558, 0.7028786815922757, -1.9891993154587364, 1.438217786851996},
    {-1.1059739870957221, 1.5444647699037903, -2.015705602291582, 1.7664525445629164, 2.3476626661364537, -2.8339923147754913, 2.1116272451507943, 2.6101290606909924, -0.5403083393998785, -1.043834807806938, -0.25460683788796035, 0.5888893857030016, 0.09888944800740829, 2.1443142332116985, -3.0833900449738985, 2.213477989772108, 1.0893994760969479, 2.2144399863002313, 2.241526037209884, 0.29289224971070144, 2.5975839225989534, -0.2591418266289167, 0.44418534185058306, 0.671804615644276, -0.14237895357794592, -2.4206548483417074, -2.0148437080481427, -0.7028438913117697, 0.5183776403014922, 0.9505048114466798, -2.3059484500183305, 1.4376329590551218},
    {-0.6074115861263971, 1.6339767881708847, -1.092683871567698, 1.5229234680004327, 2.4753388795881412, -3.1006836919397416, 2.1338335358957465, 2.3935702308968185, -0.3809896181370626, -0.7076297573913617, 0.35957379541334616, 0.8468033158207973, 0.3154338010483951, 2.184817136348171, -2.8332436648280708, 2.280387079360559, 1.3743908660149116, 2.421984081367929, 1.9991489561530245, 0.7495717392854635, 2.5056251801945852, -0.23525130819816703, 0.7802476989238714, 0.8985504055244362, 0.21571668547367673, -2.233006481224344, -1.824589074945368, -0.44202343201742333, 0.22938735764932278, 0.6958840710788876, -2.2681945466025946, 1.4409050677703474},
    {-1.172590625214734, 1.3380810088169053, -1.8882935077040048, 1.8999755522122794, 2.4916952402739043, -3.033781936588305, 1.869494713105414, 2.6040247689448193, -0.6241212427949508, -1.6760404425926403, -0.468717152436784, 0.7311448170971581, 0.06233987182670325, 2.3295484823919383, -2.929751742395436, 2.44096683769979, 1.0214105596728889, 2.428934960085812, 2.376067004453288, 0.42137197008436555, 2.4774292947285264, -0.4507751886252206, -0.03719654414629533, 0.19016258437303626, 0.10163663808279223, -2.1651473473213856, -2.634537762496618, -0.6778711776731726, 0.25098036788696965, 0.708653182789383, -2.220883875479159, 1.760043622293102},
    {-0.712065885483798, 1.7606502450350903, -1.779122151269083, 1.9798197234562527, 2.7412333513369065, -3.229206787700937, 1.9833076213417384, 2.644552099328638, -0.45813872679224, -1.3234260119795598, 0.14193841349743308, 0.870849208981951, -0.07238256305824801, 2.1177744434352017, -2.9363396083781224, 2.6524035755599566, 1.139242693652838, 2.164037975618127, 2.2867415854233006, 0.7659296321816418, 2.7339630253664753, -0.6925435778136253, 0.10373872176719189, 0.5164774915757304, 0.054686867887026806, -2.150632150075212, -2.1747994330005476, -0.74342761126963, -0.055325597571204164, 0.733533511614863, -2.5114341021228186, 1.8728182147449903},
    {-0.8930394076803394, 1.3996854550038096, -1.8398868966363666, 1.939320145638939, 2.638322392676976, -3.0085740001775236, 2.279498895021713, 2.6259004203812073, -0.07220479002202643, -1.4131415160282434, 0.49356377716755173, 1.0951105494996423, 0.40577660841515006, 2.360211452975222, -3.1878641197838142, 2.848504984614698, 1.2970462824442806, 2.708379999016281, 2.8454120349479632, 0.8208983242723905, 2.5497690039799292, 0.16382821826646163, 0.3472227732047676, 0.9685739127090341, 0.49790188525919965, -2.002150219776144, -1.6935024029607126, -0.029202290533451906, 0.6471589454862514, 1.2115689518704673, -1.8371187135770115, 1.6350455313383327},
    {-0.5286113987299957, 1.4855928867165629, -1.7726866116059026, 1.9073561472550806, 2.6415505034398548, -3.170866774743341, 2.0551523832300918, 2.7506312760551253, -0.12099383339978256, -1.2079255876851112, 0.3647117963462917, 0.7995223174988967, 0.12856735793500926, 2.3012414778222925, -2.9342529694757684, 2.820372866774985, 1.5076404583637852, 2.3244886979964927, 2.545889933303552, 1.0586813057317939, 2.8227281909544506, -0.31395986036674084, 0.3224618493750566, 0.8753549692198127, 0.42582347951053295, -2.09519770724316, -2.1972686450300665, 0.09124442443033234, 0.5431369657545221, 1.4289844682098103, -2.016827045452186, 1.741112981847987},
    {-0.146890391181013, 1.9716872623116417, -1.489475969423807, 2.021211202487054, 2.6286129844520367, -2.772197516138065, 2.463605701699979, 3.0325276923694595, -0.012887502368890098, -0.9481652393459784, 0.5876652513399107, 1.2359202922331327, -0.04857780422376584, 2.2396622869252476, -2.6833394879495542, 2.650249086481371, 1.5943156110540504, 2.5301144077027007, 2.4913571800756573, 1.0614122124160958, 2.9460146944768733, 0.14947949889642145, 0.5765123790006262, 1.0466035114421077, 0.38876799390251904, -2.360743979934466, -1.9952387556182931, -0.16268528990383507, 0.40004495075969904, 1.1689964434138136, -2.4309501426022777, 2.1462621043867536},
    {-0.6193083306382108, 1.9356762498493683, -1.874782409039715, 2.4844713759383112, 2.7518185885076347, -2.8179880618528816, 2.7256259721763554, 3.018562521626971, -0.17238818410683204, -1.6165517630505306, -0.014416464594721777, 1.4120035429982334, -0.07092998773320881, 2.68355087569983, -3.2179183723332105, 3.1717307231744387, 1.5479286171945597, 2.6680110692703445, 3.0178094422774357, 0.7606404164923973, 3.0453397901112025, 0.18807926985063997, 0.8654107995384073, 0.6891556918885269, 0.05756323924707402, -2.6283776125219824, -2.3322546288391424, -0.2000690735777243, 0.6002256667833424, 1.2748731481047109, -2.5699767118864885, 1.9254044916098596},
    {-0.9281672850420711, 1.946713850021175, -2.148132797748982, 2.21409634655012, 2.560685908571799, -3.2229882797637113, 2.564284722028409, 3.093185134524334, -0.32522367189940754, -1.443758656926546, 0.1762186994017263, 1.4213719415738073, 0.07639785767187691, 2.462478981221932, -3.1665640940789017, 2.8843220169196724, 1.5735866290976854, 2.6047582706349317, 2.598500045603769, 0.6692786893791517, 3.2204501462310584, -0.4624821467436726, 0.9755119320004777, 1.0754701155515034, -0.18394608501077714, -2.5910211050899634, -2.7367025144227095, -0.5536101073411875, 0.803247437172086, 1.4804129472006362, -2.5488719573573255, 1.8745180219340014},
    {-0.44706145269222924, 2.1880758747420934, -2.1324585346730887, 2.494932814188488, 2.6011606444359474, -3.1481734187039936, 2.5942293286814255, 2.7689974441328498, -0.06407869935505285, -1.231203811353291, 0.18644990943679537, 1.2069864221456958, 0.27707124212736295, 2.5249206077647597, -3.038227702974699, 2.7774668375673452, 1.6445181039267407, 2.771097311993475, 2.866444628170455, 0.9782086473175559, 3.0657772419153964, -0.3132922483724754, 0.7059804576803964, 1.1321958052088352, 0.21032572181783024, -2.5797968277068457, -1.9939611051873958, -0.3154894384248173, 0.7191726562750165, 1.531349055226924, -2.486929402576196, 1.8197527318559923},
    {-0.9865911286059307, 1.6349658622502559, -2.1754511647323587, 2.148433307489152, 2.8361319990870335, -3.4814720913022508, 2.283917624143419, 2.892388228674989, -0.6644482172974168, -1.473443615009563, -0.3714067428831844, 1.1953975859389656, -0.0348394430649596, 2.41995488737624, -3.24792932776805, 2.829118732469945, 1.009603381977337, 2.6791854581395786, 2.585787623803471, 0.46514918928620935, 2.868892730184279, -0.4485340595895559, 0.49284872847166383, 0.3069469793992132, -0.13752701126589353, -2.730207652512667, -2.5595321696893176, -0.751588620258086, 0.28782745165983786, 1.2685604230129417, -2.907606213179721, 2.112590685280737},
    {-0.6329673063112708, 1.6901082585087883, -2.2541834625381894, 2.1510366130947647, 3.0576613536260475, -3.083124749545496, 2.3396629087791054, 3.0159276657110876, -0.5194870265792844, -1.3570878984965142, -0.10463526823808847, 0.9705929143766739, -0.12652563043459616, 2.475898550831877, -3.26689444907903, 2.9542495501475132, 1.4918551360536985, 2.8679555500135216, 3.09330210090113, 0.4961318047342505, 3.265454016636484, -0.031378771571024956, 0.5947047280559612, 0.7150589434792513, -0.06836887823658785, -2.6654079929164185, -2.263925952390361, -0.32579319590874206, 0.3071697034797746, 1.3064034031716862, -2.469205955553685, 2.0578192192030165},
    {-1.1257604427217793, 1.4079943410722997, -1.8689530520406061, 2.0129508450196782, 2.4748918624398972, -3.042193458030825, 2.074588639875354, 2.9590836400375515, -1.1817022796503034, -1.5163399075970305, -0.39717561345529956, 0.4545905608356098, -0.5305924204332765, 2.2166469070521346, -3.1973628078197303, 2.6275459357527775, 0.7483191608884058, 2.748976208341322, 2.6757500710905164, 0.014761049550394109, 3.043957061562962, 0.10685318956273053, 0.17994867426349329, 0.3403062683274531, -0.518701862670418, -2.469440887335243, -2.826579031451023, -0.7276653409149103, -0.0860167253516389, 0.9410193879549951, -2.849226501379527, 1.811516806740568},
    {-1.060653887665139, 1.4136132786068283, -1.8823950234710591, 2.363308223048582, 2.8793764332788494, -3.112211767554482, 2.332495319706384, 2.843671322550739, -1.2337058176015, -1.6678898209740518, -0.6467074130973564, 0.5907839083234272, -0.6136612283767794, 2.347447317280008, -3.530409170906243, 2.978446644767511, 0.9756553573227993, 2.6977980421603482, 2.702876374934852, 0.3154538682839298, 3.084519878529402, -0.0003472414763822014, 0.18284996843427134, 0.6017613103295097, -0.22372503453235573, -2.6588691532422475, -2.654415105381274, -0.6907260445748911, -0.08032405541679058, 0.9611448139046779, -2.9603442678386322, 1.8707679386741216},
    {-0.9638473956976563, 1.6913437738118273, -2.0078314048661525, 2.294826050435704, 2.8822126389275287, -3.2414897723121183, 2.54412666442384, 2.7628004372745507, -0.8688306001110008, -1.5373423376801671, -0.00015072382039040469, 1.0021041334793919, -0.5064547858151613, 2.1760091146471776, -3.186030122582286, 3.0291236185952113, 1.0615634229459248, 2.822040873026531, 2.8302703800733764, 0.3586933379826621, 2.926973809518848, -0.07389801484306502, 0.403055522678072, 0.5168371669595395, -0.07202032388363888, -2.815895042207763, -2.1983941178637627, -0.45931102059592704, 0.3648299109352247, 1.1899461827632523, -2.804651253886508, 1.8762518508136372},
    {-2.621572360751668, -1.1752692834259872, -2.139478558135467, 0.4379268900740486, 0.6860353489800698, -0.008332246688200108, -1.5944678113112438, -2.0221109800087005, -1.7304615853953773, -2.692343156552262, -1.9537925679542198, -1.9042750345690531, -0.854548595588134, 0.2999098683560463, -1.6136568135364462, 0.2325077828642818, -2.336880435150292, 0.569846602823771, 1.1669112800549368, -2.716224902244579, -1.3388888949623605, -0.5630047413758389, -2.798774470678537, -2.6250017859736787, 0.4935407387878755, -0.39037092710105076, -2.7169804265216753, -0.19903542576150401, -2.3721972037276995, 0.2329058231278744, -0.7748668034978559, -0.3868361419319563},
    {-0.9289893556073568, -1.804144008254891, -0.25447925162712287, -0.7496993995195305, 0.1293842452709048, 0.147626981185598, -1.6130036870853548, -1.0195603483781996, -1.554552967605763, -0.5995264999424557, -1.7544766753731542, -1.6337539816608515, -1.2455520899379633, -0.4572165058259252, -0.922174060974286, -0.7480021176455253, -1.1541698462566135, -0.4354829664013354, -0.17395320989711371, -1.6002753706767845, -1.396209282027244, 1.4333943117838253, -1.4713253787204523, -1.5141459088559377, -0.965618529736734, -1.790611382376368, -0.45394117063926104, -0.9812454752084914, -1.9543993234475021, -0.9220076406844802, -1.5985910597463266, -1.5345828634675889},
    {-2.535115463010095, -2.50003452726737, -0.8384648321061174, -1.9370188749108126, -1.3525357780685545, 0.45261220874777636, -2.6427717090892426, -2.433578975702272, -2.3263132072428796, -1.687997335848037, -2.2696259900220666, -2.8684855422386963, -2.038055897477392, -1.4461974414141352, -1.7373269513787533, -1.6676926482659566, -2.646348156899349, -1.4568935426921426, -0.4508794701823763, -2.7892735792668075, -2.4886974609532118, 2.120706972391143, -2.5385361158857944, -2.2879480629796505, -1.9314645450314119, -1.969951693983996, -0.9410933985015011, -1.8174789933077657, -2.352780184626214, -1.971372332891776, -1.6757313729794379, -2.2206392684353706},
    {-1.7548516472016873, -1.7849361343127654, -1.1142578118371296, -1.767671463760078, -0.9582877198004719, 0.10453324859083891, -1.749196746392371, -1.8070757697094824, -2.209790346283639, -1.6172566262140446, -2.1857082517235344, -2.2859032999067037, -1.3773900140176598, -1.2637261692501993, -1.604094687965083, -1.3683438653279514, -2.1377573065783095, -1.174042379463947, -0.5228268364930185, -2.553830911513309, -1.9817785394765195, 1.2546026822129321, -2.0222270675364395, -2.199414277780518, -1.6720378748959834, -1.4952623058032577, -1.3328299394905343, -0.938627710243574, -1.8668788378953773, -1.87222657655475, -1.855553539061813, -2.0555812787200467},
    {-1.0032115319055699, -2.125399279603115, 0.05677802968807203, -1.9080328005570784, -1.6819834019660418, -0.40637614462501503, -1.863784280701197, -1.5175516824577513, -2.329873084323165, -0.4929919339131929, -1.5671844630172689, -2.22865698332714, -2.2726522576732715, -1.867245788977274, -1.1427324656860653, -1.799233363320064, -1.539342512040185, -1.5779216707817514, -0.8791860772790663, -1.6208236230983777, -1.4981250720623787, 1.4326760821333946, -2.0997810706956086, -1.428888652250149, -2.5142752124643604, -2.149471100747689, -0.7459159248825872, -2.3584887693911267, -1.8290195335763326, -2.2638730359158927, -2.1885924871039824, -2.224332035612877},
    {-0.7921378703880784, -2.0218439151833008, 0.21402022486374372, -1.9136349955900982, -1.0779678575960974, -0.07355865119324077, -1.7804395575375729, -1.218035198321826, -1.535855480987216, -0.11363802248897961, -1.243431947737236, -1.7545718405144033, -1.986674485155079, -1.5367305128602002, -0.5891680843399961, -1.5388096967798899, -1.496156718168829, -1.6486840975680228, -0.6056432027339474, -1.3322457584000589, -1.8376280233286473, 1.4882702225330626, -1.4142735216568205, -1.0810157728216687, -1.8728249849263559, -1.9811964972437417, -0.029650506716573648, -1.5827466557725944, -1.324468407703383, -2.3690475945038716, -2.0970010030279456, -1.8655795309821375},
    {-1.0300640332874236, -1.6737436414001508, 0.03906495207388044, -1.7319435986079958, -1.6222130829553403, -1.3360133361976718, -1.5088202559859705, -1.4469488366594363, -1.8320322050682523, -0.7673265116809662, -1.4719362245595082, -2.2344770672558467, -1.8839497368347697, -1.779264646411961, -1.5207002065580362, -1.6951314193344296, -1.8806970594523376, -1.6769348269736242, -0.8296751988264346, -1.5376001249442286, -1.784892415914635, 1.1733110436027268, -2.073774750676653, -1.7015118713440476, -1.7107333462039014, -1.6438161384520662, -0.2632342059207053, -1.7333262421191085, -2.0891465606192865, -1.7363348224887103, -2.328804112870218, -1.647103606914144},
    {-0.5278449861357767, -1.2688436762820372, 0.17074324288438686, -1.2366724683551127, -0.9860326388651555, -0.5126416646721184, -1.366836048827632, -1.3960480593796425, -1.6841892328828194, -0.12729876833431097, -1.2482622351799484, -2.024345834671541, -1.57993943076737, -1.7924848053496334, -1.2773876152122272, -1.2078967820648177, -1.262027793751706, -1.4053689755374508, -1.0023818594036598, -1.1009572859937082, -1.1778669717073564, 1.6847784625996003, -1.9658305182891034, -1.071183879100925, -1.797137392701576, -1.647786684362595, 0.4242341073066578, -1.1156508136178616, -2.144082797001536, -1.3675108197035517, -1.721537720895408, -1.8544721841893783},
    {-1.1041480753196593, -1.9776880970040909, -0.190215302370455, -1.876022014091704, -1.380184098627102, -0.5695036696228106, -1.7751909644637882, -1.3949836734794134, -2.2686999092014473, -0.19332354164022947, -1.4979207875646157, -2.4839205427485878, -2.163790037288229, -1.827910206664184, -1.4113383253512592, -1.609719678973051, -1.7121270313871622, -1.4951248198253158, -1.0751646007072941, -1.569449241105278, -1.1962880585967497, 1.1934881181873065, -2.0461730339946467, -1.5991408726823997, -2.217340508120245, -1.8819408143994938, 0.03680924230995349, -1.6952504179252332, -2.376582529251516, -1.9374630722181547, -1.750566589527543, -2.1708905053249845},
    {-1.3473116880643081, -2.120416943716346, 0.32275228009502865, -2.1574066781403354, -1.9626944176378218, 0.08262748246833701, -2.071829941749559, -1.5517770514696652, -2.1508922919235065, -0.056022427031257725, -1.645079904286757, -2.5963405326313658, -2.3955734942957743, -2.023332860472726, -1.2970603972770454, -1.57623466633868, -1.9791763563646443, -1.749343549760314, -1.5496241255137106, -2.256453773758037, -1.776658572176176, 1.8108068548561889, -2.2737680983235027, -1.9010044108641915, -2.172615635528885, -1.8278762108815163, 0.1333122563713818, -2.0310654397788475, -2.1618468182821773, -1.9207594823264036, -2.1852156546490975, -2.068273630723873},
    {-1.6151110603640473, -1.658387843793791, -0.7168538619751509, -1.3109459668985366, -1.4011078036912006, -0.2436768326036249, -2.053119206453073, -2.108992394099069, -1.9052347605454227, -0.9748463092801279, -1.4927360177060576, -2.2072494079312714, -1.7767585891867144, -1.7038847178209326, -1.6157542733562509, -1.7436111648926, -2.223771285607276, -1.4208202557583012, -0.8622536000696739, -2.1975553214075507, -2.196247667221843, 0.9808949312039474, -1.8433188332084114, -2.13162887792348, -1.6234818040432624, -1.526940194010985, -0.8278109985168733, -1.3973740647695527, -1.64310210324455, -1.7714660811033154, -1.6974794321377775, -1.9075850361923412},
    {-1.6568949177244656, -2.459535557535575, -0.40833140309069493, -2.017099549225803, -1.520585437431425, -0.8117004804202239, -2.359248427497442, -2.1318493707359147, -2.400132355988963, -1.3225454418124092, -2.1265479797746325, -2.5787981873606505, -2.296414379048314, -2.101461164348706, -1.3865198477862302, -2.0388369275887426, -2.499276760416842, -1.569271572313413, -1.1785888514862346, -2.591574708696592, -2.286037971010113, 1.7793249914637352, -2.3159270927686557, -2.3249954451250696, -2.1920823217057017, -1.8745102618549723, -1.2806256410748147, -2.266289885232815, -2.610623040697136, -1.8813880439822535, -2.3131996426007815, -2.1914183525567092},
    {-1.7090437686072193, -2.0977518343683212, -0.4639060947425938, -1.9242566026374115, -1.4885237030540748, -0.9173367504973974, -2.137693465316905, -2.374264924868552, -2.3214411287800876, -0.8785616294985028, -2.385025244690181, -2.0900161657089877, -2.023799209023914, -1.625577976055191, -1.4408199137870135, -1.6279002191163379, -2.2734466193671965, -1.436381204607981, -1.3090685925830063, -2.3577055803885285, -2.2970107903905763, 1.293188550093689, -2.586920571921375, -1.9942413377010808, -2.1223885638478523, -2.2329866578003568, -0.7949378960194604, -2.0494944627971607, -2.3334411918178857, -1.9490899964118376, -1.9253609912723406, -2.148562948339071},
    {-1.627765315559466, -2.513997458746211, -0.2500749108434839, -1.6367737921895404, -1.1130585836457798, -0.4837848763843351, -2.6817665411880034, -2.575283256945237, -2.646658140469198, -1.1929284279415904, -2.699271030933279, -2.6168462890011, -2.06964301101095, -1.5908954026602948, -1.4135234326251314, -1.3468499222316914, -2.7380489352827353, -1.4625437693609773, -0.7418702233367346, -2.4593332805575145, -2.3596489487844474, 1.9307028660612817, -2.744075108853075, -2.424225782481572, -1.9881377961394533, -2.258024146470182, -0.6201341480212893, -2.281230375630542, -2.961237197453849, -2.2579859272877583, -1.885724230330287, -2.078092761309294},
    {-1.9372366457102848, -2.891254248086941, -0.3203287445420782, -1.8342139912579813, -1.227365682776305, -0.11052230581326242, -2.551794195480718, -2.0222668740866663, -2.7185987796354167, -0.9567385656394838, -2.8137078864088343, -3.003616551832318, -2.6771656659170278, -2.02921818112046, -1.986098729943724, -1.3246814280276498, -2.6359507384606107, -1.1478770161667076, -0.7775414823291684, -2.8854308653969887, -2.026244051263444, 2.2886912460747237, -3.093351726172002, -2.738474888972602, -2.153206270337209, -2.2003972455590572, -0.7621675364728607, -2.1041624675237793, -2.915378312968082, -2.488553966182724, -2.2854923230051982, -2.15045815749464},
    {-2.548407483887665, -2.641969899241269, -0.999039553841954, -1.4936763327543834, -0.7618017733777076, -0.20166146982518443, -2.411837319420954, -1.9582500598690067, -2.9945563891787326, -2.022837225344375, -2.9544456667004737, -2.905879004813409, -2.4460499453284315, -1.5882416862765925, -2.3629428653533266, -0.9036903647738874, -2.687243300997205, -0.8003336603294964, -0.34386114204500473, -2.7611472455429023, -1.711072827170296, 1.8033891869035084, -2.650028191599041, -2.5148858416450923, -2.064124473152838, -2.154074614331743, -1.4951949433711007, -2.377966036959196, -2.6861429625942956, -2.164923529790254, -2.1795982440938984, -2.0457354728039285},
    {-2.388005674241485, -2.4585080232967336, -0.8364864591618228, -1.5305058741953754, -0.5918076161751751, 0.15126070771332, -2.3044171279286725, -2.055983413864388, -2.662225902084476, -2.0089258235929535, -2.5874922117875094, -2.475392087028068, -1.8052751588245215, -1.3507235346786923, -1.921163444915577, -0.8533242977128653, -2.6955078530786314, -0.7269370357798446, 0.13092847866084736, -2.872871726135676, -2.3754630430731645, 2.424118430820455, -2.9530817868652273, -2.855018311095015, -1.5054914180394567, -1.9007104683824376, -1.4036199401436649, -1.3612476179476418, -2.929570131642499, -1.5878736862765421, -1.8307700552955732, -2.159999625403988},
    {-2.6762913217730904, -2.3743535971714502, -0.6535904002182097, -1.5507135795246285, -0.060753456909479066, 0.8201811435853417, -2.2476703640310647, -1.9562396054365496, -3.0008571791739285, -1.7018694845456341, -2.904984858287185, -2.5637986390248995, -2.0901634574763035, -0.9831705388291784, -1.6024418237224116, -0.7633844965304765, -2.8153506192884175, -0.4018414253428949, 0.45269020412769084, -2.88929739582932, -1.7095574124739272, 2.979171998982359, -2.875111251411082, -2.9279838997935257, -1.7226496423615059, -2.451691377132016, -0.8890082706041792, -1.5786337438450244, -3.0862592206171593, -1.7573224396792007, -2.258322750737224, -1.9081611442389026},
    {-2.637878831428272, -2.553003962045837, -1.3623941359383496, -1.5840372708885833, -0.35678008157091473, -0.1313790954959694, -2.5021002816694313, -2.3275275953220746, -3.0843744171877585, -2.0422453690295597, -3.258842015712619, -2.951898754632274, -2.126674852319036, -1.3800734410064524, -2.0654825069670872, -1.255584129769144, -2.787095179832382, -0.4460465390988397, 0.04663649547906401, -3.1560481646481047, -1.8996802352418543, 2.2099963580340263, -3.185133684748036, -3.005012928625206, -2.080761903855287, -2.4489499337656735, -1.607890280608848, -1.876050897684813, -2.990574472217094, -1.8604066445980045, -2.503506074889532, -2.283608566818928},
    {-2.6157709656393626, -3.0104886013759997, -1.0829733011553815, -1.9561412415779442, -0.9191827031044627, -0.594919291034483, -2.7376292087077996, -2.8432680606320995, -3.1618717823495954, -2.008642016007081, -2.8630010408248006, -3.188549994529508, -2.719173536386129, -2.0024204765870826, -2.5841343289887484, -1.6497820710260311, -3.2822509460232445, -1.2204216143148723, -0.30444359602001186, -3.304316476462861, -2.459856109887245, 1.949096774918597, -2.941903249173223, -2.9333528091677863, -2.4293945856066173, -2.4668964267398437, -1.8263849970055024, -2.2491658724764108, -2.9800312752557074, -2.680801607736557, -2.5670656056814214, -2.671238106501313},
    {-3.187388438956841, -2.986110893019969, -1.1476420599076236, -2.2812146222650376, -1.1676406662288747, -0.08619605062503406, -2.9811238603592622, -2.717226935792808, -3.1255145462383798, -2.565149875711072, -3.3406512626477443, -3.178990985590373, -2.6856814066315526, -2.0698249715578143, -2.0622938834905544, -1.5812890691163086, -3.1570815661070086, -0.9596310849624442, -0.24226132765411773, -3.484175902838999, -2.5595014996869145, 2.622313156202873, -3.234283383412843, -3.08840947434111, -2.7186970964369963, -2.7899814079145178, -1.7923391833011169, -2.6792840502883983, -3.1355948264119844, -2.4672713030602407, -2.948070640762603, -2.7942051656509665},
    {-3.3783773403920803, -2.9497910396234284, -0.9959070713023305, -1.4173154467408389, 0.7185036878000418, 1.8880694686264292, -2.9618937432805286, -2.0425294741262423, -3.6995894454304628, -2.6565611507764904, -3.495455707149181, -3.116662556767673, -2.1528126564380554, -0.39519382983591506, -2.1371177763261153, -0.2091323728337146, -3.5858025278717824, 0.4151880903316011, 1.3047880151539832, -3.9093736505811165, -1.7804598359294226, 3.6695019475337483, -3.774642098504048, -3.5830789895566, -2.0726750008281667, -2.743847812586782, -2.064990530374609, -1.8646480000901464, -3.390925890675954, -1.640803136487955, -2.2788485578977618, -2.0006001709188204},
    {-3.9117798762836036, -2.8771579518131603, -1.330339130730964, -0.7253644879086979, 1.4616669838530434, 2.196231112579397, -2.8044072279765864, -2.1875016555633087, -3.4556449096863266, -3.2319659979963524, -3.999357188792069, -3.1515688626532192, -1.79912263995961, 0.09300935382031139, -2.485524576651944, 0.5596886453498271, -3.726212044854279, 1.3773337871465152, 2.304309788180067, -4.190754988570825, -1.5812543256223237, 4.001467234345518, -3.98106017123745, -4.060809807159503, -1.4436240700826364, -2.4731091541064583, -2.73832366244332, -1.254624064320572, -3.604206753073843, -1.1451165041184983, -2.021379420449556, -1.562143733925581},
    {-4.021427704420151, -2.910046674269446, -1.8106293861336524, -1.3970415085600811, 0.36503765549003536, 1.5790850322160823, -2.734961264234403, -2.6888328470397362, -3.5899389426865187, -3.09691959352211, -3.80741902394433, -3.6106045428580096, -2.624064812515403, -0.6545711019999555, -2.6178709642736986, -0.6041943059819513, -3.749904993988134, 0.3370647081905854, 1.2044044257803508, -4.116434615672303, -2.1156095975012, 3.614362678813203, -4.0013993393144425, -3.8136983918997722, -2.317692095548079, -2.698964783363255, -2.763365009792139, -2.1145597740713566, -3.673328249758962, -2.0575357703561745, -2.635622549906747, -2.0165424819490414},
    {-3.5244041573357885, -3.0964218938926655, -1.5064087372588093, -2.0456750385312636, -0.847445919426794, 0.39983615454390387, -2.9224729967796432, -2.7000424540395547, -3.5914330055174672, -3.1100091578740954, -3.513616120283941, -3.328914659757591, -2.689160998544269, -1.434330473556123, -2.9619909024424005, -1.530596944663503, -3.5295001608708434, -0.8141758439476141, -0.07927517390630265, -3.514185234763543, -2.4771135972733416, 3.0091857049471353, -3.3697898380742615, -3.582812681891477, -2.704763477638403, -2.8614177603836306, -2.8068823526229023, -2.2882878030958707, -3.572817396173265, -2.2924802970784683, -2.811184056951684, -2.7411851131759657},
    {-4.078681500964601, -3.183037947395037, -1.6966752714484608, -1.1282723791167888, 0.806650979658194, 1.4220786067654854, -3.010623911312553, -2.17076615894862, -3.6957191527418973, -3.55111185905004, -4.057968519413758, -3.606111295558633, -2.1629683596728175, -0.6095909185332795, -3.0980314709117573, 0.14174009831311152, -3.558428305271828, 0.5229052953837761, 1.6475357010940128, -4.209691896067675, -2.0877075361839763, 3.597123842485973, -4.086599227859724, -3.9528982679067717, -2.0651035533782243, -2.617061536970183, -3.0324253238325354, -1.7644041661332914, -3.5916008470166343, -1.5701835237435837, -2.796373519530507, -1.881452112513043},
    {-3.788616837781376, -3.406526278604326, -1.5221912698703495, -1.488619018182877, 0.027537717306407344, 1.559594099360979, -3.247463578354266, -2.6184157246398594, -3.8608379655465392, -3.380092962371334, -3.938982312675759, -3.4092543082049733, -2.6717932296519002, -0.5277028226778236, -3.073392818409763, -0.3906213479285232, -3.606593286783453, 0.08187724269178034, 1.289196963480519, -4.079516721587692, -2.330384959096101, 3.469606724624847, -4.063313155064023, -3.9159046259225776, -2.369397281298305, -2.790412179228328, -2.533446734316751, -2.1995550493968468, -3.904005512533002, -2.083557849530955, -2.7860894271729832, -2.208844849565305},
    {-3.9439709725609884, -3.272316354307599, -1.8362546437627099, -1.3375886449162013, 0.009856922481948298, 1.4924832785313504, -3.273938764843062, -2.7194594491482986, -3.806245237122623, -3.0844698964860777, -3.858415257903798, -3.5977027969935977, -2.8463226109014754, -0.8450510337139993, -2.827326496428486, -0.6363154661104609, -3.7519179769174373, 0.2823780288511622, 0.6870971498753325, -4.003780159875966, -2.4146523169426337, 3.24376578725323, -4.110879104071081, -3.906901737016875, -2.3722811000188515, -2.5958039451824972, -2.8915113577624982, -2.3281797471808945, -3.757266785525161, -2.1977336364985733, -2.735833964117245, -2.133139465533123},
    {-4.013640172519026, -3.138701656411177, -1.9347610240721473, -1.040503406469055, 0.6503329234566845, 1.0658188351728513, -2.7317648964312737, -2.6280130785073115, -3.5844402155629864, -3.361558057457263, -3.9082859373577894, -3.5975077579363166, -2.388984484979739, -0.344308505619999, -3.0348741551616736, -0.35993268317191823, -3.962903825942433, 0.50296901071307, 1.5254053183537746, -3.9658243214807776, -2.1862088431593825, 3.6716129118366876, -4.063036436735776, -4.051664660069719, -2.160894241266485, -2.7673388218000663, -2.6861508617810474, -2.1478115408857574, -3.803737003154746, -1.7474806130655411, -2.684345174736684, -1.9096593912119704},
    {-4.178103081601902, -3.002350283758599, -1.9991141072941097, -0.6866405353645512, 0.9837352038325631, 1.7807334706103097, -2.82893121449863, -2.3984696796729073, -3.705388767575685, -3.631422675853613, -3.9981551584390593, -3.3422201243395913, -2.041493851405541, -0.04519070487373967, -2.8971745413475074, 0.1497751472594947, -3.906221843060702, 1.0653236877699264, 1.8128740955301572, -4.14558082943254, -1.759063773654226, 3.622987498688545, -4.154870190957329, -4.165286149388585, -1.5491402877723968, -2.0235897425778275, -2.960026926947956, -1.4084155503461167, -3.5967775498806787, -1.2365312774185402, -2.199688195744052, -1.4355452770880917}
};

static const float b1[32] = {4.800495903370425, 4.6383486636560916, 4.819822439820081, 4.770810686059553, 4.864935578476362, 5.078816895983101, 4.684251022500359, 4.835144038171734, 4.7342764366725545, 4.819642921353192, 4.603778742941509, 4.84354778343048, 4.743965119979796, 4.813703345563329, 4.937354729706971, 4.67375281722835, 4.767296964343177, 4.812341225688507, 4.770603510494439, 4.842768121605029, 4.787756080369014, 4.977856786811229, 4.765925086363779, 4.643050978502413, 4.698186138982634, 4.7997074980330865, 4.994146036787286, 4.7191633785942555, 4.616794577837315, 4.744414470250963, 4.847533107291106, 4.626712286706358};

static const float w2[32][16] = {
    {4.24454526931892, 4.159597112207822, 3.1671090707098934, 3.995701482840147, 4.226098253950209, 4.074798500215956, 4.449878595782604, 4.358631970274859, 4.422201521380883, 4.5841036666719335, 4.4607013403710285, 4.27791382617236, 3.780280955859405, 4.198951953322274, 4.4515104645271855, 3.577724802710556},
    {3.901096369913553, 3.3084707208639568, 3.265440256367307, 4.014104000338793, 3.7186858364485116, 3.9064952691027, 3.9545297873192786, 3.8938373627443363, 3.8874944675205128, 4.4148202417768045, 3.8687137888110703, 4.0009492784593705, 3.703515332127556, 3.7264911844097415, 4.23471744846632, 3.6388062353641315},
    {4.374502763344862, 4.051901004006118, 3.613231702246501, 4.5890422592008555, 4.268039443325692, 4.0833982390333246, 4.322294837809852, 4.342769859260304, 4.241909386903654, 4.238048889390757, 4.688729905858363, 4.531719082151509, 3.922310422855436, 4.615951873783828, 4.733492162854062, 3.6325757436337294},
    {3.667542852486328, 3.7639173498295273, 3.3648065613120086, 3.978557885770785, 3.5333739622108293, 4.004003845812134, 4.043189998081634, 3.907768088486401, 4.056661421349619, 3.7076355191844543, 4.036405310976478, 4.321054594963101, 3.8145398282329475, 3.8115821140076696, 3.999603002635909, 3.6749171503904265},
    {4.400470528544249, 3.472993214700314, 3.263628565729099, 4.031257049382343, 3.8395631265687165, 3.6214526585006945, 3.7775346178651628, 3.7941595528842926, 4.319412732998517, 4.299363131738027, 4.211179988853781, 4.304589226113751, 3.530747374993443, 4.269520639351195, 4.3792055241776975, 3.8362479581643707},
    {4.950577332743869, 3.6344476853647323, 3.402935679545864, 4.685768972021295, 4.710898388373112, 4.595815245865251, 3.9753849150945086, 4.817816692989303, 4.456249341591341, 4.198848817646345, 4.681027715208762, 4.28113283811505, 4.4583685063222, 4.488233215154104, 4.550793898136082, 4.200066610905814},
    {4.0771617748020645, 3.530848638205272, 3.5009878427684287, 3.8481953593139755, 4.066222241609199, 4.020779582357207, 4.248524904119399, 3.7531343874520586, 4.207904613239453, 4.285835460201864, 4.144581382753475, 4.362440646680728, 3.950312009992602, 3.7797280630062633, 4.314519818717739, 3.8682494331562833},
    {4.298754859376372, 3.551519543494439, 3.0834127386855217, 3.851966742885122, 4.232064991223601, 4.360853947548358, 4.06950862182376, 3.945816139891818, 4.302422441724287, 3.928317484827724, 4.388897564316258, 4.414610122196012, 4.1636544003680696, 4.084804692735284, 4.310139387799361, 3.620960925688105},
    {4.518095854121871, 3.967472551361574, 3.2996735345757284, 3.9048547317350453, 3.955068070947537, 4.319847146131918, 3.8726019985742406, 3.9199692968409923, 4.278543206550245, 4.079756209250865, 4.394515457390181, 4.10813600688712, 3.9483853029850278, 4.374993324088417, 4.128722634739609, 3.653322717493557},
    {4.2239274978339365, 3.9896789158972314, 3.771354221251666, 4.3652581020747245, 4.38354727656716, 4.317937280693244, 4.521929182788987, 4.2940388838463175, 4.501840483381764, 4.1616016322830935, 4.194862872151374, 4.740346919692056, 4.009397031997062, 4.625006472540303, 4.571975551900374, 3.468993135436002},
    {4.507897608828463, 3.649148376190839, 3.6181049497254896, 4.536148025210443, 4.106755572281967, 4.343570946501411, 4.145324609808922, 4.150792975878365, 4.540554718705094, 4.114950243669773, 4.545699910358016, 4.204079141466899, 3.9137500319163383, 4.385845928083992, 4.205526036246589, 3.7400686288970566},
    {3.692700259717653, 3.9104572075809285, 3.0409319349173196, 3.9251371886217528, 3.5689256104754157, 3.638828839102411, 4.121898209587761, 4.208027820355164, 4.014136180847665, 3.9475960570965425, 3.698008384986971, 4.215698885723946, 3.391725722522898, 3.8430285860079656, 3.726189584577196, 3.8613356957154066},
    {4.0507480988711695, 3.624976769319434, 2.8593674828668347, 3.5539272848078594, 4.169905694273456, 3.492879491737011, 4.108805265488673, 4.230155475838056, 3.5758626606434962, 4.281539899856414, 3.8299942677997945, 3.958879099224167, 3.4866202961340917, 4.257479590494399, 4.2065069670355175, 3.8376927479414515},
    {4.21481891807103, 3.6309904178111316, 3.1556774054763195, 4.260683924748179, 4.146259627939873, 3.9925291982375013, 3.6567256719293924, 3.9520891188874994, 4.106195396323266, 4.234136455033313, 4.071317019370553, 4.15647536183019, 3.578468570080844, 3.863060612114466, 3.7941225471532745, 3.530721969988053},
    {4.7224594128732145, 3.645184591601138, 3.632676693037638, 4.40912860828861, 4.4797707526436925, 4.124141633742112, 4.395790134717707, 4.845602726672695, 4.285029749800451, 4.243576228847409, 4.82476165988103, 4.27473816042956, 4.1343749105697425, 4.632191796950333, 4.924708175098337, 4.254570531247868},
    {4.282504949227207, 3.975622293194928, 3.437274841080561, 4.10862470070166, 4.195957007288382, 4.165701090743615, 3.9215684720663893, 3.948945986137586, 3.8757514167660094, 4.43631249318203, 4.1162364680003645, 3.889159105857328, 3.453164740218691, 4.152749733905669, 4.424022918315566, 3.483890599410109},
    {4.516501570586733, 3.7192989647055916, 3.44201882296724, 4.3550140550245, 4.389668026916367, 3.828572707181741, 4.105641091511637, 4.316097279520443, 4.426158232777138, 3.8219867208915574, 4.274725942461331, 4.27662773886784, 3.619248570126757, 3.9339556567656135, 4.5173468842981155, 3.6630305077954746},
    {4.349888639376578, 3.951047498006853, 3.043823375090462, 4.413179780245083, 3.7366816374036977, 3.6860761478442394, 4.217134515584836, 4.417035724281697, 3.731109438251672, 4.195294632077309, 4.259560309203216, 4.169934076730774, 3.887180800000325, 4.447816313338865, 4.154728702807736, 3.6706130328691238},
    {4.104603382622688, 3.8440661584590465, 3.091195616625711, 4.5351260984862725, 4.0515993001343515, 4.283872005956369, 4.351776552766589, 4.590077793594786, 4.129256968634213, 4.104555352305783, 4.185802609953195, 4.115573623379048, 3.8151759344215357, 4.033823199627119, 4.444138350517133, 4.103427535353364},
    {4.054654297329803, 3.883046142284719, 3.426856628593874, 4.094932332192854, 3.813592308217358, 4.036070569184363, 3.9690307519859593, 4.2359057197704075, 4.134895485211514, 4.464678639371808, 4.28706550979307, 4.3549064817348295, 4.102548489649235, 4.021222510945851, 4.487313699609321, 3.950544092016969},
    {3.8599580968886027, 3.339293254557658, 3.3928881922983685, 4.248912354134394, 4.231320512635579, 4.055758706809365, 3.6657915821118734, 4.0015344566887165, 4.351807853462338, 4.047469837878301, 4.2741822651451296, 4.064704915624779, 3.4385171032465274, 3.923816033978033, 3.849741774614176, 3.9657367826208914},
    {4.063755269363768, 3.591841591499707, 3.1242726830548415, 3.874279722773406, 4.178148164180107, 3.6761752794736715, 3.6934827549687754, 3.9766788167325955, 3.9066306433458697, 4.095704120755905, 3.8996597259940713, 4.3633854903443705, 4.243216957995698, 4.205879016328276, 4.276859214018911, 3.423200799264728},
    {3.834563926705317, 3.4625346192649125, 3.0707023716596216, 4.064931120521059, 4.071122142375977, 3.826079553909652, 3.92301057078752, 4.184477704119906, 4.105168014889399, 4.366397193847331, 4.0526569424939805, 4.447443672670559, 3.865024549251399, 4.353675227209072, 4.403430882446284, 3.846048430924264},
    {4.165902967449872, 3.5976319761170106, 3.0498331519182167, 4.08127137389799, 4.562291485460427, 4.056167064835286, 4.542889808003561, 4.098719413202733, 4.692375047818219, 4.635384430455961, 4.18593592262326, 4.122532916889275, 4.16454180570697, 4.515958559086357, 4.036634740622448, 4.110320861689558},
    {4.18016378033878, 3.2914789180567556, 3.4245695375080767, 3.839437709838746, 4.1470407722952976, 4.080504964650131, 3.7043006469279027, 4.256684279286178, 4.01217989104937, 4.183483167733982, 3.967698252079438, 3.7042435086898995, 3.9171618406595186, 3.76964951747966, 3.9277468720957756, 3.4868368597638875},
    {4.338591851627481, 3.4686603692631257, 3.6038701113559277, 4.48173454242497, 4.438022502963907, 3.8662837882008088, 4.125666989433959, 3.9981707100535093, 4.281657577856329, 4.224437807488122, 4.372151514442405, 4.4148466197593, 3.920594570779825, 4.383577480426748, 3.956179864886281, 3.982206923791371},
    {4.585169003486688, 3.692027654201548, 3.3670661482333832, 4.097924413053171, 4.636782907299571, 4.470507560468002, 3.856912555335748, 4.5982146827418715, 4.167169419141723, 4.1256529598467955, 4.39333923703066, 4.612908889862819, 4.07433506373603, 4.417040519122911, 4.525134257646148, 3.6458234960197236},
    {4.16380913757133, 3.60504782105088, 3.47103277009719, 4.022176550197481, 4.087378122823071, 3.6026121319022097, 4.202027972644456, 4.12449675156904, 4.161924833234682, 4.1866324571345235, 3.8160338043680486, 4.21345198146118, 3.9952430012468674, 4.323090750673463, 4.135862817726019, 3.6290654762764283},
    {4.523011842054237, 3.4133103470712634, 3.6479717117505657, 4.211633112765026, 4.287320165844144, 4.1047975753484405, 4.354980855056924, 4.321272907378327, 4.075670255523518, 4.185386284334097, 4.134263717039723, 4.040062664353192, 4.114027355926808, 4.199270853872389, 4.097351335960967, 3.6507275393490493},
    {4.189452727941465, 3.637521225773568, 2.7468364769515863, 3.607538548884922, 4.091008325919161, 3.6619243830099895, 3.4651015460320598, 4.092640236967514, 3.891548624626163, 3.916114833123386, 3.830158368901818, 4.138902920056196, 3.8968664330148886, 3.8561567214585186, 4.318791030621158, 3.6433343991282126},
    {4.1531468007601715, 3.5780456875422226, 3.6948314263109028, 4.382097687727034, 4.220375945316639, 3.7368915718268103, 4.378385736336186, 4.072245043843037, 4.100407562395632, 4.0044801155444025, 4.525729823054267, 4.542731807052106, 3.999903475211668, 3.9812566885671377, 4.170744535047078, 3.814049723573348},
    {3.8196261720247064, 3.606829805014756, 3.0589743295877456, 4.1922674859965205, 3.949567587251245, 3.5474947136455803, 4.0468735436838115, 4.199180369998329, 4.000320820199158, 4.2795392144751805, 3.690435910211365, 4.025829144035434, 3.7394305464717497, 4.205503550295447, 3.9346833101161804, 3.4410635866726844}
};

static const float b2[16] = {3.9232613964076695, 3.851516560537264, 3.7151958324600125, 3.8126314380154556, 3.7894385219589313, 3.9560556091778336, 3.824322170894219, 3.7183316447252097, 3.7527405585499394, 3.7630375132783622, 3.8246233974468447, 3.614375282451977, 4.057957086015448, 3.861374190983937, 3.8961725751939262, 4.158781212245383};

static const float w3[16][12] = {
    {-2.6208450449223433, -2.571513578894482, -2.559965098160541, -2.485705068892293, -3.3969791121710804, -2.734260052190935, -3.3824621014320995, -3.2235083994653384, -3.126583540726122, -3.163362545745097, -2.918322308130015, -3.431506087687194},
    {-3.0168914514254856, -2.0323002048895797, -2.81901610977601, -2.6913490805094904, -2.8326946480907673, -2.7512369207195566, -2.528871863455963, -2.8219414611978175, -3.347570311088077, -2.9451215478979234, -2.4366635079468915, -2.4389614465676033},
    {-2.456916032300454, -1.8951547031050135, -2.738916678662369, -2.320645502894594, -2.207344901098418, -2.1268208347262516, -2.073656062765484, -2.5142647887570533, -2.528342550484162, -1.6774839726491841, -1.7850623077458505, -2.3401996334460753},
    {-3.248507536322588, -3.2129129410165067, -3.301845014696667, -3.01865860996609, -2.881588514357347, -2.7629030433441577, -2.9914887208007492, -3.0947338963692963, -2.495164001579138, -2.5620646501101105, -2.526084199584509, -2.554530716054239},
    {-2.580356657750151, -2.7436091185220706, -2.845242822413553, -2.7642878318785242, -2.8222163928734836, -3.317922397347983, -2.628216883323061, -2.8271092250695453, -2.9043607911599074, -2.9730684606844355, -3.1960421680619135, -3.2915560725168564},
    {-3.4336725106167543, -3.423607559281113, -3.04230308721587, -2.9915573764015786, -2.6333702127364993, -2.8003400499626543, -2.894508908776656, -2.6993769088443718, -2.403943320300415, -3.370568374893736, -2.604495512890107, -2.997714310862233},
    {-2.7202985837914335, -3.406346343269005, -2.7136857358431317, -2.266212674750557, -2.496847290575177, -2.8937992550081506, -2.6412595430239882, -2.4191479700394787, -3.058209145001348, -3.127044687811493, -3.2364361375734303, -2.43604224358393},
    {-3.104497848300165, -2.9743581529765164, -2.914485710497219, -3.1979221717637905, -2.8316471814563045, -3.0768204364805127, -2.8295465927109316, -3.351092117997839, -3.243517007832681, -2.7196622776636326, -2.740912329507866, -3.2862414154885142},
    {-3.1315964785942123, -2.5915005089890037, -2.9645048180612124, -2.8645954548467016, -2.5900697076545973, -3.1897923162416646, -2.875902122369513, -2.690261847507918, -3.4083012518619413, -2.6066719127674918, -2.7957460590351872, -3.0660744096607693},
    {-2.5550281926832423, -3.3381858439729313, -2.7117666091615598, -3.0418859225096577, -2.982608239115922, -3.04843135336863, -2.6136846689850723, -3.080356090675373, -2.637432280263493, -2.9084782294806093, -3.2846151187052057, -3.2732064647637946},
    {-3.191221877749998, -3.2545189839922712, -2.677429710144813, -3.382737189604078, -3.210095498653067, -2.596350974368822, -3.4814252890861037, -2.506396230010008, -2.8355904102539973, -3.354506144139247, -2.7927973348516812, -2.814338060899008},
    {-3.002783582577517, -2.8391838534819764, -2.991631716766919, -2.6332909288752493, -3.355324609913267, -3.067592247680241, -3.0341328560125085, -3.294481989840965, -2.852140170414081, -3.284623202557665, -3.3654429858306103, -2.6251318083184234},
    {-2.7880064396986364, -3.101354320340302, -2.7036224835392795, -2.625976441690155, -2.5165636476610924, -2.9597836301906044, -2.676739054292216, -2.8846468554836697, -2.3484128437146827, -2.971207932239017, -2.8986360739969945, -2.622693745826462},
    {-2.505836301428657, -2.820916123292903, -3.2295108719559957, -3.253930200950154, -3.247250450668932, -2.8656396957355126, -3.290678580920219, -2.9931736823042967, -2.7195901938839047, -2.607211780325423, -3.42117211466705, -2.782157573885444},
    {-2.8560688462333985, -2.9205027995879487, -2.9635026837372194, -3.3617343135234177, -2.6852519602257643, -2.7540271958952087, -3.182537152637628, -2.869763302913422, -2.7083375783686936, -2.569274981865315, -3.267958781629611, -3.1639202081943836},
    {-2.655654432722596, -2.464411010867185, -2.577337048015717, -2.6058472778406157, -2.96810064550124, -2.7515259246416535, -2.409959167709406, -2.4035117251946514, -3.1926201269600774, -2.9284853497344945, -2.1905556325121647, -2.4437342684067422}
};

static const float b3[12] = {-1.712285773418945, -1.5760906940828399, -1.5816977315819285, -1.4992489052751183, -1.3284229842765884, -1.1786307002967815, -1.2708989579428924, -1.5530230374108294, -1.098165219829208, -1.7356702872827579, -1.3039414074075226, -1.6597981637731931};

    // Input Layer 
    float z1[32];
    for (int i = 0; i < 32; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[16];
    for (int i = 0; i < 16; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 32; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Output Layer
    float z3[12];
    for (int k = 0; k < 12; k++)
    {
        z3[k] = b3[k];
        for (int j = 0; j < 16; j++)
        {
            z3[k] += z2[j] * w3[j][k];
        }
    }
    softmax(z3, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
