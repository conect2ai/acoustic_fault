#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][32] = {
    {5.668838593039756, 4.1093623722716845, 1.054016334726584, 1.1004228904680107, 3.1156329044540225, -1.2467456971953912, 0.7721436221673961, 0.9297735996491462, 0.5092154040305737, 1.000989002059976, 0.6174225775029214, 1.1349064171993661, 2.6229523322931376, 0.5972394660498476, 3.728870821985219, 2.917184591788521, -0.21339475899811766, 2.183175791307552, -0.24937570276611595, 2.1551657783310394, 2.7235663161174433, 3.9139593292258867, 1.3149723095879076, 0.626999966120557, -0.37743360659321334, 0.6991272042304749, 3.394978433291501, -0.08850036704240104, 1.7349781480498394, 2.8160938191877096, -0.29633540383027934, -0.25871376223842674},
    {1.2970634721621424, 2.3893715403372484, 1.3799783240282857, 1.194937770406615, 1.0830284953993947, -1.2965379513459103, -0.12243391911650335, 0.2683309557752784, 1.7088260465730225, -0.03884970213925515, -1.5603974856562426, -1.0527201810146338, 1.979811294102287, 1.5348029571796695, 1.5176020978756897, -1.7600024892509836, -1.901833133805716, 1.515078103495782, -2.3638030386833613, 1.7114024842894962, 0.056577660612502606, 3.190143784966255, 1.6133379791868923, 0.6196971960815469, -0.5529233394353098, 2.5412981215253243, 3.2951022631319864, 1.1060788259997676, 0.8461484082676595, 0.7930736120191629, 1.8488228456979687, 0.19068328297518236},
    {2.92709396333941, 2.4528062285825194, 0.7824040616293373, 0.09166822125712915, 0.531498678715125, -2.232146690810495, -1.9784985630591019, 1.220574290959065, 2.1741041258700506, 1.038325712999249, -1.9468107773801655, -2.696985369350421, 2.40916498460151, 1.0409477088253958, 4.791287767224498, 0.880267559926398, -1.5349683716096216, 2.1516143286886176, -2.160592166204203, 1.9600108299681138, -0.10006276834217222, 3.751365475090659, 1.6247694088772715, -0.6242605331597216, 1.5248022676450772, -0.03072050544988845, 3.5040070806193317, -0.7857339574065378, -0.6289751462575524, 2.6293971316549647, -0.3962788626559606, -1.056711903369197},
    {1.495541136572791, 2.355194699280339, 0.3099618924063553, -1.8241496136097735, -0.5969028723370557, -4.430958050633536, -1.8680020422878862, 1.0191935333142852, 1.0366665519431486, -0.43342706444498363, -1.6176288255078708, -1.4583934294406842, 0.7325053857747515, -0.6089704972731499, 4.344761247931899, -0.827045755192187, -1.2086805707832473, 3.106653580307829, -1.9777432007914177, 1.176337047739324, 1.8733610747812803, 1.0010629353943454, 0.07398769257205655, -1.8602819003676039, -3.663513658195658, -4.074745505455309, 3.7330778389286685, -5.188023895526197, -2.2698341510607936, -0.31759524167297426, 0.11700620975432516, -3.149150489246087},
    {2.0846771335488, 3.4831424332606766, 0.723674077024372, -1.9167913398239946, 1.971509440336389, -3.6509116400699146, -3.304740928365993, 0.8608659990850965, 0.8298656317268444, -0.321740555597213, -2.1402246187299983, -2.5196248844273836, 1.5330456669758035, -4.388259067335325, 2.2126286236049886, -0.6293151768248916, -2.2151144787401833, 1.7080318082340917, -4.318409657810785, -0.5152189879591541, -1.3279024714771366, 2.115724625330195, 0.4766097361479408, -1.1043912491575452, -2.134200581940958, -3.3005609172404218, 3.721946755807035, -2.774682381208269, -4.160078768637154, 0.3555522927260058, -2.140219196383094, -4.413617042559452},
    {-0.167241583054854, 1.2926895190923113, -2.2561825902193418, -3.153381585493444, -1.0774733101061622, -5.791102074061473, -4.129080548518177, 3.191376511669128, 2.6761125241732566, 1.2474736115038205, -2.151816104373378, -1.2814187649377569, 2.461766826194438, -1.9684834467435421, 2.67054562622217, -1.1914255484351484, -1.7840664982224244, 0.41818850142464986, -5.285574473299804, -0.5598150424464681, 1.4208032640052959, 0.9080737254213588, 0.9617878272140062, -0.363469575992532, -1.8191798756296576, -3.590175488012079, 3.1679621092979082, -2.040500238007189, -3.019113381366312, 0.9114748996341032, 0.27749013271006306, -3.361246208609624},
    {1.6511675473094083, 1.0162088345264944, -1.874649216556556, -2.888569015127992, 1.464132298003074, -3.279051804951063, -2.6906622966526483, 0.39943382170008446, 0.8510907741776621, -0.6902737612486944, -4.010905037524137, -2.086578152191925, -2.7991519434154117, -1.9584431479609339, 0.5107555868940339, 0.003247828644566916, -3.689559270379291, -2.161520461617881, -4.333605229353381, 0.8625074291319328, -1.8823682648506534, 0.8003042981601872, 1.8572151801672852, 0.5512996390251688, -2.581078343091121, -3.3274474535228507, 1.2407657747226666, -0.9121014916184285, -3.556932023894672, 0.6669088614067822, -0.9178798256651667, -2.8049821091574962},
    {0.43718550150748603, 0.287772607867253, -0.9648727642085665, -4.02446744843063, -2.171361077440027, -3.980788490248341, -4.911202116509854, -0.32582890121876235, -0.02890477681771783, 0.27200335422013605, -2.793667628045777, -3.0979429314081384, -2.179211066874153, -2.488486769841026, 2.395699357298072, -1.3315440250109443, -3.9323107052896975, -2.083704194439745, -2.1320441262222998, -2.1405180005081577, -1.101024527358634, 3.2047716200508836, -0.9914479851754491, -2.028448929934975, -2.6186699958692503, -3.8491995445796383, 3.335553305738891, -1.4986595500810698, -3.4207158600762306, -2.2226727913083706, -1.004330232526163, -5.637843392848748},
    {0.6572763462238675, 3.6401091503186906, 0.08231885606784933, -2.1150257975943383, -0.8184158414912844, -2.9603255859700175, -5.473346738793581, -0.43807940448144334, 1.2593495995940795, -2.115880886994588, -1.9846071093740818, -3.137437297619776, -2.5185832755565363, -4.717138934252709, 2.099232391857466, -0.9589545323384392, -5.586036731132482, 1.847758362377303, -4.46445030515366, -2.4023818388813547, 0.8558086607872254, 2.025742485445417, -0.391167197615174, -1.208727353523861, -2.8561195488351907, -2.8647639037576944, 0.9513398150047391, -1.1878730578650485, -3.1199426897644567, -0.6066542947540229, -2.0102778164945208, -4.095499015932822},
    {2.6249244040901787, 1.8879348774956384, -1.9970467240972993, -3.8261619517352443, 1.0885556406338381, -4.818276902329508, -3.3392311561843147, -1.503078459201953, 3.0318534599360962, -0.07811534824761474, -2.72132673246043, -0.03771910907038152, -0.687460167295397, -1.9705115382892673, 2.056924187622594, -1.3854026201059084, -4.496497643485746, 1.051111529016348, -2.9622450240988982, -0.8317434630226148, 1.1513264004101675, 1.7508142534655748, -0.34791448472283587, -1.4553920417643402, -3.752417724841697, -3.072248968276875, 3.1663311625240067, -2.2301856263589794, -3.3555439801747253, -0.9028047019411614, -1.5905132521488126, -4.311915896505006},
    {-1.794813172452583, 1.977970900478843, 1.0880663520644138, -4.020857750880752, -2.2410413364196633, -4.170052068445138, -3.27812856733607, 0.7966186473164951, -1.4941451342391732, 1.6970399602039508, -3.948437520922512, -3.616091144809402, -1.319143423585023, -1.7710427996262361, 0.9289374115650343, -1.2012238763579135, -2.789806175265565, -0.6428427885707069, -4.62106835263731, -0.7264580001054645, 0.06006355529191085, 3.210381115826626, -2.7755979488471842, 0.9796784837126957, -2.0403417393016423, -2.4090166185435233, -0.12033541271363697, -0.1912641439910643, -0.7502723109610484, -1.4035044123337268, -2.215111486243054, -2.1863569514217565},
    {-0.15199706682376066, 0.330714847590679, -1.1662058274899834, -3.308451040452418, -0.33885390649389907, -3.306150196659662, -4.1650324162657695, -0.291351217547304, 0.2295161236853795, -0.43515682705022435, -3.113700519629095, -3.348370694879163, -2.319420720048347, -3.2270494876537126, -0.029374070311001633, -1.4713650990859464, -4.647637502326188, -1.9388924121218452, -3.9063534856717883, -0.09081570465269594, 0.9343601018895706, 2.3925470147562957, -0.9125866715088197, -2.203906492925715, -1.7692177977365433, -1.3049321912716227, 1.6255742538447548, -2.9854821684664983, -2.924749058874777, -0.5612657035437044, -1.9424881698767884, -3.5311976869038006},
    {-1.5721841907005605, -0.16131175620025132, -0.4870542436070236, -3.7421926378422627, -1.7371038866498236, -3.9277482640461194, -2.078329549881971, -0.9249676702847108, -0.8851882303923629, -0.14166963618225, -1.7044251280737033, -2.827348334733162, -3.3602425928027415, -2.9483860753257987, 1.6146646932382274, -0.12208086683414174, -4.257827380754075, -1.7517479938348959, -4.064451162773762, -0.8906446418695616, -0.013191405004631656, 1.7564187593366702, 0.2150782258976804, -0.7413031118734709, -2.2196928535173304, -2.620144120119404, 1.657152121635035, -2.261024725895855, -3.679688681791389, -0.7840388765250003, -1.2274574258923676, -3.691288993940781},
    {-1.1588700154873113, 1.7961659997195498, -2.508353149438902, -2.5990544414930317, -1.0404573219214, -4.928433755904617, -3.675540524483714, -0.024520122923259502, 0.5698230699548447, 0.42356786888811737, -2.7651607444705895, -5.274929895805325, -2.606493416755294, -5.285697500973914, 1.6311580971907407, -1.77668352639201, -3.6839377689980846, -2.1405075214996714, -1.539551125390402, 0.4897336414852018, 1.0262237713445395, 2.671319360177846, -0.9911051328508911, -1.8896634206925234, -3.0332245651745176, -1.615084981392856, 1.9610806402624763, -2.5257302557713044, -3.5834756082300436, -2.1748251882630645, -1.3825614385700848, -4.553153111400595},
    {1.2378130513959826, -0.24388733690632597, -0.8095818521757406, -3.39674021503009, 0.8912891519378722, -3.455887547924985, -3.0862015187791223, -0.864989742966265, 1.811660847775557, -1.2391264399620123, -3.1663276370179, -2.0946964428507058, -2.067848733215718, -2.019036977807905, 2.43797197923683, -2.7994918892540896, -4.852380841849433, -1.1803970561264052, -2.4273602335461635, 1.9209253677715223, -0.41461574655282646, 2.308640053043184, -0.5428359312791086, -0.44567768678859027, -3.3438651961421773, -4.164708015413297, 0.46486713495761184, -1.7641761764523731, -1.3406201791135097, -0.6509113864174287, -1.2335986357803104, -5.198886767777938},
    {1.2296851861075442, 2.152241966844088, -0.13187539451261793, -1.8726498347512797, 2.0371936712720204, -3.2567855082333272, -2.9281329891409382, 0.07157999112735265, 1.9132207040430322, -0.3086280836008195, -1.384216422096517, -2.767751985974083, 1.1377919306451887, -0.39634489290944813, 3.0640450410272115, 0.15884399297167257, -5.059509114915947, -1.031631831711705, -3.038896316900232, 0.7647709502930811, -0.05220488414551912, 0.5941048908502625, -1.8809429816549865, 0.10022686834555554, -0.12199132295186568, -3.782689807931661, 1.3503553849828993, -3.052449842809318, -1.3326957772549888, 0.4338343369741235, 0.08310876934500207, -4.3044932248930845},
    {1.0892250205831724, 3.7244808259937594, 0.4150992384497244, -4.666777441888292, 0.5440072940299651, -3.7230463258640536, -2.9182024701955163, -0.07098148774201817, 1.6568433399394669, -0.046028763009172545, -1.4261660946101131, -0.9803951452630093, -1.259685768182629, -2.0624290190344143, 2.7607906605028587, -1.0326691141254745, -4.438546454753993, 0.4423131625426207, -3.372585506782089, -1.2582157480195206, 1.1725749591526415, 3.6086400701725023, 0.33019492392892613, -0.568461349190384, -2.1069258082174063, -1.3219345849018893, 3.136235139137303, -3.353762986290278, -1.4745386613759972, 1.593509340632443, 1.1235428821055315, -4.465702902232321},
    {3.186437065524469, 4.177457734381717, -2.087547738188473, -1.872449722620656, -0.9493981233557645, -3.1045382776741195, -1.1581472308458938, 0.6767943331553246, 0.6555089179957662, -0.5085246737492197, -0.04692866325969601, -1.3762971508775057, -1.659350248067161, -1.8404382779925266, 3.5992119897452213, -0.42203380133608737, -1.5081213285567043, 0.9806279536728925, -2.9084329752353546, 1.1909093311910397, 1.9538200451949004, 3.871843318296381, 0.7397665678190624, 0.23796803798339194, -0.5581554178738214, -1.7546251328789038, 5.660353588811055, -0.734705186269652, -0.33509502857776524, 1.141821733824407, 2.0698344557518182, -3.6836485192535866},
    {0.6017450670032205, 3.5412405323677016, -1.9861987985680216, -2.8452673097509233, 0.7471424280931179, -2.3032852022627632, -3.4288872683550577, 1.4776592795626244, 0.8859129077627494, -0.3058873404604082, -2.5535654327531296, -3.2109747556689134, 0.4030546982044731, -2.483145250020929, 2.636254267904628, -0.5924808369268176, -3.175848694068036, 1.2386966254265492, -2.613607485490196, -0.9286652855233641, -0.76153679148732, 2.9938683543428244, 1.6418796667140618, -2.5889946964919517, 0.2630881132844356, -1.979795527139986, 2.9725287951744868, -3.1533465259130216, -3.4240956831128266, 0.332541223645364, -0.9950642388190932, -3.800149103712577},
    {2.217927619594441, 1.097007767944074, 0.05414500856324791, -3.849968315757701, 0.9593986491156046, -1.9439691487525124, -3.2470706742876407, -0.6989439454243344, 1.5026215619850982, 1.0063170084473394, -1.6969330891550927, -2.4078274630833274, -0.4836869693798793, -1.7152696406960928, 5.975257481086616, 0.00994589401476979, -3.615946431104197, 1.656945194359216, -3.141715752398576, 0.7165663476255469, 1.0903734419718683, 4.428287635060601, 1.1860207838342811, -1.3612417403167614, -2.0348603080375685, -3.465683015084177, 1.9534288364251686, -2.653876992305486, -2.2906875957364248, 0.3783021289432696, -2.780271169150009, -4.8093311044025135},
    {0.45808574177529265, 4.308394042520564, 0.47694407320688814, -4.338659282277991, 0.5388943199070799, -4.87068639926272, -2.5407748462025688, -0.02769807469920787, 1.0408888142260782, 0.0537775204712779, -2.795416866239092, -2.66843383423992, -0.553011634012958, -1.9509172135694481, 3.4876065857113385, -1.4607589510970929, -5.506130937972615, 0.4981515675631545, -3.2318181218871835, 0.6048518795370571, 0.270560766244063, 1.8747798045664599, -1.0529932086814269, -0.6058373856845619, -1.374752313697518, -1.7441144285485854, 3.560659892996472, -1.1054140625246813, -2.8707947474327082, 1.749469198029506, -2.04932484435342, -5.366534316500303},
    {2.828002488687057, 4.945987647102996, -1.2735474447874153, -0.7776439201674521, 1.0457026898006594, -1.0390894562112378, 0.38518671402476706, -0.08255816495228277, 2.6561433512139154, -0.1388895513594939, -0.16200018030787164, -0.8673144660190188, 0.008755139935930953, -1.6633308432009533, 4.062446295599744, -1.7674188426606587, -2.837015407160145, 3.3709567610733777, -2.3215544631613305, 1.305886303131818, 0.5986614308366872, 3.5535969166557013, -1.1171568310147653, -0.4142264813412337, -1.3866637865785398, -1.7147043553683725, 3.844752374417748, -0.4822770014518423, -2.193880007936585, 1.9300597059229652, 0.20886046945657155, -3.340396432088433},
    {2.63569461817681, 5.865611798319853, -1.0814259506671073, -1.9311274113785852, 0.7924384044308593, -2.5445107932084503, -0.2570611552676116, -0.549261392155186, 1.0573980392283895, -0.29153421345436326, -2.7370527917575647, -2.5961482371803903, 1.4825447843352864, 0.2663417199246106, 3.1527841970756443, -1.2429332943527005, -0.5217493646212489, 4.40396455484503, -0.24122694148876853, 0.09958141602883391, 2.459177960844722, 5.444014848673637, 2.322473691096231, 0.3643080659916619, -0.6183283930576381, -1.2131994107513926, 3.8678092488999956, 0.6701888116720384, -1.4363610988890918, -0.2635490477434786, -1.002119332814604, -3.190991410984109},
    {2.2176437795275055, 2.6013921752460365, 0.19801421501918193, -2.984718290472176, 1.1640180419592514, -1.3681096000573303, -2.6018036367002044, 0.033361084739833936, 1.963923618784601, -1.2765558047828718, -1.5443567569232457, -4.80440339335097, 1.9762097879646154, 0.28220606332343395, 3.6676781979343462, -2.4721884965116816, -3.5293684966806214, 2.0904373418815982, -1.0013830666568797, -0.035178194652219, -0.18522607414528364, 4.992951326035748, -0.22096387632028636, -0.8580955007321164, -1.8167751928626872, -0.46983067066769685, 5.918536090283605, -1.1930222820937335, -2.3804453939972023, 0.484747736952664, -0.946019173455842, -1.92206052193762},
    {0.6830126138275184, 1.5413841307198834, -1.4208784512842398, -2.1587086634746027, -1.1674750849825408, -1.4111358912273444, -2.4488368748360667, -0.35069490053850433, 2.3870198917659637, -0.2580601045155004, -0.8908970477531732, -2.441958802829097, -0.9387298806173008, 1.1456336546319705, 4.434821478414656, -2.760126085316197, -3.9074222016765146, 1.3755310102633589, -1.9615145187450587, 0.7588078479060378, 0.83458231178444, 2.4342762738181785, -0.6739417576364137, -0.9834299592343583, -1.5135985504335259, -0.2815117268052142, 2.9332668670937605, -0.8701557075386154, -1.1746663420155656, -1.0802262426149571, -0.6717191635993319, -3.1453041667200408},
    {2.055385630562231, 3.113567337004589, -1.5552657451464604, -2.887764916090146, -0.386219270834521, -4.2919342682422705, -2.4173210109280983, -0.8969325247394074, 1.6775563621457963, -0.12604650903903175, -2.849322372687559, -3.6908657106524063, 0.6185802754226479, -1.3918270095928233, 5.378442809020525, 0.40138810754931953, -3.763914789826025, 2.456129719740704, -1.8791402835015019, 0.09061288225816587, 2.920973584215587, 2.702780106004748, 0.49731096993416346, -1.7059430043106725, -3.8110056244396024, -2.66264179967836, 1.818938077705055, -2.1921316584506734, -1.610470965072709, 0.31109143347907586, -0.949188976940922, -4.2500234340387255},
    {2.2854896917284333, 2.403178678589832, -0.0643603780634091, -1.702469903930004, -0.34837341386325926, -3.008503313006648, -2.238043824147638, 0.44783958394721396, 2.599568903407524, -0.8524919699770169, -3.388458404466232, -1.9429037652086025, 2.6585992344614553, -1.538849213485764, 4.260891135743517, 0.4214053762698586, -5.210831483391028, 2.4477610061941486, -1.478870983558779, 1.3876753593787345, 1.831555212747723, 5.053812085947012, 0.44050567919676553, -1.1717294724871525, 0.1836143936512943, -2.2220585526785346, 3.3337193050642964, -2.7997160863963884, -0.4714991654115765, 0.06233674948454959, 1.3368303669680723, -3.469786740665939},
    {2.8827093991030606, 4.296106262898579, 1.3641330120460602, -2.0936612450483576, -0.4824976739878342, -2.223742755504764, -2.081772356679503, 0.01837068954223551, 1.021207130544664, 0.7107249604355319, -3.043616979902037, -0.9124027127417635, 1.7276803660765565, -2.0167390489525454, 2.4387056941832737, -0.1567099886536095, -3.156615550156837, 0.2632776813353931, -1.7092248172487254, 2.326780616977193, 0.20964255197929807, 4.037237553154305, -1.143285699906845, -1.3638347014911076, -1.416145361712877, -2.2584832146918923, 5.329062253357588, -1.6287425427677706, -2.160421492367861, -0.5826722530167748, -1.0631109557531566, -3.188999938693451},
    {2.377022098070103, 3.125372517122173, 1.413990347292209, -2.5120000274322325, 0.027234408471665614, -1.9417346426170856, -0.9251723287061252, -0.69147758485211, 3.779444847909348, -0.9303541492650518, -2.652439138648894, -2.63506784553244, 0.27041813708556545, -0.4308843229684152, 2.0033524399754206, -0.831140903703551, -3.6995269898395846, 0.45358895949861594, -3.47213289096222, 1.631321253418171, -0.532429330697461, 4.662262854563078, -1.3184238713507295, -0.2511882807781297, -1.1683101922255323, -2.4771907055270663, 2.6659901931160777, 1.0324649017248784, -1.851220556534077, 0.7279068429842678, 0.6916274376687208, -3.940918283182252},
    {1.74142429263103, 3.9692902334471483, 0.09204371197747635, -2.0261488357134305, 1.7908785289168807, -1.333932833934794, -1.6513442501557722, -1.1082617399694732, 3.131026507093329, -1.3165373754928529, -2.050014685773719, -0.3515021203474918, 2.2809430219664923, -0.4111140050209295, 4.371908042532701, -0.7647351274336324, -4.100370795398371, 0.4581619056478014, -0.3014522842300566, 2.1826188839530345, 2.810599298979633, 2.4344654280460167, -0.43373295129680184, -0.1816434929728984, -1.3315481644244036, -0.31628306466559314, 4.802659655332785, -1.399743202761815, -1.0281185493596927, 1.981798705822119, -0.7946765649095764, -3.5094227816065553},
    {-3.1112719756558134, 0.9418110607936029, -0.35080539212707634, -3.18777754438598, 1.0940942627253067, 1.0069236277569218, -3.463287174209965, -0.39779117510404993, 2.700086144925417, 0.20270285797735, -0.9901710748822417, 2.010554624239498, -1.2906945312345284, -2.810030199674973, -1.5799053627776158, 0.1048434859472318, -1.8718007835886155, -0.3234827100447877, -0.1828894696268005, -0.21777939650194267, -0.4821860459912868, -2.011802874541171, 0.504296523506434, 0.5980516166705339, 1.252909967377101, 1.3975414926071767, -0.5021988205363292, 0.5871062078778467, -0.7280695130989265, -3.3119417365712343, -2.67112279073421, -3.8965072993279644},
    {0.5083837946551566, 1.2595197841752352, 0.16109668582419895, 1.7152640120613178, -1.7297401913972292, -1.8131660774084322, -2.2215805100229327, 0.0045434844523119244, 1.337197323324367, 0.032072737611916056, -2.4589185608788333, -0.9449558422632682, -0.6953338380258143, 0.5063652028506116, 0.8728079307698389, -0.5662443234305615, -0.8235353881459707, -0.9017487577487233, 0.4915738371747695, -0.9156583188830153, 0.09580158035888267, 3.1066114809242382, -1.180925740858682, -1.4608209570297574, -1.8725447371563093, -1.2311961572991859, 1.6747610012043477, 0.316334402795705, -0.5971691212832116, 1.0296385512570292, -1.7396350118284836, -3.998455325106916},
    {-0.6421931204546028, -1.0371715834997999, -3.7846746954597057, -0.2699555016642248, -1.4352604360297345, -2.6118987053295792, -3.6018435342305213, -0.37391874411784953, -2.2177527453052313, 1.1045890481746963, -1.9328467962987195, -1.347005162822359, -0.175477067979063, -2.60761196280308, -1.8022483832217409, 0.4721436133253833, -3.3290697153757454, 2.739242150572815, -2.2362181645605035, -1.709081778848177, -0.3637927034088202, -1.257786615089358, 1.5129570910765342, -2.272576572189833, -2.0939316487836734, -2.8417375570058057, -0.7757129680609236, -0.717370123563305, -3.0997342700103636, -2.202972615811409, -3.055016833661553, -2.460463537113273},
    {-1.1745662389452394, -2.5282143310928107, -1.4117185622104569, 0.5854103450404341, 1.0297444055855176, -2.768476039943523, -0.672988582793671, -0.37680771866618723, -2.53839597131557, 0.6766718721964857, -2.8523025296443834, -0.29167116147886035, -2.0828051297204198, -2.268535266417444, -0.3654841250827773, 0.7169276611241756, -0.08023438957578828, 0.5181082551396111, -0.9096279360011419, 0.32561138481634544, -0.7560276702696102, -0.8827531386234875, 0.679557732243528, -0.27243392866334576, -0.9923596308975793, -1.9695865038192488, 0.10770069110467555, -2.154405876338221, -3.52887204937383, -2.7462659568229717, -0.5724295378588173, 0.31897714477095024},
    {-1.6923719484192554, 0.3440019631247033, -1.5176909327366521, -2.544638504149393, 0.8663318048070355, 0.07952934765960736, -3.6327206515800676, -1.7221596847314653, 0.7278766857411082, -2.1567609653367033, -0.5277151846510476, -0.8185174467494403, -0.9082822173354131, -2.4943375576988656, -1.8495310687637982, 0.23396225168688548, -0.5244801824590332, -2.88352512725771, -3.2482440366174385, -0.7309892187168924, 1.272284690059624, 0.8191566058331763, -1.8821874599355877, -1.7120557104443859, -1.6554981043853454, -1.0450250571750406, -0.001941992381157473, 0.7314858456819319, -2.217877455403502, -2.0351751794351793, -2.3381036700374853, -5.041814390417706},
    {-0.3729274742024233, -0.42432305671278997, -1.1193357973304727, 0.607887143549201, 2.8195742131816734, -2.347982023267738, -2.644841283685589, 0.6138456406787263, -0.9785304646379833, 0.5428854830407109, -0.44444722162870715, -3.2602347989252576, -1.4206463161967957, 0.07766695407538915, -2.823465970316941, -0.28008454709234204, 0.7846411132899208, 0.7175239028139144, -3.690656784651519, -2.5293929584799115, -2.2842974566309575, 0.4276091623034745, 1.2670290252187342, -2.2158885401686303, -1.9693072554985491, -2.148528283103026, 0.4198943313613561, -0.4165225278198808, -3.0324869764539946, -1.3719542270587004, -3.129302063009013, -2.0579947562955603},
    {-0.842011238767903, -2.1241547317195253, 0.4967818212740678, -0.6047242289116798, -0.5155817680674235, 0.39160744960956445, -1.9382808835031835, 0.1705795175240856, -0.19852272420741998, 0.0714369925711959, -1.2373456088655246, -2.259552220172795, -1.9198011166435547, -2.1467565605095844, -3.2660330240105795, -1.955566031227074, -1.2415763569142735, 0.08221314820634956, 0.012340695599057448, -4.464890649010896, -0.16370550368282677, 0.0303048601628884, -0.28488554202478766, -2.3644307367261805, 1.1530540219950738, -1.2889389357669543, -2.7229349283252278, -1.275058390704637, -3.068467722088733, -2.5063427086067596, -2.4739120775516814, -0.9375867633877943},
    {0.37712504967968846, -0.9600007897172137, -1.636557703224781, -0.8879378563506143, 2.1491176110164747, -2.346689360232415, -2.159020069498053, -1.9357357598581564, -2.5838639634787306, -0.19779217603826615, -1.8045235537716546, -1.991388000674001, -1.5219959543788741, -0.7853815746338735, -1.3989517924004422, 0.08911079538146967, -0.9902600940924625, -3.234494180567031, -0.6496665690841779, -1.520599963108799, -0.6914112596085049, 1.9352733074306177, 0.6170740943662025, -2.7402344043926385, -3.4103016587145403, -2.8882340198835394, 1.7307072566519353, -0.6898557096823683, -4.161065113414715, -1.1332605686333566, -1.0192187208848313, -3.0647843021574066},
    {0.036675205176717116, 1.3846936278180186, -0.2551009095363313, -2.155848096749252, 2.021994241473744, -3.6335892031965993, -2.0032317938904725, -0.416142482449684, -1.517794648958187, 2.5024148642668864, -3.238724344722853, -0.9975618179793705, -3.964034771487955, -0.8456138366769006, -2.6392967673986694, -0.6962249553690045, 0.4273877191865303, -0.8794903214624762, -1.9021844021350485, 1.4379095809676161, -1.0233427672508413, 0.18779016057778392, 0.8767390705395257, 0.1636762045429719, -2.218446597385724, -1.0770367981188036, 0.7217284728115063, 1.1754288473209864, -2.9499193417850478, -1.859964523754802, 0.16088957507685697, -2.0195544958140026},
    {-1.5043620259068378, 0.5310842143573384, -0.4018927944215192, -2.332411006930898, 1.6189590688034285, -2.0488176026531817, -1.353782164440939, 0.4532793261536669, 0.18638867037993173, -0.07999191972598994, -3.1089674220218826, -1.7872303043413813, -0.9903672371701026, -2.0559557437954865, 0.23501925448228844, 0.7282542887574507, 0.6516748378245374, 0.29319156327598966, -2.2236786800210284, -1.6852238106855992, -1.0961560963364492, 0.5405095143195547, 1.0951811549532982, -2.1269499410535304, -1.0622753363273245, -3.1760436253603466, 0.94026962449698, -0.11842076666946307, -5.041149733064679, -0.29656117352686817, -0.6141033437081155, -1.1122540367344926},
    {-2.2735651651333235, -1.5499259773893819, -0.5587362843069691, -3.0046251816247462, 1.4884716551378365, -1.2515824638355058, 0.3475576337046462, -0.10225461116445718, -0.7889377264498291, 2.0510643955661174, -1.9865523636351825, 0.5403918682903818, -0.9189374779494672, -2.3924765658361573, 1.1249496312478653, 1.0627840166874785, -1.6172664065794278, -0.13103120777716246, -0.6595890079786679, -1.78274025506475, 0.9951976015396815, 1.6531444281602736, 0.9650909332792602, -2.973507006295062, -2.0653765829025725, -0.9056046501977377, 2.4044075654314065, -1.6501831075738083, -1.1453463091063902, -1.193073877092093, 0.3978275432849209, -1.693742533929283},
    {-2.7796665986997913, -2.0038687003408797, -2.894956202348008, -1.8825929611992733, 1.3452640185066238, -1.7993682921150365, -2.6371224799883395, -0.9497344941832336, -1.1616233536293037, 2.178689400411812, -2.089723686646999, -0.4882760784296944, -0.15685678843426865, -2.831607252122563, -1.0859583191044373, 0.16883902468764952, -0.2428632462230902, -2.1916529412588908, -2.1812422005640295, -0.41654589535708497, -1.3238910947061808, 0.4285264792489957, 0.5647657630246757, -2.1538564167559406, -3.3155935322062864, -1.4424083701380124, 1.4815582280443078, 0.99954915611001, -2.86057035366112, -0.8585398043370277, -2.2256772279295136, -0.5368432274370006},
    {-2.2338077996855996, 0.6069633950666784, -0.017921040289234542, -1.3342681374722072, -0.7550141655983043, -2.7458786768741827, -4.16043258959606, 2.803766587821795, -2.7297224140681027, -0.03289516709957743, -1.8743464233346965, -1.3283525490355372, -0.6142057770904987, -2.623633937382116, -2.7311858984923623, -0.12675932252696803, 0.2637511789442428, -1.459943633716384, -2.0109836895742177, -0.9092997164432356, 0.18794056177439952, -0.307966358286823, -1.2397602723112924, -1.2215307756103426, -3.1641574810630586, -3.793241189036765, -1.3212629230258255, -1.3174774175545032, -2.2152501868920815, -1.9224863709876818, -2.978487723287912, -2.6978955418380237},
    {-0.4938156184156299, -0.5723597032833772, -1.117636441974925, 0.46747485960892543, 2.142178714091139, -0.9684517135168699, -2.8332680559831562, -0.4797439002910892, -2.1176839697791547, -0.18134886847200526, -5.110095779512018, -1.731882357616742, -1.2160408294039766, -0.7655869655557395, 1.5483724164847676, 0.058736336258788595, 0.7671985230876579, -0.16579288028536815, -2.144632507027136, -2.431285105670497, -0.07598886983990315, -0.6890675184828383, 0.05487815821788969, -2.2651744466666375, -4.060905038638324, -4.742947933766549, 0.15953525681305566, -0.26423708938930246, -2.868499403750506, -0.0853474870244963, -2.291802867556927, -1.3428992298581068},
    {1.1578321032832772, 0.4059462575111105, 0.6391787404347992, -2.6266326550983505, 0.30629189569989684, -2.4861371337809786, -2.7917790610391386, -0.3747330668820516, -2.121111006818491, 0.9741518961262357, -2.365435700732875, -0.8101700650327769, -1.7294208270259426, 0.013297465750727188, -1.9958998695644337, 0.5341901932584117, 0.9332572451135468, 0.21690417115576996, -2.1533247095418786, -0.5834276074190362, -0.9055924086659124, 0.5731000521738555, 0.43631148686910304, -2.1835252821046836, -4.3262782694568, -3.2832531627942094, -0.32176571368516105, -0.83728607851061, -1.3072294002169977, -1.2975644710536136, -2.1543741432490564, -1.2998849680469862},
    {-0.6690790894079568, -0.38648743011382397, 0.008103821687669, -0.8043386542786304, 0.8309581217157624, -1.597847163875173, -3.1570500440220406, 1.2833820467932966, -1.0818305465627003, 0.5015183660225275, -2.568693439185468, 0.16189808046766982, -0.08658769683909788, -1.999574576738426, 1.2405777848409782, -0.52473980033216, -0.2135897804586921, 1.0531628578324785, -2.0052902458557607, -1.4841811064939627, 1.820359273273248, 1.2817387149388333, -0.5277544923844337, -2.651317471214971, -2.658235164083316, -3.472050901124223, 0.9529718285621702, -1.857282802480079, -4.221636091411615, -1.0487050849062098, -2.0742868991593832, -1.019076403527884},
    {-2.1127761875548283, -2.549440385591732, -1.6013660107951142, -2.263359291631377, 0.7259031357158632, -3.5392199343545507, -1.2140822381462475, 0.9921476782493165, -3.468414554381369, -0.11751881008004142, 0.7349001641476134, -0.34809096608150936, 0.8272483928136233, -4.754287974808411, -0.6637291951978261, 1.3243825757727943, -0.26607248626267715, -1.8533407481963349, 0.28276937258481327, 1.3017319333673592, 2.2639032874876803, -1.4831216957774587, 0.8007093804460154, -3.731334673134368, -2.177659244342071, -1.926187065979933, -0.720099944425642, -1.1032997939660514, -0.384498777247718, -1.2770593527630973, -1.7598861737174027, -1.012274178156544},
    {0.3024523939581867, 1.0155693460270536, -1.651545777650613, -0.18111199832004019, 0.6964421171088591, -2.7641058274185464, -0.10211576383610885, 0.30550705417280893, -1.5294617100462105, 0.8285584824343182, -2.31965883293835, -1.0964024743720617, 1.33222539923082, -1.522424691074247, -2.445594845641665, 0.2440019079228862, -1.5559476424270315, -0.5326369764522998, -1.526459279716057, 0.9266732108157464, 1.1924195560743847, 0.5723372576071982, -0.6562909504433915, -2.8604416884473176, -1.6764855508245315, -1.308330048450737, 2.9277753871487455, -1.128283095997788, -0.27322404192991373, -3.325318938868794, -1.8546797245157909, -1.6795164747625433},
    {-1.4290722096434507, -0.5711665393551701, -0.9231978092984613, -0.01776219230200041, 0.7222584273558766, -2.1074223748861907, -2.6192176380148724, 1.4955870065182022, -2.6944385749637934, 0.2673025945593478, -1.6855395230671557, 0.1803423702219217, -1.3508105156564545, -3.118065000105558, 1.319340014825127, -1.8991395297556604, -1.569398160289515, 0.5679083671526332, -3.154778688782505, -0.5048715336023432, 1.9542006853181006, 0.05692666129022955, 2.2690541036985103, -3.621068212861076, -2.046692984079574, -2.9255394218644994, 0.8309005935926096, -0.7956692585397017, -0.6937503839907715, -2.0296703505322586, -3.0468232705581086, -0.7743420658874777},
    {-0.9913094400881256, -1.0792779844218698, -1.1627133730823247, -3.394610272041394, 1.4476909706327095, -1.1522901369023875, -1.9974069406779296, 1.7613284001942795, -3.315149673188779, 0.662609280282242, -1.75637859015059, -0.2976228202718969, -0.32018572713756915, -2.545002969647838, 0.6645583264272722, 0.14513866694657185, -1.0416348099560475, -0.8907176838907122, -4.03038250311062, -1.2928735115434415, 0.4183719779591837, 0.6942352442750371, 2.0864917804844056, -1.6217655592495341, -2.4007725806578777, -1.9771086428602296, 0.14006539995141046, -2.2500158212911727, -3.982390908886968, -1.526814718347126, -3.2126168785640252, -1.8446811306065811},
    {-1.3306401727757045, -1.92208720170055, -1.4335376177202197, -1.8950563527007989, -0.12812636340805417, -1.7010130888429986, -4.277094127165476, -0.27303842458621974, -2.7394515955863885, -0.02839292904776815, -2.953191213720946, -1.914971516744598, -2.8397064517356436, -1.5434556465879647, -0.9073525312535613, -0.05763309162825667, -3.0919911943375156, -2.1917442788863744, -4.074000358009177, -0.182644333547477, -1.473019090203905, 0.09090136426590341, 1.2181477944406223, -4.668785114307888, -2.441699109248107, -4.187165924872818, -2.1044724053268347, -1.3470141023712685, -0.9355692165221612, -1.9625430969521924, -3.983262738793768, -4.177427431346881},
    {2.206896115321801, 0.8705627119532257, -2.69873835038617, -0.9611823287815487, 0.44341278480080143, -2.775445461694241, -3.157638944906969, 1.179625029468046, -1.0983898078469452, 3.1320602888673874, -2.334174229313779, -1.3324534907281633, -0.10343566928267726, 0.2824495667772823, 3.0516040464437664, 3.9478639004213796, -0.2182681484366901, 2.3255497068233386, -1.8198246590492415, 0.7118753062933089, 1.066804866138017, 1.2870654983662515, 0.2744783193141318, -3.043177686487142, -3.069221053888444, -2.1505557774304864, 0.9753945694817715, -1.497603225039575, -1.2829528029262005, -1.733304537735808, -2.403613094138041, -2.4672226564179196},
    {0.941248566535619, 3.802911480046165, -1.6646418822767126, 0.8923740276241859, 0.5342198742661992, -1.91092489808359, -3.24537348591632, 2.7655074202766903, -0.8771556036659446, 2.539612187690828, -2.3573863631989815, -0.6691639573135405, 1.1124680416280943, -1.2907169774008225, -0.10037040535506864, 2.4673305386000353, 1.0929438165097105, 3.153147347349137, -2.826008435221814, 0.9136555175035005, 1.652347380086467, 1.0325488532575557, 1.0208742526505314, -1.731223484289781, -2.0613344284782595, -3.001588389292639, -0.38827078703711904, -0.30333107970524126, -2.269421402478206, 0.07105148875697631, -2.0201515719413683, -0.4068950807721883},
    {1.5396880968111417, 0.5697394550280891, -3.860970857818261, -1.5377973142715147, 1.21428143121984, -2.7638591524559337, -2.1272299699443957, 2.564098350248804, -4.4284942941235395, 0.9346203049979194, -0.7842846227054502, -0.8261407493815653, -1.309406997700462, -3.7243504941677785, -0.44566609201578106, 0.6114948600018899, 0.8779075702740593, 2.1514849238119282, -0.9797616365129632, -0.46803505703132514, 0.4303201961158277, -2.625538685974358, -1.9997246759874552, -0.5299541917844479, -3.377300852609044, -4.244927982126099, 0.1749077141477054, -0.03420328572839224, -3.9157854304698447, -0.13668470782950215, -4.29997609428507, -2.275449328229048},
    {-1.4142108707486543, 1.0766490235029171, -2.6635045555914822, -0.47040623157808253, 0.3761563799032308, 0.6990392159030827, -3.7888127499567066, 0.6218626481865541, -4.633037576557475, -0.42539682750193597, -1.025886074067824, -2.138700429115887, -0.1981825443424434, -1.5767874410463767, 0.2522393565823001, -0.8775106395928353, -0.9781768599993496, 0.7736535792460161, -1.9868262020955882, -1.9849687660145099, -1.621524725206554, -0.40857102009795, 0.24363673039815362, -2.9056041391829397, -2.369778310620714, -3.3259297331497213, -0.2992320503236859, -1.1465929141653124, -1.5967033925066012, -0.17732545784714573, -2.3232259132138813, -2.3634477669237133},
    {-0.12222408649909064, 0.07206353428063776, -3.350147791996204, 0.19478813614709464, -1.6072479374584934, -1.3862943906308864, -2.600994892271519, 0.04892285947484317, -3.9321110905855057, 0.9285547074470282, -2.473844172396044, -1.8578730743583423, -0.6556526638907296, -2.6850584927882712, -0.4610599119151136, 1.3676750164655822, 1.0358406845251857, 0.7397469660743328, -1.6073309124148938, 0.12291630087636139, -0.488345610470981, -2.706142088009056, 1.2286299517156285, -6.056718043249744, -2.5809530500845956, -1.6346784350637389, 1.041821893681408, -1.9457143299336228, -5.011976672474946, 0.2677106377181939, -3.608487746024662, -1.7734749077030594},
    {-0.4736152110734898, 0.9482507816559409, -3.615573742713998, -2.7105526227563184, 2.283978178278708, -2.628519025250213, -3.77249761185857, 0.9329290224238349, -3.0929500893033843, 2.1255118754020663, -1.8569557985407852, -0.11121387863154422, 0.9082903047183202, -2.307876366626471, 1.7196558919121443, 1.0690505813230824, 0.6792668364136728, 0.10657034550109104, -2.3709904774109107, 1.2850294874222892, 1.3069517748410378, 1.592166220817153, 1.002146207377524, -2.085337214828235, -1.376219348466308, -3.644896198720751, 0.6945358832657597, 0.185915061837336, -1.606453974209988, 0.9846087732581084, -4.050415928920018, -2.6289706121531937},
    {0.838131766659571, -0.21336596949410905, -1.958604052113356, 0.17467810825245006, -1.2019825011006315, -1.1552012569095151, -3.1285282847594713, 0.222024974669916, -4.219059546454537, 0.9048979291236756, -2.696522188016494, -2.2979230706245874, -0.36995193214741606, -2.325623320256324, -0.5125226029399956, 1.2229953681237518, -2.648530242386697, 0.14151287456286477, -2.644522201132417, -0.9424117635583568, -0.6214126045167506, -0.6637949149760303, 0.2834792621185988, -4.263879528455666, -2.747352597810057, -4.491142310996644, 1.6360499441368466, 2.086145263666592, -2.441944940475282, -1.5502899964288612, -3.520080179690817, -3.4354652388082703},
    {-1.4179600370315357, 1.239661943870587, -1.2030145379004595, 0.7223847210359327, 1.8279136951205501, -0.7104874297460277, -5.407791090677114, 0.7033285671421216, -1.7973123968209481, 2.0282597041224477, -2.8567717693205936, -0.6193709160538609, 0.5910274468406223, -2.1927605211308796, -1.4102897162625525, 0.43200330541523463, -1.0333470858769613, 2.900194331208453, -2.6131679180520724, 0.6118480414953615, 0.11412018913091584, -2.2504271780251206, -1.1836098487264095, -2.9415420607096934, -2.468840015422987, -3.92273352504773, -0.17019535468465363, 1.5785707286392696, -4.339387982074971, -1.5266877720745775, -2.430444056984314, -1.9800365480171442},
    {1.1112309939760285, 0.5408370643879992, -1.8609182775296418, -0.19266102745194397, -0.30727499645051143, -2.994424584914228, -2.1999106843174654, 1.5840075876977406, -2.375917479804438, 1.7493609198762252, -0.46576071959596294, 1.0195865767595325, -1.2623273834239794, -2.1559494166583306, 0.9139990764543763, 1.2990658933042962, 0.5512982844937951, 0.1875410513697588, -2.670315496010651, -1.1545873270157727, 0.013461028473017755, 1.231208999048383, -0.14832390794466224, -1.1700915760049246, -2.968289773167474, -4.734649496378698, 0.24789167016517977, -0.05362886148675258, -3.082851187983579, -0.9691862660700477, -2.0154077430507065, -1.9077355529201974},
    {2.315438330440396, 0.7660094069470179, -0.23861131927824003, 3.777665463081458, -0.5034964843749579, 0.08710048289192487, -0.2702769381152522, -1.9394787628299326, -2.1769134555996104, -1.0675951690765109, 2.1077096422221486, 0.6865456827739483, 0.9568796026686878, 2.567698576363827, -0.5854768284799361, -2.397780856601749, -0.7308967937896017, 0.5400394414984309, -1.3898504003308458, -3.1372563277209125, 0.8066162974997165, 0.7058051363264866, -3.6059504822244555, 1.9705515395553996, 2.5717767080181666, 0.158782844143975, 0.8046134898664208, -1.7546374271980885, 0.5344470146292823, 0.2111988761473037, -1.223808058374321, -1.028021496652191},
    {3.7586974801319144, -0.5771171412053099, -0.41527454260981944, 2.0663937716488494, -2.006691369764834, -0.5842858709218999, -0.3767975442970082, -0.6220022234345725, -1.2726479351818683, -0.3018824445150861, 3.2511581253308375, -1.5027341008968456, 0.29761318640300205, 2.8933642437003644, 0.4042240627392173, -2.115298156898448, -0.7888080028162904, 1.1819743991683653, -0.4306115680729975, 0.2663388941909455, 1.5151030400812002, 1.5978391820036721, -2.259421349448611, 2.88677009116291, 1.718051712883696, 1.173858535252879, -0.6964229484222263, -1.535118679318948, 1.090801138113695, 2.505064204025942, 1.453804737730706, 1.9298193575346403},
    {0.7656191430210969, -1.2264656372749523, 1.446641666272743, 1.1666456477756075, -2.5678334459160848, 1.3814730809442626, 1.344761310660515, -0.9743035648483556, -0.28998453822653164, 0.2530767540392752, 0.8894739097965353, 2.9757489677103472, 3.2656931410958485, 2.786345424559773, -1.5142274177505997, -0.706564224445684, 0.07235564270376225, 1.1097031304344025, 0.7874472752949293, 0.6028683032522504, 1.9540644204679911, -0.37641558956215915, -0.4939717337763228, 1.1349539091428091, 1.2711545007276726, 1.2940561807317672, -0.6378261988471354, -0.5238459955282923, -0.936054975157004, 3.4616798066973877, 0.6058722654385255, 0.058601644727605984},
    {2.921044248528574, 1.1970996003873644, 0.343952117775556, 2.636542821227459, -1.667449935942947, 0.7547926565737155, 2.182128555086513, -2.5187120852259577, -1.8035619885036482, -1.0481446853252225, 3.5921941596147007, -1.1601638102357648, 1.784473443789176, 2.024815945048372, 0.5303652242236507, 0.0888471693813717, -2.444263999290446, 0.8096613059417916, -0.16667042378102362, -0.3046060600848202, 1.3543605988533163, 0.23989381269118998, -0.8057141133216302, 3.8915307077803494, 1.4195359757316788, 0.17635768879168076, -0.6314319281977765, -1.8550052650174322, -0.8724030588641803, 1.9225546175468229, 3.735442554607769, -0.13500578550045172},
    {0.7045384948659975, -0.08947880315818414, 0.9717977418650774, 3.1263028514941693, -1.9218316796681205, -1.1210270347723268, 1.8563832946514924, -0.549004995680126, -0.2018081594590624, -0.679332053491112, 2.9829619017531765, 1.283071976433803, 0.892676782840885, 3.113572990311156, -0.8470969947983505, -1.6067541745558553, 1.3185980478551542, -0.11385334637336389, 1.327620004156147, -0.7056597822935594, 2.2427130740412857, 2.258512895692335, 1.0659513417925595, 0.3143593342374792, 2.1586027344708323, -1.8720783643689227, 1.434253150462553, -1.403453628714594, -1.1495928377527702, 2.548363611148531, 1.7807473290974514, 1.2885509990373787},
    {2.4255838098594764, 0.3468019036301032, 2.4577437526867563, 4.442936251106275, -2.102288521272623, 0.6165368771153286, 0.39489471752194966, -1.9057392113109335, 1.1898984618414747, -0.2730846176580869, 2.0854970519258935, 0.693593602555275, 1.9475084512049454, 1.550822462111783, 0.6845384506725296, -0.09392959049926804, -1.1457638579547087, -0.4685431453024889, -1.415236332049859, 0.2448221284587167, 1.1772924187640057, -2.2247731616014836, -1.492888022745883, 2.2543452770686168, 0.2722652215047498, 0.7061472976323263, -2.3015598091737353, -0.8914593033365387, -0.36796568042424116, 0.19512158719379197, 2.0383127457411345, 0.3912564141213517},
    {1.316918328168526, 1.8613149793158688, -0.24269289310811398, 2.344803806369416, -1.390256931266373, 1.4148309884169539, 1.0220183495241275, -1.0305441588880255, -1.5235039646471067, -2.6384174187818705, 1.8432190190314315, 0.3974994453347592, 0.6406331622067272, 1.5317487396580696, -2.5863374636849827, -2.2709152952888667, -0.20931229220795686, 1.4459835627711985, 1.1307160572468764, -0.04460556772367345, 1.7447524318705956, 1.1172223553709635, -2.3131571596353804, 2.1622478421730413, 1.449163263113801, -1.8838598628390704, -0.2258263547139694, -1.642252473601366, -0.2646131262260211, 1.3052858678083334, 1.4206667328841587, -0.35799595436106785},
    {0.5256945105061837, -0.5935643740813434, 0.14480997577391566, 3.2123694771102493, -1.0580706066706616, 2.5381272602414615, 1.4069249773334171, -0.8608878975417419, -0.8202709071519584, -1.646163693834425, 3.4755727474346254, 1.0450561517477701, 0.8781911764955982, 2.1785623545899537, -3.403325272896629, -2.2677882334556796, -2.694766043340494, 2.07865750248482, 0.7346772811154424, -1.0608558298120598, 4.157823696844638, 1.7367633825346176, -1.4339662339613182, 2.6561080355512963, 2.1115080285665524, 1.3748406887575941, 0.06307482619783004, -1.9409551205225368, -0.13889630696847946, 1.139060890342163, 2.3309387063723968, -1.0592842867830112},
    {3.1388139422102714, -0.662648590449093, 2.311271363455567, 3.2739206573904838, 0.16792360323030228, 1.1554647686174497, 0.03812865381073658, -1.0498052041447885, -2.2870111308257712, 0.4953751946577682, 2.0751295318959437, 1.9099558449163503, 2.006952070299178, 2.6047588284551697, -1.5765706523561775, -1.874617589143926, -1.8597316371015469, 0.9832727852014327, 0.9021952570111326, -2.270095936586149, 1.4178159968726562, -0.2830933454739339, -1.7458596191825395, 3.674745463967143, 1.1789226491423397, 0.6204648848479388, 0.4486992120610929, -1.1071362818044785, 1.237199292618299, 1.5621243656106818, 0.18515816619375888, -1.6208474839430307},
    {3.1324059017849337, 1.15478624996896, -0.11822670672320695, -0.1274660751446006, -2.7249012401532333, 2.149552473312893, 0.5646031835941131, -3.831320410063619, -2.9330867382088237, -1.5965632114252875, 4.48691838566574, 1.7101559442350462, 2.147328216061239, 3.8402266297185026, -0.698782263956085, -0.7012779986675004, -2.5256707788873882, 1.8253792366646062, 0.47985649497133104, -2.731112975642993, 3.2847623466021436, 0.9944574758934667, -3.2727071027732997, 5.337579987901268, -0.646210616756527, -0.8194018320575032, 1.3656965105412089, -2.946170611142693, 0.18302616216418677, 1.0534524607548763, 2.231355209424847, -2.704402373912537},
    {1.6349926406593134, 0.5915235211286795, 0.05876648002631209, 2.4577683136529807, -2.66222668355182, 2.0172844457613253, 0.7457977407619971, -2.2707057554489474, -0.5053847560317254, 0.9815455361510456, 2.575225024315452, -0.3756728892430897, 1.4839372185587834, -0.49525648983379744, 0.07641032102441599, 0.9745262405709201, -2.3557474524703386, 0.5136091713710457, 1.0398866594554206, -2.962347719289864, 1.8618606643689681, -0.6342899632018739, -0.6919367919127386, -0.054868635373554096, 0.41622489174498856, 0.9022405145907755, -1.196827409678587, -2.435694132166308, -1.5106970936301969, 2.7847193703368975, 3.0246353465707165, -1.1933174448386812},
    {5.112234900272801, -1.4125388646812633, 1.897794601522982, 2.783811898504276, -2.4373428602254, -1.1077250559275114, -0.40211041746611986, -1.134119803123985, -1.5902556048314207, 0.9320810266441616, 0.686532562547553, 0.5980425676531786, 1.4600433562758302, 1.132852759484118, -2.630027100111808, -3.343973169626753, -2.0207056003921595, 1.0151047139849045, 0.3435722244614924, -1.4169675648563378, 0.8943655167333457, -0.396557138781316, -3.5265639093427623, 1.7061244892099159, -1.4092538621917392, 1.3058525146415618, -0.21551804281150305, -2.674292043961893, 0.07882871133673193, 2.757709314491802, 1.7554147271014648, 1.0445832028510451},
    {1.6013100748681217, -2.7325543724746217, -0.4748326271614812, 2.587610018336136, -2.1048368362793832, 1.4566487795505538, -0.08666894537818862, -2.4961455319857033, -1.06868429906063, -1.9537504707965574, 1.418521962716426, 1.3896703394324095, 0.9309484292587197, 2.4600679381525654, -1.299982704817278, -3.2132156791637407, -2.618173062728835, 2.2462911559839727, 0.4958997438279276, -3.699833907358466, 2.741481385028594, 0.790750462706045, -4.383786087587892, 3.111809800551986, 0.6714769609525125, 1.188116216386147, -0.5818698365835874, -1.5445158177241838, -1.003642717932189, -0.08249927247678472, 1.5996153638718567, -2.2176928056035927},
    {1.7132367749800914, -1.3564923063807843, -1.6165155407617013, 3.889466176805593, -1.6519113718791085, 0.39765286009424167, 0.768884825046143, -2.8215225448457937, -0.5262020972275577, -0.6779511594640356, 0.3202622594353009, 1.6952737523672239, 1.6654632803966651, 0.1319223041570978, -0.9120456440579676, -0.5139500206445131, -1.145930551850944, 0.23484316853121556, -0.6955233667284779, -2.2324432393131475, 2.441156786312801, 0.16893932150024515, -2.769761453920812, 1.1463359453679243, -0.4869821823767732, -0.2141122797212135, -0.2616639116265123, -2.644826996127991, -1.713918093842811, 2.223255761455187, 2.8600641051808355, -0.5904210555761116},
    {4.509422588034301, -1.2479041782380864, -0.6253166602205268, 1.6885701599292586, -0.6851734925302393, -1.247291679592073, -1.0954448523201563, -4.310612918219673, -3.043280479621698, -2.1823702646882226, 1.4564359650186853, 1.5458853139618407, 1.7857681368532032, 0.47776507615805286, -0.6859337691254374, -2.2919199907486276, 0.12255160680317201, 0.7554899873335206, 1.105850910708871, -0.7381630722401423, 3.0802171302661008, 0.20613446879803413, -2.406425024774319, 1.6187132675643072, 2.976316019167985, 0.7951720307038025, 1.8750958163959954, -3.570017001172623, 0.922403800017104, 2.6688387649757135, 1.8556305950727348, -0.9896410271337438},
    {2.5299704724073244, -0.8432024874157328, -0.36405858109207956, 3.5923867032847583, -1.4593336356317017, 0.1176368544624906, 1.7251731738973983, -2.279667365539168, -0.9168036746766968, -4.10841860643396, 2.907691616887599, 2.4253067550131613, 2.1758895804014347, 1.750338305075603, 0.6090349930629835, -2.1329070449763017, 0.5448866980191045, 3.3354658216521225, -1.8522649419107862, -2.1116374676759633, 1.3388256207199607, 0.41758224044878667, -2.507347348375636, 1.5772857198611985, 0.28250351324244405, 1.7789408378220315, -1.0241654028534422, -3.622599623254678, -0.006047844635579327, 2.154131206327175, 2.563005184271165, 0.4680514531094945},
    {2.551805884663665, 0.47819907413192553, -0.6382444069009633, 0.4885466384803186, -0.14294150907110195, -0.7355965000275455, 1.3035803780403739, -1.1146426181674536, -2.3314052937572294, -2.4821705108707968, 2.355574432685467, 1.8686180270783854, 0.3423327700932269, 2.4852860897821425, -1.2777845997292352, -0.9701488288475709, 0.5807914401297671, 2.7701420112375374, -0.5527890848800757, -1.5261355332556163, 2.232672734495572, 0.9054882757887425, -1.3058741439031811, 0.40494359465147606, 1.794877425299228, -1.5411820238379783, 0.5044363534752262, -3.759675598725743, 2.32518637259987, 1.2703101591951071, 2.6615790043448597, -0.8424165243550517},
    {0.8061688154659995, 1.1780386404823986, 0.09372049755960364, 3.2370579398139125, -3.0913225364928674, 0.9900575439042365, 1.9077273092057963, -2.7455391307245995, -0.9632702248684338, -2.7341723969836442, 3.210812058091072, 2.384967756569423, 0.6502214609095229, 1.5590837877221349, -1.0277180288894925, -2.5253951778188903, -1.2086970359384754, 2.54126198279714, -0.018166255599707117, -0.9439426120105077, 3.196239948755232, 1.5346880513575627, -4.944196987541325, 2.2411400876324525, 1.311697238144268, -1.2858674425615955, 0.9535705249309572, -4.005234882944935, -0.7980372927686482, 1.4654815122860496, 3.6645836712813624, -1.049832537367277},
    {3.2264840935107992, -0.5046311136272635, 0.6241747526076125, 2.1359652615870925, -1.4863166317308922, 1.3128984597668718, 1.830201172137056, -2.5951142174564668, -1.4072686667827177, -2.3383204773626036, 0.6206130375672183, 1.097966044425078, 0.5476142055953956, 1.2970417826366736, -2.106582298083313, -3.932927608812904, 0.04317694480741521, 1.7258885679310385, 0.3204072665066298, -3.5414091440461855, 4.08810309015985, -0.10085758568667674, -2.445646075144628, 2.5943814624612145, 2.002507389822982, -0.49977783634882433, -0.7586019403747883, -2.8360984160225318, 0.46371538282437713, 1.1431653600322746, 0.68294192085266, -1.1244054324987547},
    {3.290823439176645, -3.347514591361351, -0.39720108327814974, 2.608026638936897, -1.435366459255724, 0.26295657294222324, -0.34428627324196376, -2.5861802191737358, -0.30448709313782957, -2.01984043783891, 2.6061187039883356, 1.6656468851600787, -0.2903183768813972, 2.6775134464503596, 0.5479851646080084, -1.7655987435940699, -1.424075191639971, 2.5523869220154456, -0.8201844175249633, -3.5793562902345095, 3.615785378561616, -1.714428958522955, -3.2309194283279847, -0.018891963253394407, 0.6619382286812291, -1.4260369712081646, -0.05770726771641935, -3.5325479050345656, -0.2510595267695001, 2.756976249910106, 3.510939025727186, -1.8889533914673748},
    {1.9764220796425085, -0.017348071086488424, 0.5401025805482197, 2.8252440706895454, -1.4329777114913107, 0.6492579786946406, 0.13371988042556635, -2.3741427430679414, 1.2625927170198008, -0.9410730465424715, 1.323913842028343, 2.8068396813357377, 3.3061947512826544, 2.4216210800950315, 0.5249503496569097, -1.6099884367761015, -0.8173517538001264, 2.4470747046303756, -1.2805165999731236, -0.5954097605336419, 1.6701029983767142, 1.2709336798331803, -2.5006789104542118, 2.0143918148655446, 1.8855997579378083, 2.1733513171548675, -3.6524934819415975, -3.675629615911016, -2.6165242833832214, 3.0724395677316894, 3.1603021514093736, -0.834727673713016},
    {2.0991297147827, -0.7509853939392117, -0.05001234949506904, 3.135029023370019, -0.6657081872842001, 0.7248833244567181, -0.6888836255555274, -1.8939029975948085, 0.04649297322848059, -2.1063863857290612, 2.9120891884320055, 2.147676309544168, 2.3093035197821155, 2.1970028064235576, 0.447748995014201, -2.336251379590324, 0.5822166798582382, 1.0188457704483633, 1.1238751251800458, -2.2812799710337504, 3.596907431435813, 3.6110127604014446, -3.9517789037415545, 2.7780189372517636, -0.11017238753609897, 1.2154443430932504, 1.063969093179945, -2.679117773136495, -0.45475876762392164, 2.6896822363491055, 2.4518888571239152, -3.2122193783275446},
    {2.695302873027143, 0.32227807913297557, -0.2900434263193277, 4.1256883101287185, -1.066409348099207, -1.2352864600439535, 1.5879048118252463, -3.941293855217886, 0.2110349080048375, -2.7995100691864385, 0.5419852646932282, 1.4162579155637125, 3.695019893816054, 1.2278320745305358, 1.8220835641701916, -2.357665777625384, -1.4132148015666872, 2.7088997124209753, -1.453205599936136, -3.5031626892479606, 4.173141462425105, 1.756810856372295, -3.272896714373242, 1.5926819781184018, -1.206598762478799, -0.5402180965302303, 0.5478745764679916, -1.9944882973687914, -2.464241185899351, 2.7960081072556933, 3.448220161092083, -1.7531271858256265},
    {4.230515580901828, 0.44152014666693545, 1.3957177482733043, 3.5519250126985584, -5.659828127565583, 1.6118803077705033, 1.1605866960486, -4.664762284656817, -1.9643707012663443, -0.15603198130452578, 1.9806815453700797, 1.463660695369859, 2.8344297534390903, 3.498415293652139, 0.16188281212153594, -2.5703305299477126, 0.2726224091289266, 1.80882999883354, -2.9620814719772466, -3.65692386715975, 1.2053234744723933, 0.6613195590816447, -4.8363951244849135, 1.808706488486087, 2.511754138968737, -1.134081429173517, -1.1675490315062824, -4.9730073758469135, 0.23715237056946498, 2.6495554806217516, 2.5918905915282795, -0.7363861798829211},
    {3.6412577102912147, -1.2596935230721162, 2.5322677925877, 2.674890128646651, -1.8343229713970206, 1.721527309981696, 0.7177293655614536, -3.1475222724751064, -1.4820980918003934, -1.7293137706463626, 1.5074079749733025, 1.3207276337954093, 2.0972005920468284, 1.8810506823064486, -0.46009451260071904, -4.163939133645998, -2.6827634596151206, 0.13245313193200628, 0.7918060043137846, -2.056398647781402, 2.8524851875185693, -0.8130457957546641, -3.697032989799588, 0.7723678608825919, -0.5529624945813015, -0.4334511918583339, 0.34663517370367036, -2.848032170709396, -0.21041762598939728, 2.375135160822314, 2.928771613639757, -0.8984109641437276},
    {3.771481487927628, -1.0444294365078324, 1.4188214681926186, 3.705678082386669, -3.867192391024359, 2.8119795033917163, 1.0143260002755041, -2.3587976560593544, -0.4004485480127264, -1.2545710478950118, 3.2034427030101345, 1.231338769404574, 3.9110307668100592, 1.080860234667449, -0.8579339877249886, -1.846816910253902, -2.2086258719888363, 3.4861616052146047, 0.04696171473531563, -3.0160653004995805, 4.274448394398655, 1.39101720970964, -3.0778221371986483, 0.5303942885870642, 0.5277865053572738, -1.0463870279156056, -0.26812169653265483, -5.222324745312536, -0.9929897458425251, 2.9577051973311397, 1.540217744912778, -1.0106071251432072},
    {3.3211440471631817, -1.5783593338723385, -1.6277402560754772, 2.942050916182663, -1.1879083880197772, 0.8367255780146075, 1.1087992620148814, -2.093571301843968, -3.169114814708714, -0.7673406186011368, 1.0694509947521829, 0.9373560226290304, 3.4891974812670026, 2.8082779600923, -1.2095752347448603, -2.035469240923654, -0.47467166128033644, 3.1093255588869066, 0.10525463510263461, -2.9597589585998905, 4.102680666942149, 0.33505726317960466, -3.666583327078318, 4.204598124712177, 1.7267317083867995, -0.683710422042699, 0.5472512429002414, -3.6593652323997423, -0.9535876857317485, 2.952221295751258, 2.283674512263824, -2.1992425638926036},
    {3.037966831878857, 0.21912120018145792, 0.5369558234355954, 2.4216441068071144, -1.2663534546929338, 0.7072944279594486, 1.7780898019601699, -2.259082268834304, -1.7203710201148845, -1.7457170177121997, 0.8559740040605434, 0.8489017376147953, 0.6149798128552594, 3.3582052290086812, 0.05115047311027055, -1.8620313537080004, -0.5594630494866669, 3.821062174874836, 0.08021820270360287, -2.788213235161043, 1.2340100843635302, -0.19121757966647304, -3.2915607504798445, 0.7774039327275484, 1.02625420070801, -1.9011409247676025, 0.12854704839058348, -3.1153201106573656, -1.14472826347212, 2.9019040608433215, 3.7449254114961943, -1.8235479717814778},
    {4.690168852985781, -0.9868683590673807, 1.4235313549858104, 3.040106531384025, -2.3927519968592112, 0.28885287329740683, 1.3028773516776164, -1.690730571763462, -0.04841980446658367, -2.4080784722480844, 3.89918488510357, 1.6927090604448647, 4.914634977539212, 3.4022726255801214, 0.23728052657726165, -1.2107476761137619, -0.8085425560639352, 1.445562216654495, -1.040859689010294, -2.8908522295742656, 3.3800900239293346, 0.05254556750382882, -4.515089459907675, 1.693248564463109, 1.5710161557012374, -2.4892026308571222, 0.1560783290495905, -1.5754107496501168, -1.7285460126569623, 2.4906406797167193, 0.29354868672757156, -1.508727148522114},
    {3.0907791719911035, -0.6060888903752487, 0.4242173635117426, 2.5579862223098155, -0.9794346056534357, 0.7532472912837798, 2.2079484571855206, -2.4244956373951374, 0.11153674305927762, -1.692105321129609, 2.909635214018834, 2.8615691334900992, 2.8003995383877, 3.629044664935176, 2.2144306814075674, -1.9921198575501977, -0.12459896502164312, 4.846513546491647, 1.2254737163601632, -2.166772919046151, 1.8155999643835716, 1.156437509843552, -2.987246386350869, 1.082077948332603, 1.3880384648315065, -0.3651235710688223, 1.6142945068644705, -4.005377899693643, -1.1226371219391404, 0.81353180480919, 2.32204998643104, -1.8135187371661532},
    {-1.3885943242594854, -0.8109990814002119, -1.8661881146787593, -0.6542698363219562, 0.5835172925447448, -1.8472036793560607, -1.50667177830575, 0.8906752076288836, 0.5642480762105592, 0.39272198291068416, -1.4955099946800179, 1.1657839725625423, 0.2572029224716305, -2.732260282860918, -1.1536472051125501, 2.4946880797579145, 0.8782663011330809, -0.07603787212408744, -1.4275051741180762, -0.5173753779405592, -0.38945210709434025, -2.294468443478754, 2.237676216670451, 0.03962268011247204, -0.9627693628419531, -0.8117914717810231, -3.7433008752027654, -1.1148784954164388, -1.8900313633274413, -1.1080586573763056, -1.3903521936342078, -0.9235621255669271},
    {1.5539865811161147, 1.149696373883266, 0.1334988006972595, 0.1922651797858398, -0.5176045976901797, -1.6280707672705488, -2.3429745515157885, -0.7839619266808194, -1.5029223388035933, -0.9453277788933725, -0.2869955834573424, -3.477625035206602, -1.0425390362350797, -2.106472516068889, -0.22900291217159938, 1.5055621910891257, -0.23511341830598942, -0.8245431450094363, 0.43350780465794564, 0.7748085875922568, -1.1029630523508156, -1.2459400956936255, -0.8773918404739071, -2.34781382805645, -0.3187893401084407, -0.854282547397955, -1.6732247589782605, -2.6578350839517806, -2.2316848496455317, -0.6229647294363362, 0.28564304102679916, -1.2459053305631111},
    {1.1811473505336982, -2.3055976967350285, -0.2069021231186915, -0.27395362104588267, -0.15586493440068197, -1.4330673709362538, -3.727033338033172, -0.018914978451461895, -2.444067825335223, -0.0750994777628131, -1.8507738297863925, -2.091622991769739, 0.24381340291871298, -3.191334097640966, -0.27338956941253106, 3.0057621615618735, -0.21793486602631926, 0.10169160674671927, -0.6864544900260767, -1.5854428817953403, -2.029755707888524, -1.9305669598450244, -0.664032414615732, -2.6097566707524824, -1.3907907467320237, -0.3225457380472779, -1.4696879976149027, -0.5939166849124319, -3.29376854499064, -1.0589346009482372, -0.11958447775739976, -0.6033590042690103},
    {-1.1587998355241853, -2.2887215907321004, -2.3112031356645106, -1.15710428535183, -0.9409946805156982, -2.2540722857525624, -0.629079705670813, -0.48465699864036016, -2.9995915426081536, -0.7658678038945808, -0.6228604761069986, -0.8998974931694448, -1.1950918668850565, -1.397210472635386, -2.3755597531505535, 2.690683696701212, 0.8243757101441652, -0.3738723760323257, -0.833915831082785, -0.5247585470019762, -0.009671845577717527, -2.718310503482151, 0.06566724496580051, -1.214010234277887, -1.8755720098745992, -0.9158267808974748, -2.20267319670244, -2.569407057221691, -3.2523825119047713, -1.312882315891043, -2.544331714479479, -0.8995429726757685},
    {0.08297566653923555, 0.81429924299365, -0.3148238714781973, -0.018310824550903677, 3.3239742401822205, 0.4256022425229261, -0.14802759110129257, 0.26176508594818154, -1.270622333007588, 0.9854855458592182, -2.2704670261428794, -1.183224151694547, -1.7498124714330847, -0.022632257169918995, 0.28818549089257633, 2.534858468100523, 0.3879698822659845, 0.3944964085772793, -1.1418829631575869, -0.03465053216682973, -0.13701917775094555, -0.5093776865777705, -0.9261727640907278, -1.795931466313496, -3.734152452765304, -0.1412422445498641, -0.37198860632712677, -0.25008464305504, -2.429407654463323, -1.4998710612002346, -0.9920245781486564, -2.6327133413822428},
    {1.0028068657492177, 0.6411558235728303, -2.19157406058505, -1.483830613778239, 0.5962561332866997, -1.5044170316263066, -2.0637032794114454, 0.3196763329822503, -1.370689012634963, 0.4535275855456443, 1.5692439476356612, -3.072414670516588, 1.1537894159066413, 1.2129753666735552, -1.668902703585599, 0.7481051077824097, -0.2611729486310097, 0.9828917883931909, -1.1487224915731584, -2.9104242616645157, -1.213133831767631, -0.2761347336914544, 1.295948875913934, -1.5226777047464768, -2.7296242479964916, -1.6355769252622465, 1.1757696784906604, -0.39620451885263563, -2.8305293610584594, -0.9434329602662053, -2.0957494314973686, 0.17398858268018244},
    {-0.658101682712658, -2.0877808170255268, 0.613594239492321, -3.1884253912243388, -1.635649925663275, -2.8948974505063303, -2.9087218292183348, -1.0663482085057256, -3.0029373902396443, 0.17214660894366224, -3.8595733315291327, -1.1552953104479986, 1.1689103836358983, -2.028808588660199, -0.4330342044447858, -0.3182861952624535, 0.0742799756965172, 1.253967319024337, -1.1370752438616134, 0.6498714341623647, 0.37402556905374135, -0.15938289691577506, 2.1411576624329482, -0.1331958038863177, -0.3911054920893398, -0.7621072196655609, 0.1900358131086526, -3.3997330512848984, -2.8350996973157563, -1.265908217422423, -0.16160669220217574, 0.8746262335330278},
    {-2.4716258441853416, -1.1725803192203, -1.7556554860761024, -3.0513722432770614, -1.2033646561761346, -0.4073345256786334, -2.2413953620743072, -1.3068457799187176, 0.47343479821792106, 0.2136809149588339, -0.42201795919442314, -1.102444515598397, -0.40855461840132673, -0.15914733997206687, -0.7034882885718237, 1.9745852193169906, 1.772050238514376, -0.7953295760416368, -0.8049181668858523, -3.5848074340238463, -1.3411999718785363, -1.4403343552844172, 0.03386246704092815, -0.5763559034515932, 0.8153083665901664, -1.6637392237968063, -0.8840698223925721, 0.8849035324448028, -2.4378827364769933, -1.3784987515676996, -1.213158541416251, -1.0371270977382543},
    {-1.1124756240121836, -1.030933927419625, -0.38223456807037876, 0.5732818881774006, 1.5210329247351384, -4.093860305791808, -0.9805931450505693, 2.0082949437887296, -0.297376404636075, 0.28013460090035514, -1.4990309507872506, -0.5169778194436749, -1.1860130013520722, 0.05960976171812163, -1.2892169661783957, -0.9010872763731272, 0.9543090534177772, -2.191310570707321, -1.402303530090283, -2.807268626039687, -1.0796502258604954, -0.40346706947673583, -0.7538100231904509, -0.18600868940364262, -2.5849298526633078, -1.2412693066766163, 0.8677351180281703, 0.8451250295820937, -3.212313020852744, -1.328750835645862, -0.7073809684469416, -2.010930175297747},
    {-0.4234007880728009, -1.7912475910438135, -0.5593413804548742, -1.0756230507785973, 0.6015388573335058, 0.8028290011989861, -2.5535469814749856, -0.18641872926793338, 0.5063158437903349, 1.9940444750741877, -4.0873531187566785, -0.4937802600962356, -1.3923179994281791, -1.489935768037251, 0.5109749706580997, 0.7402377849717116, -1.2763014909561743, 1.8919896133544194, -1.913521499160369, -2.3529433696564834, -0.7258733033626332, -0.08380293438969151, 0.08540492729397312, -2.599671743389501, -2.482347560178049, -1.8496867745902936, -0.49139614336069765, 0.8252407231167882, -1.3135042293288657, -1.777600915380569, 0.9423967625330606, -0.2456382782636483},
    {1.8958511107454252, -1.7854657249185595, -1.930041045602364, -2.0822858526402332, 0.9556521951299548, -0.6863150997340831, 0.7449400103987841, 0.282411818225731, -2.92046915336643, 1.1146289984898363, -1.6062840874576634, -0.5984063659929542, -2.5687030400671915, -1.573307779509628, 0.02309451617742178, 0.9747806260330175, -2.078109620502986, -2.6625834189126323, 0.000809015475981034, -2.3842568260064656, -0.5037468216325558, 0.05840094987477334, 0.49530288630033587, 0.6094645303486972, -0.11925688302493874, -0.40327264359691584, 1.4846663249816798, 0.0946220770607709, -1.4798337787814924, -2.541764113923032, -1.796275981111944, -0.439871190624515},
    {-1.9087413704817922, -0.4167674489617143, -2.517302196275826, -3.108603071625787, 0.7907115975241661, 0.5541628139033355, -4.150870064030535, 1.064823132194119, -0.02081237604197549, 1.3969949338963175, -1.122678052436121, -1.5856484707155782, 0.7325960494994199, -0.5446961371521221, -0.6424223403968765, 1.1033301311634327, -0.33360768251529715, -2.0493938661877538, -2.0268204865736483, 0.9680879299919288, 2.2477565478364414, -1.5389233097679509, -1.881415580030746, -1.225440078298268, -1.5372583164373586, -0.010574854098455452, 0.9422731443049505, -1.3167941751351555, -1.6696919108150892, -1.2493649988320465, -1.4326543439682813, 0.9269059894908679},
    {-0.9874698158275577, -0.03463964046826324, -0.5027467870938729, -2.376386753482969, 2.397435281720882, -2.8393622680642445, -1.0708453665483055, 0.519030387772619, -0.8225876588050288, 0.320858407885724, -1.771481736146082, 0.056819950199607366, -1.4526422444674452, -2.0727728168238078, -1.050552836829127, 1.8381649964396374, 0.2823768878672096, -0.5087029958046685, 0.13783857201059668, 0.5210184548986193, 1.7189703647668229, -1.0531208613354048, -0.8284545535238315, 0.5408693964366368, -2.083563739957681, -2.1179587671896507, 0.5714996077221439, -0.044417882467618054, -2.3096800938401785, -2.7390591702087, -1.631244974338021, -1.0719942857456044},
    {-0.3689789470116926, -0.5561830575168818, -1.167227439342965, -1.1810476575387547, 0.771512940585233, -2.9102097277208117, 0.16987973293735492, 0.4545210018418937, -1.3628095495978425, 1.123341117101595, -3.10058486378165, -0.7471374304031382, 0.0702801657323851, 0.0729486131085834, -1.7457346084720948, 0.7946236251023256, 0.7641630323161258, 0.8581213720475437, 0.12025333870388843, 0.5927960988495187, -1.0515322282922566, -1.353728082262039, 0.7561612652239782, -2.14752631743124, -2.919305485099553, -1.1547381170623854, 1.067075198195123, 0.5017571527347562, -1.5754995650841166, -0.08929121597149588, -3.128940221874333, -2.683618493213359},
    {-0.8703374266274456, 1.6036404415718948, -1.7168690347989384, -1.2606060085153663, 2.3084754246105095, -3.6968806029582155, -3.8447135501889425, 0.5754093500753316, -2.3578432456832124, 0.6540024976500738, 0.47313885374830006, -0.9701083036100279, -1.3131376014558718, -1.9490492742884362, 0.7321499671615094, 1.7342795085620635, 1.0482978533399827, 0.8788416165934515, -2.687355371928109, 0.8955946659525286, -0.6415542931530396, -1.5756382456736058, 1.795684402670706, -0.21350262652415905, -2.5181608466444927, -2.127483934661723, 0.03300872267688616, -1.409578393122276, -4.488089981630424, -1.496864473247189, -1.0514512018913935, -1.0648621451238907},
    {3.2620471078893947, 1.5171885035120056, -0.7172629590639913, -0.08821399011852533, 0.7704326718484605, -0.5830942604746685, -2.7793894460814412, 1.2886896196337692, -1.1618575972745908, 0.19255490060960254, -0.46312562434489296, -1.14155116268711, -0.35540097256615294, -1.1548631783099554, 0.9389883937453057, -0.49599064895321615, 1.7444671209636324, 1.2091097439351388, -2.130842715748314, -2.80230960494948, 2.4107275127798116, -1.1868051880622972, -1.674093038691183, -0.9625627192059563, -2.089303846942285, -3.151327406484454, 0.20192250943259046, -2.6869959788820785, -1.6379354675200803, -0.6881855293041725, -0.884709236008656, 0.6176395951291976},
    {-2.844024698020318, -0.7341501452638126, -2.8128091056772098, 0.5925649896567617, -1.0362394480104669, -1.5571181847719928, -0.8233807234655637, 0.12579779488012668, -2.641133070138306, -0.1361949605946355, -1.2723813954601029, -1.060897836138299, -1.6384021148562973, -1.3269809711656748, -1.320260015432558, 0.912690451837353, 0.10488282370923613, -0.7622622924078574, -1.9337130418183266, 0.44385962812844026, 1.627384954314663, -2.6626580403121323, -1.6829969023133415, -2.383841447561478, -2.5713697631292916, -1.4259109172179993, -1.177970879209413, -0.36588731129200197, 1.0019346893063674, -1.103404808525834, -1.6643517406618331, -0.3441366900982429},
    {-1.1085015390340813, 0.8421205425141787, -1.6872283821031768, 0.07367287089049618, -0.16271807756124174, 0.9779151186975521, -0.5461910461549607, 2.925799564840903, -1.8854230385175517, 0.27891343896330917, -2.8142807025423298, 1.257341706182846, -0.4953439874477479, -2.050703587144371, -1.6816890285390786, 1.3056101710147645, 0.6755101565532562, 0.3160556644395931, -1.755345122208491, 0.650402028864613, 1.4381499021599065, -1.6491757935752325, 0.822002764654092, -2.090731964034219, -2.8475649602345787, -1.382306365544236, 0.1859558107265618, 0.7233425939661727, -3.0473605398798056, -1.943317036042537, -2.2257639610273254, -2.5238753350310668},
    {0.16101654791483838, 1.694669420082509, -2.873068507097209, 0.44532609626456676, -0.25415580421292766, -1.5037450473848029, -2.147826147604506, -0.1025955905714185, -3.8147845486155196, 0.1206130269217163, -0.9583827876394546, -0.1970977601703862, -0.8504869938126031, -1.4621832352914221, 1.6814149947293653, 1.779643576962349, 2.516095467697255, -0.5609240675506194, -2.8894887417370496, -1.5588209379675282, -3.1716897326098534, -1.5214251152074247, 0.5498444714433574, -1.620037523800468, -2.978794538716929, -1.0639813856417675, 0.6038271526733295, -1.6508647551610736, -2.032899813401796, -1.8487267325338723, -1.6033398653258233, -1.978510205531209},
    {-0.34946129688891264, -0.09134696055178777, 0.26498919231264995, -0.9022153109663487, -0.6034296221533754, -2.1187068860723017, -1.2433917628058495, 0.8608331953140009, -2.1438277719240597, 0.3300229864648601, -2.7734913599857247, -0.24346167287827536, -1.528913919795399, -0.9986814102827444, -0.32653054539161586, -0.9738255956598199, 0.5234977325271801, -2.1802190052492754, -2.2264780115101432, 0.18197193260796019, 0.7020338201569248, -1.5957195380648692, 2.35176080593767, 0.5802886946506263, -0.8151337445150526, -2.978771352562865, 0.1596222151583872, -0.09340957831408801, -2.311182395796121, -0.4898957815361389, -2.386256715888772, -1.176779387148959},
    {0.6508474528084462, -0.6714019544846869, -2.127781342634191, -0.3635878691857276, 0.5590994971501015, -2.7100711683849057, -2.0986180966981403, 3.84788785568472, -4.556835788954587, 3.889035318686331, 0.0748078398125166, 1.0452136886882686, -0.7123992074658713, -1.1399710673558112, -2.217703463008915, 0.8742325578882716, -0.3165649525272697, -1.5662897526390243, -1.4839456131116333, -0.24785593714796741, 0.980005835204589, -0.1474141309951646, 0.5154844341921204, -2.1256500967775476, -1.3665240318305387, -1.9855348083454927, -1.7402743262570646, 0.630835121508574, -2.5981315692385554, -3.2722457973938854, -2.567181118036989, -2.6365384166977557},
    {1.6121564583150114, 2.0646427273779593, -4.389442707286097, 0.49477071710860643, 0.6697481404359396, -1.4470840553557736, -2.2620801505801547, 1.8791364435779185, -1.9390262046465563, 3.2882605912164586, 0.4515682224998156, 1.0222485667885595, -0.37739105397432043, -1.9729657336212858, -0.7070157435124734, 1.8924262949154667, 3.178711935406309, 0.38012568948867037, -1.0613826062306373, -1.6440425137942853, 1.9461534233246194, -0.07360166839400031, 2.701422354104339, -2.82565225098918, -3.9443301414522254, -2.658224015690968, 1.1389002762047509, 0.7824651475600236, -4.2859222594670126, -0.7127450073122721, -1.8618020339001469, 0.4277187561179688},
    {0.04348378536283435, 0.8868618135648587, -2.943434091438402, -0.5411365286695021, 0.7016370563549255, -1.039308199703876, -3.1042745110866914, 3.1837248835078595, -1.9487204774911955, 1.4415725933242465, -2.2779670598105755, 2.513591065498904, 0.577922905574399, -1.6433688700614386, -0.5288716387121966, 3.404913855386525, 2.793026111201649, 2.974546410105327, -3.161776153255253, -0.5557413695357616, 0.01531786190554815, -2.163839085778907, 1.3421695491368086, -3.1887321075570223, -2.5109206687025907, -3.5910400027783362, -0.2040394343989605, -1.6182231431844067, -1.7579633603796814, -0.0011003798323560195, -2.6062345868017585, 0.4941056868249444},
    {1.2723975829672027, 1.175305676829858, -2.770773042019519, 0.19692385904948234, 1.445227300953984, -0.3254936931935371, -3.0512756058197468, 1.4073026913902311, -4.077318559302622, 1.2826449939265545, -1.1817790670844466, -1.2515433429196656, 1.943553605671112, -2.8867902663856384, 1.0003996079699689, 1.82763318393454, 2.2469070388082715, 0.7724527704945542, -2.4384141611929055, 0.9221000574117709, 1.3912010718440762, -1.3254559919968059, 1.0020190641746118, -2.8751450872148077, -4.618536026699268, -4.073223539342353, -2.0462578156079836, -0.20034335489001232, -2.67050395380197, 0.6299328377346252, -3.5006231096947853, -1.9630955342034562},
    {0.43682071024525854, -2.2552135313191863, -3.948270063314721, 1.4431724856017638, 1.095240408649954, -1.1506348163479099, -2.5610031443715373, 1.2214424506202286, -3.668826135712683, 1.4203705272646405, -2.577786438054093, 0.08115362515499448, -0.5050265817595014, -0.8438125223885133, -1.2999206287910798, 2.3469367605188216, 0.3128644746856411, 1.9356061493663752, -3.2500565706004108, -0.6715509810517111, 2.1424504352761504, -0.7735933096483291, -0.5767825181632746, -2.0725827881982832, -3.0543270835401297, -2.9179197223430413, 1.2722208017614585, -0.4469776689578746, -2.604322657392913, -1.4431144820116049, -2.304979566680712, -1.852388415067787},
    {-0.5462751738361876, 0.5327055506135504, -3.5244199781179066, 0.38254394773112166, 1.8003640221754906, -1.325465039896855, -1.6850306066409877, 1.4863103788078174, -4.912152595031723, 1.3635431157130204, -1.1935476325270427, -0.8829214548527348, 1.5458197661806947, -3.132311733497242, -1.3061732752292732, 3.4297176460616265, 0.8460213687630218, 2.718681212737873, -2.301362962714996, -2.2908863819367222, 1.1766673386526816, -0.08195162786879667, 0.4495239240596457, -4.535617574464628, -2.4263092051442, -2.563764541368754, 0.29611625944526615, -0.6505090465120521, -4.208102589394595, 0.3826454460422614, -1.1947781191600566, 0.11590539785144548},
    {2.6236766387925488, 1.4914094725779585, -3.006813958576743, -1.6992493352450935, 0.6577051948588059, -1.568853093469783, -3.976364055381477, 1.1802806950233118, -3.02514516483584, 1.4959287679450257, -1.613858227790072, -0.5177253622103796, 0.44550407228304945, -3.4110116484770727, 0.21710056284222942, 1.0644861170378002, 5.063642755436605, 1.62016931982516, -3.3272648072467406, -1.3625397440991607, -0.11072565246058111, -3.244118860303025, 1.2317080615469642, -1.3942104403586886, -1.6267982454940937, -2.777094376573508, -0.929549930227267, 1.129540359413063, -3.6869545643967934, -1.7560844202029116, -1.6017352068610557, -2.833179021406022},
    {1.3143029475283485, 0.4593906244042337, -2.2116904003463227, 1.7312181521395256, 2.046918979097749, -0.34075352126690855, -4.912013155185561, -0.5984030408583269, -3.292761635984825, 1.7142120578944067, -3.318541627383078, -0.5480866479880769, -0.6634612158151162, -2.885566363660265, -1.1808521645744603, 2.7525406752706756, 1.2211290346925265, 2.1994470343189345, -2.861953917021774, 0.39558123323258737, 0.16443374837548902, -0.8033749089285174, -0.3700328858280935, -2.317918681600953, -5.72330155092315, -2.4147264427982207, -0.7928607844695292, 1.1348503015341866, -3.3986119341725307, -0.45543567560230586, -4.329132246595474, -3.50678617686217},
    {0.968829080558975, -0.06897362192890041, -4.278661166972713, -1.65462441743371, 2.5071528651676607, -0.5839203521684878, -4.121747564382564, 1.6797693095696653, -3.2760443995955795, 2.1898604826652495, -2.742661641313821, 0.0885530235319518, 1.1907652289267807, -3.8271086756140753, -1.2341566730397078, 1.1772942046255486, 1.226700204918353, 0.6483072229654436, -2.5183056859921233, 1.138628124082969, -2.0202635291422917, -2.8214350396985752, 1.9784297131684017, -2.5273791201319407, -2.6223283366718717, -2.7105764658680442, 1.150309035608449, -0.8226365126343912, -3.2627799174938357, -3.383877654353747, -4.093349619959321, -1.5147789829883935},
    {-0.651489203329583, -1.0625368532054282, -1.6081203048005321, -1.0224843140177458, 2.3968033930837143, 1.017456083015851, -4.579950046363661, 1.0154715227682638, -1.513695997916804, 0.25335354114445485, -2.252284931097722, 0.9350736951584248, -0.7872461794304527, -2.3434435689163626, 0.08557826970797626, 2.047945393815772, 3.1330838713159643, 1.1491093490743167, -3.040783003888621, 0.3288156312011333, -1.0660494871241504, -2.6461785039924957, 0.26899938113357236, -2.2424541249444423, -3.0853402053427135, -3.2153335469125435, -0.42504554381097426, -0.20515932267175915, -1.6693132801850823, -2.474222723565229, -2.2399973639591475, -1.4176303459353206}
};

static const float b1[32] = {6.430712894895404, 5.786283255921689, 4.429417442793049, 5.874945992238787, 3.7283810931770205, 5.500578404069904, 6.28296996870761, 4.4794909744582165, 5.831487123079906, 3.337711741064127, 5.9045796543278, 4.36057742244679, 5.184249518600756, 6.216116443224357, 5.899002419783431, 4.545557740103889, 6.219189288948026, 5.559211993684361, 5.540855286676409, 5.247678404323846, 4.756382341718982, 5.496052928599197, 4.896742906183758, 5.453941536296094, 5.680817687797328, 5.9045975201090615, 5.475105522717749, 5.722685207077426, 6.351611349367441, 4.998004179375571, 5.664775296527735, 6.172306675975963};

static const float w2[32][16] = {
    {4.0716609052227835, -1.6435442599609957, 2.470017684729804, 3.1856872077682867, 6.47150274534178, 0.781263472131016, 3.937608469012669, 3.831447956059951, -1.3494725885035925, 2.6934018541018587, 4.0969069530322395, 0.4058456630726478, 4.035106103030382, 6.4526859471676055, 2.861117028659676, -0.7727805528789091},
    {5.460370457209559, -0.12702834608240018, 3.5777398752016056, 3.0123646015968886, 5.138286616142698, -0.48701308976965135, 4.093161821824915, 3.8617538738121837, -1.2834613335972274, 4.5071333475173505, 2.7109819678808065, 1.7197444681456073, 3.8367073665601894, 5.009427646798576, 2.5033028989036024, -1.8992860574470916},
    {2.252623930011309, -0.695075623384378, 5.686452847169908, 4.983609375149153, 2.8586279802887673, 1.3642070886292084, 3.3308853251008053, 3.4988347843860415, 0.8462908888550983, 4.249952810023798, 4.896199549666624, 0.7909915387798063, 4.393928385330525, 4.883795716392621, 4.981526995968436, 2.695376028789915},
    {5.786865452511604, -1.5822944985440637, 4.150235461425587, 5.858033812920857, 5.340351999529376, 2.092468364898129, 5.114391028825447, 2.5628468401545734, -0.3247547645161807, 5.464311846600547, 4.018490885160704, -0.8229126763396112, 3.015649344284194, 5.4209252910259265, 3.474990952795601, -1.8923183526426457},
    {3.297392307097276, 1.0516347128285082, 2.8344111929009723, 1.1469939531547773, 3.486527578297936, 1.673988816450729, 3.2396403380727308, 3.0241392580912914, 0.3472034277455618, 3.084436998848938, 2.9654638262343846, 0.13659273363783783, 2.8497612733978013, 1.9524729679155155, 3.2090817559342733, 0.4032048394062756},
    {2.620519921903091, 0.6088577318657866, 4.583188493860786, 5.248259287214984, 2.4146646494784147, 1.1483414042865427, 5.534168942463069, 4.182881227567783, -0.29728707324750697, 3.6495066818893247, 3.3176447020324997, -0.08058564058582356, 4.86154810814029, 5.381567203804191, 2.6743219339461044, -0.19706627552497688},
    {4.850531803172949, -0.6966761410267258, 3.9658787577551444, 4.612403740475262, 4.941442163977743, 1.4316656343996481, 5.111167789756621, 5.769132447278878, 0.5717120884753835, 3.896343049691897, 4.3147395046248995, -0.28821358767670635, 3.300766726219131, 6.8998604011333535, 4.407706866353375, -0.053318493302743734},
    {3.588080708199973, -0.05849319943099792, 4.574694458118949, 3.4176737059635216, 3.5016197139151672, 2.6793919464515787, 3.711353418129623, 4.1698024031686245, -2.4887238247342154, 3.63353706623905, 1.6179796496486887, -1.85204933183204, 3.868373075399055, 2.5276882294804204, 3.2662739107284087, 0.7128857783981409},
    {4.787599882305262, 0.43022126762156787, 4.531022448388824, 3.3773879555726274, 4.582408556709169, 1.8000389519603464, 4.361713158480448, 4.229793931302068, 1.1261433694714198, 4.285134714617407, 5.193577532567433, 0.3692164404163039, 5.20166003517821, 5.325247846734206, 5.212245818974329, 0.008277758870221622},
    {3.021133731310798, -0.28745316382909025, 2.0549951206966863, 3.3640703384595256, 2.219886905344666, 0.8388014508582373, 2.2739358831878973, 1.6674984711329401, 1.931997941831564, 3.928621325558389, 2.6387299958038897, 0.6306404132840235, 1.7484058440598262, 3.069246521627786, 1.1029450604417719, -1.7670906255530168},
    {2.8704002365913976, 0.6140397819537722, 5.585940343136845, 3.6042091728072148, 3.6084088349472903, 1.3587231771009711, 5.728377741016037, 4.175327264146429, -1.557274239270552, 2.2705728081340917, 5.230555639144476, -0.3817211081643543, 4.343593713520541, 4.836969402476655, 3.680384807835568, 0.5399233928292456},
    {3.6568134148660167, 1.0499109649157912, 3.91859025795885, 4.2111286473070155, 5.62616265077429, 2.4608647839755178, 4.10458672241022, 2.9016781151652533, 1.052972437513192, 3.9452650593573977, 2.647061730431164, -0.09294307242587178, 5.341507055998318, 3.2965980681684104, 3.871708086499535, -1.8478154515836323},
    {5.0627824253151195, 0.3643372489403433, 3.214743657851796, 3.9764192223758696, 4.160427704200922, 1.8840828496510567, 4.976541417938601, 2.667247803922609, -0.6285327685352682, 2.967963317295237, 4.377001834573385, -1.6599961150213807, 4.47791917961432, 3.7433773064689326, 3.667153942791494, -0.22922466196836908},
    {4.900646356850939, 0.364569342634166, 3.7402571127757986, 3.825031373476704, 5.311413994679922, 2.3015183051530803, 5.48474082636151, 5.852914859042395, -0.5494358222073925, 4.413582338144042, 4.028931879942299, -0.09457614858964773, 5.999082793782736, 5.924085207128845, 4.5202602938284855, -0.8830477170191156},
    {4.075286152522051, -0.40966595771403486, 4.636196010080627, 5.298861780788984, 5.000469938373529, 1.328862092026627, 4.974091258929464, 4.855123152292902, -0.7788492815920856, 4.304298936303208, 4.757127579070372, 1.3500615801319877, 2.5573385708211975, 5.3051274106450395, 3.261599663634959, 1.0950986859447567},
    {2.2236571136008747, 0.4325220495788803, 3.150766642873246, 4.952283238382367, 3.10471636466592, 3.5281468617966762, 1.791140214662119, 2.579788079508003, 0.4465056114351833, 2.1870312518560335, 3.6334901212968216, -0.2983298874078386, 4.148193317768871, 3.8451974963143574, 2.2526608343587107, 1.4806505106611911},
    {3.8938589188306896, -0.23526647452200247, 3.2659783378102274, 4.726523194719119, 3.976653401178106, 0.5724060967689667, 4.709561921412404, 4.0797074702977865, -0.8741876877538935, 3.9483614642171445, 4.349472911649652, -0.13219310996283853, 3.6181006782849567, 6.620562590213842, 3.9327583674374083, -0.444771705836242},
    {4.533061894743289, -0.17616297760623034, 3.699738734762978, 4.832412682239533, 3.842185976470015, 2.3887498993767977, 3.5341246745541803, 5.1213151903507805, 0.20444428036924214, 3.007241943496291, 5.295560450794338, 0.6505709167264251, 3.424355458130715, 5.6058389197981295, 3.333634122073238, 0.35112158529205634},
    {5.648898296813828, 0.723262377888956, 3.181194152229792, 2.816681898402268, 4.521351494692252, 0.5339972126373937, 5.316050548430673, 4.973435660307684, -0.09573814204067715, 3.7476579848697957, 2.155093233944419, -0.7089626863786339, 3.0886671818055484, 5.272658435524901, 2.8967123499476064, -1.0727777097837492},
    {2.7387932898766962, 0.679119721877767, 4.963591899582975, 2.9517564930210867, 3.620221016110269, 2.4208146843282834, 4.7791682520296765, 4.859829203496468, -1.3345620886571394, 4.118787431458329, 5.2179810979369075, 0.19556465571939333, 4.336958486195775, 4.451450637049706, 3.0429516121529923, -0.9762743855827447},
    {3.499652984189713, 0.6720065300625762, 4.50090414864995, 3.3261781195498408, 2.6181374828678003, 0.28270261566541244, 3.6901963634621273, 4.144257510122373, 1.1274134045663373, 2.703184116880507, 4.912457949087074, 0.15960761204588228, 3.3508726032000027, 3.464949447537748, 2.7383474142859017, 1.2647024807738039},
    {5.077055363512264, 1.2963732714724965, 3.534548012322351, 4.196865076186845, 4.745640850333469, 1.4204720244927405, 5.112765312880368, 4.355365920117246, -1.7261341305304245, 2.2327887847611785, 1.7710530140363292, 0.2138036598924413, 3.647152341295981, 5.208338304101472, 2.9975019404352325, -2.1695499342328253},
    {6.447584800170375, 2.7986625268000624, 2.633094808914328, 2.9451163971400884, 4.5131640794211405, 0.47023907981678886, 4.609988808705326, 1.066048414856795, -1.1146906899258582, 4.356699344301652, 5.120775200894992, -0.6089516305493005, 4.06296570408016, 3.6027397513257813, 2.7275524421196438, -0.14796676004412837},
    {4.893309069419116, 0.5699942483887851, 6.5289423218804465, 6.016424938460103, 2.58717592207118, 1.4351330597373195, 4.9467247656639355, 3.4802375970095736, -1.245148989387135, 3.4568442086100983, 4.3726703569230025, -2.260707052541516, 4.5331709699382055, 4.157589269637067, 4.1401370480327255, 0.25941278466807316},
    {5.2342294766432484, 0.02427517869526563, 4.780282390081428, 4.131875056406741, 5.00672825510797, 2.460203094166372, 5.391524758919594, 3.2484779523866556, 0.27667702771107877, 4.4185759836156215, 4.41196039184986, -1.740769277448961, 5.546932522962121, 4.296672985642869, 5.580663206960554, 1.0562308587199536},
    {6.731760837861975, 1.4716911177179899, 3.5934960023654186, 3.4473812928026226, 5.193723817249205, 1.3247811512856842, 4.414566064582885, 5.151766549040318, -0.9332694303934639, 4.105828625943213, 4.751569002775925, 0.032334006175308724, 5.942053834425869, 4.906919515005431, 4.566387480064814, 0.22498953528600368},
    {2.0708332360274575, -0.498885796111507, 3.8218710861344714, 2.284143849471982, 3.5417283637842227, 1.2131745122366948, 3.1597999619812978, 1.9775521545418981, -0.2333697028965322, 2.881373556691971, 4.196718206685997, -1.4292337804377286, 3.960853654074784, 4.599305410253906, 3.7653346713441067, -0.34940126548357514},
    {4.714919146783633, 0.9928169653968163, 2.3304839721475687, 4.018553544635231, 4.3049433730871565, 2.4899754779835797, 4.517429094618802, 5.209854502790378, -0.022352201226937957, 1.3963231834756522, 6.262262486563793, -0.3587491070686093, 5.209183627740227, 5.21484105723471, 1.846284758616009, -1.453232083276741},
    {4.934520430517381, 1.2662047451030116, 4.25304445138664, 5.2714501756764145, 4.278880138099525, 1.5508934291857157, 6.248543426525069, 3.9427394198387615, -0.5306838055536152, 2.311768650004279, 5.133728594302118, 0.04477473784399741, 5.685342509140575, 5.725115545436092, 3.394639647613411, -1.8678343467239522},
    {5.5217865603778895, 1.0390700692168806, 4.2956642868694495, 3.7848512438104596, 2.8795114404642304, 2.3207912516391302, 3.8300152120395445, 3.981627164537385, 0.9389324510664218, 3.439676512248617, 3.6979830949601884, 0.20329968179149374, 4.844220322945038, 6.273689421708206, 4.405670695451447, -3.33552373947085},
    {3.6914940654162938, 0.4552937725681337, 6.284719545069539, 4.497849374425886, 4.699938812004383, 0.7015925916248933, 5.960676593039193, 2.026612868466368, -0.06992440676251153, 3.7420203233875697, 5.479469353227411, 0.0010354198486108724, 3.428182116284298, 3.9278807536374267, 3.1891563151425903, -1.9034657729006008},
    {4.18963413059984, -0.8265012789296007, 5.220063375578847, 4.2355596203632535, 6.373472983236536, 0.7707099131078389, 4.418334070764569, 4.36978391098806, 0.23474503301286134, 3.367855206217908, 3.501715374515567, 0.7789577740438742, 3.0498132682310786, 5.445239138337151, 3.8765984508186735, -0.5798680691780628}
};

static const float b2[16] = {5.530432186469039, 0.6051130803716492, 5.549816905839891, 5.215606992165027, 5.406404631152608, 1.8618769575427034, 5.645506242787373, 4.585484811405182, -0.2812722439049717, 4.09064174896923, 4.881050752050905, -0.24372549242714123, 5.1078668601594766, 5.998447550572404, 4.6418163564031385, -0.47352413950153427};

static const float w3[16][12] = {
    {-3.4681343996999194, -2.331145557189973, -2.553373968287082, -2.0969688000972906, -3.389024220530017, -2.469703168478041, -3.504161105480007, -3.319648426965599, -4.709088779354001, -3.416771691627264, -3.659452392355193, -3.098541564953591},
    {-1.1658848780404936, -0.454935138485134, -0.37039978016926056, 0.6912156417328201, 0.9985330423662607, -2.0448980040241636, -1.1087730297260756, -0.9368766746054976, -1.477801456342384, 0.294065546979048, -0.9218119117425302, -3.0930269051106465},
    {-3.2610676356916297, -2.915803976309027, -4.370351584840911, -3.1536592155479486, -3.5407534821258855, -4.362783963714733, -2.0222073473629663, -2.2608470881181875, -3.5320907322667647, -2.66119292293275, -4.431163526154088, -5.074212116521933},
    {-3.1312954006691665, -1.8723542205419739, -3.254765686834236, -3.200601659339333, -2.9114296082788744, -2.3294156966436645, -4.00215645580171, -4.407778106007177, -3.7892524216842722, -3.724828402771296, -1.8712611632494947, -4.093422975182682},
    {-2.9166272487586786, -3.7107494249258286, -2.6887494353187913, -4.226398503236621, -2.6448381619815198, -2.933570852654175, -2.400047493809493, -4.752781394015429, -2.4617014127245924, -5.9228948358863205, -3.9229199519741966, -1.7418527549495404},
    {-0.37911298119591597, -2.037309423966597, -1.7797263052209593, -0.03989033420501598, -1.174288969692018, -2.0295027905918968, -1.230984041067814, -0.7109456017626078, -1.1360213859303354, -2.259916712601488, -2.1003806986729145, -1.7066735063332241},
    {-2.6775690479471774, -3.897628937305233, -1.3459323754235832, -3.838028014880031, -3.478715126029437, -3.752382891125765, -3.8662327834867987, -4.266799451969963, -2.4232520821155554, -4.353128526331788, -3.6467902522653692, -2.574737862892564},
    {-1.7400522079909455, -2.4559879687403057, -4.7566853179675785, -4.044828685808603, -1.9266530815330316, -3.326753718617649, -2.145174967519063, -3.7574390428465283, -2.8893504162320713, -2.873852209248426, -5.154830412240343, -4.398830254279419},
    {1.896093501551981, -1.1383857075953012, -0.5988241323728639, -1.344787571194068, 0.37406303396399804, 1.1291255459535274, -0.3815360444879787, 0.6298882504455545, 0.9078205499292861, -0.5953620590043291, 0.698215866914188, -0.38201336533646596},
    {-3.2155211769333034, -2.767568085877974, -3.1801473337589186, -3.5923342567265295, -2.597896672827027, -2.46807765928713, -3.822973619586988, -1.376957888755672, -1.832517675448954, -3.2963497148179663, -2.4611155172370625, -2.1779885680002145},
    {-6.175243740984941, -3.4578703918752898, -2.7505149920531724, -4.867707203986855, -4.288712883005182, -4.263152006438934, -2.6448701035142665, -2.296050016063282, -4.463881220075451, -2.0057561724180077, -2.221650958532922, -3.4274219320147368},
    {0.07477061772150533, -0.0546026768924639, 1.0951358805699627, 0.0014512800660786479, -2.5392553685322286, -0.6181682672228007, -0.9710770422122441, 0.6074660345319141, -0.4638069764611401, 0.11823186549481253, -0.9975879989802237, -0.7938161036671684},
    {-3.911630423729985, -3.8011915556567204, -3.797418928221492, -3.1815825387981946, -5.122226887147318, -2.508215330499018, -3.5240571509041465, -3.6665511050235393, -1.9098346850826347, -2.3350494775744055, -1.522815350774422, -1.9358700558176767},
    {-3.654555396943554, -4.876424016492788, -4.4204186988097565, -2.380791938140423, -4.6061045767902815, -5.151958681709277, -4.674095159371604, -3.1576540094084824, -4.935296717845138, -2.3452286093258055, -4.05189346303316, -4.615666187822337},
    {-2.446282328047308, -3.6722902652284968, -3.3551480252884742, -2.567583163772453, -1.456620333150164, -1.890828823683842, -3.6411323676084733, -2.9862037911817554, -3.1078662001849735, -3.221426229910057, -2.957575701923709, -2.837393231023321},
    {-0.1553070423174349, -1.0476466341035435, 0.1977105266060785, 0.12737083129771165, -0.38789607614160027, 0.4296608693929863, 1.6614166767940823, -0.46896731237787076, 0.09153255238409198, -0.034028206555487106, 0.19609957956343585, -0.0355949909326826}
};

static const float b3[12] = {-2.8608538787722155, -2.6620379321788064, -2.427119964341338, -2.3759922143080803, -3.03898085298319, -2.521339049919703, -2.5343768384226, -2.6227267964408707, -2.306565942877161, -2.5126168941586156, -2.3117654183518073, -2.2213070874097482};

    // Input Layer 
    float z1[32];
    for (int i = 0; i < 32; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[16];
    for (int i = 0; i < 16; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 32; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Output Layer
    float z3[12];
    for (int k = 0; k < 12; k++)
    {
        z3[k] = b3[k];
        for (int j = 0; j < 16; j++)
        {
            z3[k] += z2[j] * w3[j][k];
        }
    }
    softmax(z3, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
