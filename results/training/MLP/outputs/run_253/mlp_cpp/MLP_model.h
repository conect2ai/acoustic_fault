#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][16] = {
    {-1.3958165456913465, 4.333251645599029, -0.030330759229531826, -0.7775644703227502, -0.28109635914024794, -2.2040429345339856, -0.905275397254238, -1.3918832394518157, -1.504947104105071, 1.3761485074279531, 1.8734911653887896, -2.137102664523804, 0.054532470149828614, 1.1153613346846682, -1.2061043805396745, -2.643862567023253},
    {-2.2738212819051813, 2.52844554915132, -2.090185945163223, -2.2029512404598544, -2.683716050876387, -1.4915769645163381, -1.8466275960921275, -3.389639103086151, -4.521367934925747, -0.2987242339092664, -1.5468452972060933, -2.762778643580533, -3.4729700789755737, -3.059281340514037, -4.160594852281578, -3.802587203046104},
    {-6.120137487995764, 1.2890748574680133, -3.8644539657896475, -4.994986118177504, -5.17947612986709, -5.2191356291058915, -5.340074270145707, -6.618663454312617, -5.644616779364716, -2.7265109023854874, -4.403372498706305, -5.581907028682571, -4.67144895058151, -5.34955916062289, -6.0970036767408935, -6.020442372382672},
    {-5.661492728255573, 2.2863576495978717, -4.964238275261757, -5.625274352447563, -5.949822904258153, -6.31490881261409, -6.194539849468064, -6.869642182724975, -6.177881051188501, -3.608324942167533, -5.147485687903456, -6.2727589350391915, -4.077397871542053, -5.571879812230323, -6.714407306086797, -6.300986362179889},
    {-7.082512559753395, -1.6706957146719918, -6.161685643816884, -6.875034633403262, -7.061392717146849, -7.295715767882301, -7.238880177516244, -7.487810079352, -6.730989234562508, -5.108774797072373, -6.692421479880193, -7.227961728080194, -5.379511345456988, -7.161357256328586, -7.37187275228287, -7.445729154428998},
    {-7.181049489318465, -3.2348497333694763, -6.135165650438293, -7.449511404750063, -7.251428324965791, -7.1579392824980195, -7.367997554809599, -7.86077841499004, -6.336805298536439, -5.637827670608434, -7.149092469154414, -7.188982061306353, -5.564448997742132, -7.272687787412506, -7.715958474062452, -7.111294411699646},
    {-6.864115251924179, -3.702191598788383, -5.867328072015791, -6.990909126863653, -6.982984913731999, -6.58580136312936, -6.953451480297607, -7.331652506891678, -6.251726266323644, -5.685252541063286, -6.8541438311384635, -6.711377095767674, -6.009890145389146, -6.941427206889196, -7.3971440634772785, -6.911347156480751},
    {-6.391398712438917, -2.964008268032711, -6.151220133066873, -6.56899147474784, -6.77402234389327, -6.406163280433541, -6.555368019094068, -7.133251013117876, -6.235356150067767, -5.360570344269958, -6.3536764670249655, -6.680492264670956, -5.137396645702829, -6.774325541453363, -7.155354086103519, -6.683809231152788},
    {-5.897894817178964, -1.279044483042023, -5.602973945860721, -6.142124965607618, -5.9498759578174925, -6.39825860864925, -6.262958751979433, -6.869567577938386, -6.185596079081454, -5.012527791105736, -5.702600601471685, -6.458375056074924, -4.992253915751862, -5.9538554801566725, -7.0183463163059026, -6.37891064047583},
    {-5.857382517919977, -0.4287501063559114, -5.436634845767643, -6.164663916405583, -6.286893510366924, -6.015274432151113, -6.148719281025892, -6.94557988556358, -6.981412945101408, -4.467778572193786, -6.073040553346918, -6.534408915948693, -5.793656701758431, -6.083954972606454, -7.192508547613964, -6.392591752946369},
    {-5.768480516705074, 0.39995172400373563, -4.784345932151255, -6.008273833995073, -6.070205371544024, -5.4368875237550505, -5.647912674474098, -6.55675100435828, -6.838885143305794, -3.744639317000494, -5.374318485278912, -6.065943255897753, -5.5790857809697165, -5.988214983229867, -6.2837616536717, -5.954849525095592},
    {-5.797542509339527, -1.196375119828264, -5.856473050888478, -5.8371546895773365, -6.288093991544896, -5.682636398626318, -5.511124872555502, -6.660977972101515, -6.798836935742175, -4.133797678267034, -5.83939090552926, -6.197117533479305, -5.690771224294609, -6.056858824193393, -6.473607618960064, -5.964742723048038},
    {-6.055309738630362, -0.5433139642078788, -5.73377829312567, -5.877749155540379, -6.562304577472054, -5.744512255828201, -5.841138955790791, -6.650827885419323, -7.138250291801498, -4.497183959097401, -6.035077023454801, -6.073355295663086, -5.993771297833445, -6.37957471828478, -6.6892705474784195, -6.1140895098418815},
    {-6.650766255210745, -1.6303729625674144, -5.85202871566984, -6.276572351150272, -6.737420406964874, -6.365896148419655, -6.347551518088228, -7.2292195443845735, -7.476038080363199, -5.1759055762173505, -6.246264709405243, -6.569465454494669, -6.6011559682897385, -6.6189018345230055, -6.777109936531836, -6.526733933065714},
    {-6.531425907935173, -1.2719194938662925, -5.237830459534521, -6.358494513000944, -6.186961382820972, -6.029393809009003, -6.439091727504865, -7.052761133101121, -7.095184958539176, -5.186941423362599, -5.4199117276727895, -6.51754630959184, -6.297189711431779, -6.088561964501405, -6.696823358647431, -6.643906335720096},
    {-6.731071313994765, -1.5697608715811409, -5.825540417835598, -6.2983465048246705, -6.838315053113246, -6.67529415704714, -6.919684703763513, -7.325592169250884, -7.266973392489313, -5.71045625561153, -6.344329656351602, -6.909158578225331, -6.87449708075888, -6.693471646548592, -7.413997155364843, -6.952868363186136},
    {-6.772031415384829, -0.32218593010180063, -5.339466277559137, -6.491470977956219, -6.562463840804967, -6.632872846868668, -6.954238288093499, -7.024287435985428, -6.902597340899365, -5.695162492621368, -5.905482519403318, -6.646612668436202, -6.2934354546351, -6.380428944326563, -7.079939100546603, -6.94233524167186},
    {-6.151543570864098, 0.1418803986107831, -4.713810367864996, -5.882202388222245, -5.51269138196491, -6.1381356479887526, -6.053254198254718, -6.716266786901754, -6.332232561501637, -4.097694626930283, -4.912846213048622, -6.342503425397835, -5.376309346814801, -5.310151764001051, -6.1058892981225865, -6.28535685974778},
    {-6.2313355738496075, -0.5735176200480772, -5.030237905173568, -5.911034143318103, -6.057346522044902, -6.378496363376618, -6.058184464434638, -6.494806333462878, -6.336919255058706, -4.14007389077297, -5.520841248193084, -6.452642466317344, -5.233443777476014, -5.709481908503419, -6.386114802602584, -6.389503477756777},
    {-6.23296286803525, -1.2076673561210722, -5.8706566223370205, -6.553859673759152, -6.622689453351151, -6.996505102528724, -6.210877886204776, -7.121600568986996, -6.759395978383225, -4.413254863991063, -6.248414238795679, -6.6091447289204215, -5.9450359307250675, -6.4248038766689, -6.995258716916689, -6.441257313324515},
    {-6.27786014439379, -0.034209652105215434, -5.585496502767054, -6.109535497473559, -6.3822997732397155, -6.374844295767558, -5.811801313736132, -6.85334064619439, -6.964224398067948, -4.425931225963463, -5.7395996483642655, -6.393144256151826, -6.019431402818879, -6.350335808583662, -6.741609703142657, -6.457836271888069},
    {-5.626469582170365, 2.0175486437014336, -4.608611925284484, -5.298625701130699, -4.9774685929017455, -6.042887429896035, -5.036000465722776, -6.0284127867527655, -6.162017204950102, -3.1798294169289782, -4.574315349647721, -5.821427894052295, -4.772668158570976, -4.60466242570324, -5.463955771841616, -5.879153374215091},
    {-5.347099441480327, 2.7088841009537683, -3.3372167016561844, -4.318661460276804, -3.5784534538072545, -5.348183737129594, -3.9596593380794327, -4.743437074644023, -5.808193533045815, -2.4588700755362565, -2.9963619111453776, -5.050210977900778, -4.3687588169795175, -3.1043451256216827, -4.326652764830314, -4.947710495836497},
    {-5.805166595931401, 1.8662068756807346, -4.472304806739955, -5.393748815626271, -4.847697768623843, -5.951632001094458, -5.183586894977875, -6.044945003045579, -6.574998573453821, -3.127612928931742, -4.502528745148543, -5.581654172107718, -5.688359787379728, -4.844897908116486, -5.6985880759269225, -5.981321521016581},
    {-5.691684234386447, 1.1213347408765337, -5.4365227801565865, -5.832992039235536, -6.11643699266328, -5.965433153267916, -5.507762318518829, -6.378691492363364, -6.846213005368684, -3.8782787501384854, -5.589950330667712, -5.9123372950187845, -5.7292369782830335, -6.304698796514241, -6.585595835146123, -6.143424738268883},
    {-5.508069929494971, 0.7916255099885954, -4.741806312403079, -5.623451865171724, -5.712431384323097, -5.700775949599344, -5.340205966810075, -6.07190004269601, -6.4989010546825545, -3.4778277897499206, -5.343720564870544, -5.757223034795434, -4.969405268447093, -5.594569079537519, -5.8548008429730265, -5.7688115422521316},
    {-6.094350271913802, 1.8064327291352522, -4.563597543447216, -5.561537997072405, -5.346289970125254, -5.9423886501516, -5.5126779770508, -6.536981009149196, -6.733949233785568, -3.6033737053632175, -4.877146621056801, -5.8321114783574455, -5.469313803452727, -5.589941889357549, -6.052032797533367, -6.0662278034238675},
    {-6.336562411525426, 0.8936855120743267, -5.312503737597777, -6.097642504457324, -6.06809314568456, -6.43595475631077, -6.044371619191252, -6.732321750348062, -7.101607930778642, -3.801725902365602, -5.134867215335763, -6.302713697506889, -5.848253114247903, -5.761069837776506, -6.8428025949848585, -6.37356865846493},
    {-6.440019131779766, 0.18659054455859264, -5.297145303496279, -6.084819520877229, -5.964018521035815, -6.378002506561364, -5.931440819565108, -6.554852257170168, -6.97374431013926, -4.2022144521822105, -5.781513768406054, -6.353547560813047, -6.343639299115724, -6.234930867750521, -6.610866664897852, -6.2073266396530755},
    {-5.71807998640087, 0.33654718395807653, -5.193177861891333, -5.6103556668661945, -5.642122518533618, -5.976235393268666, -5.221145640120541, -5.885257379816317, -6.817500057802227, -4.363171751219938, -5.450513117898994, -6.103875901771837, -6.004228187213766, -5.778960492720666, -6.735834133641968, -6.116842878725495},
    {-0.38694818204504144, -2.758427066990675, -2.2842268983937686, -0.21758814325087017, -2.295985997907101, -0.9108023236291051, -0.43241589520061446, -1.8183147998546854, -0.6316549853143905, -0.29658618076278886, -3.3387783498145063, -0.7538056882622689, -0.27481025510214835, -3.898371986214723, -2.45948603004349, 0.0922800443249812},
    {-4.181246042916057, 1.4068192277791909, -0.8554464115118333, -3.884909575971818, -1.9110625158821355, -4.050857578048587, -4.1674451158539485, -3.663508275603932, -3.9154786327350606, -1.833695715971578, -0.6120754115540592, -4.347250752695021, -3.1216491542232867, -1.3248112947319695, -4.036089080583883, -4.178968222398651},
    {-4.735958928776736, -4.545108308849197, -3.682422433438131, -4.8695991236825105, -4.509813356432255, -5.168312856327643, -4.830521353115822, -4.4746235701526205, -4.238426446191204, -4.596441591884387, -4.465158089437218, -4.684962123779234, -3.401355919824215, -3.966956996717207, -4.626204673389976, -4.462357994324951},
    {-3.5225354383850918, -2.516870411788376, -2.0736686979482797, -3.6109440703228186, -1.9841792620010363, -3.6935013709449276, -3.1928695135209155, -1.6673327667090978, -4.082909971897157, -3.6389712241039818, -1.9634939760288246, -3.643401910130221, -3.203308887185895, -1.8189944001341019, -2.0526733012189906, -3.3091761922534317},
    {-4.448588618697259, -0.5582568055262669, -2.7617192735160434, -4.345452499376635, -3.6945884399589346, -4.450091845185813, -4.383951692841925, -3.5265396542825975, -4.0614494130256675, -3.326073596452168, -3.466535167997479, -4.1340137406054485, -2.7727528025843178, -3.370372426844126, -3.815041668411707, -3.9213819101246243},
    {-4.252225889934528, -2.3352244653326117, -2.8285985001491696, -4.269544076513959, -3.8708054687983675, -4.437653920973313, -4.133573718718043, -3.587069186618813, -3.818132636432109, -3.6834895152190694, -3.0628368693511656, -4.248802256030579, -2.7539386344156704, -3.2260892763425915, -4.343479869562306, -3.8886376103045266},
    {-3.968740560881047, -1.99450037790934, -3.1000244717451197, -4.335130550555954, -3.5032771103728213, -3.8014807136103905, -3.729499945170291, -3.637056449951067, -3.9174255103859545, -3.435792329116758, -3.5995356212598324, -3.8432617114979406, -2.769835712243284, -3.8088166451909444, -4.138052360130836, -4.001997897646683},
    {-4.148822709496864, -1.046976242388798, -3.766456872635532, -3.8117347369958927, -4.207028482548125, -4.030331137543166, -3.6422861966867592, -4.1989755703483915, -3.7327868858621933, -3.500316754751162, -3.5495527927008523, -3.7993476268271777, -2.319846971174199, -4.061436798946882, -3.5871832220278566, -3.6585789356553784},
    {-3.3145246943283357, -2.3038626503099424, -2.962535005699375, -4.126963592994759, -4.1828537634689, -4.196617355838591, -3.959809251551622, -4.274953200561091, -3.207645954250798, -3.3587048501925363, -3.309215231880385, -3.930104411088702, -2.085862528242245, -3.5880713370775053, -3.8947162849062633, -3.5901972829995112},
    {-5.133407373172397, -4.435402740674164, -4.350448061240297, -5.072306016339374, -5.060555939259547, -5.242608989974189, -5.329257496063694, -5.262128591039166, -4.6341580249736225, -4.899805561244484, -4.623576773886441, -5.202265431335171, -3.2690966519583675, -4.699287487035245, -5.351751315053259, -4.784408632156477},
    {-4.01734629399405, -3.296828690133383, -2.9496962144334193, -4.201197537486172, -3.744524726837565, -4.17640859181726, -4.040734154175103, -3.8300322015879527, -3.9815712484498578, -3.519611418562546, -3.473818327473992, -4.208866633815504, -2.4086760111496894, -3.4420630887225876, -4.267378831048854, -4.130947378087631},
    {-4.187420032622004, -3.2843629817058004, -3.963504209877829, -4.381477441109252, -4.302404395067643, -4.686567765274651, -4.211363144706553, -4.3171794313822724, -4.190330060806557, -3.9997698941276636, -4.164446797929681, -4.25045345440648, -2.964735056630531, -4.21663227443109, -4.572547161969167, -4.452358668555767},
    {-4.83855067861395, -3.9737748705596796, -4.397041400338714, -4.97576840995552, -4.985716078866976, -5.133574795880954, -5.172618835046311, -5.071107290320692, -4.56789036593042, -4.6379483910617925, -4.503357442923293, -4.873393914968601, -2.618945276109124, -4.91078079666499, -5.45625311227148, -4.816951567413651},
    {-5.201812878663051, -4.189312652288976, -5.05732831569933, -5.258351991952071, -5.228763981144674, -5.392947019781421, -5.20806710901448, -5.442833601699169, -4.703779860352106, -4.885216941239417, -4.993466419280297, -5.638559200543329, -2.337055731567613, -5.03352902022057, -5.736129344057648, -5.3112336982306045},
    {-5.003861780746607, -5.02650704412627, -4.541438378936748, -5.2597384342404725, -5.463174273343814, -5.575035380763744, -5.481866257957068, -5.568087158040084, -4.366588405125987, -4.982708092757975, -5.021029853896803, -5.39668880195443, -2.433686377428147, -5.110457530786195, -5.830179023479327, -5.622541775858906},
    {-5.743062873169868, -5.445870929350488, -5.094897495644445, -5.5166662808656275, -5.765816095834242, -5.6823038028079615, -5.779205203488334, -5.87231900354434, -4.675189717831507, -5.354646298155334, -5.240734947274334, -5.708489922013168, -3.390411414814555, -5.5796894278119655, -5.934331598346309, -5.636251075945429},
    {-5.556757288910354, -4.471744259296212, -3.3627418649996828, -5.137752617887155, -3.7539006942678164, -5.258436820841138, -5.233215402524539, -4.31696702234199, -4.617065793002327, -5.204533153990704, -3.126098759075031, -5.017865755078055, -3.2262030576908214, -3.0274699679132766, -4.6573031162015415, -4.872830527693474},
    {-4.206870363487261, -3.4322131549266697, -3.2214701010116142, -4.194364262826982, -3.3137947164941317, -4.448046068768947, -4.348677511993078, -4.354878881337932, -3.471059630080469, -4.002179047399304, -2.7651742030034017, -4.098099040392131, -2.1809571243270045, -3.0883798397073288, -3.833421338264372, -4.400134029718303},
    {-4.294418091576568, -4.464529354927963, -3.4933013712505487, -4.353207882137829, -4.07938005351841, -4.494285627409996, -4.8089515364016755, -4.592990513832079, -3.11970672961306, -4.495245769709848, -3.529822997758296, -4.15689707526839, -2.0729811056095913, -3.617367959684958, -4.300542031407814, -4.324482071799942},
    {-4.489685239182637, -5.39184037631798, -4.2511357144188455, -4.718562841291193, -5.144364947094714, -4.9953441359976, -4.831621324413482, -4.745803617106144, -3.504821259783137, -4.767559956459516, -4.278448842278787, -4.98466338315819, -1.9550458642175197, -4.780484982883948, -5.4930694780193665, -4.727496030482973},
    {-5.386685223346462, -5.744003193834733, -5.055431043198607, -5.698128969253207, -5.547978741412832, -5.610425472338444, -5.602100529489391, -5.247635772996664, -5.270538072811821, -5.491724043382326, -5.310556509105831, -5.4905261351493, -3.5628972610974006, -5.396211511042991, -6.258865694843232, -5.539809461422302},
    {-6.068927233723121, -4.589690622052763, -5.076346191206208, -6.09620910932959, -5.635342792853303, -6.382976525175889, -6.40214320357404, -5.8533683901580496, -4.912254241515755, -5.208497055947329, -5.174062986473082, -6.135946151714126, -3.0240025054328026, -5.561255391475163, -6.54241287548905, -6.244944210730559},
    {-4.924930103138326, -5.624978398166271, -4.157188540615517, -4.88833618637932, -5.105529679133505, -5.427802266545492, -5.832396485960036, -5.253824779284582, -3.255649586920031, -4.351698486877226, -4.439015483153294, -5.26239277098592, -1.3341259553703142, -5.0733688885089, -5.3892976376582675, -5.180661153476543},
    {-4.840092153997337, -5.968024634413103, -5.3001318512998985, -4.841794059117791, -5.76991020666924, -5.033878464431276, -5.168892693606923, -5.89477638099489, -3.632196545789024, -4.565558991222155, -5.422389731291688, -4.711711996580114, -2.1718655380544987, -5.862386373015921, -5.562147209622058, -5.019158522828563},
    {-5.596616892709014, -5.7775592145126335, -5.423249945072941, -5.610506155893615, -5.476736961713042, -5.723495563349729, -5.754445861334737, -5.37936775781759, -4.68681699428414, -5.120215416252945, -5.522077095390885, -5.587575237844001, -3.458261923298033, -6.066864036789355, -5.988179167331784, -5.47511644367036},
    {-4.40268338616532, -5.796656471353003, -3.2644615351547697, -4.677985034688847, -4.412962956349888, -5.268654289040961, -5.198709907489541, -4.1788402637980555, -2.841097717747719, -4.740505050258054, -4.091005949651198, -4.532872037031817, -1.4722937095771227, -4.327149716582316, -4.514315726533406, -4.664371318863035},
    {-5.663013866588951, -5.846941374830595, -4.92619050668698, -5.822476778814048, -5.6066613450001945, -6.21189934699072, -6.1414901783736315, -5.715994142784431, -4.3440018583785776, -5.364659205279144, -5.13836679176181, -5.957766695116487, -3.1333871593121803, -5.575026207345386, -6.403822790513313, -5.858840107864769},
    {-5.771335304915067, -6.534884172758156, -5.71065155736944, -5.536447426146518, -6.123761445706549, -5.771596720482233, -5.965357950837969, -5.598524748649098, -4.896373008649431, -5.536937850749529, -5.806837594858311, -5.566140491799261, -3.558476086298636, -6.3971625541769885, -5.798282413723891, -5.5822096002694375},
    {-5.920156970960609, -6.677236162204331, -5.505607430164737, -5.660208237604183, -6.225051656918322, -5.902422371863849, -6.25315194050355, -5.585387228854772, -4.670513969512897, -5.850366815185584, -5.56889681795021, -5.769248239700604, -3.4184324027261166, -5.974355875709805, -6.294459935441625, -6.081430414899019},
    {-4.764531182789741, -6.463827984314979, -5.956197027376505, -4.750918134127321, -5.7076866401009925, -5.583323205474261, -5.2627851762381574, -5.424982707907107, -3.7211602886385946, -5.411141277275836, -5.337238421386792, -5.362878627611718, -2.0850130055234906, -5.721378817319075, -5.897638191433897, -5.344396857603452},
    {-4.266563477160087, -0.7925846719541562, 2.213237396640864, -3.7804077307823873, 1.8097364646650358, -3.6015669674526256, -3.9197864792007793, 0.3009460912890632, -4.185629847109162, -4.143140264802469, 1.709315815623786, -3.6955025239999433, -4.851517686228105, 2.089477974849003, -2.3410322699778905, -3.2581930529000025},
    {-4.218152497267296, 0.9430441260205829, 3.8850468821574244, -3.2008926340935417, 3.2218850863447073, -3.245964535934498, -3.54892311496075, 2.121612795901093, -2.778333227999633, -3.151431979870417, 3.238578850003497, -3.0446783685040035, -3.4775953994733024, 3.5855427648301403, -0.9227518551341274, -2.7074151640216795},
    {-3.8664015485912873, 1.3746634988298787, 4.864975270494203, -3.062965054014238, 4.416268387319751, -2.523159130414108, -3.581020528590419, 2.7393586690616205, -2.8725541623594237, -3.667168058841655, 4.417991135874262, -2.718713126420274, -3.690368816363722, 4.715411588336036, -0.5588824036428726, -2.422136618859664},
    {-3.630646582905559, 1.7671665184891305, 4.4141530287159165, -3.1671827111393887, 4.040315193538513, -2.4036150970445083, -3.143921691702391, 2.4829662513913364, -3.1000248029193984, -3.7892929399681594, 4.2316511720879575, -2.4921332833913685, -3.7701365491300054, 4.363244929974815, -0.02277811047139621, -2.1494135585756955},
    {-3.4241740866967243, 1.9398404004814407, 3.957495920382087, -2.7677358722666043, 3.757106539600672, -2.1779209788453016, -2.7097069999576755, 2.9167159870240855, -2.0782199275961775, -3.2098273837398845, 3.613577177397867, -2.035446441323909, -2.8979914600862537, 3.975589827237322, 0.6113092171357002, -1.6120680443014967},
    {-3.66652479700568, 1.4269973148574888, 4.2372452582405105, -3.042718587191425, 4.352147363159063, -2.1468198855258716, -3.0001158119345566, 2.4237771906081322, -2.5559905860717183, -3.671177691486559, 4.134156894025628, -2.3012750663364168, -3.5851771953984746, 4.296900985129525, 0.0971245959103242, -2.09227853889763},
    {-4.577937227933536, 0.6183306894911439, 4.021248774062779, -3.8720621055548903, 3.8211566331464706, -3.5602247018304047, -3.84278034501666, 1.6837111616731673, -3.6083494484355634, -4.255169334989688, 3.6199184944751637, -3.2737044982413233, -4.390576965159913, 3.8273290172944447, -0.9052429977580302, -3.2379225895909576},
    {-4.54575405674565, 1.0984073517328212, 4.313802653265615, -3.7718056825935173, 4.343028431573047, -3.4180343787111767, -4.156016435096405, 2.319907622526909, -4.269598212671825, -4.217699509568182, 4.076758431301879, -3.545935546303655, -4.675459412015728, 4.198762404765886, -0.9224133123943231, -3.20633874466329},
    {-4.728380069354308, 1.4432252612517342, 4.739473609241547, -3.9546850087307703, 4.453905786393553, -3.4979196482657007, -4.115864623958808, 2.394419898144913, -4.530784457351125, -4.398410507967551, 4.579309929339411, -3.656830898746356, -5.202562884123913, 4.7215813063676215, -0.9340543957591754, -3.292928136731742},
    {-5.00214022057135, 0.7362885636947889, 4.120397893688426, -4.4762949525714975, 4.147393393921793, -3.9939463341423793, -4.5003797155405, 1.9552350335809892, -4.658033992149724, -4.475494498068233, 3.798543667366338, -3.712926504876346, -5.517872407591561, 4.004886739950674, -1.8421577211085316, -3.7915413664922197},
    {-4.908309760630564, 0.5705986730894286, 3.4920231307366096, -3.7811074873874455, 3.386408482963011, -3.4544037481551157, -3.8671289814622543, 1.1700462556370714, -4.566212082132395, -3.981726776285239, 3.00192298501157, -3.4964400417518164, -5.0630087665668935, 3.376642850056919, -1.6412365587650277, -3.446192580409944},
    {-4.462546232900008, 1.9873849455681334, 4.653412357797243, -3.3352184649300307, 4.484666776551105, -2.9283800367932686, -3.620888864274182, 2.2068180296089994, -4.0345343978535455, -3.7081783172435108, 4.398897395639681, -3.1946520832235548, -4.775381089700211, 4.7295170762643854, -1.0465754416593989, -2.8250427182730316},
    {-4.868825827910517, 1.0306308257598393, 4.848403325076799, -3.821495375352716, 4.781242234811719, -3.3316906905333417, -4.160469650730476, 2.693572744733639, -4.344243631077752, -4.561780168259281, 4.438509150738435, -3.277100816392513, -5.091709762005725, 4.849751396244022, -0.9548957067941205, -3.0935063961284444},
    {-4.642584750931771, 0.8860519566875781, 4.4667901341568506, -3.8451228084531217, 4.3971740915551125, -3.201882737028374, -3.816567812097606, 3.0717624333285958, -3.5620304466094272, -4.178764194691461, 4.307480435502565, -2.8457848947520192, -4.683725831937041, 4.499200849748716, -0.6551718811319089, -2.7105828427818577},
    {-4.460562352433552, 0.6398123467816642, 4.429807294622528, -3.5742981102837112, 4.177781798735759, -3.151877033325915, -3.632121227662076, 2.8178116380770004, -3.578502114507485, -4.330646800700714, 4.2075408301831185, -2.9017737687416103, -4.706525376233585, 4.449752485855995, -1.145092259661631, -2.946489244604831},
    {-4.587877628816862, 1.6013655996634752, 4.999121966619348, -3.6147470935730293, 4.78211647565354, -3.6328443742503223, -3.9080653962464496, 2.7028252865158677, -4.432553075072569, -4.093506184502229, 4.617456566118706, -3.2452037443600528, -5.335097167109715, 4.973449343742171, -1.1262079039082065, -3.1291645778728463},
    {-4.364121258759708, 2.5945852120535497, 5.210758478536437, -3.667483394850797, 4.810519589368024, -3.481163356241502, -4.15396266546178, 2.84951182849453, -4.188003505439339, -3.9225532260692733, 4.892377657479734, -3.663256381425611, -5.0891350337968095, 5.223142601865974, -0.18124357167089464, -3.2082328537571017},
    {-5.0974232047425225, 1.5629994073484157, 5.096902591978224, -4.2552155068981055, 5.103963739904422, -3.8724771754644687, -4.318004992880553, 2.7962428533395642, -4.5994918045512385, -4.213549988045816, 4.967278063733198, -3.534063520559721, -5.497735825612339, 4.933246419116698, -0.9928411998424533, -3.724788291723401},
    {-5.308967652690773, 1.0149515791503296, 4.973146026307308, -4.237211881036658, 4.390267677062799, -3.5850803020625257, -4.427036134397004, 2.2363110296292117, -4.622692363614013, -4.648750041781151, 4.477235351968101, -3.4672927318251108, -5.380653803426755, 4.604363385524608, -1.2378193306641785, -3.2295099541853816},
    {-4.592931897558387, 1.4508053322025332, 5.042983740880675, -3.763068650581385, 4.301418383108836, -3.412905127556473, -3.765640118767397, 2.395113001534423, -4.3472483849678705, -4.303302961674829, 4.222160257140898, -3.5088214217841265, -4.994116674508817, 4.671722004630156, -1.1810737278006975, -2.9162784227657195},
    {-4.843450685526431, 1.4206847800167013, 4.609096904843679, -4.12634308814046, 4.001636368254441, -3.309286282360361, -3.9735026398600612, 2.225535431062651, -4.402392535913499, -4.3162261162924835, 4.337204732700529, -3.428638758931671, -5.1002661929912705, 4.318130223795008, -1.0071733517414685, -2.8872447924806317},
    {-5.29083611217881, 1.3134704320019333, 4.751207932682406, -4.593674062306436, 4.4830213685833895, -4.256536272039979, -4.773575639074914, 1.9584165775936764, -5.141331816145705, -4.573001789213281, 4.370264417587854, -4.385882408370319, -5.772207326408741, 4.579341451260862, -1.5646953184453962, -4.005546198244724},
    {-5.8587980535485515, 0.5934987208955794, 4.907361782626032, -4.839106532640802, 4.294127453194886, -4.364173409543998, -5.026322855534555, 2.1044966921945782, -5.555646373038776, -5.434788868720171, 4.335918539771241, -4.520139959366532, -6.02253420352752, 4.8740613580902625, -1.8972649098132124, -4.308306315997022},
    {-6.2010985136832355, 0.5477880644722263, 5.22139511986172, -5.378281149772015, 4.42892791040612, -4.729179525641517, -5.183027798251141, 1.9754241701726218, -5.67898459848199, -5.355729782160721, 4.726847885968881, -4.926590723167423, -6.149817034931365, 5.103451469671274, -2.454223868668416, -4.750358928929492},
    {-5.351453789137201, 1.7011746012884574, 5.616304757593099, -4.690719310855856, 4.729019539645033, -4.321281070209857, -4.848205736257679, 1.944222198102315, -5.155796705416025, -5.1067728454340795, 4.944788580606926, -4.429185011874831, -5.612747412703682, 5.340422988532479, -1.7127833254023743, -4.104520327190759},
    {-6.352655790898873, 0.31776080764288106, 5.368095389168325, -5.5459401306408, 4.758755536246221, -4.698134414977597, -5.554424355155562, 2.042545133406285, -5.489029257518678, -5.808784215230688, 4.837292723659446, -4.858532975484439, -6.3475599716633955, 5.084259375576274, -2.2720981281308203, -4.477834510270139},
    {-6.081685392795575, 0.19791132221475402, 5.430534585781466, -5.410826663971804, 4.725599946629333, -5.2544340255678526, -5.7586810792400875, 1.770533423834256, -5.796465649658593, -5.937882719267254, 4.88152569016262, -5.090305184648252, -6.236012373418274, 5.100198826507833, -2.6753379379765256, -4.9202666263389725},
    {-5.556706211366274, 0.27176724700407273, 5.802969383501597, -5.062069525189663, 4.500555299726178, -4.823739422001436, -5.14656778808422, 1.6618207661083975, -5.243761887616102, -5.559100938201228, 4.63626687748424, -4.815886752635278, -5.917020956600256, 4.992608186087147, -2.4602553939061527, -4.177283177738794},
    {-5.8174407490334525, 0.31315639345611823, 5.296509547314963, -5.353907463280824, 4.179451007529831, -4.891082779037811, -5.69061764477144, 1.5310923557169207, -5.538186613736537, -5.797860132782159, 4.624664945366093, -4.836256354879076, -5.980414533791945, 4.878434589263349, -2.409238225933655, -4.388646754939091},
    {-5.651862382538587, 0.5899018377209762, 5.622057229801626, -5.1174160969082365, 4.587342694760655, -4.896924788189617, -5.419373499095837, 1.7453282054071797, -5.656003238980454, -5.564299538977866, 4.900324679363047, -4.899177947447313, -5.91638216021385, 5.161264848142471, -2.954628015780037, -4.782085023848791},
    {2.644195542070749, -1.804062732331903, -0.12774946558388223, 2.811741292680533, 1.0461623243077822, 1.9473173971817201, 1.9366243224742385, 1.7861374233178917, 2.905722222537208, 1.688287615604583, -0.16454745761505685, 3.196973947858699, 3.4720222516318717, -0.3014736336487102, 1.4277089179819844, 3.180601611799293},
    {-3.2254803936383354, -0.109276569422505, 0.3957262354536564, -3.3068115333857895, -0.8622178378088841, -2.3246538621902064, -2.881778071590447, -2.2817504745597574, -2.665040140481676, -2.0776260411984295, -0.4173243112046296, -2.8462780115038075, -1.77381845282471, -0.22144475382658801, -0.16799092014200323, -2.631175742424598},
    {-2.802836072832431, -3.9529292193754975, -3.8817638574808875, -3.0164762011397754, -4.371795465768843, -3.3366459733098424, -3.156638549719695, -4.217493843864967, -2.703310960503989, -2.9887342894719837, -4.133450417584082, -3.2513829942526313, -1.5166161154917368, -4.4026910584642245, -4.376873185947667, -3.3863927966395724},
    {-2.1879720505108233, -2.6160462996381426, -2.1704187161249497, -1.8423988696097104, -2.190345746337982, -2.3730394018993484, -2.1247434029907906, -2.030275878661824, -1.5628553886766001, -2.4950688959681524, -2.037416885039347, -2.3020503550291007, -1.4957890020414548, -1.790866515809737, -1.970930231438076, -1.9988979042759043},
    {-4.000656982557045, -1.7274188998481315, -2.4839524774289443, -3.95552989169876, -3.1513130803444485, -3.831825686889205, -4.181782383568977, -3.06956051453537, -2.665034064509215, -3.1659035561030064, -2.657194366339729, -3.8551991435273982, -1.6096934049610612, -3.0747647130125864, -3.311723263266935, -3.9171423305874438},
    {-2.7169232811457973, -1.5410759495360788, -2.6565333767743553, -2.6265535416452392, -2.8094643374744734, -2.7884298393512585, -2.4943795026313227, -3.1417506772555512, -2.6879968237753316, -2.470783830289601, -2.7383960473286337, -2.660277570415698, -1.8799342859366304, -2.73293796663682, -2.710120006263734, -2.6975399106585574},
    {-2.70836493681956, -1.6666642717177322, -2.1330736415654767, -2.4519749550932426, -2.3657247666765566, -2.300619379418217, -2.436183060007864, -2.0884560584450607, -2.5779618207381403, -2.1373658950706718, -2.2822856932669295, -2.183843035959055, -1.5671773380391372, -2.6471811966320997, -2.526771609714644, -2.08349463860964},
    {-2.831695034250704, -0.10221361674881572, -2.3186976955765797, -2.1802650351465855, -2.2904502600524506, -2.223520337510066, -2.1305120226562053, -1.984185181669296, -2.2814089126383927, -2.3612869529058105, -2.136468053293543, -2.341373931634828, -1.71860509507137, -2.2661616845368138, -1.5611537632730095, -2.15172954648115},
    {-2.567546747141922, -1.7586068264383403, -1.937329382248372, -2.58368853552233, -2.9095076987271957, -2.3733039023229554, -2.666282435672426, -2.710940868740496, -1.8405115579332114, -2.437860456284166, -2.5358750618631447, -2.4595345242699636, -0.9782667784731895, -2.288596296867533, -2.5413551982743257, -2.988139432814954},
    {-3.6529858819835166, -4.332279080700596, -3.981275389571849, -3.8075255552469858, -4.55087324086875, -3.83970733085506, -3.939107268888677, -4.886523687521778, -2.766731483932282, -3.2881427700012567, -4.266809861216814, -3.707893581516299, -1.5113925144643554, -4.611874558623749, -4.6478788811447815, -3.4712039411590756},
    {-2.694854771391599, -3.1877225734056163, -2.045412353481004, -2.9941820032096516, -2.242169663129946, -3.0826606873910904, -3.3509561764561275, -2.543697968150285, -2.37250533265941, -2.567576735672421, -2.331896179940935, -3.3286955380743684, -1.621014865543838, -2.2632887020959056, -3.263341417998832, -2.840542634515393},
    {-3.1041218170449696, -3.1125773365603933, -3.0045140361744425, -3.6050992466846483, -3.134781026796631, -3.6930209790498925, -3.647017108954238, -3.7167253762611137, -3.162248981078169, -3.4583681831344295, -2.8927698157760613, -3.8267579222674564, -1.9107154418919319, -3.0487384984415544, -3.4885976290830953, -3.541402324932087},
    {-2.129245646345261, -3.5160457098835214, -3.0162906341452094, -2.7710019752034363, -3.6297767405068626, -2.9265932584319176, -2.912972034931898, -3.743333251355935, -2.3908921589085654, -2.5300794521647685, -3.4460597658356527, -2.52435786444436, -1.0103849942903713, -3.944571186031537, -3.5167785582715307, -2.8306957432707343},
    {-3.1399036740660247, -3.799998784598756, -3.0198645561594772, -3.824582167360254, -3.5427479481990383, -3.859137302929207, -3.5229380462965327, -3.5481643278960275, -2.7057664114851976, -3.5523377750445713, -3.3382462682423313, -3.7853515957516497, -1.0719379886268678, -3.4887623455811547, -4.307805492093644, -3.6351441847202444},
    {-3.439765539727413, -5.092322309836483, -3.789983852141531, -3.8543197785812993, -4.720832636535417, -3.741730757189121, -4.079356189543746, -4.2052194645816465, -2.01659432611268, -3.287939116236708, -4.453884213859269, -3.8457670885780115, -0.4756042779079399, -4.593503403438888, -4.7942805377488, -4.1011075091774165},
    {-3.7613484493550042, -4.85357065516781, -3.576176279297182, -3.5686133768971526, -4.007895714054279, -3.7964591946256303, -3.874160505418066, -3.874821932207667, -2.3505027748958507, -3.5471572691787716, -3.717499358846729, -4.12412588877241, -0.9583966982760105, -3.761598772677042, -4.5865715576081705, -3.738248370499882},
    {-3.1774781477027543, -4.865050072644031, -2.410765414711729, -3.276777141776327, -2.8163103249210044, -3.2262100034362633, -3.118831227666575, -2.449377654035935, -2.145276694735206, -3.774180278613766, -2.5056958711099124, -3.037812564940853, -0.8526292788037119, -2.793386907725434, -2.9650912886619003, -3.54998036960851},
    {-3.582870608807333, -5.047032418469934, -2.7525316429727753, -3.506485857316753, -3.425241278486217, -4.06107203136866, -4.0978561487694485, -3.3565816552064804, -1.7800678595840036, -3.9932777261665953, -3.0885871425431732, -3.8722281096450706, -0.7036982674641205, -3.43340799161685, -3.099657299720128, -3.5609193822145073},
    {-2.8746341905792416, -4.286208939522849, -2.128247006204798, -3.0686316409211836, -2.667887683328295, -3.4985125259757734, -3.6343226239313506, -3.1701604651359685, -1.8463882221101868, -3.3471315393188354, -2.386061474180336, -3.726884360535739, -0.7341403846513985, -2.6040944508793773, -2.923873336153156, -3.47494780460017},
    {-2.7482772354783926, -5.0966097626946425, -3.0812478456001737, -2.9802069005153564, -3.555919692707741, -3.1619500351195966, -3.3284751594548454, -2.9012329313376997, -1.3865809893912537, -3.0605053249210354, -3.295038943152441, -3.0348102824609526, -0.19353659773113815, -3.3210628941348754, -3.5893445300429367, -3.2276114602343466},
    {-3.1923977656445093, -5.575271616145785, -3.621786574290285, -3.5457789099528063, -3.6599935171285836, -3.4064275634767123, -3.821591976307625, -3.5485688177479435, -2.1420562130712435, -3.564121841108443, -3.472340965871377, -3.260752924345018, -0.33456552116415206, -3.857773987289978, -4.180199375373564, -3.4349270366216396},
    {-4.126295082469356, -6.708200569402257, -4.004542760036804, -4.033929955157544, -4.741400827045807, -4.5278649530019175, -4.889397537517214, -4.59973458239461, -1.507511577590665, -4.272984592675295, -4.293116087785414, -4.638335266802404, -0.33135986782825927, -4.646561219926509, -4.753783470887106, -4.4474795089668495},
    {-1.765267311949487, -7.111412009683891, -3.550113566166465, -1.9123492511488263, -3.76897307461656, -2.9245144337908267, -2.881486108783053, -3.350325676657142, 0.49371315518892506, -2.086957102470524, -3.7460788247769212, -2.6690428456113127, 1.6480136801784082, -4.407756136664341, -2.5621950523534123, -2.60267747659215},
    {-2.225879412032144, -6.581720122692194, -4.340380945074721, -2.6766560884686643, -5.0679899578884395, -3.151845838475132, -3.4419943217486897, -4.195578072275335, -0.7027687030893462, -3.152317769075098, -4.72746648516275, -2.921349862616924, 0.8205294577510347, -5.348548662405669, -3.6266692172406003, -3.4527766036831187},
    {-4.35663651128723, -6.786853878351428, -4.827831618209683, -4.6363199009264715, -4.976621057692835, -4.942590536701194, -5.312065071838791, -4.969948909922118, -2.9895070824740317, -4.827086354223019, -4.722074462395792, -4.69643060271808, -1.4525106215518335, -5.095008942293898, -5.212102590754633, -4.882879227866333},
    {-2.587519844726854, -6.369064132160533, -2.492463514034085, -3.021239897550445, -3.8915703872453116, -3.529695354225121, -3.6577596142220177, -3.026246984640453, -0.9240084434850859, -3.3031565546893913, -3.3310879252932906, -3.499664426311827, 0.4474431355043493, -3.8133692242271953, -3.46838178788327, -3.35481051053258},
    {-3.144508099171975, -7.132741368446323, -4.663620487364189, -3.77961242897119, -5.113191898058903, -4.089998716647425, -4.688978520109599, -4.706621005178161, -1.3040961148624655, -3.8894258056800477, -5.074761241582808, -4.31318475786739, 0.1642241646015976, -5.648395519728523, -4.74627943742967, -4.285482571638021},
    {-4.090207037335747, -7.549782396339136, -5.605976815253902, -4.314875209101719, -5.794170321183085, -4.685068807214129, -5.097197291156947, -5.217384977204278, -2.0760692427943543, -4.441866654152226, -5.7275026037403585, -4.446454585686151, -0.7620213725339385, -6.141180458862035, -5.004042970826565, -4.246726091324602},
    {-4.27953941144799, -7.536304744654127, -5.182378237348504, -4.033815484453846, -5.439826772478407, -4.485709694789311, -4.763353249337837, -5.191974968477451, -2.04009008393706, -4.704695531577928, -5.537608277023993, -4.517934176564089, -0.5423300442621302, -6.013332471046478, -5.137226870987389, -4.384889897979669},
    {-1.8395332754441884, -7.155076537768352, -4.658153118928422, -1.8078705160402937, -3.6766530328048654, -2.812813360883521, -2.5581075469269736, -3.3989910879046885, -0.30698946226337814, -2.9405817439400175, -4.339602305422383, -2.815961211910455, 1.0506874304425857, -4.853248575241027, -3.4396323781101796, -2.372277100708164}
};

static const float b1[16] = {8.197505898772938, 8.56688758305876, 8.166097357319737, 8.193693025194372, 8.278060129190196, 8.284097587179053, 8.299233332895637, 8.369128183519479, 8.265272950930385, 8.241467217342565, 8.205638042022008, 7.96703625145933, 8.205784626378508, 8.328476686377204, 8.16417846631871, 7.9414778105518};

static const float w2[16][12] = {
    {-4.559908467871386, -4.666089368041793, -5.13119776843009, -4.67441601561072, -4.974797721462057, -4.7819965899027626, -5.018307288306072, -4.276648744141926, -5.079531524467439, -4.674840648935631, -4.8435130025429745, -4.920929527935467},
    {-5.11947939876451, -5.337883637489661, -5.051685167619792, -5.252002636632951, -5.0252373163739135, -5.208788709912264, -4.914085201118457, -4.808602827100526, -5.30161356757982, -4.898733088675541, -5.130517575753972, -5.0482898514041095},
    {-5.356093796839187, -4.652485565565338, -5.084289382818633, -4.476752125207241, -5.1983209023608, -5.382187327759327, -5.5523420698126005, -4.763999835419175, -4.165029701447603, -4.930261088834665, -4.34293028829712, -4.797965467319237},
    {-5.383658281591217, -4.694859671892474, -4.53451341923704, -5.253480097286567, -4.6334609777808975, -4.568387809232997, -4.169082533890955, -5.095910343330778, -4.026925987986972, -4.672685479533974, -4.754445942718443, -4.938750329268337},
    {-4.679909275930582, -5.449929307434376, -5.427261021039941, -4.8729507553784925, -5.231271702817473, -4.784923828454697, -5.177872915220341, -4.611451572822372, -4.940142009473609, -5.437631010580141, -4.12042237866692, -5.373370442920535},
    {-5.211585432325421, -4.85778911815707, -5.04812490716457, -4.352074277139614, -5.2156927632778896, -5.063355386587934, -4.984818523046808, -4.27728627277072, -5.409281647253478, -4.919008513582325, -4.795374274794838, -4.063015927632268},
    {-4.568344389349204, -5.145308600297488, -4.6888655056135615, -4.267380457646279, -5.151215509203199, -4.5519481117764755, -4.175365523535342, -4.733072479534544, -4.785440879452179, -4.1680955128375565, -5.2050370437824975, -5.316200301423095},
    {-5.005878162046501, -4.934283520194663, -5.007406043926051, -4.81620616117279, -4.778113224247478, -4.849886272961529, -4.708715185225446, -4.463048926859204, -5.05632591887469, -4.067097590062414, -4.758999935274371, -4.781425859584462},
    {-4.605424514749086, -5.00506103094917, -5.306460834076379, -4.446388118267677, -5.201386201547672, -5.0267544797904415, -4.356720682257886, -4.81446755017114, -3.6474225111942213, -5.293786685754055, -4.716313209273965, -4.791135490267807},
    {-4.7219114168613245, -4.705849928055612, -4.8813856105402955, -4.636081761683299, -4.858012661833637, -4.894993076273923, -4.995631573739584, -5.161669402084634, -4.348639764703949, -5.062881130407636, -4.654160666108395, -4.353840686863877},
    {-5.399254281909141, -4.422008185303894, -4.977264858265312, -5.397727449833035, -4.706918848710985, -4.5788116371373455, -4.335305935619065, -5.911736326986015, -5.074908326680324, -5.22039235263855, -5.880948126582512, -4.443440862069268},
    {-4.7069978956075795, -4.847238193340934, -4.174036082636986, -5.439059795300145, -4.136273450816833, -4.454298867642091, -4.885075879080168, -4.677087321619832, -5.567282043636349, -5.0160087276279945, -4.743736703513196, -4.7982693228630655},
    {-4.998467058168813, -4.7726639862348454, -4.663666350340812, -5.384319053162562, -4.690719999546323, -4.7433755625369045, -5.350936920431239, -5.0751628379794935, -5.533113456901977, -4.69370358092607, -4.942671784588534, -4.910476158249441},
    {-4.33312408582257, -5.259430671141541, -4.384299647577301, -5.178898935010208, -4.760574791070004, -5.01439055090626, -4.919076450964284, -5.069960031653276, -5.556267506064891, -4.811937581399731, -5.543736408241654, -5.259586271825368},
    {-4.644351147685143, -4.373759525508439, -4.516398425074202, -4.586471162280726, -5.007264127691404, -4.716347213168588, -5.377994090211356, -5.264045686517491, -4.810143426309876, -5.161206423643629, -5.047195245430748, -4.848175326042293},
    {-4.603571409693683, -4.807217406335979, -4.9206101122524775, -4.944719527840588, -4.179743401528181, -5.256758659148287, -5.088216789698919, -5.091059543031642, -4.979657536785862, -4.766776324978838, -4.393967442691835, -5.122094556771012}
};

static const float b2[12] = {-5.825951455596377, -5.496813281131656, -5.941600460902914, -5.546149875652612, -6.553116866297629, -5.625983844262935, -5.91519426747656, -5.7168239488820936, -4.695370119060522, -6.413112829234475, -5.803737137483528, -5.932825828444673};

    // Input Layer 
    float z1[16];
    for (int i = 0; i < 16; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Output Layer
    float z2[12];
    for (int k = 0; k < 12; k++)
    {
        z2[k] = b2[k];
        for (int j = 0; j < 16; j++)
        {
            z2[k] += z1[j] * w2[j][k];
        }
    }
    softmax(z2, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
