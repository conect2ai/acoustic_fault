#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][16] = {
    {1.6248343530618088, -1.543489845632814, 1.2830250695244223, -1.3637479887042754, 0.1980598088095312, 1.272415527246263, 1.6306886214741954, 1.422719273597181, 0.01706941405184408, 0.7391309173806598, 0.9005131051401607, 1.4480307352134572, 0.9856699693209735, -0.07833738148044585, 0.7309594347823848, 1.262118064329866},
    {-1.116280792122952, 0.4585280794427136, -0.15620794940102756, 1.0970721098504064, 0.12319080456486368, -1.0526985703235494, -1.0979589107942012, -0.7120742561228677, 0.3836945224820926, -1.7053901829343827, -0.6561793962049817, -1.131336640476754, -1.9945951791160397, -1.4317843076937302, -0.654684662044339, -1.6056179244136666},
    {0.31617801179497723, -1.0264171301753648, -0.888846396967903, 0.5191344114090775, -1.5236011966551415, -1.845271369533258, -0.5500846696339324, -1.8085387735736906, 0.1714156911892863, -0.0973914396848705, 0.08276746693961838, -1.8890774848552154, -1.953720818009253, -0.620789003841676, -1.908818924941074, -1.067020162610734},
    {0.874603282100909, -0.43858638059847166, 0.8802664335850858, -0.9025704336711018, -1.0860769266762456, -1.0351937979463028, 0.37623855206079804, 0.666731579223963, 0.5971986368554155, -1.141218731691837, 0.7563871705218089, -0.619705732141555, 0.2503881157923228, 0.7790804187874396, -1.1781848680498517, 0.11155635395751543},
    {-1.0135401905244208, -0.03745625138295273, -0.5500246951272552, 0.27652188162098956, -0.44801574983690934, -1.565611790587977, 0.23545957509681595, -0.21489317340626962, -0.000309653935017824, -0.33385662500923874, 0.17119669586327446, -0.3381294770185969, 0.28422082073269517, 0.6325288910494602, -1.7800126086159729, -1.2933608667906198},
    {-0.6432574903205494, 1.1403491479033765, -0.2165026275538015, 0.9430930820233541, -1.8649912650854092, -1.400383491589456, -0.2852020460936724, 0.18358413051642464, -0.2440210713854448, 0.17875144386449462, -1.0300456927685036, -0.1312647543243799, -0.42965716146782024, 0.9307869930428476, -0.6277925714044158, -1.556386823357982},
    {0.4296734024964764, 1.3154284480414602, -0.21934618099004594, -0.42914134598176906, -1.789594743143789, -1.1611424326064492, -0.32389946404053227, 0.4742156791091713, -0.020850268851830077, 0.5573310183076714, 0.02182431970529379, -0.12329672328906521, -1.080517973552033, 1.00540569846935, -0.2091352353945631, -1.9412624158883094},
    {-0.73526116538833, -0.33411900064000577, 0.24763152864616725, 0.335930205971629, -0.04338823127882858, -0.782210275070091, 0.36278563694127286, 0.16930916939719204, 0.2992736589012887, -0.8528412585798736, 0.5580209193863312, -0.25548399491028206, -0.08829036917879174, 0.23751240285218028, -0.5342144380009919, -0.6313710801221872},
    {0.18762447130800644, -0.30819631142340403, 0.7011194618827536, -0.4491657480264708, -0.07452099743890893, -0.7767771418688288, 1.167473336396001, 0.2313844164448441, 0.6033142584296153, -1.5800970986346343, 0.7046914487155888, -1.2193350105796463, -0.834174986873698, -0.2633118791142378, -0.9784067708340527, -1.593418443996721},
    {-0.580026530687452, 1.5272718457346197, 0.4582108874835174, -0.002828088300040067, 1.090069815173975, 0.5644259210488698, -0.30179852951819003, 0.663443403212761, 1.3104952560459864, -0.25245237345171845, -0.49947980506430417, 1.13908812204805, 0.5606796365398529, -0.587964276445652, 1.9764033805456027, -0.27593180918550664},
    {-0.9023176268543207, 0.4887939783039882, -0.16967423108512816, -0.6605370306998197, -0.3132317832322065, -0.04163181167847153, -0.2656468492794848, 0.23007779208332665, 0.12264577550282066, 0.33370464133593686, 0.14996941400548852, 1.2596324790318152, 0.5336034371698756, 0.27611408832999934, 0.9766542873870876, -0.09197617643066314},
    {0.38000377624252213, 0.017540384848875944, -0.515264732228872, -0.8542935567823341, -1.0909956639149154, -0.7677053394579927, -0.2147890546931201, -0.22866861506634137, 0.4114321491246078, -0.5751165794303371, -2.0007186290319705, -1.0598159300353818, -0.7209360852599052, -1.265137156512599, -2.0120704267744824, -0.9849506586516391},
    {0.20871764102821005, 0.9894097272683909, -0.9149056944493916, 0.18257207369356634, 0.4489718794325683, 0.07987299896813177, 0.010275737777338822, -1.3280692246701642, -0.9602931388220781, 0.7065778436188611, -0.6724148112727855, -0.8985829068417256, -1.6431522035950847, -0.5194516707902322, 0.548344609470891, -1.2400043350061372},
    {-0.8871029813910275, 0.6848787859525521, 0.6451522202392129, -0.7051590481011578, -1.8670774124789664, -1.039612838909207, -0.5381601071111879, 0.9156896788822367, 0.2776374370772894, -0.352409119787675, -0.7034822220490958, -0.6355752025239625, 0.14004472240002044, 0.707454907739872, 0.5864236817503448, -0.22698215496034974},
    {0.19925498731729063, 0.7378653015738672, -0.07332643529598618, 0.3466822731085919, -2.05902898418785, 0.3248112380826615, 1.0105225181332733, 0.646783333524671, -1.6031246909248478, 0.05552524591531159, -0.1576069936669794, -0.13353833526969147, 0.15507147343366265, 1.2272530891426525, -1.0045151697418007, 0.11145390953923073},
    {0.2544800574704024, 1.2475442878143415, 0.4178201266709416, 0.7466290563394483, -0.5559398647822958, 1.816084429919592, 0.34590181407017045, 0.3030285571523902, -0.854009968064512, 0.329427805378327, -0.3034497560943497, -0.559268995336057, -0.6655181735847275, 0.2311667286588928, 1.4396915811745539, -0.5229759981003514},
    {-0.7389162702894585, 0.6356951396291681, 0.3644756798423702, -0.12000380946478574, -1.820722597470184, -1.1056384321668278, -0.3174810513213226, 0.8784873424278125, -0.13178738073572957, -1.2494740762410603, -0.1239430813698592, -0.1044941758508414, 0.1491166715569901, 0.9986912181458304, 0.22293848312523282, -0.3508376500803148},
    {-0.19142411792898145, 0.761675500573046, 0.2416833475179679, -0.5287000982411614, -1.3367499772279188, -0.8854543335493287, -0.0031921486215038073, 0.4380174633107935, 0.275919273649037, -0.8599188105414736, -0.8388366744870911, -0.06855205184256837, 0.03943756142907481, 0.23583234663184596, 0.15762175989235125, -0.6167744154548709},
    {-0.6379054504566097, -0.418118011760782, -0.011869757896599949, -0.11425881479613821, -0.6182452272829223, -0.5365726780028311, -0.23853060748868016, -0.40298527522640715, -1.3935860954999362, -1.0597645912842606, -0.18287019049035552, -1.4393821617044822, -1.3036197328136425, 0.19812133930732342, -1.6399387772402714, -0.8483445664422081},
    {-0.6627705012541731, -0.4821853264218501, -1.089765345869862, -0.48302439152029547, -0.9580020211694814, -1.311128319656884, 1.132794214765012e-05, 0.06257871081934571, -0.5546789305410873, -0.6785590066015782, -0.43240749990729627, 0.05755090786123726, -0.6898941972477645, -0.7023139045627628, -0.10427732175109712, 0.1120821170948121},
    {-0.6342928380420775, -0.5146471189570356, -0.10500512847045054, -0.4522094006635832, -0.9539184004195931, -1.1256986612733977, 0.3419132590379902, 0.1420684930141332, -1.1073853687920054, -0.6397600187450662, 0.16557995200838066, -0.3694959627470604, -0.2800662351883686, 0.8484334939935089, -0.7190464306887084, 0.6048962856839211},
    {-1.4231056328699219, 0.7500355681863982, -0.4291044842278037, -0.45169834636225686, -0.7393583870640927, 0.1841467457258044, 0.1330230139209389, 0.9013725362867451, -0.6782760163505628, 0.11167502811356046, 0.019688926435655178, 0.6625046983047902, 1.4619820465799307, 0.7359340128506836, 0.9924001125624913, 1.0000060745335184},
    {0.5361074670968904, -0.6450085840488216, -0.22149321583013318, 0.6256126538864175, -0.2067896378462551, 0.5561810379857669, -0.693977381462948, 0.2514034826163766, -0.28784594744560205, 0.08052417971270155, 0.3573235608063704, -0.27698751807944644, 0.29223774869604946, 0.15731489985727323, 0.5683197922328795, 1.7542948675909178},
    {-1.787684445082118, -0.1474939398654343, -0.3503923435085514, 0.45527139599774036, 1.3459624484123962, -0.26277324068742547, -0.7835059582805146, -0.13723159932524068, 0.210656841467671, 0.11202629727481538, 0.2256577862345318, 0.6420284718567582, 0.7373399244606844, 0.10178793814057571, 0.5582179678814827, 1.8201223651056104},
    {0.3194627949719069, -0.5697679007338716, 0.33241820610223083, 6.721010991009199e-05, -0.11847587074905702, -0.35125860266044273, -0.7592496809433802, 0.6705637785520892, 0.32163351720823424, 0.7483446597864576, 0.5023017422433539, 1.182314466609497, 0.7407475935849148, 0.38737702061637563, 0.45845533797606347, 0.8018374091673086},
    {-0.09199896318251666, -1.3161735170155804, -0.01609572272011034, -0.6831091374494277, 0.2608542446860779, -0.5961723697779463, -0.5109236784992282, -0.7276126328471977, 0.34320303665276436, -0.4994831031716557, 0.6839619073809181, 0.5409553515806468, -0.569042409102841, -0.48668865793662364, -0.9085806742718874, 1.3555718989974326},
    {-1.051782047735989, -0.048652572582221255, -1.4462481070441389, -1.2074393469074773, -0.16032235868579628, -0.3968358468211773, -0.7973067865321212, -0.6137827875128282, -0.90560006421215, -0.4379338433448248, -0.33233318069939055, 0.749871515252683, 0.28875102011808, -0.122601569042851, -0.5947025915989558, 0.9235735392162482},
    {0.30788467143214654, -0.7468756534993889, 0.023725960903864238, 0.4539849321903406, 0.7070764144982232, 0.2063286750799527, -0.5950469149784365, -0.8306893438111256, -0.3387850030013364, 1.4890875916637178, 0.6928430883385901, 0.24430658718757686, -0.4811811030364991, -0.4681413648436385, -0.3439820382464192, 0.5801662809542081},
    {-1.7456410081506806, -0.008329102442461846, -0.6647031001078575, -0.9041166209357664, -1.2886734018832682, -1.6922926551891657, -1.1183784428770642, -0.5827212685275416, -0.3031522578229851, -1.3130709070855795, -1.4892066158693027, -0.12851077424660218, -0.07898370528942816, 0.09532864667621128, -1.4290950020429176, 0.15077748480511213},
    {-1.0894891821398534, 0.01762971063251473, -0.15737903304097975, -0.17494386630540326, -0.9971851596499303, -0.49678490369570505, -0.48256270202101104, -0.06132010028178377, -0.4667392102293119, 0.347624576155807, -0.6644217840729548, -0.38457757185636265, 0.04784163610180216, 0.5035890090569412, -1.543511977508353, -0.8337159778350781},
    {1.06028112795654, -0.8778846860463084, 1.575384542575252, 0.12234002199498167, 1.1989424406663356, 1.9007951766451392, 0.010937123861162332, 1.5648112398083918, 0.6064406344757476, 1.4426593752759753, 1.2486847748862104, 1.9049405839164615, 1.3320995794837895, -0.4561869803215826, 2.133017044893705, 1.2929656742928868},
    {1.7524759951454716, -0.9805280188576054, 1.9443710510941328, 0.7864148712717774, 1.4131418003751346, 1.9171018660392753, 0.3211044020191372, 1.6369646054041211, 1.1880795818770324, 1.1449388926349051, 1.9076462704235955, 1.8144060162514626, 1.8738234903970126, -0.4655003730297251, 2.0044408606559507, 1.9142846439899392},
    {1.0431945607446447, -0.5268624172975181, 0.9536279778650043, 0.03189016291529842, 1.0988178890701157, 1.5273681271168749, -0.16663305045295876, 0.8270361105760923, 1.1543748120031143, 1.174129187833991, 0.952245511150365, 1.0419032698037038, 0.4850930859862634, 0.11454146462995006, 1.4032366420830464, 1.385396471051929},
    {1.454521176789271, -0.6630732879016799, 1.3777815470510968, 0.9236888627614315, 1.5105670085625922, 1.8528347677960166, 0.3132774190072526, 0.6015950371313149, 1.3538293287841912, 1.2844081948191266, 1.2703593057194926, 1.0483859743753576, 1.3562956147927654, -0.2038125598090729, 1.8578312223845859, 1.6701477517091803},
    {0.5501780723990879, -0.24858072235546505, 0.795990294628334, 0.1451882389350963, 0.48393635909526683, 0.6074626370959314, 0.020001714742989698, 0.0436652271716967, 0.10825793466650618, 0.7155416458674422, 0.705389584304358, 0.8320939240187749, 0.24264767348154936, -0.15739454652589493, 0.8987669394000891, 1.3567314932534813},
    {0.38089151536226434, -0.26986507092434964, 0.12747024821198133, -0.2782582719370466, 0.1708064516361214, 0.6215210624210945, 0.21795401857180446, -0.06349810446604198, 0.5855097151081539, 0.2548369715083967, -0.19945466022099992, 0.8040812687952846, 0.24260549450349533, -0.02738539346242018, 0.7074857558323627, 0.73074767207985},
    {0.5546763315217432, -0.022250032270221737, 0.45610489198275217, -0.18468227877476406, 0.11374690063034255, 0.6890874906780605, -0.16232422467423774, 0.03313434584544957, 0.405402060140731, 0.8121276916797688, -0.04074598090546349, 0.25957877628625575, 0.33711616783509063, -0.48014777247717205, 0.8313821617404662, 0.6196707986001606},
    {0.5730207796608061, -0.1875976568292547, -0.16273989490567606, -0.2960303830532253, -0.05063242391593082, 0.5279161916315811, -0.23163006736385397, 0.27715012184161625, -0.5829347000998012, 1.0993178690405492, 0.05275912121163871, -0.1842047448130373, 0.08605322522811265, 0.04053620537704051, -0.21961974544370785, 0.055214055437373975},
    {0.42843797047123794, -0.3786713703631653, 0.08504063201882037, -0.27924264736940274, 0.21363447474805866, 0.20126036503225467, -0.2550858295161574, -0.12930381374690308, -0.3639308564542553, -0.10572351752313688, 0.16598787194955586, -0.14003870646940636, -0.1516790504622561, -0.0719881796011104, -0.7090608573225152, -0.021207427146376707},
    {-0.49888465266120746, -0.04891185072100188, -0.4593542710758651, -0.3099390827471742, -0.596084505215334, -1.1861837185702373, -0.1699264038048306, -0.8632988201730893, -0.48908542684254225, -0.9950089989602666, -0.5331499684622577, -0.7174118950437428, -1.0571809062887594, -0.3448370746046148, -1.3036929426677981, -1.0577513716886235},
    {0.004813534445646285, 0.1630893259629221, -0.37997599291657164, -0.5936896126160587, -0.5767521615320791, -0.34566517867196755, -0.28018682475654005, -0.7569603690938853, 0.011979816850976502, -0.13144424631864512, -0.33745339238196187, -0.10243862586440733, -0.4290497677732457, -0.35434448837962096, -0.9757491142776976, -0.6370469496278378},
    {0.6926610963015307, -0.26391967567837066, 0.6269237104647168, 0.45212881426703105, 0.8451589417752541, 0.8882493292277193, 0.2966877409772586, 0.19426671483850558, 0.8026252476078425, 0.7594999283729109, 0.19115790505365005, 0.6944228429836028, 0.6821193371898467, 0.009509971185760236, 1.0962512853093052, 0.830174041898531},
    {-0.6316080067428479, 0.08554790187076648, 0.16342731242671876, -0.5780060714101811, -0.5091978053783301, -0.6441755402561689, -0.5574565667645679, -0.6479891666690667, -0.26468185675677514, -0.8946136124079104, -0.13671742972825818, -0.6539067510286785, -0.24595127743395231, -0.12058953958345381, -1.0192007025788723, -0.46328596549649076},
    {-0.23095042568056837, 0.0412926460698159, 0.06305825420027034, -0.18471086560020608, -0.16903084184636555, 0.09155724162576002, -0.10633427474381492, -0.03405833590041998, -0.406319399597277, -0.09420237349572849, -0.11218533506197496, -0.37356493201297875, -0.1766116762936773, -0.060940554638479305, -0.28710646652609545, -0.24954833568643134},
    {0.5024533028383926, -0.028365246882640444, 0.35895796770440486, 0.07253068205937084, 0.48696969919368355, 0.0768564135320297, 0.07878279496529593, 0.4525677483514227, 0.24656673009371338, -0.08450209308173445, 0.17221932888353153, -0.03756108484976873, -0.02744261414382763, 0.11361685517397598, 0.18695549122042465, 0.10827072180381932},
    {0.343374981860067, -0.04068829647092981, 0.14655333390788103, 0.2149160662793269, 0.18619936504840853, 0.10893265295619366, -0.057274047487392, 0.42441176370472466, 0.8529354904546211, 0.12379622944721583, 0.5997806454900296, 0.10419062186167002, 0.5085040439747325, 0.05400687990789839, -0.20894973271669592, 0.2423892406689524},
    {-0.03425651514270016, 0.020382990372172304, 0.06510791620688942, 0.100243578019595, -0.48169684252200223, -0.6128367664972131, -0.2370721043276222, -0.4897589072250173, 0.14040880407715656, 0.09958950066443115, 0.039780364281604884, -0.1538318058154559, 0.010840642568472916, 0.3611460616674029, -0.3830297604206097, 0.1693404661480791},
    {-0.5667929336989681, -0.24012747299075957, -1.1638370950013057, -0.4891387710592232, -0.7884164540178797, -0.992825379814452, -0.4422216709332773, -1.1634493563638797, -0.8217086826582186, -0.4807386611532255, -0.42137316119473767, -0.5006492135435957, -0.8621352080999783, -0.18566107589263225, -0.8296392160726827, -0.7653597062419815},
    {0.5530665853769157, -0.12765810934513544, 0.5168410490283009, 0.3508551341639744, 0.5617154655290618, 0.36799669006961083, 0.3597685762379723, 0.23799663587449157, 0.7213869785626429, 0.7369539680731436, 0.5288848438144111, 0.11094131385074162, 0.12127391328289511, -0.19822996425924289, 0.46198782889944834, 0.37331418830858354},
    {0.01206782537967483, -0.4092455574122917, -0.4082445334386709, 0.21566073825161483, -0.2451809434068459, -0.033790069496714495, 0.053053548666290425, -0.6623815485602195, 0.33669154732517476, -0.13123037038096613, -0.5678971658949382, 0.04819551629635449, -0.6123700163801528, -0.14580984783472928, -0.7260286290398655, 0.024092293226571353},
    {0.24578641222004524, -0.20953317487122666, -0.4645104697792353, 0.11799509666309993, -0.4977807903531461, -0.04658839986711907, 0.08227936960424859, -0.37263520930494504, 0.38556766712755275, -0.16170333155837804, -0.11348961265556029, 0.028398615299802237, -0.37717560088896707, 0.04294805889752046, -0.12607411406856883, 0.19405211834684258},
    {0.5397482320664999, 0.06723099214622755, 0.267616590127435, 0.5695734875468891, 0.2822062403647031, 0.25347621921527347, -0.03929067530080584, 0.35029305845308184, 0.6063609232868841, 0.24439184603600955, -0.10405012914940172, 0.018462684089391605, 0.275842988290454, 0.2401724536476438, 0.5222575322770227, 0.3184625000907604},
    {0.47795238959414965, 0.010839662034931717, 0.5197599573688981, 0.20704916101761062, 0.2053177795892913, 0.19713237183080357, -0.07157674304538339, 0.12569087619544808, 0.9187122817434736, 0.16531042038383478, 0.7363669964791204, 0.4281907957130794, 0.6337355614107052, -0.19813977367410757, 0.5527883170045226, 0.29575466327669164},
    {0.22094934915148104, 0.2615843328037143, -0.0027830267650934626, 0.24386149427713907, -0.09151000801422013, -0.21568879436818855, -0.13043173148244058, 0.1960164722463689, 0.22725940736274136, -0.27833142034720765, -0.29286531170335134, -0.3984899970649292, 0.35251578895152746, 0.09524999688784702, 0.3718202388428379, 0.04651595559441823},
    {0.2944503899653716, -0.30093586069639133, 0.1955683748459761, 0.16456447030496296, -0.022561361610197492, 0.09299974874124119, -0.3619478131801071, -0.07409920846951913, -0.17893341460670686, 0.0014891583330733755, 0.23623718447830014, -0.220812830406239, -0.1028202968796563, -0.05597957626480215, -0.37061848612762105, 0.07145976922603366},
    {-0.6634803951738861, -0.24037785299437767, -0.0436767664934936, -0.06185121944246353, -0.22031461000414468, -0.10027235348100169, -0.07201540169965746, -0.2669431873462808, 0.16239692124892807, -0.5957564253197977, -0.2183757915653424, 0.13098551571361752, -0.27595347503595463, 0.007568313216520122, -0.06343620636850261, -0.437344380404781},
    {0.2574181626840961, 0.12891214780216972, 0.08710850417892484, 0.1235466432261598, -0.0412146811696257, 0.30287450323078835, -0.21579013707089892, 0.2543640865679341, 0.2934125035129376, -0.18801081321496912, -0.0854152080194688, 0.06163707661583173, 0.13897964859036266, 0.13370571153414598, -0.23560745414632023, 0.3413212342287181},
    {0.1154844374905807, 0.2929894443877191, -0.24488614301692993, 0.01662213916305486, -0.48259068542291, -0.026886443288488916, -0.3730717665124117, 0.13900298004036632, -0.06096797072832931, -0.007187614563753893, -0.3850545599040175, -0.17423640142644475, -0.08498372189898648, -0.424529508786762, -0.6468052015351351, -0.30058366020216415},
    {0.49482549213640115, 0.290861010957696, 0.743699871358618, 0.5106035781744451, 0.23194522441202559, 0.5433132946435156, 0.19432537904106167, 0.5853477710803409, 1.1726411222885988, -0.08813534968860669, 0.5173470810319521, 0.9105931627266032, 1.1616341923342008, 0.17724425588686885, 0.5162759211724312, 0.49911132428626354},
    {-0.32444402945611395, 0.19782192418371786, -0.10384588165538909, -0.12028539384214394, -0.44668344526760656, 0.03259274979198662, -0.08416031593508069, 0.4518235363272849, 0.09962782462848685, -0.6495117277772244, -0.4754931248161914, -0.1461829696292477, -0.34052891364712545, 0.2197308712509391, -1.1090936529792155, -0.2804825540234335},
    {-1.0948177119579923, 0.3069065561667182, -0.7991369654488932, -0.28272280367772407, -1.1959778691873757, -1.1334873095163527, 0.30912055713528325, -0.5785890517681633, 0.13966557987820674, -0.8112624834726325, -0.905131739462666, -0.7768491574812407, -0.7492057185847886, 0.22013075471163884, -0.9625549095802179, -1.0674801320647882},
    {-0.03153115337243618, -0.025784240595591708, -0.0033208530929675945, -0.10125612196379521, 0.10963416278742139, -0.049449020045979696, -0.033847912261872164, -0.18229095449431226, -0.605831245657729, 0.23032949517779175, 0.21355007224897996, -0.47809814354122493, -0.5381070767496055, 0.08151728647312281, -0.6563788333545826, -0.11301686625918747},
    {0.7258086648055255, 0.36212343848095035, 0.7170189118189733, 0.3603926550790741, 0.759623013785418, 1.4890836347745187, -0.29665609113580554, 0.5439589679638573, 0.6735742168884372, 1.1467234981230978, 0.7687465241381065, 0.7513893258622644, 1.0219783695067837, 0.16374072201820192, 1.0082767281419631, 1.0270594961047723},
    {0.9761235536521868, -0.19600461329195998, 0.672283948772554, 0.4943461786544681, 1.1091005000760599, 1.0417460231742675, 0.2572832203209078, 1.0500652917953128, 0.5130373496587917, 0.8706502462337934, 1.0229669134206225, 0.59205018983687, 1.002464625429035, -0.11190282260613985, 1.2284640477910485, 0.8769939980057802},
    {0.38252826956541275, 0.11193197622887964, 0.4389125603001679, 0.1997637720438793, 0.1802910009328642, 0.15665005778681154, -0.391962350905949, -0.09019308880339032, -0.254292723491632, 0.5418360672577502, 0.31290135547769127, 0.2734459088069708, 0.055725536577129274, 0.07849063817495507, 0.48739764413617304, 0.31311888960245826},
    {0.8624084045221188, -0.07222237069638972, 0.928797652276625, 0.5009744549051937, 0.8574245649127131, 0.6722743202572089, -0.13619853840025717, 0.6380494116582387, 0.4217511898399841, 0.7616435567230548, 0.9188880097181503, 0.5857428437045484, 0.8333900293214885, 0.06084598401631798, 1.0827859349847113, 0.4024190830164227},
    {0.5875776595500762, 0.1630730537983051, 0.6182639881816413, 0.558674558833489, 0.41862330620160115, 0.649233149251971, -0.03929864317133525, 0.3047944022680351, 0.6826974902101732, 0.313517369328646, 0.5427902339078178, 0.48705521464554613, 0.9330887417411107, -0.08947784675100413, 0.8639390261041473, 0.7271398891452442},
    {0.24339022024043513, -0.3788782856724461, 0.4055879089534203, 0.06465424633576135, 0.6638150698511833, 1.0125537957123927, 0.19905412383057627, 0.059993768818635614, 0.28140511023084697, 0.5723703879080545, 0.3903092114814694, 0.42485859495131867, 0.45359040688058366, -0.5064638433701693, 0.4740700085187102, 0.8340811447292746},
    {0.38352233643468053, 0.076803843476811, 0.34790067156088544, 0.1531659663652467, 0.42574691942313503, 0.06248581078809416, 0.283757042682312, -0.3747299872203549, 0.027979867764659775, 0.36538722034908283, 0.6134012973212662, -0.32805002111183823, -0.10470642572161151, -0.055156231011461776, 0.3570028334601126, 0.3587891132548532},
    {0.22480020046092017, 0.11178813375978144, 0.36313375868164754, 0.23637019785889624, 0.4824029042751801, 0.875396174576154, 0.290317063816578, 0.6200040837586095, 0.34118852504182406, 0.5740103457008657, 0.41464357957324455, 0.5831092599836538, 0.9646602750908218, -0.06454909848634384, 0.6941580985557447, 0.8879031317605919},
    {0.6805033763466221, -0.22967794465316088, 0.4140742254438683, -0.061703727937975766, 0.6385404995991499, 0.6696841766123591, -0.12871044867590645, 0.3457970958957141, 0.25320720371698024, 0.24560552305395336, 0.3871352190009336, 0.33197356141116097, 0.5897459145588346, 0.10392525490090296, 0.6208754640362567, 0.6794938718061978},
    {1.1572300765945052, 0.0937743518098393, 0.6427234013340475, 0.564734157127357, 0.9693570741624599, 1.1519839538676404, -0.10789458383510941, 0.8185946111215193, 1.1381594299060667, 0.5958048347238027, 1.0211392617739306, 0.7597666767197437, 0.7598386150709456, -0.00027700190871255006, 0.8681538249886575, 1.4040057567871314},
    {0.5386469809844148, -0.24601611300767018, 0.44709975202252267, 0.1402236553429466, 0.5130955606127438, 0.6728371986322508, 0.10979850582077466, 0.09982765454391679, 0.16868784582912455, 0.44225948470462834, 0.2792326961260972, 0.24551863575949137, 0.5480020285842473, -0.15302112818700972, 0.20231154826627443, 0.2018649772171442},
    {0.8081566041654243, 0.40032299507557645, -0.06754983116465073, 0.16070835865711597, 0.13986522126364007, 0.6850607563247336, -0.3470836706974683, 0.42799895761802315, 0.24263937557992218, -0.3378680915691649, 0.010700679146312954, 0.1825232410187647, 0.18759047576851648, 0.18370478682059205, 0.015749257180345644, 0.2544313146275818},
    {-0.031998011271955305, 0.20076739351886982, -0.04031671759706807, 0.09181986791779811, -0.09238777532824002, -0.40333683224747646, -0.05766461501661702, -0.26216235572281416, -0.45895015833045877, -0.3231418426978159, 0.08079750903442227, -0.07516273907728, -0.3262453467855801, -0.07759666261522104, -0.4751299884560109, -0.2010099730948951},
    {0.415355171248012, 0.22878785070897617, -0.04359460628321943, -0.37803119481436265, 0.2517994095920752, 0.17494086290599403, 0.2736402797773286, -0.022374607693003593, -0.10558596873206841, 0.23133364880619134, 0.09725405623907082, 0.02695138137641938, 0.1406612178117548, 0.19874040888945252, 0.402609650100872, 0.2026670080552373},
    {0.04377397962836629, 0.14447867552358787, -0.46419408193738315, -0.019513658857485773, -0.12581505330960455, -0.44058851982328834, -0.18012264966465022, -0.33868867273651143, -0.7108270330084456, -0.19426655018014957, -0.33650799601270703, -0.24403933188040638, -0.5115357728974033, 0.042282604276598135, -0.7358565381429284, -0.47933166570099883},
    {0.4802803071697236, 0.012661222571983247, 0.7679468877448653, 0.3391008149653067, 0.4960420124078411, 0.525889622521168, 0.18822738728115412, 0.4521039349286008, 0.8410318688198206, 0.4989048188317033, 0.5351484453185834, 0.7109143205624259, 0.6591320002173553, -0.04887758229481582, 0.5841417435422358, 0.4528236813927378},
    {-0.24959782479643972, 0.059182246531326387, -0.39568482325830634, -0.431341985213982, -0.30862365142679493, -0.27922132325857973, -0.14169920991594578, -0.04093458978690252, -0.31184909083793877, -0.5993252645466542, -0.14013732803189893, 0.024159199734119105, -0.40645941566743743, 0.045782899080168665, -0.7584068124848201, -0.4009822397345968},
    {0.7876898857337299, -0.14241098714236122, 0.40621946322860697, 0.2505683678325058, 0.6472273254295113, 1.1131832992956885, 0.0011523002944587484, 0.27725045893151407, 0.6404888293653799, 0.35517071472499073, 0.9951098238517678, 0.6711871110263902, 0.923049774763024, 0.30354905149942774, 0.7530314001809209, 0.9497155509424086},
    {0.5396853018881829, -0.3156887238897064, 0.6396344300753406, 0.4589329422949423, 0.8588807148371371, 0.5531315878139061, 0.26201885704728767, 0.07535564400756008, 0.334344097098136, 0.2763348195610363, 0.12120754955499698, 0.08076104737716093, 0.3879047322092328, -0.07485560570553049, 0.6496908758314895, 0.2193167961246393},
    {-0.22825759602722703, -0.34562019301690194, -0.02376798665024054, 0.037773885132497034, -0.5285692115786038, -0.24160293653396767, 0.0040291859550971015, 0.35491720822573775, 0.006763718830400729, -0.05533869280155258, 0.06088592893803337, 0.04391194724941885, 0.09200317871935214, -0.04503680793582975, -0.2531694141242993, -0.21007277051957057},
    {0.4086118306560178, 0.30898113347035494, 0.3467105476080701, 0.12858673631646925, 0.6724288862288077, 0.9081302099357574, 0.1860644188810293, 0.7650418606395025, 1.019303955838862, 0.4905825335598518, 0.5846358570074229, 0.6590072189502392, 0.7801174795858578, -0.0419052831479153, 0.8504447505868304, 0.8267044308054602},
    {0.46379367532181426, 0.15113540206879933, 0.6744867252376575, 0.31960596228030536, 0.6987738936227385, 0.6142373809852492, -0.20007452372179876, 0.23296006654152743, 0.5890610758266909, 0.4223870230869192, 0.6979441343832038, 0.6368424254214028, 0.8413012663775307, 0.2818586251735812, 0.8681836943131248, 0.6513137806479501},
    {0.3948450840614126, 0.11367736072778328, 0.34787309516627435, 0.14209810390806046, 0.045321946608744036, 0.14568802831919897, -0.05669180196064432, 0.030765689740181373, 0.056581582544824, 0.0034315043283288356, 0.17821770463426787, -0.07958700953777142, 0.38247527378815266, -0.038871435126875166, 0.3218264977681933, 0.010543379667743451},
    {-0.04120521892011515, -0.1440549369922541, -0.471036558686946, 0.034722426474519716, 0.05466653139649335, -0.3264306518538108, 0.32207947816435395, -0.3845026817121619, 0.2445490650461763, -0.009169016783089718, 0.10133659883751045, 0.05197208975656953, 0.10605947845945465, 0.11148907021979386, -0.0825815279042539, -0.4659803468278861},
    {-0.4664773346106012, -0.009855098272032205, -0.06794763732640557, -0.28572359826221067, -0.2955024779447011, -0.6165401729372931, 0.052627828882532986, -0.6832917510796127, -0.42653537076671344, 0.22596631588304225, -0.018364902256140347, -0.11611416853398039, -0.04279504823517909, -0.09244093201294351, -0.19219122054975604, 0.04207861661630376},
    {0.20774079081632316, 0.07193992560790816, 0.2252730170467655, 0.26238076252693454, -0.07261684853420265, 0.16123467703769784, 0.09649125840103247, 0.2623729368692941, 0.34056505795190184, 0.20005686171222756, 0.23942243148380635, -0.04776275186924056, 0.2507845652688323, 0.02681059939757365, 0.13837825111844748, 0.1493399134422127},
    {-0.1904862916096573, 0.3637405205715222, -0.6290788713884318, -0.2142110671010629, -0.28415791608207724, -0.41210026631113666, 0.1537799306357849, -0.37844837385722846, -0.26728390186235806, -0.10000660180548437, -0.09769735198654436, -0.18320565891418222, -0.34068551665718255, 0.27522937671618997, -0.055189289219425744, 0.045533058355743644},
    {-0.6123899171540838, 0.05203352589654248, -0.6715821277819499, -0.2693653678240159, -0.3667117790260055, -0.6067755083926601, -0.017414856153536242, -0.35193281375123314, -0.4760439884155158, 0.06639613816797864, -0.22956948787537923, -0.526589144116258, -0.016000744453787356, -0.11188059919766496, -0.44859383752106397, -0.3997639079414553},
    {0.7147012896989255, -0.0128840364555687, 1.9041345514087686, 1.158220408735569, 1.1901014003828634, 1.5653926333259636, 0.6422566888577446, 1.733655618073225, 0.3796343526679422, 1.0685955654701051, 1.3750936377451788, 2.1065749905681965, 1.4482174700211239, -1.5407360437650741, 1.7099135603921602, 1.6688473271892081},
    {0.6470484826701749, -0.28005468955198176, 2.1078987085028977, 1.6631855609028432, 1.1361665626744641, 1.794391300118291, 0.3999471741516748, 1.8155099727440276, 1.092922708439583, 0.8137171851242673, 1.910475846861771, 2.2343359938272727, 1.504721614612302, -1.5486924715696642, 2.055767856659305, 2.0727697862461505},
    {0.6452143623433947, 0.04061348922323449, 1.0558862066303534, 0.4676992552917251, 1.1527438243648567, 1.5679869414753176, -0.12825441481820984, 0.7290598931757072, 0.660426400599527, 1.0951580381632704, 1.0968455117406188, 1.1879868470897879, 0.617261943579427, 0.16191691766677346, 1.3298694640901285, 1.4168818868691295},
    {1.059259206242789, -0.6418238464713216, 1.2354715784385468, 0.7153541548470828, 1.3223184002066168, 1.7579527864463025, 0.3381339624195965, 0.7197748003387121, 0.8090874219604051, 1.282398531472984, 0.9735202848447556, 1.1639434496900694, 1.1220288114763546, -0.2556268041084462, 1.4086912675897028, 1.3374817734763276},
    {0.3594299075981429, 0.26487779684108503, 0.7401664220512062, 0.18682893391771555, 0.45046174192974686, 0.7062932024340609, 0.009943039459600558, 0.132596860054142, 0.6797350932092805, 0.42652567918117906, 0.43360819925042876, 0.4500250294411303, 0.6054971270150753, -0.08908824674232123, 1.0284143367252514, 0.9425841631819678},
    {0.10556757954028945, -0.20677196628478847, 0.6069257152197859, 0.2376877740512884, 0.06780916715411908, 0.9807173298959312, -0.0545060678399696, 0.26102666713605394, 0.437585616375167, 0.0006891210626060014, 0.20197286661887676, 1.0309612835591986, 0.8086316898913093, -0.6139189312071898, 1.1207495859327457, 0.834073477037796},
    {0.20087331866395203, 0.01547791362372499, 0.5190007974998645, 0.3063564598613605, 0.22064446600123774, 0.0676604145372287, -0.06709090101626675, 0.16231202325489286, -0.04195688909530943, -0.03219445131899971, -0.20269796075259366, -0.3611394251189195, -0.15252077451690219, -0.16758249935267758, 0.599164923126266, 0.34542440083060544},
    {-0.046344811192853504, 0.2627659347859953, 0.2587178259114618, 0.15356398513566483, -0.23853750446192165, -0.23226544182182698, -0.2014167013102124, 0.12231385314410595, -0.2143607479150344, -0.41531483426845595, 0.037308552018076445, 0.12053348041250658, 0.019848031202235262, 0.1746248176958598, -0.31465290536385465, -0.018129097955023363},
    {0.10213503227570232, -0.21499691148887673, 0.1713387295810699, -0.05376574055477756, -0.09957509926570243, -0.04228569812989847, -0.2803551632191496, 0.13436112217429458, -0.552053826317014, -0.3832682323038488, 0.5491496962481346, 0.5269641294145282, -0.21447927448366916, -0.5993650876888494, 0.07872426016296359, -0.010111344750298087},
    {-0.11317167717770678, -0.18023510860230132, 0.46523380669486425, 0.10883448635216418, -0.2319345260655252, 0.2796365832106746, 0.21619810938613795, 0.37982471388318695, 0.2246478171587541, -0.4637141147601672, 0.2279624959927802, 0.39393350093647295, 0.5006625533938315, 0.13840766580851185, 0.15264092873688376, -0.0484975122248783},
    {-0.4481595949988991, -0.05760256310973313, -0.40149231825827775, -0.26925836968627676, -0.3047314267668653, -0.41089968385942943, 0.036875428074705285, -0.549508155670678, -0.3080938578693454, -0.11821862615307033, 0.016675786756878617, 0.13044882849614128, -0.34600436559838615, -0.1652315415134693, -0.9494304074890115, -0.12213464265511613},
    {0.8250680453619822, -0.5004817718728667, 0.682282373088313, 0.3159020068870117, 0.8446244130133258, 0.9173193378462122, -0.0195622881740471, 0.5195338745311276, 0.7845002051023677, 0.7423708505367417, 0.8568640650388072, 0.7709069825631873, 0.8141323729571354, -0.144681286889133, 1.2184041611714957, 0.8966562818353996},
    {0.0016035941871738021, 0.42637651502359974, 0.09469677392249709, 0.2821654878154851, -0.1465703880670163, 0.2227566625887852, 0.11201250613027584, 0.18892393168042584, 0.5651118003805219, -0.026664250167261525, 0.00909541122415508, 0.43331771526236873, 0.6406459445332398, -0.18773770202541248, 0.11514193695411101, -0.07401221929492215},
    {-0.2252017954453955, -0.06109729658818919, 0.059106223616331284, -0.2908361853486785, -0.2882667775892514, 0.030939942442035382, -0.2578188892264275, -0.5187592906973139, -0.2720058409812559, -0.10735985811261556, -0.41562937635011504, 0.024528396440366924, -0.3426979959844639, -0.09062532354970641, -0.24389005520813428, -0.13546378312417884},
    {-0.24141081247977686, 0.3523840567370998, -0.323447247689887, -0.1830742384304655, -0.3755680747284359, -0.42603384803035577, -0.13122374331106218, -0.1405197700201888, -0.7176432112770639, -0.2425316932903826, -0.48935273935955587, -0.2482427120022865, -0.44499496856218346, -0.03718481246898446, -0.42945837405612175, -0.14374025884248515},
    {-0.4823176122025632, 0.4947187324198803, -0.6690638150631336, -0.12960217090213846, -0.7154600973201801, -0.37002063851970135, 0.0058613237441416345, 0.2939595005558668, 0.21149273574858654, -0.4083718703814466, 0.23615003034076767, 0.3189148007200813, -0.06608340366905398, 0.1388628232065038, -0.08867408182937556, -0.13461608412406845},
    {-0.3521997652362813, 0.3560123924164057, -0.11600331831728264, -0.20763665721227648, -0.6267212313631977, -0.6001833345484909, 0.13231199793679335, -0.14894964814413836, 0.18958938689678473, -0.21660822749581807, 0.06909553218101878, 0.020009709333590142, -0.3173610348227282, -0.20028383363033964, -0.44951795960966523, 0.07249110034795127},
    {-0.10497376546237869, -0.5065697818910753, -0.44924635137744634, -0.20952247168174032, -0.03461247103245955, -0.32843675958303353, 0.2729696872286649, -0.22389773740720478, -0.6123203417037419, -0.0850295380281732, -0.15663693128785752, 0.1436965858486869, -0.45768917705260403, -0.4481527119958647, -0.23786634619519412, -0.044101109318329425},
    {0.43577823596125576, 0.554800550342728, 0.9104639083161787, 0.3152494840031474, 0.23243020231554665, 0.7433295973032966, -0.013789517846627292, 0.5616279686623542, 0.5109093918014629, 0.43059653348904, 0.7588150336489468, 0.9207404009481206, 0.7224288674193452, 0.14392933405391603, 0.38442741087988486, 0.8566221568759298},
    {-0.5080557818477215, -0.2743465166757942, 0.2901117876720106, 0.09955708096288449, 0.15892700805271964, -0.019321649768999055, 0.11627245463548205, -0.5994612457501812, 0.15826355834646433, -0.4883611212180986, -0.46031304641291093, 0.031489473944360045, -0.2569216793364823, -0.4592721525429258, -0.6176898444830774, 0.20497382599574562},
    {0.521672890964201, -0.06199254254272951, 0.44049542643441936, 0.3922592759421877, 0.5724709440845951, 0.4445177796686958, 0.48004518305220767, -0.21383038575290497, 1.017448920858679, 0.3863363058506003, 0.4374203795340223, 0.7812470602382537, 0.6755801198002727, -0.5066634119717051, 1.1083774845591545, 0.4328570210809969},
    {0.6010906436335617, -0.07756409784393652, 0.43559656435242905, 0.07755692411073871, 0.5367323511437688, 0.2687033477103545, 0.14821469264161458, 0.6694555362223222, 0.06815453710055969, 0.6876814965098914, 0.38538271824859016, 0.6885170119516945, 0.28871352223529884, -0.08994301382976698, 0.7455139843136175, 0.39805901405730715},
    {0.2977346523976497, 0.11188340516791383, -0.17012258908596578, 0.04058115945882765, 0.33545412469390284, 0.34218229342782136, 0.15434228704354694, -0.14989279826377322, 0.3119304292830126, -0.1832359784367269, 0.2135083222468597, 0.02717412453208906, 0.5320716380383159, 0.055027709770044154, 0.033604869876989116, 0.3616362332260107},
    {0.5836686048441259, 0.18567649834150457, 0.32813337713295854, 0.17323298245894084, 0.6935133095040792, 0.4894256374926722, -0.012315285671045261, 0.8467837924188626, 0.2689092355207056, 0.09676734682582434, 0.49308166897512273, 0.349726322321837, 0.7789014796792959, 0.05066691767778127, 0.9351913436002491, 0.5991907290931497},
    {0.05491091755973953, -0.002966614349758806, 0.28142617215940396, -0.10176048791313946, 0.5225872174300115, 0.16523064707667287, -0.24725714088220943, 0.2733782558274283, 0.1355002476170373, 0.17442836327279987, 0.04797449636727469, 0.48811792983519453, 0.4627099987020555, 0.1600740188259843, 0.21984421214085023, 0.2638500550028881},
    {-0.2013699740771187, -0.2003886496723125, -0.18030538216554717, -0.3521933874789726, -0.2902930356184913, -0.0743111816376792, -0.00270114291205269, -0.41039382521504914, 0.3837726287641743, -0.25514228978998926, -0.043589400439043954, 0.31179827021531137, 0.15949613045371733, -0.36334345133533846, 0.09995294232428034, -0.03817186871704303},
    {0.3298866907578931, 0.40278250198703, 0.46261393964962383, 0.13273539118456368, 0.5089967521016017, 0.04873014341750945, 0.2913968414894473, 0.4149951792659089, 0.2936708743589205, 0.057140978894092954, 0.18464687102123226, 0.6768435229503126, 0.5269281160579233, -0.2550364713608674, -0.1644656520219754, 0.6308190368265182},
    {0.2654803435828914, -0.19059209022229381, -0.3008277733305914, -0.20811007496148765, -0.16025319273710392, 0.10574681089920288, -0.15088159341169746, -0.099524426729782, 0.0415565754882377, -0.13311721570313242, -0.07605513900967063, 0.20526963046039742, 0.008087041305114982, -0.01082738825702322, -0.3546990282132743, -0.06784992248614494},
    {-0.2831950310413964, 0.6879224455491927, 0.4708764037938765, 0.23397727529354606, -0.2412157393647506, -0.08581097310935695, 0.39213372234163596, -0.041275613691524854, 0.9230419415728669, -0.10694493598430822, 0.030875182190310393, 0.38656858006240696, 0.5852445929615706, 0.06625277554398674, -0.31181690146555835, -0.07197913992658472},
    {-0.132898252639212, 0.012532806084550983, -0.22551318012772986, 0.012699886838143083, -0.2708278681189544, -0.18809101450207855, 0.08004548208244502, 0.2152769179100413, -0.21399910554786147, -0.8401958654722873, -0.48023626180659135, -0.6472936791343877, -0.26719096290171346, -0.1051352859768792, -0.7534596927986887, -0.8054259687842017}
};

static const float b1[16] = {3.2524165027550733, 1.688588462509612, 2.4246751094336942, 2.6123236031431043, 2.295259448231151, 2.1833849983744527, 0.9181403835153714, 2.545408782376716, 2.1985461415898047, 2.674419708340672, 2.067433108728611, 2.7996159527501474, 2.592424683745326, 1.3240551517973964, 2.676685131349076, 2.8023718910622915};

static const float w2[16][12] = {
    {-1.9749104831216426, -2.4903510602678387, -1.7733195554486811, -2.599961914841561, -1.8383325652796176, -1.4357856142994727, -0.5056021561716837, -1.1361285227425184, -2.1220328975086384, -0.2024486426897645, -1.9301568091411225, -0.07576833258748743},
    {-0.4290407164076586, -0.7223786188872425, -1.7109463291699811, -0.6664329469845893, -0.894192217979852, -0.7371053229254368, -2.1884079133929437, -0.9765120954177514, -1.0770269286348153, -1.1603519547625079, -1.0046489965238772, -1.9474243084077076},
    {-1.4703269791914653, -1.0506023839479495, -0.8449268399166157, -1.4806985532466088, -1.7856367569450595, -0.30121742590346456, -1.1934108368345728, -1.5303278638298712, -1.4189665971976426, -2.0154248082249118, -2.5561627655683896, -1.0993591750169736},
    {-1.3357333768420037, -1.5941474115813214, -2.1753684422128186, -1.416255362248623, 0.7036822339629886, -0.605420132647514, -2.331878597425877, -1.6543883454201131, -1.05146048408645, -1.4119007044112972, -1.5674831234977358, -1.7424998576491526},
    {-1.8614916629225433, -2.4238605524755967, -1.2829304127336496, 0.4261493132852022, -1.7554179468903641, -2.336366550770143, -1.669416621429659, -0.6524115462039013, -1.8933833245930136, -2.977186226164807, -0.5006610333196995, -1.174586860512527},
    {-0.666418193500949, -1.2741382340074963, -1.7300876342595546, -1.498558500980988, -1.0772813829091414, -1.0666965208529415, -1.7545357252196092, -0.8407937560689648, -1.830506032633466, -1.055865721513482, -2.2764931572327893, -2.0425225360257366},
    {-2.8059188429238104, -0.357413428285313, -1.2674181537027838, -1.8841768484328483, -1.4200722995373785, 0.180824601368292, 0.23567464206173555, 0.07872057415445567, -0.6409198908579284, -0.5917704268852695, -1.1838005211664613, -1.3744008542664787},
    {-1.557387531172927, -0.7861486981070185, -1.0921770240362225, -1.4070510722694387, -2.323260804467306, -0.8617251572561632, -1.1358508462937695, -1.846237610990081, -1.301704881316085, -1.6080197576527582, -1.959234476712408, -1.3659180306442342},
    {-1.0937358984651069, -1.6913426745300004, -1.6909442060534254, -1.080668113710643, -1.3294430770053187, -1.5375582305160829, -1.4927914989066788, -2.0498661179323543, -1.772315002077096, -1.7955391439098458, -1.2859990187658312, -0.29751640995689066},
    {-1.9179988523360325, -1.117362571110289, -1.3065805906316963, -0.7126855100040242, -0.4068447833342331, -1.596261832406325, -2.1789220784348804, -1.8324574444831838, -1.9870099858827757, 0.14531860313610864, -1.0471440563593197, -1.67160977144769},
    {-1.1909211363024061, -2.2303746014606034, -2.5730896441157953, -0.8646712092170875, -1.1249635682661936, -0.8772043695636905, 0.0796431485087887, -1.3294057379207234, -0.6479757667548023, -2.306702378426245, -0.8585162541690334, -2.088786910934162},
    {-2.5292814797051864, -0.7417445490215772, -1.6271233714444535, -1.8530523696549728, -2.3298920848801314, -1.6497110242547244, -1.8089555527140389, -2.262329846339763, -1.4252532357741534, -0.7735848041741029, -0.2243399392930248, -1.7231184122768752},
    {-1.9406886496133218, -1.2111209586986638, -0.6002457485500269, -1.8588032400988188, -1.8420193951703416, -2.6677144121377228, -2.0201608316799384, -0.9725873646900923, -1.452666853097445, -1.4864932767658183, -1.3176649286440096, -2.418880693234209},
    {-0.7417197086294858, -0.8917140206312486, -0.11530297767115186, -1.5270846765562196, -0.6829383460673442, -1.3237555564760821, -0.1362831499471984, -1.5553665185973589, -1.8028088126845716, -0.32821590524844096, -1.7536933517487114, -1.70310537556207},
    {-0.00942835950235288, -1.2697255607139106, -1.9381321853131548, -1.5659285771878395, -1.8989545149399647, -1.597130140532203, -1.523112581531972, -2.013834032031725, -1.9120507718247937, -1.7774131039257977, -1.861055162960387, -1.6863916678815751},
    {-1.8512092337159045, -1.537844901964336, -0.7870944615454282, -2.9759229699820406, -1.1120609457807977, -2.1063879966754757, -1.792985948909872, -1.4791667902407255, -0.22448684802681868, -2.1160741042768234, -1.5591737409103503, -1.3015637236767088}
};

static const float b2[12] = {-1.648572790639488, -1.1302765436877702, -1.1765897630676045, -0.6533708921662884, -0.6840365071991465, -0.5853431044467344, -1.13573091731631, -1.0426956485858305, -0.8271577355915978, -0.6813314023367157, -0.6832471251458356, -0.1777687562185657};

    // Input Layer 
    float z1[16];
    for (int i = 0; i < 16; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Output Layer
    float z2[12];
    for (int k = 0; k < 12; k++)
    {
        z2[k] = b2[k];
        for (int j = 0; j < 16; j++)
        {
            z2[k] += z1[j] * w2[j][k];
        }
    }
    softmax(z2, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
