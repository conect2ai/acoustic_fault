#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][64] = {
    {-0.37248293230202467, -0.34389594977456067, 0.3055000746633792, -0.20073487870587503, -0.45944050462531094, 0.3665679971998093, -0.41537811230240196, -0.5113892505312779, -0.18809414719022888, -0.2544970373786424, -0.40599725542803966, 0.36317551514649454, -0.23566984708235528, 0.42509294800845476, -0.26586683147313683, -0.3825653214196913, 0.032957070751985965, -0.4395751293033561, -0.47982661951608474, -0.4705761065623397, 0.16752242156220612, -0.37208418643585867, -0.24745581710043144, -0.35077143583323833, 0.12939752238976687, -0.5283326592211794, 0.1767162164168336, -0.4950610005032742, -0.5761333148964137, -0.17984686006077172, 0.37482643476621363, -0.057626287420164776, 0.3303267443219106, 0.2105017005753961, -0.02077632715713759, 0.38001768750156295, 0.06541714194088613, -0.3967814671743989, -0.29249503747382555, -0.5219171493092652, -0.17236634337300413, -0.13632914670367313, 0.39036250115740845, 0.47981079532297877, -0.5647107418323634, 0.4900378076232251, 0.18395750074264922, -0.5169345383337021, -0.32940441580756685, -0.5028584480198317, -0.44029582837706255, -0.16097398305334953, -0.541035125239674, -0.3152175850096997, -0.48454123367715457, -0.21916383751235527, 0.027922342462266568, -0.20554974519746105, -0.5102629196908519, -0.273640519545941, -0.26265275285695294, 0.27517707189281837, 0.33599331772488494, -0.15150990709432058},
    {-0.27105444775370563, -0.2225818565349212, 0.24994361330196593, -0.48268155637221577, -0.24179651789416656, 0.18136004579498938, -0.38213043626836773, -0.16011861576002717, -0.20510072167292256, 0.2815593128178951, 0.13956094710693692, 0.5522963554832045, -0.3837524940638881, 0.604106814448232, -0.30465995799940127, -0.29655172984757977, -0.16643538169174596, -0.2412362755943478, -0.6125506988793515, -0.15223986022465943, -0.3046271617884279, -0.38607091003285565, -0.43881762925087936, -0.318357586159298, 0.39085196915943354, -0.6612890791936542, 0.1013766984904053, -0.5223498282520908, -0.58001922125459, -0.272804767767403, 0.2430772282526852, 0.20589661780578555, 0.5566206212448837, 0.3518785403472386, 0.38512915850349333, 0.21489076518382555, -0.1379095431207806, -0.5102305373243119, -0.4860561740614531, -0.11406051183727083, -0.4808867377042404, -0.5840443817121481, 0.28335638724735795, 0.5553313232296546, -0.35383328433937944, 0.279958095763779, 0.1571973875773399, -0.33822717853198936, -0.5513924645858845, -0.5923693404187096, -0.650534666973967, -0.35007323392651374, -0.5989988335247174, -0.41839247330678375, -0.34188757071230974, -0.47465127839346444, 0.11117034685984978, 0.24854247908599003, -0.4976050925318007, -0.12334814679863179, -0.12116210168558474, 0.4042148473604977, 0.23811445562253652, -0.15760675765926863},
    {-0.41990834684212186, -0.5221830847997042, 0.37689316497454023, -0.333878700327443, -0.38883784323107223, 0.674591839001855, -0.27946312474297597, -0.5776326647455298, -0.4690737995122721, 0.21688349834617401, -0.0005018410706058667, 0.390173363631227, -0.39759251529934514, 0.6382168615352384, -0.012846486862228411, -0.06146675926341472, -0.20225090504736243, -0.17628295905635616, -0.6064587529453299, -0.23006823881216312, -0.11730208297460994, -0.37971238993299744, -0.39279092336876326, -0.32084468258379184, 0.5569964427384793, -0.6924578994939441, 0.318503804588316, -0.5216069768221773, -0.6611288797526631, -0.2992743497571418, 0.5988487879985711, 0.4085086033372994, 0.6776380628636035, 0.4560921255317522, 0.11226803489889198, 0.6024645411670251, -0.2212479809991113, -0.4510011774555322, -0.3959528696598212, -0.21432040592561474, -0.3155973986813062, -0.526263993592066, 0.3692596480146878, 0.5751094350584168, -0.5730019279185494, 0.38534881654132885, 0.28184253300960466, -0.3851182719067294, -0.42083845212317916, -0.6042535334281129, -0.5450134205622128, -0.38579800449428986, -0.4351758584922997, -0.4936030709572091, -0.49977787143510305, -0.398978648443844, 0.5169181249626923, 0.17110381049494344, -0.4774274051303423, 0.22412271953876248, -0.0829369643693792, 0.5540696127528205, 0.397504701984626, -0.5250706965207534},
    {-0.6749418295743885, -0.5397885528215842, -0.034825240964468075, -0.45524389055155123, -0.356339492492237, 0.36472557999762967, -0.3804542018446646, -0.6092044023457173, -0.427581824023657, 0.0031610386064708403, -0.2955733022092427, 0.3968365331006568, -0.4954065228374287, 0.4939461856740409, -0.2311009904733327, -2.1081140447262476e-05, -0.1609250100753094, -0.4090665678971371, -0.5385894919370905, -0.24770038506648268, -0.5483658083798372, -0.5277581061865922, -0.6564073767324347, -0.6850797927872024, 0.6548793640874407, -0.6723288149486474, 0.16474963361945266, -0.5516388163010693, -0.5862633676460751, -0.5305121155581566, 0.24614527830727803, 0.1856633619375903, 0.579058517489462, 0.4999574536334117, 0.08712268876147332, 0.47796839390778983, -0.41874215835055995, -0.5192186195909236, -0.5515322125276825, -0.40812853205652855, -0.6252451717520974, -0.4121015484844245, 0.36370478200103673, 0.4562260421951578, -0.6510261131408448, 0.35394934408690637, 0.40928038992751525, -0.31732381586063124, -0.5568847071305898, -0.6338121326273621, -0.5120345644671583, -0.6735569212256273, -0.3898329434941805, -0.34983419607472843, -0.7209873259129561, -0.5682260332455529, 0.2608060916613754, 0.2032561429160126, -0.7224274119032934, -0.143344151113197, -0.25432654975917496, 0.3650106069562655, 0.37657992712639793, -0.2200118892600451},
    {-0.36090023728666626, -0.41731038947823773, 0.14191707860093047, -0.3802932050031554, -0.008955625218469666, 0.5940028255629421, -0.3460360434415771, -0.48947171485228835, -0.43341194712984693, 0.0820025761459305, -0.30403657007105955, 0.4213090413917976, -0.6324911258679958, 0.4054473365321032, -0.31629430941151226, -0.14693935583396442, -0.1155506244998685, -0.2170279239067173, -0.6354216450346574, -0.2670679511967585, -0.4347973884962087, -0.4499303320097126, -0.4688007405204453, -0.6802383102759885, 0.5718977739086957, -0.673845776299055, 0.01916196973226072, -0.6438694087902949, -0.5925391248169111, -0.6461852038977127, 0.49453610110897167, 0.3746338149393612, 0.34232609119275936, 0.5836730008907564, 0.01728428572768603, 0.31828834075874207, -0.24552420968703206, -0.4298527130906129, -0.42882822651716085, -0.4153988344493766, -0.45393092048093003, -0.3176381889765847, 0.41963981678649176, 0.3662128514163274, -0.38794286402430506, 0.632736772681326, 0.4707829131255515, -0.5703886007051383, -0.567693950224395, -0.4389836688770599, -0.5849036308181208, -0.48013042420051494, -0.5558301745792926, -0.54762401661865, -0.7016787732226795, -0.37908153430468045, 0.48699142289572317, -0.056233896247028244, -0.5801356349493461, 0.09964045223297356, -0.26241105633832557, 0.44189224301739555, 0.4589212058980091, -0.365441170504739},
    {-0.5130600022525296, -0.6084019836801686, 0.04948908426822374, -0.6100273156515554, 0.04038402966822902, 0.40567393619139575, -0.40734299962344367, -0.47391198114485045, -0.384846331548546, 0.1870289875404978, -0.3134218528541706, 0.5177611773546382, -0.518167072632454, 0.427985937393502, -0.2409213742645814, 0.06577395469376017, -0.002753258217109837, -0.30335841228526855, -0.6832636290736416, -0.12048638782578018, -0.4807677589941283, -0.5082173293078642, -0.555391656596176, -0.6536941313395417, 0.585709649106859, -0.5853370548211105, 0.08424364054909746, -0.5874753137785527, -0.6679007230699561, -0.39597813222387096, 0.2649420501337898, 0.43211069488450404, 0.5054788378774031, 0.40287696561434133, 0.2761296567663818, 0.5384314313953692, -0.3326320956733014, -0.6349377811378605, -0.37618476833425757, -0.1502743662744264, -0.32117545854778734, -0.36106889652246904, 0.4904702890509283, 0.43835093571154327, -0.3799134467223434, 0.6473593093307559, 0.5032275967270456, -0.2556944832573742, -0.6773083790626638, -0.40222008391982433, -0.5537067216978862, -0.6782440074575609, -0.4305813458985903, -0.5588892985715929, -0.6400857209360923, -0.37877005417072684, 0.294177146514678, 0.1576748632299401, -0.37037890415261804, 0.2384994262010009, -0.29360934397124305, 0.22744068977786785, 0.5594510051002431, -0.40416261530914027},
    {-0.4221817003764, -0.3539769561424418, 0.37925175099635394, -0.4641180201970091, 0.0065179366089819476, 0.39020072964940156, -0.5713959129612814, -0.5802008105784136, -0.6039044774705652, 0.0556803184964454, -0.06000187749278012, 0.17536659899169182, -0.6645010302478755, 0.34343971583666394, -0.145798674243477, -0.027548558563670653, -0.21149512568915396, -0.2710079899673504, -0.6565654843479631, -0.39804945423917476, -0.41966973528765456, -0.5014775070271764, -0.5621516659326944, -0.5595357400685296, 0.4141290010185453, -0.597536607722437, 0.04616412623305647, -0.39739183703497544, -0.44425830046217074, -0.5689500785395011, 0.346178529822821, 0.2783831464414343, 0.24486477429009357, 0.4688871876777604, 0.032245976343705234, 0.53739359621221, -0.1725468895339846, -0.5418643088442333, -0.490153377642648, -0.28184227240256055, -0.5839307324055905, -0.40484625948675046, 0.2072779249884445, 0.2506861804057345, -0.4834097774432073, 0.5206995553123293, 0.45648959727466193, -0.399282436233331, -0.5311318991069087, -0.4942066574263085, -0.6570486186848254, -0.5990340344293063, -0.5918261647323669, -0.5961967269365035, -0.6398245057951225, -0.37311445819164746, 0.24641689228710517, -0.02953228861026432, -0.6258992403448719, 0.023593280012319626, -0.3298854358704241, 0.41003034713502806, 0.3964080852945539, -0.21327239178828028},
    {-0.40452269542219993, -0.4406508813805988, 0.3201950645904172, -0.5752122993742148, -0.015222492129989674, 0.3179766980259819, -0.6075716499918036, -0.6073775870361938, -0.6413999733244555, -0.009261853229938404, -0.22156790661762255, 0.18102579844734218, -0.37477377054597105, 0.3691092067064415, -0.50292069654522, -0.079762260402071, -0.09966751905459055, -0.18366928785609277, -0.7386823580938761, -0.49791615003821077, -0.5646382165331965, -0.6475895526835681, -0.3491291145594303, -0.3469795992694025, 0.27851920853653184, -0.6642938663235952, -0.14074107766061678, -0.5590949653443703, -0.7110766902734836, -0.4943741590125082, 0.4120212842157585, 0.024257217621490072, 0.5309800901658591, 0.54952860401853, 0.2031474452515298, 0.2962089491749243, -0.22847268770575033, -0.649300067626145, -0.5791067623386388, -0.32001083975540306, -0.4036091302813759, -0.3754885907668908, 0.26296084252089247, 0.16161234497568472, -0.5175272135022871, 0.34135338656780306, 0.4063709439415499, -0.33000394542794703, -0.701494396861936, -0.5586838028517498, -0.6791110947287009, -0.4147099061371759, -0.3359438139007652, -0.43293867526766294, -0.4566479236251688, -0.5713698445834531, 0.16852337739852702, 0.03992771128488116, -0.7548168857290689, -0.20139142632410648, -0.608742785122964, 0.278481250434398, 0.4877343612384761, -0.41834566832434467},
    {-0.41867359422885997, -0.4996359192561421, -0.05518800475077977, -0.4709067012959348, -0.009764652836078417, 0.32152192931312384, -0.4748696728443969, -0.5590412378642465, -0.5700799143963733, -0.037633027511694124, -0.269115485563881, 0.14503360352481237, -0.3273934773422551, 0.3907606942598509, -0.43645398372623007, -0.047912464475738506, 0.018595025716625992, -0.30258746291708927, -0.4504416850397238, -0.3325612362064443, -0.5929984735997277, -0.38080531224033987, -0.3922370409147663, -0.5508771476065412, 0.2069794346093416, -0.6554710900091875, 0.16484413949319915, -0.5555398468140721, -0.6361099830746533, -0.3264419684264127, 0.2647384971334803, 0.1809177905339047, 0.5519922011519212, 0.3199484452913957, 0.15223883364388777, 0.29531338535742385, -0.08461891472413899, -0.5642767446861516, -0.3810288284640874, -0.36756553912482726, -0.28678381939653724, -0.498899323227417, 0.43002606058250686, 0.18116737120877013, -0.5563951777642426, 0.5184652359707475, 0.38974515508184565, -0.3360379190967162, -0.5704787542698356, -0.6132240382794617, -0.56569664872138, -0.5771315766712137, -0.611095670822462, -0.5551963326232865, -0.5455089864811504, -0.5025308589730276, 0.07108737056736941, 0.12134331938620903, -0.4724340053870336, -0.14351761128205107, -0.5582071236474019, 0.2505254908766235, 0.3898239144112729, -0.31131637730784156},
    {-0.6407464741024297, -0.3331256196457358, 0.21963754351819703, -0.46207962343039943, -0.06317084503321496, 0.213498060689474, -0.5188958690167663, -0.579297211272539, -0.4808577336587342, 0.22208505547987564, 0.011810267251647738, 0.20437174787609885, -0.5464180055430825, 0.4641616584940651, -0.22268389183805654, 0.06342307228006107, -0.0029021470611023097, -0.11228879986629965, -0.7199439734952098, -0.40647523666434415, -0.5707603453377401, -0.7310846867425462, -0.6607848113347765, -0.39687076188500076, 0.33017267209966483, -0.6096472664661668, -0.08147014973417924, -0.7088913154345594, -0.4206472989028951, -0.5551190684317929, 0.43127691012225317, 0.36739900676215226, 0.6048589892126965, 0.3566222282223185, -0.035938656166993786, 0.5024996419042732, -0.09969262206801004, -0.5604092345939848, -0.654152970952792, -0.20671851055506776, -0.47176418639566386, -0.6431585282231862, 0.2322226456200067, 0.42639319797376346, -0.6737826710505084, 0.3755961978803413, 0.38870422266742805, -0.3210728524627946, -0.7274019040989484, -0.5415938081148916, -0.6137979110273754, -0.5613904421193594, -0.38270004684981535, -0.4678624857612289, -0.6214247956381573, -0.6796955573015038, 0.042314594310800965, 0.08650297910513463, -0.4474796377736335, -0.2511663519511069, -0.5130710139842479, 0.439677274025327, 0.5546748253178626, -0.245326371070544},
    {-0.681537921355809, -0.541777818955259, 0.1316850217703722, -0.6202648424914434, 0.04122131889255802, 0.06544950487833412, -0.39301983897162723, -0.4871231828648064, -0.6176221137143865, -0.009625405470538615, 0.13541202947808928, 0.22533851494729787, -0.4443391927198971, 0.4150198574980059, -0.29070235242405446, 0.0999345134163959, -0.06009968971720766, -0.3441729164241695, -0.6313980016034934, -0.22222190755138885, -0.6922457811525102, -0.4858161578923236, -0.6566247229834012, -0.5970256532862801, 0.23449304670308913, -0.657474590787913, -0.017983686180837857, -0.5690570628157375, -0.5875402359498633, -0.38036659912819415, 0.3469090140127823, 0.42097607010948657, 0.3859892169540566, 0.23498755826299517, 0.32164759993322345, 0.09848500017517925, -0.13783179151087516, -0.4254516259911964, -0.35733215604182994, -0.09264532951699944, -0.5719600111322728, -0.507727859253843, 0.09562917031641024, 0.45810013915968484, -0.668011779735376, 0.35815607691314383, 0.13706971039247115, -0.5927703596835756, -0.6381989363757964, -0.5318395962770692, -0.4479881793943043, -0.4980418542448771, -0.40851207028864545, -0.6354338611389612, -0.6079208166898936, -0.6203125733213655, 0.02218343623999907, 0.2203722218117368, -0.5869505937417613, -0.05416837217699498, -0.5934393525333608, 0.5416126503332583, 0.30708402692764114, -0.562055691040507},
    {-0.5848311664650809, -0.6555342379567725, 0.18441659218646808, -0.4551432416699768, -0.28120791013962376, 0.18927059888953482, -0.47732080808788324, -0.6640647111282314, -0.46983912754048013, -0.14234925137390675, 0.09121305321914695, 0.3377967782164354, -0.5383076323223958, 0.48694431477172445, -0.41329835262596515, -0.16255549252848014, -0.11268514020906704, -0.0403827654649819, -0.6815261844952858, -0.11579958568477457, -0.4235459545531582, -0.46221116759600617, -0.5169464564968992, -0.3426946561274301, 0.35684746053151883, -0.6855553597518632, 0.028393526145536, -0.49338560102401824, -0.678364483700131, -0.34324525338232, 0.3166289649965435, 0.184475281775938, 0.48943554347785573, 0.18547958396892453, 0.3204586870959804, 0.34673165630596037, -0.2950828614777656, -0.5915152729649829, -0.6035368649750184, -0.1403954067951497, -0.7027727839150402, -0.4621442690528274, 0.253196198762959, 0.45018282125941284, -0.7095896031796961, 0.15761406825304883, 0.011343267253971645, -0.5204475784894415, -0.5455094951662185, -0.6885175445874576, -0.5742049733888257, -0.6308122680489835, -0.5798673771794622, -0.666522722488418, -0.46643351831574575, -0.4144306906971514, -0.007778884862244347, 0.10749604829152468, -0.7556688894390251, -0.07732293851894477, -0.5772495722200918, 0.2866446725335213, 0.44001638204064153, -0.5436676585136389},
    {-0.6535722264881576, -0.6071213530022983, 0.03904333402946748, -0.6349702148384874, -0.05240389695182959, 0.1977461907149471, -0.3510932114241583, -0.44417533769308687, -0.4914912837860778, 0.05226919584475219, -0.09910558114169313, 0.36264810412477716, -0.49491276465913253, 0.4452418933644511, -0.3904862627840698, -0.14173786225141483, 0.06461300783842186, -0.1478683754504058, -0.400637178044528, -0.4113146526278961, -0.6556030690239757, -0.579915207181046, -0.5081029279899305, -0.43173786980559997, 0.2150771487079566, -0.5179861550835492, 0.12950819767464522, -0.6895989900079623, -0.6334936070148083, -0.6241419586864246, 0.15196804427845467, 0.1180178400377403, 0.47007956355387187, 0.09796014538126822, 0.3187116841309212, 0.13103355912134118, -0.05161591568276979, -0.5499281567554978, -0.5040246052593438, -0.1432276286354369, -0.3453899586466888, -0.6377752538528815, 0.22893626340078654, 0.3326820318310114, -0.47431224226162405, 0.3805669095022837, 0.11128924297014808, -0.5776017518966662, -0.44066684884692786, -0.4980254206838673, -0.3450202392552487, -0.5872090047533947, -0.2986489562017266, -0.5755308512568178, -0.5441601450111336, -0.46587134964066307, 0.08516738773184356, -0.1113499743711155, -0.7398061128258734, -0.06346812429275746, -0.5407489229545799, 0.24242357824743563, 0.3554129739417145, -0.5056378069465881},
    {-0.6054935968582376, -0.4068332028297014, -0.13046538863394305, -0.7159008332416167, -0.2004843286654575, 0.32905075798847316, -0.6436132914999861, -0.5770886828688616, -0.6807853845547084, -0.09828993726483083, -0.20205498786966533, 0.293429880412293, -0.2974434430915259, 0.4866185033308244, -0.38350251567097215, -0.09737782367829588, 0.06683752339094812, -0.2527738823638427, -0.6840710636634237, -0.4362070608556417, -0.6967499861196926, -0.43459842108979924, -0.4235510133852399, -0.5903479714311781, 0.47131126870953716, -0.6810938240009494, -0.08371581725595746, -0.5694375734925096, -0.7014714921757365, -0.5819123195973404, 0.23533230352811008, 0.2220730720699241, 0.5020143220063299, 0.3579695233297532, 0.2909546399565418, 0.29964003676376416, -0.10079193184846602, -0.4211778153648397, -0.4219951458223892, -0.07001215219155375, -0.34823119308325057, -0.6681289465039495, 0.22060535191611597, 0.46864461083407755, -0.574800855259383, 0.36901188263957846, 0.17877205528531795, -0.4246360528627299, -0.369010462715197, -0.6212973608041059, -0.6225122276932454, -0.6719388553912181, -0.5415459672851993, -0.5804996669225068, -0.7162415195639923, -0.462029144145339, -0.03739775717107156, -0.08943181710898906, -0.7103006049355477, -0.022602092818179768, -0.5702686608282902, 0.4412680895907298, 0.44508890292210634, -0.567538271710686},
    {-0.5552646103032889, -0.5778293213482621, -0.14132574191376568, -0.4204492321652859, -0.31262631087587106, 0.38458180730360736, -0.5601319597925315, -0.6348368497753675, -0.45077171805474636, 0.17850575316705136, -0.03232457339809248, 0.23045598915434198, -0.4835817591430353, 0.5002329082436809, -0.38798277927528974, 0.08123088423380488, 0.0034283813459139428, -0.32612183331074257, -0.4688344759495726, -0.08356576552988296, -0.5262192465941887, -0.5710657690764614, -0.40439856269886487, -0.498175530490825, 0.5103076291361412, -0.6845431605496982, -0.04140222917283498, -0.6376096805002629, -0.4848505616348762, -0.43817438821025034, 0.325287160721605, 0.35609496078785435, 0.4314175472213499, 0.1876883721070932, 0.3141321286085299, 0.4950889060703823, -0.13909981372331742, -0.5186963002483961, -0.4226474322450037, -0.30019916790588197, -0.613166000525994, -0.7191567553928948, 0.17251183521209418, 0.23336043990261449, -0.41302950671067945, 0.4055855909492064, 0.12807326160105592, -0.25075246642556087, -0.6658631262444716, -0.5259814105123467, -0.36149050049630105, -0.6743940238507444, -0.3541882825480702, -0.4171808226631292, -0.4635195166064867, -0.3821047912885311, 0.18149892010697322, 0.16605980863821837, -0.5031763942031412, -0.05243744472493618, -0.6637346862077566, 0.3636619379483781, 0.20825840365505152, -0.37660874044040554},
    {-0.4993112717510904, -0.585483216016906, 0.19461429208538658, -0.6412395415056854, -0.13127452692711827, 0.3590850017521416, -0.5767362864848772, -0.5811367851825088, -0.5906267920301993, 0.0328682530665042, 0.11271410099577753, 0.4832657105709018, -0.35986821254554635, 0.2700434773751923, -0.11066849260710034, -0.0766553537716437, -0.12291918865147793, -0.12005317438684292, -0.39025744313668564, -0.2678905960732179, -0.40045238683940665, -0.7147620929298162, -0.338598886182603, -0.5442444930678985, 0.5578973052067888, -0.42711891438669425, -0.022795034353791852, -0.3774437896480274, -0.6458419726199685, -0.45630534240205395, 0.271607241361666, 0.1479082242415342, 0.6053766356170476, 0.5241169900098962, 0.3126734449538684, 0.3567444413295467, -0.13928814420124552, -0.4342646069577324, -0.3176778034321634, -0.33580156953875473, -0.3714272748581549, -0.421283789857484, 0.2013049426906496, 0.42226149448658123, -0.538214218999681, 0.2789390715119012, 0.28054070451394825, -0.41888015396609435, -0.5848294285048732, -0.6554836900752997, -0.5561777006898483, -0.6807238380682163, -0.39668958775923135, -0.32180235388686784, -0.3662952941432028, -0.4130016478440889, 0.3250366632684308, 0.11887376243802077, -0.6687450204038554, 0.025944377111870153, -0.63946542876736, 0.5090254735902789, 0.5567209895966545, -0.45392196444194827},
    {-0.6404093822893885, -0.43439328082447215, 0.09016353870527298, -0.38062560716627875, -0.09633269469289386, 0.6099660726947342, -0.6524690117641498, -0.35010023134826157, -0.4281426748065061, 0.17983185998185452, 0.09405405614469517, 0.31472510642258494, -0.6267212188552755, 0.5319391665329618, -0.2559253308026621, 0.018164235115258394, -0.03922261012990892, 0.007064772548086256, -0.3792954642840912, -0.140586813216013, -0.6109217052702274, -0.7312267041034158, -0.6111405318024142, -0.5118401200837949, 0.5160343224001702, -0.6438328167156747, -0.04957897613211503, -0.7159215174667626, -0.41085059727661705, -0.5447638975701328, 0.21943275421092592, 0.16670707702554016, 0.5685726243086031, 0.4146145888377066, 0.2613821836342361, 0.5081535664647614, -0.14600551556223232, -0.3562962098343216, -0.32790321942514083, -0.17198024058147166, -0.30955146905187825, -0.6880259847099447, 0.6232292555065858, 0.3735734121361708, -0.4397522160283071, 0.6478072937381035, 0.3670332499579898, -0.2793165466142891, -0.3594870987209411, -0.6486077352847184, -0.6576580074978715, -0.3644386459618641, -0.6081895400340706, -0.6281152966446611, -0.5671530449964732, -0.4523961518246373, 0.4133899637419117, 0.2362940129723754, -0.6285592902061553, 0.13537806205508163, -0.5802878719507539, 0.383161145635395, 0.4306672094367097, -0.38624592988282713},
    {-0.6066127236441081, -0.534641397163857, 0.11092929372701049, -0.44811021287210917, -0.06936662547815896, 0.4899688190505856, -0.6086104536539698, -0.46459540534726707, -0.6241773522810355, 0.06611123585726111, -0.021886112009184368, 0.48692551190112066, -0.3211705442767131, 0.46217112352033235, -0.05600606483960071, 0.14559399378733517, -0.03770570269406845, -0.13928066070961428, -0.6104642439591507, -0.09667643195429321, -0.526731670273278, -0.45519529944751513, -0.4448539502560001, -0.34160188174753003, 0.613529992596277, -0.6705407071359302, -0.029465561688429464, -0.4125773720725229, -0.5615542460575801, -0.4318076664653273, 0.3288524497560509, 0.31569342912889164, 0.578998286113754, 0.29549908447418927, 0.04441813877631218, 0.5078816259884259, -0.2625763495923509, -0.19454613602264367, -0.6036334842721831, -0.1460214594290483, -0.17354703103823566, -0.35001842452017456, 0.6388709257431947, 0.6317849762876352, -0.7064170829066048, 0.6187460660246371, 0.4437072878387391, -0.2602982576359622, -0.41133909309838806, -0.3502252228105806, -0.42758216049014336, -0.5905558133801938, -0.5260197255463656, -0.553743848783522, -0.4458403057909543, -0.5826097191136993, 0.5023745234976271, -0.10336963947755576, -0.6419806349685323, 0.059565942565482664, -0.23765728080719029, 0.4367866139466166, 0.5379787701141922, -0.4632922882491222},
    {-0.4646967759230776, -0.5814174574362622, 0.33977807862233916, -0.6159985359050685, -0.4246823400302381, 0.39074464682137977, -0.34978483845599334, -0.5261632467635702, -0.4514835504007006, 0.11324618608313712, -0.21562909458895338, 0.18458032514410705, -0.5519299349949507, 0.5163341434278982, -0.11365684899173042, 0.12810321969738336, -0.25060993767053297, -0.3949782496753678, -0.5916182718563524, -0.22050068973712147, -0.4225136342691949, -0.5052186183058693, -0.6166384511026222, -0.514339404882243, 0.5275394892698735, -0.36058878939231515, -0.02118365513659345, -0.5217796290302648, -0.5259653365554854, -0.35942312234358087, 0.4901122512117104, 0.22129257109341074, 0.528139868193279, 0.5330588555489448, -0.01590958926567245, 0.37938523197197743, -0.13356277445726028, -0.4154358804511419, -0.5461558546709339, -0.360639651222888, -0.2312029189014574, -0.6689448591140204, 0.6015838849291884, 0.5822407141119139, -0.7077219624528458, 0.6531849710241857, 0.31320563463444223, -0.21734785811729154, -0.4569368797720741, -0.3627419407377639, -0.59838521750413, -0.5460167906553974, -0.5633134665972724, -0.5401892459840519, -0.5167657769036383, -0.6638706174861587, 0.38503973809498604, -0.15053026170516423, -0.6452964815686476, 0.12002290532710491, -0.2974134461588176, 0.5397660798842194, 0.4019599785605097, -0.5140846469258937},
    {-0.7080299397559268, -0.4682422065297763, -0.03720961551269888, -0.5234772278457334, -0.14734051626469333, 0.47716038991101845, -0.5330926736628312, -0.5441491314923904, -0.4940338618864662, 0.15555080637530702, -0.10294309830977003, 0.27077057955263273, -0.5266548550331974, 0.5705764860818572, -0.2902851162280685, 0.11655256767347241, -0.2085981603815778, -0.18124856954889274, -0.3747691333972265, -0.32994589058810647, -0.28983518262216534, -0.5944019794230868, -0.3701550749948462, -0.558073368495993, 0.3628515338412471, -0.445929676151889, 0.18807601511957084, -0.46143421583096367, -0.4636082492720751, -0.3931180019662188, 0.49682368913242325, 0.4346267407911918, 0.2911355379547253, 0.32978473680457976, -0.029971539166026576, 0.21431583095413337, -0.09129117081578385, -0.575468078044663, -0.3827852956549303, -0.3442700754025336, -0.570621870136632, -0.6772330313692049, 0.5420478562299756, 0.2771452753673458, -0.6342502469838456, 0.5058447075473171, 0.09552074523660464, -0.39083996588823994, -0.6866828191914768, -0.645429538015186, -0.713380747036157, -0.5119971738525467, -0.4208690425317435, -0.6128152972866968, -0.5603299034588656, -0.6070738288362587, 0.1419675084482815, 0.11100327046249266, -0.42435894792200174, -0.0064354727236584286, -0.3743429063711159, 0.5828741741248916, 0.27482341274272903, -0.5234459175316444},
    {-0.7188507737289697, -0.3855110212296533, 0.008743454752297614, -0.5297220267711108, -0.052594920287445265, 0.3525619093200951, -0.36878054058234305, -0.45659532440674355, -0.4217967631360857, -0.08796184614278531, -0.08065842496680022, 0.3190048813455245, -0.5393204234885968, 0.5920571902185027, 0.05569785739898058, -0.12274711240773142, 0.05931277976721945, -0.2410334118500818, -0.6952973640691439, -0.15911385711846748, -0.3523914017554126, -0.6354197846470087, -0.4748071226509369, -0.37841381698451615, 0.41085847504397116, -0.7418311651456593, 0.00642151336438414, -0.3422484917129372, -0.3473820903927947, -0.5493303887377389, 0.260888924300283, 0.17404841988406167, 0.4102924333287606, 0.26820450500268295, 0.06460928978107168, 0.41055092448684355, -0.11752342077477669, -0.287278640132805, -0.4631915613144328, -0.05268741905175755, -0.5772827921645265, -0.5456305917398913, 0.4693523689368828, 0.4645566261233213, -0.5116315127359521, 0.471377255367731, 0.2762111355882024, -0.4097731558913221, -0.6062251493889309, -0.6425535712869165, -0.4919045827492806, -0.5529652471739785, -0.5326072707564864, -0.5395761955134084, -0.5084172948506647, -0.6311852275932217, 0.21083824709813126, -0.0457119746106295, -0.3984189323338367, 0.04801053440299265, -0.3163798512198327, 0.507700623200094, 0.36085814986797404, -0.22640412603296303},
    {-0.3286347109774209, -0.5121861444465771, 0.3178913341727533, -0.5355906493567641, -0.2593845721822181, 0.597199663411704, -0.3283143900254778, -0.2409189356832675, -0.3731463856641087, 0.06011323533244015, 0.04779202198465807, 0.4171714894500813, -0.28215130590084025, 0.6055118930462282, 0.04498575714678763, 0.0067404991467913435, -0.20418665944093023, 0.00914480213155135, -0.43473654149447116, -0.26939753322601456, -0.3989668136305103, -0.6838866750973372, -0.3996146749908267, -0.3974955838102356, 0.5496873352381287, -0.5336603745284774, 0.32197616960414455, -0.5410493960617944, -0.48675830651876323, -0.43974840468974297, 0.5741876343435732, 0.5006764378228356, 0.6540065958986412, 0.4174895411721131, 0.3391282426593585, 0.3209364077418621, -0.004591653068577233, -0.18706278571708895, -0.6009160454604275, -0.22243614948574805, -0.3360797020132907, -0.5234472202217463, 0.6843011490370959, 0.6730331692376411, -0.45069551376322997, 0.40574476855719827, 0.40547666797454923, -0.5467503488181772, -0.510927037202838, -0.44989758963144233, -0.6171973559574175, -0.5856302915361763, -0.5955413090885449, -0.5154257051896832, -0.34892311933915643, -0.5090341332947494, 0.4352809399262947, 0.2278470909860198, -0.6020140583184339, -0.001179499348072869, -0.4338040519105286, 0.580682799593777, 0.4654441601994861, -0.3072955022041981},
    {-0.4902869102203928, -0.43395860751138515, 0.3442678697857619, -0.27249294730771995, -0.33565418262960645, 0.3947685154836988, -0.4226336337756161, -0.22994107142626866, -0.4535858632739952, -0.12437049727888656, -0.019297908269292036, 0.4039753672207081, -0.33199445627825297, 0.43506844173977366, -0.03794398676417596, -0.19405764808211173, -0.057284739972640566, -0.03284083256090485, -0.313386957652381, -0.31899942033708417, -0.30270354929422616, -0.6443849200565493, -0.5430942654227234, -0.47952597418485904, 0.6548066691051382, -0.6466466256758325, 0.07909089145004754, -0.323018244259779, -0.4277356365988856, -0.44191587208868327, 0.3596619946597771, 0.491484986741071, 0.5252566297629799, 0.46742542099007206, -0.002036956950539569, 0.6393378753163467, 0.010853178604379605, -0.44451771885663915, -0.32998483879169355, -0.04294959880519239, -0.4710775926093092, -0.6198542618484434, 0.5638127598990335, 0.6755449670622635, -0.4792861402823186, 0.6824282497562014, 0.2386777619520553, -0.24397137562527166, -0.4278022164933309, -0.44558602324429564, -0.5608589220594972, -0.40124655998611675, -0.355929093048066, -0.40470076787664594, -0.506980473066889, -0.45480344674360984, 0.47475173301899065, 0.09713071325114656, -0.5483226477004818, 0.007458205896414077, -0.07773432354462613, 0.597575924643551, 0.3004077048545737, -0.29473059889313363},
    {-0.3985757629489058, -0.6287529895235517, 0.2049534759130269, -0.48326419352045624, -0.05661967508842395, 0.5679173893112939, -0.49463454753863395, -0.5061581412917201, -0.5646811004207478, -0.09985650392152187, -0.15436716892227062, 0.2866068659739963, -0.4616197178264597, 0.6218420281887512, -0.16646626448843901, 0.14694764223485235, -0.11987483677617349, 0.05839431444814205, -0.3466980409049603, -0.36809807272936, -0.23608297157317368, -0.4837068555066505, -0.46150914658756537, -0.46814326913883764, 0.6387471135986273, -0.4652877143693517, 0.15556726420961306, -0.6228405021515703, -0.32659118523853586, -0.34189664719620233, 0.4900097280855702, 0.2759476690705905, 0.5094522507754156, 0.5331353892025245, 0.10187199123255622, 0.35812304591496297, -0.2032126952384896, -0.2674339316338294, -0.38331313375035353, -0.16507985593869498, -0.582373746652237, -0.692454483034421, 0.5142008612710192, 0.5140718330856858, -0.5959469344127812, 0.33367479015822316, 0.2625874511507364, -0.236194869090819, -0.4559138705848986, -0.4727984461187214, -0.5938990199350175, -0.3921395705500663, -0.4976418520404319, -0.5866237393516305, -0.6645924753189542, -0.43101046639462004, 0.4396311164040677, 0.2400215941991218, -0.6039475741518954, 0.001971319833617975, -0.2955150962877657, 0.5607727564000847, 0.5649341387212885, -0.44208926566434836},
    {-0.4107682340026424, -0.5890814564572868, 0.1654634072827389, -0.4525381586640898, -0.28688752004071355, 0.298727773342905, -0.36232386101180597, -0.5366146664960706, -0.35627832401041304, -0.09078672887280023, -0.09131927231496904, 0.5163400205910169, -0.22420748230866974, 0.5778622393235183, 0.09559513399662949, 0.12935754553261036, 0.03632721478567752, -0.16735742891433006, -0.4763768095908857, -0.03901638403740336, -0.3865401504018823, -0.39887136735040496, -0.6133195887401993, -0.42593500289679903, 0.3850311852400332, -0.6508271072156449, 0.021600774494807826, -0.619099435408257, -0.5666371253973296, -0.6123191861035678, 0.16560356354192637, 0.3171855554110735, 0.30999233266188464, 0.23075177870322455, 0.33322139508047327, 0.48513518717251836, -0.1893217089453276, -0.4762849922600333, -0.6579694252186034, -0.11754508427521475, -0.5410472512881347, -0.6247269799023325, 0.510872151930279, 0.3529044200868306, -0.6751539440840036, 0.28928183639891647, 0.4928376419233621, -0.5091708750828465, -0.5402581112274537, -0.4948334777972748, -0.36212999436415755, -0.7031890262154507, -0.2988270774219878, -0.5983329857018465, -0.36313340047175663, -0.6812754169159974, 0.46166404085635654, 0.016439458911573602, -0.5731752109753238, 0.14315685284067087, -0.568748652436003, 0.4545427155193098, 0.3598956297145821, -0.3429815779293429},
    {-0.43963817145171874, -0.4559703975318684, 0.2966735328367426, -0.30130485310448896, -0.26595259612281513, 0.5195998841346979, -0.3854387322331794, -0.5279376313358033, -0.4447025075418895, 0.17552398828820925, 0.1772165951024474, 0.536610732797333, -0.44788303963676995, 0.5499628304280268, -0.05144014101217073, -0.045880551379375155, 0.09774282583716797, -0.08998566321610604, -0.3373603275879704, -0.29483059260988614, -0.3513898581653991, -0.5305028813200612, -0.64224450900277, -0.31515488066333114, 0.38501767644655893, -0.4722658140475938, 0.14195477554874322, -0.47924274329392436, -0.6177618183718532, -0.4770701629878021, 0.31061304714985405, 0.41187937897769406, 0.523330879192083, 0.23893558088017952, 0.02018017365409149, 0.4548897662148338, -0.027290922184534803, -0.2850707346387097, -0.5421543743834708, -0.001751730224578897, -0.45038074122485605, -0.6439432852337854, 0.5241158249874314, 0.5594682863808715, -0.5100215392616856, 0.4299349609349319, 0.426263573973556, -0.5431924828260694, -0.3540771573731127, -0.39177745556686805, -0.45017540038874226, -0.4198879595752691, -0.3399306549525402, -0.5062908158961179, -0.41944237232493403, -0.33006724267612575, 0.34803728925698235, 0.16190417877267024, -0.37775577012879746, -0.017465686111670802, -0.46778371689966763, 0.5613967253410022, 0.3098797685803817, -0.5452606167529764},
    {-0.6188614251949359, -0.5547807185184578, 0.3623195807741859, -0.6394033091660782, -0.3819274852347723, 0.3512871525784179, -0.35285530449453817, -0.2756369474677198, -0.6044516132800217, 0.24752829131822113, 0.10718558864547173, 0.4755792329108119, -0.5214711800638124, 0.4241407777179652, -0.22452545312794578, 0.12428067509995876, -0.023866190399082634, 0.05168161939457695, -0.3142978492343148, -0.1898439483349282, -0.42821611520864467, -0.4511754819297743, -0.6048110908433472, -0.3028253991583395, 0.691781258674375, -0.44843953235196454, 0.11158396942932679, -0.6646624657931487, -0.3270820124740781, -0.4687414120961689, 0.28683864323530717, 0.27824177834553543, 0.5505820760598297, 0.5768207985148894, 0.12481133014643657, 0.2501470216132867, -0.19342347812508093, -0.28403873588729167, -0.5436844243572719, -0.018271262638065847, -0.2957436601210599, -0.533036055317525, 0.6206164636450114, 0.47248890005321853, -0.536398194732862, 0.5801182852781784, 0.41698013909574333, -0.369966803980486, -0.6674307598711458, -0.4264397940507486, -0.4164763039499706, -0.38809185068065, -0.585947733654428, -0.5414421601418801, -0.3965858430723797, -0.40789013536005264, 0.4109287994841871, 0.19163704716491523, -0.6161029500919228, 0.06024200093401924, -0.18500888358738962, 0.5138434184034032, 0.2915091034840604, -0.2933978949686017},
    {-0.6351896281096588, -0.6232482287473939, 0.08166217851799615, -0.5044059579883258, -0.36865551820017245, 0.5236679439239008, -0.3210899161373468, -0.49124393406465383, -0.5177944470790112, 0.10135993600794985, 0.007891393990269375, 0.539414178568721, -0.4608090430932224, 0.5246268555095419, -0.1426880787464212, -0.1255611907456136, -0.26619350115351115, -0.1879941025900825, -0.48765650208188116, -0.17272805304880076, -0.343168035759206, -0.5120223199819861, -0.4634261980171963, -0.5764543444830595, 0.7016036657944393, -0.7013658953619494, 0.2149404839585952, -0.48880061446523015, -0.37145536891325276, -0.4456081549445478, 0.5233299542225484, 0.48861664584173986, 0.6690845536112867, 0.47901396694615306, 0.32214190164484036, 0.36814609308260227, -0.10299964062964836, -0.22721066934485992, -0.3787160421041246, -0.23800683489623536, -0.39528031083512666, -0.5912898134993139, 0.39521045313612213, 0.35004966035752577, -0.6234852703363765, 0.6177324245124581, 0.28093687638432796, -0.2600062652053972, -0.699306338163535, -0.5503306071577679, -0.4753981069658914, -0.5990162559476861, -0.37605616108042705, -0.46925671682529785, -0.49980856339953894, -0.6496129330558896, 0.27603660104581274, -0.08322597619097044, -0.6667576946418509, -0.05850327622781852, -0.20914028222130193, 0.3632334341308635, 0.44836859554797376, -0.3682051266911184},
    {-0.5446304427962356, -0.5086913377073824, -0.10462921913667664, -0.45441796841315046, -0.2587380450196565, 0.35474326680205936, -0.4193485965891435, -0.5967203109781962, -0.5841596234751807, 0.1191654034368737, 0.015545873845918167, 0.4887802126859333, -0.43442124903297397, 0.6679129264826477, -0.05310731396358628, -0.012703078904506365, 0.026672857165468238, -0.004057944457754483, -0.36150306894438333, -0.10849460139768179, -0.4659479880990463, -0.6644390824958235, -0.5066184824799741, -0.532353507967569, 0.5279291963304453, -0.7423653441832956, 0.21049157552991743, -0.6289566608674125, -0.5124002970291416, -0.6536125501193004, 0.38402198796317527, 0.36573159093061053, 0.3630591562768155, 0.4608093531291958, 0.3448478478471074, 0.5274860701372432, -0.2167596059369427, -0.20320155694468506, -0.6214110879242303, -0.2959096730734569, -0.4448079525243689, -0.7136303913980551, 0.3308224896120916, 0.43252636643272996, -0.3996083674444663, 0.48705690549630565, 0.1804840801810119, -0.4140270846880712, -0.3336763324649063, -0.4988459330212973, -0.4112302555870027, -0.6616553216966469, -0.4384801426376883, -0.42718111791033153, -0.6225954735155883, -0.41479358753258994, 0.509584147775301, 0.08184218599717889, -0.39242903161149656, 0.12312249667844195, -0.35066877182962386, 0.495008548236496, 0.5637886288081431, -0.2267736381413887},
    {-0.5884743701334718, -0.5016134770259344, -0.0460478200849486, -0.38466096078016604, -0.1654941504905603, 0.46092092237358473, -0.6665405590487599, -0.2808634485528057, -0.42117549388784536, 0.10420311729746161, 0.004792193153874491, 0.26654298715331515, -0.46343635140843026, 0.5168986217321486, -0.1645219324937856, 0.010987630258035118, -0.06707457432061434, -0.14109340970822684, -0.5925669212769847, -0.29262605921090584, -0.5394392123721591, -0.5693083093100619, -0.6675738732791984, -0.5373180894625089, 0.6397214480549401, -0.6574099132192774, -0.0007188923623783757, -0.5036061534490321, -0.4559985629681866, -0.42632626948144925, 0.44617319286888424, 0.412678562812707, 0.3786775653192791, 0.3928944254971223, 0.2773374235219451, 0.1769682014165079, -0.10763450708935092, -0.2112013629695053, -0.638528417295114, -0.2944558662588097, -0.5891020901913528, -0.6162144668618679, 0.6385453296946122, 0.627606825357837, -0.5802044752901223, 0.29662178376089854, 0.3335145407978319, -0.4647268396161176, -0.4209239097539326, -0.48977164663846384, -0.5342129948302548, -0.6657325518839675, -0.5457803450335112, -0.47115567683451787, -0.5142971900028062, -0.6842293420891661, 0.3818819300592454, 0.15665490780631416, -0.402835189287507, 0.12986145079237482, -0.5080571465667393, 0.31336172448449023, 0.3336373011825528, -0.490094738160448},
    {0.22679578295747974, 0.010014513590998463, 0.49630002858185757, 0.10345246219727358, -0.1711897936529491, -0.20777168668317372, 0.4006186481082706, -0.12178295381942125, -0.04498195386955531, -0.29167767635160086, -0.1268002049159179, -0.3491599290728369, 0.29780149775735504, -0.29705813335858744, 0.11600177069770773, 0.1341059679721402, -0.35449388160971834, -0.09180383118179751, 0.3671641204064286, -0.3236550841683234, 0.1467014281786733, 0.3800228819543827, 0.28505661844003566, -0.11981336804309213, -0.6327137962496145, 0.3709867954538274, -0.08658704890277158, 0.3930354454617807, 0.32625340241736295, 0.06715772815025806, -0.09566831817207243, -0.4877941467865299, -0.11073953465022102, -0.4437570224273369, -0.1287901595625201, -0.49012373286176536, 0.2751488683606995, 0.10504257505923029, 0.20764532554714984, 0.09751853127006134, 0.35729801700729846, 0.4367180518811172, -0.38119383851826516, -0.5768352917224365, 0.21814776116292764, -0.4326950665373811, -0.3424203217672332, -0.05410116800281859, 0.3022534692627201, 0.18877803493831855, 0.3039385724735175, -0.14325697510896, 0.3363610284955877, 0.2968065344935542, 0.27586987429884696, 0.2552843871419826, -0.3511569053600249, -0.3708443403423137, 0.21581772010206632, 0.15242341066799617, 0.10023342019726741, -0.4318448996341152, -0.12426124150550696, -0.29304372383912375},
    {-0.33730650267042994, -0.3818220328892429, 0.219092238412615, -0.5093360906861641, -0.23319976545833077, 0.009588910684613828, -0.22088215130277639, -0.3913007294669752, -0.21419622378692782, -0.0910073437147467, -0.4417880610973986, -0.06712131191133001, -0.5845846502261467, -0.11981940198835378, -0.5732114581646558, -0.09624406210868233, 0.015929364406476656, -0.14192159263704038, -0.3473253396731533, -0.48301269941232156, -0.25302452005253373, -0.30379066824285844, -0.35881677809832696, -0.4556279352229797, 0.3271242312585502, -0.5297967850301393, -0.3233243584073621, -0.6037416344132562, -0.43642186202863875, -0.2919203911250372, 0.09336206099158088, 0.04644653354509971, 0.15423577968390798, 0.026002058858485853, -0.24297119119698382, 0.016015397822658515, -0.04841091046345919, -0.28710966158633733, -0.44457116524262946, -0.3275883500361247, -0.41227318699970794, -0.5979709420692476, -0.14255154194650901, 0.2598831368273616, -0.4204407099459453, 0.15948499067476904, 0.1086656323686472, -0.4510768195064876, -0.29512592550063704, -0.4704291429489734, -0.4308884160754619, -0.12532736566583202, -0.2738807304374219, -0.23255571251398263, -0.2392323488963698, -0.11413634535172988, 0.1538306316890732, -0.3848465173897294, -0.2741368744656656, -0.3173855311846587, 0.06810308329742842, 0.3114050408559994, -0.0751247292590494, -0.27471839112076185},
    {-0.3947851524450798, -0.4123903273119437, -0.06800332021231376, -0.28599802253750056, -0.22788089640484172, -0.2750416758268321, -0.21636574792216953, -0.4169778002537574, -0.5106721911844613, -0.19298078654292636, -0.3938561417329554, -0.28475184463195496, -0.3679429648591347, -0.47264744358486227, -0.5575121510185337, -0.2592912798649517, -0.2901038657547472, -0.2015122245337758, -0.41607251215453905, -0.4436346439734404, -0.08140547969585561, -0.20628330179716284, -0.09891724085297793, -0.3123474043102422, -0.4040188290117408, 0.029902954122147333, -0.15570526500140555, -0.2693026858462162, -0.19298191937171963, -0.13241165709937722, -0.1125564506921972, -0.22238870606639094, -0.2371120756125027, -0.3192314846736023, -0.11536746960671433, 0.0008370099356053403, -0.05267813837294912, -0.21381800570808143, -0.14644807186886738, -0.0863961021898826, 0.2384507224313758, -0.038998019004483304, -0.3546660223176899, -0.432016047495008, -0.009822952673962274, 0.07898851383204988, -0.25061707167406694, -0.24499542334001614, -0.15222481678367836, -0.15741963130151762, -0.24686498414498997, -0.3383220688278548, -0.008484499986705977, -0.4623602821334093, -0.34471049388503927, -0.09923444271270417, -0.23764028115903105, -0.4164779312035213, -0.1986196784567782, -0.09295966651267197, -0.306845378895851, -0.3078623373250315, -0.5051459823113351, -0.22987593724794872},
    {-0.3083184858530571, -0.39161258444559494, 0.013535569421091555, -0.1900864205317952, -0.5494565741879338, -0.40237484479192176, -0.1419655108562778, -0.18638935593310293, -0.451330296268435, -0.36935336103201577, -0.5221844434209676, -0.19339019418569567, -0.28333294283189664, -0.5087616310450362, -0.36487572557350834, -0.2344223305040011, -0.008647972276133722, -0.27428066974841797, -0.31475042017284866, -0.5591374076566978, -0.22057113297941244, -0.3041682417400154, -0.2693469265671817, -0.05639286963341238, -0.14076639375935102, -0.016396013978112293, -0.08237561593714272, -0.25661566132740615, -0.4112033127250873, -0.17761710224142316, -0.14112881404017413, -0.11829085916462741, -0.09735463613647961, -0.010204414192445737, -0.11037348913518427, -0.4460400405032466, -0.09406112940018413, -0.1162283565115993, -0.13098056591151722, -0.15858877850282366, -0.031699426391588556, -0.334130205034685, -0.013278894645132606, -0.3593389658381858, -0.4503334634328087, 0.09669110955191167, -0.419331047851202, -0.4260548526548825, -0.26378901825332063, -0.29430042999356537, -0.3551638495603519, -0.513760240567183, -0.14124184425705366, -0.35334745063944556, -0.08174001293265833, -0.49569877004343044, -0.045778868778950946, -0.11309249660788927, -0.3817269591800568, -0.3109690960780421, -0.3437147153900106, 0.14463371100799952, -0.46914118052886955, -0.3119157182005439},
    {-0.22078053678574563, -0.4333750032100903, 0.33726568499412835, -0.36184569946451084, -0.5428854774368591, -0.05777471730585133, -0.26608014695408766, -0.5887292924354236, -0.409577351988153, -0.35863597374261413, -0.3480778518273423, -0.150971910770873, -0.4741950800423132, -0.06770270221239189, -0.04240841015588717, -0.14811263039870268, -0.13635338029231756, -0.23792830539888904, -0.4949697655534255, -0.5452805576702549, -0.3579726876339609, -0.18933894559864428, -0.4087894969889035, -0.1577394155307487, -0.05193184600236805, -0.6222123090537471, -0.1876835115671177, -0.2748436600016368, -0.5203428707652032, -0.4996468503353605, 0.15799372703537323, -0.04495382157552095, -0.08228895333828393, 0.20457391294701097, -0.020721681676655876, 0.06050883788775644, -0.1899275200327871, -0.23104348735941552, -0.16342961332940664, -0.3893082060490373, -0.2089043584136867, -0.28752897909177305, 0.05037056898694913, -0.10652661692196652, -0.21143712331779313, 0.18536156238610543, 0.02679623440554599, -0.4719560182339189, -0.18943244119414857, -0.3220369989074548, -0.5215489635403818, -0.2804535205152989, -0.2484840562756001, -0.39341974877200253, -0.24641406927770573, -0.40815171553958896, -0.08585328659331093, -0.3766217408233631, -0.5657211774032015, -0.4712229429247577, -0.24118454472810252, 0.3362048180193358, -0.12881616947840563, -0.17504047547679222},
    {-0.24249339832081113, -0.28267336902729845, 0.14163217027048006, -0.3385532728842084, -0.4128512894216199, -0.29400483880603073, -0.21104308973688712, -0.292630481132004, -0.5039347165549262, -0.38946156774668, -0.28616542440670517, -0.10808761805490356, -0.664822925206759, -0.1515092788564145, -0.40193013819603995, -0.17452577065908348, -0.3075770098594532, -0.4754126330979918, -0.3283445069701529, -0.49220991420052174, -0.36287806279532286, -0.2941997180940394, -0.1758717934041032, -0.48017183817736026, -0.04072181396821825, -0.5130438510702445, -0.4447536139854018, -0.6039690773411449, -0.531031377634347, -0.5094369409099367, -0.0837813214128831, -0.3305495512147152, 0.04434469148202682, 0.10754154706917744, -0.0753378738374451, -0.1236829404468736, -0.02714574493269951, -0.4246501025664156, -0.2070161769189563, -0.5666535282500863, -0.5289029040091946, -0.06529214525059789, -0.19554875770618893, -0.3352283429878909, -0.3263667989478876, 0.08614177171011485, -0.2942011821931638, -0.521303025436752, -0.45062426298500835, -0.4250783238838682, -0.5421374481418922, -0.48192523713263163, -0.524151270827866, -0.3995471015539083, -0.4835642983543561, -0.2818072664470238, -0.11421200296668854, -0.4845719718436752, -0.45461451926416974, -0.2923162004679402, -0.11368205072467558, -0.05018668579563618, -0.43813394334173583, -0.29638484921224806},
    {-0.4444476360369589, -0.3064390216887076, -0.0023171233090938125, -0.4365754931043252, -0.42092930357817326, -0.43733752708592627, -0.1178202487785021, -0.4954818069620158, -0.2622258818138185, -0.16285437989563661, -0.4412588753272086, -0.32206597300678763, -0.553157862763878, -0.007411401904300338, -0.5710097888949477, -0.39506169359455257, -0.3537703847573944, -0.5727891684241891, -0.577979675466878, -0.37347292029279255, -0.2410825111354931, -0.14266841992853965, -0.12554984794659785, -0.5466535453269655, -0.3841688547106497, -0.26754800035809917, -0.4439436616998179, -0.6305708673811123, -0.5635365668299802, -0.46721463902462995, 0.04992569086737851, -0.22743438221649973, -0.04848523542107911, -0.17852236169561356, -0.27470733636997224, -0.027435454913533337, -0.2656931081521541, -0.4440431781501931, -0.2121425456492997, -0.3219410352254282, -0.5605652327625005, -0.1666410782620498, -0.4293074148482075, -0.2750136175845408, -0.1384862674580034, -0.03920124343264174, -0.11547398932434833, -0.5225334519601651, -0.41370115488893094, -0.42858279406008243, -0.35583087856623247, -0.31573372041862124, -0.4114798674264186, -0.5909281885394536, -0.6272702348775523, -0.5022245414565314, -0.33903863616680663, -0.38826414459462405, -0.36795349370435365, -0.36464181498205595, -0.37090828211928945, -0.04886661170165567, -0.10925164707916264, -0.14005323564794386},
    {-0.5482213480203583, -0.42480201414302216, 0.1507842331394907, -0.42418724778947, -0.5836554186253705, -0.5386713569218695, -0.32734116572520233, -0.3890800759012923, -0.5032409113112786, -0.23975949072937427, -0.5616862504846284, -0.04105742617462055, -0.4072518328308182, -0.12383010107060402, -0.5266403319516794, -0.45114621077560163, -0.051696610842780814, -0.4451282756081392, -0.2923010304805997, -0.5822980078162193, -0.13062240461718352, -0.42874784918413555, -0.0529571504978995, -0.5092353530200724, -0.2976072996672936, -0.36864318377863037, -0.36355831995277166, -0.34992571071029577, -0.4776695891580395, -0.23692753991680063, -0.25800906793530365, -0.4311100290238385, -0.022497612680918655, -0.009542616343089257, -0.15193615662116894, 0.020225619091030614, -0.08982808468221024, -0.5237844621421197, -0.2365125452370688, -0.5946431256251374, -0.22150806041620333, -0.10142767798690247, -0.4017334786242202, -0.028243199285969946, -0.26817727692739307, 0.03679430860642688, -0.32091407214617773, -0.4570948093301813, -0.5027381240585652, -0.3001690257989014, -0.44348738686306477, -0.582774099809087, -0.45339924976177953, -0.5357737545218232, -0.4477013172356512, -0.5572623102726922, -0.005603256043783471, -0.10377103842790479, -0.4253329345701566, -0.4536613331572377, -0.5518359894963385, -0.12109055986188562, -0.18340204814686206, -0.22579633797491813},
    {-0.27224982183403473, -0.618595622043648, 0.14682631662006082, -0.2714723743096105, -0.3355689240127253, -0.46195372690143405, -0.12607986518471978, -0.48421854790797764, -0.5279190051733208, 0.0420719392797031, -0.5680464379250545, -0.07604286083218505, -0.5810059710883142, -0.1753767798677625, -0.4761341536952262, -0.585237842649677, -0.23136888641750897, -0.22046128165683812, -0.40131907058101285, -0.526243839299081, -0.04092217510651443, -0.4402336078651454, -0.2881248622128474, -0.4265171828937207, -0.08312157868024317, -0.5371178607447552, -0.2812397250657275, -0.6444022663867345, -0.33590910474154745, -0.15075482222300182, -0.005964155615683371, -0.22596686950245623, -0.025534281207156277, 0.22521050294133393, -0.4178751005138872, -0.14035149606392788, 0.11385256746327474, -0.3358793396412757, -0.2195738835180223, -0.4462305427970704, -0.5226401758594494, -0.08834421289463307, -0.3390483616494289, -0.014018962179605446, -0.30052763555057593, 0.3076806719923862, -0.1730749102935065, -0.344933530413106, -0.3555878385529716, -0.5393381598333034, -0.15665576937974862, -0.3785919980921034, -0.4304928599646103, -0.6140201604527016, -0.31592220468578114, -0.29340243458143156, -0.17505818619622918, -0.12725305795624314, -0.32935471340602757, -0.48293812153831694, -0.38569119580258365, 0.16717026279408795, -0.3419636421285462, -0.41139777903789304},
    {-0.29496900457616915, -0.2834089198149266, 0.18019029045276058, -0.5742803056258345, -0.25915040106187165, 0.050743635285082356, -0.15706259826236615, -0.5485030518253106, -0.6061398685839924, -0.1287999108823105, -0.4914250375832757, -0.12836108420693315, -0.5284668309055508, -0.3279379008918983, -0.29708617774303375, -0.5703118439329872, -0.16561159035417053, -0.5037459428692094, -0.6226671700318891, -0.29520242738881364, -0.04025193210694919, -0.4844503413173612, -0.18210797723024738, -0.5787058608775242, -0.30494953139531067, -0.5146906703195134, -0.23678669433492303, -0.4589580072380582, -0.3436254413966599, -0.39148417798359314, 0.012134825313249794, -0.09217904781142584, -0.15165859202956763, -0.08338003517795732, -0.2818550626318822, -0.30633039737724166, -0.143148062225822, -0.2104669780365326, -0.32260283800843426, -0.48664603792103345, -0.48935413401787176, -0.02862293315856324, -0.004919508490630435, -0.22746593186868777, -0.5430566459574161, 0.23357701714860926, -0.4559474472906044, -0.4815517881219533, -0.43709203505573935, -0.40488799485431803, -0.45101932529415123, -0.3964220700607826, -0.5360505684278112, -0.3693436289348902, -0.20791345205233233, -0.4920119581332426, -0.14335959311862836, -0.2884668844240731, -0.25245874227933207, -0.2836754451916815, -0.07929541705393948, -0.18898828346037644, -0.25962937654751056, -0.27938047411575534},
    {-0.3647517950968258, -0.5422528804131134, 0.12494386166640842, -0.48119223772275976, -0.48905795739026986, -0.41109071064945923, -0.11649272303848306, -0.45030376390835936, -0.3685577707174558, -0.5185710489252222, -0.516025732905558, -0.2799663680074265, -0.4814305102660073, -0.36275134236427237, -0.36520581669007923, -0.2306639834326011, -0.39488315926901074, -0.4801583859866124, -0.4570180807979475, -0.4861614681157395, -0.40493721119269416, -0.2958862659463062, -0.06399055181365058, -0.21395943854564334, -0.14895560338251354, -0.2063178409235531, -0.35348639853520003, -0.5466386197535514, -0.4649258968429446, -0.42097745258120983, 0.025970138359547094, -0.2498205328763896, -0.18344300009201575, -0.23185794612413757, -0.09820633311618271, -0.39158836049677015, -0.16729309309285692, -0.4019965762878237, -0.13533532804097181, -0.4105014583188708, -0.38577230032101617, -0.02966506972490464, -0.05444456397858556, -0.38055067671206083, -0.4239429947147812, 0.16192395755162078, -0.424803882748306, -0.44060648979701034, -0.1490160615728588, -0.46353095565321584, -0.4699122597511769, -0.18343501646223226, -0.14962468110365226, -0.33143605184044667, -0.19081650091962601, -0.3106630231344497, -0.028719003617432595, -0.17059447231683272, -0.5372882540158131, -0.40380078216123, -0.1443679560521828, -0.03237943735983096, -0.03091376023891767, -0.4141267001231513},
    {-0.3374583523913428, -0.44003309091892484, 0.0899035542354913, -0.3774692118847201, -0.43706712903589606, -0.16220096197887002, -0.5011390922929151, -0.29009932042959286, -0.5905693509226564, -0.28915550077016133, -0.641547956861319, -0.2358519659854831, -0.27101076462318374, -0.4534538964590053, -0.574118154054803, -0.29133645586305057, -0.14986695766722882, -0.6294168368481193, -0.6416944686447216, -0.31607345771876305, -0.3574737487181873, -0.4752624319523878, -0.31565021956145334, -0.536438140507168, -0.23968962051407808, -0.5765404786678902, -0.2896821877641475, -0.4717637302410992, -0.34023160331491187, -0.40626828092936734, -0.006455272892771148, -0.5601601785608428, -0.13748480031988666, 0.05500330405476932, -0.4040922122309602, -0.322213495939836, -0.02202339386749736, -0.297310297951879, -0.30966316654695103, -0.3022171851937479, -0.3283474177326242, -0.0033665924914335348, -0.041942857945502475, -0.12943863037930933, -0.22181679689654535, -0.017005361532371425, -0.42608799204703723, -0.5435369908406629, -0.44855438456293023, -0.21740354852242716, -0.4792501128066088, -0.561440372203284, -0.5027170990564293, -0.4983819162574436, -0.3987618879900809, -0.4742795712450946, -0.2719055926335246, -0.42485375505693446, -0.36432535274216393, -0.24311133981135963, -0.334964001569628, 0.16919588355337697, -0.103372030377578, -0.23810495667375212},
    {-0.5723851031712218, -0.3360740531530331, -0.04727720773716273, -0.509939595553445, -0.4001994921246585, -0.3939516339418106, -0.26987360527394755, -0.45705976323492203, -0.33533796211764694, -0.18461911537247244, -0.2732076549943268, -0.309041036773491, -0.5062853319643703, -0.27185506385275515, -0.5657863531061582, -0.4950421181788719, -0.3465172054867698, -0.5725514696480434, -0.3877992663388084, -0.5543304341301706, -0.11965088719095573, -0.6063435480431126, -0.14980831710518372, -0.35080388596627404, -0.2497474502166001, -0.5178599353596913, -0.3777130618587001, -0.6408328614870529, -0.31361247192887093, -0.4614046564711924, -0.04055157677402228, -0.42464335896945643, -0.15560747694311966, -0.002588854510168904, -0.12837349773075302, -0.25420530023956717, -0.26323937439000095, -0.2628826985280601, -0.23095028828510053, -0.59000109600769, -0.31805731803848303, -0.22721588817661445, 0.09112185624633756, -0.365312384672214, -0.3345694585562895, 0.21056238475580125, -0.5468904824147057, -0.4597100857002482, -0.5719445813588239, -0.2829655085927927, -0.6092996579981432, -0.609669157699908, -0.6408607756286466, -0.25719535378949004, -0.6093014638585136, -0.5971859072617092, -0.14141056600033627, -0.38706424941043593, -0.444769515553357, -0.4157869654385527, -0.2259921852822495, -0.09472724080644339, 0.008922522816190775, -0.5266420052230859},
    {-0.4538754706760649, -0.4617307019641653, 0.06749308356556911, -0.33411304557746974, -0.30252391903873366, -0.2168416198779003, -0.4094814202011939, -0.5674857022994951, -0.6418355627733073, -0.3343507399547045, -0.5220937440877761, -0.3710362982245177, -0.6191188712049388, -0.397873773720932, -0.5148335714546582, -0.5828292987467683, -0.5006105399290328, -0.6080219367404605, -0.36889201782920644, -0.60537133169673, -0.10354866662045599, -0.40289902414722034, -0.42181953868063976, -0.32565216652472373, -0.42818207406246267, -0.491632575781278, -0.31729142878738115, -0.46684422543331616, -0.3933844866616602, -0.4157585153977817, 0.07029288633885941, -0.24494854603641944, -0.42848876582162904, -0.2806511573398886, -0.5590535782027415, -0.10374073089251706, -0.1169522017842341, -0.471141181689177, -0.548276604089502, -0.4942203565064359, -0.20485128485802404, -0.018194623700608394, -0.1636634320811606, -0.3526742673007783, -0.34111147879471365, -0.038004555960533946, -0.28642509238447195, -0.2511143432061732, -0.5218786106896499, -0.3287855304157446, -0.5725196364401494, -0.43133472371993664, -0.6086692098782132, -0.48801310497666095, -0.41565437459967786, -0.2786922306238211, -0.1598670670308036, -0.3277310422153214, -0.520889531367117, -0.18052942844713724, -0.3584434038018184, 0.051300400368308775, -0.4433091659953958, -0.2938255397925186},
    {-0.2763649959104932, -0.3005500301673788, 0.3100040905571793, -0.22973499964448363, -0.4775744491188339, -0.028372289957745576, -0.3290513701840935, -0.5215325332860725, -0.36226391107458955, -0.49516695971921854, -0.27790000479687593, -0.48642953792543353, -0.44617946731148245, -0.40096583758127363, -0.44122031174785514, -0.6209995307931203, -0.4707143148899906, -0.6374173009802795, -0.3673779000092192, -0.5632392906548104, 0.04548250474559692, -0.4095085757285152, -0.05928639407647663, -0.5362551400867129, -0.32577311014567656, -0.5167136495985881, -0.504195317378604, -0.5889063299553546, -0.44141347907025585, -0.2068600859377067, 0.1275281598127587, -0.39229254019467585, -0.45581375216117087, -0.10193072714395328, -0.3095455131501042, -0.3453897315415691, -0.03501914785421469, -0.3919073015159658, -0.24162875651854435, -0.4887133833179068, -0.369661367994746, -0.03743491738743962, -0.1925630872241468, -0.16998927865000799, -0.5463726707708911, 0.20814886324693566, -0.24141108826779992, -0.4726440047616138, -0.5485466898633241, -0.4513983450196428, -0.4189752614834979, -0.5471557840476099, -0.3459260251100404, -0.36706040323803946, -0.6014648733257089, -0.570818280278061, -0.32029395027136376, -0.3198544383361588, -0.4213284037490941, -0.4352915036510271, -0.2715545360318396, -0.18797433957714663, -0.2431294084961727, -0.636261686794297},
    {-0.3322794155583275, -0.3898882439769645, 0.16658030165389567, -0.5865235118921481, -0.56970790520384, -0.2508367466618045, -0.42739234106072244, -0.6091452557970192, -0.3261743068499507, -0.35191576342225767, -0.6061058962537677, -0.3263238776015829, -0.2855079576505149, -0.2986465094138149, -0.6503811037916487, -0.6063529825546713, -0.21435109468105404, -0.4092439087047457, -0.33218239751155265, -0.5831007723240039, 0.029201276385032695, -0.5344425476307542, -0.08237583977289799, -0.652969005897014, -0.32763182918569983, -0.2266985050200548, -0.4119630648125209, -0.49287321977928195, -0.3902863920243777, -0.18671134608122653, -0.04597500347081723, -0.2652062310102177, -0.440426084060172, -0.14070105693906437, -0.37058691815160694, -0.28527206725947124, 0.13932618388951593, -0.530214196656741, -0.18117351083146674, -0.5650659763835881, -0.2178574187292514, -0.25095455046469767, -0.16261851433768915, -0.24760858979315872, -0.546252178133055, 0.12253166659242982, -0.6093919620843451, -0.5172356377487702, -0.28388010238507794, -0.514330447721371, -0.3491011974562776, -0.2766786494407985, -0.5491767128495887, -0.5946101956784775, -0.5703722858118162, -0.4664110561593408, -0.34950433435656797, -0.2663367767268688, -0.1613816804694456, -0.27587342712568863, -0.37812767297085337, -0.10020424646104398, -0.3599150360324149, -0.6189035503713517},
    {-0.28543020819011017, -0.5105852333855795, 0.23386307571378392, -0.5052636514170089, -0.6324846232463825, -0.1360815296700106, -0.23094569075902557, -0.5915848245932186, -0.3559041860475352, -0.44934634676896923, -0.537257269320109, -0.4317633066581678, -0.4397497035735788, -0.46772338260049146, -0.36711829696811416, -0.4558590154932993, -0.5072889182366398, -0.4097160962702138, -0.3109722510105881, -0.4207065586985877, 0.012326309139242502, -0.5019805585527874, -0.09136106785333775, -0.2569320800672565, -0.1397214338015662, -0.21620572167251126, -0.3586001761995242, -0.3602850932068097, -0.5812748465460749, -0.3182204704890195, -0.23499331080365174, -0.1758921622846731, -0.3272673726525162, -0.3085579798625242, -0.3537695266405923, -0.13811228971019351, 0.1081556004770679, -0.21222663898043784, -0.18633821150840468, -0.32816831834659704, -0.19137452649814793, -0.2144835125722609, -0.19681172036996344, -0.28775312797496216, -0.46951158408508187, -0.0034714753293600903, -0.6090954701576574, -0.42292213170102433, -0.30805465719946784, -0.4039925742553527, -0.48014613749228635, -0.5341218578984004, -0.22368065171340482, -0.2878509572770418, -0.3198206638281394, -0.32613757428434, -0.0316927677121989, -0.5782805823617211, -0.13604279635912708, -0.264804034536213, -0.35284186759586217, -0.06119879562527631, -0.5264636545896003, -0.36051830444831506},
    {-0.45015351928598946, -0.330805360030784, -0.012684478601756586, -0.570027257252459, -0.3778047820699873, -0.1040655573556548, -0.2068322872124647, -0.4660963554127144, -0.28225184927072716, -0.21938905052575203, -0.6048814364691479, -0.4387532221334062, -0.5165547527626299, -0.2440543506191438, -0.4685289757925841, -0.33659252327540856, -0.25876533250023337, -0.5869538340999363, -0.20680714481815035, -0.5141056488936886, 0.08112718656991472, -0.32368586665655996, -0.3467118288278994, -0.4684083889165488, -0.3838381377518001, -0.35963305561283015, -0.18728065181623546, -0.5447869572672405, -0.5021725313646068, -0.10279721179894484, -0.11751426221218005, -0.31527252824167856, -0.13026962124182534, -0.24741601742922248, -0.23585674138949905, -0.046475095575838184, -0.16797228107105464, -0.4045497971660377, -0.2997579277085609, -0.4104305796982719, 0.09988499330091884, -0.16811569194520354, 0.15253946593536077, -0.2249851317260539, -0.5428156127957361, 0.14043571164726737, -0.5714223684417448, -0.44590339494339426, -0.29678369991744424, -0.446431410003045, -0.4353268170422491, -0.4704610302085248, -0.47602573645766183, -0.515848126459473, -0.2510373885009769, -0.5193943746907835, -0.12922699019261727, -0.44710252603735595, -0.2690155913830554, -0.3094443707342153, -0.42048479664628624, 0.06102159222014775, -0.23472489448931597, -0.3350922160415976},
    {-0.3325088921663423, -0.4989935610714999, -0.1520291329516385, -0.3073263687603762, -0.3003857860710638, -0.44199907360154683, -0.1936108239065934, -0.3854994613550014, -0.25979420724862473, -0.508679399417519, -0.3540960515113396, -0.4438393237334825, -0.42533529322466623, -0.5082293528169983, -0.45078954365711527, -0.6034164525281789, -0.3555326568108215, -0.35508721342594973, -0.4898631826771481, -0.3770028261432388, -0.25642190724134445, -0.11761675060061275, -0.099672900458606, -0.5069913209821133, -0.4268894385875231, -0.38038898808195076, -0.3955467838988607, -0.5266802322268545, -0.4182739619152966, -0.4127640072905136, -0.3000274737496921, -0.4195703944099492, -0.21773648829086528, -0.3364654338939077, -0.30301790739926693, -0.4115712671685148, -0.07373807488175706, -0.19749504453213584, -0.27029564149201707, -0.6243547517088257, -0.21453960579429723, -0.299576341810081, 0.024499710714495818, -0.44045723386859925, -0.5268879480227514, 0.03785087043128972, -0.5186219890259837, -0.46686147431292685, -0.20371591421003277, -0.3767399542179065, -0.39859805493030104, -0.37126382898376675, -0.33140790703243783, -0.45550476856610883, -0.42267519425717026, -0.5819190285768826, -0.41632742501011316, -0.42184724748193014, -0.28318757534916417, -0.47979679125638436, -0.4336693531928581, -0.32144398704588567, -0.5578083283588955, -0.5070940631589997},
    {-0.31715409843799575, -0.4963724626680434, 0.02961737936545621, -0.5138291318491186, -0.6839557498633019, -0.36204130055680783, -0.42593775571308384, -0.6075392529937389, -0.3700406415035549, -0.3981728908323798, -0.5199563271055713, -0.2966957647649787, -0.48813616784676983, -0.555620216591791, -0.6016093741053014, -0.5280339634785014, -0.2977731853359575, -0.5006026085700436, -0.5350014523835529, -0.5290483229552666, -0.25115289251846884, -0.542554813830355, -0.17455687725841781, -0.49409341205553636, -0.3960366855463161, -0.2791066686465893, -0.4202030313362552, -0.4798683485636658, -0.6397232805788455, -0.10416850607873132, -0.07243098158612804, -0.5122963626484426, -0.3489889053210326, -0.13968269105244457, -0.6315302241581293, -0.2625691551382407, -0.014564474036100308, -0.3388984489826299, -0.32605494401146257, -0.46976444888944274, -0.2795399663514156, -0.21242451569279064, -0.2489918030443803, -0.42348203956770214, -0.4513681894309172, -0.1105936380176731, -0.5177017123504797, -0.3983756423227213, -0.5333617562638132, -0.3595496269737057, -0.32837711078416076, -0.6027389292931896, -0.5648150103574673, -0.4820060522553229, -0.3253761363781364, -0.5789635010850206, -0.5123404358996565, -0.6162957129532751, -0.20133263553134986, -0.33558116801273263, -0.3521103021568543, -0.37861143475841075, -0.3204432634268038, -0.5943406787027127},
    {-0.2447145518647297, -0.6450681387871786, 0.13865849062045188, -0.5663434374080224, -0.27675992790094667, -0.35262692709107557, -0.39451613771266564, -0.3390862980009758, -0.5585731713243002, -0.32114335418873374, -0.34633745412612627, -0.1212768502330756, -0.47251028181935023, -0.08629262938386374, -0.4607422286570618, -0.4624300594467013, -0.4940336443559443, -0.37251729833592856, -0.6523479689756769, -0.546666206128212, -0.20710454220774946, -0.5707589721698947, -0.25154861557442254, -0.5712558105952442, -0.1003249128059281, -0.5654527542738091, -0.2632643038778697, -0.421971298914014, -0.5168294067782125, -0.36232577229262886, 0.12455383442732731, -0.19596168929263114, -0.33161676188030964, -0.10774820138022623, -0.3109909499934965, -0.20398957739565188, -0.08416221911978689, -0.5805577256242394, -0.48587445176551897, -0.43920900427407755, -0.5094633229852092, -0.35950206776782373, 0.0044032926889265986, -0.066521545209121, -0.4640101366724427, 0.2581930330530359, -0.5586974098629008, -0.5837140679958617, -0.44743656636849416, -0.48829104720080463, -0.33659492942190006, -0.5774282113025291, -0.5120300367769968, -0.33864494390169153, -0.5595331231494273, -0.28888871310974434, -0.21521838422907294, -0.4406546703618925, -0.4453511752863978, -0.36068369633904945, -0.2701073451410017, -0.02501720824283937, -0.326463385002823, -0.3893584411297206},
    {-0.2574427658846933, -0.43556359358865865, 0.4724189461996636, -0.4304525290156774, -0.6112468259482333, 0.2999833753965048, -0.34094687428076254, -0.6430841531387845, -0.47997418644268014, -0.46434253396958686, -0.6642241859758247, -0.28747841239267263, -0.3071606587023483, 0.00930854724320716, -0.27592494840846926, -0.37400256720990444, -0.3586789303667706, -0.546545564929686, -0.550403706152522, -0.4290164984536887, 0.1513346661413682, -0.23690580273951756, -0.4083568143121532, -0.6826794382218718, 0.012644141550942364, -0.28922997326408983, -0.20485637378143803, -0.5899051506605184, -0.6002434991231327, -0.3641671037626062, 0.17795470748336895, -0.22848323228836576, -0.10607122112191775, 0.3304562621221724, -0.41465733637307045, 0.026695791683341363, 0.1039480903983198, -0.3832514861850114, -0.5399440151644027, -0.26201676931336587, -0.2241276201603427, 0.006455154961735305, 0.41758443229659964, -0.09226249856851793, -0.5462661109812946, 0.32447043616245763, -0.19883197849536824, -0.44771514281548, -0.5531567108585849, -0.2832071297366645, -0.5206244429622464, -0.5705562896758424, -0.6107517896428206, -0.5251873787239565, -0.32508449872252, -0.3121198596023737, 0.07518331460820446, -0.43467499502901774, -0.2583017617464771, -0.3237321711024906, -0.1753807087141878, -0.13046640450160427, -0.040335295058738646, -0.2561087504334002},
    {-0.06655515446722195, -0.5374662891277645, 0.4583509039225318, -0.30164394315291065, -0.6631617572131575, 0.23995991942019426, -0.20289259647067728, -0.4361320812145971, -0.1850911132367964, -0.3360586114445019, -0.4295872501781415, -0.04555418323535298, -0.6005627142749913, -0.25095837046564373, -0.42817261461061035, -0.4102558415797475, -0.5034765948073358, -0.6293628690925296, -0.07690715767741868, -0.394369714386973, 0.3288272731018695, 0.13698678291563307, 0.143654105801304, -0.38579561749586627, -0.3399705368586929, 0.09579344673023857, -0.49171152971338633, -0.4496291815269338, -0.4348084444550148, 0.024576205688778052, 0.25635493673157683, -0.43360288217571813, -0.29914077466652417, -0.028718553011922672, -0.48670397120116315, 0.2531711184668308, 0.4533814409836632, -0.31107691105047147, -0.030638121699930798, -0.3461743144113639, 0.1348539604255657, 0.11436977473002817, 0.1888640849436944, -0.3519392720598655, -0.024258647011518576, 0.36171956470557726, -0.3854672645301613, -0.149027978264621, -0.11550472369897763, -0.3803639771704225, -0.4367226177797338, -0.0904041709097104, -0.49803005463487654, -0.1672975158240711, -0.12105701518814013, -0.375117771373265, -0.031048637056777458, -0.18166276685434524, 0.1633527601706488, -0.407870040339986, 0.03197324386887799, -0.3148568944251759, -0.5002490077526147, -0.43628712544903714},
    {-0.3421200227151055, -0.6162729690099049, 0.43057329280138723, -0.3385950656032878, -0.4592961179243483, -0.20788940634307818, -0.11232665838406819, -0.4896628636452277, -0.4619104135317127, -0.476190689368477, -0.4550500486705, -0.3656086317522449, -0.5982045454211626, -0.34540286872639603, -0.29335456294169177, -0.37773058549213573, -0.36453806469933314, -0.5112709085923618, -0.2099984521004085, -0.4854110912015627, 0.3062998633296659, -0.12021768522958513, 0.01974398821989589, -0.4658844714990106, -0.34925774557545275, 0.035435249281676254, -0.5416858098953269, -0.33636863646102444, -0.22890560981484154, -0.28105024071950674, -0.13144061578866154, -0.3778273799868388, -0.3862598979069379, -0.12934035964145513, -0.27749223902477804, -0.057856369816033024, 0.3428627406527218, -0.3262189215658487, -0.21467585011751986, -0.2666283892569537, 0.09309166578782284, 0.2004407971864935, 0.024711878975889983, -0.5509576917225811, -0.4220008587878453, 0.23053199486336387, -0.39755250053706476, -0.2108284623660473, -0.5230689685021009, -0.278667180033979, -0.20856465291198986, -0.43600544494450966, -0.46547100049654344, -0.36996800679970826, -0.29172574356975023, -0.4227655391593987, -0.4629706490169132, -0.49491598775220297, -0.2155744993109048, -0.19601870659067147, -0.19475561924003104, -0.23712628062117436, -0.5370843450023739, -0.3898368138070777},
    {-0.4056779285514154, -0.5450908277947809, -0.09111001112323384, -0.5545256052490166, -0.37180776326579434, -0.33230443102427565, -0.31870582962406957, -0.613000280342996, -0.3269734908405865, -0.32063450275247046, -0.6022216298412759, -0.23920605388967608, -0.5236001281706133, -0.32782843528549616, -0.5151476896636019, -0.6219163221146057, -0.5113325770830989, -0.5231153795087292, -0.5980768379053204, -0.6085353475049446, -0.011779754052334328, -0.2686891575379812, -0.3161275770903596, -0.6375914984732802, -0.5086179797947243, -0.4455322511227152, -0.38007916092552607, -0.6184636814627852, -0.5940576269956974, -0.30475891210628087, -0.3411208280975919, -0.5978230505251758, -0.43540871438291634, -0.19742577127333277, -0.516684477922818, -0.07574793285203409, -0.00598162613129191, -0.59691919600819, -0.4442920123867784, -0.6147220398810007, -0.44938522269017933, -0.35061573159978665, -0.07653115051644276, -0.23337560504683158, -0.5220990804777612, -0.14282963036403315, -0.369155555495654, -0.5532703777722354, -0.3239224964026039, -0.3518004135283547, -0.5476926979661397, -0.49752277509038606, -0.614044419716139, -0.3152326614697288, -0.4264135849029379, -0.4696056700392423, -0.1841530073139827, -0.3713363577339083, -0.3718538565969843, -0.40150549723982976, -0.40024960306166474, -0.1383814976190945, -0.5985549478958441, -0.4684685084246185},
    {-0.07899112553176574, -0.47194114146078514, 0.4434854261484344, -0.22303977082448673, -0.40497916842571835, -0.015953924741855637, -0.028785012436391352, -0.603078104256335, -0.34289752850780286, -0.5639056670460222, -0.4408365670597263, -0.24412423501151567, -0.34762289996019863, -0.3812898292714847, -0.30565319581559663, -0.5800149722357232, -0.483248500196587, -0.44861387070176995, -0.329984449983136, -0.30438019123829446, -0.060490316736157304, -0.16970492098067316, 0.11108415502128592, -0.4226161968603539, -0.38127709263049936, -0.1777560574930991, -0.5148638973728173, -0.5271720290145583, -0.49337458478531926, 0.008435427488836992, 0.06402610268081181, -0.44397635893520027, -0.3562395856583131, -0.3751491190859172, -0.5436681852604257, -0.35939843993552145, 0.30584758694059205, -0.5220594016750638, -0.356609718341459, -0.3368844578281274, -0.036375318045098644, 0.05086967893167939, -0.05763580377826101, -0.5011992774114195, -0.15662906262010418, 0.1840254674471609, -0.620110754125988, -0.5109511774340094, -0.16285095767963115, -0.4753713221012719, -0.41479516912660364, -0.3927629210362917, -0.37039109868982983, -0.5026441749149446, -0.10729268833076902, -0.3359465769647471, -0.33140795711706805, -0.3234798109427338, -0.18868652425287508, -0.3538736183750379, 0.10387921316727443, -0.33677671665281805, -0.36230033007011503, -0.3254677809250581},
    {-0.11054133749900438, -0.26630656479367604, 0.3327891305101866, -0.3410258542775084, -0.5603728269516038, 0.049750908923511715, -0.17987832785519928, -0.5775880225789118, -0.44787069928839063, -0.25570639822201796, -0.6020303603269953, -0.19677615190499329, -0.5201003474737297, -0.21733746491415337, -0.6185281735303123, -0.5860848411612084, -0.45647388681551565, -0.4585009494883117, -0.4220634982536006, -0.47721673747674387, 0.07181064461517722, -0.3182285237058934, -0.09039087793264616, -0.6644612293943442, -0.6006235567983755, -0.2620260581890653, -0.3734139884619205, -0.47979910836343526, -0.3322155568749236, -0.3308555120409222, -0.012760901042539585, -0.6501042370225733, -0.4090720897102279, -0.23217675368083152, -0.5930080016535825, -0.14586377691507965, 0.06154245383505962, -0.23937577401717625, -0.11758221954773258, -0.48786962881393475, 0.17015878756277988, 0.22320870141021376, 0.18102234987735738, -0.5402430695363424, -0.1398916344298793, -0.02779176604513924, -0.575306899299282, -0.39049681979749196, -0.17908943592751256, -0.557053222392092, -0.2936224717476418, -0.259130693650523, -0.27753046939817244, -0.5170037880693106, -0.0771764035400074, -0.3520751953135829, -0.31683652271127083, -0.5650162812639035, 0.024113527415925037, -0.2410352460102716, -0.06421099164145666, -0.22677069171808248, -0.2956883164081464, -0.6357052062747447},
    {-0.24739876102633218, -0.4109355742095714, 0.3997228346923296, -0.6499826651350641, -0.5509077248748432, -0.19263921603288547, -0.5071950972071049, -0.46446174157441583, -0.46177468442087116, -0.24539507854984988, -0.5631942969572554, -0.519655288605626, -0.5284540246143893, -0.48575678457980537, -0.5775655289448508, -0.3298983940480058, -0.2237529506464253, -0.39338174406963644, -0.4526940801734464, -0.6112910476679374, -0.22013285534011373, -0.22303901327207837, -0.26213346030452095, -0.6923761327521036, -0.5045832287116602, -0.2637763628712284, -0.5074195355557978, -0.46816721488963353, -0.49799857755532395, -0.3112510213868135, -0.11337106460303148, -0.46044425469491146, -0.4961656528439353, -0.3225246999154421, -0.6202199652912218, 0.022434778624419803, 0.06158801085131908, -0.42981727749562393, -0.47403074259313366, -0.3493489691210542, -0.03226401172577899, -0.04581040067582679, 0.048578445541887665, -0.47616651055017234, -0.21807543146733988, 0.19877714081139547, -0.5734898744769336, -0.30702841371100403, -0.582678520257745, -0.3826258729417642, -0.3351288491814507, -0.5695604867416163, -0.2965470628515772, -0.36386016378424, -0.47301576517660854, -0.28426894685041, -0.2093401850722802, -0.6742544120992661, -0.08993981307480609, -0.38611552532224797, -0.03710173908810302, -0.03540809830107389, -0.37207817253958564, -0.5259524149635758},
    {-0.1428357281084965, -0.552386993859088, 0.1870870360718499, -0.6112890879297751, -0.5184650919117816, -0.3149451831839301, -0.2252232420610586, -0.6265217717633704, -0.305357837224167, -0.29984944115695367, -0.5171039087184447, -0.5130745380120731, -0.35075265692458446, -0.3441173109992051, -0.6596890461256418, -0.5830026726931421, -0.4722126601841154, -0.47884738747883177, -0.34403709725269777, -0.42979939441325415, 0.2264397712031372, -0.04663415766718016, -0.060458536179021846, -0.6973574326074434, -0.37403615512656424, 0.0005005075726081461, -0.49752617262657967, -0.4265357709998392, -0.5194872930087687, -0.1881272768898859, 0.06580428779510791, -0.598777367006775, -0.5963716056912735, -0.24879258269161506, -0.4290353102160421, -0.23846876854229215, 0.1640846746950343, -0.25996314302399026, -0.4159842915014006, -0.3822180231968097, 0.2821989612544009, 0.03895777544608795, 0.10300565458804564, -0.4250788424892868, -0.4474640659624815, 0.16680711179954083, -0.6266684887369625, -0.4531209084384912, -0.5719368686916122, -0.5736725927236397, -0.35346569626789337, -0.34026232500906606, -0.47669474316970634, -0.5526939670288195, -0.11052358890986098, -0.3232948211374168, -0.28538777203556515, -0.6333394534690169, -0.2568712854388729, -0.39326730415037947, 0.16299074204524594, -0.36336811090509363, -0.5027592876500587, -0.37332472363720537},
    {-0.2797163814220863, -0.39835559547294636, 0.38411094012540586, -0.2289224110428288, -0.45204861711123556, 0.18155435144003582, -0.09502881001695772, -0.5295729934371646, -0.5277619103070195, -0.2814775722544455, -0.6217449528462321, -0.4793573632104657, -0.5475536708379691, -0.41113760192807913, -0.5345192364067454, -0.4485293498663514, -0.4079476008435141, -0.44733555240493267, -0.3144496923492777, -0.6346014048104927, 0.16936232685140354, -0.08438175676412549, -0.1287480542391773, -0.5559307758780365, -0.5073978720212234, -0.0004462894772860671, -0.5649293268128118, -0.23941463371568303, -0.23980409144952927, -0.2875510482341447, 0.1123787212995264, -0.5658196118958505, -0.3846215088780986, -0.2622399692373314, -0.6219475672088017, -0.09145400582605714, 0.302079663193958, -0.3110687497821471, -0.17333838712044805, -0.4409658676701671, 0.344930155121131, 0.1487928656277956, 0.10009362264677253, -0.5419730953692689, -0.2776898241294461, 0.17494319342770134, -0.625924004333972, -0.4233318095954674, -0.49118967435755867, -0.2434126827930586, -0.38458567299267343, -0.354684489160975, -0.47193932565831914, -0.23698529094020207, -0.08664595712929168, -0.38887653465983907, -0.37453694255188746, -0.5963847273112091, -0.1176245464530999, -0.1714920040933325, 0.16363613147032036, -0.14092290849388828, -0.6199863710187699, -0.4911806342226174},
    {0.309802343336148, -0.23179533775409797, 0.14656003063532205, -0.16961363481379776, -0.16909908637529744, -0.2327922881571637, -0.013546249840668833, 0.4011767792256552, 0.07837895786113554, 0.5205251685044774, 0.10511687237836238, 0.45785492309540204, 0.3535671710989533, -0.09023958237479524, -0.4230221850801033, 0.4638314674237774, 0.46445742552331226, 0.1688807387697581, 0.025077654085092747, 0.025807058138861725, -0.25700208081618264, 0.24035208954310758, -0.058923101443138996, 0.13853574905770075, -0.17958349913383617, 0.15365478615851524, 0.1673194300941886, -0.15765451540432174, -0.14703187531071713, 0.04476740945578805, -0.390038255476854, -0.33332677050800275, -0.10454312640804547, 0.1952732823512039, 0.22452813132844432, 0.17129474695357108, 0.1960700091420023, 0.3912262155753096, 0.08865374664459771, -0.06734730978958556, -0.09870708137433606, 0.008089838186412861, -0.5585994756830485, 0.2335801076569315, -0.1045378004170481, -0.21793027072858612, 0.08822108497155853, -0.24529448374225749, -0.2624007756467572, 0.33079508834756466, 0.30944608093241993, -0.2603225993304518, 0.04229315805324723, -0.3446603989687433, 0.06625451947216295, -0.08180588106730285, 0.5112469456906887, 0.38968279772782477, -0.11488628559215727, -0.4981816313473012, 0.31018098503442154, 0.20410307138798328, -0.29616926775916297, 0.34784082896818164},
    {0.5175502267108809, -0.030282097323597247, 0.06235022797234199, -0.3193701429216748, 0.13161423357813212, -0.22249419579174676, -0.24388499425838325, 0.1622992668444747, 0.1237189292904055, 0.33859507684978984, -0.0926882788727483, 0.5117597356232404, 0.45668488912911936, -0.20041137170294804, -0.11586010494740209, 0.32763674572732066, 0.37435147790164874, 0.40978720739246055, 0.35006641277928874, -0.04811299402118345, -0.23089713300291148, 0.29109178082497605, 0.10367177939792639, -0.2563124360396415, -0.13299959915759854, 0.14984087705292173, 0.0959087076816445, 0.3328052990005276, -0.14737155546950334, 0.05354628831770355, -0.577918488466474, -0.045568041571913125, 0.26017003026679614, 0.34484811039653834, 0.48705586609665213, 0.4882989563268571, 0.4058607454426916, 0.43923042974750465, -0.06498921212790428, -0.23926787216033632, 0.10657521047471469, -0.09174750460823737, -0.3640527502762957, -0.016710746185834, -0.07512309776510609, -0.10092780887990063, 0.26167771182695987, -0.2655294359824573, 0.07132458511283374, 0.3711843321018744, 0.1407974732419096, -0.3418923932629898, 0.15780587482567118, -0.45068412554139925, 0.15205675594575382, -0.17992856314632685, 0.36857901190491293, 0.5519163675188674, 0.19423330791422397, -0.5893738581451085, 0.5437638017283001, 0.17410781260624247, -0.1804381672893133, 0.21573645354681925},
    {0.44293702488105297, -0.0662574987809003, 0.3021351812756414, -0.4544026069137997, -0.19507179742835618, -0.2641446293383424, -0.14158801874266613, 0.1107325958526947, 0.41043389203185227, 0.5173188356041836, -0.4248673623676052, 0.4624451671609176, 0.20850182391977493, -0.09536234238184658, -0.41849650264931826, 0.16019209082145516, 0.5142756692468716, 0.40934675131401027, 0.44058016552112833, 0.034038590095172315, -0.26987720371547136, -0.03414565325979218, 0.0677086011341523, -0.1215574688282086, -0.0450807159288353, 0.36524316761110254, 0.19944193470257734, 0.22151349751143418, -0.14293672331776464, -0.07548907969194799, -0.6037189697252888, -0.26916855048971794, 0.2870222857027926, 0.42854461244331266, 0.4031164648553467, 0.5560858459952527, 0.3987186005551794, 0.11647900516320406, 0.014600230851984003, -0.3583982821076218, 0.0713802906112919, 0.1911102230796675, -0.30543454947176446, -0.06141912324178405, 0.20657153542914503, -0.06955187175244036, 0.286696694148304, -0.2617382821815483, -0.12495053067305038, 0.09513928025771874, 0.24932645119157287, -0.45819510450837314, 0.2977937213991273, -0.4922475107941914, 0.010603257969035931, -0.34378022229648136, 0.5162861076544562, 0.23583015782142175, 0.2514112287836847, -0.5744590980662566, 0.3831814978993209, 0.061442056858448266, -0.32171930775387936, 0.4684015444114539},
    {0.2162871247702684, -0.0834234537154082, 0.4370387191239079, -0.30321878653632256, -0.3034977122034732, -0.4990412057737216, -0.16553511218162553, 0.2973129697138534, 0.20566116723698782, 0.2317678606453411, -0.3253758839682143, 0.34904682340637316, 0.36907135188131457, -0.25176851834927166, -0.4575472033689543, 0.21700067469774711, 0.3480202383719593, 0.499752308170552, 0.125106950330508, 0.12113519131904647, -0.22813727570366843, 0.23272635841269493, 0.14378664072159175, -0.2697419940659097, 0.327806192559271, 0.11176192578648253, 0.4246711312424977, -0.036746276050382505, 0.08527450762592492, -0.35192040739497943, -0.338880590616666, -0.47378831561418927, 0.16119322600947647, 0.2922743639534546, 0.29399476991029605, 0.33244802632065423, 0.36532280076224, 0.3416173770168238, -0.019082317791682932, -0.34454861274229337, 0.04294350676021481, 0.3289446925220819, -0.44622411732314327, 0.003892033959954603, -0.0977435680888949, -0.16368402229217274, 0.1693854774498415, -0.5785751497836605, -0.38526813643546687, 0.26772816980100256, 0.28642304541234875, -0.45131191787625036, 0.44471300290419913, -0.45820434762958356, 0.36251676595930493, -0.48755602268775, 0.326904299588148, 0.5680964660711962, 0.0959411909660524, -0.33328546795358, 0.18312558007987215, 0.19172540213352898, -0.04534323997271128, 0.4528218057865595},
    {0.06429423129688491, 0.022379315963327717, 0.27913330445954637, -0.42730015339481786, -0.1740465830675358, -0.4329489393972487, -0.3517597385834207, 0.4160460040942393, 0.3997620622882999, 0.20891654169157725, -0.21258949993648604, 0.49726592964480615, 0.006131293712514937, -0.0878265385721177, -0.025792501210956838, 0.37929367513116247, 0.3534118668854042, 0.4753226876023675, 0.29248578825256566, 0.245178345225611, -0.4575677615358452, 0.09313260943567461, 0.3125971348934437, 0.003740625629602814, 0.4176435522722895, 0.27212012748136544, 0.4826841493007803, 0.11888862879414863, -0.18144894285836127, -0.014752042738950944, -0.5122067415526329, -0.4403792765858281, 0.08182980902514315, 0.08761494707694624, 0.4375604133082321, 0.3981144710028103, 0.2532046491381279, 0.16416316682193882, 0.03366095833834241, -0.4369745149569763, 0.025668918871614366, 0.2866159613109374, -0.41778832315252484, 0.2526565793888593, 0.038416386548350376, -0.2609413595081743, 0.19615188653656276, -0.3418885034773807, -0.368433379067417, 0.344536813673312, 0.1452820507290521, -0.38538581110099424, 0.34427841468584375, -0.43994361995980785, 0.07543123899143991, -0.23294241361851314, 0.4549763939897287, 0.6059614097432773, 0.1113572034688918, -0.21858471167678203, 0.4886655674343865, -0.052803697919430966, -0.2317689416887018, 0.33189641583581675},
    {0.14131107241972454, 0.14632813826436333, 0.3817925271385457, -0.42515195302301395, -0.31746838622974616, -0.4032693644508428, -0.21644071586879696, 0.2719847902705953, 0.1699309282893065, 0.6224328561048852, -0.44475754120315225, 0.3798908286895456, 0.09987461084625923, -0.1917729970786037, -0.16815773924994318, 0.23579152991135904, 0.4387175006323711, 0.2747745707285869, 0.4353875870827174, 0.09146678670254924, -0.4466449206830127, 0.32510382345730754, 0.13933030406840174, -0.3568985916151093, 0.23001106221350023, 0.3834975709092444, 0.3656980252336761, 0.2004235231726129, 0.11074385314164266, -0.02618432999307498, -0.6357058559174121, -0.25395507592177735, 0.2959236576756062, 0.4560595654856382, 0.6022782692514108, 0.5765789899229696, 0.46691224088920663, 0.38220018371341136, 0.21872306188389437, -0.5543760234420844, -0.12831311353162816, 0.08933333963545809, -0.5127613928016416, 0.2427867076455035, 0.2472224827108492, -0.21986541421623423, 0.45525049805313594, -0.33938070601217624, -0.07412264998086622, 0.1104789889140763, 0.04168408829326289, -0.036631839365204616, 0.3494159885153284, -0.13529538201567207, 0.1432119053745687, -0.21917164661350771, 0.3258218426688648, 0.5337669012310793, 0.22909494412435885, -0.46003150936761056, 0.22895469020311787, 0.130151473475129, -0.2922690874211046, 0.3068192578280957},
    {0.2900403162043767, -0.3506412820843385, 0.4017641578745183, -0.4446015226911965, -0.2907459111255644, -0.5503312444548785, -0.10340765317470421, 0.2944243544226918, 0.08872257267816656, 0.5136584458178478, -0.26729973000996804, 0.11365362991360203, -0.04993264128126919, -0.1796592550737242, -0.20239410253630147, 0.33017348819988157, 0.2632979665497604, 0.2560648985320434, 0.32945777003157223, 0.22967368502449753, -0.6537006689423028, 0.3895628051874685, 0.2722238133279678, -0.36849625653442064, -0.038306456593833416, 0.24286557079293156, 0.41002867329238624, -0.23871640564778684, -0.016825319078345096, -0.01790624243571686, -0.4719073358687147, -0.5812186483376446, 0.29726950312486344, 0.354706918685913, 0.414353274153873, 0.47059531905451296, 0.3064397397516612, 0.5598707405961988, 0.3740922323069664, -0.4117505918189709, -0.059379337727548484, 0.18203385186569385, -0.5137623097473917, 0.0073057337594735015, -0.08195328659854723, -0.27515056371868646, 0.3113227592188708, -0.4563593300254345, -0.2356689233371867, 0.28519802190412086, 0.20352907142182214, -0.3834558397334558, 0.2817872593958795, -0.3670330213301097, 0.28699710816357754, -0.16455644524880375, 0.3268120498040248, 0.3690136853425337, -0.028051363969404778, -0.489118147128611, 0.4824354899654686, 0.18762465088015917, -0.08893953730435612, 0.4526489176488018},
    {0.4451548264882838, -0.3411398698064152, 0.32467402234406, -0.20183851193783822, -0.33415452595637807, -0.41823756583854194, -0.15232526571161786, 0.07338349429785973, 0.2215930841738283, 0.38238788749862174, -0.33596465274305654, 0.12016888792641564, 0.3679160912392311, -0.19940989179371998, -0.32535537072326043, 0.3025754841767647, 0.3686590361616049, 0.32541014572612564, 0.14201000647695552, 0.41350261571877756, -0.5261349717040449, 0.38978107134673906, 0.1860940101994175, -0.3301488546828235, 0.19600842144062086, 0.22406211716270058, 0.2679850629209213, 0.05620486496143503, -0.12321252218044731, -0.37756363523675757, -0.6471106507217059, -0.3922801577819563, 0.29334473045033027, 0.17168819120706794, 0.25848465565115525, 0.5824644131996802, 0.48471211458831154, 0.5510467895422084, 0.38041476567153304, -0.5027161301196014, 0.2143975516119922, 0.28052017355811404, -0.19907928453264537, 0.11124286688503755, -0.08556139189204068, -0.3519073967546531, 0.14433797317876362, -0.5894164143794354, -0.3115145662807747, 0.05105028979503708, 0.13991877764514948, -0.0644017018565647, 0.3473398798561553, -0.16384086895971248, 0.2298047104100114, -0.4500989004848145, 0.34291032417607775, 0.37714560220098675, -0.07787039629532805, -0.4055058066748724, 0.21839551132471574, -0.01577965592736058, -0.2452266166791986, 0.5511983003846623},
    {0.5637761277190836, -0.30522316522129783, 0.2626565995805883, -0.1373716479521464, -0.16466896482663854, -0.5755169085128856, -0.11325152662640181, 0.20413280916097915, 0.08983800769657177, 0.5539677157687574, -0.44315304072996287, 0.5241727916669455, 0.19133672254255327, -0.38120164732217743, -0.33425315728893856, 0.5020427264574043, 0.4003107496864214, 0.1937205776585999, 0.24089792356508066, 0.47739133027281005, -0.2484500982179736, 0.3486723295415399, 0.2722370922716393, -0.25008795895045854, 0.3741456220855081, 0.2703951510959301, 0.5609291875175964, -0.10183365861311469, -0.09771269390547796, -0.025801091710385266, -0.4848164951116618, -0.30602027984129176, 0.47223604615336484, 0.2634207643474811, 0.6166573262072215, 0.42826888579422784, 0.29687067006873485, 0.3569933636699091, 0.30363386137483456, -0.5335296381236291, 0.2001942821485243, 0.3347332413826543, -0.12318322927972021, 0.30924999766668454, 0.07737385295469304, -0.14209013700283651, 0.37209773787100464, -0.5135088898674595, -0.1932425544324481, 0.15128787318046175, 0.29909336171393985, -0.3506228706778544, 0.3208826765539379, -0.14075958397314606, -0.0329746084421278, -0.5237258993712749, 0.2849753626552778, 0.5491430647834602, 0.03643262343371077, -0.2574297820438217, 0.5230043136875174, 0.27077992007610807, -0.5001368091826763, 0.6231054994119906},
    {0.28181712407333925, -0.32969438327430084, 0.44894872273678166, -0.11494781928891665, -0.3085126865419241, -0.27820773965994355, -0.4008131871758829, 0.32821526710898496, 0.43631901544751645, 0.5823687539995549, -0.12054999320434126, 0.5525391307387221, 0.22384982371252796, -0.2666481712021619, -0.2809720304735982, 0.4310701219123391, 0.48902855506338644, 0.10814119261657751, 0.13080427466083366, 0.14050235864535113, -0.3006313922029502, 0.1608246906708339, 0.144621598736871, -0.2593698898608208, 0.0995569829560071, 0.2610025636966666, 0.3345605133036866, -0.025769768007213086, 0.20477262159114537, -0.21695034163634372, -0.5726240678213814, -0.5397154719813414, 0.19681702161261394, 0.4595141935507204, 0.5202679892993095, 0.3811704248793854, 0.5603724879651037, 0.46483904166402895, 0.49000232830030865, -0.20875654445454261, 0.4192296889928048, 0.1063223751616766, -0.45680960333384707, 0.073952394109611, -0.015766687351704084, -0.43311957681630325, 0.10425926243982139, -0.560005889458907, -0.4421549103277827, 0.28007931256946356, 0.2035899812742507, -0.35617574533122714, 0.23218413550938824, -0.3477957806991196, 0.20165113361083778, -0.5155024201258246, 0.25548681896883246, 0.4094207061431029, 0.08581837700470557, -0.43822995068218684, 0.5044834251213821, 0.2033595009478518, -0.38779931444727866, 0.5396682446634922},
    {0.45097641762142776, -0.15445891348908594, 0.2909006745184293, -0.1599292582270132, -0.29645464112145026, -0.29647112616237326, -0.24137001006682218, 0.09975745389286932, 0.5009927966036293, 0.39654749835670516, -0.3221524598496918, 0.284233965406707, 0.30334014466000125, -0.05773558866788695, -0.5382344498642592, 0.16210718619232198, 0.190469201467627, 0.016894396548177842, 0.29944386729681877, 0.0013336227477904082, -0.4975986079199739, 0.3592005962522977, 0.2642493433902071, -0.28880517876326867, 0.16764922291722772, 0.24049929203028328, 0.5264479222540706, 0.3231841672165074, 0.24333230989369814, -0.2277381377133224, -0.3640063154249454, -0.5689235996910943, 0.1915189356146464, 0.5127883595349567, 0.3759220997654056, 0.4944081287668153, 0.4745680951204415, 0.46768315189071746, 0.47367669376708443, -0.15838097645289953, 0.18560305100460428, 0.08428292765369287, -0.46827422531384705, 0.17599090423146238, -0.10958175523022455, -0.22623544141928686, 0.3007921430714682, -0.31921359344138994, -0.32106664739832563, 0.3733726721522324, 0.4636588376036533, -0.43986941562827336, 0.31720745317189397, -0.44084531708994873, 0.14761957124197508, -0.20329463355661517, 0.44093618563470527, 0.22841676717394813, -0.02271127416010636, -0.5396278425027091, 0.43942553141572205, 0.11687471106115062, -0.15853041169453655, 0.34064087387634395},
    {0.30569173372394187, 0.09419357485575161, 0.35332126711357126, -0.186986642986021, -0.1517749327258964, -0.4167951507017173, -0.3856318829014518, 0.36489095603619226, 0.5190051471451993, 0.542410419209897, -0.3069968980098364, 0.38708312318640165, 0.2058616703426476, -0.3509534355713608, -0.42558185831355805, 0.4666187580325891, 0.5174001838280061, 0.1323681568552277, 0.5327246068439324, 0.15445464832448677, -0.635119854210647, 0.035914464269406185, 0.28843582005299284, -0.35158768977179616, 0.0939429887179418, 0.15149605277043102, 0.37916638922214524, 0.3699179104432825, 0.05462629604868376, -0.11521369789631976, -0.6646069243468672, -0.5784673655611119, 0.47084850959370367, 0.5293240634435897, 0.454285894501707, 0.4492407777039088, 0.5728074545465401, 0.32930838170842963, 0.2394928133741584, -0.30867589464465583, 0.41803554158785144, 0.03082313084001936, -0.2980838104153131, -0.04191922676278613, 0.04347919816134294, -0.18809403424642088, 0.14437487654869843, -0.34395019860269527, -0.48727503747881784, 0.2551406236841777, 0.20777162834626578, -0.2270787405070767, 0.44216200549393725, -0.5165028174591245, 0.20351371775214275, -0.05300812489124856, 0.5934196189420773, 0.6264084165527017, -0.05968970475921926, -0.5438688144627697, 0.6189134040996839, 0.23816259063023715, -0.2759542476310077, 0.5448823461628493},
    {0.3675169434067066, 0.04565686674104022, 0.39212801634607614, -0.3750939523181026, -0.2702307363629504, -0.5688627246254802, -0.42684120607164966, 0.5011500678538959, 0.41724986037531475, 0.6431605419120566, -0.32903372524114183, 0.40130397030245923, 0.41213617722325097, -0.26260967282709446, -0.4118154293555963, 0.34543801043432976, 0.42846763261164933, 0.09509076934607583, 0.25562725765750566, 0.44673093887023896, -0.5959518911722003, 0.1710846407153179, 0.40340573018823134, -0.0939291356480963, 0.02966499829713538, 0.11249677258804638, 0.1496186377380879, 0.32857679968863296, -0.05479060400063027, -0.14086614954093823, -0.5098265996697892, -0.5411909146454976, 0.37972789595903644, 0.3224928220245518, 0.3772539729529853, 0.6216865348319934, 0.4812994382057003, 0.5304094650987243, 0.36149286457990154, -0.5681601877075203, 0.27890910669778274, 0.15309552603286183, -0.19312603398095884, 0.20621895602302326, -0.028216560870941782, -0.3164660621878297, 0.20985709687809298, -0.3603842949279211, -0.35221797787828035, 0.1842132184205337, 0.2992812026515767, -0.4667551011196454, 0.5830221879477426, -0.4044422871644555, 0.13124228538380392, -0.1522175471777931, 0.2755747062338107, 0.6057560626273469, -0.06174518352103741, -0.6271373909956551, 0.3667483578142658, 0.19170618652150265, -0.5029929384805515, 0.28281376499418104},
    {0.4435154593536038, 0.0743052937439163, 0.26520768480966134, -0.4803991537011196, -0.16248343982805233, -0.2274228037995528, -0.4453391835618548, 0.39696070532585964, 0.2886126862828683, 0.3630799687959704, -0.20657163617666843, 0.192322949663638, 0.23157210799828856, -0.27109085046522974, -0.3822842368428231, 0.457374122061635, 0.31443903674827706, 0.49788161057939595, 0.5482192227065487, 0.20666387413762863, -0.5919044484370563, 0.027455194436179324, 0.4851895342932354, -0.07593231136741793, 0.11390602135240235, 0.3327004051618279, 0.22266832097117836, 0.032438938690479896, 0.29612769132782724, -0.18389939363029753, -0.5372867540343229, -0.19556226342250674, 0.26964650684350694, 0.10796536655546624, 0.43842480678320395, 0.49056033638682184, 0.5581387016278312, 0.5419419699933715, 0.27514345938349477, -0.6419709790362619, 0.1803528436874645, 0.24838565001339416, -0.5375306483984995, -0.12749903910277655, -0.1258396051489288, -0.13366638470991582, -0.009269526801637744, -0.2909412113753137, -0.12734862367817681, 0.1598683867859925, 0.5204597200229594, -0.39877719790243715, 0.41853673967667016, -0.4830813640475881, 0.42252463346402197, -0.32256618604540793, 0.59684102943184, 0.5323630387011019, -0.04065147818730157, -0.6468419343606121, 0.3038260041417295, -0.06203660724955071, -0.17981468526074174, 0.3590511637835408},
    {0.4075031252065962, -0.31521667783550456, 0.5450054420106739, -0.4602481769724713, -0.38696708266863317, -0.43013991730695866, -0.4299871254038947, 0.4126117186515726, 0.5671027150800648, 0.2993607046241733, -0.08547090378749778, 0.2440248923270876, -0.000178455343977183, -0.07529669119391735, -0.4380735349291783, 0.49294005769668847, 0.17730171567069092, 0.4718655400579241, 0.2149394019908012, 0.22381634112842022, -0.33588894856091905, 0.321545191093286, 0.37155144892073566, -0.3007790558052347, -0.0375295541808322, 0.20676214939850776, 0.3100785581350766, 0.21661533331385222, 0.2689230439223227, -0.4190768467887967, -0.6373072148154258, -0.06669825161010302, 0.08043336545046398, 0.11068524609232047, 0.42995312646091594, 0.5113284658227841, 0.48063920983566993, 0.6031830667606835, 0.40604748030841076, -0.5589699690167412, 0.25335493844773815, 0.37122822535032046, -0.49984828191546643, -0.12366375495327386, 0.07247828947988982, -0.28588425849026644, 0.23920485795062646, -0.557123223603288, -0.2573841032705371, 0.36713120823344264, 0.29579752032821754, -0.37577345397113215, 0.5144927549545127, -0.3861740694015244, 0.09748996728089968, -0.4561985077866054, 0.605293540825588, 0.2745903091237042, -0.06361440062872818, -0.23182332083084056, 0.6208202831102868, 0.2061691047017598, -0.2883431477824788, 0.3651583307153302},
    {0.3401379007775715, -0.2180049601116687, 0.5069198494772099, -0.4604627689200693, -0.4140407201349259, -0.5841727746955465, -0.24717283688722622, 0.16696003651010746, 0.5373039758322934, 0.25488009236359765, -0.12226328197243938, 0.37315035140401437, 0.3676171874663383, -0.39605311467115395, -0.4584253063195132, 0.35308601430949144, 0.18644859526142862, 0.47883735945009154, 0.28165537348605985, 0.49491489059484794, -0.6203228884864377, 0.07607055692216584, 0.2634904525052472, 0.04912876021768771, 0.16795919782180127, 0.13327048767848454, 0.4720376403455419, -0.0553262153441282, 0.23476830710066177, -0.3629813078782223, -0.3315757479629952, -0.17552915320049492, -0.1302842430947334, 0.5367494885777703, 0.5915124396457494, 0.2765386768018893, 0.425038705232098, 0.19385355821524608, 0.09317203203774693, -0.5069192070266089, 0.08393966743471665, 0.2311328675780432, -0.502331798960432, 0.17129273224789238, -0.09423247368947937, -0.48793591992980057, 0.3470046965030016, -0.5805406565141342, -0.3779362943126878, 0.31190903534627906, 0.2309603016589387, -0.05961104305093403, 0.4174621163629088, -0.5476304394453043, 0.005978151736645191, -0.5476696557771085, 0.5953494376581037, 0.23928321646531447, 0.03855955940439693, -0.39382502267390934, 0.5524257576829047, -0.04412043933812778, -0.021040732505493338, 0.53403097945573},
    {0.391154004953219, -0.46461374145735207, 0.1852532909043137, -0.30123924137960467, -0.41974431666054074, -0.5379273486332309, -0.29830504494285326, 0.20528830120916014, 0.39454085298361663, 0.5178823812717718, -0.24553695444094306, 0.32620282035321824, 0.26130336930756654, -0.3305015237273912, -0.17285653210917115, 0.44318499882760504, 0.22965840061513715, 0.5291480716064548, 0.46847817232595323, 0.5168512661065083, -0.5763160623066081, 0.28768328659989223, 0.2883903826292282, -0.1379724910202534, 0.051034748349963376, 0.03145557286627723, 0.49632341155138715, 0.068790023140967, 0.02444239501669598, -0.13583155471097252, -0.24113653579048933, -0.21283038620404943, 0.04936022055301303, 0.46978014502790844, 0.5643093391237274, 0.42350972481686583, 0.3615468187360669, 0.2899992103951343, 0.1410428632804168, -0.3686821494685353, -0.11974271582202003, 0.2582153874869269, -0.28896789888230473, 0.388905865141663, 0.04013138602805696, -0.12245829554223593, 0.16746273686063096, -0.40532526737432406, -0.18392819207890915, 0.4753915540695343, 0.3108363308475235, -0.1726758109935435, 0.17995974834522235, -0.27401391028854144, 0.3350234430167607, -0.46031386370630617, 0.2662191024480177, 0.5700182486505656, 0.2380084889010638, -0.275077173446333, 0.23268331092543243, 0.010561326487589284, -0.03090286707208841, 0.5790073151676297},
    {0.32698870555536175, -0.5233167982163649, 0.22645747371201258, -0.24523334099283542, -0.08030869543976982, -0.6034882665058365, -0.43525429576503105, 0.3431297315766807, 0.17613051382976852, 0.34085976028335047, -0.16896184573208672, 0.4398301277791185, 0.26984407134864896, -0.07889554879305281, -0.17341365088820435, 0.5156966691864298, 0.4288103228214382, 0.5338573743160466, 0.19287247729030624, 0.34384461322509235, -0.5140745107427493, 0.009167509492723666, 0.40174007962856856, -0.13966838503517354, 0.049853500738810064, 0.2998906437897483, 0.5472054881573059, 0.1386176133565541, -0.05668652870312569, -0.011161964198236392, -0.5617443180209689, -0.427129069572462, -0.05284858468093026, 0.4029455137432805, 0.5099438408323762, 0.6321621651587743, 0.5293803187561045, 0.43782795320816753, 0.23104433675792954, -0.314659454726421, -0.00819378936875464, 0.1264520456457532, -0.5130725426686392, 0.18871482863782402, 0.011924340057266681, -0.16662328831516782, 0.11849697541457724, -0.6287300565213579, -0.35798309808638284, 0.25192411043458135, 0.37895771501534314, -0.1410192771372531, 0.21804927042670522, -0.411269896696224, 0.2830348723959599, -0.2831208090181161, 0.24449155471823644, 0.39678344995896203, 0.22966737019294092, -0.24355174085511344, 0.5524130411322274, 0.2383923947198126, 0.018011595177406324, 0.2552678184715096},
    {0.28423654431363454, -0.5133947145396711, 0.15974384221191087, -0.5551356020896908, -0.38199895590147254, -0.6188781618997788, -0.3459933058922389, 0.415849398008383, 0.047267913235198425, 0.5106355197821061, -0.14553781673444685, 0.47744316394939335, 0.25291265300156873, -0.0011694881028960612, -0.41776020196910435, 0.3221038041997773, 0.3262781687562766, 0.5026485670925497, 0.491258674100025, 0.4535489618026448, -0.3991770645235563, 0.26693495992607863, 0.4719892336395408, -0.23864797045046598, 0.0824144111822721, 0.3898754415573439, 0.42886886987510087, 0.13861970534454243, -0.27055710596602, -0.43902838645412473, -0.5224384535678265, -0.1250680360879584, 0.28635089863451224, 0.49016995309561556, 0.36148573872236456, 0.2404381334322868, 0.5183752773228633, 0.5100186474250152, 0.3992480625475715, -0.36396894629780085, 0.07884132071240152, 0.0802898140271932, -0.2756512374749273, -0.07320927058319479, 0.01946309298433328, -0.41713909684144856, 0.3779836602896493, -0.41707368110286686, -0.40873577579050835, 0.4524307156322192, 0.4148842586365155, -0.23809758349543528, 0.24612646417833905, -0.3355556020872751, 0.16026694314714932, -0.2785360476944089, 0.6022998271159702, 0.5346176009197561, 0.2899677116985863, -0.5653291554363904, 0.46578618341698824, 0.09832697629848726, -0.3436463464501473, 0.24496604568395258},
    {0.4557386369486367, -0.1439035902490009, 0.32646872332635085, -0.4655496682759027, -0.13781039683354104, -0.6337453525918881, -0.4384921698058151, 0.30471519364983046, 0.23452841525329832, 0.21675736203535123, -0.09922238124076775, 0.4790677585362835, 0.36372242691829904, -0.1750250606971969, -0.323806597383728, 0.4033748178557706, 0.3712935614934304, 0.5386022959408926, 0.28137953975680097, 0.3674781427507749, -0.3498690451299751, 0.2303736300566232, 0.3083373634628852, -0.20427950769381967, 0.3264172208905077, 0.10466596987691902, 0.17832152158076398, 0.12922000915317566, -0.20306569176037964, -0.4041651232005164, -0.5285701028555582, -0.4356454119773423, 0.2742937778392209, 0.5736696092298385, 0.5813720289134999, 0.2567515657946566, 0.2776166620511153, 0.5743189057515828, 0.3029743528685679, -0.6057399439295197, 0.10144255505360197, 0.02831161740584733, -0.43831584889525105, 0.13797548800626178, 0.05838465656695061, -0.20519367295459312, 0.2813974420512278, -0.3739822448941574, -0.4229130686612293, 0.16305658321567593, 0.1624466473418443, -0.03731975724945582, 0.4943198671391148, -0.38720770057046316, 0.3689721915525992, -0.35066983912541294, 0.44902732746381335, 0.6037615576028703, 0.3024433714195284, -0.5198242900519013, 0.2171151384939332, -0.07008015728762594, -0.3093489695397132, 0.3404747277587321},
    {0.46927735640172163, -0.3188256272632136, 0.30914697562521654, -0.31519356508293067, -0.2615610595912398, -0.5672662411692053, -0.2541063381162288, 0.5032033162885694, 0.4115796368248508, 0.2814339390600655, -0.5517125871965889, 0.34834015810265007, 0.15106436469691367, -0.02024697416027446, -0.5789449687464572, 0.5784923558775666, 0.25503658942342333, 0.28588424629625897, 0.2612275254252921, 0.3513292543284552, -0.3389028471664442, 0.25920617557870684, 0.29184456683461263, -0.35719929266525086, 0.25171968111686227, 0.2879640666313591, 0.2712486801032073, -0.08277092966065748, -0.10495627057280828, -0.09949580535626322, -0.4986700503932971, -0.4333711870992216, 0.4080936945122397, 0.5708646732876264, 0.44071224625882355, 0.4983727010684479, 0.4274119869314389, 0.24017699473715148, 0.18645440746708739, -0.6286623472279554, 0.0966737307854902, 0.02676476145899052, -0.22628756058996416, -0.005331719319495296, 0.06751074144621459, -0.3688164885728616, 0.05481685623999648, -0.4887470905359835, -0.3702476646937024, 0.41838982855915796, 0.21745091663731567, -0.006336787244478008, 0.39583766261472764, -0.5869321696383127, 0.24724460975852702, -0.19774420226491612, 0.3373648429339101, 0.44960156716478905, -0.034869750166055424, -0.6561289871831248, 0.461768454941069, -0.03770389097787236, -0.4685075609465319, 0.46068873601829224},
    {0.5482342361574624, -0.11890774278904805, 0.3695950285330482, -0.35324816835897077, 0.05284422683040081, -0.611921566799845, -0.38505443742232487, 0.4576528055979436, 0.4350266139615193, 0.5477672854692621, -0.5183917751844862, 0.5746626804997269, 0.4132946583994878, -0.3459403183353276, -0.28932085221515036, 0.5784209318526249, 0.5554019500144655, 0.390759380935695, 0.6112962871722104, 0.2856244145912015, -0.27175045673249754, -0.03780433871342026, 0.5134330126942708, -0.2112105033969574, 0.23492363447664147, 0.17509770068058064, 0.1927542592303146, 0.16465686766941506, 0.11810813134150261, -0.045344158705647654, -0.32023331437000374, -0.4862615334626209, 0.3905102744538699, 0.5222072504894595, 0.4690867981485596, 0.6605011171603434, 0.5465838657901723, 0.3724789152006861, 0.4703497481968608, -0.6089560207150954, 0.359166169939951, -0.05187339197881274, -0.25640447256326, -0.04138159361162701, -0.04816120380623825, -0.3185163884232068, 0.14418785937637763, -0.4191477779559184, -0.4567455056981425, 0.4918608559959799, 0.4699499849057675, -0.1139093094814769, 0.6096539697528979, -0.411676115201339, 0.13217073092195605, -0.48576557990591035, 0.4835566844694248, 0.455346762443103, 0.05473742568902397, -0.48211933556824454, 0.2850780396888127, -0.1121450818250482, -0.4249771287261496, 0.487135790412645},
    {0.6128887356411232, -0.28849375500505886, 0.5167949201838866, -0.4785446186121228, 0.13736880056431514, -0.24665557700447904, -0.23847867873736586, 0.49801845066971423, 0.3058037200147172, 0.39020814911004337, -0.5001272119996325, 0.22960521648090362, 0.1476683313876048, -0.11076213130024794, -0.4411219555329602, 0.5453123937216862, 0.5727164689069034, 0.5393652768724653, 0.5906203099364884, 0.596055993445937, -0.42029209446325033, 0.004266199619531195, 0.46503894793079403, -0.17744046364990546, -0.01097207608681693, 0.13465240288192057, 0.43648137165503265, 0.20969217886813118, 0.028356285202668693, -0.25407047823114043, -0.5048845032817174, -0.13139741813564465, 0.11031908414701776, 0.286879618081762, 0.39534482082973127, 0.5228408385109368, 0.5355620874886665, 0.24050718893968756, 0.42429126606024126, -0.4598652325274586, 0.18002199840743477, -0.051036006871947266, -0.5887501234549392, -0.0697224139976882, -0.07172080387403494, -0.4051115819264397, 0.015993356957183288, -0.6687349428100073, -0.5178731492385699, 0.5570878513786686, 0.45882851466464214, -0.22618075514602012, 0.5982964708103315, -0.4719452238339482, 0.17401182397375842, -0.30389916872595085, 0.6503245064972974, 0.6770487402210039, 0.3505305485158039, -0.476020353492308, 0.5621774385613602, -0.06519841301693649, -0.341011523878267, 0.35216841778411023},
    {0.5870300016670562, -0.06201610528226869, 0.3170674700237155, -0.39408236368605254, 0.013990469549716158, -0.24253376508288602, -0.18756492504145916, 0.5311076480571578, 0.5651960680313335, 0.5590213290298293, -0.5007345270332076, 0.2849129929027958, 0.011845030781980901, -0.02631433465002666, -0.5045827426733841, 0.6284642027504328, 0.39060669775591256, 0.45367956123919656, 0.45162945820365036, 0.5285488670943563, -0.4686999106381521, 0.01230235617431532, 0.4412057234785564, -0.1321291142321271, 0.13854294861355973, 0.12463710859049527, 0.2761856907192551, -0.1413687711463563, 0.25518031966003996, -0.4524716906308232, -0.6646746646356525, -0.1306724399287199, 0.38812838310903786, 0.4262974594461155, 0.4127424488700801, 0.3296338797949822, 0.2850418595968023, 0.5287894246542036, 0.1905407084379226, -0.5074315313420217, -0.02221433216424118, -0.01792064852583279, -0.6234754507662743, 0.2688611962966999, 0.002137741062037249, -0.43138181973918077, 0.20147443269551857, -0.5821092926298594, -0.4573494055576987, 0.4130421474855945, 0.20860725118081516, -0.0745449764807022, 0.5234219755828102, -0.534616660501784, 0.14618341399810253, -0.2978611908447169, 0.47134062077143496, 0.6353534813862384, 0.3558214681689923, -0.525408525789722, 0.43641061981447266, 0.11461757576359893, -0.20396868610294108, 0.3906684492419777},
    {0.2925092115207809, -0.3361259194157943, 0.2457974707051424, -0.5724946571458472, -0.030221336817777684, -0.5395968052836636, -0.4182858209114623, 0.28582953822474794, 0.36714468154749175, 0.43028595772164174, -0.5063605799703339, 0.5463247898725063, 0.0845084068198209, -0.28613548396615346, -0.5075434696177724, 0.3249572564278396, 0.42318906556439484, 0.1625464426847801, 0.4935914023160278, 0.44597247609698015, -0.39891383622497095, -0.01676812751148528, 0.4935569596429938, -0.08305805652888293, 0.031142187544980847, 0.1286705325622622, 0.4167407510154518, -0.11865824342670506, -0.0515378607921175, -0.23004915971441442, -0.38214416317031086, -0.13115413522035885, 0.13695475010231864, 0.30486388770220524, 0.6110899788881883, 0.6299843044636028, 0.5885245394412942, 0.4077441418715449, 0.5019953627736241, -0.6074153058296832, 0.3472628009167404, -0.05836425167561382, -0.4016818447956459, 0.3466220713871698, 0.06628313052897704, -0.3816517861661764, 0.1141448828941923, -0.5125824840831772, -0.3891417342657543, 0.5980251571621148, 0.3309812963680165, -0.24367954505905742, 0.4747713506800504, -0.26100808774378004, 0.41001267945993636, -0.3392271995959085, 0.6036580124531581, 0.4935647383193313, 0.21870649731402605, -0.39096681844570325, 0.3246365427399265, 0.2852685477739851, -0.48736495360292675, 0.4851510496440316},
    {0.34604118246995036, -0.41435350958856576, 0.23283866696587024, -0.602548217752922, -0.20821705100657806, -0.3905647932011712, -0.4444691138766004, 0.18265084402518325, 0.5065220070582892, 0.38531296214275274, -0.5755362739276805, 0.3751244624402311, 0.08222628611970349, -0.16654014118387545, -0.2519349120757899, 0.6520703552537301, 0.4171850296580896, 0.46665876955255536, 0.2533322605206201, 0.5408768230535045, -0.5700701459312685, -0.11808259792329334, 0.4427422322756268, -0.39052163595428596, 0.3028788188428053, -0.03648782793608857, 0.48762168740501266, 0.02474707068284817, -0.20693581531823135, -0.24034192176299285, -0.6283125537869343, -0.32570106309590124, 0.07997767646891317, 0.5890538153284891, 0.42172783215894033, 0.5881945842354026, 0.4904356535774121, 0.5390488890630409, 0.3135018138414126, -0.47370075514697135, 0.26281412618688726, 0.05988090413841126, -0.3268214524620006, 0.31946656936802964, 0.143276403037208, -0.19841139635633231, 0.1032886379141528, -0.42108171475903905, -0.31707991517693807, 0.3168882909751963, 0.4427403148938107, -0.3264221646154071, 0.4260356181788117, -0.5909542680306897, 0.3961359875129035, -0.3131988049798596, 0.6356212660235505, 0.41939155950635587, 0.1320882909863906, -0.5515808524277109, 0.2887047602645428, -0.037948799802195086, -0.4040133007677763, 0.44896117460790913},
    {0.3092983388244797, -0.12723824474514545, 0.4595738705823678, -0.5320552356845667, -0.04528222513915346, -0.29524338903927405, -0.5366029950611143, 0.34957586329482926, 0.29816736016673906, 0.4487760410503468, -0.3561801223436059, 0.37343517278589144, 0.14899094195408882, -0.33529152419079555, -0.35787082616764504, 0.649034641363121, 0.6185718044647378, 0.30087897739274017, 0.466174489705834, 0.5084647504937154, -0.2709674607118532, 0.29107490719110013, 0.5673058723438936, -0.032158691237631945, 0.22011316921953814, 0.3587059456895817, 0.22728299766353297, -0.12938978573732285, -0.13039344731598423, -0.19891489075046745, -0.6561415584894171, -0.18708797623470308, 0.04277371503864309, 0.26970815325164577, 0.6442141956849072, 0.2971050926067785, 0.44888505705984955, 0.5033073679536235, 0.30647312434198115, -0.4465764154774482, 0.23089463211608646, -0.03530154099045761, -0.4707023325969217, 0.2866559500064253, 0.10793045767661724, -0.25830162334642515, 0.3300288489139834, -0.544872266345444, -0.1868334643969765, 0.5616356028411704, 0.19500698683342182, -0.1867597182432847, 0.43731272454395126, -0.6081382288178829, 0.11673058698960177, -0.3107512526259245, 0.5287344803423445, 0.6242515609498753, -0.003554482205184626, -0.6004834133542116, 0.45029037829140484, 0.17307729461418067, -0.20157958529632755, 0.6128962420141608},
    {0.3626968351709167, -0.26136115713357794, 0.36825882639407975, -0.46181994491186207, 0.06674270439385513, -0.3330691398506556, -0.4676966552202011, 0.24996471961646974, 0.3795762754636058, 0.5383752456852943, -0.48926680960737906, 0.28664848158135847, 0.23167925941406342, -0.10774722385435584, -0.2834418523715317, 0.58611599284625, 0.28428860386463783, 0.10921225658011051, 0.46157880800011625, 0.1727188893563343, -0.3321501973182571, 0.06743085366523947, 0.47691243462030425, -0.21721270054113678, -0.09828450668275293, 0.21236793495835962, 0.1642069936059339, 0.1466304687475955, 0.22791046531674894, -0.42823856844887054, -0.3918029495445154, -0.15506261543161493, 0.28777689933423894, 0.20878186121718076, 0.6133187702667287, 0.3684293519206574, 0.3727377436145824, 0.5936801018210149, 0.20162691878128894, -0.5173923172428051, 0.07604880136029195, 0.06055456269220037, -0.4555073286691228, -0.04715585050367362, -0.14931398039227006, -0.3848038786012766, 0.38788973940479554, -0.4929863855399054, -0.3529703947072477, 0.535275723100551, 0.2077036867726494, -0.0683771457575311, 0.6014845762045689, -0.5147715454831294, 0.01878970078176068, -0.2614855016324886, 0.367894508648843, 0.599460899897909, 0.3440659957369203, -0.5759921091343158, 0.477039153915702, 0.2340551185686003, -0.22455412341966519, 0.5870217409117688},
    {0.42776771329095725, -0.34627922771547814, 0.5017115185045129, -0.39158648178634015, 0.017610890876878626, -0.6365161966222023, -0.5350212493176337, 0.5297160201759458, 0.4413691948700963, 0.5429404235132076, -0.43020426572967013, 0.5521811062111811, 0.09010879413297802, -0.29821918569006906, -0.4131760794612677, 0.37868448699350277, 0.3925581983892428, 0.18105193079847917, 0.6103957493015875, 0.46156932394819944, -0.6053549219282963, 0.11299572170567587, 0.5040789917707442, -0.38710016126530356, -0.0350277724679202, 0.0959300857786226, 0.3443175079935411, -0.15487123792078972, 0.1777027934605346, -0.265763629188866, -0.5708100821306293, -0.15315393687336126, 0.22267787897457514, 0.4507712220511912, 0.44266462603294837, 0.5130401134616416, 0.42354737189987224, 0.22805694914891683, 0.1415296094758825, -0.562833072465623, 0.3308761384171191, 0.1607281747298675, -0.54803324131256, 0.24928711473988038, 0.009189894109030889, -0.1741036372058332, 0.3444567715908972, -0.6228401813923496, -0.4969365852805343, 0.5761952289759604, 0.344325800919174, -0.3828592793400387, 0.5901546431072966, -0.5812445066241355, 0.13941640697154317, -0.3749436419030536, 0.5995619020438743, 0.6629475482504571, 0.2848764997180394, -0.4678976359795547, 0.277911586799225, 0.2523128831666593, -0.2744994133159115, 0.6356645243340483},
    {0.5207540125684444, -0.09152829580663006, 0.5516488727378911, -0.4154779370685344, -0.06682348877443964, -0.4870213216046797, -0.4335283880956912, 0.385844284569905, 0.3206412919105825, 0.41120566625356325, -0.20477702549589732, 0.6120377335825345, 0.24273101290245216, -0.3583776301443719, -0.5840423873131402, 0.5835205096664917, 0.524187977323372, 0.11705926452194193, 0.6248985324937679, 0.37273071549279685, -0.48697698602559614, -0.1472135489412478, 0.24845261425379414, -0.04030256615760994, -0.16125259606887157, 0.2214881785444916, 0.4932741734247416, -0.03685757115172247, 0.11836747179723844, -0.06429071209562086, -0.6021701644869504, -0.46742760943319894, 0.07278293654483425, 0.48419883913994305, 0.5688135988863289, 0.36487005295363834, 0.5942303736632448, 0.21085733743324045, 0.3174214579561541, -0.6407494438878099, 0.3388820831230103, -0.05341906218981494, -0.3521184729628362, 0.21179076136098116, -0.15103234731183682, -0.4934426987906686, 0.4208233183166589, -0.5577812246897189, -0.5051206206871117, 0.5711708348771122, 0.29561657675882685, -0.2796960518060097, 0.34099915794300756, -0.3898251187280276, 0.2868829980271368, -0.5575073807547977, 0.6478664948139882, 0.6531159513004845, 0.10757866189209886, -0.6892842964193844, 0.40785598066282297, -0.03587795089923559, -0.18797241915018184, 0.5054301161932289},
    {0.4779860885932632, 0.06837640085246476, 0.4102267971286588, 0.027558781841781566, 0.1637265659460091, 0.031311903406782936, 0.32560140155838796, 0.012717399381513022, 0.1696362146190995, -0.3332830541326055, 0.1434345469839453, -0.479674746180806, 0.39740387076218364, -0.4320848612969761, 0.14810538345642876, 0.2963094179755667, -0.04073885198395655, 0.15089102167036963, 0.4885914164232388, -0.06927704107842297, 0.1892218992292705, 0.5014222215832995, 0.28871850007043387, -0.03676191528541234, -0.6247256305434764, 0.4289411952640304, 0.014089923261752312, 0.27610465200294676, 0.6127784638974929, 0.3668016628226753, -0.011420225022822006, -0.40663699639617046, -0.18983110837425235, -0.45004048624940274, -0.07184881737706893, -0.37852784391749633, 0.15110810816224474, 0.2738233788652188, 0.44404305402888117, -0.03988558337371022, 0.4070071970476333, 0.5243611876006365, -0.35559964910442426, -0.5923602936552179, 0.5231630872723886, -0.06405212011236866, -0.4422979941908368, 0.25267111940717407, 0.30312720521579456, 0.34820547890115605, 0.5102907301289815, 0.07147685585537437, 0.300577057330142, 0.3400938085228921, 0.5054273442395519, 0.12743151462551164, -0.31708075909930156, -0.1763051006691938, 0.4676653389417648, 0.10425254555702775, 0.49081300386468163, -0.11550180361720724, -0.4275358126374923, 0.17335788994926152},
    {0.049575577172227915, -0.03269276824566034, 0.37545210168211185, -0.005298484240939433, 0.05336300946401016, -0.0599839277292197, -0.017053286521681452, -0.16433216605498832, -0.08263846080924134, 0.15510906981607442, -0.2954041698516834, 0.039704194519160955, -0.34969912152372895, -0.16326394268020705, -0.2493280912276439, 0.2631397160026343, 0.09768495490829991, -0.19308281121235035, 0.20462619093971132, 0.13713933471206524, -0.0925511550204002, 0.03503343476113935, -0.11843294770045575, -0.31509917298888585, 0.26656153640873, 0.19627699615529873, -0.19376629412323815, -0.35817106007958766, 0.12099310035290764, 0.21082984307727867, -0.16443341798700017, 0.20067455979344428, -0.11985750763292388, 0.12607602157457862, 0.020119328770048038, -0.10324307298628523, -0.06697165494837028, 0.11013438768387582, 0.17929135482215083, -0.22592120654620637, 0.09789197928531154, -0.2983944174494511, 0.3108536898689968, 0.2182141097111684, -0.08210508217532303, 0.19448986271066385, 0.27581875620560875, -0.09146990171743691, -0.07857251202470454, 0.2290469030310835, -0.08902810404301623, 0.06863540721594427, 0.19635659570260372, 0.043901200085500726, -0.10739627051853003, -0.05982351263862121, 0.2518122436204576, -0.0918331760283517, -0.03955351221221026, -0.3297943432547785, 0.25858432802298437, 0.35982283187466446, -0.1495650584122341, -0.12515253682306746},
    {-0.2131954568903673, -0.3258246655987471, 0.20609556916165675, -0.3406473524557518, -0.3450604609394561, -0.02424732450406473, 0.015384372012710966, -0.5339407014835769, -0.171351247436114, -0.3316705736423956, -0.25078411108269916, -0.5017867068469309, -0.3281962414066249, -0.26691366969923846, -0.492637463045894, -0.22446005503378877, -0.33547497241518914, -0.20561570277035254, -0.09152728929487335, -0.29271699132940154, 0.21746511414986341, -0.2636907758678583, -0.009476881800640309, -0.4441893817217575, -0.3434759670996508, -0.07730412894153596, -0.14557501782610482, -0.1066006210312781, -0.11603016109437297, -0.21368894348784187, 0.034914119293560184, -0.21742196393937782, -0.45999127525363526, -0.4211727419203592, -0.37607017104549495, -0.13594489568721468, 0.06987997006028675, -0.2482637529274132, -0.13054960217515524, -0.024179899422208447, 0.22062698303128198, 0.21956800241397784, -0.2876897767671992, -0.525552137294218, -0.23017103614663664, -0.06250471542756265, -0.2770015717434808, -0.0462080614704734, -0.2195751139424406, -0.4589294760454233, 0.08561362382132406, -0.2399742647408158, -0.14891523931680478, -0.38484077980809434, -0.06260231387880352, -0.18286937000839695, -0.11875587497196831, -0.36668641940903557, 0.11447494337912655, -0.10372572263132104, -0.32256143626691536, -0.31956091838001016, -0.4746554385034456, -0.2912608575870321},
    {-0.020859359717878896, -0.06981347386317788, 0.09673763218523332, -0.35285570236890496, -0.5378445360976147, -0.25285705852640816, -0.18490225434906535, -0.05982064792316122, -0.39547233024511863, -0.4402769968771479, -0.49261940051168424, -0.43706527772038284, -0.2143181921519695, -0.4850245100900958, -0.036419872357895275, -0.33661544539238647, -0.2224922997644855, -0.009895297977978987, -0.3331416717627652, -0.29216741940781793, -0.1031948100027628, -0.11861196262734426, 0.1581838391639314, 0.0464569054143686, -0.3711362516686781, 0.08521804172446903, -0.1399574131108483, -0.3490303166360648, -0.12478328429992662, -0.04609262123174983, -0.1069499973387867, -0.39296725168241703, -0.41974978801108076, -0.2387298502996503, 0.07558096300541745, -0.41612607557178133, 0.0036435468379822623, -0.26922438674210997, 0.13604585241423056, -0.23595810366799344, 0.2286031316029566, -0.02907605444976693, -0.34208197346076147, -0.47586396422497174, -0.20017299580081455, -0.044164873634130616, -0.17352312198164407, -0.44518460517364683, 0.012311024899047058, -0.31136776002424194, 0.010998357681037187, 2.005473875373823e-05, -0.33924328801481607, -0.08120152747288219, -0.15349884028933336, -0.43057738523944905, -0.07394775887722099, 0.011793200492259206, -0.03043392028858489, -0.3617949198081754, -0.268214306405067, -0.020726564402162168, -0.2288369792475297, -0.3429991024697481},
    {-0.4545513710389219, -0.3458265348478375, 0.40464786350105175, -0.37688288677997095, -0.16557252787300253, -0.10591118097147259, -0.38964518750848176, -0.524680111875991, -0.5196150378722597, -0.2226450108050534, -0.4679015690551568, -0.1582140938256878, -0.540834585311539, 0.04838769421094527, 0.013458275818142797, -0.22855490177371257, 0.07197264793208835, -0.4214942106771488, -0.3102041422289575, -0.5287400912657554, -0.2748303305341591, -0.09574945462527473, -0.05504523417329164, -0.22548387553485721, 0.041272067737725925, -0.30195695714705734, -0.38824541576151683, -0.5053796030855198, -0.5476934425295816, -0.4470097527429425, 0.03666829881877446, -0.07229877402669281, 0.19740712585347223, 0.158755931605401, 0.17334672634055362, -0.0029122103758718603, 0.236048630790858, -0.4628027692984902, -0.3645841318439697, -0.27741545613957164, 0.13094072188160413, -0.020888467016083136, -0.024357298661649752, 0.1357471866683926, -0.08015763686142566, 0.0767395512659973, 0.008124667677229887, -0.35777992631454797, -0.4400200596556363, -0.3791121965415801, -0.18477441692817378, -0.24394911334341565, -0.3169416996704463, -0.5157378760529167, -0.3825276918439439, -0.5532847575763055, 0.11506787842704295, -0.26310303943904817, -0.14559280759539253, -0.4598924620329748, -0.23631496732394675, 0.21712487579755363, -0.16394368717211244, -0.06790642815172059},
    {-0.46039650758269074, -0.44573772619392965, -0.02410393583876401, -0.20559474391789698, -0.16412888850491475, -0.2672191411584277, -0.2718319599394903, -0.26540825982056115, -0.5277314099849472, -0.11869900015538022, -0.31253787428147545, -0.12358204662452484, -0.5940393733750284, -0.1681796783452074, -0.31493199874798905, -0.02357227856932997, -0.2361872117781756, -0.08789064117615504, -0.10154436313738956, -0.12453949135386277, 0.0651140746815124, -0.23318148405568534, -0.2185289341054155, -0.33972807769834334, 0.029517522747762325, -0.34194881155025053, -0.4744529823755367, -0.4156710984231372, -0.15367935727624996, -0.322349804324269, 0.13777949876147408, -0.3295969588217168, -0.0808837947695549, -0.06926439407902002, -0.13862641944614612, -0.07836176042336818, -0.0719852088543826, -0.41192107880091694, -0.10120920447859676, -0.2650647863515742, -0.3193969739457675, -0.07440808015744489, -0.258671129199085, 0.10753276269446185, -0.1402048613204346, -0.08719617548492298, -0.06520395284065532, -0.29918722128312547, -0.22877978145354838, -0.37846225861848315, -0.08999785187368228, -0.094073895365865, -0.4883408559088217, -0.34751414383137363, -0.19813117690434282, -0.15379954388903402, -0.16900647067839314, -0.42938731903960053, -0.36683182235794076, -0.26591984909380373, -0.13960213332635749, -0.10697817027810942, -0.30457183289613443, -0.21716156419461563},
    {-0.22621466159008807, -0.30800105030826097, 0.07267308010851443, -0.24474137759971953, -0.25092771457480667, -0.3449408193881703, -0.07222567178684107, -0.4378557324737448, -0.114981187465794, 0.14764219944569182, -0.28023973447655454, -0.19937180679191716, -0.4813146008413998, -0.16361040967053417, -0.26319033954917725, -0.43325627652259274, 0.022997140912045733, -0.35197809987770096, -0.21808208665481263, -0.31918747923933677, 0.11959188527420535, 0.07572660089383068, -0.03279184514093778, -0.5525617282954559, -0.4037718232334573, -0.06231289884829483, -0.1617133220374446, -0.4838798304000939, -0.32322924270273323, -0.4237769435449771, 0.12242023055905016, -0.3828165641808045, 0.04926168617328565, 0.029208895705381953, -0.1534372185433988, -0.3002375819106927, 0.03714839404500677, -0.48997305134575475, -0.3511273825582429, -0.18109358780543675, -0.19115518823910868, 0.18008736515644527, -0.1990029023312273, -0.32438383042751634, -0.13667027418878222, -0.10986353872852087, -0.18023613062153407, -0.4642552022254474, -0.4214589837133926, -0.23536735717713814, -0.23603613996386558, -0.251610974945122, -0.41639596907184734, -0.12714565882037368, -0.5015122703340725, -0.41753349002136864, -0.1475350903579265, -0.11851000608967471, -0.2491920529276575, 0.03760789459143173, -0.3550964294376418, 0.11840587521057194, -0.3183439384894244, -0.02893516877287058},
    {-0.36162620838817494, -0.2498652518308995, 0.1329078972072796, -0.3109630142942798, -0.5659724343010674, -0.3486252228569105, -0.04302603799010463, -0.14606957727623227, -0.31088151766471184, -0.03326256764072568, -0.31114034613815206, -0.07095478273057765, -0.2408931556611779, -0.04032295862257728, -0.42355666327685493, -0.5300895452424756, -0.2775323760285135, -0.23926176195280147, -0.312950863073696, -0.2654027816644581, 0.07369263540135887, -0.2625532839023223, -0.15900417502846065, -0.26898531198532316, -0.16744719214429268, -0.3894935252201131, -0.05746489723194118, -0.4643004870679247, -0.266986297770457, -0.2840873416171921, 0.04406777132807011, -0.22738903828493817, 0.0658227618094141, -0.06689584901140147, -0.2649582404408503, -0.018231371149536046, -0.021952213170638682, -0.44030584991570826, -0.08080179154185904, -0.4640940438538256, -0.2846265046758022, -0.18707970747984476, 0.06124863829227277, -0.2243502196770372, -0.3827139670233851, 0.06047946950157672, -0.3000415089706963, -0.11431024623998177, -0.35949253528243186, -0.11588678594415366, -0.12921808198555068, -0.36999664433750495, -0.1037924623766966, -0.4928819733568215, -0.2652032443145464, -0.17514566987318023, -0.10982500758834343, -0.19235100724962728, -0.17265709829007694, -0.1447814842782233, -0.24116709519739513, -0.15291087972099954, -0.11665528237197122, -0.08320741960952698},
    {-0.186120965040079, -0.3674972329143324, 0.003127663960087492, -0.11428152670077248, -0.2489575172594933, -0.17867835040247107, -0.11957468553758742, -0.5101725279111935, -0.26931539236001967, 0.060392333390453336, -0.45148203809788784, 0.06214264748223801, -0.3648105135282434, -0.34207221812467853, -0.4332971985919799, -0.24740050072275097, -0.02639745074586487, -0.07837649349019757, -0.24394238376443866, -0.30366231169581503, -0.14670553712262513, -0.3374104063633373, -0.036234937218241836, -0.42704519903871524, 0.008402403117274452, -0.1682204780580626, -0.128492778994564, -0.5500839078766966, -0.42831522739841926, -0.2684945365175422, -0.0405870559437841, -0.4088775064733447, 0.052800674463373824, 0.21601348285073416, -0.10146929965787914, 0.10368700705734397, 0.061039024081635106, -0.45772183289060286, -0.28810317916605266, -0.4900434673793506, -0.0902743524071171, 0.09186621809061289, -0.17895646562579848, -0.098292760422109, -0.43394933083441034, 0.315779097807607, -0.006163741847922931, -0.11405772937013603, -0.24160192608892497, -0.1413018758578311, -0.14121159228228403, -0.5145822948992359, -0.29810911172755006, -0.4990438791139615, -0.315292438832885, -0.21383599700140127, 0.02493120299515667, -0.3869168795638133, -0.26900202896697906, -0.0447566213585942, -0.4748969751536156, 0.0752796849516618, -0.14563509588503715, -0.30424540660640614},
    {-0.07620098961250303, -0.2765785576716129, 0.2794809515687731, -0.17698844860530918, -0.5610665099566919, 0.0824910399005111, 0.023835230240039872, -0.2851077872772155, -0.2708573715227849, -0.2229688683794089, -0.4573718609999855, -0.35614338371681004, -0.3378564846657249, -0.1567871891275345, -0.16236292439848915, -0.2432862709681783, -0.44322056134838195, -0.17825941268839202, -0.290314028485714, -0.5140588663350015, 0.14889225436314668, -0.05849883740584155, -0.07207130265006265, -0.37546527650910555, -0.42214442138243774, -0.13418849311501116, -0.29467508191889336, -0.4289148288409542, -0.38553025283828124, -0.036702549243600134, 0.00485352832612093, -0.17560901258240294, -0.060581078349607256, -0.06632923761882752, -0.4986127082431844, 0.05739405285284981, -0.0008445015214777392, -0.24414363336900552, -0.0743927910549846, -0.4747807197942821, 0.07344984918816162, 0.12945443019681402, 0.17454755724581608, -0.2761687442665725, -0.4157183179700398, 0.28477380320585877, -0.2411106113392583, -0.3334374074392221, -0.0916805582914053, -0.11563793964670595, -0.05999503884211851, -0.3052098967385947, -0.28903463617613034, -0.10551014153647668, -0.13117065222471744, -0.3760079444467438, -0.03599263178532502, -0.25796218095265505, -0.08081549073121803, -0.31774767485128286, 0.06225074112958066, -0.2000062575350965, -0.3234245912803892, -0.40150177819150124},
    {-0.18048838310293447, -0.3944285578177955, 0.22514048648872587, -0.20283408297581118, -0.4613462696602977, -0.39515177298170795, -0.14870163268163714, -0.4633985850950542, 0.041984180333171674, -0.24731925369405988, -0.41767699641595785, -0.03554287539120643, -0.05801530811945515, -0.2698452259868177, -0.380138249361085, -0.19160980457219026, -0.4531621685902054, -0.18932116952560257, -0.15190731759567486, -0.5129308646094275, -0.16919667377606637, -0.015022545823213355, 0.10362166153243532, -0.0398460036544768, -0.486257478078422, -0.23068895757544286, -0.26939130293928176, -0.09602132829678307, -0.4052697968556439, -0.15827231883964163, 0.043793112507006744, 0.011369233955921912, 0.028879826510633592, -0.33493850072588427, -0.012629746497995246, -0.3165073081848247, 0.14657445866213997, -0.45128608441909335, -0.13032821378256854, -0.4701268589140527, -0.32390142264012056, 0.11864539174854634, -0.06047298612407176, -0.25362307967250297, 0.011696957719102221, 0.01585231800657028, -0.14020366174106785, -0.054648828804972245, 0.03477332577279549, -0.08432442028026561, -0.08407743369711648, -0.034299808401358996, 0.1009031839573174, -0.4445326807904165, 0.02149444769204647, -0.14137950529284585, 0.14379682903529323, -0.21288402879748852, -0.2019362703065469, 0.058904137128484683, -0.0641931101636059, -0.13821869682162782, 0.02639739958464412, -0.2803520828699553},
    {-0.1970823796799447, -0.3047472394525206, 0.41365077279744294, -0.5264118788187039, -0.37458713893205864, -0.19421879460279243, -0.15406222846237116, -0.502348085618817, -0.1098926680035296, -0.5116297038807877, -0.3604343078688942, -0.28089592759431586, -0.34012886871260484, -0.2541220199077495, -0.3795626698511216, -0.25518996131040367, -0.39440279512790555, -0.36653482387489816, -0.5141686562018574, -0.31816127112419257, 0.16212928535892976, -0.432432651835305, 0.1450818858353994, -0.5692225005426305, -0.2829685582333489, -0.37890745638496054, -0.4253818743476656, -0.35793834853658674, -0.22700270480137866, -0.25925204653586076, 0.19551999640297926, -0.527471282475716, -0.19650514439022648, 0.06285287514706278, -0.32045364421200045, -0.25413380822767856, 0.22085219684334598, -0.3271232526280982, 0.003836561450692217, -0.2838373804672114, -0.03893179250034694, 0.3194713318733447, 0.15301095886227079, -0.3110873846361307, 0.0002618667427163198, 0.25194991950133655, -0.42119845042150755, -0.13695020284284462, -0.3206297109915193, -0.2529480734773165, -0.10038510546000604, -0.17787412289941978, -0.09585091597353552, -0.37596385963478174, -0.24488475803463514, -0.1997938450892391, -0.13913059797858288, -0.439412487467999, 0.07637745650294714, 0.05551667762191865, -0.3369689652473103, 0.02504134005854421, -0.2921373634678995, -0.1668236794825978},
    {-0.36195725442912735, -0.49717927557263925, 0.3745832812527068, -0.5126729802197385, -0.16100343089454447, -0.04820404217776435, -0.1810232673628369, -0.20421140111048575, -0.46400342927207494, -0.3371628706077719, -0.38482046214944615, -0.24733350721291122, -0.214784277778696, -0.27053045657504987, -0.19544098614440808, -0.4595596829932474, -0.18512191058011201, -0.3085169445182906, -0.38642031644359304, -0.4011801281513094, 0.08058065126770406, -0.14969283566140054, 0.1216808431028404, -0.3792007250708041, -0.14675538355011397, -0.12578687361109264, -0.48684854135358685, -0.12779117554660147, -0.4481581528216909, -0.24011024623818603, -0.21033054434363674, -0.31133982359865364, -0.07927043413435625, 0.08193779255805703, -0.2711455264415959, -0.30116707431848294, -0.08386624322549391, -0.0541128872294821, -0.21353369632256317, -0.32840061949741073, 0.11085121530801532, 0.16516701108880286, 0.21593943513144273, -0.1614451623984436, 0.011220452592485521, 0.22043480826209855, -0.5802932137269114, -0.13149409062182146, -0.47692770719916827, -0.40645320503563687, -0.09824819826485877, -0.2515801624016782, -0.3070298697851401, -0.46369446594378916, -0.044279866246296644, -0.299438423419039, -0.3844889039504926, -0.45711464731855594, -0.2336703424000876, 0.012502043317210807, -0.388849661159868, -0.10401417944687368, 0.004478691099768746, -0.4271728321529031},
    {-0.0008674290121315479, -0.3295511350720706, 0.4081502386829568, -0.17326703586958098, -0.31144649875745595, -0.08179361241864073, -0.24686220876464673, -0.33183712364229007, -0.14833295726418244, -0.35200823172926077, -0.494209080013842, -0.35718371051369785, -0.23405431681852942, -0.23849111900249317, -0.38941540701349053, -0.5031334321161952, -0.3090099499961689, -0.42007456493588496, -0.10182484848741324, -0.48216405055062, 0.1042646579033272, -0.10208406420754416, -0.012435484492555143, -0.1981187275175647, -0.4211484684848444, -0.1871110766648657, -0.5397421026217654, -0.14605629396466188, -0.2993565770104564, -0.27885198753039886, 0.2148490707712295, -0.5240133938190265, -0.4127288485107626, 0.048978857326657396, -0.4587306783685914, -0.30342830442600877, 0.0194482150040818, -0.20017740885082308, -0.09280975874434705, -0.25657619143283517, -0.13960185341900627, 0.19942899266528064, -0.13487838006183697, -0.3336283088207479, -0.1447543505656521, 0.016858414200469816, -0.4726350056399933, -0.3167698452153488, -0.20249975923848623, -0.357297108417461, -0.14028064982853536, -0.20078648802946056, -0.49466072018789625, -0.10305711917835002, -0.3038119998507666, -0.23483933648954614, -0.28070611518381966, -0.2197956730285587, 0.09882401265734025, -0.01363625778873708, -0.037253668759580263, 0.006001113233442378, -0.00201190088591916, -0.23532149961327437},
    {-0.3019103387253921, -0.45481010393520976, 0.5216027708895354, -0.12181152803830027, -0.390973359602192, 0.14523210776274958, 0.03857673608108636, -0.5114441401410326, -0.4748081372329098, -0.16578147846706268, -0.26827151865406357, -0.19729357978860212, -0.42989786266902796, -0.14541564689285583, -0.2766859151978912, -0.5260635013903845, -0.10323758008705958, -0.5132919928455119, -0.44864495537878335, -0.3861399653837464, 0.31242599596765397, -0.31923692056631925, 0.08570577380624492, -0.3782616763449888, -0.16369654198104125, -0.27267400347387877, -0.45849354373412105, -0.3055859033829832, -0.3702037858542282, 0.1649072180288824, 0.3208498884921502, -0.16837759081029735, -0.38886221220924866, -0.08845071637057395, -0.12601182696079002, -0.0428593889979067, 0.18908983368722354, -0.28636711024239525, -0.2390597705219786, -0.3995284690481115, 0.31060044955110744, 0.1355084243155874, 0.03623804177541285, -0.2592789166340784, -0.012033197919354609, 0.20508001433961526, -0.26528370569145254, -0.12526790335538723, -0.4107184787603309, -0.08896535242895351, -0.3605425924684946, -0.10200197759883708, -0.36410538910777174, -0.33584481814143013, -0.41557659712548, -0.12577942350354426, -0.14052287686100015, -0.2699807633237876, 0.05450567006405096, -0.16562550358191475, 0.13245790307255254, -0.17027007338217479, -0.06856875630443736, -0.34887631717704776},
    {-0.10569632430736678, -0.336183142576461, 0.48859751755341274, -0.3150166914112736, -0.6132805626282303, -0.04944782139878944, -0.19909541297534802, -0.2700875727266677, -0.09498058466553637, -0.06497430123674011, -0.5420461891538396, -0.37033951408246557, -0.4772728878907034, -0.4758258045897986, -0.5561622491804977, -0.252868726297833, -0.32126759758333623, -0.5981281659290635, -0.40468940242456286, -0.5520554600819273, 0.04267512540050375, 0.02460040773465177, 0.11618109528559799, -0.5088080858759899, -0.2327349874247288, -0.25627290245675727, -0.1868579337766138, -0.3891905512748912, -0.3189360816545789, 0.1252408187939948, -0.2289622689127891, -0.48437794725651284, -0.0904513864101327, -0.08312161120272535, -0.31529932703503916, -0.05889236503901019, 0.11652055279862607, -0.2760177795239601, 0.12678362442505292, -0.4935516749236636, -0.09348524250730562, 0.3174958774660544, 0.027128877088907204, -0.31776187693187036, -0.20180285894266806, 0.1416363296236183, -0.3416144720773049, -0.14363052650631802, -0.2575918699175248, -0.08420723567779845, -0.055656632739059436, -0.22592920009703624, -0.4532517042213536, -0.49751690454283903, -0.1724888287421126, -0.03465849409806131, 0.02633590623821009, -0.17322947228780775, -0.19799708821792011, -0.3840945493763431, 0.055758712379145134, -0.2960850708573594, -0.17977211190419476, -0.1513708897628633},
    {-0.2761560815515507, -0.407030849701853, 0.3838964811808966, -0.12267124285955285, -0.5004420837871836, -0.2296585205536408, -0.12172763550720929, -0.18271960867738157, -0.2621926379909971, -0.1807616715271322, -0.22792765638563114, -0.211825889026687, -0.46629280978454485, -0.4536082519906821, -0.4911899481966787, -0.34023769634452744, -0.43093267370536537, -0.5650806957738431, -0.04024307964806766, -0.46961467473611923, 0.332241663760514, 0.04648234455950772, -0.05240175970523787, -0.16439180647006452, -0.17841494527766774, 0.051539109894602496, -0.18477176965281766, -0.12014742181543303, -0.3122530709519345, -0.0072287076332858925, 0.11504200588759343, -0.10782656183208242, -0.1883193003393743, -0.05090898716517671, -0.2632899511890436, -0.07315041663252299, 0.08849256536075567, -0.37140669531904885, 0.13585940105045063, -0.12318312134172457, 0.3657359585785335, 0.3360812666272106, -0.01129745938805641, -0.10881476104704811, -0.3288879312393585, -0.10478452483768219, -0.5234878736071414, -0.3309729114904743, -0.13672146457586787, -0.26259102308581783, -0.10098898064954341, -0.32602972380602396, -0.3761574847908461, -0.2319980899216888, -0.15032228124718147, 0.026324774006674465, -0.04533452797293354, -0.38146686288631115, 0.09967065761412418, -0.17373452120151361, -0.28601255101951, -0.11392622907784804, -0.41005172100332565, -0.18312287748095268},
    {-0.2654298427191201, -0.41102615249735236, 0.15415060363760677, -0.3030020117379963, -0.38087288915238915, -0.010050584283044672, 0.025025250467771265, -0.1932928596113912, -0.20282992136083342, -0.40489521193511463, -0.4747605630264718, -0.507344143415335, -0.5082027736389774, -0.45145482716964686, -0.503088510898153, -0.3485524580100485, -0.43361035498008305, -0.485585882333121, -0.11216863031377919, -0.2508208180405477, 0.28000872314628333, 0.12533039425186146, -0.08505725005821069, -0.26475350916286644, -0.3443411942465023, 0.10238750303577834, -0.40300849962663904, -0.32821224511767716, -0.3744772767591969, 0.22458210282589025, -0.20453486544659133, -0.4612149138268223, -0.3164821343529715, -0.18621032516314937, -0.49554654043741136, -0.024734339531766285, 0.29425411204314883, -0.16400750021673088, -0.1576117132508277, -0.40927085722526735, 0.27534565577905773, 0.19856449046981228, 0.19369949349449617, -0.41115634239418064, -0.14697794089326083, 0.15508314407375975, -0.4530933885687241, -0.4016361687815172, 0.0009372395197557693, -0.33405966869176457, -0.31797853478181165, -0.3047340175289351, -0.10258636698001296, -0.10010989856194923, 0.08737009467075796, -0.3560527189193707, -0.26302407629229685, -0.1876376977257077, 0.23921670112857565, -0.32741733019832403, -0.23755363029053447, -0.15888141970423164, -0.2055286173651002, -0.456252703028474},
    {-0.14418772883147127, -0.22105740853576572, 0.3327248806547393, -0.38159975662637824, -0.5859474466224646, -0.33701191533941666, -0.19937209967825065, -0.381403476287415, -0.30813168010693787, -0.5094457021487824, -0.4923955355638182, -0.5096909353327177, -0.28897352018806516, -0.2814198669187342, -0.34206200159473416, -0.1826986759309973, -0.13127579350275026, -0.5454838728151067, -0.1587665231551644, -0.1828319197017545, -0.018348015921208004, 0.2280922817966397, 0.1779478028549854, -0.43264855657266676, -0.46858054779265673, 0.2051423192052355, -0.5456086390342432, -0.45562021568316813, -0.4125695526651309, -0.197522475781247, -0.06001442573919225, -0.301219987476658, -0.1147937268129749, -0.17838883573941097, -0.2789054942308999, -0.11921957692802658, 0.3872103147989206, -0.37938593567971945, -0.15871473578670559, -0.5324182116780518, 0.3098135256363412, 0.43181432475249987, 0.14672615561237212, -0.15503521722631725, -0.3367209144399882, -0.04189415081772541, -0.46145088055982947, -0.24809012291978086, -0.18385642770492583, -0.3567959802493114, 0.008575923922027238, -0.09557049874785242, -0.026047121038296508, -0.4187231417228652, -0.00611138147496921, -0.3410054487741362, -0.14960165886319615, -0.5169091647668581, 0.09073093160148987, -0.26985389390886655, -0.26220275796314724, -0.08316254383924632, -0.34395157092731343, -0.4402180310396558},
    {-0.017033642926994903, -0.47669185684313903, 0.003194359231155079, -0.40667279806397105, -0.36589367957916535, -0.12122473580897541, -0.1172495522253223, -0.25442708479923565, -0.4297338715061889, -0.15594723138480998, -0.42673798176698974, -0.5137746208221675, -0.47660272003787346, -0.4934232602055192, -0.22637647591902837, -0.4667936053847287, -0.12862523108630222, -0.5758961995975344, -0.11346035942859095, -0.5427878017448601, 0.1202707107690203, -0.07933383566464547, 0.018170673283190022, -0.6103073439015745, -0.29712686894376117, -0.20194123181992366, -0.24185197910561987, -0.38176614255331, -0.559813705895934, -0.003557503689840356, -0.1999305194091453, -0.3063403122465483, -0.2428055312464681, -0.2034986030104793, -0.31937883837639536, 0.018878963921211602, 0.2907990466343538, -0.36261726152338364, -0.2105047359626466, -0.48306162317785467, 0.2725730796219122, 0.3052620257331091, -0.10976965318453849, -0.30954967844552816, -0.3997417120835639, -0.23429984675779084, -0.6225475715399625, -0.2971077696208283, -0.4470171928774012, -0.11083690544151543, -0.0754073647673427, -0.5178524527553303, -0.26583991020994946, -0.2547234829885369, -0.21868562369577638, -0.5089290812542111, -0.22332349580841446, -0.5278330820621254, -0.10024036645234712, -0.2980725645215669, -0.2676184181002906, -0.2189921434589686, -0.4549724295122447, -0.4399096058626561},
    {0.09115194885089865, -0.18145284386909197, 0.24548210242847796, -0.1668899968772328, -0.5337548516756166, -0.13664443239545918, -0.059760098121934384, -0.3435560035611701, -0.3717898915196873, -0.33501503292232376, -0.5137178817871233, -0.30543429986990983, -0.5658494041269782, -0.341188406356436, -0.19906431840939093, -0.0749918686082002, -0.10175699000195465, -0.57967769321893, -0.05777812932050864, -0.2334611134074797, 0.1724351136552851, -0.1848499980129858, 0.1988975101465951, -0.4870846592572193, -0.20961733970209345, -0.11965384732468717, -0.44530225592715084, -0.1509391309634936, -0.22878006660884942, 0.2626154115850546, 0.17268066832373716, -0.3384302812514642, -0.3875688903268613, 0.1809940620978942, -0.1897089513273481, 0.12778178621629432, 0.07223082013230617, -0.29796113903883803, -0.16878840664828051, -0.14079077503130252, 0.39348896988980975, 0.3955342998345358, 0.25653924589325344, -0.35060600245785545, -0.049025437393556366, -0.043742898160177957, -0.5161578699033865, -0.37303986198324474, -0.17717232873086167, -0.20285376013040116, -0.0710185422160346, -0.36203743968050567, -0.16213827353671462, -0.23487373831972175, -0.0620296955852701, -0.020792882214994122, -0.1159603688080482, -0.2351281945071658, 0.21801501145985586, -0.21058124990268826, 0.06305324468328721, -0.279943633338642, -0.12148035294728914, -0.3878418786888603},
    {-0.18251365581934517, -0.3596314037989076, 0.3330859886489594, 0.033483667551462266, -0.6218912483154548, 0.28172275937048474, -0.006943484957559372, -0.27344129432429587, -0.4260089652834157, -0.3572670519121372, -0.6920533426891144, -0.4500394555263052, -0.45734934577372643, -0.4594548067857721, -0.38646571666471785, -0.26684524253030356, -0.42704630962662504, -0.49823153461313, -0.10644763364325466, -0.6332469430833739, 0.27854252325642703, 0.11970103122858464, 0.23955455136798803, -0.597673565087648, -0.30429050915345696, 0.09145717287374759, -0.39815950251102095, -0.26902291763730823, -0.18491460261076398, 0.08641039167457787, 0.09261343471900144, -0.5848708470006818, -0.559083413768528, 0.29888050046091236, -0.4118485798829259, 0.2527688954752817, 0.14492152999683644, -0.20759553554782992, -0.16794936327467597, -0.2956018029579661, 0.4825473977131966, 0.605465978941881, 0.03918804982793261, -0.5102873724007487, 0.04359233922175783, 0.18939571925222232, -0.5942938579948667, -0.15085691249422667, -0.2846760297410245, -0.10986854498250723, -0.0747224934615112, 0.021716603015206948, -0.4480678718744159, -0.19743038120258669, -0.04117611209559988, -0.15770262339667274, -0.010887405739274165, -0.559542871270207, 0.4444856816523305, -0.2365503770154359, 0.4050263597810261, -0.2682134901924635, -0.5310799185026656, -0.4127954656072776},
    {0.17678401629253637, -0.18277483610544168, 0.6524612223191782, 0.1285148652651199, -0.41241374576614737, 0.13105770960940388, 0.16516092038471875, -0.31755104023622105, -0.12213896545063431, -0.2192521794734591, -0.562829284122568, -0.3952084872296396, -0.23344818626318647, -0.5183939903951496, -0.11822975589513512, -0.34305625852338695, -0.1857076681290181, -0.6176257311675462, 0.28866781145641374, -0.21225697554756262, 0.5858909796354831, 0.22697419022696785, 0.44238772445827945, -0.4709387281215524, -0.37905616827640404, 0.23697168330966698, -0.4779681311219177, -0.0731788872895206, -0.05066910281805328, 0.46984514442174513, 0.2693386510710115, -0.422153110338318, -0.5146940069548475, -0.036194997794224124, -0.5255169322186654, 0.11144465157823692, 0.5471923302194837, 0.04445522818289488, 0.28088675902095395, -0.3469960671749576, 0.42691346606322317, 0.5704752914122493, 0.27002526072527744, -0.4319686293174858, 0.24385542081596898, 0.1729670789334824, -0.4302100897353201, -0.13625914630716135, -0.08661516527126428, 0.17490702099154, 0.11194982976703427, 0.07009732863388433, 0.006751057862030256, -0.11107628080798564, 0.2505122563196371, 0.10314929376089679, -0.37337109485016984, -0.19310777145874317, 0.4565246243113632, -0.021814941857979452, 0.45879547099246953, -0.35170081448611995, -0.5648823730419008, -0.4327655876485739},
    {-0.061535741738924975, -0.4185328312362688, 0.6093567524529095, -0.17918794527414633, -0.6221785539920283, 0.05121830950959938, -0.08291536032785127, -0.3890110025414027, -0.01758966254638002, -0.6102655617467935, -0.5426680047120617, -0.3646864593397682, -0.18961912069348452, -0.302557726367843, -0.30656855467882443, -0.21872784540343548, -0.4701265942694431, -0.46916134433179785, 0.016619054335605378, -0.4296236601489008, 0.5012246224326291, 0.46732068363097046, 0.3235539018993215, -0.5354135053899952, -0.4606630328110337, 0.4503291751731929, -0.5319944414734455, -0.38977446483183403, 0.04401046854149118, 0.2810720021469865, 0.244558536848856, -0.50649326655974, -0.40252669001818825, -0.2763375187805189, -0.48313243007684525, 0.055062667814485475, 0.3407507486568908, -0.0469914848812599, 0.20623419760635447, -0.47899055941906554, 0.5347809972908079, 0.35332022565086996, 0.045477630669957254, -0.4189802423318669, -0.08162699136877942, 0.20259643296550187, -0.3866776403939466, -0.12087993250073688, -0.2180683488164054, -0.17491153748875618, 0.11594327299646073, -0.1744788382791588, -0.2574059320869984, -0.32982993975021, 0.026250296929663897, -0.2207646663245339, -0.4459148002593495, -0.46583362148591273, 0.49451097119620874, -0.11865800078159168, 0.21463148134905255, -0.5339907907369061, -0.31892922401024604, -0.47294358235919914},
    {0.0242700418134193, -0.256542205229129, 0.40490145879414735, -0.3286725855987023, -0.6494832190714093, -0.10780920887664674, -0.12635595263256733, -0.4884209809718822, -0.20404051423070158, -0.28242973263699483, -0.5000317947045796, -0.1811067849912094, -0.41027738547966164, -0.4114051010865044, -0.25906133560113953, -0.2941934943434124, -0.2720466464125158, -0.5758977329420893, -0.36547462388771074, -0.6448109092866287, 0.10113568691820422, -0.15933021897724614, 0.02527727245882468, -0.5998220537576701, -0.46653714713658445, 0.09249790992766721, -0.5522063785683348, -0.5545523250758824, -0.37698360213804855, -0.1722314142207516, -0.24890901889502434, -0.4143973730987762, -0.373431233897662, -0.2522125489479031, -0.28160208257946484, 0.06559232712386039, 0.18686656370345667, -0.4426204237341039, -0.010172298948740036, -0.2724881711429415, 0.0561595768285815, 0.4374356604448038, -0.14186096087535904, -0.3668759488518316, -0.080711952472423, 0.011969262930338263, -0.47440207964923437, -0.2271044592298098, -0.44045846041641273, -0.36469663343238184, -0.13114673298460527, -0.5273002748121405, -0.2945352157899783, -0.30656379957103147, 0.052216435499347943, -0.31392318830400384, -0.18812523066054673, -0.35674579366470915, 0.2858544246442064, -0.4972807344543691, 0.1861238083761144, -0.2974478072842134, -0.40034538229221434, -0.5007396349804276},
    {0.1890256966594194, -0.07723431678115503, 0.2802156786167039, -0.2732391611593096, -0.6025205710966256, 0.15438083909889028, 0.15734991662587253, -0.47214340009791084, -0.404309547921114, -0.2723145280640356, -0.6841575031693081, -0.21955831265086445, -0.3149801196963754, -0.6141167093986516, -0.30496938399097345, -0.2448759651028534, -0.2961336990986374, -0.5578302697441472, -0.20241778475600228, -0.3373205428800739, 0.5459003965647236, 0.2036679330997341, 0.2868801395822596, -0.22864261534211022, -0.49590397722863955, 0.20735598842229214, -0.6067871615154758, -0.1020967806247585, -0.1179638931168499, 0.4061419378745498, 0.08166931582138949, -0.4199110810506392, -0.3177481951378719, -0.08770471909892288, -0.2893005430354213, 0.10011252188727598, 0.17085961612864753, -0.3870625192886894, 0.1426340562080535, -0.23787273801545475, 0.4336495190871291, 0.5542823695450095, 0.29327622618620647, -0.37842683033123947, 0.22431256161170016, 0.0004765327288215142, -0.4872257529724408, -0.3239417758121136, -0.12846436090686425, -0.25136119155419695, -0.0652959966878778, 0.03082029938593664, -0.17084583415818289, -0.21971250153159835, 0.1830422561663786, -0.24328418545399946, -0.07852666555537954, -0.22605436533988146, 0.491421180039923, -0.39765505107704713, 0.2594389343923365, -0.38564716404953475, -0.44571772364787093, -0.4962674486159864},
    {-0.04351490376235776, -0.35216914332181454, 0.6177055834075591, -0.2674492433300109, -0.677316878302634, 0.33605364129891585, 0.07885274772469344, -0.4287698221522468, -0.24238829655362853, -0.33546862551131346, -0.4267513963983496, -0.3425265955028717, -0.2466518976870284, -0.3052800019926049, -0.29410717803821973, -0.5025425416093418, -0.41080487183952663, -0.36955664464032545, -0.24554497180122034, -0.42328950125934317, 0.563136659957903, 0.23545125498572506, 0.10306867831978733, -0.5922110109472255, -0.4842538307884298, 0.3564491048611055, -0.6283122223443918, -0.09243500291680073, -0.05177641204672826, 0.14822698741095883, 0.26619198895959423, -0.45474477978850203, -0.41981675557205395, -0.0246765362776913, -0.49327612124188486, -0.22080452446144802, 0.4535776305050067, -0.31274397147674665, 0.28434739920965857, -0.45351456897509573, 0.6381121807085315, 0.45062254926059814, 0.20888814086044602, -0.30409175669972494, 0.30673567582155536, -0.012493327115422614, -0.4179894411388731, 0.06555485491530856, 0.05386196969235078, -0.0671958235426205, 0.24525439878122968, -0.2600817115441943, -0.24211966590959824, -0.21292170375244834, 0.27232944333678916, -0.11730366459608878, -0.3534941428289413, -0.5669149889292294, 0.25753394636375665, -0.16078757759232282, 0.47244917898041117, -0.3697679530707065, -0.5670114365727784, -0.5335030960105355},
    {-0.09241826509019514, -0.4229520239948836, 0.3514182610583675, -0.39387074836051855, -0.4494984538552071, 0.16493409675685328, -0.09111407003538459, -0.2900708838638525, -0.20048932160115532, -0.5465567404661562, -0.5658778866732266, -0.33704204147319816, -0.5238136990253991, -0.46151482299389257, -0.5544324330487571, -0.4990382193307011, -0.239467514905398, -0.4409795039934874, -0.06290749100592194, -0.5781277821344515, 0.5115018657641255, 0.3675274720066245, 0.06998854247032692, -0.5575622798108277, -0.6723458226392334, 0.40045066052063744, -0.5875547737051813, -0.4133455290762488, -0.039647496276167676, 0.08111324353205666, -0.07545615689785773, -0.5861765779914748, -0.44635186759870704, -0.046555342340421656, -0.6271841456660582, -0.03588463717955611, 0.1879417375154097, -0.4049542112887634, 0.0932293977700605, -0.4295904270430734, 0.49788932350911735, 0.5869064806060063, 0.17471825205524089, -0.575523585245788, 0.10525318471364654, 0.09816844826046865, -0.3662523067130333, -0.12275441641740693, -0.17261630597768995, -0.30701436246654484, 0.058068718525897685, -0.29579358107847126, -0.26809325210031676, -0.2382116582244622, 0.10399680178679883, -0.37504592562703265, -0.12611025024803008, -0.4250130960207334, 0.20960738219213637, 0.026788655136071707, 0.3447499570003868, -0.2529932426989531, -0.5415351372548024, -0.4518599628308745},
    {-0.10670239221296333, -0.29064253556593955, 0.37423625172966685, 0.025012881456492504, -0.3949624715263728, 0.17424504081530293, 0.022067809002976373, -0.4812221996176678, -0.038617771006836506, -0.2984256102169451, -0.6541936226927293, -0.1857302064412954, -0.4651867750895805, -0.42187646717185284, -0.23782590996601527, -0.3890483290239166, -0.22132486131877532, -0.5803007417335324, -0.07290879733613492, -0.526998097339498, 0.47302054324823617, 0.30347908098899246, 0.4598508177384724, -0.5445671089025871, -0.4093061301602192, 0.3936207836735725, -0.6112153686935046, -0.28448092592836843, -0.24424418377025153, 0.33047637779869116, 0.06512674888064983, -0.33023160441007743, -0.5433490602781643, 0.028914137023680092, -0.5851468577329042, 0.03060287772750607, 0.45098257742547876, -0.35605359030148653, 0.2436043027642853, -0.16505340154282283, 0.5056109229464685, 0.6108720870435237, -0.04166572265296501, -0.6005500775118461, 0.026311135848726665, 0.11198008091206789, -0.5261550482093347, -0.15180220413668682, 0.006730657496485501, -0.1916189809675501, -0.11813662977981103, -0.06541200827856632, -0.004665065756666006, -0.33995050977004354, 0.3194039521472005, -0.20714319716415844, -0.10802202461955923, -0.3795757791241901, 0.23817140846556178, -0.24631527108076343, 0.3765670496866326, -0.47634584821158843, -0.32674813547866316, -0.3752644261556166},
    {0.10918876291244332, -0.08721629678848332, 0.6702330824145447, 0.03362644206707149, -0.5874579646164433, 0.327748565359829, 0.20529359076381518, -0.3734183769152493, -0.08560744635149954, -0.43650185281206466, -0.680951868529616, -0.38598315456036686, -0.4386039918818834, -0.5183391215765973, -0.4418957884803038, -0.3270168443041931, -0.3766224737845387, -0.6254575600354515, 0.025588250550809218, -0.5570974733944051, 0.39311968857353, 0.5421116104038335, 0.44187670629538583, -0.3270780595684149, -0.6688053255758409, 0.5895175225567332, -0.6337809996354133, -0.06274695890457661, 0.0440899271758497, 0.4312156519910594, 0.15839381008366768, -0.6252826884322538, -0.6777094147184947, -0.11337607444280275, -0.5736971312857637, -0.022278962865181197, 0.5733123747210951, 0.03399353645253052, 0.32243723207239366, -0.22451839231271375, 0.5073081290303394, 0.6598656851350311, 0.3141334599263541, -0.5693076811404184, 0.43370372196462464, -0.11882958216175298, -0.36372987327862843, -0.13292270550421428, -0.09385912653030433, -0.08186002419451892, 0.12232940780655115, -0.18740925401051617, -0.23169299681192887, -0.06849287229087514, 0.11934647505410773, 0.0366699331181574, -0.253579838984184, -0.4104715648938824, 0.4338235779138443, -0.08031782801828302, 0.33042400172004777, -0.48591999021640236, -0.36217378423460006, -0.5241942869841576}
};

static const float b1[64] = {0.5669243176406127, 0.5978153392526646, 0.5968649720855863, 0.6194514538096065, 0.6219284764227732, 0.6620985447481724, 0.4806799282257973, 0.6212437451250787, 0.6226444254132814, 0.6427101383100057, 0.636536011136392, 0.6109932195730582, 0.6235005861172987, 0.6240837857006837, 0.6415777782735054, 0.6160281924917037, 0.4823838777626207, 0.623311347931149, 0.6134912543607661, 0.6306565128017879, 0.6617062190979031, 0.6408446265317073, 0.5601505784010763, 0.6517256461457163, 0.6244811480240493, 0.6387419139211225, 0.5944112441186138, 0.6350815652008818, 0.6239120763627407, 0.5260612343923255, 0.6490849549816277, 0.6454117086154829, 0.6352348965705783, 0.5760049981369174, 0.6014262692311907, 0.6162596974882051, 0.5214815522941137, 0.6297834735396234, 0.5056096692250177, 0.6190101044912223, 0.6200355174436928, 0.6182084438211607, 0.660601823167504, 0.5628518649802582, 0.6182244648754612, 0.5028898261514262, 0.6153933419725232, 0.6305365975883943, 0.6118545290643944, 0.6287224764916419, 0.5598721013053951, 0.6183919264109854, 0.6154785081243745, 0.6014497315946483, 0.6380914848070073, 0.5754143728698486, 0.6426779372336064, 0.629601201132785, 0.6410680071142354, 0.6332566656910182, 0.6062536736803451, 0.43864128529965396, 0.6163582587913536, 0.6297785556689763};

static const float w2[64][32] = {
    {0.1549257189363735, 0.8171899977922817, 0.5558409475021492, 0.2845311832750548, 0.2325524226975449, -0.08486235273868734, 0.3283979603860692, 0.038999375845983716, 0.336331319494264, 0.7961057307923577, 0.7794410468749442, 0.7337014673592438, 0.6164413422167372, 0.3494493408172792, 0.5110145864090104, 0.26422006756511723, 0.5703781139027733, 0.472504157297685, 0.34571227920645103, 0.15192779975613632, 0.39877702613869015, 0.5101769044376887, -0.05372921016210388, -0.044423106371684756, 0.37334800425529935, 0.12138968678097667, -0.06637335537167117, -0.20520138762139767, 0.6818801367371774, -0.19234700992793458, 0.41608800608509944, 0.41415318261841855},
    {-0.1133471145753225, 0.7798463132404126, 0.6283325666929586, 0.4952942766653133, 0.25518307236094845, -0.23387761954499867, 0.20087335683910607, -0.0041434966570902355, 0.5870493581194403, 0.49195825131649606, 0.7229479603668868, 0.6383393577685919, 0.6532306049162018, 0.2475608928150737, 0.6567102393142461, 0.31145398763919097, 0.7494099495926833, 0.43005619689841595, 0.5835896178232868, 0.05189584294207885, 0.5308328451715992, 0.5032100299178672, -0.05162688824793847, -0.11663619847131933, 0.3658883512609942, -0.2149968689120702, 0.12719297734557813, 0.12136561588934404, 0.5301631744389662, -0.02913402963792992, 0.6474121859750404, 0.5444486393280684},
    {-0.2168487205262966, 0.3923720914880319, 0.35134757111996645, 0.4947369840390487, 0.0918804285362263, -0.11643027339143978, 0.4654925840061409, 0.23161094842291527, 0.5903213490419146, 0.4396258733672552, 0.7247685657717273, 0.4256862411548776, 0.6268059528379383, 0.6941661808557539, 0.39287565220302656, 0.3770725544357642, 0.6421247120563861, 0.4742336149505468, 0.7579592105011079, -0.1003220028846302, 0.6510328508982538, 0.40773122134945106, 0.3377032827330962, -0.03965855732580032, 0.44008471812338884, -0.1276787329666494, -0.14970495157447625, -0.010961208637521008, 0.6921171991028313, -0.20241306160783998, 0.7527650924871705, 0.39450983455359645},
    {0.058541013049959005, 0.5848624855177684, 0.345701155395211, 0.40271509670568767, 0.1526925355599469, -0.21708976320000592, 0.3414045307824369, 0.007139776430851856, 0.4853401065779309, 0.7903924896685691, 0.5572893756453485, 0.6328509109782835, 0.40250686310836437, 0.3696208521328026, 0.374329726248553, 0.49576474870111703, 0.3370816164545903, 0.3979346562294604, 0.6480816697636791, 0.014682446338091081, 0.38455875193550937, 0.30989267592683284, 0.1323702236653315, 0.03705407513935506, 0.5458058755767627, -0.19294102570548557, 0.17111834390814193, 0.06380095557643466, 0.7067296901384472, 0.15370498734042107, 0.6935174126714958, 0.14925133495923099},
    {0.1832957808009606, 0.5306449570716419, 0.5449933484905911, 0.4402126283482534, 0.04566878035463711, -0.2681309108810457, 0.11702178957704072, 0.28505608736696914, 0.7204303613928049, 0.7138568979119496, 0.6657236581954972, 0.5979885350037866, 0.6318314439384402, 0.3484934873114772, 0.7466088336480068, 0.34405546179920055, 0.43666145656654076, 0.715973457326148, 0.7389034080966043, 0.13403459324577674, 0.3578780208018401, 0.5842511255930382, 0.03953552864916733, -0.1496634444775974, 0.7976950020355374, -0.20070828400279325, -0.0711085904567677, -0.21837169725918287, 0.7232123833746892, -0.18290934321375027, 0.7555014565256251, 0.44768461391690434},
    {-0.25424582566887505, 0.793043163229694, 0.4540918724351191, 0.4464146566434868, 0.37066814327708525, 0.0813339568213333, 0.2522983897404694, 0.582787470767402, 0.5556689858881485, 0.6182617741886539, 0.8348128211042124, 0.7020593503037229, 0.2399370454998535, 0.4917682437865432, 0.6153576909868403, 0.6280814630213097, 0.5647269129286088, 0.6827923106946857, 0.694705616964242, 0.1530407693625401, 0.523744830703007, 0.6748788661730863, 0.3358564969513684, -0.15198780470199685, 0.6076598507887653, 0.09853853242210046, -0.2453407752677464, -0.13676523612018568, 0.4415882866711283, 0.1101181970523223, 0.5223128266002613, 0.6841567583231315},
    {-0.23235155906429922, 0.5275659304697271, 0.545011450309882, 0.46073979070358567, 0.1502362549312934, -0.06114942174788298, 0.36865516260405085, 0.35330258932117803, 0.7906558097863948, 0.46604113577536854, 0.38636016685144836, 0.754927290784333, 0.29341396580256773, 0.438125144535975, 0.5215015381352348, 0.2447114758521046, 0.3747167014690502, 0.614128945189303, 0.3735469587513413, 0.14412451675450322, 0.5262963788613175, 0.35284666467249826, 0.28189889524859263, -0.053718282928685336, 0.7417023882689656, -0.20546693537321728, 0.1456951595531773, -0.2622280545175212, 0.38289949335252166, 0.21070259135460576, 0.44446162561228736, 0.5711167549839615},
    {0.18158812633382446, 0.5000703037091567, 0.6815869727292402, 0.4717769161487768, 0.07551526621166398, 0.12444159732761166, 0.2498596501297605, -0.0135526163864317, 0.3438925617219827, 0.7082959552913161, 0.7545558856729943, 0.7705146579850459, 0.22351859525504209, 0.6251755889929589, 0.7752210184301722, 0.6456039261467129, 0.38161700460655446, 0.2707177659717311, 0.6238360054065838, -0.2279702347615207, 0.3548436339484875, 0.42419252154536424, 0.03283250585501458, -0.26184909037889936, 0.5854373641777536, -0.09509664173852311, -0.16550281448716558, 0.02598040074087137, 0.3110134950406063, -0.09543974541148814, 0.6684828892146428, 0.5361017840664775},
    {-0.12554965831858, 0.8155001081984974, 0.5183671595449867, 0.29880753003289634, 0.2175961055597567, -0.12285298158644742, 0.4014053967608589, 0.21545968093252005, 0.5993947011160581, 0.48914078187302706, 0.4023596023303992, 0.7021615664622999, 0.5042634995049198, 0.6162385260870072, 0.7557186967112158, 0.5426779917215917, 0.5040839746876935, 0.3102273362778009, 0.7936190071929494, -0.23523828345523112, 0.3194276282089804, 0.5935172249160077, -0.027864415673476597, 0.00531530114046334, 0.7711992105301185, 0.021743243917332955, -0.05703067877189027, -0.07393108959120602, 0.4784715736622762, 0.11220643685720022, 0.7506088830248053, 0.23862013154265932},
    {0.06701326003899984, 0.4499391000920054, 0.4520310988739667, 0.341473079461882, 0.08951019531749926, 0.1965069456801124, 0.17955961510270763, 0.4679683131164367, 0.37707820905607314, 0.841402561756776, 0.5364220587122651, 0.35042713330802694, 0.3915431170511219, 0.6333983444226678, 0.6367314242144667, 0.6179334543282096, 0.44097283738543425, 0.38621135134085516, 0.7456393586972135, 0.01907163082898113, 0.7359570080008685, 0.8180052179347207, 0.15893043347646985, -0.06680963804672257, 0.6617763787993155, 0.19220285970825526, -0.23821806078982946, -0.04923107097314267, 0.5263112515032253, -0.10859305386836327, 0.5648726420906655, 0.16932644804491145},
    {0.06134965576894699, 0.5138673342689376, 0.5045887101396215, 0.3324168832856299, 0.26629143489037255, -0.22990882948803332, 0.4735315943279017, 0.48808509660008675, 0.6645514815884731, 0.5163598103937633, 0.3785449526302442, 0.8013985660739251, 0.4523903824305488, 0.34504571881597196, 0.6967652959786992, 0.38925021289732165, 0.7433860940044245, 0.7447174321925963, 0.8148856822306221, -0.2164486140465189, 0.43983806825800004, 0.592024201398866, 0.1889090986800074, 0.11677174029563792, 0.5627836989395275, -0.07343982575100445, -0.004002095314871886, -0.017312182912298087, 0.5117701460076455, 0.024926910766450577, 0.34204774171041324, 0.1922369246387127},
    {-0.01816099051120451, 0.6703243738395882, 0.3412826232620972, 0.3779189149257338, 0.448632677473073, -0.10399030790376752, 0.5999660306809225, 0.39480283730748944, 0.6560259757973952, 0.5640747687852524, 0.5705775777275008, 0.7262362370127577, 0.41452640393152745, 0.6917677132314572, 0.6640145368033593, 0.6002295723873223, 0.5053520254129035, 0.5429502276360618, 0.5010118956685383, -0.12263807935958614, 0.7457898208054633, 0.7158182039000592, 0.26905484147308745, -0.23658931858677945, 0.6481632613745085, -0.11824256293410479, -0.1011777404068855, 0.0010447348804191853, 0.6579495445010246, 0.1889108292758205, 0.766998052604299, 0.5053432852738812},
    {-0.19115994929230623, 0.6439323768246261, 0.7910014793398383, 0.13391665382736834, 0.3412205503526042, 0.0840757368169966, 0.11841422501030585, 0.3812471854089498, 0.48198092962148364, 0.5179088264230522, 0.46529139084852095, 0.6452684004232829, 0.23011709409185624, 0.3930373299105651, 0.7952852041820916, 0.21096357765730694, 0.6308813480073864, 0.4443366540727886, 0.7334474831402793, -0.1764836866141933, 0.7230298405571491, 0.7338096584853614, 0.1019674724493893, -0.2773989059180025, 0.43970820958298334, 0.06328515415079657, 0.21163568053875093, -0.12569876376549804, 0.6828730623263295, 0.034929755381782064, 0.3094640916399961, 0.3331417552989842},
    {-0.19753705053730078, 0.48698996608497125, 0.5284184698684489, 0.17604249416118029, 0.34571057619986484, -0.26142147322945775, 0.3451830072428035, 0.12611803753763057, 0.6931698982503546, 0.48904608959829, 0.6857776329817185, 0.6843927860134914, 0.5315122145058917, 0.31450556866736806, 0.5800993406080542, 0.6233608165755471, 0.5575644228079165, 0.44310828591801416, 0.5351253367534752, 0.04984289614503796, 0.3993309748125888, 0.6786070625595066, -0.005007942207042036, 0.10256675609051408, 0.42205346602579735, 0.009098536910015973, 0.08680453417271639, -0.14793106196317649, 0.7731017837494073, -0.24490120041397265, 0.5170360575296757, 0.3738315234073464},
    {-0.005284025886315284, 0.5434737277678325, 0.8261237805483358, 0.20943592264397978, 0.3108614116769768, 0.01421456734073143, 0.41619442959445435, 0.04293813144259953, 0.4243454595420088, 0.6433574678949469, 0.8129812792468193, 0.4116982864255217, 0.24739928401177577, 0.47194222177655415, 0.7738203742471685, 0.4007290120705774, 0.48095073633131263, 0.5852894707166592, 0.5266075891597625, 0.01962708450683958, 0.5954067757352424, 0.3931215705276752, 0.13210451569995124, -0.2088281095243144, 0.5145049164204296, -0.0006976966264483318, -0.23378128836177564, -0.23399451186802747, 0.6479668860922781, 0.02325788664302284, 0.34826971276402907, 0.17711921759118823},
    {0.11723802568702212, 0.6650864876706953, 0.6008199239398699, 0.15387844370589412, 0.06644107183022878, -0.2367406218724014, 0.17365958338401077, 0.40692043773276265, 0.44481004789973105, 0.5075471253158907, 0.7736098331916552, 0.6155812494602698, 0.5158601360567086, 0.7034413537780138, 0.4641722751961199, 0.33700971274602826, 0.8452324422559045, 0.7196807537630026, 0.4603756789156047, 0.05219055464991462, 0.3315244309275391, 0.4179860966198753, -0.06603044026859467, -0.001333843018250595, 0.7185614452733136, -0.11422782653070769, 0.14976805914923574, -0.19602865590805715, 0.7750927282180723, -0.045856544844659355, 0.7598319879354446, 0.5217177290207949},
    {-0.09897222836015765, 0.5143256859873738, 0.48747282286859744, 0.37243515366593327, 0.3240502186354793, 0.1058849211321731, 0.40647038815674713, 0.10621830211744654, 0.6040618654886534, 0.4804571986199601, 0.6215779439741821, 0.4141097357731921, 0.5993220440495586, 0.5823769782984095, 0.6218106026909054, 0.25884880833218166, 0.8306516416022108, 0.537970124152885, 0.3929740512146101, 0.052227268127461465, 0.6604535491550801, 0.6099290635181566, -0.045151036790391265, 0.052523332198349544, 0.38597627753243957, -0.006676486143767154, -0.034178814246696734, 0.014371116387361972, 0.7713848960119012, -0.10606191324619177, 0.33781398857658557, 0.39601483013602695},
    {0.09387216392087624, 0.506957164086902, 0.3687673956786299, 0.3570541697714567, 0.1862226452956375, -0.2304190015860904, 0.4512508922390848, 0.1226355635088407, 0.8132876765373445, 0.6819431594315556, 0.7225403695383888, 0.467347304422731, 0.27841734843601296, 0.35885295755451024, 0.7930969340953072, 0.3907527535412485, 0.4655439887053701, 0.5229281788454115, 0.6963864875203954, -0.15409069944609907, 0.5646190206746379, 0.41516788306314073, 0.3040654258219496, -0.23997063548946754, 0.4623061384064597, -0.014755971060649234, -0.04793956130894359, -0.19038209809630374, 0.5969571239795266, 0.0691885357376903, 0.5579895302951161, 0.11723294334829766},
    {0.0662910264731866, 0.716271910457471, 0.7707615358061494, 0.2674850666478201, 0.21897618103876812, 0.0754708076003357, 0.31863354228898827, 0.3211018809778226, 0.7547364810344364, 0.668347890079695, 0.4882206594068398, 0.46802842547027473, 0.2715365001149278, 0.642409035837615, 0.4238763146312396, 0.5786577503234106, 0.43357761312182513, 0.7238149426493778, 0.7960222766636483, -0.051590689751364445, 0.6467326270435525, 0.6550391257679492, 0.3533498351935248, -0.09156256339627045, 0.7133146966661563, -0.24227956974156692, -0.26672872019191923, -0.20335005315382326, 0.6787538647146776, -0.2947811894925127, 0.5982615422014961, 0.4182346634933538},
    {-0.1487302459436282, 0.8284962831001749, 0.452907476558854, 0.35041485909634235, 0.21840799904219974, 0.10732641186261198, 0.140523517881047, 0.30414049241480107, 0.7403242358158086, 0.7178653843005014, 0.48415492948559014, 0.5086304176882961, 0.320881647194535, 0.5584035316579387, 0.7269293286758677, 0.5017655428712151, 0.5116470605074633, 0.5902714360203326, 0.6064122846892165, -0.1859026975037248, 0.7281104731364998, 0.7302391820449471, 0.0733537435282115, 0.11010999743011263, 0.6129232627553265, 0.02742798338038124, 0.009687890252786432, -0.08686260078018868, 0.4834448031852749, 0.01320730316368776, 0.5098377653056796, 0.2802553243867736},
    {-0.12692156391818116, 0.548276590223837, 0.6822585545171527, 0.5867658904371864, -0.048084171078467235, -0.027384022142443655, 0.3829735108540177, 0.07967413908953935, 0.7580547834780405, 0.7301991889833764, 0.5251927055841734, 0.6148968996625815, 0.5639106611032676, 0.5199631466831711, 0.3616419952782302, 0.3768995091238981, 0.6666622248209663, 0.3472546218326695, 0.8288130531110387, -0.23341537849390503, 0.6053372504830454, 0.7640875241022899, 0.366860628235439, -0.0072601976023492585, 0.7114597753155242, 0.14925859630792815, 0.11689013667672062, -0.016548975002765854, 0.41481748649761624, 0.08108892675329384, 0.5478627962099696, 0.34018177035824393},
    {0.054366290707338276, 0.7606319456084812, 0.7789920958258841, 0.624474009700757, 0.14239307374787175, 0.008973821076291636, 0.37187722816590185, 0.39858820446799686, 0.6644533721616231, 0.6177711264058343, 0.5568320284165756, 0.47384223683525956, 0.3585907577388049, 0.5555995747644369, 0.47698271003684445, 0.36845140047488556, 0.6582797910376713, 0.6319388911698867, 0.5527008305059328, -0.24181659510261863, 0.5675989362905471, 0.4827131601752242, 0.10313342010121698, 0.055129023627494625, 0.8174627105811162, -0.060314335962410384, 0.03821745594558851, -0.055996315809316084, 0.5426819760871286, -0.064875185401704, 0.5316428157777003, 0.10205034143243379},
    {0.005474144069404878, 0.6889903252520778, 0.4386048594342764, 0.4302017475856002, 0.38873402216994596, 0.06685498975018854, 0.45794119534171845, 0.16357672313934143, 0.5507438657381643, 0.44791005702857156, 0.48690110341818216, 0.6569789605236342, 0.5589398346406963, 0.4676542798306049, 0.5193972819501844, 0.620625750825869, 0.8186798767560881, 0.4663871279889291, 0.4971645007547564, 0.05706230928621496, 0.6788791469944441, 0.3567956516547179, -0.005039926917315576, -0.12064354080131784, 0.6058508492812804, -0.2798508993701502, 0.006363796467470767, 0.1548240538770948, 0.4625657228526596, -0.17414950364545886, 0.7299782878066227, 0.5947164373641675},
    {-0.17781499859891056, 0.6106343895765434, 0.4875051122071185, 0.3565131668085999, 0.10158958320984965, -0.14701171126796744, 0.10034325377353986, 0.19208782374277336, 0.5296727047403728, 0.4680704462096123, 0.4984700739692612, 0.7223109002599806, 0.3421196391615161, 0.2743933029880865, 0.5256870653248187, 0.6338717818843437, 0.7617288940162159, 0.5169164635833621, 0.5119949878032358, -0.027049860815318304, 0.518596194286711, 0.36478962029111567, 0.07130024633961564, 0.08779202564324105, 0.650730727517078, -0.23955502412404392, 0.14286256071067688, -0.174597245794057, 0.29664905705654576, 0.028383818758992468, 0.35861794464420205, 0.1441543459153952},
    {-0.07502551916386796, 0.6248157406876358, 0.6747426217207627, 0.21713871640997537, 0.1516043973434472, 0.11678364180909705, 0.5989527739419154, 0.07347256783905001, 0.5517142265726709, 0.5705402745588745, 0.7108407879595623, 0.38232961972555624, 0.38748193799979697, 0.4751478652349174, 0.6440681401216093, 0.49910043821594513, 0.463651647913565, 0.5631119580829614, 0.6702086586295737, -0.004158723810606921, 0.6118038069943765, 0.803553016659203, 0.10694742025318667, -0.03142544898759339, 0.7269952566672782, -0.06187153371715938, -0.13210327183608775, -0.24345029698947437, 0.6611264804309662, -0.24753431486114932, 0.29320503240396767, 0.5615774152803978},
    {-0.204847183536925, 0.4190846110306268, 0.3476015224055241, 0.5535621274109908, 0.1889513489638212, -0.22790364053575946, 0.36715852302495366, 0.24574173465593707, 0.4928970033067471, 0.6298275635932036, 0.6464651025643047, 0.57594250593301, 0.3819435014516998, 0.33999646759025454, 0.37625849424632085, 0.7018240218734256, 0.6413564945422507, 0.652764250439294, 0.7932742607407123, -0.25819491364667563, 0.37432723017300507, 0.40684840447709486, 0.15903191565209343, 0.12328358829395833, 0.635682009332628, -0.15762259202907478, -0.0875541523508846, 0.010560776856060498, 0.6219011637089916, 0.17961905572317763, 0.4541130054736034, 0.15268712846706878},
    {-0.26434091669870435, 0.38961336202890845, 0.5061066390298158, 0.4472735768024949, 0.026180588944828137, 0.008639949720097287, 0.15462618881976986, 0.4574413982937264, 0.720612370216144, 0.5765984434402417, 0.6214534240659018, 0.531890371986652, 0.6513529092392266, 0.5796648128794369, 0.5246626292287166, 0.30845008622240616, 0.5975018950200806, 0.465667526573684, 0.38169963993033856, -0.14313222742495366, 0.5957145082552778, 0.7846181519902793, -0.06638582189776018, 0.025094259235586433, 0.7514892887653624, 0.09298663094493445, 0.11711407151399933, 0.13366000998575708, 0.7899349870492895, 0.17513192302422548, 0.7403387420518869, 0.2870683251174361},
    {-0.21280206200989696, 0.4529667491357355, 0.5741360547977594, 0.19537384399327914, -0.06214548289347004, -0.057556797221671986, 0.5246438722590431, 0.16169806230152245, 0.4585036572692921, 0.652007992909735, 0.3835233918207925, 0.7540310082195059, 0.5485228038305038, 0.36366014272692776, 0.6446771024251957, 0.5341447263057418, 0.41478564860549305, 0.6608507466794039, 0.6693253119669047, 0.09828706688363541, 0.5514346582620042, 0.6931571555062906, 0.13287920945079867, -0.14228069233402182, 0.7083661228744701, -0.22600025482886285, -0.14702359468436862, 0.149906817154346, 0.29875517406085805, 0.18008478374477424, 0.3341565806291056, 0.09338204296466814},
    {-0.25401772699520975, 0.5097197656000044, 0.47860761063999074, 0.3624344999987414, 0.3072565976513173, -0.001852943840325189, 0.1805230693043889, 0.06808944417030705, 0.37816124798903905, 0.7395038963268583, 0.6147786629102194, 0.6120270530948599, 0.4389705867474311, 0.31224140542700846, 0.6905177213190055, 0.2039247312051638, 0.41440765275823754, 0.6427714925066784, 0.7548237792021247, -0.14959715346342656, 0.6771494959453088, 0.3783408714069525, -0.0020244641787833173, 0.08934816343415652, 0.7923483564208277, -0.22157226659845716, -0.2721967161759631, 0.08040054575764696, 0.518288722782287, -0.14656138472436894, 0.7482465295983272, 0.07616148562221918},
    {0.012393259547246968, 0.5241202232036367, 0.7821035139303542, 0.6442523272837948, 0.04555769947021754, 0.021723660378633835, 0.38158487154997217, 0.07062476888108658, 0.6351338135142396, 0.39558636481582593, 0.4823456715023191, 0.5934117957430861, 0.6851157213697993, 0.3369164366494268, 0.6265618430968376, 0.5100507821056868, 0.7964309878076333, 0.6091575352057398, 0.4309475855002095, -0.07664966012534896, 0.563472979415003, 0.48477376577110026, -0.02388235820734748, 0.10303025280279339, 0.5890534430392541, -0.10585640687351579, 0.18300541943437146, -0.17890162278727692, 0.4365122168437469, -0.2341194126401737, 0.5508971376811325, 0.3272457609709037},
    {-0.06723366078347569, 0.6243376320184676, 0.5457840034320406, 0.46423006595054234, 0.011764791020893813, 0.009446166700227736, 0.200709570358776, 0.10445349284699752, 0.46691920630427697, 0.3916886462830496, 0.5060212762992976, 0.6345069193995874, 0.5398862150598788, 0.7250309783836218, 0.6498722370973911, 0.43931712973987275, 0.8146137484366129, 0.8008989934835733, 0.6989791193477997, 0.038079842161550026, 0.5842640667291005, 0.39850763949208373, 0.1356896912530594, -0.14377573360747645, 0.651199613768474, -0.06896620132852059, -0.19875251075548087, -0.15368185709973173, 0.4938446252084995, -0.14652619913625692, 0.7082089341825759, 0.6848158303375068},
    {-0.03294132226854973, 0.5824666068901244, 0.5290375035206419, 0.575869773168926, 0.2814814332760739, -0.11997016357280126, 0.13679994124624137, 0.33147922273972535, 0.7876650630683999, 0.6396287426131525, 0.4917892914820993, 0.4909226395311436, 0.6111569380795514, 0.5677779791780289, 0.6219046788307047, 0.4339420917751724, 0.8463477520853272, 0.5071309175306645, 0.829360636275559, -0.0008048166206010688, 0.42311805520989715, 0.4697658666370696, 0.029916689662941653, -0.20005831245533195, 0.6194389797616187, 0.15280255658917402, -0.22249261461600228, -0.1048263299503786, 0.6515643532500135, -0.25647503644923514, 0.32667016110151287, 0.5134393567741659},
    {0.014688969510549328, 0.7791763469431768, 0.4693725243015063, 0.2095324849832435, 0.3976838894466622, -0.18097406462492727, 0.5733796678050742, 0.19442164086317665, 0.6034760431277771, 0.6780150002127502, 0.7989381537887633, 0.8174428446746396, 0.42683032807964405, 0.30998344411942014, 0.41054681892239653, 0.37003867395485057, 0.5366305660204924, 0.6284732865616033, 0.3855656273339428, -0.07934768520203418, 0.3698510703609115, 0.6870843762269829, 0.4225992502172664, -0.016888069680751367, 0.42569373020672174, -0.19961565391301958, -0.023755483749744358, -0.25012897810702744, 0.6385203407070021, 0.12947548017372607, 0.3066195034569623, 0.32031029523276144},
    {-0.027383668716851505, 0.42225952869483563, 0.8105394624515104, 0.14788157926932158, 0.05934851615910537, -0.008204194963559633, 0.5223672701775579, 0.4785508242122029, 0.4760954535248648, 0.3887172086639571, 0.819535475361529, 0.42702619306448875, 0.41961285889102207, 0.5674395968046466, 0.7877616682009524, 0.7094791129757025, 0.7369925825489766, 0.556485613685654, 0.49865249036085574, 0.08892376319235976, 0.7301275186484101, 0.33971358581330446, 0.11340317190429253, 0.1258314050299715, 0.44153443037238743, -0.11429104427388477, 0.12115656563911026, -0.271285469093299, 0.6177991610649503, -0.12153301810424277, 0.7770393748834294, 0.2699241458346475},
    {-0.15623751132310795, 0.7787982720939554, 0.4430037077950619, 0.4794797858826452, 0.19408359639671, 0.10714323315566264, 0.4427452657097797, 0.44154636646644885, 0.6850254607075804, 0.690108698010402, 0.7039035452598916, 0.6155718391272254, 0.5305048821480997, 0.3318652302453691, 0.49762576021626226, 0.28294289751465407, 0.7661151849018444, 0.33468659894765285, 0.44981504887658247, -0.19449450851113465, 0.35379276517548897, 0.4883554155541077, 0.32657503169216284, -0.08039523525840717, 0.5071777042502292, 0.05954415938180521, 0.18844358737594527, 0.15298509212872421, 0.7823821349043021, 0.10847235496242881, 0.550601719778072, 0.20718688049437933},
    {-0.16373105611352912, 0.7470146860084804, 0.7398963523396278, 0.3589643152015516, 0.3909785768379399, -0.27913791013252265, 0.6280684394229012, 0.22959299932193197, 0.6681679684626258, 0.478702114297092, 0.6582164539109494, 0.6570386726050204, 0.3724633319917383, 0.6349851171383425, 0.8396655933548313, 0.5326219650608697, 0.40488355661275555, 0.590654520331656, 0.46993136312972617, 0.13625106849358387, 0.5180761427540834, 0.7490220235911053, 0.08619065494159141, -0.11019264925723363, 0.40760226789541615, -0.2321446948266628, -0.14727520056177482, 0.004870738600087275, 0.7349768427666987, -0.2566512555752761, 0.4822842634370304, 0.5197763192588261},
    {-0.24978639104728956, 0.8192701022942653, 0.41459161893800367, 0.6740319336257381, 0.04801508541519622, 0.041197788918782764, 0.3036863426645089, 0.24305837032007566, 0.5375447744713387, 0.5042078839835338, 0.5605507462301251, 0.6594523441707534, 0.5534854127602213, 0.6866023904504384, 0.8000887967653464, 0.5921375331546329, 0.5306709338829917, 0.43732328697131223, 0.38665194966901695, 0.16264389023208978, 0.3743519217883468, 0.6017922061285513, 0.3863026908215204, 0.05748874302845266, 0.36038431392121567, -0.08160710717499231, -0.19495732459050882, -0.25877000819713813, 0.5479011871858221, -0.025490992369168613, 0.6111706374203979, 0.5207821557257947},
    {-0.2593612194790872, 0.8006452064026476, 0.3766528117257324, 0.20988676485875749, 0.05334593464878065, -0.11718844913638335, 0.10579742157423283, -0.01895856784786978, 0.5378351098860907, 0.5681614071651916, 0.5098999110536616, 0.7196088793146199, 0.3036714094745685, 0.5194454939112698, 0.7002691994659331, 0.32499527150095875, 0.3777334205222818, 0.5234883264508644, 0.40583609506360363, -0.1437533977379245, 0.6331577098610565, 0.6601756816472655, 0.30080572503876263, -0.15567070634624025, 0.6346975051521955, -0.07892794187468158, 0.05265616613292763, -0.1089638966669764, 0.6613293402218011, 0.1321052591695653, 0.3276716154140991, 0.5416962390870406},
    {0.12026340211802994, 0.8475051338730846, 0.5418474109838747, 0.3542759443792213, 0.2641580006161077, 0.12985521932219665, 0.3877878021336883, 0.2261546679942799, 0.4637566672667501, 0.6613033710474604, 0.5406110912634468, 0.7531529550953019, 0.25946953148331464, 0.5866639715398289, 0.4238063207862784, 0.48998981652335005, 0.7386366457566574, 0.28819332692840655, 0.34810115465687064, 0.021176366164256062, 0.5253998402302529, 0.7964023366451458, -0.08060483513476589, -0.1828913098961312, 0.42322507694190886, 0.1759220908190269, 0.04036866117508267, -0.1885888448228221, 0.3695002592226906, 0.19507618376749047, 0.7272863530839105, 0.2098620828855323},
    {-0.2610703077561268, 0.7778016481345921, 0.3391898978419185, 0.533145105749051, 0.19693147535457287, -0.08525721990703665, 0.5340249142876862, 0.22387609648161724, 0.6022413264498503, 0.632341249383808, 0.6956155755317225, 0.8185188491589568, 0.4847744774606085, 0.6678727637586566, 0.7805601195677223, 0.5371322373090266, 0.7212491821317003, 0.40635848615752923, 0.7461772992660243, -0.08936199337877482, 0.8058309434763165, 0.5832701802952414, -0.012442063186342755, -0.12142587207911104, 0.7981649144100857, -0.041041644675024753, -0.1241256651032926, -0.18267300731489586, 0.7700082762362309, 0.18980912076849663, 0.724758575860396, 0.34422056638323845},
    {-0.07603055184291495, 0.6275837172705347, 0.6697785056101, 0.2018988688712439, -0.026592794405617463, -0.24059769847201926, 0.4902684244168054, 0.3142191588659672, 0.6291091160410588, 0.7460859446421453, 0.635560090203644, 0.6404800652748366, 0.41250716717442015, 0.7172824603371594, 0.834499618789656, 0.3080378084805218, 0.3877144167365876, 0.673927902750579, 0.4680948310526062, -0.15590999464033273, 0.6153028149975676, 0.6417419192283895, 0.177411718255004, 0.1283164619148618, 0.6644126586402026, -0.0953731744223755, -0.09850102674209284, 0.028896421985589525, 0.4266420713011876, 0.15132549921310842, 0.688361548991284, 0.4156021712669113},
    {-0.1466341043848212, 0.6847084991274122, 0.8375060312659881, 0.3360852796256364, 0.28445950484795895, -0.08775144518372528, 0.47373200527150156, 0.3612039126815326, 0.6103533345155684, 0.5852300018420873, 0.7713840599703645, 0.4941836970411335, 0.5053993528949637, 0.38091303750045125, 0.624706697585328, 0.43941341513413446, 0.529100589183447, 0.31907952693906483, 0.4421273603073733, -0.12362276322684612, 0.48447272556373117, 0.3504348831023751, 0.045179541081924735, -0.13261090677017554, 0.5242436676602263, -0.17928870873130381, -0.12721912908797484, -0.09762324800352093, 0.7841033305196734, -0.13599326857316804, 0.5880573415274106, 0.17917100360021335},
    {-0.11000318132727505, 0.7709959791930664, 0.4200002607261316, 0.5341850378644003, 0.3363476329396704, -0.02677349011859913, 0.3326210199876655, 0.5507803398844195, 0.8323412479709517, 0.3721582704658162, 0.43657036828750645, 0.5470240453087272, 0.23851259727993357, 0.5943794575294366, 0.546517598801541, 0.33411294717084294, 0.6497649179662057, 0.5125164939458455, 0.5828105601605746, -0.14061535872309575, 0.41488808603079413, 0.5009982923469974, 0.5074659087958366, -0.12299921938791303, 0.8266971495087048, -0.2690431751727888, -0.06527960068347018, 0.1292053861748161, 0.5282039887111277, 0.06399571229041802, 0.3311852432655609, 0.40437511125225983},
    {-0.03897372700201314, 0.487661493161717, 0.32381707137327964, 0.5527171896175143, 0.10985872439876322, -0.2558722724084818, 0.41412616495442556, 0.2754722057838105, 0.6332534195461065, 0.6224998798867292, 0.48893469961972336, 0.6594072014346313, 0.39958546816605156, 0.38059458467695795, 0.7052250318048051, 0.5379859760022049, 0.8143040941665931, 0.5603876992442377, 0.3992543469703402, 0.06981679089952345, 0.4922478820785088, 0.6885345663080995, 0.13881023438371395, 0.0641458774490915, 0.5131253451145603, 0.13059432411069963, -0.07621567634166104, -0.23707364619975219, 0.37577694804837297, -0.0029793758020249172, 0.6113885930031736, 0.3487382663804273},
    {0.007514169434750362, 0.5084431197937779, 0.7410510136998849, 0.39131872772873266, 0.3443933410294615, -0.11971654160035651, 0.128754178541952, 0.056329886493563325, 0.7302866098646524, 0.45364811448339676, 0.47755542990948124, 0.3839076299847005, 0.384487752112091, 0.5633729219472579, 0.35639670013899116, 0.5178021259169716, 0.3949745874737262, 0.24048485448400586, 0.6849415822706568, -0.2052869846127721, 0.6674890464432647, 0.3469869831261145, 0.06157668079835313, -0.23546055036011743, 0.5410284979325453, 0.07774324472257824, 0.10307331875884147, -0.24582508049648796, 0.31431541664567014, -0.21254836086389145, 0.7981380489790875, 0.1456767093276303},
    {0.05339810129278343, 0.4304390991400671, 0.6989435430062814, 0.6362748997177418, 0.27455295839141314, -0.1446359795869284, 0.2929601602190505, 0.5500145373542937, 0.7531356711635893, 0.642984048705646, 0.45085312941352457, 0.4499127410819397, 0.4540976139266653, 0.655476644807171, 0.6257205216825334, 0.48562278973006984, 0.5197740587681365, 0.6150935970203061, 0.5207610713284229, 0.017270622353530947, 0.7928892917031957, 0.7029057684901584, 0.20989823773100166, 0.014623555439100858, 0.45607381238181777, -0.23215038706998753, -0.20648290659660973, 0.057494039483477616, 0.8134689544488019, -0.12050030076731759, 0.6683717469207328, 0.5019688290924791},
    {0.17744884722103044, 0.8182920995906394, 0.5678873499637759, 0.43580552940360445, 0.04570324072519189, 0.17649653299366141, 0.5538030704619743, 0.18073505245263027, 0.6828615755747871, 0.5979238989278429, 0.5622999231228344, 0.7558361269373791, 0.6187875304859846, 0.5581701851004817, 0.635950093005596, 0.3298398597600506, 0.691982690216678, 0.5728405176326575, 0.44441360980753425, -0.22692375095381245, 0.46566616254897153, 0.7191015297272653, 0.15384377060485638, -0.1088678855760744, 0.5731713598296256, 0.18071623523888355, -0.012083403077725414, 0.00043194625853756186, 0.5244363528810003, 0.10692414224870686, 0.49534883039607597, 0.11033465389668355},
    {0.07376485623742765, 0.38046587406924476, 0.8257201367239754, 0.1980166512144562, 0.09305794311333687, -0.0003016175430276178, 0.4344297129335512, 0.16157892570051605, 0.3899372152360113, 0.5682998099493574, 0.653838217864246, 0.43943863546583767, 0.6046547305006886, 0.34254634024489716, 0.525994771677811, 0.41643501129957433, 0.61955989058864, 0.4900934013792974, 0.8276626339584952, 0.013380172018544129, 0.8389112974370125, 0.4865107330403108, 0.015314967149654503, 0.1958196808644502, 0.6671155853287614, -0.1916296328657844, 0.0998267796942687, 0.12102255497379018, 0.29032838402563915, -0.2916906207302097, 0.7409031450707564, 0.35657125898474706},
    {0.04949659074662823, 0.7422878439355941, 0.36333510194943475, 0.4449662764540752, 0.2929645416814992, 0.1652342446921654, 0.3488437209662268, 0.4303440794121515, 0.3599800865560428, 0.5688527732910421, 0.7001791503741188, 0.4352339521255211, 0.5661011129965055, 0.29694052503134716, 0.4008151086531142, 0.6253028172842345, 0.8370794028493755, 0.6048503963991595, 0.5851474832535073, 0.11521738051392634, 0.33353877311045005, 0.6192361201549965, 0.2709162811816814, -0.23560856779107142, 0.7387938780721043, -0.08257245972428627, -0.14315777424352208, -0.12607108855922494, 0.4380510449452631, -0.1810101150173211, 0.6046882716172624, 0.33812177161693535},
    {0.019270711482873775, 0.6178239464235025, 0.6057328841826856, 0.5302705665731474, 0.36125232478827507, -0.12629211224328873, 0.347103049871168, 0.053845681148913575, 0.7020765545001525, 0.7406184281099825, 0.4863025872533609, 0.3905437322620828, 0.49306677819002653, 0.49958350600439844, 0.7885527454649544, 0.6257705328887144, 0.6260132532877141, 0.7037397002150884, 0.7814775684993049, 0.05937618783139892, 0.43397224818139213, 0.36330379019761205, -0.0005405551668312389, -0.1091624933036396, 0.6983002942279739, 0.1743888069002105, -0.015739286678817424, -0.1116510295059405, 0.7249816007435118, 0.19048542833844997, 0.41461975950752616, 0.4627658580809464},
    {-0.04625464097802122, 0.650976999038259, 0.4998615165074987, 0.5934898427952413, 0.2619110732263242, 0.21605908719466094, 0.5166376751252477, 0.43297131787501975, 0.588734038928522, 0.41412935890540264, 0.5479187416572654, 0.45402179153857236, 0.6406054726294754, 0.515933878053262, 0.3576987142109813, 0.24860951658406436, 0.8063366334181502, 0.4698551539635498, 0.6295085903871417, -0.1126394910762387, 0.5873882749246448, 0.5389530035232537, 0.3422445343241154, 0.0635475643044954, 0.6856595998557701, -0.060042796219818076, -0.15674869019962728, -0.14199281541338118, 0.3416858958827339, -0.028326525440689244, 0.676195903416039, 0.541119711312067},
    {0.04243163180270308, 0.6809781854725742, 0.7608199634056302, 0.4511441640149958, -0.044102027203906456, 0.1559289675093182, 0.12250388354129571, 0.32039161863875115, 0.7861269437966396, 0.4508752288183077, 0.5714000532598412, 0.460880903995129, 0.40639834031968297, 0.29323241106983194, 0.33726789299912885, 0.2751321695630589, 0.371985273358829, 0.539944926835796, 0.5699705607747009, -0.25194902697909655, 0.45622596885159505, 0.5012973709536939, 0.3410830201207795, -0.25928131219902417, 0.8036461701459838, 0.07905394818911546, -0.11236847318663701, -0.03721410960158058, 0.43295161332988724, -0.16012811104563432, 0.3948705640117224, 0.2978844826931014},
    {-0.2637776705911784, 0.4287579776790812, 0.4471288688551358, 0.21191652890818943, 0.18672767569119417, 0.030930723893558585, 0.2511649855760119, 0.4004043527635372, 0.58094578284491, 0.6268625238848141, 0.5540311209714243, 0.460800028490399, 0.49251967780781236, 0.7011816013655726, 0.36536522268488025, 0.6857920466424583, 0.8005017059354913, 0.6237525323818927, 0.6795643181871487, -0.2478336820881058, 0.6191649584730979, 0.5035695105638657, 0.1232459628904772, 0.012946030716721912, 0.6926190438959343, -0.2501294319242252, 0.15097550457388145, 0.1872001027428026, 0.4044958902009426, -0.07658716512096994, 0.4493148236055254, 0.33934339266241387},
    {-0.18129832582580258, 0.4791270584147829, 0.5717013983682291, 0.17571540588769224, 0.3233408790061285, -0.13457515867514108, 0.3028299123585883, 0.4246060767688296, 0.45713456193350693, 0.7295625884422698, 0.6619140069095734, 0.4712704470890492, 0.6393399745300485, 0.6568833601567922, 0.676051069576547, 0.42625641760230437, 0.35938689569489685, 0.5288177916287001, 0.7397060779843192, -0.17654817611018397, 0.3592148036775952, 0.5740239354021508, -0.04115596759571513, -0.026463577000009116, 0.5663248122019998, -0.22613116124313734, -0.15615780817117056, 0.051998859600317325, 0.4406574567025612, -0.09386391860872573, 0.7189497813877115, 0.26506038900066636},
    {0.11630939398874979, 0.5578541701191195, 0.7963346354775511, 0.6128516612601487, -0.06196874242152322, -0.1470271649661503, 0.47535298137654597, 0.383214359891799, 0.5625938341113078, 0.6037519874897739, 0.8283819391241629, 0.497351820978021, 0.6515084606869491, 0.612064829026385, 0.5335385481722628, 0.5680725340091243, 0.6466207928553965, 0.3827714615219541, 0.5480716901883375, 0.10629306290664373, 0.497154371767517, 0.6662827565102858, 0.24713681883211494, -0.1715315478730753, 0.36753908976263633, 0.10562097349765275, -0.05570337773399668, -0.14338012157360652, 0.6145650714223851, -0.12211032705271302, 0.38805722545659027, 0.17757279010800464},
    {0.20313340988023268, 0.8104627571707131, 0.5217957415553937, 0.22495642437060004, 0.07669188104949631, -0.06324595621696606, 0.4302243655343331, 0.28991312964368293, 0.5470955541003714, 0.6610816633893921, 0.6649003917376739, 0.7464806427266951, 0.5894907433515317, 0.616696750484833, 0.3958511177682883, 0.4762296465674639, 0.786514799605728, 0.3024197690963719, 0.5169955307385753, -0.1630918528411273, 0.7785767186747958, 0.6586564576994787, 0.07980730566921042, 0.038984372324285865, 0.5121956001384513, 0.16077917692415566, -0.2801426584680095, 0.053700934923989675, 0.49914751689414655, -0.056561689846937456, 0.6671222255758765, 0.14838012471922032},
    {-0.26301432156521054, 0.3974652002423412, 0.39953922377759604, 0.4480569668005485, 0.45266683415123543, 0.03843102956899105, 0.2613789382313251, 0.22854729929658493, 0.6694205096474473, 0.6135032255478184, 0.5223421618799388, 0.6196288977944943, 0.19912553724123572, 0.7046322397008892, 0.8078191853677589, 0.31032546292408764, 0.828447585662787, 0.34195202445116607, 0.5301910544058078, -0.18643915001840852, 0.6188641328495761, 0.34254304303455096, 0.11745744209039664, 0.09806085452906735, 0.6481866826340174, 0.11623381067729176, -0.25947825664527335, 0.10352080891433733, 0.587583313319798, -0.2649978833616255, 0.4148707026599679, 0.45173656494052555},
    {-0.16546336916716473, 0.44654751015587113, 0.6058495883218036, 0.5376361794827997, 0.08527275797220935, -0.11555077731685304, 0.24730393830719097, 0.15221977651608182, 0.781893960578385, 0.5879517926752471, 0.6166360718351314, 0.8043837978970589, 0.24961165362340848, 0.6166272880024395, 0.3665028527047272, 0.39226344463024276, 0.6467087277664386, 0.6803689351813371, 0.5334856366401185, -0.011448391614751294, 0.45022176359791855, 0.536087146106515, 0.13803654914717362, 0.09372715912802766, 0.7943910752065243, -0.2899598154214525, -0.29070287318260274, 0.06603347405058137, 0.7688851143517839, -0.059945754710391576, 0.47293570181743033, 0.15149181575569406},
    {0.02355614535850645, 0.7673772615853965, 0.39610315041922606, 0.5789036778790981, -0.04026796248787914, -0.02842463854945386, 0.12449239268160031, 0.06295670980935175, 0.5615391181095036, 0.5450539799009777, 0.5870496752182027, 0.8070645679299634, 0.3872104366734002, 0.513678510522092, 0.7734712965565003, 0.499078963328558, 0.35172292491665075, 0.5805558904732526, 0.6161700763067658, -0.0949438955110152, 0.640862658272321, 0.6690977281148316, 0.15189180304029243, -0.1936060069929935, 0.4821795755622923, 0.055615860023159464, -0.20435433577349224, -0.10050101439942748, 0.6812438328103717, -0.2451233129560547, 0.43885768934827885, 0.3118159615271631},
    {-0.11182391876760445, 0.6840103467038755, 0.6707625904145257, 0.21908325392132927, 0.2979794035136384, 0.055554569160573525, 0.181199521561716, 0.4293098499400262, 0.7160930505825787, 0.8618516355785101, 0.700505802585758, 0.3776879239665686, 0.4430256627286189, 0.5295675731731148, 0.6048729893402861, 0.4866232823676809, 0.833189287620972, 0.2941818855186294, 0.5554831655624544, 0.1728451689297061, 0.7878542563552301, 0.6557234729608538, 0.2158125257077208, -0.15619546306260784, 0.676523127938297, -0.26761606844253855, 0.03901581946068283, -0.2583093916020681, 0.7845526635320877, -0.14480024626208976, 0.5504812246703669, 0.28119897659330323},
    {-0.1883573934797437, 0.39295915187477726, 0.7253678250760025, 0.2693550098486444, 0.22743729084907013, 0.09312251885914072, 0.46651093919291925, 0.29946361596371807, 0.807886202540258, 0.657329392895307, 0.8336708654805861, 0.7554607474652049, 0.5991986636820871, 0.30235007086754406, 0.3926003229368974, 0.35872480348065894, 0.6400189909034291, 0.7292266762110959, 0.38954188361129327, -0.26558210428429, 0.7845383438899842, 0.6896608387985851, 0.0031789157603694554, -0.10613138245078434, 0.5913702894615253, 0.11412329267140471, -0.17264671875547455, -0.2271974934678868, 0.5833516068066664, 0.005175052201129391, 0.4875692176483599, 0.4144847022973556},
    {0.20499803086792315, 0.4339710524920648, 0.5164324474302935, 0.6431559288456068, 0.286837441136495, 0.20735515014921144, 0.5694686715375509, 0.14345625602528062, 0.37565248914064636, 0.5700856273721018, 0.36888748320521314, 0.4741204359975585, 0.5994599863305559, 0.6131186845849771, 0.8395826216738345, 0.6417524437837906, 0.5197441320159611, 0.6625035235521971, 0.5612162196060406, 0.015060114357978655, 0.6061900501361025, 0.7678487260942461, 0.14873733544898904, 0.023178898333496668, 0.4228454010689245, -0.006015109241606743, 0.12543399479428793, -0.10019747212763447, 0.43931456476445413, 0.049286647057222216, 0.4748698935487014, 0.2185961455437818},
    {-0.0037355174181169875, 0.36715658165200804, 0.7231734903929705, 0.3395420823652864, 0.05982129680603959, 0.10955357528579196, 0.39321553537904613, 0.21944713597332463, 0.8215003294106995, 0.7736763004747264, 0.7454024065793783, 0.7947413709646142, 0.3769444742734075, 0.7480123428384302, 0.7168339087080858, 0.42718245945070465, 0.7917875223035272, 0.5498519437377152, 0.7587425053947132, -0.29205431171280744, 0.46931541859563214, 0.49569274583872236, 0.06465046672210807, 0.04136115725760462, 0.6517794051493122, -0.2069189856700649, 0.16318166025310438, 0.15043061009808606, 0.7776703498860319, -0.08484019139956253, 0.3789345300615005, 0.259981282339043},
    {-0.19059107778411433, 0.6666558352819808, 0.30263253866873563, 0.22056931686255113, -0.08536163102781717, -0.2352859755874673, 0.4935222576855293, 0.21606437876615794, 0.4553840856677377, 0.620150551874793, 0.676074771428582, 0.3728323073576455, 0.3389895005690254, 0.5170790346480908, 0.6171541086961547, 0.43927981737970045, 0.5181802863105528, 0.6370944960916142, 0.605889850465443, -0.22265953016681234, 0.45744789006105935, 0.4148212752240704, 0.013578043927587755, -0.043854224087290526, 0.5415943640648706, -0.020801945383801434, 0.10271159795194369, 0.139632099719162, 0.7358470259141441, -0.16143784191880745, 0.551271604393332, 0.5556110778231599}
};

static const float b2[32] = {-0.04068898114370412, 0.5643402667670725, 0.5777468760282451, 0.35476877033406196, 0.18754249154506772, -0.06149651303789918, 0.37196015219651696, 0.2785449574020261, 0.5491420608654751, 0.5457296836728049, 0.49701098015276574, 0.5622626471316028, 0.4184590762558681, 0.4580421640001646, 0.5353015747534288, 0.4440881699629841, 0.5578829611192543, 0.4470951303095739, 0.4935192070959678, -0.08297479837354609, 0.5651392470932451, 0.5591865278586025, 0.3011926548475787, -0.05806482812303456, 0.5114732926238768, -0.04381369721690962, -0.05111454360377749, -0.049642568208013035, 0.5279906465142002, -0.05938651450399361, 0.5066447128856163, 0.41878023377824525};

static const float w3[32][16] = {
    {0.20133032569346793, 0.18634798226564311, -0.20843964708317156, 0.11366239808740636, 0.1075285742572372, 0.3671530904039266, -0.269207860588375, -0.27343370338170825, 0.03520889496336924, 0.16013714097204454, -0.010418151472154049, -0.23085482131093674, 0.1729110238162946, -0.13978324511856505, -0.2413437508776388, -0.13897236144390468},
    {0.3153252186952721, 0.13282197763443337, -0.1524010461505385, 0.7473499713033308, 0.33012167314453567, 0.36216573180901945, 0.8303162887571973, -0.3071990680921023, 0.5786339593172145, 0.4485744095443056, 0.7773125568562875, 0.7669156272875012, 0.8946456358134303, -0.3676657327754564, 0.5936671784108309, 0.772768965660752},
    {0.9266201741287241, 0.10367684993604478, -0.3303061844373971, 0.3675274840818036, 0.2924603443410373, 0.43915319685105775, 0.9546900272149044, 0.10546447730129703, 0.23893538847953893, 0.098449516701797, 0.8617311549416797, 0.4855464076460559, 0.5916276790410382, -0.24298674269318418, 0.8762899151878366, 0.643794890590564},
    {0.2627236224987062, -0.031781300579406584, 0.11166124574601465, 0.24299845838241874, 0.8668340271691178, 0.2506438515889812, 0.34445435134803637, -0.08079998736367487, 0.4373891853488429, 0.31518199406631725, 0.8739407595817497, 0.3106125366683142, 0.6656458851276368, -0.05144265998588771, 0.4469495337878642, 0.5920588999760221},
    {0.11826207758778312, 0.13581091115470975, 0.16414518529410346, 0.40120885975969894, 0.4742254830048596, 0.5570212660783952, 0.4508076442368405, 0.23431437532962346, 0.4723011252619846, 0.4647626860366237, 0.20391833043192328, -0.008063431508910203, 0.24364627919902465, 0.2214390380555379, 0.33920129622987766, 0.17562705380868934},
    {-0.297994011956961, -0.0517895194460913, 0.28273965184440225, -0.15462123045870357, -0.10814120696174302, 0.043528447578385684, -0.1666429670865245, 0.07976232319414844, 0.07996386101757315, 0.10637305414248933, -0.13791966856668542, 0.40231613679271894, 0.03289665336985084, 0.07384731648334572, -0.10608576963608918, -0.2948033982661698},
    {0.577557119818745, 0.24205884138621253, 0.20735916840420915, 0.20469052333943275, 0.39051823769764676, 0.5542827947735132, 0.7809568472291928, -0.08310752446394723, 0.45043322779258843, 0.49103522234190194, 0.4333673931631502, 0.5284240446572276, 0.1840857241268091, -0.08029415657837077, 0.7753620954444719, 0.2022014798921912},
    {0.6066296616874531, -0.3652087550881903, -0.3154269220561755, 0.4534098677460837, 0.5201550405235433, 0.6632880267023559, 0.4035875200843992, 0.11526432995494391, 0.6058957009795953, 0.14946273610568497, 0.557739297369879, 0.09860623527437327, 0.1843793941621956, -0.18438778516114201, 0.2707186974293609, 0.029520492881159672},
    {0.8487314145336092, 0.11961652748303953, 0.1590316797509639, 0.34897927230719755, 0.8350799605893593, 0.49258592620351505, 0.3413235548165415, -0.128748496241209, 0.6968417505962543, 0.41573677119067753, 0.6547410217753143, 0.7730601169902983, 0.49573323595395746, -0.044655434160662325, 0.6342319867015688, 0.7233352752493469},
    {0.9068460815721356, -0.037754638668891845, -0.08720646639440104, 0.16961236747730038, 0.293868880951709, 0.8002940748977928, 0.8298788638304802, -0.36817010200123146, 0.6396682634564488, 0.27405011391222317, 0.7419872066927677, 0.7445808496252253, 0.3071447158586184, 0.19282669300679825, 0.8766207327195514, 0.477838776540027},
    {0.8854655548711571, 0.06491431998521546, -0.11020040296164585, 0.7438425693421431, 0.9594740005909591, 0.6803206134935376, 0.42201235457365677, 0.25811715638668964, 0.4827899413421854, 0.5912461092351168, 0.8735074572993657, 0.7690391691387694, 0.7249733491937377, 0.1878966336332222, 0.6559264527787595, 0.8425731275161531},
    {0.7274978497164348, 0.04706544828972044, 0.11485095375252968, 0.8031419988739922, 0.5012246760376735, 0.27164527159677104, 0.5965930130451063, -0.2079169105132824, 0.5724786867877827, 0.5227820732305147, 0.8830090325486, 0.48095425489739285, 0.890596039730492, -0.1250369107575239, 0.6136158889446649, 0.72793495536699},
    {0.797101105156218, 0.1932793111909509, 0.18158132387227716, 0.2883204772104635, 0.3845118164132406, 0.27264127053270526, 0.3026091699193585, -0.2851893727047858, 0.8127815298830836, 0.34748665235913, 0.7710474244641647, 0.3983494946523087, 0.5929511577426803, 0.2607925930419787, 0.3712214232305184, 0.3004077330805008},
    {0.47483281135753547, -0.1896979631203694, 0.1635379108023037, 0.42793487601049673, 0.5951263730416645, 0.7794234280736028, 0.30074692724062335, -0.360401133777542, 0.501728466883014, 0.10493525376240295, 0.7396269810297551, 0.6525249484659124, 0.5240046392834309, -0.23090128177133878, 0.4819613811252116, 0.5052489103426894},
    {0.7592936058229122, -0.2282215549925956, -0.019114983023028102, 0.7726695915782023, 0.6911466305443593, 0.6975886875503581, 0.30358120943058653, 0.26854777048924006, 0.903334318772445, 0.5640478690353266, 0.63856648050584, 0.5287937131559365, 0.4745040373105195, 0.190235224757936, 0.7674903869820056, 0.8593926776403353},
    {0.31390270830746164, -0.15062836907194982, 0.08866794415106825, 0.1453561663152198, 0.3315441373189761, 0.7518846529156181, 0.46690488641244693, -0.11091203809609104, 0.8334235508750001, 0.19988887772247588, 0.3774836303651252, 0.5656441367250533, 0.6501700479872515, -0.020180755705185866, 0.438905173802785, 0.5105283914390756},
    {0.5879483394327604, 0.16000697497647418, -0.3071563028275052, 0.427801459607462, 0.34609223514211385, 0.47013967293484193, 0.45899248962974415, 0.0956030375973115, 0.38375605979667804, 0.5355511464736248, 0.6207902153571037, 0.680136410884733, 0.7991778275847587, 0.12599724661712106, 0.36475551505260084, 0.894973031411728},
    {0.7905323676736872, -0.1335915202932621, 0.1496754286262199, 0.36714535984877383, 0.43788812214479556, 0.6666652463407831, 0.5852238262631233, -0.006830836171158948, 0.8210653486643342, 0.561208881940061, 0.8605239993938587, 0.3186801386381358, 0.4976815381976864, -0.33134893142964594, 0.3740264233756057, 0.6368337138393227},
    {0.6444160445674966, -0.35215314831952377, -0.04954374167684896, 0.4543038352790519, 0.8621344568821216, 0.23035144203916705, 0.5691642840611656, 0.01970470518935006, 0.4049763462400387, 0.6442414695779858, 0.5642500842799895, 0.9086775412748557, 0.889119059663837, 0.04418921037197366, 0.9483927232965088, 0.9063779918130289},
    {0.2191427739437242, 0.040003119972733425, -0.16406347236401125, -0.01718194585166303, 0.23389527382427636, -0.13355403800011453, -0.014690059729216288, -0.3566941501505386, 0.2780527108086894, -0.13557400128490632, -0.1319588005181481, -0.09357580538977119, 0.2555638094267631, -0.3320695472909558, -0.1390147174353586, -0.25078105734657297},
    {0.9494643388947762, -0.35268171416831057, -0.24290454320553165, 0.5885879784016324, 0.32018188991590946, 0.7205191492262447, 0.9401960532519895, -0.11575762396930186, 0.4139095049058723, 0.4006446969258971, 0.7272583099335873, 0.590864947172732, 0.6183909058370322, 0.08169409909233341, 0.5210892143791066, 0.489533945625473},
    {0.49910602107938384, -0.11425822821137745, 0.15577356206534818, 0.29726776929279086, 0.9331357809164846, 0.3826096922511451, 0.9318984439254921, 0.026257713818637087, 0.3879268172644418, 0.2089183451658549, 0.402499833039678, 0.3117354756393974, 0.7715860147570994, -0.1405992654549434, 0.8089813411913145, 0.7115874252382886},
    {0.052968548075921384, -0.2945701664915474, 0.27257153642067095, 0.28320163552103433, 0.08680159685216705, 0.19040761118569427, 0.28126863546849523, 0.3123549952514897, 0.5849066943840557, 0.5056886235610926, 0.5778829337642651, 0.45785803233651073, 0.3266727609792804, 0.08409712395710028, 0.5544284481540506, 0.24701460927618685},
    {-0.045350006012216545, -0.3347041435046799, 0.1464363182245366, 0.21868856897136293, -0.05147449821236397, 0.20888725723186521, 0.2719201451380007, -0.02040469006715765, -0.02206933847894465, -0.015599008936291974, -0.018464833041895813, -0.23141200231420792, -0.28490049585832267, 0.16119338136506195, -0.0632984803252524, -0.11148642997768933},
    {0.8464041568615578, -0.11426534548206971, -0.010238018617157382, 0.5186341458410125, 0.8385670856330515, 0.6477587574283584, 0.607947901158279, -0.1286716557856802, 0.848965111625792, 0.1405387801757841, 0.7736429754064174, 0.47574100604874886, 0.7231801179809091, -0.19884665657588063, 0.7329703883811063, 0.9038860493472558},
    {-0.2538149270372722, 0.21565099688128078, -0.29511028348528406, 0.3055271412819083, -0.04691421152547398, -0.048651166321643395, -0.03272735066378894, -0.14855760355211597, -0.30255641070470063, 0.20762162808562165, 0.08758332988788313, -0.050531129096388745, -0.03813824260525199, 0.12876831665650235, -0.07528835743722553, 0.1108737160785035},
    {-0.2703766154336167, 0.28422367418314626, 0.32146204525403327, -0.08344358271504514, 0.2511789885781508, -0.30112769882330187, -0.12746505416673948, 0.02374986727662597, -0.08208534361276582, -0.084437390060569, 0.2566883143148743, 0.34707111564913706, -0.07501337408251313, -0.1843594788566112, -0.2779693606726795, -0.021334670519283734},
    {-0.05016702652064137, -0.2184383619945514, 0.2773314870396594, 0.22028657608511862, -0.18033901208612102, -0.24599033652142702, -0.03382590905751859, 0.3398290942361881, 0.120060521826189, 0.07299061515269926, 0.33322409707176537, -0.2699667770320235, -0.1976047738257516, -0.22109511832704523, 0.030073515818692644, -0.29815983240721455},
    {0.9078191364047415, -0.30530251073813613, -0.31717714709625777, 0.6760250055927882, 0.8520688297616443, 0.9024802217992569, 0.4330673027644288, -0.05206185981980117, 0.8252647100754296, 0.29487928095483273, 0.2706734904842966, 0.2741892411467145, 0.8943031902733586, -0.12683578901684142, 0.5159671233434668, 0.47722792467090924},
    {-0.20286160398665878, -0.34674559539015537, -0.22717938899840628, -0.13401256678162138, -0.03569543371774221, -0.06250907273275191, -0.059295822583838774, 0.28377253676522324, -0.18701349940511192, 0.046692885442462195, 0.2965409017078668, -0.23685925800888497, -0.23723208721433325, -0.09953242717409509, 0.37239403912412156, 0.2993954696747907},
    {0.4371442423513469, 0.2830190310226847, 0.3567437990650721, 0.6807258196391536, 0.5446953657438743, 0.8941514393235965, 0.6831841786556753, -0.2334989055521875, 0.5511721545313799, 0.09683002092309327, 0.8822996292149333, 0.7358195356415823, 0.7277124423575279, -0.21804798864827754, 0.5946401724654512, 0.45928470463268883},
    {0.39060557706095483, 0.298416950515619, -0.0444679088970512, 0.7230771614640403, 0.4902186528666401, 0.5033484069475175, 0.7109698892555397, 0.27649195473414007, 0.8018990187620556, 0.689800740571549, 0.49304837763925347, 0.2379814726093701, 0.6218034122584497, -0.23690182285875025, 0.6766313093664638, 0.3237789656336818}
};

static const float b3[16] = {0.4095375240377057, -0.03553595970897198, 0.03332766183526727, 0.3996884191769825, 0.40656075033777966, 0.40296515608018074, 0.44372656300218477, -0.041411953567273875, 0.3604223460998516, 0.3927054005617016, 0.42455646186238594, 0.3617047778259086, 0.38394668688362854, -0.02492724937098064, 0.40296189764379525, 0.341403625732027};

static const float w4[16][12] = {
    {-0.8017631316586491, -0.8640352651281501, -0.3119035895847136, -0.7711982014064882, -0.09159274677465903, -0.6577816351505263, -1.0005026167458781, -0.6839347860846515, -0.4272688226608477, -0.25406651458485413, -0.3321594273568781, -0.9773691623074906},
    {-0.32375161555048204, -0.3573753475838531, 0.3384212959802464, 0.3756292204687525, 0.2801048165088752, -0.057105450750738945, 0.1601209318374896, -0.40548381367823344, 0.03401364700910856, 0.3445032202257987, -0.06009036384396586, 0.14381204591965704},
    {0.12013837845200805, -0.2933693432389368, -0.17986510789444035, -0.15832709380834722, 0.3558744424507048, -0.3255874545678741, 0.1946024635003862, -0.035771223292502256, -0.37110601860503845, 0.11414051060308666, -0.3816138700051028, 0.29854322132714084},
    {-0.11835536452281531, -0.9997412162676232, -0.7744156094624798, -0.7349077160632349, -0.40312335475365446, -0.6784083231918348, -0.34881072715645434, -0.023363559184400924, -0.24692162033745355, -0.5416826808166907, -0.5925834598127753, -0.7067079685249466},
    {-0.6190404703521362, -0.1299683276404036, -0.8293665590648862, -0.8750791724350827, -0.5107347237165533, -0.7789284788042553, -0.1361651934693558, -0.5602239405584821, -0.7458518896257486, -0.49878428247123313, -0.6701805796104456, -0.6810107315668542},
    {-0.9248734937243579, -0.7609901738351263, -0.5659377162739851, -0.2989830743963656, -0.8844157041411175, -0.07988267955660547, -0.48531253024870447, -0.2293516310370983, -0.21832695074308653, -0.8625593939290189, -0.2347184893028896, -0.3484819394719578},
    {-0.8091208472481758, -0.7509543736479846, -0.8397912935971328, -0.21279815776676556, -0.5976159673934096, -0.5734668759274264, -0.2721609866761332, -0.8528136862200771, -0.6598398577130423, -0.8305935485983869, -0.33865390154207814, -0.24230683093668795},
    {0.19800186522824612, 0.3633946517414993, 0.03278554504547966, -0.291531494885689, 0.2319430135950482, 0.200996708218648, 0.15419746758683528, -0.06070518877433962, 0.38686087575828326, 0.030209920969231877, 0.10564564859280862, 0.4123252843385628},
    {-0.3310549452026757, -0.36355149578364, -0.5407049978785189, -0.817273841151663, -0.7648077082930715, -0.8602407677238368, -0.7511710906921358, -0.4723717748134624, -0.5749152759989896, -0.05656486013548126, -0.3691535747904503, -0.23008703744258832},
    {-0.4997633578945298, -0.2598353188345475, -0.16071322217680162, -0.174083617977952, -0.8105993588627413, 0.001180807711049662, -0.17748478513909363, -0.6132981739529271, -0.6093744139825017, -0.49407688712189435, -0.8812426854068993, -0.19205084605378286},
    {-0.8869483649583862, -0.1287529403686697, -0.6615595986659968, -0.8355651561401449, -0.22778064252065208, -0.8405175921180803, -0.7769257971051966, -0.02105904842407074, -0.17351029257046624, -0.7631881728875779, -0.5823904309301484, -0.6867397476855475},
    {-0.28753627429640666, -0.7727765325337617, -0.6616241906345305, -0.6582401991544331, -0.5785252383071269, -0.7038595897148803, -0.7626322118131357, -0.9417376594809884, -0.9240248132648271, -0.6620766698139869, -0.9475431366245703, -0.6036187763037462},
    {-0.03647661985907875, -0.048575156877728384, -0.7853859324017953, -0.10169495477762698, -0.9206716225208263, -0.15981632373371676, -0.8406471211047117, -0.9149188165890646, -0.7882468993904586, -0.7263100942629409, -0.34975910402047755, -0.5425525734055756},
    {0.15567070044436102, 0.3210464713985778, -0.2821851422336267, 0.21640220541406457, -0.37657661615376153, 0.19181134028829688, 0.2945588141847169, 0.03484144338007226, -0.34695553537924856, 0.3298044587065489, 0.3845931125972466, -0.005845324632546885},
    {-0.6697447608673572, -0.7915745653205515, -0.5952997221030699, -0.1377249961201737, -0.6063036147262412, -0.8954491630624964, -0.49767794446579733, -0.5949406162485318, -0.5220114553327257, -0.08029339102046798, -0.7332102541832435, -0.7159448226502908},
    {-0.572828052503938, -0.8698297522436291, 0.016458881513017404, -0.9491468721853271, -0.4553705905186219, -0.24473143850634754, -0.3910880272352685, -0.7500660120397493, -0.7534724825753846, -0.9459346504988644, -0.8624669802491005, -0.6060214256565434}
};

static const float b4[12] = {-0.1696907489749205, -0.2294664536149632, -0.11471300901022033, -0.27171265080489393, -0.17820206066566946, -0.10974933468341609, -0.2800620531350259, -0.11351694234725077, -0.24472493697794787, -0.20927875177154356, -0.15933363225431973, -0.1924320560943227};

    // Input Layer 
    float z1[64];
    for (int i = 0; i < 64; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[32];
    for (int i = 0; i < 32; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 64; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Hidden Layers 
    float z3[16];
    for (int i = 0; i < 16; i++)
    {
        z3[i] = b3[i];
        for (int j = 0; j < 32; j++)
        {
            z3[i] += z2[j] * w3[j][i];
        }
        z3[i] = relu(z3[i]);
    }

    // Output Layer
    float z4[12];
    for (int k = 0; k < 12; k++)
    {
        z4[k] = b4[k];
        for (int j = 0; j < 16; j++)
        {
            z4[k] += z3[j] * w4[j][k];
        }
    }
    softmax(z4, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
