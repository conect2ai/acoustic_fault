#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][64] = {
    {-0.2298173716735178, -0.3151850590889127, -0.3976333659121115, 0.2918959578662145, 0.42990506631426645, 0.42156180861094883, -0.2642097007429261, -0.33861727975274447, 0.5723765928994506, -0.10357990367598471, -0.2202178021782511, 0.26236090025692893, 0.09512942652172322, 0.5100222711551587, 0.2269419022277925, 0.4101876525208289, 0.06179089055145442, 0.4610848485404817, 0.34388113539555837, 0.4571467886597101, -0.11585031086468452, -0.1567453538448965, 0.1425158175252483, 0.10245517220987853, 0.4912698601845103, 0.03631302284415609, -0.2734632188098654, 0.13662871824261777, -0.2179551003092633, 0.14165025877502763, 0.3810804944384797, 0.42329936059255563, 0.281705992939625, 0.21370459445023554, -0.09531430090599746, 0.1257768182970979, 0.1679291306372583, -0.17311416492844323, 0.3030874480106748, 0.0192717718764992, 0.29987409812310184, 0.09745158017321616, -0.33025793206639675, -0.21728675614060647, -0.25156123509363115, 0.5055672519485849, 0.009052027196219364, -0.21944987958224735, 0.0774342239521338, 0.5585920025556971, 0.5134900265078467, 0.082358400643272, -0.18698793447759032, -0.024378973524799168, -0.07549530537087566, -0.02597240289049913, -0.3257649213109984, 0.24899248414937752, 0.6228903017007633, 0.5196689248640763, 0.14849044050232998, 0.3660474254507644, 0.3064392423992609, -0.050312689749070647},
    {-0.009796093284843004, -0.4950740304006705, -0.26450479234226393, 0.3630696914669186, 0.4179236252072927, -0.2617783749245158, -0.039938051696977804, -0.19121264009003705, 0.34005949080732956, -0.13818919088314546, -0.5726477812292762, 0.30809514692430084, -0.4829402991275607, 0.40623239389095117, 0.389999124328249, 0.5367599735942109, -0.4930264329166538, 0.3324751356679209, 0.1334924782750061, 0.5864152233262055, -0.06718346420145062, -0.4707603807712848, -0.19712134922580002, -0.2329384393794077, 0.4014080501547205, -0.2103509825441404, -0.215859885302998, 0.08037112749126747, -0.3233679828049102, -0.5738790182034219, -0.16046664601239186, 0.26379134840580776, -0.1893035410702725, -0.2966700049761311, -0.04949110023916365, -0.1331109100082541, -0.2917651824300897, 0.1477220172374027, 0.34872095465342057, 0.3751776204716839, -0.1358145189001028, -0.5178806261425127, -0.34883798624447393, -0.6639388828515613, -0.19451338340914803, 0.3468100359924019, 0.424973394979852, -0.3333091202620905, -0.5502878901495244, 0.503928175440766, 0.37763323898260986, -0.40187744422054855, -0.6187981460464221, -0.49996076385199095, -0.4994791019458356, -0.6844923807515475, -0.13586302425746813, 0.18939324866527635, 0.39146038681238043, 0.04637095967722225, -0.45437842425975683, 0.5595127295534146, 0.28547479902808187, -0.40601839304382914},
    {-0.23051017839063298, -0.4737132273763146, -0.25475888796132373, 0.42063105205703366, 0.3631657440582197, -0.48997927989394086, -0.3698103563718972, -0.6319383697806337, 0.6708626767497179, -0.11403970921499527, -0.47804131969013075, 0.5937564639003612, -0.1439716259969096, 0.4265250573445718, 0.3333520140024084, 0.6360070334525848, -0.4218783734130064, 0.6444731802228276, 0.4811801043435628, 0.679234026229742, 0.08123023321650415, -0.1830862119529365, -0.31560655939608234, -0.3082705282584259, 0.5931337770231445, -0.46624142853921235, -0.5820644766387403, 0.5108212781448441, -0.25465301371951193, -0.2835585261487438, 0.2700472293264129, 0.22067254011158052, -0.39144452073112895, -0.40721706560918386, -0.08486825241039488, -0.06944193292146218, -0.39896278446377376, 0.14586929851802283, 0.4671956735768775, 0.23403714876917256, -0.5343228461363086, -0.4657026559438505, -0.3702364324820092, -0.5247433993890918, -0.44748072206385525, 0.7117733439312992, 0.499454843953663, -0.24629180522818278, -0.2851254637877742, 0.6818013678582223, 0.7751906698503483, -0.3373074672685322, -0.6378956931402847, -0.3447037501915837, -0.5879967990747813, -0.5891718600527133, -0.2564091630741884, 0.5276241692422452, 0.6481234791127336, 0.5709652064496625, -0.18682322569487322, 0.6202636941161274, 0.3121547596241118, -0.578373587581199},
    {-0.6283078533083343, -0.6162659369443709, -0.4872159396429895, 0.5736288960073257, 0.41722624923412216, -0.26362890800854877, -0.10002638868459765, -0.6387796799635624, 0.5469091256334933, -0.21502371111448035, -0.6317372892574263, 0.33637527039851, -0.5833360264104478, 0.4923683641466876, 0.5919123622018616, 0.5596757993963684, -0.4985732526642527, 0.35618236333379427, 0.4179902505741434, 0.6622483093894006, -0.18552561108035273, -0.29697416251159753, -0.38212698599364386, -0.31866477075305066, 0.3863810901536782, -0.4655040185657804, -0.34224440064200995, 0.4534964422269079, -0.1942853618692924, -0.4992940599914973, -0.07312154838605464, 0.4466232344339782, -0.42921511239629434, -0.5837292578365534, 0.1366164068022097, 0.12979197420996771, -0.35791323596062363, 0.34303548131882305, 0.6301345871705358, 0.26312253456497137, -0.507554937240909, -0.5350330958238882, -0.48566252867502036, -0.5859484396061503, -0.34372977602289717, 0.5407037684286786, 0.2300857356616003, -0.2935606929567079, -0.3284695350845471, 0.392685155670245, 0.47138555637898216, -0.5491456881268575, -0.5229295654937315, -0.4313588424460027, -0.6021754560183302, -0.5448293279489314, -0.5210610034959205, 0.47566970222365645, 0.4059746441735148, 0.6474740666123369, -0.34866460771748237, 0.44550538497715103, 0.37065634319443796, -0.4213037707638687},
    {-0.6546067342157171, -0.742179965645338, -0.4199860054310561, 0.5161573479248394, 0.3537591544889656, -0.3860394744814908, -0.44481151529345264, -0.5632285614300504, 0.5182466557658969, -0.21710249549664773, -0.5253384171162117, 0.4368793186345559, -0.6572488992374046, 0.5626814696060429, 0.41940644893817697, 0.2266393271561567, -0.39586463820069023, 0.5777186148024227, 0.37026606189734884, 0.5705630919353906, -0.2524354356053143, -0.6765790782898894, -0.5393865023862687, -0.44795733760868645, 0.43193650206300715, -0.4183095849814858, -0.5468733525148346, 0.47411849210378315, -0.5815267371564259, -0.6490273606413134, 0.23774716914138735, 0.27428384214743445, -0.5187295325710253, -0.3777405047463852, -0.0028019076843745004, 0.1649776304819811, -0.29755243759801214, 0.17154863393104058, 0.41347030164164694, 0.40507620674883954, -0.7134933546514298, -0.4410121360826672, -0.3889633629991163, -0.5627345688984035, -0.4600074498019308, 0.6825111653047069, 0.37164755876074357, -0.5935022886245082, -0.3107546766030615, 0.6422914450180679, 0.6640381907020653, -0.37055181695867623, -0.6357847360646294, -0.5816235334898893, -0.6094452892805826, -0.4015126082167494, -0.25691343502236186, 0.41925679338275185, 0.5550084913729318, 0.3164617609736244, -0.5760165398331781, 0.41853420404602015, 0.2905011663458511, -0.7344559786592711},
    {-0.4934837648994963, -0.6555800686012235, -0.33690029037498154, 0.46169010377858566, 0.2555940879493257, -0.47179265371871004, -0.23839494997004154, -0.4435404780984837, 0.32736346033891106, -0.43220300739068457, -0.718666063774858, 0.6058714494922829, -0.6809892675002738, 0.31104237702058163, 0.36826235269814556, 0.10441167002259595, -0.6526827216379778, 0.24843189948691952, 0.5591691210735732, 0.1790848800580641, -0.36762936030401766, -0.4257920249760042, -0.42479361380347624, -0.4579916325445437, 0.2358833618708055, -0.47061940248487666, -0.471633290547342, 0.3587073346988101, -0.4683917531112395, -0.4527662214329094, 0.008466824987735842, 0.05156713175539985, -0.7031316715708534, -0.3537019816031655, 0.07358588655808632, 0.12461357003391621, -0.5734755817842849, 0.23860637670580276, 0.4522454276511385, 0.28353042164985864, -0.6556775108441371, -0.44224787341325283, -0.34374319800959474, -0.43185180125500705, -0.6928890505266604, 0.5362528788785399, 0.1253724431462159, -0.5222125606972565, -0.3094576265886917, 0.5707353361628926, 0.31747238284815626, -0.40757475984765895, -0.6802446725664747, -0.5273183635187747, -0.41858896193391887, -0.3607690285206897, -0.2630870708099439, 0.3694308111737296, 0.33625511440743094, 0.628626025385293, -0.62211903276633, 0.4339158983942429, 0.2666184147327318, -0.7158706888370626},
    {-0.6687299924303896, -0.6085197631003927, -0.6456072366042556, 0.34981555617784565, 0.2259586546007531, -0.23903827043391485, -0.45781127793658294, -0.6756199927642172, 0.3888379682979821, -0.41990318744002286, -0.5560918706530715, 0.49689692979309696, -0.6082079947028327, 0.5202344985156268, 0.33266269072715604, 0.3084217525086189, -0.6474518095238715, 0.29289978700818975, 0.2599056766829968, 0.2786077861063995, -0.035445807522067115, -0.5648741924971964, -0.5225429120155847, -0.4381277884259611, 0.22242216735771533, -0.5984616347163301, -0.593875548261217, 0.4841322836818309, -0.5175829897916747, -0.4028697931996468, 0.18944213232593513, 0.1609402417289347, -0.4814651998364525, -0.20649452920385375, 0.01892313526591303, -0.0010204802884573691, -0.44252715945346, 0.09911143654666633, 0.33989540772139076, 0.09505584852262293, -0.6313045906456941, -0.5319216502206389, -0.3371566455139949, -0.5930518108444268, -0.4404192596556591, 0.27069268523899226, -0.10549251932851393, -0.6209506457403752, -0.37142983227670684, 0.49270905768825535, 0.5373560934417145, -0.3578450617846496, -0.6417580737572582, -0.7751576070184586, -0.41173455665451486, -0.44090844035096594, -0.4085032872474212, 0.5462618172935019, 0.31871743356292975, 0.6282225635850307, -0.39916546774123357, 0.40585689252479823, 0.2320076675182573, -0.519475180355331},
    {-0.5567321368248721, -0.7558520934587692, -0.5672915066040777, 0.52472739733903, 0.4299318993411015, -0.5849658162747641, -0.29323745924887423, -0.5469791670744036, 0.4809245734717753, -0.21100981269988056, -0.4787397033842305, 0.16890722120314322, -0.494740137219665, 0.5038912649699527, 0.4397575407873824, 0.28968461727283124, -0.6221437899690038, 0.5014833768496509, 0.29649372986112965, 0.5009786582865372, -0.08042787123968381, -0.657970475883184, -0.6975705916973566, -0.25392791123348557, 0.07107384402309745, -0.6591752780026469, -0.37063227576439184, 0.23180759955423683, -0.4785495465830575, -0.6728113229956263, 0.11109136293631973, -0.0025279008605776014, -0.5129671214687392, -0.3362494240031414, 0.032419765331098714, -0.22640836906161713, -0.37588489720943985, 0.0953372368478116, 0.650298576909819, 0.2529814153066165, -0.6474629433169651, -0.516334692595535, -0.4895535218693386, -0.7375176803047784, -0.676409469640346, 0.3632269311237775, -0.01374062914674429, -0.63292299995867, -0.4070307452273126, 0.6426368117703943, 0.5426119735883839, -0.5453006770399031, -0.6373683349917243, -0.6725822433544064, -0.649298856357652, -0.3417723576743851, -0.3967134818613251, 0.3396627267805048, 0.38674690375558135, 0.5034891542291131, -0.5929951082070346, 0.46736493488684977, 0.22470747802999383, -0.45533865841225124},
    {-0.3512425160394331, -0.5976259691086486, -0.4119654126297331, 0.3037532341620491, 0.3624893332836571, -0.3267767948207881, -0.5222743955632222, -0.6570145796144392, 0.5162403047186925, -0.3965548699056667, -0.41785810627748843, 0.14348095612395284, -0.530498566044561, 0.549852543002179, 0.3680037914677616, 0.3943650084548162, -0.5388380981522612, 0.5336337208663914, 0.49254931387753537, 0.5820696586766256, -0.23272645679380594, -0.7673290703343902, -0.5638808376580811, -0.4696803708970785, 0.037537433988137664, -0.5759282748198962, -0.6984851345538915, 0.18263400104390728, -0.5362776433367253, -0.42148476005516766, -0.2985685420446148, 0.304770047562866, -0.463107489572282, -0.5998637692843503, -0.08857485907253496, -0.17808036676673933, -0.3046650319889155, 0.1383850404999181, 0.5840804254326744, 0.026979704063990074, -0.6695329865005896, -0.6699612329823953, -0.30287831353321104, -0.5090931666280321, -0.5491414957538601, 0.31309937183684844, 0.3080520512115568, -0.5982026475534427, -0.4247009924986448, 0.6642839435109716, 0.5754516253606522, -0.5637376392423674, -0.7088812833469985, -0.43816438995757423, -0.664225889401375, -0.43442363647801024, -0.5559506055707827, 0.4553314785728285, 0.41102822156950497, 0.2675030681621779, -0.6582231358251819, 0.2931304279736679, 0.460381321084961, -0.7226527291911868},
    {-0.4669501078707422, -0.510755522784224, -0.5258612937693207, 0.3718521259142219, 0.397546980938719, -0.5664374398516809, -0.4574620622490297, -0.5175121436561199, 0.5938117565086334, -0.4625303935398496, -0.7483989349754931, 0.2932924268543046, -0.4539055694998783, 0.5615837040347593, 0.4460381987962194, 0.39937354835584254, -0.6966152427907972, 0.4793868624639734, 0.35655569435226797, 0.3892231949869896, -0.051800219986854606, -0.6610791249410072, -0.5289757715522249, -0.3335414247365543, 0.23178149329535572, -0.5960083604924244, -0.58758388175619, 0.21481628001134012, -0.39356692425302725, -0.49936569863190555, -0.10018634934596526, 0.2656895308529831, -0.6705583402903402, -0.3600163125401791, -0.334770804191656, 0.037674075613297386, -0.4947620521814937, -0.07276173483838608, 0.34749220484856463, 0.17497981164419749, -0.4827493245904838, -0.5324124467738139, -0.6092099722083504, -0.5996957865055934, -0.4041914925182061, 0.6627424421045314, 0.05644365581151725, -0.45571142841455314, -0.7385998105681564, 0.6370355084291839, 0.45006403422157204, -0.41208161725217773, -0.500896428764395, -0.5225825392751817, -0.6046104404497465, -0.5524792547345396, -0.5089115038996262, 0.4009944971653378, 0.2985647527435139, 0.38531585830780557, -0.5499563468289164, 0.5473991480837016, 0.42665572769467386, -0.6397957203839968},
    {-0.49392898423287335, -0.7478641340598382, -0.6328248325611543, 0.432457351718686, 0.5478247809994241, -0.7050777169978376, -0.42053065744792123, -0.4674630314756952, 0.3558446470225185, -0.163244674374977, -0.4337868275103951, -0.06907658864764231, -0.6439636076272408, 0.4311719844951213, 0.40866866555967657, 0.4213851248795039, -0.380570465320346, 0.40549061059599206, 0.2601002301752129, 0.48893864245584356, 0.07394652833537733, -0.7662209220260208, -0.42647396760186224, -0.25850298379641895, 0.18038058564876847, -0.6680641084010863, -0.4661460312614052, 0.16094625225025283, -0.620240689271973, -0.394921955314242, -0.5100755462223057, 0.052675509379902674, -0.7036883015049984, -0.5017910818436143, -0.17934711565328557, -0.18413323928096526, -0.4947077602395597, -0.10513677994527625, 0.4485269800499391, 0.2582176248391692, -0.5787440382385981, -0.7244282732773436, -0.6766302470875256, -0.495344068742384, -0.5391812898649299, 0.18483313204241117, 0.2967220093305477, -0.6079144106531663, -0.5885662660203438, 0.3773415565573846, 0.4545334146596486, -0.709173385954849, -0.7723877937270942, -0.6447427477616298, -0.40028667853344063, -0.5382682818475658, -0.4080100681586331, 0.4497791209559096, 0.20923848382122737, -0.03577912976954515, -0.7775809615498769, 0.42898330977156707, 0.39199397795322105, -0.5714208551275964},
    {-0.5620649437550872, -0.5916789425251417, -0.596672984664886, 0.36331210971197647, 0.2554239199341313, -0.6696130843492893, -0.5351894450552707, -0.706009502941225, 0.3132133084982343, -0.4104085336489728, -0.5177345496648125, 0.09750584924485095, -0.44707631216734695, 0.24504122723276808, 0.2775867755350679, 0.43157645488485935, -0.376612504225059, 0.265692956809551, 0.4825087913169461, 0.20991421440166838, 0.06657557512405815, -0.6010867551300441, -0.5215691330884095, -0.32403557555351625, 0.01599243429828252, -0.7237001644992486, -0.589382384331881, 0.20767914645421978, -0.46395066259182816, -0.4850506430372634, -0.5257267081541687, -0.14481321209451029, -0.417185460830947, -0.6919766842782749, -0.3306604985752336, -0.18028674302583497, -0.43325546907694135, -0.1521716866760159, 0.4803673460675188, 0.2577257523035595, -0.6535428428781288, -0.5544450490653452, -0.514420729886805, -0.602285659460369, -0.6130230028639315, 0.16740672357238673, 0.00029656206783265534, -0.42210862427213663, -0.6830456340725223, 0.44033680632170463, 0.6155179862204706, -0.6516907106633647, -0.6209631065766685, -0.6674810475759708, -0.5088804537414615, -0.3780007863984467, -0.6706342756211733, 0.3464296570395126, 0.15675863349895763, 0.17108549499724982, -0.711911363432273, 0.4285784932595426, 0.1544537757797916, -0.5019983670849286},
    {-0.47854671813835675, -0.48945868471750653, -0.44677958694114034, 0.349017399211554, 0.4405018369840195, -0.5580269397110224, -0.5080798782348682, -0.5526814211353055, 0.24289101962267984, -0.10378230114017818, -0.5755106984595465, 0.11506520906481336, -0.6410468907297103, 0.46382431482789127, 0.24756902642410702, 0.21172778064629788, -0.3666124333194695, 0.5719148787273065, 0.23273974526762217, 0.57956707010418, -0.014723215695935817, -0.615838454243717, -0.5332682705722809, -0.5152754986354441, 0.36281633097840954, -0.4644127477395658, -0.5494087992265078, 0.47465263613968117, -0.6123052667210409, -0.7025486315737723, -0.27513220330478466, -0.09025892419379614, -0.7119063409537882, -0.33856496134370845, -0.15741703808747531, -0.11009695927500007, -0.4926763778921772, -0.10810731030863209, 0.535581431112911, 0.2022358734218319, -0.4925144153051301, -0.6129854770885317, -0.21034961470945623, -0.48814848657519483, -0.6255254156423957, 0.2212181488562296, 0.290896346664428, -0.34879856996865466, -0.6290379130550193, 0.1819788986027971, 0.4472863389206961, -0.5247153565900167, -0.6365354211012061, -0.6489137540190023, -0.6294734933211564, -0.4517458271644617, -0.4165561360627879, 0.563894972731347, 0.4188837490852869, 0.38966647844927443, -0.6353051049810082, 0.5447017675629118, 0.16990529930652645, -0.6358497205402769},
    {-0.34610549812820834, -0.4588155080161175, -0.40316280583704134, 0.29897411164628235, 0.2983536494188166, -0.6921084395190367, -0.47817136660661896, -0.6697540216429152, 0.40303217345792614, -0.09658772419192525, -0.5320988817687917, 0.10056026675749648, -0.606829176925913, 0.21819597088895706, 0.32332270315316036, 0.30342987629392404, -0.4975337352486592, 0.5463582054199246, 0.32711424505798686, 0.4365399463919872, -0.12148649020318225, -0.6093852969682798, -0.5039380405545197, -0.5021451870337096, 0.07149044863046053, -0.5789533919306904, -0.6100002683035902, 0.4563183170388801, -0.33867445440569066, -0.6399853756161697, -0.37466842486797014, 0.18337553780014923, -0.7046883074670388, -0.4822491697256015, -0.33151096689568904, -0.08566846960393104, -0.5592277648927072, -0.24269730716930513, 0.25474085389808004, 0.1806281534442888, -0.5807908121656756, -0.43084195768874123, -0.26137060012732266, -0.43514208432943463, -0.6077758776055434, 0.5531327364857426, 0.1394290779449843, -0.4561370493176971, -0.6541894666270216, 0.362900565100504, 0.5059549957739815, -0.638925276537947, -0.714424237101951, -0.36523957922340206, -0.41198340047252235, -0.5550444775284719, -0.47969891860749553, 0.5573853915818668, 0.10764972838379452, 0.41353955091439903, -0.5865928327103299, 0.4972825066954768, 0.31913247623004903, -0.6633679401505539},
    {-0.2748555484507227, -0.5346150442999306, -0.3601599957026453, 0.3938145831276259, 0.4409535964237982, -0.4085985996440837, -0.3819353085114932, -0.6449183732242425, 0.5222154061973852, -0.17277504744988603, -0.7167077115412301, 0.09323026425616866, -0.46204923955116317, 0.28644683399806364, 0.23375299017949822, 0.36876972791910684, -0.543007346949548, 0.5708460708500198, 0.4342523580887183, 0.46750445430215976, 0.03105671209505163, -0.6832229879374282, -0.409397015032599, -0.26890236672991924, 0.3603273452134116, -0.5471794145675437, -0.5075296670499988, 0.3368171012181706, -0.5061947525639916, -0.509290701396995, -0.4873019749534712, 0.29370533935873294, -0.7290322816330842, -0.6229432206731853, -0.3536443126920032, 0.11181411042452608, -0.48318091942452357, 0.131927322369756, 0.4820383362099586, 0.2429411670312793, -0.4368110578390931, -0.5042754022265697, -0.595112641126551, -0.5775222447721877, -0.3027888123004574, 0.28796705865906397, 0.28681134544050974, -0.5597339494417052, -0.6347153014426751, 0.5616481896805098, 0.55260676082642, -0.5141601595008143, -0.5512352070527515, -0.5527971864466175, -0.4373918135008144, -0.7046904342286195, -0.5451211325992082, 0.46003434724153747, 0.1661980442467514, 0.47303110303034807, -0.7323023245061957, 0.345885409879561, 0.3031170362179548, -0.7237584839806146},
    {-0.5454691650752168, -0.5591657637972326, -0.3930093162300235, 0.3902671713635088, 0.2572707662457104, -0.45481481808033813, -0.5030084699712686, -0.5112255664910456, 0.4657806896491006, -0.16699979177259444, -0.5646569427596662, 0.45606208749983873, -0.6784530245014704, 0.4662398438997719, 0.5310355920344759, 0.3033270499276441, -0.7438558011681087, 0.5327998176762584, 0.46363660304285187, 0.4743450621770205, 0.047647534330933765, -0.4912816162135682, -0.5559880147007399, -0.5158323344821343, 0.414952909492742, -0.47832798668045945, -0.3736688431718658, 0.44254760351791267, -0.3116544437644753, -0.5696294667474036, -0.38060180834521923, 0.1911467211294588, -0.6995034960944249, -0.4216572241146516, -0.16348969768777719, 0.028374557568775344, -0.31261319633071294, 0.20802778983741563, 0.53617713152064, 0.2793371526229004, -0.3475963872279828, -0.5889439446182765, -0.3218855051246261, -0.6878432905255684, -0.6517333368781155, 0.36212348627997576, 0.33656403587961337, -0.44955935677187225, -0.3962509868901735, 0.5618045524132003, 0.6844115243206216, -0.6960123744223958, -0.5586401421646431, -0.6197503821575306, -0.6586948883740791, -0.5326424351196903, -0.5321673978826594, 0.4975685807341966, 0.3650733444620998, 0.42015506637271344, -0.4824356744951361, 0.47048359339530915, 0.33658359310593994, -0.642624621976291},
    {-0.394002429021381, -0.7152459736047478, -0.2643795712357007, 0.37847878876744584, 0.5243940958995864, -0.3911570437250396, -0.3703297839611211, -0.6124405814130358, 0.5623349968453708, -0.240504005183121, -0.46937463980331356, 0.2888998789172788, -0.5259347964916619, 0.560526469591665, 0.31167461755767106, 0.32874113280896344, -0.5454035823610976, 0.4659202754278318, 0.3219260846751921, 0.7006229183649486, 0.0723160697388513, -0.5637222082845247, -0.4609330598494475, -0.48042256724547716, 0.24451859857023844, -0.4620269855460897, -0.44297745023131796, 0.47586373574339935, -0.2879358610447282, -0.43792604806657337, -0.1646958800670014, 0.42713461796745683, -0.47223557956466067, -0.6280055681825131, -0.06602677596378967, 0.21352619806343962, -0.5253538016565007, 0.25439422179902865, 0.6100979603312208, 0.5158223336444594, -0.45160922331822784, -0.5582932233275918, -0.1628757635878389, -0.5215228615900607, -0.3097055179196077, 0.5758831279342976, 0.428135667373343, -0.4503764797793732, -0.36924206613358646, 0.37264491823723156, 0.3955055077825125, -0.31639742639925406, -0.6234850550305199, -0.4922226743262758, -0.5019755420945079, -0.5672518416658745, -0.3606202523677412, 0.6631775202879552, 0.47884226108673594, 0.3098876747644413, -0.47801801209984107, 0.5514318676036313, 0.43802671307003965, -0.5655237914537574},
    {-0.22353034656413887, -0.5431971395457816, -0.4441045007807014, 0.44292794833236615, 0.5386817063867946, -0.4227006830589313, -0.17905080878627214, -0.5097801906221129, 0.6282075307063462, -0.2630090471196361, -0.5429251299547468, 0.5210125680357074, -0.20864589926510888, 0.49610526672917143, 0.5262364027086979, 0.40930698323065007, -0.4831344197013486, 0.7264649922186158, 0.5831399627040942, 0.6850349979869629, 0.16491817827599858, -0.34843171073100354, -0.6123871495715023, -0.3828972044355815, 0.2594851316243007, -0.518111058709504, -0.4118126041161016, 0.5325535757147174, -0.48239085228181783, -0.4498743794303361, -0.22467495955539732, 0.3669006408449735, -0.5121461016697251, -0.4767180733799642, -0.21533279821511367, -0.06942367848980495, -0.1868180703770815, 0.1834594207300137, 0.7075156640988485, 0.2413073463818339, -0.3031381583976845, -0.3673688256710885, -0.1359497962810414, -0.43302900098904007, -0.5437449176995214, 0.7213070915248878, 0.5719462737879997, -0.40518291645433674, -0.4253354212649324, 0.72501188217626, 0.6932944100464049, -0.29388171937798263, -0.5244979556355903, -0.36902284261073387, -0.6069325264982781, -0.43180394988607257, -0.33499947897396937, 0.38188951157842016, 0.37460518761686595, 0.4424566790360216, -0.5218951039992554, 0.6374461302987257, 0.3902149500141191, -0.4168589929984332},
    {-0.2904142894278182, -0.5921714004220199, -0.2909387717081636, 0.5821865208717353, 0.42359787733356535, -0.3719706680276084, -0.2570433714607808, -0.5077406917335329, 0.6418904360461357, -0.09599391091995389, -0.4305361359028663, 0.5256346121441109, -0.5353680467926982, 0.41808735959456456, 0.45546270365365504, 0.38832782864102333, -0.287445184284113, 0.3941173392684879, 0.5230805955521398, 0.4484437418512939, 0.06577240659933734, -0.37532443506024266, -0.5512490169490012, -0.2576694250450803, 0.43477476744119564, -0.5529488094371193, -0.3917705403272553, 0.5169278555087256, -0.3794376029390331, -0.5318569748639078, 0.11365912077005731, 0.4008530550205448, -0.45964312265874074, -0.29032324158843154, 0.016945440670652914, 0.08158508463314224, -0.4132185964825107, 0.24295942226441114, 0.5877985291772791, 0.2248800708175362, -0.4735260981332267, -0.31279506828550857, -0.27581633668542704, -0.3480727899449191, -0.5150428041204393, 0.7168459120911406, 0.5066718479140279, -0.3036374716140004, -0.3439085954674166, 0.563089127879052, 0.7634513292970746, -0.34499277019022545, -0.611710825700387, -0.3621923770051709, -0.3197683598623261, -0.6225499504143139, -0.23648134439356142, 0.5423553076546948, 0.33920465434210667, 0.3639692575811607, -0.3865562963884752, 0.550952428026253, 0.27161220466318653, -0.5695706284973031},
    {-0.5128639357213713, -0.5385779891837552, -0.4933677316542723, 0.5711029751406332, 0.47457942818070553, -0.6177700302152284, -0.18111507265678062, -0.571731338618783, 0.4706836808414451, -0.33938484447173467, -0.6501479884410855, 0.2800059957256512, -0.29725798761478306, 0.32796588412818684, 0.3448349592644609, 0.3315827259973662, -0.6883114630886442, 0.5783467251393387, 0.44697700342142765, 0.6806045127576862, 0.13777735682972006, -0.40981013716394854, -0.5374928055891919, -0.49095061902148623, 0.3677241319626836, -0.6569128566511154, -0.40150748197174085, 0.36379940212993717, -0.5664010404307566, -0.6912625414096825, 0.03703264996528093, 0.36351573086107436, -0.3336399905726681, -0.357118165816909, -0.3216708062086605, -0.04043732649659668, -0.49327107537324544, 0.060826156376560366, 0.4854307934067369, 0.40824920480257787, -0.4601029067892945, -0.7212199914740205, -0.3113497961030071, -0.43330796852146064, -0.506159832637214, 0.38263963486357805, 0.12458847370106553, -0.40466476116677264, -0.4925090760488116, 0.696319083549621, 0.5335556708112043, -0.6031703297309352, -0.6817137228837413, -0.5271936781815078, -0.44446259278683653, -0.41244741465335355, -0.3043567229030619, 0.47078078432612086, 0.6540197354051098, 0.5816995345377423, -0.6522404971047095, 0.5033725467995044, 0.4349733669061721, -0.5158567544103889},
    {-0.5450497426539271, -0.6166341653531126, -0.49804034259662033, 0.4648153022783834, 0.44799275580181624, -0.560901945578131, -0.29717054496305234, -0.6760826295129024, 0.3336931567587062, -0.19617728084580913, -0.43024972250947346, 0.3724515462076069, -0.5561921385591896, 0.5202696744880413, 0.5590545102818867, 0.32833092219467513, -0.40363474040071506, 0.45013133570152475, 0.4042252428267577, 0.4816215102823484, -0.029643646494991707, -0.4281247832996429, -0.6315090500402408, -0.3030206673908797, 0.28136976313415824, -0.5147567063802101, -0.4237824100942792, 0.3844309775525259, -0.520325292619446, -0.6713185460366476, -0.2750714971535855, 0.27756350281698344, -0.5270146956173494, -0.5078775115198343, 0.05666850710649482, 0.21203680893565965, -0.576401045888896, -0.05157998609243851, 0.44654533423821163, 0.26725078733037383, -0.29687310210162904, -0.5249289586404555, -0.35303383891290735, -0.4793371404357009, -0.5323921703910929, 0.41261607341254347, 0.48197242628545744, -0.45928574285024165, -0.49650691080701703, 0.37415789480240785, 0.686514632793409, -0.6351712902779839, -0.6241671233966976, -0.39008921247430195, -0.39308067043800027, -0.7059273559745181, -0.4452756936982898, 0.38521616174181367, 0.5663965784402321, 0.3593184664900925, -0.5663094497636616, 0.3920061452017755, 0.5532277423678004, -0.44392159967520173},
    {-0.4341459495584117, -0.46832941738016787, -0.5390446274551001, 0.5094258586171079, 0.5467167880101549, -0.5444733696037375, 0.07040897194512115, -0.5700312394556333, 0.5570147872189128, -0.03446907857022834, -0.5406942491622919, 0.45659349562889967, -0.43451057073958066, 0.5762773892173381, 0.40969538705424124, 0.49050621957581986, -0.579641958721444, 0.4423453360261744, 0.6236041745514254, 0.5569652171573656, 0.35279852264117517, -0.5654633050734534, -0.5013663822488313, -0.2123079942168967, 0.6186940229433999, -0.582949297545014, -0.5351482514701122, 0.554590662554049, -0.19541377735245336, -0.6244106472530395, -0.2544306998527068, 0.46695087839914323, -0.26937033280476474, -0.5302915930981582, 0.06811350079985941, 0.02513884570483188, -0.41968167486642394, 0.05721806749305959, 0.4474259538095389, 0.6349310355653168, -0.20103376622834992, -0.540795707122935, -0.23303509763700003, -0.552449319767895, -0.3086978785474628, 0.7398872542634247, 0.5237317420138075, -0.2894798880329278, -0.23294928035591764, 0.4676366708260452, 0.7200222966161682, -0.35035505467744615, -0.5021259421130341, -0.22840720937947584, -0.49041862010132087, -0.6023321500913477, -0.19712594734940153, 0.6752849755050018, 0.44790312798948656, 0.3889663058599253, -0.5977910280507617, 0.4192141044156907, 0.5401919757858789, -0.3930696348038013},
    {-0.321522598573605, -0.43648488519896217, -0.32863436096882565, 0.42754155977844654, 0.580624674442702, -0.4507871539617879, -0.09997237278507354, -0.31003626090733044, 0.6945312040151194, 0.18351280747855822, -0.4279412732687946, 0.32001872633165146, -0.1477598712587523, 0.48849903635216646, 0.6834820496754707, 0.6339274572297178, -0.15498975476446933, 0.5683716831344081, 0.6511361613335811, 0.7503889736322288, 0.1763938255806518, -0.2378215929316681, -0.3958056880394273, -0.12284245513989374, 0.3883232616681939, -0.2903974641733247, -0.2949010329081324, 0.33669036588918044, -0.16480590924556826, -0.5222174513702798, -0.18245655531387345, 0.4685860876505166, -0.2520757509505698, -0.5273237897053588, 0.0629218960384191, 0.11250863091568415, -0.3009911504253557, 0.32625958019250867, 0.7891471541388523, 0.5835047861591052, -0.2044522115476688, -0.3473668341112152, -0.3863076901824333, -0.22956802855590966, -0.2727125294746389, 0.7130966254798965, 0.3989568705045591, -0.31696435039479137, -0.49624306347335695, 0.7053791762351115, 0.6323654275387992, -0.4379943452120663, -0.3115146831001959, -0.42795979120860395, -0.2224277742227844, -0.5740714924008872, -0.33849430528193336, 0.44623383122699356, 0.6891811587168483, 0.44661139288023866, -0.24933718209670996, 0.5645043257618354, 0.45184440414642685, -0.5180336676439895},
    {-0.4044361167031122, -0.40127680080865036, -0.5171411278262258, 0.6240527994554654, 0.4647961503750083, -0.3416560503102876, -0.17741790130918186, -0.5660757888546754, 0.6374935668295, -0.22145760353880595, -0.5020189303751138, 0.267743914905871, -0.41657653830791525, 0.6148946025265953, 0.6294286206120022, 0.46865218406856995, -0.6021703526738201, 0.6274124796437446, 0.4578689665814959, 0.4723977753563232, 0.09211330431917789, -0.33629636847292227, -0.404558929398956, -0.18556832636950343, 0.29148929902902526, -0.4492845924139946, -0.5837883161305496, 0.5622927214640521, -0.4354462518668067, -0.48600738278139666, -0.3864628413461805, 0.4936855278348291, -0.564361247418122, -0.42176789795385905, -0.008351866913959624, 0.008398740881142517, -0.21786827952264112, -0.044133169357731795, 0.7301136406519041, 0.5675091703120039, -0.28951333274520613, -0.42565243869600444, -0.28563622408059675, -0.4389540059454939, -0.3286886498555892, 0.4176026828078971, 0.33900276342831825, -0.41372087667564433, -0.5702625497495235, 0.4787726315438734, 0.5042037405565347, -0.5191018770661685, -0.6517274588572108, -0.4503104481097218, -0.4902087650032822, -0.5211866877206126, -0.2958791465631946, 0.40005548141941427, 0.59221922210762, 0.4316818508324328, -0.38155851285498504, 0.5511246741311251, 0.47326715087428145, -0.42799980122199716},
    {-0.3598266089015713, -0.406639150910955, -0.4524151661484923, 0.47707407238329835, 0.4903148629816425, -0.4184168098857253, -0.12931276507799744, -0.2956291037152844, 0.6434751143657447, 0.04258496175650074, -0.6883114167671616, 0.24055801727184664, -0.586050766716641, 0.38419149433175825, 0.5972413321256633, 0.4898634590308302, -0.3706378524946611, 0.5278850537116511, 0.30023674624439656, 0.44121593058886677, 0.30841573181665877, -0.5071387829225985, -0.5646027702948251, -0.3923463595457433, 0.3710139680707187, -0.39318956029778857, -0.5450707492525874, 0.4619697786058414, -0.4325549359087605, -0.5361310647142706, -0.4769151055779133, 0.1935210498005228, -0.455808424185781, -0.6350342315859037, 0.12559162005211805, 0.061143122469467175, -0.49528574664422836, 0.2183234228963239, 0.4012560138748441, 0.5574745579281015, -0.18368463119813822, -0.6577906036038778, -0.15192184220118474, -0.5028626304558337, -0.5273040566799138, 0.6638660089138931, 0.286431836023505, -0.36856893585872513, -0.42303803829436487, 0.5681134899688571, 0.6132797233948679, -0.3141513638941851, -0.7087142432962021, -0.4654772595940559, -0.37524215983043213, -0.5288320829778416, -0.37553271948196, 0.350958805704659, 0.3772492752415997, 0.4842407947617452, -0.3741479523575874, 0.5125225502778757, 0.43313548953780534, -0.34029658746481306},
    {-0.5158762344834578, -0.5887753964113654, -0.3796536685279978, 0.6612959743878837, 0.39637235563735734, -0.4697230547014228, -0.040192506830780184, -0.30554764551882074, 0.43579341454077386, -0.300991376291992, -0.6125102119781264, 0.4206910520542281, -0.4091557750060925, 0.4064017060232447, 0.30210954373042664, 0.5893519751782061, -0.42429418321592965, 0.5590649952199611, 0.6588849468681999, 0.6163705548338121, 0.2049324424321501, -0.2744231013360161, -0.5418770452784564, -0.2879981997951394, 0.5548262177432998, -0.6036259987487599, -0.35685384373297774, 0.4430477000567832, -0.3327086540122076, -0.6651349614990597, -0.4213362614123937, 0.35170997760755807, -0.5252272188559398, -0.41347852717497763, -0.06263728205901013, -0.13716310600343948, -0.38754268839295924, -0.00894095977133968, 0.7338031265640292, 0.33956208776501173, -0.18459855016819884, -0.5418672658972924, -0.2701484552355856, -0.6123989511616043, -0.541357907347501, 0.5783096502978801, 0.4182277096278001, -0.4405974056704459, -0.5289344069820733, 0.6898029358863406, 0.6852883407045893, -0.25609186399292655, -0.5367466227534341, -0.2889803926227304, -0.48505959131973325, -0.32656099777144587, -0.42032307964626076, 0.4460081742966619, 0.6156626415546359, 0.27444656195721845, -0.5021562383419892, 0.6721280891266316, 0.518750927650634, -0.43170975489926633},
    {-0.3527986386011715, -0.39318106646340334, -0.3220989890197226, 0.5823098343458769, 0.5728719365537898, -0.5439973820976266, -0.06187575651963499, -0.42215653376235657, 0.40267042641917095, -0.16637551987023555, -0.6775267128155876, 0.3494152355307905, -0.38051788940541076, 0.7029869286889465, 0.47311318135196584, 0.36676397157016877, -0.4786222612417723, 0.6746063525257966, 0.5457555726154192, 0.7242499616479311, 0.22568690653096452, -0.4811110605718696, -0.42073707960557044, -0.44391193958397934, 0.4374808949167785, -0.4758229368552232, -0.35529604577384183, 0.3585131947985658, -0.5537394299813156, -0.5055879947193722, -0.2774117417146568, 0.38315648799939367, -0.3957959766698897, -0.5358747956464108, -0.014027383611417775, 0.2154188155409671, -0.4615254705200332, 0.12060636351315897, 0.4234053396744744, 0.28198036863297227, -0.51899607833686, -0.42994710843054607, -0.17660276865814162, -0.3111489812237911, -0.2593747568551256, 0.6038644009237646, 0.4591744170670022, -0.45367656686806246, -0.6294080226075683, 0.5771457716369696, 0.7190229016955477, -0.2710281008367869, -0.7000249523122286, -0.3143538526874172, -0.6483667582963036, -0.4408880203017276, -0.33641868167392236, 0.5806048730119208, 0.6501130585126503, 0.5176395698795306, -0.26032626012940596, 0.4576245385650804, 0.45240999560901746, -0.583114833283313},
    {-0.4568321357361393, -0.38480742065904533, -0.5310657332197597, 0.6706252307649148, 0.40886622420500196, -0.5417669552754771, -0.34983135695337625, -0.5344254522235937, 0.48920996535737155, -0.025059210185639096, -0.6391442690612981, 0.49510624909381457, -0.36094182444541884, 0.6843505633228313, 0.5075998133244995, 0.4736123761183778, -0.2950049112071048, 0.538418276158295, 0.6470875821786941, 0.7574007518186293, 0.06090365900358926, -0.3613344309317508, -0.3631449052725944, -0.2535179125414451, 0.6212610613196208, -0.32421146481057117, -0.5564168429232818, 0.4585019439010867, -0.4623086493956226, -0.4972175065247234, -0.26065845017256556, 0.24407961536913633, -0.6099386568510075, -0.4679300410178123, -0.0032196451636973076, 0.1618791334330397, -0.36044350618949406, 0.2786404366238922, 0.44868269206824324, 0.5447495637271507, -0.3107971181393249, -0.7063232061392113, -0.2389830390196368, -0.6555773305317938, -0.2631630280755711, 0.7097179714838666, 0.33500595289723367, -0.18299843309434885, -0.5230214149750267, 0.5357749425613397, 0.5462973402745253, -0.5990822347866475, -0.5459268710238281, -0.32143384516000373, -0.5432754432779598, -0.42351200273128947, -0.42767125216145063, 0.5666346926837846, 0.37563260266836124, 0.5902622037836516, -0.4358385304510531, 0.5123798054186522, 0.46150931813570795, -0.5365611143849017},
    {-0.3225793548940641, -0.47041773136633186, -0.3902923021783747, 0.6439819299756084, 0.29183968169784713, -0.43690078807363153, -0.419447061558747, -0.5547536490399982, 0.6067285832661882, -0.18010479539041394, -0.5181272382177097, 0.44760559617213547, -0.4812191345380281, 0.6813069447420602, 0.576219095333564, 0.4623970870245244, -0.5992572857498459, 0.6854269917499115, 0.4529126845145313, 0.7452485600871533, 0.1389393809751644, -0.6072716096721952, -0.45169543715121746, -0.4002677238356488, 0.261310968269427, -0.6063786013855079, -0.3639008708021062, 0.3979322295774633, -0.45729679100512055, -0.6310530558844722, -0.39909788186681566, 0.2963192839574647, -0.4986817343763732, -0.6270331994776491, -0.12273737322966168, -0.07281170726893209, -0.4967738176386331, 0.09698824958913235, 0.6711114394666986, 0.26565074786601584, -0.38819830914272974, -0.5986859921554748, -0.38832290614121173, -0.36633275657128783, -0.33180347235862095, 0.7026948499600529, 0.4779435222740368, -0.22889465921887184, -0.4515845489835447, 0.3738105947180824, 0.6889728431665062, -0.6315601996351803, -0.47757071436666976, -0.27869825428014494, -0.5260498563239772, -0.49873385039942747, -0.5972866812733653, 0.47598742356418755, 0.5063186516563298, 0.4364327149231187, -0.3730624417976343, 0.7557595323008249, 0.641046311563306, -0.4734258501023433},
    {-0.12555032756393203, -0.5962382284208809, -0.5046709627663084, 0.6125540497729999, 0.49367462724372224, -0.5302097330450323, -0.028332036583500704, -0.5555415585215279, 0.4715481030527855, -0.11413223133870848, -0.5660987726712894, 0.2903182767318932, -0.23731914800096648, 0.49256552907978124, 0.4791117511233679, 0.27485662142297035, -0.4163533667435742, 0.6672053986400039, 0.611849127372066, 0.7271486199196983, 0.31839974140372623, -0.4243045677803313, -0.5132334474215672, -0.3456038009611517, 0.5088614705489116, -0.5486592307348677, -0.4657605684510903, 0.43525618370120156, -0.43771829882485125, -0.6641144103540225, -0.2179142844238339, 0.27425957097792597, -0.6209006300933744, -0.47073047874566687, -0.23828147715192713, 0.14607673092295706, -0.5260356279495857, -0.06610578602024383, 0.3894531893350103, 0.2926486299879908, -0.3730405389178649, -0.5895375890115112, -0.29003280616130983, -0.6604877880086049, -0.4618048985297628, 0.5890643461741011, 0.5442558861948414, -0.31347646065458884, -0.30431373630542546, 0.5285108288069073, 0.7221216938828552, -0.4135160415527685, -0.5807817793932436, -0.2262840222231565, -0.6269958263106303, -0.47972615505970234, -0.4133619290655761, 0.4541929079340493, 0.6042616191673789, 0.30443427668257694, -0.5853034459440359, 0.41024767684139574, 0.4404922931342722, -0.5982092724775031},
    {-0.23036874370182428, 0.11408570626357072, -0.01504013139664861, -0.17638842315182507, -0.11942477870101996, -0.28873350916728524, -0.2194356914600605, 0.10999650582490912, -0.5404081170620109, -0.13876522162347443, 0.03837052666727369, -0.08044778282152461, -0.1365721291233241, -0.4075823249979929, -0.5689963970045576, 0.12739296125158173, -0.03267584537040512, -0.33764593862155623, -0.14906304888899244, -0.4826611928557023, 0.10640863451613412, 0.011436109536977027, -0.12549639425602863, -0.12364705858831908, -0.27975642901844205, -0.23826843345157148, 0.034865207151509335, -0.06062007510929579, 0.1756496158542019, -0.19303387936519695, -0.052267953569706885, -0.4639213643349244, -0.18793855567249385, -0.24182107551190937, -0.41418475190087994, -0.4883274714660078, 0.08596112752197041, -0.27268674359212786, -0.5387928426124297, -0.4916637012553739, -0.49335727815817904, -0.24044663805310681, 0.25115376877822415, 0.20448782077612027, 0.17890224631433968, -0.2805399293278446, -0.5280394592097226, 0.06791888208487527, -0.16929652014449023, -0.13885914946738323, -0.16261598236865885, -0.3151225488096851, 0.011492085703117114, -0.19731357009926218, 0.031810458471042274, -0.03751057339627184, -0.12863548688171872, -0.39121912611979176, -0.4597923979652464, -0.37306177530845813, -0.011738889074136498, -0.1358865893869234, -0.19043696975321978, 0.07934496420792717},
    {-0.4668977459863648, -0.4289848275443714, -0.1321341441352971, 0.17268420935874818, 0.23481796879403316, -0.17109017953815756, -0.0950202200177184, -0.49388362063065283, 0.13541891440306547, 0.052884254165691556, -0.06189979877439095, 0.2778551867213201, -0.36318518374558345, 0.41316800324276026, 0.2161333346172118, 0.018068554700690694, -0.00039109735132443826, -0.05257950337258692, 0.27000793727943134, 0.08632528345091368, -0.18216365166387669, -0.16102733450589243, 0.0617962010032184, -0.23858214292259294, 0.013704218781183974, -0.33398724011390474, -0.2877381940527288, -0.11459146284591715, -0.13921208946122773, -0.20832127618121424, 0.2530191018024872, -0.017656037244998136, -0.03116820807719909, -0.4250442988050915, -0.24374156048595028, -0.25013808376060176, -0.0865543739310959, -0.1945067422666662, 0.30528684442215787, -0.03725123756065197, -0.17141703117939758, -0.5745962576886351, -0.5766366059590251, -0.4676679832360283, -0.14023572992579955, 0.3038688707082334, 0.23199168848309193, -0.06400666250042551, -0.6142446106742324, 0.3915291244623113, 0.17450859320885798, -0.07448854951843521, -0.19627517908040434, -0.1327909244987615, -0.012259324608494498, -0.1522835959051323, -0.24827772318007776, -0.04386932677206253, 0.3788882218660643, 0.36855429321782146, -0.05286748153462936, 0.20977772985267448, -0.13654619814929847, -0.10783904518497053},
    {-0.35246602929322474, -0.2433901001682346, -0.2597550271185278, -0.07313125245061956, -0.12035422460596187, 0.3752674923925419, -0.5503254157961524, -0.18177921544829093, -0.010829627944125802, -0.19498629692858263, -0.3495463526928097, -0.06290243912503049, -0.09687284177796403, -0.025509864888339086, -0.4206656897272059, -0.2614452829588655, -0.4235776144817459, -0.5158649946680591, -0.1318923285415108, -0.25682997742711167, -0.5080284131722986, -0.24398391798064292, -0.16541163052647434, -0.18350579236674516, -0.6473253359946458, -0.40952880224375987, -0.12499822377674316, -0.0003248418412038592, -0.4394271504712077, -0.16479851274042545, 0.4275516704368537, -0.2795484929529985, -0.2900789974170292, -0.2124218293486305, -0.34162402309634443, -0.4772898464840753, -0.09815455506092381, -0.43134565968041944, -0.16009230228519006, -0.31210090718557637, -0.3774332731471971, -0.24216383095027919, -0.45089753767370283, -0.154229443464625, -0.43520229853451414, -0.12429153740728532, -0.5360963330312997, -0.3790240452675325, -0.16424327663388016, -0.23752118369811287, -0.0011433944382563128, -0.14202200148736294, -0.12171401575538354, -0.24178017155428397, -0.35602461770102595, 0.24111259032060386, -0.5665828733166501, -0.002374767410173543, -0.13164853244565583, 0.39764169561114515, -0.23737706905327866, -0.42993275986230933, -0.5676475373973262, -0.44758499335794744},
    {-0.21778008400245896, -0.10030540952790927, -0.31137990510760893, -0.038766865466727765, 0.05509765426995912, 0.14662760171852096, -0.38675647234784444, -0.20563876800976816, -0.14978137520499216, -0.17247809569621467, -0.4942409201961173, 0.07574827665988902, -0.38804902255631535, -0.2655042634403218, -0.14291654196084846, -0.19837554297258847, -0.3975127481219931, -0.22340068513293226, -0.21395561337898275, -0.05472332514335348, -0.43669808863377774, -0.3048326757982969, -0.1863781726550334, -0.5991249952435257, -0.534594976777506, -0.19380075561145124, -0.18146448490045064, 0.05454955857093407, -0.4203357066566176, -0.36834054417415973, -0.03298769227360724, -0.5554825423710609, -0.2866054181536555, -0.10348277264459477, -0.41145221447542246, -0.5459018359314097, -0.390801102460254, -0.2650331808704547, -0.10552629733215649, -0.5323382123177147, -0.24439886757723542, -0.33832849876493115, -0.08121224355377789, -0.3276741594728301, -0.35833941619749726, -0.36953424253910355, -0.4472253168973484, -0.3044321369640407, -0.20340739133491806, -0.17979729135314312, 0.09471826306951306, -0.5499010865602111, -0.056071960060213366, -0.18718978693202784, -0.3153411983802196, 0.08574829354773658, -0.3715290481999291, 0.09555092875922597, -0.08633071995341492, 0.19146779568876293, -0.3706403033362817, -0.5119063758117802, -0.47242922300770107, -0.26016850551803206},
    {-0.6123852418667591, -0.23799277985666467, -0.5452546839994268, -0.10533107747001469, 0.11971478940483272, -0.20355959737609017, -0.48913119829738566, -0.5584286583024731, -0.175665569998129, -0.5010461099704803, -0.4992809541131364, 0.09269608885837714, -0.31071314486462365, -0.0334623285278147, -0.23916836061138994, -0.05736892783294388, -0.5195297216239962, -0.3105771483095553, 0.18737570541074108, 0.01958223148645583, -0.3221925323390548, -0.30724236781351333, -0.30008469679369487, -0.2598727222747418, -0.18505162340798367, -0.3268680583193191, -0.5403850213074288, 0.10500805049056663, -0.3835403477362487, -0.5202924950114638, 0.08889415583038014, -0.22125765311390816, -0.07229346987909693, -0.19039700547583185, -0.3468525450114517, -0.17703165141667815, -0.4349054706243372, -0.20842839055423837, 0.21497939512580277, -0.30238376676570217, -0.5012999609085955, -0.5242982411320822, -0.4751059122347758, -0.456512435531758, -0.3863024351917021, 0.1361629492783691, -0.36725539692789944, -0.4625470586004323, -0.4573398308147674, 0.17574817813684857, 0.008743310826745666, -0.24232170870607908, -0.6310104478682884, -0.647187453727771, -0.3434870597729708, -0.3128747833881214, -0.46352090460841766, 0.2788809135896595, 0.14105187224976135, 0.41333844611060194, -0.2127145916234987, -0.14878649978575548, -0.3093314316422079, -0.6193584595859197},
    {-0.6571562645007789, -0.3594405577068732, -0.2640605705279866, 0.022549879431141544, -0.030688507726911705, 0.06819031274942913, -0.6244635672172162, -0.5444643939832122, -0.26797457335253544, -0.32018254415675046, -0.5848799806020111, 0.09972419377440159, -0.4832974547913343, -0.23793346992062514, -0.023544643728195057, -0.2560713858304945, -0.6437603200817951, -0.15587346323386367, 0.11691435365893767, -0.14380728051990505, -0.43397337493135546, -0.29562724050692213, -0.277155016622075, -0.6090413777068255, -0.13111307135280967, -0.4542543944031798, -0.2864171979761446, 0.12437885673980914, -0.6056013927915365, -0.16509733407175683, 0.2898750588193192, -0.5523418017104753, -0.34524638381501865, -0.29987550948150465, -0.552915917268366, -0.3536616375012471, -0.48323215554262966, -0.20299135432447368, 0.05880702115197613, -0.507250884856282, -0.3924888685646116, -0.5956467107087292, -0.29131682206335746, -0.09282726712663558, -0.5356319756638325, -0.14977964222620951, -0.39714769996934174, -0.47970279079245326, -0.5860754317367265, -0.06177713701525851, 0.22257318418850722, -0.5885989487980477, -0.598922597590942, -0.509244254679653, -0.4735667649950444, -0.21452148431755563, -0.5573454688561927, -0.14871840615292897, 0.01932829767816426, 0.15729970401643498, -0.5237977077843268, -0.12121570096005299, -0.34018921811022423, -0.5216105299957416},
    {-0.507508376885131, -0.410444219646469, -0.5974072736345024, 0.041575124673197246, 0.016395619324884154, 0.0757445179637802, -0.5506285483547948, -0.3432125240266501, -0.13011854829135694, -0.6224422509164471, -0.30128792285960565, -0.043773441691773066, -0.536214631412364, -0.03579243642421798, -0.311486318915178, 0.020289912317104336, -0.34566102021860373, -0.2609128508748519, -0.013884910828391519, 0.03550506566526774, -0.40997414711433167, -0.613292960897357, -0.22598554450081937, -0.39704226051283414, -0.5202130109504765, -0.23982663613197944, -0.1237783898392309, 0.24843754076257415, -0.44945181293815695, -0.4256591924598575, 0.014186738765089989, -0.4460494983153249, -0.10134489060293381, -0.08758532122230822, -0.4008158071792305, -0.28908952979434127, -0.14453050111798052, -0.2739369649200303, 0.22536118810769942, -0.30057383370982566, -0.36446839741631454, -0.3092765275718642, -0.11355369023806934, -0.09876612306052703, -0.42017210114893505, 0.12182707215162483, -0.47327653216153837, -0.48953710627817054, -0.5217904609279718, -0.042072263827857156, 0.11967519658647612, -0.5802141936089431, -0.5994857633033803, -0.2949641374842404, -0.41265997011284095, -0.4241421397092721, -0.4753577222699044, 0.08628884364546897, 0.19413388766716846, 0.24175778008429577, -0.46160017238551937, -0.37831900619159614, -0.3177797803164128, -0.36019369606838086},
    {-0.534560540080018, -0.5707183859584386, -0.5402440475652168, 0.03049914309300217, -0.2405027107835085, 0.2022492368561899, -0.4362702364778505, -0.46908173403882397, 0.04637227641859451, -0.45899084938449525, -0.30496281604170056, -0.00038960391105375536, -0.40239765253845683, 0.07816798449243292, -0.360016013069805, -0.4203253229865127, -0.5316404935145647, -0.2906961212254595, 0.1196180715573683, -0.26756571149838193, -0.20724397034941341, -0.22208942024409312, -0.5576399534339178, -0.2782826342463885, -0.37049527954797057, -0.22066923575346375, -0.1600289575924173, 0.13862264277434994, -0.27377378234501765, -0.23302325008788058, 0.29100340050673773, -0.576714653625258, -0.03257851600518271, 0.10052269947205027, -0.5321286049330463, -0.5521086953393158, -0.34846903261970213, -0.36859151564267556, 0.19649255168264906, -0.4549407238912753, -0.607030421855678, -0.24150886220412188, -0.5358339908051695, -0.0968843083783385, -0.44217430887207015, 0.0455215390984921, -0.19821735430604223, -0.46743417202411863, -0.6481458190803194, -0.26070774724720347, 0.06663757688459486, -0.2267367109798378, -0.518083874736525, -0.528986982961837, -0.376236290506661, -0.3053528592583153, -0.6850407332230056, -0.07886160683733463, -0.0796079159502904, 0.037594429094699004, -0.035840878020458135, -0.07790864084736797, -0.2932839618110268, -0.5487741072144643},
    {-0.40297387783944577, -0.5440188840926325, -0.502242451590415, -0.16362681852204408, -0.05205213749821547, 0.06041463262502748, -0.351375445997609, -0.3870794563104961, 0.1890484110349969, -0.45068791047125273, -0.37941077674504303, 0.2574410357797446, -0.519657528466062, 0.13200980907722482, -0.05056029473969612, -0.12740010344031588, -0.39976077205342364, -0.4000361588325125, 0.009986076030989333, 0.012552876523664104, -0.38333097025267104, -0.32498766739069074, -0.20837991971218356, -0.3409548477189827, -0.290212181503287, -0.4851244616744963, -0.5334437470602719, 0.05504365669651822, -0.5100185395982892, -0.27057652734419124, 0.27146576446185905, -0.46488154222716177, -0.28336394698409767, -0.08093506306523181, -0.33139415941815964, -0.5579330936008245, -0.5192703633205373, -0.4589314898532627, 0.09486181143703543, -0.3652800457647203, -0.3084127574221668, -0.34533985064202904, -0.6080373175363519, -0.23091066808148009, -0.583843103967284, -0.08123787530306417, -0.23321407136924754, -0.32656499020708557, -0.600604664233446, 0.22675807862330544, 0.06122308220812027, -0.4315219722739388, -0.36864664530529384, -0.3280957368334643, -0.5686389212683237, -0.04294775250275853, -0.5005437256330567, 0.18933557927738484, 0.16669717925374913, 0.23752256735999366, -0.13646763837757048, -0.1989063911014948, -0.46613697311694224, -0.3224810029349588},
    {-0.4511420574426629, -0.40190083898815093, -0.5812637280733901, 0.23183432495459397, -0.019924797895132636, -0.023029144447163925, -0.5991099657639414, -0.5813915348345409, -0.005569322448356124, -0.5379687171871296, -0.4802203348700872, -0.009986799844703733, -0.42800703380952, 0.03296406619492301, -0.11386803053257012, -0.11574813503943483, -0.5831952260654765, -0.15373263940336376, 0.2483161722914905, -0.12552888591442576, -0.29688280739436773, -0.3350371734673611, -0.4350518168551932, -0.296127332326543, -0.2797772239129965, -0.5653529318697029, -0.22572486088708316, 0.09642586026330759, -0.2868132165418061, -0.4848210888988542, 0.3382379440722675, -0.3404895855187984, -0.17186355334605347, 0.05977208003634086, -0.29704648197237554, -0.5462380983373094, -0.5955445079167604, -0.3670143673811295, 0.2129758479416682, -0.4034547730889167, -0.5927078434774532, -0.2578241677806141, -0.4894017445430156, -0.5061006084965203, -0.507331328175316, 0.07543299653148422, -0.49773318644230174, -0.34790040055164906, -0.6003307344917983, 0.22898730168974418, 0.1917434470902615, -0.4307566077423937, -0.5996383278567052, -0.5759228272258998, -0.5801537760972515, -0.008946081980007464, -0.6893327992557455, 0.09938942451013313, 0.02117265583684847, 0.060289054695924514, -0.1294991842039155, -0.36463631843111516, -0.21860668106910258, -0.38026687618670324},
    {-0.5461395847859045, -0.39561716068184644, -0.44589307948070306, -0.08752034206129869, 0.10740745733451729, 0.0623665160714146, -0.6824744350578188, -0.5013998474144408, 0.038535009551106204, -0.44607099656770133, -0.2897005451330006, -0.03895856683008273, -0.5536732841388942, -0.10596950970609209, -0.3967270542311697, -0.14164273594954366, -0.28790889762678706, -0.23902111727387562, 0.10779828347102426, -0.34226746481914644, -0.40427192676985346, -0.3259748490573737, -0.18982796767257304, -0.5065983723894829, -0.4828121820104171, -0.25312952923306703, -0.3661934942708724, 0.10145331617912723, -0.30155136859537063, -0.32182113859762346, 0.32167030030361765, -0.4217912990737311, 0.05916401505229952, -0.0072310243908239825, -0.2907401342741765, -0.558261465971462, -0.41175501075766413, -0.282994300340314, -0.03412618285996231, -0.3135344371298142, -0.4659608995603864, -0.23697951924803476, -0.24550656034445098, -0.483522778176105, -0.3507677733387795, -0.3037027234954408, -0.38714780984184083, -0.2873175832708928, -0.30086988964628414, 0.03973313516640552, 0.13734589767620242, -0.3733685993344149, -0.24155117692687125, -0.6392339956571735, -0.2765933947996558, -0.1783064906003627, -0.6306051291191652, 0.14412596420712834, -0.2373758233815843, 0.1783401803943315, -0.21079866459994828, -0.43983441014523383, -0.47187951627843966, -0.35384974704341876},
    {-0.5539732742222526, -0.40121809233116695, -0.5581286719298301, -0.09169897520515266, -0.05090407056650945, -0.17776262111880767, -0.3434012734468322, -0.3780326839087033, 0.053210300013063316, -0.5222806019973694, -0.47086927784793614, 0.21829842731453655, -0.33121075303397385, 0.0853781431461648, -0.1881376685604116, 0.10913247426911239, -0.24137333147434856, -0.19146048070634944, 0.12053661583590476, -0.10845653117805623, -0.26107121224239443, -0.6058357053874965, -0.2748821752935917, -0.3876700070749468, -0.33183055825422103, -0.5481782156499188, -0.2732455807695407, 0.048719893589174085, -0.5690254351044902, -0.1430910391589551, 0.041102033815294765, -0.5635441133228885, -0.01874386462185452, -0.21009173159979103, -0.3461191521212217, -0.28714150271473127, -0.5158145654896259, -0.4007282154893935, 0.25146130402042033, -0.6815367713171909, -0.2768564965294603, -0.42045358473855426, -0.5062576345279712, -0.05947715911591441, -0.5337419495095094, 0.06385785771163083, -0.43812568198604646, -0.22376121239943655, -0.46821814322151895, 0.0129258488468468, 0.14482139494734325, -0.6452714411596395, -0.5555834203106669, -0.2936171445143211, -0.2628448290773568, -0.13177977695744805, -0.3409986063284243, 0.2978455455440181, -0.12112865596822575, 0.35093677214876884, -0.40087958223875403, -0.42156817859804774, -0.4277323273827232, -0.45278321773784175},
    {-0.4636254080630499, -0.3263267621693239, -0.4953289918896609, 0.024290619153645512, -0.05955349707611507, -0.13517593378763534, -0.6247051408913897, -0.5668552699771803, -0.013643196277716397, -0.5097500257276596, -0.5986101429429114, 0.0352477961564756, -0.43984053163659903, 0.07848898263838809, -0.08584839699122646, -0.006514898369056291, -0.6352445655941548, -0.37922264331909605, 0.08602689926076128, -0.1561810948231422, -0.5726080657430729, -0.4557715791209794, -0.5032841211442798, -0.5111846207605771, -0.5507791639081449, -0.6061373068645672, -0.21307472188323034, -0.03703036612286378, -0.32331004042436295, -0.19576268144857173, 0.1497166080031291, -0.46443020536472535, -0.13798257743979372, -0.15848652174984082, -0.2848807675021406, -0.37734687877286915, -0.27296130296805715, -0.3605904264578552, 0.01705561925239006, -0.531413501271837, -0.7041945314214746, -0.540073673186709, -0.5645055552802026, -0.12058728148773294, -0.2671679908997825, 0.02209489807788601, -0.6950228875934258, -0.402310418684338, -0.43195138852166326, 0.05617807952049536, 0.28661243876095105, -0.3877872528017678, -0.634035242606286, -0.47870761923267935, -0.4956810685069003, -0.10867065268288577, -0.3170487859482751, 0.16979091008382566, 0.09363559094828759, 0.13456529467865913, -0.26974817739519674, -0.23708186262296482, -0.2513507587247184, -0.5442195914816568},
    {-0.57018527119769, -0.3003716834903671, -0.5789782274534727, 0.10733991160303216, -0.16292907742641824, 0.12873797557056216, -0.636334259611149, -0.6195334352501293, -0.20286607349295513, -0.5804393273123063, -0.3533187274394675, 0.07190313797723903, -0.2313760309645784, -0.0037775462696579675, -0.38843420663421374, -0.11050245780631773, -0.3733709421743687, -0.23868424929765472, 0.11105019319792392, -0.2664926837371079, -0.6256078058438328, -0.44552915582665364, -0.43770757306370406, -0.5372659611660747, -0.30974842596100904, -0.5455287180582591, -0.4420845260424993, -0.004372499941651666, -0.29100010167189855, -0.4313339499241444, 0.16642335107240624, -0.36456192060254056, -0.40379841596354643, -0.11063302079221142, -0.2136849805621384, -0.3138679807675996, -0.40514912452392077, -0.4217650666420897, 0.2092188785251556, -0.6880855052084375, -0.4617508923352212, -0.41896671941210756, -0.3563130801667107, -0.3337689233550026, -0.5869159222066633, 0.14518013954173187, -0.46126733569163403, -0.31123277976189867, -0.6058044145581027, -0.0023078908717265806, 0.12792286004846112, -0.23748103335156723, -0.4640172934528358, -0.5123600682492272, -0.24284502845428002, -0.20975912462623195, -0.5334931079222006, 0.046070985861900025, -0.0058913263384672366, 0.25396295855491213, -0.2513160980269431, -0.3432789996264579, -0.48331396963697004, -0.5114227987215811},
    {-0.4759964289793815, -0.44044014401781967, -0.4955650039441702, 0.10440545017612496, 0.006371770814888676, 0.31304204410761893, -0.6667468752776939, -0.5102404361449416, -0.048888365932346446, -0.4716132972053091, -0.518568042768444, 0.3765364800150923, -0.2928111647814438, 0.18715993659630195, -0.24397652807619924, -0.00737948017905258, -0.301142333581271, -0.08601249884999948, -0.10755789481304406, -0.30320886300486444, -0.4846991501244089, -0.261664004726754, -0.3810127605700925, -0.4726576454174768, -0.4571355547830979, -0.33807576189944377, -0.30903323437654734, -0.013508819153591317, -0.5292091952650987, -0.4622219932312541, 0.4027667214214742, -0.4091271652254702, -0.20025107736737593, -0.16903276575948942, -0.25595691080208555, -0.6022185211818755, -0.5482692875063682, -0.353409022762045, 0.2212417261122692, -0.5036412714561389, -0.6864181513831006, -0.24208894167317324, -0.46066753486460754, -0.08642152409741456, -0.5037901369598179, 0.26987962411810096, -0.4130957779380323, -0.35216677905134663, -0.4714514486205632, 0.25086788729501097, -0.10177474709366818, -0.3560224287892261, -0.36424768602332763, -0.5484225876033043, -0.28438238969177765, -0.25919811269808485, -0.6559759844621121, 0.2153896698125807, 0.3111309927035561, 0.25912389828692006, -0.32347657909362787, -0.4303459620406642, -0.47585960739630156, -0.46212284328269626},
    {-0.38705572471132543, -0.31884203176953657, -0.5448702600040256, 0.18801459580032065, 0.01738732604954024, -0.0484866555692494, -0.6558754640488769, -0.5577337871918973, -0.03167222518642057, -0.4738872880231034, -0.47096170340131227, 0.2150251126373558, -0.48770247530909083, -0.2289441634785145, -0.15030057298843055, -0.3151101328112836, -0.33034933992299637, -0.3439756652267053, -0.08702523513425751, -0.03430506913269308, -0.4674077688224957, -0.5075235430534157, -0.4184021494945753, -0.42826421696043915, -0.34622512827485236, -0.37803917187365604, -0.5358525626753311, 0.11185029893975978, -0.4382226960766053, -0.17776359486364904, -0.025818599313250496, -0.4274824190147945, -0.4507224913627264, -0.07321509395863439, -0.592219237057331, -0.5339250545443222, -0.4381086236907635, -0.2832406322175419, 0.2301519984725057, -0.5931808345749815, -0.43380453838707783, -0.26998182666371096, -0.29639241876406247, -0.3773157686087086, -0.2996660966094282, -0.13524854439755138, -0.48049056881408814, -0.5728986457699657, -0.4001467083054591, -0.00859528907681487, -0.12219571528158356, -0.5175220302644673, -0.3139109158627686, -0.48007775079198306, -0.5013887656695029, 0.06432877918601994, -0.33704553052534053, 0.11101911788438748, 0.13654359656699594, 0.20965822095255818, -0.25641619297452134, -0.5050592754713962, -0.22329353345684755, -0.5785676867059707},
    {-0.6028750927291024, -0.3827917326092619, -0.4929082446536319, 0.1907286109177897, 0.022603871037294117, 0.08234907631694449, -0.4212155677679694, -0.2868524796780275, -0.07781937874489624, -0.17639908227365017, -0.45160746500030574, -0.04828150283537865, -0.4573651256049285, 0.13600007508665127, -0.06429461735810271, -0.3854169482512704, -0.5701969049091763, -0.3699995058813867, -0.17611327806369909, -0.04419649269228796, -0.44482291028166887, -0.3530980424058096, -0.35571283710768276, -0.5210658931886297, -0.5045834587292829, -0.5568167719480657, -0.388707209741288, 0.24242032313053619, -0.5637631713798814, -0.3781922605097484, 0.1388815537444366, -0.12657190462480658, -0.356042833616061, 0.12906462751139144, -0.2752509318457928, -0.3220872670350396, -0.4941426277204043, -0.22302231452218377, 0.27834273889961386, -0.49027799048181503, -0.5680831227298363, -0.257194069745159, -0.37414218091590334, 0.026648901350526815, -0.3153146755701049, 0.08603418265071885, -0.3433984215004742, -0.3294088797592538, -0.41008108728363385, -0.09200184105551547, 0.24104541156756523, -0.42473466684701683, -0.2416045008281062, -0.3428859045803593, -0.5459212348280946, -0.21077087851367424, -0.6033669011783177, 0.13277189388847127, 0.20772357288813337, 0.2511005982877223, -0.13008603991315884, -0.4435773751059114, -0.49870337072321697, -0.20651179689021962},
    {-0.2135516690349742, -0.38651202806840607, -0.5921235197846707, 0.25669156460535375, -0.03887128091013691, 0.3517058215250931, -0.3928594056471042, -0.428712419220183, 0.0958497935058466, -0.3186464023913872, -0.3526025550395201, 0.13468584996553065, -0.4120448270173332, 0.05194505739858059, 0.10253007281260709, -0.15764540087145576, -0.3830424258072033, -0.21900072650824676, -0.02466584098487416, 0.08176155466674244, -0.21009703600366036, -0.5262680221955479, -0.27978649647042547, -0.6020492564374954, -0.3039001914004524, -0.1803251494572663, -0.2699350316457231, -0.08288460358219428, -0.23012901064711816, -0.35792930972258996, 0.3189420355781292, -0.09906320669255456, -0.168423593727007, 0.028652814455491296, -0.555824938435255, -0.28433473251482155, -0.29809104727478214, -0.4727740947323808, 0.08701014521558001, -0.46164837097920663, -0.24450342048967233, -0.1847428972768316, -0.4372352431296002, 0.06532660447784243, -0.23289442995137044, -0.1350624106630625, -0.44713399396935954, -0.24632476427332908, -0.33768677184711765, -0.02671309062309983, 0.21659748167965662, -0.2609529867456951, -0.2920037029262014, -0.06538708741568444, -0.3979091782166876, -0.17287716160949107, -0.4799223418536813, 0.31279590792795764, 0.26960774708042523, 0.42323760196287624, -0.07214183175872715, -0.4216353423636078, -0.12934646351608492, -0.30751315887208225},
    {-0.46481645449302217, -0.3248070982568616, -0.5730395541078802, 0.1506124981842017, -0.06999111438920269, 0.15507578949721798, -0.7006401719246782, -0.4449859111907798, 0.05814533439573252, -0.49305852945213247, -0.5610325253984404, 0.10037353481275127, -0.1508329182941735, -0.28935966252738116, -0.20519564722796002, -0.3542725187675938, -0.28785799961027897, -0.3713454033005056, -0.19492434333965666, -0.12679407762329797, -0.5765354769446029, -0.4158941133012694, -0.5672906255986246, -0.6709775327873546, -0.6027633027692301, -0.501905132962752, -0.2652738376492184, 0.07123692329727954, -0.3404620029676984, -0.30619575060948256, 0.2931173886824964, -0.6188804111968312, -0.034835565502537726, -0.2749016588685124, -0.35279219430629805, -0.33788159490778824, -0.37210145623298874, -0.4065873390740964, 0.11129512147644931, -0.46990868614913833, -0.4128722270448999, -0.0947310798819528, -0.5026623717256293, -0.24070062401860046, -0.5852426926641172, -0.2703678101566736, -0.6319372165114034, -0.5191904657361367, -0.31719871411471123, -0.12105456667979328, 0.14712101065463667, -0.3455327930287817, -0.30113542815016353, -0.32838049760697857, -0.53549500246792, -0.32793577408155083, -0.31339988762967486, 0.06400293880954212, -0.055544808507076306, 0.021189767500498623, -0.014090230581109054, -0.548504807923941, -0.5043874246444823, -0.5483948337070158},
    {-0.5191589121048742, -0.3907645154847082, -0.44574384196044137, 0.14115152398158293, -0.015676402042003355, 0.19185096202685104, -0.6721195899662499, -0.5563682460331187, -0.07285288127946053, -0.5681582056876168, -0.3259736693371786, 0.16171519452803856, -0.27523162163130294, 0.03844610240233138, -0.3124308441174445, -0.17858713727582173, -0.48921453142709287, -0.5661874653155837, -0.1490138196403631, -0.10751004763294034, -0.3561909799667432, -0.3904958607388841, -0.3386076632777776, -0.6613508265527714, -0.455928530834855, -0.5183878010832125, -0.2872264863416209, -0.042985115381335835, -0.30809745814194445, -0.5176358603323687, 0.1459664437980526, -0.5244188105518752, -0.1145295103400205, -0.09237275174907261, -0.3417030927501713, -0.4001315476566507, -0.30307381367149017, -0.37893340871262016, -0.14871663044973163, -0.736251378206462, -0.6935393311715856, -0.45017950628439796, -0.46910054870207335, -0.3885087761592243, -0.6241156865453745, -0.04579221364177352, -0.7021758877472983, -0.462955428232814, -0.589364857111949, -0.15669578393261321, -0.04013094859545367, -0.5504330083785456, -0.38792445469821196, -0.5759389526005895, -0.43594583544481563, -0.15321495914351269, -0.34918834252392517, 0.2669264248158967, -0.02372448169548953, 0.17700766527838346, -0.30432211176047214, -0.4215050155773463, -0.4062151674601444, -0.5550261923632883},
    {-0.44802206320358184, -0.3913360885954219, -0.7283561757178624, 0.03746602449524472, 0.08494993334083856, 0.10295303595451834, -0.5528005017877774, -0.5558443927972455, 0.054616537819898205, -0.5663232411782377, -0.4896143672957716, 0.14718721391857942, -0.6703671961144955, -0.11402598133489367, -0.016739110210378962, -0.11612635971042988, -0.3927143843573917, -0.057839643805254574, 0.06210719740988218, 0.02095752291900128, -0.447505417360559, -0.5556782676345303, -0.6436184026481943, -0.6212361754692084, -0.5390477838719104, -0.5714153040537081, -0.46759141172309115, 0.19471630569971018, -0.5094976732432966, -0.5988559072945281, -0.09010684503498824, -0.3746638670134213, -0.36294819778110227, -0.33960583449233855, -0.44384922279285205, -0.30264706480392606, -0.4583656416288769, -0.3131121781649563, 0.1397567393437249, -0.5988217386289892, -0.5673522882415507, -0.3840344163380362, -0.5403513473706898, -0.5261892042685213, -0.5283364365262591, -0.03724603606500585, -0.4308646046328115, -0.32743677414947103, -0.4734071590302767, -0.08750096829838418, 0.05993764792203214, -0.425496564528794, -0.5870669254848032, -0.5936016993494384, -0.37347600700208167, -0.46407233095483486, -0.48611603851326896, 0.1633280574586238, 0.09836447078482109, 0.29823639487718917, -0.4561157216790808, -0.3356402029452236, -0.5531244780369946, -0.5213036139835961},
    {-0.44712540570418247, -0.24533908064396828, -0.42149557636628043, 0.3015593098983286, 0.0943321175193344, 0.20266449017717972, -0.499912649391356, -0.4676006448339811, 0.2885919901606879, -0.45807264368426187, -0.3751595843489362, 0.26730462201958927, -0.08605639981504218, 0.3464211003918069, 0.22004524480396062, 0.2631080751279078, -0.17834361849713234, -0.07513347781097474, 0.42066616206163027, 0.21174499505764285, -0.3711159388179301, -0.5323844709923599, -0.30890195183930375, -0.4876298742926573, -0.22651334825736558, -0.2605201437569855, -0.312519344237792, 0.31765296570525925, -0.4210758889441754, -0.2704029726427938, 0.4826196299312522, -0.3159903790925837, 0.007974627407162262, 0.10697044546287353, -0.25796221874772834, -0.3717556539951474, -0.18998671141660659, -0.3187205355411312, 0.39293846259047716, -0.4733456881621262, -0.4319834611185978, -0.3623298248966584, -0.3732586468379086, -0.04594316214873523, -0.5119233698989318, 0.5309962862413965, -0.5127517817819588, -0.5567458213152461, -0.5725809686102645, 0.4598981811312462, 0.2645516706265181, -0.23661398048821328, -0.2108995849528189, -0.4599277253446146, -0.19419437762434238, -0.061569906154492544, -0.2169374559120051, 0.43799521361510774, 0.3639966992831167, 0.3583762842114684, -0.08249629018015296, -0.1463752967675924, -0.35421425980661714, -0.3296647950567988},
    {-0.36553114894934763, -0.01089241607658161, -0.36990029341816943, 0.16475993109769, -0.007878757497717563, 0.3819427303087683, -0.4321100448242633, -0.35842505074310343, -0.1116457606386718, -0.37029358952932506, -0.1974366630807181, 0.419215569034374, -0.1620907392304884, 0.19270133925699853, -0.09039711167416721, 0.1904255477417181, 0.07313559772680371, -0.2612505966804562, 0.10424879429966703, 0.15953127969776287, -0.3774757330816333, -0.06480416098483219, -0.16233789570496437, -0.5073726627609041, -0.5316035779745943, -0.32450971844491694, -0.22444888193909424, 0.48269278144633515, -0.23277279437554893, -0.22684783401849332, 0.6787319642726477, -0.35117135562836693, 0.22922282387798287, 0.37297627755415014, -0.17546240469370658, -0.06533884969764944, -0.2955171200337154, -0.34018824954217947, 0.2365492302341107, -0.6364290163579674, -0.3929041003637554, 0.2795047187155212, -0.21031812863700078, 0.4330905292453833, -0.33025111502574234, 0.305061702226086, -0.37331849286934227, -0.4802654130838163, -0.25649777343388047, 0.20036854982426058, 0.212583223938683, -0.19630517012787196, -0.15947813753999604, -0.15342121101479092, -0.16298523460642483, 0.36455398515319554, -0.2157384067465802, 0.2896386283243093, 0.39109401678236694, 0.36243469671435635, 0.2948373882970111, -0.49286042677337727, -0.2222482180341794, -0.14268903059632118},
    {-0.5995273779661529, -0.1533851954289427, -0.49755243896132184, 0.027180636302876912, -0.07018452675823433, 0.4957306100700271, -0.5687535501266318, -0.4129628286192083, -0.2770341024099161, -0.5363110063677327, -0.5216784619479691, 0.363661325142393, -0.22997380025815722, -0.2698600446121482, -0.35989062840051095, -0.13195245381893322, -0.5310195947758422, -0.23823992804002128, 0.2460030124206051, -0.08865666503187859, -0.47776461773212836, -0.16855726244956995, -0.38231983928474167, -0.5693987006856864, -0.5166726032161727, -0.39221273951526187, -0.21662861426446522, 0.40739515303921686, -0.5094659112354155, -0.4786982972298864, 0.2686599632546104, -0.40351590941899795, 0.1289800526447555, 0.08936267925180491, -0.5241218876621768, -0.41461672417402035, -0.45530328311822477, -0.47032574990361187, -0.0046802172004852625, -0.4833464549111735, -0.5534373028817429, -0.14935582806871253, -0.11304321203309853, -0.117003515695349, -0.4440079258868692, 0.12772045116642688, -0.6790400179018931, -0.4916313706151149, -0.3863587299512515, 0.29012030886529444, 0.013567474632497224, -0.544121029050782, -0.34596048470441265, -0.14169973173369071, -0.37646303638494116, 0.07580647875554179, -0.5088366926198582, 0.37770379251302433, 0.18444829804420915, 0.41773939248724684, -0.0993941459634387, -0.37698213534018926, -0.3389772470523704, -0.5591884299517335},
    {-0.6185887140503153, -0.2900482886072483, -0.3647860850137827, -0.025939139346066904, 0.02690954389433393, -0.056994667760641674, -0.6892286406316878, -0.5524573128933763, -0.09303392439830495, -0.6337602255817832, -0.3797699009833884, 0.22812005527390344, -0.42460113634728386, -0.12465040358597414, -0.06463623928213107, -0.03274499214155426, -0.3391840570987194, -0.49260994184706314, -0.08210665932792029, -0.08549419127927145, -0.4378724633927308, -0.2732322229071141, -0.27623080763259655, -0.5747988915353057, -0.6501830660825016, -0.595362735338569, -0.47299882158648265, 0.16661588391817322, -0.2709338339663469, -0.3341123485787323, 0.2767356444652505, -0.45480006680385954, -0.29643980628706307, -0.25494470920501927, -0.3610271204537256, -0.31776931011940096, -0.2922117416796024, -0.5474764686015009, 0.13081855485687988, -0.39015314569934434, -0.6459312146339687, -0.29179587315852007, -0.24497859168746353, -0.21253225862744948, -0.34167545183857706, 0.15390914979296366, -0.5134196614623451, -0.46378045496117737, -0.3523852840461335, -0.060932652644404506, -0.040575139578824915, -0.35114411390453987, -0.48178562209713954, -0.47235351062559633, -0.48606877210186966, -0.12563663878437153, -0.5678139306210004, -0.0003484253915586792, 0.18498835527835183, 0.31264561740687574, -0.19319985615899646, -0.5623578487971987, -0.5243777850204226, -0.3445075174786748},
    {-0.5685881498624844, -0.2357634503797981, -0.5742668926573179, 0.10253672746893762, 0.09831303816186204, 0.411175818885194, -0.6763351136504553, -0.3364564649229986, -0.049087855796074324, -0.2830617887996339, -0.412715844366246, 0.23112587021038167, -0.06992321555294426, -0.002832855090597664, -0.21783741643118387, -0.1378840080793849, -0.3111273002791409, -0.564597585578475, 0.10995622277076389, -0.15597402296858276, -0.3521237963461812, -0.2712291519674082, -0.33524658150342435, -0.464351511639242, -0.40404385867750076, -0.415738427333043, -0.23970286182388842, 0.11595181824923508, -0.41067235499108123, -0.38917182822072344, 0.15515754819582803, -0.5945694366786326, -0.22619813244656228, 0.2220575112725285, -0.31958212719931933, -0.3378794241054626, -0.27133874567608535, -0.33492616868865166, 0.04338132675928853, -0.6640472583437441, -0.632579388609206, -0.0929797504740356, -0.19395576762330416, 0.13804111214890372, -0.5050093627213631, 0.13449940249669554, -0.6453396900800589, -0.41941272982398764, -0.2621651884967833, 0.06253343094089212, -0.10327899931293213, -0.4692497764776039, -0.3536630103838286, -0.13885866077805037, -0.28012908201961356, 0.06860062197453992, -0.5432172936100149, 0.12167201041985583, 0.29354049605593896, 0.10531665307449964, 0.08359591030748989, -0.6555071740516171, -0.5799653894581915, -0.44276357338880923},
    {-0.5089152581177161, -0.09152501366142508, -0.543317475091174, 0.05493610103403812, -0.027288697244492108, 0.265355748369047, -0.7052360422970951, -0.2678775388079435, -0.04421333678741351, -0.34077161137034606, -0.4734463899954516, 0.2956583511803391, -0.2154244620745638, -0.1366717014570886, -0.18214226585042764, 0.09868745286357523, -0.4927337411348077, -0.32545732288337437, -0.025649521241891696, 0.02127494395920772, -0.6027418974410241, -0.28652755049138956, -0.18332051483783146, -0.4163390661705488, -0.4090407344655113, -0.453229641606582, -0.302740559263236, 0.12477043257064065, -0.15654142119849673, -0.19850949903233553, 0.49052124565743443, -0.3684842474175391, -0.046634556800149184, 0.05789207757856097, -0.3192020925894907, -0.4076207694618323, -0.23905562357036816, -0.3341232432234691, 0.017428144924781667, -0.38567554028052686, -0.5007212246634359, -0.2633034212563233, -0.05841004933387895, 0.19915605829743208, -0.5316085859773337, 0.04741745369595901, -0.5032869100978014, -0.35151572411355503, -0.539395968829422, 0.24236649292536272, 0.1712166215452244, -0.5041382593589883, -0.3142773500116863, -0.49705746210444857, -0.19404799507910067, -0.12693415278202697, -0.412852380623061, 0.09837327714241738, 0.29621076719494505, 0.41128187959544893, 0.1392293802159525, -0.45847579767158225, -0.3184788253797645, -0.24636103496938833},
    {-0.6759312477542778, -0.2605222070369654, -0.5800024641983644, 0.2711907180795468, -0.05814956045498836, 0.27723663272836674, -0.38231901452237366, -0.5204147533361183, -0.07049409329221962, -0.4217014821640331, -0.32472063558646813, 0.08373241490474354, -0.39955432727558715, -0.2113533485670667, -0.35234888235047546, -0.14402587140158324, -0.566586170236869, -0.4409980218462761, 0.224630539637934, -0.03273731248533405, -0.3562298320780398, -0.40011981344200326, -0.5184050970966736, -0.5045021368597133, -0.4623616261305513, -0.5949265878917327, -0.2895564453238722, 0.15107168782496758, -0.46202189056773757, -0.5523623380623215, 0.37186464775558026, -0.5980073505121279, -0.07021474767134375, -0.022251081598861796, -0.63361275784178, -0.5272614302984381, -0.5560707030100231, -0.46023464046243406, 0.0008158409023180314, -0.5637719595497149, -0.495976770757634, -0.4491004846854718, -0.38618032704022415, -0.28874943651235807, -0.34371175410399074, -0.016819440693729395, -0.6398441842722505, -0.391093654560561, -0.5218590681642065, 0.27323384876047974, 0.20950689816749177, -0.5989593447772988, -0.42086688892211177, -0.4390917623248155, -0.5450672125124053, -0.041795935918133756, -0.7116749790126697, 0.3901288876447277, 0.042338737239063354, 0.31775483548909367, 0.043859371620287226, -0.4545807822964307, -0.412467497064864, -0.31754118750898375},
    {-0.5678726251360645, -0.10964481331297522, -0.5490811142189709, 0.04416974453699695, 0.08276051821343117, 0.21685308690917926, -0.4987658615816968, -0.4399749094655466, -0.23803351678446516, -0.627300851462461, -0.4327073711815704, 0.2334101126990372, -0.36486028935387177, -0.08426174105240515, -0.23403189782297085, -0.06460764714025184, -0.442346948388305, -0.5697261033918705, 0.15860917432448943, -0.2359309697601289, -0.4903574391824301, -0.2172467157183151, -0.3044159430783948, -0.4131899509574322, -0.4577573834477548, -0.3144650527237941, -0.4565454170114603, 0.3141598812399926, -0.340924935113678, -0.2661948406735289, 0.15144573667074906, -0.5041874927482727, -0.1238773567869328, 0.09735805369689714, -0.4621476201056884, -0.34410114140271636, -0.4598329504094162, -0.45859351767790624, 0.08371422463328944, -0.5796425538251746, -0.6546001838142285, -0.1082392145400149, -0.11504486026031888, -0.041257251515293816, -0.3309595693592494, 0.19215561055949004, -0.4344380465584415, -0.49017234304161567, -0.41590044869652876, 0.11623359002850438, 0.06019946207949829, -0.47519770695322816, -0.5758643095854228, -0.2531246531189402, -0.5076345504354012, -0.06970693390125314, -0.43722860844708733, 0.17720458605308367, 0.04806048936934978, 0.4966133896673624, -0.1478446903897229, -0.48235574059934855, -0.6149739685956569, -0.3188574270165814},
    {-0.6414956992703732, -0.3339212949055695, -0.29706132284145087, 0.08662678721654578, 0.1052273509833346, 0.36458676137134316, -0.5575855426182434, -0.29398525717056945, 0.008306010662528932, -0.29372687777688633, -0.3667521509833543, 0.44571235830288475, -0.34588312275999056, 0.011458741166215543, 0.032016744819620815, -0.12031813683327112, -0.12683946016840203, -0.23304812922676144, 0.30027258973058235, -0.25355178944420403, -0.4110801429169471, -0.44383525847670513, -0.21186287311766464, -0.5050373661908129, -0.5540312126595175, -0.29081872211267756, -0.48373537226664204, 0.083550056651545, -0.3050415322787414, -0.23810284859502692, 0.5665291019280895, -0.41674150082795614, -0.07040944115372152, 0.04235098432717856, -0.27025929291873346, -0.49223677895213513, -0.3654318754368776, -0.5724921110708828, 0.009654587660950625, -0.5540042812752454, -0.4657019472454222, -0.02183595967875922, -0.2503551956067423, 0.0242219821609736, -0.4009326974727516, 0.23265594373467166, -0.6840147718431172, -0.4818282567508152, -0.4741866804624061, 0.05205172490249354, -0.08915046049333496, -0.2911305203134131, -0.4466790575359828, -0.01185801381273716, -0.3909638706403023, 0.17823887711284211, -0.4379279736089245, 0.3458248144908318, 0.3785244953170192, 0.23051569093335914, -0.060401768515971364, -0.5651921253399548, -0.1897421531262373, -0.4927526380358898},
    {-0.01680909940340607, -0.1861698933539067, 0.19619078188066583, 0.1774625558058898, 0.029432151883633618, -0.17908579262707575, -0.06748393698186239, -0.23859062302962658, 0.3412816565058215, 0.23344858183741204, -0.3450877115877185, -0.42414751285278224, 0.25863626065911427, -0.37416308492307226, 0.43657409477552134, 0.3836800112459978, -0.10833456332684374, 0.13900107735637307, 0.15482409089782134, -0.029302580376417142, 0.3289015040234128, -0.34050214152085045, -0.36318639539540887, -0.0642735999646791, 0.04653244390657131, 0.10145748774714897, 0.0594667432111027, -0.30796205051526915, -0.5101054485150684, 0.1404058333140794, -0.46749319965512537, 0.4844551192800941, -0.558195700569661, -0.45232404754123245, -0.32616459366461087, 0.15586389730009445, 0.1367509351152269, 0.5066387548079337, 0.04818384706960486, -0.3856208630512564, -0.35026318537024165, 0.3744794433157542, 0.33090051178923413, -0.15642279890096775, 0.24464688428824466, -0.28900536734788423, 0.13365644194128856, 0.39661895472565756, 0.0676555120465659, 0.0105889505411662, -0.12885264754905618, -0.28219964259369607, 0.27075893852884403, 0.3499146167143446, -0.17170237927089332, -0.07412416296420224, -0.0814191816713552, 0.31283435291228406, 0.25014827999338696, 0.0057668274580944335, -0.17010510700834014, 0.29634197887601854, 0.2379326114551225, 0.056977882122305715},
    {0.2508894512828887, -0.412908568633829, 0.296824870867829, 0.5342008381464446, 0.325575329905523, -0.048804479041057926, -0.34444829569285734, -0.2607465556584593, 0.12741045703059195, 0.41297614964303186, -0.22771709125186548, -0.37506738719265026, 0.21735439986364222, -0.20443514470606883, 0.5054684373830479, 0.4245773688649704, 0.02699454496073842, 0.14396928396443381, 0.13517163169443114, 0.20861013789491265, 0.40049119214761225, -0.20712817301155056, -0.0837361755175218, -0.03607192472427531, 0.4292562837817535, 0.22574312134986443, 0.17358216137366123, -0.03187255589567703, -0.17352884417918013, 0.06700163879069208, -0.011617157217193665, 0.5486048335873409, -0.2886641919821669, -0.0030063051137710632, -0.35135447772747536, 0.4449727510346538, 0.25641801636788714, 0.2184762129535256, 0.036172586242658906, -0.09541714730184388, -0.3226261515226663, 0.40164008985212957, 0.21323571713875225, -0.0012901303432996253, 0.233155395057333, -0.2786930184453426, -0.11843313796832958, 0.2642507111149641, 0.10854834114462925, 0.17310525417317976, -0.07895247963277839, -0.5255219380071798, 0.23332384744716256, 0.13666831911260474, -0.14669261029162964, 0.02183005192924044, -0.03207582598221954, 0.24987453631141796, 0.34054606101303314, 0.044353971384537956, -0.19260129557148978, 0.33526428782450435, 0.4369050301321964, 0.40517802449104007},
    {0.333650718582309, -0.3679173539529048, 0.5196274290280063, 0.4639093810638777, 0.37366886570319224, 0.1090060146079043, -0.3289249978021199, -0.3786085584950188, 0.29333995033921834, 0.21696334870507192, -0.3350145629321519, -0.38756649772896334, 0.6442495691015693, -0.3101264101638749, 0.5837915302592684, 0.6325307190200881, -0.2392806502516713, 0.4577228408062973, 0.042766265760928186, 0.378405175713328, 0.2526681929376404, -0.22888982322343607, -0.3958538636084399, -0.17907483120426063, 0.36013874848867544, 0.2139281719756493, 0.4804388535116498, -0.40096539258077446, -0.3615858907383592, 0.15664086202069544, -0.13230322783698495, 0.40582646284913093, -0.09995364667015189, -0.21225510431184155, -0.5194083608130098, 0.3814011069447818, 0.6372411356839827, 0.35744893292917473, 0.2941665305110169, -0.08099617361576057, 0.08902612002619165, 0.3183450979272975, 0.36581071596063447, -0.059329385954486905, 0.5209152019414438, -0.21968360659192313, -0.35851885741450307, 0.49508242408765185, -0.3084575448271541, 0.21842734384328596, 0.1478452574374928, -0.5849051294485255, 0.29606451448254345, 0.5296992265164826, -0.0720612680280814, 0.026143468430178774, -0.16124047987764573, 0.36188749964945627, 0.31181495175904556, -0.3083874346717714, -0.10489950060602897, 0.3217392874791472, 0.3954553565699627, 0.12486554050200395},
    {0.35120265081869645, -0.44786708701669464, 0.4380344489740024, 0.45948678050424074, 0.21337588829862933, 0.044514216110367356, -0.38207835677778984, -0.26967274353315185, 0.3437916319134439, 0.5436196590460702, -0.4712950956986119, -0.547045349253282, 0.5197052941147016, -0.36200030192055604, 0.2887445758675636, 0.4937777401294786, -0.25406244784885346, 0.2548204450648203, 0.18622016029265148, 0.36012178769509334, 0.30647471694557654, -0.22383616305421244, -0.3234607338082523, -0.2883726924499869, 0.2882585958547189, 0.20183362994256646, 0.27568677879257536, -0.28273258199393364, -0.5012516376469808, 0.13527774245833554, -0.5449849864162747, 0.18255291945756674, -0.10057716042072562, -0.2366350237309725, -0.2963684076788299, 0.586850538054227, 0.4208311046040969, 0.5607536559442806, 0.13310950871872007, -0.2843383509783981, 0.1153929492109912, 0.5080194277073602, 0.1396067690895883, -0.1446325888929306, 0.5573458788347655, -0.2827195340451215, 0.0399649380978806, 0.5476339916880395, -0.2494942978048464, -0.19154779204750755, 0.206750171244884, -0.3110676279727648, 0.24795625163205176, 0.26337080074963093, -0.2715085582712791, 0.22948854338680377, -0.34633340919965055, 0.23266232809947313, 0.3518507758339931, -0.31458358753543736, -0.2804262424012753, 0.14025564503325127, 0.42069456309659153, 0.006598735443591003},
    {0.47289437473505946, -0.18546063394066264, 0.5316198578002398, 0.435700214469443, 0.24293916860167614, 0.14444194484930864, -0.14976892742827935, -0.5016000409258589, 0.1792533899088781, 0.4718078167905866, -0.2856436961775066, -0.48919498237387576, 0.25619000109045803, -0.3733462283091737, 0.5593486244120377, 0.4688801206447201, -0.4790280402245623, 0.26920777643088595, 0.19051210293439558, 0.2241610542265942, 0.22799767772852983, -0.15876753552738057, -0.06715258108129957, -0.3741913675744444, 0.6084658904355291, 0.17548046309475387, 0.3876342447587545, -0.03366557573792518, -0.16976715751016305, 0.08951966239307291, -0.2693232173716676, 0.235378360573389, -0.3190836674686445, -0.12976991236529686, -0.4765855190855324, 0.39638186568225964, 0.5736218297010024, 0.5433003598821563, -0.069066360910834, -0.32395473473347075, -0.08180830529909665, 0.14923550949905717, -0.07681537802387803, 0.17320428039434263, 0.35077005308185416, -0.31771596455412543, -0.07766111602426502, 0.4287943903228573, -0.20024400758037644, -0.20493772395726426, 0.11651747865813243, -0.5788300076742566, 0.3871551509980587, 0.17169067003009503, -0.4917735953941316, 0.13608286629036562, -0.2430105558702273, 0.06605775914873317, 0.22297047134195455, -0.3310811694182894, -0.39231220698544506, 0.16050558217900926, 0.3163255744836255, 0.24656347234028847},
    {0.2972938934078473, -0.3888728082104398, 0.4169040401493868, 0.40334317327418634, 0.4871359555642033, -0.006010299719601001, -0.330226706796381, -0.298171259440214, 0.12512494250647724, 0.1985515196095106, -0.16108866458864246, -0.3887280319880356, 0.5749713927376304, -0.3963110458969721, 0.5859254406186567, 0.3407313273649934, -0.5364718430698535, 0.3682864111956182, 0.08046788874453428, 0.3953629693504121, 0.532288748059812, -0.32021846328070563, -0.4312083595946723, -0.37035005640143875, 0.5698828728124805, 0.43834471909314676, 0.4737250011088696, -0.297380473905171, -0.30855725606936507, 0.47435650415025105, -0.46510712252974656, 0.5001455394350697, -0.23698620228009518, -0.21944417767413146, -0.5645527475165025, 0.312296516367492, 0.6267141726827157, 0.5301298369871832, 0.2636249847220645, -0.14666805263781155, -0.1476128730612816, 0.09754049917343154, -0.01565570864800736, 0.093626360412254, 0.34626698989329074, -0.19509125457995952, -0.20620458553385068, 0.3740001322483675, 0.03935142495478742, -0.1445112619849462, -0.08543378235097736, -0.5951510720673343, 0.25678678779662556, 0.14756164654730125, -0.5237047713080705, 0.24057224058777116, -0.4075502606380175, 0.38933970563929715, 0.5413452630403968, -0.10984747106938918, -0.17245933111180242, 0.3989318235028243, 0.23896520288110668, 0.11676317241499894},
    {0.5018547302385099, -0.4337018771657266, 0.46064231021170254, 0.5691211021022174, 0.4009878543810804, -0.2820724459542787, -0.48641986542220644, -0.45895258669306044, -0.05861293371045336, 0.2146098436168538, -0.2358872920643273, -0.2957801172005552, 0.4016288924579237, -0.3366006910792679, 0.5776784041810571, 0.4881660554894513, -0.6091389978754231, 0.4819344801339682, 0.2961201823121054, 0.1702492328870204, 0.3605706705398742, -0.5639167086773089, -0.18755080002289515, -0.14278064147613448, 0.28894037791526045, 0.26969942543337594, 0.471286028993184, -0.0715562169699356, -0.30416957706414643, 0.5256999818196515, -0.30032758561052786, 0.45605468835678553, -0.3961411407768771, -0.22521028206854726, -0.37062044937583294, 0.32758446039636835, 0.5033900165853881, 0.4630114003321338, -0.11907855010685903, -0.4563167725333363, -0.3649090990316189, 0.48116550645280187, 0.16451759165008029, -0.3654667022683243, 0.43532626751331677, -0.13281863858433168, 0.029128161210695818, 0.20449466264140578, -0.42768144550948495, 0.11592558587058989, -0.04810665321033412, -0.5324247280993817, 0.37789417816916, 0.28178355970066543, -0.1744815050605344, 0.1413205416539544, -0.17809786514248224, 0.2930906764776902, 0.3432909893445313, -0.052666262302002435, -0.5737830559380073, 0.16848582764117348, 0.4456379508352712, 0.17854777540650058},
    {0.4929231587691785, -0.2950550548492254, 0.42796769179546645, 0.46960598271017057, 0.16575406858987327, 0.06061661811164454, -0.4023275114311579, -0.13494506928701006, 0.15130021434431862, 0.3567930882529666, -0.515456829639836, -0.5058562137672551, 0.39435075540226694, -0.5578649649258527, 0.5780620072622882, 0.4491476158899005, -0.5905953256796103, 0.2170951236850217, 0.2098306392397314, 0.43532291903744386, 0.3785868542078843, -0.5500147665395811, -0.21913665085919343, -0.28833312129400435, 0.33074385113463095, 0.20969840747328328, 0.557990647319199, -0.11028993922702832, -0.24864703056852186, 0.3665240675972923, -0.2816009703781088, 0.3003714314144876, -0.2221082803124075, -0.5240227626664705, -0.4937494121629191, 0.19163263634569727, 0.42789717434765356, 0.43722484835143605, 0.04630762380366163, -0.18227025961663357, -0.2971752808696396, 0.1736572750352579, 0.14475114836160505, -0.16097961242225645, 0.2558204260202946, -0.42800601505609726, -0.0395001011102958, 0.20101820966586445, -0.06290445077440814, -0.13321399401532072, -0.05573429815627444, -0.2703030726020916, 0.30157231243688887, 0.2833271099766806, -0.14595603328804196, -0.3360668116577472, -0.13209849764584805, 0.03677381356168673, 0.24715531929629606, -0.33884910689107317, -0.2568507552955707, 0.02860677965746813, 0.5364701820439938, 0.1572298301790265},
    {0.26390491445980074, -0.5436899119671735, 0.4610604979394224, 0.33736389919007154, 0.46210008708114964, 0.033008987589842144, -0.2225681959799761, -0.4440806223205113, 0.2437333866647548, 0.543367863768641, -0.3555801161072283, -0.35099530240975596, 0.44218835772611376, -0.49923304178226874, 0.4490909229950411, 0.5833438462027113, -0.3668988306239338, 0.16528875664576237, 0.2135252579463938, 0.2732652809604419, 0.36357002880695694, -0.2592663671341383, -0.2585219529945594, -0.5009136204315936, 0.41932863871121284, 0.39002220182547553, 0.423689612418524, -0.2390657264085627, -0.5096630921996705, 0.46057508053321256, -0.29810545944199357, 0.19253231452112538, -0.30362221588831895, -0.4166237875088263, -0.3565782271309085, 0.32328878323710425, 0.4615905000693981, 0.39740917115884555, 0.032805548683341144, -0.1351351385905199, -0.11625193163040921, 0.23543942672616117, 0.39088022854195337, 0.014536102500891646, 0.5497452471795145, -0.04995593896502755, -0.23753134988233096, 0.20587655620532677, -0.1600003315626269, 0.25738691229609656, 0.14212022265830057, -0.3056600589077508, 0.39966113664524144, 0.28018529612656823, -0.20122594288444318, -0.25414608714561215, -0.5345425417573247, 0.30172300958738496, 0.16052216973001107, -0.34682562337396644, -0.23313175475390613, 0.43593968578151787, 0.4412125200496511, 0.3427951017098081},
    {0.40676172637181773, -0.3437590254206485, 0.20225805623736967, 0.24918840192158026, 0.3647528968928285, -0.23029450775594326, -0.2353142140886878, -0.28618509039394885, 0.42623387513917155, 0.3206208356881009, -0.36387651513898145, -0.4250987900964445, 0.416163667495394, -0.4400308853761709, 0.3011925639282699, 0.7335964651017133, -0.5271887647002467, 0.24570930718285022, 0.32402011743272324, 0.3142264919565673, 0.24368969269224422, -0.3441048542086859, -0.4352070604179664, -0.5683135561442207, 0.5647612831532551, 0.5864197708257978, 0.6214217066605875, -0.4601975146242468, -0.580183772524389, 0.6353230469947532, -0.22969272868242405, 0.5563234897323134, -0.4539463895313644, -0.3117710893593367, -0.44909134121311234, 0.4956193327948292, 0.5740311879517264, 0.45507166167300245, 0.03057875902738957, -0.11159324897179539, -0.301021362850834, 0.5062761094368773, 0.3963774708505355, -0.17261206610710553, 0.34406356724142817, -0.08696669008398773, -0.03777609495015323, 0.28298443814353097, -0.3377970058596478, 0.06716933886370058, -0.20726100009899598, -0.23439976637932886, 0.40679532259546874, 0.6037274331002409, -0.5388164324163727, -0.33847312824832015, -0.4497528050977599, 0.4880527921604695, 0.3019902713302236, -0.3712021391657061, -0.38627439580794787, 0.20873769080414636, 0.3767549961143301, 0.4757739607940041},
    {0.15598768550282827, -0.49947327199455493, 0.445281471799035, 0.31783453361532954, 0.19687267909066447, 0.0735550831767268, -0.4840676143818731, -0.12160436130455719, 0.11789339397032858, 0.5817245839533002, -0.46191400732209315, -0.40040743278650187, 0.4032941884020279, -0.33718816996697193, 0.4766874448669432, 0.4638092138308529, -0.45159202815371347, 0.16588142901866337, 0.224605620922244, 0.22076416342054267, 0.5969143615705244, -0.19760245664252887, -0.1912797094988209, -0.36023985284406573, 0.5331914777088214, 0.551734137477419, 0.5306895846166967, -0.16724754775727887, -0.4566734702961193, 0.44044151284265554, -0.40816538076064207, 0.4338619859718502, -0.09198014049989804, -0.3310644235566508, -0.6168965850785253, 0.6069604350597005, 0.5089931188940928, 0.26566963141843525, 0.06925433592938905, -0.09365436078151308, -0.07121771648675132, 0.10292126102283154, 0.43027942252472595, -0.33103270191104994, 0.22407341008042433, -0.41214318350938717, -0.07821861541190006, 0.4725462931963668, 0.022086524808303136, 0.13986311721876007, -0.06956642224957464, -0.5750152425895397, 0.38122630677498615, 0.5940413844029427, -0.3392151541059673, -0.18902193170328938, -0.3404806305313235, 0.11848885757661337, 0.4657768699080495, -0.22871887747098063, -0.2394741982914853, 0.05308997302554936, 0.4581926614643536, 0.25938494003052637},
    {0.5216308966379102, -0.25830501527314775, 0.5017900278511781, 0.42793517730252545, 0.44180774365055514, -0.28204524466000486, -0.4898600568196518, -0.2702523700699749, 0.1782307643834278, 0.35957104963705144, -0.49494068697298527, -0.34367192528444696, 0.6454969205928184, -0.43954827900159466, 0.295177544008848, 0.6445155281515781, -0.27786869397372205, 0.5415363203509059, 0.42347341094343094, 0.360549852104747, 0.5958546488372408, -0.5664227062794592, -0.4200448604744198, -0.5290832193248037, 0.5918116924269265, 0.5610692101880737, 0.559286272672979, -0.522573220990273, -0.4909742996314562, 0.4862436676480127, -0.5042965938921367, 0.4536607503489133, -0.172971870414828, -0.2431005174220459, -0.6098161504973673, 0.6548265987178514, 0.5255995589116084, 0.647902727755876, -0.16847273216553843, -0.07042460369463988, -0.05929388379690091, 0.11702380742189697, 0.4604788196951796, -0.35226135990999885, 0.5642645552645629, -0.2311894011114491, -0.3552600411000688, 0.2940867311846386, -0.0029447111678122936, 0.25167074427707603, -0.15602646704908996, -0.5104322192245218, 0.1760539343265326, 0.29444533554205193, -0.2637781555692749, 0.07288858721883523, -0.3998511086106102, 0.3706051911194834, 0.39308291978171145, -0.40783694716067914, -0.328334797647699, 0.12703925017820988, 0.39837383324573844, 0.36588492695461794},
    {0.2901821745635281, -0.49130130203221783, 0.6037472949959407, 0.29929735564746796, 0.17408870634911064, -0.315094109626747, -0.25432484021201457, -0.3881001968750033, 0.08362117035083459, 0.4199662892947639, -0.5185290007923867, -0.6472027276228024, 0.3683345352034998, -0.5718331350474123, 0.5904867332245494, 0.5712828235960821, -0.34888943759973456, 0.5804792200930191, 0.4178322142255922, 0.16795924129148027, 0.5864220916674489, -0.4322243472745832, -0.4832326506790112, -0.5658265990269189, 0.5733327498219939, 0.411513580214908, 0.6139893578217067, -0.24689491469773142, -0.47069182232131945, 0.5473623690359163, -0.5522583661308997, 0.6127728656765616, -0.5805580085046138, -0.35183993358717264, -0.6584545982703268, 0.6134998259757988, 0.5208812978632622, 0.39941433251868036, -0.06610494371733965, -0.4098577680963093, -0.2308310389057388, 0.3764630220647317, 0.4717266361691135, -0.13511062856652206, 0.5098027285162685, -0.3813926291665559, -0.40638772546535445, 0.36497983224136055, -0.2201602590483263, -0.2151634541029714, -0.3226028658777931, -0.4039992568347376, 0.4220467137485667, 0.43724630101780937, -0.46975759714763116, 0.014614321269918969, -0.22646901461145136, 0.17370743757557378, 0.16619183137869012, -0.5132216340632836, -0.5463985632827106, 0.17193913768726382, 0.4702256486054139, 0.2789330982739531},
    {0.3629874896385529, -0.3522933195031486, 0.5864192557564512, 0.5337305728046894, 0.4764777011349946, -0.3380566331826595, -0.32838237628365274, -0.4509811568326584, 0.3482002149341397, 0.6333169556977855, -0.2588380508027653, -0.40329918127972963, 0.5379937068436006, -0.3178740328113745, 0.32050242233992593, 0.5017282675324666, -0.4221205058366585, 0.4514496869799218, 0.22738909076846425, 0.2313401939857961, 0.40160465200205925, -0.3572625281041248, -0.29557193930188885, -0.4347616053381601, 0.6122263478785183, 0.5956401336279228, 0.4189849682883993, -0.3262168457595605, -0.6028383098484513, 0.22904585228734797, -0.3215852870993923, 0.5185811045695865, -0.30246024474264827, -0.6319828724032868, -0.6768365831253469, 0.5393358706914386, 0.3548368670609382, 0.51730317320317, -0.017598068910924917, -0.24227040238649855, -0.02048634559093552, 0.30660412598432935, 0.4716797075726275, 0.16038612702408026, 0.5058107369687583, -0.414686662125309, -0.16000537692122818, 0.47638608720587333, -0.3456083183606135, -0.18191482022456926, -0.2665879763113761, -0.4691571743384344, 0.5561765335157033, 0.43503791137723147, -0.3465101422900852, -0.3940500919536249, -0.48743985355743, 0.05808240016208214, 0.29817886094160095, -0.32051791796258133, -0.5001228034700663, -0.04554172799789227, 0.45733861519531593, 0.470876336909677},
    {0.20692247878069464, -0.489484290386604, 0.33675574191125945, 0.5438704539942333, 0.4819786254418672, 0.11048064700860706, -0.25773897699259807, -0.5037656464062352, 0.2792699892904429, 0.2975422412657843, -0.4118974588058232, -0.551682898674206, 0.5415409994619654, -0.34753255485027923, 0.4704498911265257, 0.43074067213415834, -0.22784331287605913, 0.14484210728268382, 0.2562330434003748, 0.06588247907612173, 0.5635182619391534, -0.3544147953598906, -0.2674874732466935, -0.5862641241098768, 0.5397137643519815, 0.30808071409160126, 0.2178840898067822, -0.5520038548025533, -0.5836216184937358, 0.18810241362227745, -0.5012181100231479, 0.21494397785831026, -0.5730319044373025, -0.4963036356271941, -0.6349207283480337, 0.5557384353039118, 0.5590501810984554, 0.46153022820276657, -0.1691379065806888, -0.1548531735088228, -0.2603141794226062, 0.3188081136657504, 0.08885695219131341, -0.24396383016362178, 0.3235558006204445, -0.20524645363254407, -0.4095541059985181, 0.4853925489414737, -0.2720030489918465, -0.04567159119342021, -0.4113330317818775, -0.4756756372916742, 0.24950487551268524, 0.40639522816882345, -0.519087570132252, -0.1719540935864713, -0.6411593566842247, 0.14636370737558607, 0.10652914577357064, -0.10778999037689649, -0.48154155031426943, -0.003468232019281707, 0.32448658696105354, 0.5342215030779258},
    {0.48885489866558723, -0.563168740129259, 0.4257570212982143, 0.28457945025881026, 0.28667483126339316, 0.0800127850299002, -0.3474020473998276, -0.38057895396590546, 0.11113881260615105, 0.24839859995016556, -0.1992129180084564, -0.3906679835446088, 0.2974897562983192, -0.5001619411997872, 0.4299518434853696, 0.6471085953238549, -0.43757758725461826, 0.4170490089774836, 0.2985002638449185, 0.10545242943071466, 0.4073187518141007, -0.5250796734952725, -0.3460638475387182, -0.4406780111808477, 0.23548692228555695, 0.2492865862758326, 0.14815006730238447, -0.39922740290245723, -0.4777741914098791, 0.36590660688411925, -0.3176358335650433, 0.489229190597473, -0.5786252447554892, -0.5355753481056776, -0.6367634279244352, 0.5066476761019375, 0.6198789616596615, 0.6480664643573288, 0.05700885007751771, -0.3167765959844352, -0.10285194065209856, 0.552979712307206, 0.39843754629950917, 0.010288368787869059, 0.2786867668567908, -0.4701983820059912, -0.18712267828904958, 0.498269351961046, -0.10418541623681639, -0.053495138691822916, -0.3449633027956319, -0.3290031116104026, 0.15754753031568028, 0.48094908887106547, -0.29389399304779035, -0.1568362261976822, -0.6534098339866516, 0.36818289938141485, 0.27511940700465387, -0.11999515214522255, -0.6402256715428202, 0.019221491993675573, 0.3517667711246338, 0.5245391528085306},
    {0.4597262162948346, -0.5374255493440554, 0.30278733593256346, 0.6245215209401443, 0.21691363590972063, -0.0014069360449451766, -0.41828484061718835, -0.26491042325840297, 0.2472861094057389, 0.5263785661136424, -0.27894688360951725, -0.23832128867502309, 0.45669246571630184, -0.2795593015461105, 0.5836724123610745, 0.7034046638418393, -0.2714902674305859, 0.4985244525783717, 0.29250779527932297, 0.42584479077599746, 0.28388301557882994, -0.5916721435692033, -0.40770633777094994, -0.3834288011749198, 0.48209773979664694, 0.2457634260981202, 0.28768645182636826, -0.16802051606962357, -0.5444907706339979, 0.27129414738662905, -0.174343121494215, 0.5936139196787318, -0.6096105813619977, -0.47904660876267524, -0.43633164473234626, 0.6304100814784357, 0.6418598329876944, 0.6535008609495297, 0.13682169448773712, -0.14166970658497324, -0.41122230461743636, 0.3803954263975373, 0.38961406627686773, 0.057253054339348054, 0.3273791778466547, -0.024518282166983107, -0.01618946124495087, 0.553589829203896, 0.03175457671958719, 0.28052047931582663, -0.17498919661630183, -0.41716257411367164, 0.10225573503957032, 0.43585138895238473, -0.5251555808600633, -0.23623591660840165, -0.2248528089949432, 0.0930000757558865, 0.18378399047289415, -0.3099215317762969, -0.4792803116106017, 0.22666860932684843, 0.5430633764508641, 0.584351936321842},
    {0.43733506895395835, -0.1862010496422123, 0.25493231006597744, 0.4551317279695636, 0.4839272293900009, -0.09087330030696855, -0.4731801316229181, -0.43365855738937986, 0.3257525168988698, 0.4073740601417383, -0.4533147579727869, -0.4758496049056232, 0.39687850090370014, -0.42070421330362734, 0.5843798080554214, 0.7005750198531381, -0.29404055865798556, 0.39734286404945096, 0.39218012517920736, 0.4063107945261587, 0.44388820115435634, -0.395798552184085, -0.3012415866402427, -0.4782889519279301, 0.5870687372405872, 0.5571250707476433, 0.5662664262851403, -0.5315157570765737, -0.6083009720075553, 0.5504201280951643, -0.2863331736943253, 0.298379647386575, -0.3494991922087679, -0.20860468321045283, -0.5323674083561174, 0.43213239841831896, 0.4952618903475123, 0.31756603671079253, 0.16049775073004463, -0.4015174640253246, -0.13698207320234437, 0.5256679003358105, 0.2310511147969483, -0.24765465354503363, 0.369039853265275, -0.062109130937231076, -0.08418261643698886, 0.6076020648799003, 0.035136732372884436, 0.2236842656237936, -0.07782795469637643, -0.449248942774208, 0.3396722367179952, 0.6294872662230493, -0.5142069817572953, -0.26058165707491143, -0.26063229989179526, 0.3067345444111225, 0.5376704666094619, -0.13058271880404884, -0.43115584491246833, 0.333734057420639, 0.3529373105008467, 0.5093674824586033},
    {0.5539080525537365, -0.511436102056823, 0.26478083068799635, 0.47990312495629867, 0.427108938621928, -0.253421514103879, -0.38938585671409187, -0.5219871581229718, 0.2008224011326572, 0.5449132233906515, -0.42655809637821357, -0.6749156534656082, 0.6907324147010746, -0.5104177417570566, 0.3194574411539134, 0.5782551348254313, -0.43296851070126285, 0.46344091264301074, 0.508362183109989, 0.4994761028649479, 0.36716701260248824, -0.20107480032381495, -0.10381927910182485, -0.4076968461860072, 0.498642011083513, 0.6391678401246623, 0.3824196407429257, -0.3681569741959421, -0.6053491519420635, 0.28224396732216916, -0.5380294842383103, 0.2366649080921655, -0.40428087825031184, -0.3649909743588398, -0.5888390485903223, 0.46788286653775496, 0.6797595551065212, 0.6575712990477273, -0.12849427391237223, -0.4359075245079254, -0.12195421679211543, 0.19172471276020625, 0.24972819846266872, 0.15112682736781735, 0.6248454034422556, -0.23048569887372578, -0.23161411888841832, 0.4342849088784916, -0.09109729019737003, 0.007428777170761924, 0.007829070862735201, -0.5298602161054217, 0.30183653955504053, 0.3910735470206192, -0.29520291432850376, -0.26794572303393716, -0.28114195767459566, 0.08500134631563336, 0.4706683632042525, -0.38131636232043836, -0.3983839335324766, 0.06208805348036159, 0.23808439086129796, 0.5947525895242424},
    {0.46490509166659, -0.4423588866225765, 0.513554665040842, 0.33812302945624095, 0.38491318897962506, 0.0021096641281725015, -0.4244089373482229, -0.19527809371125895, 0.4739321671308851, 0.39801559123420943, -0.16101969613283698, -0.33041459146732294, 0.5724013225712469, -0.39571110954450434, 0.3188765651269285, 0.6368597127254921, -0.15666617661916976, 0.28996739665695265, 0.31775990831945017, 0.4081451358600919, 0.4979037667138591, -0.432538128307475, -0.0977341662897816, -0.5578519991754133, 0.6193899400794124, 0.5092648333158076, 0.5787730268184983, -0.3788865485612843, -0.45167944979990976, 0.5207863894497848, -0.47856873904398645, 0.49458249720009567, -0.18361938994082572, -0.37467964967052325, -0.5657442502007854, 0.5426150902476106, 0.47105837778138127, 0.6134706894972242, -0.19414752413093916, -0.3212348814218998, -0.12121536003197124, 0.39444267140867056, 0.298775170871332, -0.20337672607159965, 0.3625128468017315, -0.47660186392712833, -0.25242519190283375, 0.30104300847815213, -0.42584841022104086, -0.02633746011636076, -0.2022503058135727, -0.621669849244663, 0.5368189986812193, 0.4181913229254219, -0.20159370727119566, -0.08294207639173555, -0.36458797179615543, 0.18071046122161133, 0.47834866050165886, -0.5108977027162488, -0.5633012483493566, 0.212726756005154, 0.49354270753595286, 0.48334042211615846},
    {0.18024631247542122, -0.34319753258824787, 0.28729085637967444, 0.6478082913087225, 0.5035054619318735, -0.24242566632318435, -0.3752961152163298, -0.25240953895734985, 0.12020732789009474, 0.321452520615983, -0.258566593818988, -0.3417152702769615, 0.5986594346613496, -0.4428160518876431, 0.36942930607947605, 0.6110645772089962, -0.3005907579381906, 0.46941138675850874, 0.3891481520284396, 0.36190390721554627, 0.5507914583568585, -0.2976930826824829, -0.24802644712981936, -0.5393047402039164, 0.364551870698131, 0.283965952575401, 0.5346173382114714, -0.21498423935668876, -0.6495514356569126, 0.39806282419291594, -0.28388944897160695, 0.6234968336628661, -0.5146711006382534, -0.5595790855531959, -0.5531172971904408, 0.4998673992688187, 0.6983434401507751, 0.6667300095877572, -0.14541044708070297, -0.42727991547669525, -0.09199792786902254, 0.46092722032036504, 0.4535909914241309, -0.1373277112649803, 0.5595617738179148, -0.14204768219740446, -0.21102965737214027, 0.4772187740125106, -0.25668172217035584, 0.23295881022091997, -0.06576755086023714, -0.5124493245248098, 0.36799667166066363, 0.4664266697222056, -0.47948530056005917, -0.08014409378562068, -0.3923501791990571, 0.15226563313527844, 0.31501228179922297, -0.21873625782443057, -0.6124061588027624, 0.04016341926064482, 0.2958012743451373, 0.3979009155645088},
    {0.24564444355232704, -0.19082417830610815, 0.4437207478084615, 0.5947094090561666, 0.4358040988680468, 0.040495838024852716, -0.45872495300529154, -0.5386699650986295, 0.39912324570193713, 0.3905686775511208, -0.24827930155842717, -0.3714016860295823, 0.4420159409954645, -0.6055916038343645, 0.5081429892424101, 0.421179803761522, -0.19268941931811742, 0.43615977670524597, 0.48174905129716683, 0.353854383344534, 0.6284212835418985, -0.536777966926192, -0.13107432843072103, -0.401519838200993, 0.29913585636605616, 0.4503767328278872, 0.3148519541787035, -0.16532011366112123, -0.5234131680913322, 0.6655176803102513, -0.4479351939645234, 0.31826084562781926, -0.6258627193455016, -0.48576027428752705, -0.6675881074385086, 0.4628036051026638, 0.5295465838658959, 0.6925904574617925, 0.16515027876895688, -0.46492148634261266, -0.11385134947660012, 0.29505845198051084, 0.3003518804814192, -0.22315894439601225, 0.5781443879700916, -0.26314468045638467, -0.3467100514538306, 0.43113770457607087, -0.14256884513581974, -0.0216661084716498, 0.002629441771484398, -0.29076467282787916, 0.37591834797048196, 0.648031985803271, -0.2171324958709435, -0.3809961830555319, -0.6101529659884812, 0.4568469572703229, 0.237939516877824, -0.4458616250625706, -0.5924447501311276, 0.2372249528653118, 0.41803373158267576, 0.5605781120225659},
    {0.46650751618622827, -0.20008720787930923, 0.5674570143082498, 0.524386848331043, 0.4824995804617081, -0.17695446103424511, -0.5125113141045678, -0.21017328066184282, 0.34440134441906217, 0.4837046243976747, -0.4286123690895489, -0.4536945213688493, 0.5144198596907317, -0.5469378420670092, 0.40121450499520567, 0.6371880637185556, -0.4174899388029895, 0.31885043650499884, 0.3908575996422569, 0.16059926860182147, 0.5976766865794355, -0.43298003680367764, -0.07420824711989919, -0.5324930514983349, 0.4159143192730174, 0.5725400733805109, 0.6221261807363407, -0.3645188930214891, -0.4160517764993905, 0.580051144789106, -0.3702413795187741, 0.5453967283501207, -0.3373713240192949, -0.3603964556915806, -0.5956533820381597, 0.6782948928407017, 0.5118374335841553, 0.4808791934571859, 0.14107015058568334, -0.4921810224727594, -0.035711939516646515, 0.40413826453811286, 0.5350343470579737, -0.12717184405351206, 0.43198712190994587, -0.4471556712994458, -0.14992091018992415, 0.31122862038229776, -0.3695468471262811, -0.006700194095110359, -0.1218232078724009, -0.3891318492700393, 0.4448461413709045, 0.5587793986545697, -0.183616096277884, -0.30939290025383204, -0.5159618426817655, 0.2728566914204176, 0.348299205450023, -0.29158186313519213, -0.5701435492614473, 0.4162356821560421, 0.24373850668488659, 0.5295369731208238},
    {0.4365722654252296, -0.5026618456991605, 0.494292599736768, 0.3527915123914302, 0.3791612799026148, 0.01732140130149966, -0.6297578047360866, -0.19027325725349264, 0.3053342437652906, 0.5929812932787536, -0.5022269029162368, -0.5990599264468112, 0.6334431138158793, -0.29093429175458924, 0.4523557631028819, 0.6035523153231096, -0.32434628598003173, 0.5107547780002137, 0.27492797428694815, 0.35448967861595204, 0.6916541963892954, -0.5790841648180275, -0.13582197205481142, -0.399951062205688, 0.35125650397830976, 0.49571495296355295, 0.5292047595830764, -0.5452306076969083, -0.6675202430923575, 0.4572595406418883, -0.34905091625432483, 0.5077804697616836, -0.4947097865769971, -0.3388948982086053, -0.4884784143374743, 0.6801653286266485, 0.4272243213226703, 0.40307776544599805, -0.03727787138258427, -0.30866725056603217, -0.3949251551586699, 0.6157977147549624, 0.2788208238750836, -0.0702727464288873, 0.3927051468481001, -0.335885331770754, -0.3398001449137433, 0.4364706649656226, -0.2612478270898273, 0.1488577527209469, -0.1012457903135262, -0.4069917460196418, 0.5387468213057462, 0.6340851881393599, -0.48211311549564634, -0.30778012517937126, -0.4740222080147187, 0.49420618994010296, 0.2084468795734045, -0.30003302564361395, -0.6136390669131755, 0.47736583743559385, 0.35884367907462617, 0.27526595165846485},
    {0.39302036946043767, -0.47153948391116723, 0.5118530392921264, 0.615819535962695, 0.5009316250909598, -0.10569906189523884, -0.37813530278748714, -0.26958694509397835, 0.23839528694541232, 0.2826910075346503, -0.4436838698495524, -0.34663646014930316, 0.7016119530663624, -0.36252731528312243, 0.5208466065839885, 0.7025140488609002, -0.3938760803408754, 0.593689279598504, 0.339489072982045, 0.16949521859638644, 0.5894874326830428, -0.2272897760446085, -0.45133326992535944, -0.5967630262798678, 0.3493698518190548, 0.39936472401934137, 0.28982515999985947, -0.4898273052670532, -0.4484967888754534, 0.45596001163484556, -0.20923008539542692, 0.6408427655008769, -0.5227841512829914, -0.5444348219172767, -0.5279027507636515, 0.5724654905055723, 0.6189002782333028, 0.4961940133752946, -0.21837621590476797, -0.4189662310268104, -0.21143938249110675, 0.648302036107123, 0.45224616288302893, 0.013642734410691255, 0.39930261728288347, -0.44949733351200727, -0.11940722256361049, 0.3775239428167176, -0.41474918033974806, 0.2643506574945016, -0.3367690143282173, -0.29622514859998633, 0.3189078791323796, 0.5479772419525224, -0.3361083952764788, -0.4120969434127383, -0.46448294827307024, 0.4316161203036088, 0.18261195892086235, -0.16231450603531308, -0.46598208496514654, 0.39804231216980396, 0.4498703363402913, 0.47918888373578655},
    {0.5393962699932288, -0.30177951209412535, 0.6103927140908014, 0.40771043131099005, 0.26986282697050695, -0.2707090290993229, -0.29742052780676914, -0.20183124581775772, 0.4616473126678268, 0.43748794590587875, -0.5554648912019958, -0.5913060936337595, 0.6213986047980777, -0.30627576943780566, 0.5589509547866404, 0.6290596243718771, -0.2700088495468272, 0.4438940968235503, 0.4009538318590451, 0.12384719274691308, 0.5284606436687643, -0.49645618795636404, -0.4833210535851963, -0.6227877914179869, 0.5442637621828492, 0.3967055077806914, 0.38185573302093256, -0.45601156413582866, -0.5103232257129431, 0.6566380544956377, -0.4479883687156031, 0.4828564707544007, -0.43951642537687546, -0.5811059200518024, -0.4725487410643656, 0.6013845587321642, 0.6902967432249397, 0.6187999558198352, -0.03587038201949978, -0.40033904446819646, -0.1656594082887202, 0.5040264319406449, 0.36522760975306895, 0.15174573408371608, 0.6399402503788425, -0.3392040261321091, -0.12490740304332242, 0.31882299541122155, -0.47240723924239775, 0.01007654240020766, -0.22511947502472138, -0.23550338374874638, 0.3419425403938999, 0.4546063996739735, -0.4897915453281041, -0.12726562627900476, -0.620403463119453, 0.3005042989342131, 0.1687599609742039, -0.21106216307473546, -0.42452122823347344, 0.21849881667029364, 0.5582908630220847, 0.3975853453850009},
    {0.3442335879278699, -0.4617671998597308, 0.5088653849857312, 0.4226436615403858, 0.37940575025885775, 0.1276580943405408, -0.4518156471419209, -0.17964856745243948, 0.18361972155679648, 0.5254524309221343, -0.2705559835809339, -0.6118481283381083, 0.399900869458967, -0.41034930907594885, 0.6199282349867206, 0.43202172154424134, -0.37482937838269836, 0.36976511941422924, 0.5584754206573107, 0.46383806728710225, 0.4747910789530109, -0.18735594732816616, -0.2554589981872074, -0.5885121685059239, 0.3889779776954878, 0.5487550442910433, 0.4871906334133521, -0.45935273915245367, -0.43400525780522203, 0.6631984161340929, -0.5465459972357466, 0.35809268769070435, -0.5898352582058723, -0.2557336634273817, -0.45600052468277313, 0.6726768110749692, 0.543690267046166, 0.4388936575576143, -0.1968713624629013, -0.5221712159067651, 0.07058508766999229, 0.37141889915614795, 0.5435006744582547, 0.1193317376518878, 0.416147923734852, -0.43713481103889007, -0.2344770238391616, 0.5742284474973075, -0.37279177627395577, 0.21859706718570648, 0.03592627124531389, -0.43570067689285863, 0.5844350848448244, 0.361566598340671, -0.5329725939503349, -0.14490691878883233, -0.36144535634164204, 0.1780425019586218, 0.444066193513601, -0.4639799180823891, -0.46838890643321845, 0.27567308831132487, 0.4016112719375831, 0.26449056558461265},
    {0.2287938717934875, -0.20575972451071609, 0.4522097845984366, 0.4758886425524778, 0.5551521513642146, 0.036879813855105754, -0.40014934846772077, -0.2367235391612318, 0.4973310443013673, 0.5450213323152849, -0.2588806855984248, -0.6485888130999443, 0.696773766009722, -0.4647663733640502, 0.4161442706974147, 0.669123744228845, -0.4003269021984705, 0.37051670132170644, 0.2995841964505743, 0.5067976689789675, 0.46486111605411234, -0.48179201575791847, -0.2847906610947111, -0.20752168006466765, 0.3391061386567125, 0.2960977994873458, 0.36436028282603966, -0.5199459915245654, -0.620016571728852, 0.3062678889079924, -0.17394827688989237, 0.3044648546034941, -0.43161421470237493, -0.5062984574793652, -0.6061542677448971, 0.6467272428795375, 0.35765378880695275, 0.713947541754634, -0.20559393361710818, -0.5270840593562942, 0.03840336633132767, 0.6166658973576746, 0.5029779558711823, -0.09732667528032637, 0.6695093291764106, -0.5028034980294682, -0.09084041571307043, 0.3204320108670544, -0.4542064592424541, 0.1625542155659152, -0.09884341589027675, -0.439203351727309, 0.38739408533298625, 0.54011756479155, -0.3812844017061794, -0.24567727204770612, -0.5144948034840781, 0.1935166520054486, 0.4301833597519859, -0.23402622306849571, -0.5591558753481265, 0.11178125468482697, 0.5206796367094985, 0.2738413729814661},
    {0.25758171728416007, -0.4340047142111616, 0.626720364664545, 0.4265539046894092, 0.5522125388076544, 0.08571107536351949, -0.5470051187486608, -0.3840669427640213, 0.36633024095137395, 0.31824257598835815, -0.3775497327161715, -0.45855095874047314, 0.42059853963212673, -0.444502125157322, 0.4564060544614681, 0.5473993725792258, -0.2325986930408896, 0.37471705090446406, 0.3414603232157899, 0.3277574415674052, 0.5688056814306189, -0.5357134103593854, -0.30375473230811395, -0.5340532475330171, 0.5386747184596484, 0.4963898939931785, 0.3591206057687149, -0.47460942386627586, -0.5920978477244746, 0.5944815361088006, -0.22774802394689886, 0.5948108714160868, -0.47023245069212505, -0.4592553329386003, -0.7369516717422786, 0.7021527840246108, 0.39841496802129966, 0.710716595159039, -0.22621657147414467, -0.267104257153096, -0.19980307742718242, 0.32330559974273004, 0.5846829980066727, -0.26957683938080124, 0.4684789885167552, -0.34577376916630265, -0.07767068127486709, 0.3104020292515933, -0.5261125999400411, 0.16798107157987655, -0.28047872253371003, -0.48856375518570627, 0.4163327094090244, 0.277931958028216, -0.6233791377090363, -0.26507524483484474, -0.4232709179693163, 0.22302520791994518, 0.35943196511316094, -0.5113886086270879, -0.669988697827867, 0.1058644240814095, 0.31014912813527096, 0.27194211084647046},
    {0.5285638808655224, -0.35242183490514095, 0.5667719492643208, 0.4757810335611394, 0.3828593595738503, -0.016787661707406115, -0.6429099693706928, -0.2236039121743822, 0.38806057304616404, 0.4127108463653515, -0.49262946948208686, -0.6043222033542975, 0.5426608269095414, -0.6655317248675147, 0.5545032823973789, 0.4784669107197216, -0.2665063589867791, 0.46424255583400426, 0.5427830807488123, 0.515216052579984, 0.6062356958275313, -0.36821234880700715, -0.35075151999671605, -0.28406355185556026, 0.5003527541840754, 0.6535277843356624, 0.49032656935464186, -0.3487498971111016, -0.624507001397578, 0.6620328252341566, -0.4851239517405991, 0.4366900797071805, -0.46226782986154136, -0.30484682041829764, -0.6978024967972395, 0.5688427887766652, 0.4542589758752108, 0.6187754643730448, -0.00022941746149211952, -0.5466636424234622, -0.24520988904524366, 0.5294617715720441, 0.3125179007088114, -0.18099847761694357, 0.6727089551838181, -0.30309189759637106, -0.09804353348008318, 0.33664028555091763, -0.5329912644845185, 0.2891515011167606, 0.029301650229509067, -0.5535528833497001, 0.5423291472288174, 0.4317966810284162, -0.6406777997528329, -0.00028501809264392714, -0.6499089068903809, 0.3961497376727802, 0.25231714202478245, -0.5662545981670328, -0.6374850600269275, 0.23780353148253466, 0.5941435387910781, 0.37257645236616577},
    {-0.14094755468512074, 0.42997609944980325, 0.025609354562853962, 0.017835929613310122, -0.15593297066540548, -0.012567854769627898, -0.26219298105518035, 0.14123941550082617, -0.5318654670650059, -0.09972697062187964, 0.26008768065864524, 0.06199827249214432, 0.010881194405682247, -0.41657916675700374, -0.5356603940942766, 0.17229155834408544, 0.18949523005064245, -0.25989659246112856, 0.0007049382316063202, -0.38145912429072254, -0.1580569068684012, -0.00699781225802153, -0.041625452671088164, -0.0736920593831882, -0.41197881173820344, 0.135071976740698, 0.16797519381383444, 0.073532493946849, 0.2911643413529266, -0.020069726948170507, -0.08051212239465448, -0.5306636601888958, 0.12825968451102784, -0.04906282650532786, 0.01029783972924987, -0.21706010142888818, -0.07715505154626046, -0.3371640722230495, -0.23257164710532902, -0.25409681625420266, -0.34312556034627595, 0.021967524105595347, 0.2479930992222415, 0.1486324614652275, 0.043157813553177035, -0.169921582229496, -0.5619670960415153, 0.0849477047207221, -0.08040813288596038, -0.4052419217304247, -0.35470432799531787, -0.2779782131164656, 0.2317738648197912, -0.003762412421330634, 0.01197672794205295, 0.5494203521850063, -0.17590815871107024, -0.2865040387079222, -0.18302072480488002, -0.10994033995265597, 0.38648127604277177, -0.1569038723159198, -0.1702754757468741, 0.2870822288132141},
    {-0.2397390252277998, -0.15745848853781017, -0.07606830552121364, 0.2286969145910434, 0.20668607861670293, -0.0780763254111222, -0.4680143528189993, -0.3066961958099018, 0.2580493079057499, 0.06786965289986062, 0.08526047569375342, 0.08014666960635042, -0.031563318621390286, -0.2006085462341402, -0.15818532508334668, -0.17966445190426422, -0.02499014317826328, -0.3339715409698366, 0.22781487138340098, 0.2254725817927732, -0.2319627377314616, 0.11241426343055208, -0.06148222993882256, -0.357602188742259, -0.19351382996847, -0.20141937545627084, 0.07129775396075726, -0.03826055789463505, -0.3177162193504168, -0.0657858409432738, 0.13955318601588673, -0.35069568126250283, 0.01768480839875586, -0.2025241618030286, -0.32145593938050654, -0.06273071896572478, 0.17186407207367468, -0.1618311863421847, 0.14126201973274852, -0.08787920631452549, -0.4020593164210136, 0.07517748759734463, -0.192907840007333, 0.12218165334285208, -0.008630686545314552, 0.02812902647151498, 0.036796989238108306, 0.12967219279624775, -0.19210163215375656, -0.11741051637515335, -0.12559807886106608, 0.1378163968776991, 0.04438880568272282, -0.012560567887565252, -0.031488849124966946, 0.017122480990327933, 0.08217696275867599, -0.1334425272815017, 0.26238577900398774, 0.10263194339275705, 0.14100732481992892, 0.04014663090213242, -0.26092822970323015, -0.21380175285709574},
    {-0.6174978008246735, 0.12424572947973211, -0.2656013423301191, 0.16084828387947686, -0.3162388752922642, 0.4610372079592569, -0.4651958405508797, -0.2830695829049352, -0.24762104672416851, -0.40201225965269954, -0.04998301975677379, 0.012029022345555489, -0.3684587986987389, -0.27011811987773743, -0.11644874292373777, -0.28124064673618054, -0.4080648134797519, -0.1870807955033085, -0.19113782179087052, -0.42404002405997115, -0.41538713154518375, -0.38214696501926015, -0.10214544060069965, -0.198049210072599, -0.5308783286810962, -0.30052486537600176, -0.3251255913381656, 0.27206679487038793, -0.36117332489173687, -0.2839782681972717, 0.07344913583319586, -0.4608350260771952, -0.15749990041617298, 0.20574568582411948, -0.19957052155533347, -0.5359073400722101, -0.26293360573665825, -0.35490142313615175, -0.1853389779117943, -0.32538275828270186, -0.279390730635922, -0.29003114630884336, -0.42139784517764795, -0.1478728466126296, -0.35283285276873133, -0.2276429429251501, -0.5178304718990301, -0.46345812038101025, -0.42486609251529617, 0.015236968539238114, -0.08261512431307164, -0.11119338849402863, -0.2637742438952338, -0.08120980976016075, -0.34451793426668875, 0.2688798748058846, -0.34128935869952576, -0.0300803762097382, -0.20522407795185554, 0.3692936844625207, 0.06557986306562244, -0.19025650655496845, -0.2161243076270775, -0.45303796468934177},
    {-0.40018942275109287, -0.10320318324906103, -0.491606697175455, 0.09289233740538409, -0.16234721532846508, 0.1590374788559825, -0.13358024217243394, -0.21636435286459876, -0.37122143891746245, -0.02939970978884637, -0.3196702273968727, 0.2059746531185805, -0.2817691149439143, -0.008862962442074532, -0.18913379204235098, -0.05863763136834533, -0.3354410736308144, -0.5194842809388692, 0.03552928272704595, -0.4714351606571525, -0.29792455024495, -0.014244007859728711, -0.2148899904952925, -0.2857405954074459, -0.30867076368266533, -0.29728730975263784, -0.3218216948838857, 0.1560069512672585, -0.3679686152456169, -0.12066811186802093, -0.06501498074405884, -0.4948713605146227, 0.19754319697671405, 0.2822021732648351, 0.03832002354651141, -0.32082646542310855, -0.3714694050704942, -0.13469880991638059, -0.020546188000643836, -0.609012155851015, -0.04470531760210434, -0.16203439894663454, 0.05880670236052879, 0.005387356908342639, -0.35123111445007194, -0.054355819131269564, -0.3861509975177228, -0.11042607908440191, -0.22115875693667159, -0.0560405039888987, -0.12160918592319479, -0.05193525161386423, 0.06575526219548332, -0.22145776594281472, -0.2756084034462852, 0.20328267992224774, -0.48830387784548435, -0.05577036488073417, 0.04427332723333427, 0.3744254494158963, 0.042593749373181534, -0.35877767556287066, -0.5062583811813953, -0.034942780209802515},
    {-0.42976366090780266, -0.47067674746529015, -0.21928541814630795, 0.23533158948052108, 0.07382021336599917, 0.1781294800061294, -0.26144032744973644, -0.5251313927374948, -0.16179057082088383, -0.4638764391492487, -0.548992575566927, 0.23601145073851923, -0.3234518797053409, 0.12663329054260344, 0.15603473420749137, 0.08925882956382176, -0.5260012294269647, -0.27097402473966675, 0.2903073800357996, 0.013742463774511068, -0.15936269140358292, -0.2917797087368596, -0.07148901771027406, -0.3485994235189349, -0.02175880093199425, -0.2831831671294466, -0.08127956489785106, 0.213059650782603, -0.3891592786889872, -0.05365111765623324, 0.3006518460979403, -0.25488382277413735, -0.10027506033650035, 0.0746971529131801, -0.05234532428177563, 0.018605229495881757, -0.3870183036223601, 0.020293915882908263, 0.2994743092996185, -0.17787744175940604, -0.5479808871141325, -0.12407335730774216, -0.41964133504312556, -0.3383201111165347, -0.3314475486667618, 0.05542030020592858, -0.2213951862136691, -0.1784742848049474, -0.5670218578784645, 0.33954324329147095, -0.02301229288801872, -0.11416577202999736, -0.238568639830055, -0.45422485728382994, -0.4564908751341569, -0.1393209866476415, -0.5795931474239348, 0.3368094335404468, 0.30284086158799056, 0.47068072524987237, -0.11505938765686909, -0.03196552479860181, -0.11197532841793079, -0.5216525880022619},
    {-0.2631678026738412, -0.17651051318221794, -0.37216089669275615, 0.11982068338988332, 0.12275633854321834, 0.29660290141084755, -0.5843396257884189, -0.3701935477909601, -0.04696665473829787, -0.5106862392858255, -0.38643083089321745, -0.04523050878841124, -0.17301087609842766, -0.27452864068241545, 0.05678416094120037, 0.05263761367775242, -0.4244010039836292, -0.12195567907542766, 0.17410710313169128, -0.1116314429249725, -0.1547602903889505, -0.3456002237184582, -0.2086726036718704, -0.3904595755638191, -0.043200722252086016, -0.46944777120331843, -0.15501015127607484, 0.2695861736592001, -0.41175267569901136, -0.055252094903058165, 0.2733680464884082, -0.4236973585518759, -0.25235203861275024, -0.09436944599627049, -0.15179384870023216, -0.33008065026858147, -0.2309616211225086, 0.0041508624263723575, -0.0012337565583102285, -0.25238565304209, -0.496616833147019, -0.5362478049129955, -0.14057408400472393, -0.09428771315953328, -0.33137292489751446, 0.17162765038983818, -0.28951674791083487, -0.27818011467122994, -0.41248044590261773, -0.24054985364047662, 0.24140703809009784, -0.510464176390474, -0.41176817618968115, -0.19820589043618458, -0.24922263997705352, 0.023184638317225083, -0.37001424649327164, -0.10733769012419879, -0.07368894993411816, 0.19740398670272996, -0.23645473369805062, -0.33031691348866854, -0.1341741683095604, -0.2484556214105413},
    {-0.1877167533633949, -0.16115501318991152, -0.3129130965595298, 0.18390962616118908, 0.012916274258296319, -0.03270941614092192, -0.6086164367053252, -0.41383359387635593, -0.1877452319662458, -0.3528875408270067, -0.2696575901738226, -0.1016687543799956, -0.382549718030682, -0.14023670884285525, -0.19817740700243397, 0.14261698462266256, -0.5451406368942312, -0.054050493270773096, 0.11124181829525008, -0.05719919521139945, -0.4898201812970023, -0.4829069536786766, -0.3726049581345779, -0.33997619624769526, -0.15603290739399767, -0.19180775576652911, -0.05057895436278105, 0.20331443078522507, -0.2587859518695287, -0.04857942249620219, -0.07618186755603569, -0.512603801195833, 0.05024258272698896, -0.13581058013382366, -0.40085638084466624, -0.16368709709710133, -0.006947667344208083, -0.46728161506047566, -0.0650535468566219, -0.44382213464933934, -0.47520597454852626, -0.4776334054168302, 0.08212386877163394, -0.1342364219754146, -0.5039061265729552, -0.07210209794309654, -0.5445186071123828, -0.27862411374014234, -0.4900851939516562, -0.27677880944482036, -0.0319457519789251, -0.45376385375324196, -0.41056300191164286, -0.37289357165594494, -0.46425568737057876, -0.22193075474611346, -0.5012920095289258, 0.03516448583881528, -0.0570398425232383, 0.07455992572716766, -0.3169009050699972, -0.20234567236684486, -0.4274710389840685, -0.42883298203056475},
    {-0.516396846218668, -0.384156409817367, -0.2905493148124915, -0.2217729275786489, -0.15577417494014675, 0.1614853425140291, -0.14983785038676553, -0.2963241157146748, 0.055437777402917186, -0.3892429664618604, -0.16486910192726129, 0.33746670871077716, -0.0961047755432074, 0.21250341244985613, -0.36348492201521504, -0.3620868660562732, -0.4206730971798649, -0.33697585396369123, -0.11525163356897997, -0.295365074090851, -0.1441412845726723, -0.23480319744832837, -0.09007057931162961, -0.34082029163211, -0.3953728173895332, -0.20707911766639492, -0.04575934239940924, 0.05922564520840426, -0.09881536119501598, -0.14682249025355215, 0.09403435137856396, -0.3184924633897695, -0.0013967198598727024, 0.13753877154133473, -0.3574467354869895, -0.32174488527018447, -0.258169139187648, -0.20772363239204497, 0.06025804271753354, -0.46917297410574993, -0.39440187208369465, -0.22303792182817808, -0.22999607020939825, -0.09143816382775215, -0.13965861122258805, -7.477419269506136e-05, -0.09188209284007197, -0.37981956807826567, -0.3067451681619033, -0.11235911945255757, -0.1394609148012172, -0.45896357175612673, -0.331337794518316, -0.17991715675548278, -0.43697741232049214, 0.0641859676415593, -0.5143687082094407, 0.0960676077438938, 0.123000459745274, 0.2976517471837112, -0.08530181232038139, -0.22989860692718156, -0.11569794498970602, -0.48202892073630615},
    {-0.4263942193939219, -0.12773282262602725, -0.4232628704699372, -0.14773482420835865, -0.07350867499534261, 0.21284455169617944, -0.16740819334887452, -0.07865384053166696, 0.10644502159562201, -0.16617528719820032, -0.4338208411487987, 0.32520059005390733, -0.33163740959503063, 0.12852911986181995, 0.036994793097170804, -0.17590128237001443, -0.26679614516148203, -0.4189253104608394, -0.06386689958789253, -0.1948357474070528, -0.28920758818506354, -0.09594029181668262, -0.10732697781391544, -0.29900649645303884, -0.2531604541233762, -0.14889700814837606, -0.2731438167784728, 0.02030479549640719, -0.24483218987902156, -0.03533794744735357, 0.28942087229164365, -0.4697618885282288, -0.013449816852280637, 0.26807622152494603, -0.14950094817392556, -0.12700729950804762, -0.3040870075730937, -0.03822387058551018, 0.2086901291081939, -0.370642567210339, -0.3071686588139452, -0.44999115917397925, -0.34359932517508174, -0.05301688621596886, -0.4042912370200862, -0.1383960651724684, -0.39059909464924486, -0.11163124434838956, -0.494052108807442, 0.1050257769915759, 0.11011801760221832, -0.4038475260188117, -0.18626259687215543, -0.2653702901178325, -0.3263257366985412, -0.08617964326486041, -0.47845674439625163, 0.30399500211493663, 0.0029755065873608945, 0.280609171923429, -0.1445860296390427, -0.22690591289393627, -0.47309688334708144, -0.2849909515445321},
    {-0.23755243736677284, -0.17809106921228657, -0.5235979992133778, 0.23331023194136, -0.19161813348555617, 0.2939687195401207, -0.3606636683067142, -0.3890656258868812, -0.10061225230493849, -0.4680204182366309, -0.17462860084186096, 0.14007428862751814, -0.4795391637871783, 0.14061339216059787, -0.17010210065319012, -0.15839381032410116, -0.5316315473016063, -0.26904871103858585, -0.06307939221181007, -0.34503606537907094, -0.11710373002759605, -0.2563556087023093, -0.4818578229824776, -0.5081251686015696, -0.5049763265795891, -0.44787637539457664, -0.47493044519304695, 0.11910092667936127, -0.06806131768533231, -0.34197478885705995, 0.42755668443867134, -0.3716281677602179, 0.08833145389382532, -0.014036334648156583, -0.08072668061162781, -0.0983117159675405, -0.5666522556711562, -0.21857430820967705, -0.0613984513803546, -0.517423267533333, -0.4393852615102046, -0.0950534853436684, -0.4078400090012015, -0.3377285330389443, -0.15654883014439266, 0.03532346006746929, -0.5349956404394333, -0.31987083365829516, -0.43772461019819325, -0.07914914289406183, 0.014671025320644685, -0.45970744592870366, -0.491756837998641, -0.47615616921388393, -0.5286464113236187, -0.18038612081560124, -0.4339383627678229, 0.1927458461120383, 0.11872863845691385, 0.3217972362438573, 0.07950691652072385, -0.339400561140586, -0.2938816137892796, -0.5062029533474214},
    {-0.13166354463042318, 0.04145790913598452, -0.4354843042638398, -0.28901159310620156, -0.11970216893677196, -0.013869777041881718, -0.4016658968449038, -0.3693060243539382, -0.25269574773225706, -0.4983875443490637, -0.08845359514594521, 0.05356926242616768, -0.3028137133005456, -0.34400269349399176, -0.46175683564030157, -0.17774922758510373, -0.23503433638510984, -0.44774429359477824, -0.25408415066804596, -0.2878378029519042, -0.27268368035680907, -0.04691185321473326, 0.005587571065497521, -0.07711356511183481, -0.15686874853950436, -0.09139590242034865, -0.25882774675533593, -0.12584725700256483, 0.004722232709115639, -0.3660633588599372, 0.37364884437118484, -0.31634038906613193, 0.23040083310713416, -0.09101403296889596, -0.35347653105785104, -0.28060506164324633, -0.3996711452439628, -0.2814448327332601, 0.03427883669133374, -0.44787851408148777, -0.47555276010856584, -0.33126399610601326, -0.1871192990098015, -0.3861518313740659, -0.31286488347486235, -0.28427178036667944, -0.47825868607523075, -0.13645338238719615, -0.2576618567176071, -0.2513814427028179, -0.142002735033892, -0.3156808654020247, -0.17674914423264682, -0.5566505974614822, 0.0016624895648992008, 0.1886548161134577, -0.3620911889529493, -0.006140815410740768, -0.3254348135124677, -0.1394289080669867, -0.04507055063265892, -0.43053028326522524, -0.22482749937424393, 0.007462239181650087},
    {-0.23117914107214735, -0.0939383253011302, -0.2744730230797951, 0.20654223292034388, -0.029025294144749844, -0.05671436117301536, -0.5640956440690152, -0.21255750531386228, -0.34504370732264067, -0.22590810497558866, -0.03752364209984444, 0.3178197750953335, -0.014012223248452388, -0.21422829787358116, -0.05043548901871823, 0.05215320778881321, -0.11693340495689614, -0.44161206444632567, -0.13034886596245632, -0.3762549257595194, -0.3676809676640102, -0.49396464529526624, -0.07924294657629952, -0.41786762479759904, -0.20266695820892097, -0.27282271025647986, -0.08592361329744486, 0.22498960586075917, -0.4263079331698197, -0.022418235859584114, 0.4277018599530117, -0.17996700354035314, -0.00931670749650081, 0.20695126169225925, -0.18197883815841834, -0.3397038473860154, -0.4678930100805572, -0.17642603138832966, -0.1233592533533492, -0.4234932939381456, -0.3503287863043927, -0.3995195057583912, -0.18152672073130313, 0.06597131310945181, -0.09732133595506025, -0.23372828370791168, -0.2554028751359004, -0.4352784209940095, -0.14658179134558633, -0.21780675653396842, 0.08896969669834079, -0.14238437476084712, -0.24681577629726736, -0.5202927913939845, -0.18524064045343389, 0.23516692721532778, -0.1273201368525784, -0.016652078398146763, -0.11583796291473462, 0.22638153714651252, -0.2587528741375145, -0.19584943934799037, -0.25363868679695506, -0.2881878525978548},
    {-0.6024830489092987, -0.362683995770064, -0.16310194286661808, 0.06227684786304159, 0.06843141670904145, -0.13478625249352455, -0.3621913478199228, -0.3354051477501583, -0.18406012661307822, -0.46841722132664165, -0.393832773271665, 0.0704816471767851, -0.2478567730220358, 0.05381725369528883, -0.2614565874996535, -0.1268469396638344, -0.14271803817650835, -0.032104116746594434, 0.14083213558973884, -0.13655476270009453, -0.5024815174218665, -0.41152638834853417, -0.5135411655440278, -0.3371139415157537, -0.26581166582527804, -0.516868629596683, -0.1085989329262289, 0.24981136271111193, -0.11200097051572008, -0.09874469596290868, 0.39187498869073273, -0.2627975734840716, 0.03882907918334714, -0.061538438744190266, -0.17811456921728724, -0.17959267300910592, -0.45335121506841647, -0.3441370308863683, 0.0654500537580997, -0.5828051022193932, -0.433799254985328, -0.3929611088156808, -0.13947258061603687, 0.1759462426919464, -0.41127055148618724, -0.05895608464202033, -0.6316197206947729, -0.36284868533568637, -0.3545196556131654, 0.08902245185569668, 0.1599387038880216, -0.2641640586434752, -0.18688166183568147, -0.45429826324309863, -0.17881295289554952, 0.3003633620268925, -0.10216788024191861, 0.28598999446884477, 0.15649392373314214, 0.3847493488696076, -0.34583793821575237, -0.3673845419038977, -0.2798409578193954, -0.3001290157388169},
    {-0.6409546630237826, -0.05119549516702723, -0.5272360598983663, 0.21395109878378535, -0.176592310191625, 0.14724389729397627, -0.38165008664838523, -0.498468163865049, -0.24285849660920691, -0.48646585789558844, -0.09408987972057545, 0.31490588623570454, -0.07715502654428093, 0.14033597589762095, -0.06877650056327814, -0.12520363389683073, -0.49255129322262087, -0.18622483285989458, 0.06409478938041184, -0.3059095110214116, -0.4228469994973273, -0.3739608162238504, -0.35227831789164227, -0.22340342003429853, -0.5696636020272743, -0.22604838246781292, -0.46638877731055245, 0.19486325809095775, -0.01253361542522624, -0.36386005875011923, 0.4039747007055059, -0.3878765693167636, 0.05773940689744016, 0.06857616433660453, -0.47807505707287284, -0.29519758924652073, -0.1960216358349776, -0.15103251837808657, -0.17015542159120647, -0.518276165932802, -0.42933952321899693, -0.1886869032667631, 0.04597787564666457, 0.10228733430909787, -0.46275596328066504, 0.14090532184826415, -0.510377187216635, -0.21782920038516287, -0.5576448848184182, -0.043609353222319736, 0.2429909740581353, -0.07658379292233403, -0.44720020215954237, -0.2191484905080314, -0.10898267474510588, 0.07841029784656088, -0.18290843895426734, 0.30170319085401465, 0.2248252886102329, 0.19046742753435703, -0.21844660426319665, -0.26120393481283977, -0.4664228819201891, -0.29231865602895446},
    {-0.6373200726525139, 0.0008472206456082156, -0.46250576556955475, 0.32183398717388795, -0.16900139103666925, 0.4588750441474195, -0.5636387370684219, -0.5264598263408446, -0.07865090333717743, -0.5534701124998267, -0.3873239002264591, 0.2945864287270341, -0.023480690545193975, 0.20990712966810293, -0.0488070241400982, 0.09854825629389559, -0.45254628512848827, -0.2191186546360442, 0.04098142559860117, -0.3320057692908044, -0.523295671115683, -0.21473555186284976, -0.1547596203023382, -0.4136003983901014, -0.3784117255144059, -0.5097638225477615, -0.42690587963299187, 0.2099929138772816, -0.3285077146802289, -0.1169850026585076, 0.5248138525584435, -0.2452550054280713, -0.012868957577146733, 0.29255324477419264, -0.28104763318376824, -0.31192680087866764, -0.30854282454502263, -0.20994293447984907, 0.22537499327853336, -0.27796796276052, -0.5613023080507006, -0.13196591012192446, 0.038840857402884135, -0.11152707389045068, -0.34599040943252596, 0.17617827969621822, -0.6158933783067111, -0.13679312886548667, -0.23895289703813835, -0.055523039415094025, -0.07510306328609552, -0.42854545371708785, -0.42899803944151743, -0.3032157859773602, -0.34903536745503705, 0.3441564019183932, -0.38250987227490985, 0.04322103174480577, 0.4070564142362983, 0.39055390819866215, 0.1546776667522687, -0.19832446264397546, -0.2551308403509423, -0.4836655783209629},
    {-0.4557816947927338, -0.3676683517436673, -0.44690235505046416, 0.2600238500331249, 0.023537450302877416, 0.3026425735314243, -0.6479663149769637, -0.2607063134821015, -0.24473543886561522, -0.2304468499947146, -0.13471609735160545, 0.03360219975970529, -0.28745626168561217, -0.05271169327411672, -0.1476925661825702, -0.23826977900235147, -0.4293396972017199, -0.14324836901025098, 0.031583109081654584, -0.01238741311664532, -0.29255563285004316, -0.3803541135424983, -0.4119700092689725, -0.38971632791566085, -0.43165548107979146, -0.0778709484905427, -0.40793317358139825, 0.0813739867764272, -0.13674686550088544, -0.011218989577198682, 0.11275115908927832, -0.23119977659720983, -0.3434458854929166, 0.10133779308628692, -0.3601077366689713, -0.3572872715156898, -0.07771370849023371, -0.16918644233797092, 0.20372564714234326, -0.5157657424069638, -0.40809530848943043, -0.21680919537857435, -0.2830361702022389, -0.17947032255039136, -0.037881890448744515, -0.14543710745751398, -0.32609694085032565, -0.23073113971804074, -0.3350778562652146, 0.30249960592706354, -0.14329806637004003, -0.35097258949097215, -0.22188263100665112, -0.3915585834192819, -0.4353467170602107, 0.2690014329391072, -0.1720418432643958, 0.05821296618234927, 0.36549920233221683, 0.07142444496852729, -0.1910927720788173, -0.14824821499368965, -0.32750619669135433, -0.4800076773937685},
    {-0.5800232462052196, -0.19082268808907266, -0.5350015167902874, 0.19778298349515314, -0.1729791961108268, 0.4181939189593155, -0.381863720283901, -0.30468499446001834, -0.1167001310125471, -0.06982965289141614, -0.06285071598932121, 0.2986544649587964, -0.3504090949584461, -0.1068502131819941, 0.03388844729961092, -0.21861299107660986, -0.1787131011961601, -0.26759081656038725, -0.11629138419944492, -0.2057680875798644, -0.15392975143127077, -0.19949255144480904, -0.3924585825983446, -0.4909378916036576, -0.6035921776926638, -0.30807356478351183, -0.436369956512102, -0.020206434485625677, -0.29735529561210394, -0.09803726309588813, 0.2663514734687962, -0.11940070044857536, -0.33745931393821954, 0.15426431159591386, -0.3055160113702201, -0.11201934884625638, -0.39388873203708896, -0.45122838902022006, 0.10995519721211688, -0.3404718670402494, -0.445584204337672, -0.08515664089154142, -0.362755795702669, -0.020993963874705934, -0.15316312884090247, 0.052084023052746356, -0.5379264820964461, -0.4596131017225059, -0.09829814808707837, 0.06978799853626691, -0.11041590784441695, -0.2855015505083666, -0.13592670557483238, -0.013733100385990902, -0.29258611480644997, -0.08990903616212409, -0.31980339705482763, 0.13089611012231506, 0.15542335336513594, 0.14776483487252115, 0.02195189742330725, -0.20986663220801027, -0.14909463081046817, -0.1936585639088722},
    {-0.28708231588216265, -0.18499544303050097, -0.4819271569227562, 0.2667011151909219, -0.1605044474916833, 0.47453914198618524, -0.6423236593397211, -0.07484048118802544, -0.14382397323359344, -0.18632512270832371, -0.08020214604560595, 0.23008047560164846, 0.04249185497088508, -0.18046910921562404, 0.0849772641281347, -0.23083234370036917, 0.0479755796875165, -0.17124527658246336, 0.009020015904188473, -0.09287479644136552, -0.4493045708356463, -0.06527620076415241, -0.3240304180953187, -0.4167454123378704, -0.4052244972170927, -0.09205297749954908, -0.3432203842686976, 0.12739750541354503, -0.2833673474344754, 0.03961527571831058, 0.18699868987284468, -0.32602467922603184, -0.10866387854864962, 0.19978829318987323, -0.49488207805048817, -0.40727129569305087, -0.10101572007737787, -0.13193463634156, 0.06524455780094085, -0.5201054228964904, -0.20635557827815196, 0.1625413998634309, -0.3569753670725774, -0.02704223216032684, -0.09253978613275456, -0.15585402536776566, -0.5588102993426822, -0.049604854808124016, -0.09622637282834624, 0.2545775124365214, -0.11556590740195373, -0.14548040279972743, -0.21569781211403335, 0.038621628920320505, -0.04881410440257947, 0.27368494434559976, -0.3885882658523614, 0.3200934727374825, 0.06302603197927813, 0.3936759153431126, 0.15591577549771943, -0.40481980644224025, -0.24400427409382633, -0.4871500978556235},
    {-0.45969827726651963, -0.023217777956397838, -0.45452167929076365, 0.15564407775901026, -0.25275998376493475, 0.45345254323788275, -0.5248876684669626, -0.12328403581293232, 0.0036383264267295843, -0.34694524005521693, -0.14942311816760018, 0.040393944964067535, -0.26208902655265587, -0.3010025466677855, -0.28074032619343975, -0.02669508744851273, -0.23363813085264093, -0.49294085844207086, -0.09691566834925221, -0.032384093767426306, -0.5738466940759662, -0.2707462084405852, -0.10797016926633474, -0.5179702732626745, -0.5882310345805738, -0.33204239549602277, -0.05991001936074918, 0.07060163982184804, -0.27009079043632267, -0.11871427707450216, 0.3223104111658989, -0.5175388189326898, 0.0947180639074678, 0.12999584874053655, -0.17370730127113498, -0.13311486795218883, 0.012921873880882872, -0.2655375375319225, 0.20009997756976783, -0.3395846139945621, -0.5486468055594185, 0.11481346810204875, -0.23922120288208124, 0.02460109076782067, -0.4088868463049016, -0.2183501644899626, -0.5097516996900784, -0.23203272225592153, -0.3438625053877684, -0.11243484208569247, 0.11383368179067865, -0.36167395488962606, -0.19265598086148478, 0.004106391379763439, -0.19939474960876127, 0.16287879528727, -0.3326340414487669, 0.35585291633465194, 0.042518605094167654, 0.32956374535036614, 0.16088718991120207, -0.4418517542076774, -0.5125588417264831, -0.40693053735088935},
    {-0.3115765656656429, -0.3936110050186551, -0.5035720887067954, -0.0015361102797830223, -0.15971667128053166, 0.47233501502646347, -0.6129818509102039, -0.29096924395926077, -0.23756918060135107, -0.2973079776296949, -0.44814029747545003, 0.2233935212958868, -0.3314723741243376, 0.0035008262570689007, -0.2759955943617804, -0.0860837725395848, -0.5038192093405237, -0.27379031761616146, -0.23994341432056865, -0.30499538032821305, -0.40721156706014977, -0.47233768728130376, -0.33690575493206026, -0.42855973500502775, -0.5606528964183238, -0.5310784761189774, -0.12908190985890453, -0.12696886929159548, -0.2474872616145021, 0.0066244564309389155, 0.3699747163758843, -0.3535505288007771, -0.09316458018966621, 0.01263751556213796, -0.21402847959399063, -0.18897766510297237, -0.3556453995103882, -0.3415445555966753, -0.2350654221621974, -0.4717063099663413, -0.4553849230957743, -0.2296270295682754, -0.11439260051411011, 0.13452962653877185, -0.4611918707098814, 0.04310847287818321, -0.37493768304918584, -0.5384469595044838, -0.5672100906953857, 0.09783762331233288, -0.15176630578298447, -0.3614590924658219, -0.2979951597292415, -0.3020014643183521, -0.21928922418436209, -0.06752523467649484, -0.35695497631943546, 0.041472149698425796, 0.07042882809182324, 0.060729766380897554, -0.26123162013330264, -0.3627878697368105, -0.5851631824792708, -0.46770793531723837},
    {-0.5907214692037472, -0.18923719555927968, -0.39828130678292667, 0.015958194941979337, -0.1557406813667109, 0.36284950411363337, -0.39719081131795847, -0.39818140955081743, -0.31100155637891075, -0.35255964699220443, -0.014894535000659305, 0.47124758445368004, -0.2293529354865002, 0.061041433386585804, -0.2815664643167462, -0.21016260861302466, -0.17445953731498, -0.30143274766334616, 0.2967317586832836, -0.20294422834011036, -0.4088453784082747, -0.3983399872177811, -0.23249614366710616, -0.376710390634113, -0.5699913464252999, -0.2021941640032486, -0.1632637922226152, 0.12909816004512076, -0.31949451395121387, -0.03501160232671179, 0.22046179097715554, -0.3619576147567165, 0.08982003740668262, 0.37586452797231384, -0.28288352259836225, -0.22671262329884065, -0.13852413636692607, -0.29274900915211377, 0.12196377409374176, -0.676373091957484, -0.505123419620325, -0.21765633682179794, -0.32749721250097086, 0.2600029732281709, -0.5094478661568238, -0.20636082375708167, -0.6618445233500289, -0.5534759635227788, -0.20234550338830481, 0.2420656221711855, 0.1908430842266475, -0.4699128380148082, -0.3100933846416697, -0.4252356570528456, -0.24266442617718692, 0.11941932290042342, -0.3139282240497194, 0.3694402860545305, 0.31983807612919923, 0.3230335549204859, -0.11070578461381592, -0.4892794989418656, -0.36423882083079334, -0.21625456480675703},
    {-0.6872856631492588, -0.16386324331222973, -0.5304818887637334, 0.3602275581966926, -0.023947227585940763, 0.5504970980625824, -0.40345788353688194, -0.2525361923893675, -0.038019009149133545, -0.41310211895986343, 0.11281243301510807, 0.6479529879737932, -0.10527040081149697, -0.1635489731291257, 0.1519796036702512, -0.03873054978444375, 0.09456604313971391, -0.13051445855015575, 0.24991003601197465, -0.12811192522983642, -0.25638957480741636, -0.35164303590531487, -0.19946598177542402, -0.2852045149001234, -0.4631149076777804, -0.2963185905476854, -0.04063257842942948, 0.36633454910943997, -0.29107210420759877, -0.005527083753794697, 0.4508584137524875, -0.27191801404416377, 0.07293515634796228, 0.5106055068749503, -0.3210310694295294, -0.10287632534598817, 0.023189628280500613, -0.5091988368516825, 0.36535677442074505, -0.5510504501449094, -0.576623650652405, 0.15304399374285105, -0.21317006884674938, 0.4292834181161268, -0.4667438565540027, 0.13633413632442992, -0.4219802926151546, -0.3445507055447723, -0.15830579440003606, 0.3232346468406092, -0.02204530451070497, -0.0676332523204935, -0.1303240832399433, -0.1416455499329904, 0.11072691319360804, 0.5144916145153636, -0.3186024146391499, 0.17841610803694344, 0.24466594037838452, 0.6403437815129087, 0.13274995780714458, -0.5840210110425923, -0.30332829945806544, -0.2810705797294473},
    {-0.5475600272008263, 0.25307081563999767, -0.21886120293441502, 0.22444251006603946, -0.026377211234403973, 0.5862381995604725, -0.5526536514892136, 0.1541090436116027, -0.2179263153422356, -0.24731441509175928, 0.1724647204007265, 0.523896020495383, 0.1057171480486167, -0.3759587904386145, -0.16359184372608196, 0.1289024103182132, 0.2988952101643984, -0.4832726064768007, 0.10171875051091349, -0.37692562016314324, -0.13036570314898333, 0.04240063630247222, 0.16152272824158412, -0.10559801113811351, -0.6753431896115334, -0.29034664892683887, -0.05216922059700662, 0.4069338464284319, 0.07621144991806428, 0.05550089367024666, 0.3849830645390428, -0.37061231693866087, 0.22736977466825772, 0.6268889792751297, -0.3473793989267678, -0.33782559015210617, -0.1096610584362206, -0.4598616729196345, -0.1626175480716235, -0.6704742978778405, -0.3820386424232713, 0.6350998421982529, 0.10925255904311229, 0.47924711461037656, -0.05239446537766883, 0.22977385493723426, -0.7660604368346365, 0.019071003806227452, 0.06645892644674356, 0.24150672477676624, -0.28708374148204063, -0.260143597335465, 0.08553714842884415, 0.30407559174112925, 0.20801716945406934, 0.37934240506087724, -0.11125953848179199, 0.17917617788278462, 0.18258389767232877, 0.5290702255477728, 0.4360804893887283, -0.4180273946083255, -0.46954781879597174, -0.21030519954218843},
    {-0.41206066344638215, 0.2832642956891027, -0.5601882853615524, -0.06190844460762598, 0.09647462509539614, 0.7164481738462267, -0.6958067708233902, 0.06508182765898149, -0.4674528380552341, -0.3164430045355287, -0.12412046278761517, 0.35562575229490995, 0.015584903752441225, -0.41939420299215097, -0.32941906123328457, -0.08283819322119539, 0.011513635662813566, -0.44463123961116424, -0.054877509500402724, -0.21444644640228677, -0.42219525766848587, 0.015337674260681722, -0.05750607475493307, -0.30532864449774744, -0.589197461774304, -0.30334242967551933, -0.34149354898087986, 0.27269194085112886, -0.3557879767434141, 0.1282884406659813, 0.6515229502197005, -0.3110961103733623, 0.273127347839443, 0.39368031437033, -0.10755876526860596, -0.3702364773863392, -0.2839401719508646, -0.19759120507032582, -0.15475864149174243, -0.551066523583442, -0.3908588011958999, 0.40538841049814495, -0.06547492276194654, 0.2946447202767379, -0.4514187490662994, 0.0015162258199748753, -0.5181102380042629, -0.37691673079689625, 0.09181977219245707, -0.0260980536862297, -0.2287574667727881, -0.38705168604881934, -0.2324342596156205, 0.030168431536965933, -0.28235910793949565, 0.2632868198726717, -0.30610491032154036, 0.2809595741789477, 0.3257250636361731, 0.5026553144285325, 0.2988431292156383, -0.4970240985650546, -0.28724366273498836, -0.27142478583214336},
    {-0.36735935352120996, -0.25471124497983627, -0.6281208216548617, 0.26462123228046847, -0.18370660263662825, 0.4833616894472119, -0.7136220578565621, -0.33984529945602865, -0.2853199977786478, -0.4955607164482877, -0.24599925533868908, 0.285757970130467, -0.09883816899654976, -0.16906734969791767, -0.02283630692346126, -0.0019062081077949168, -0.22886319714216222, -0.33082513857170454, 0.137083006995416, -0.16815348584872616, -0.30536311299495456, -0.1448207425386783, -0.15150860668794197, -0.25962779551105886, -0.4658636957811873, -0.30777035689268945, -0.4119721840827048, 0.04194146942080381, -0.5246886756241689, -0.20319921169783264, 0.28088324429428113, -0.41034177866175503, 0.025873781431966475, 0.2566862343628145, -0.48192416385138515, -0.41000585978717274, -0.09847196475374717, -0.5118769479201206, -0.09890857065389838, -0.7099855817219584, -0.5497209724240533, 0.09328924252123837, -0.02399731601341175, 0.29270871558518186, -0.3767573383320303, 0.12551306129952572, -0.4556451990204931, -0.18965994275025774, -0.41989597598442413, 0.11590730520759734, -0.04017102257439322, -0.2987610681113636, -0.20850785223919227, -0.09408435398429563, -0.44359439151349006, 0.017939268250210062, -0.5990970742080695, -0.00029404001011630257, 0.33390727298202344, 0.5021428853395823, 0.14222014644274056, -0.3126111005221677, -0.3903041961108444, -0.4859119516852457},
    {-0.6276728537500309, -0.010081224811873943, -0.4654559029331795, -0.000563945621988053, -0.1506297418347182, 0.6285106134628899, -0.403506214339719, -0.37072280688649023, -0.4557480575034814, -0.5553164963183473, -0.1387111722388986, 0.2002224535125125, -0.18767641748016356, -0.4285474111046317, -0.04863342089349379, -0.23653753271949685, 0.139788844326073, -0.6222771976559035, -0.1087691338395399, -0.5680251710770446, -0.2384759824891993, -0.3172342090763666, -0.3828169351680892, -0.2330852639404166, -0.5616707725380182, -0.36077784231038873, -0.23704629110610534, 0.29179161892007655, -0.05595084687148826, -0.01928371977510395, 0.2766620109286242, -0.33069300977594535, 0.18049118313865994, 0.13261659220168623, -0.4053432604020018, -0.16876042671158517, -0.22788642038016477, -0.3361779062247148, 0.07382236358702868, -0.6352107653491482, -0.6244860215206917, 0.42354162097998443, 0.24289017495573795, 0.409742889639679, -0.21843042764676743, -0.156168234092088, -0.7074983903506371, -0.223286362941313, -0.20116992582120177, 0.21770876859635244, -0.23323716945082987, -0.2578198458318273, -0.028006392614781512, 0.19665092897792447, -0.1748836886466009, 0.4572777475626782, -0.3315653829989921, 0.08952438166501188, 0.3172321227294761, 0.35340813761381284, 0.3301849590214048, -0.35255859024069214, -0.5262952528512423, -0.05858023173561315},
    {-0.6440920237279513, 0.14500349781120908, -0.592781693445502, 0.12566999232251314, -0.03526966973209654, 0.3828393044841485, -0.4292626483884221, -0.25096253722092654, -0.2182653269761658, -0.2793910148231711, 0.10286585724632416, 0.2911997888892179, 0.07043592040640843, -0.2586122723584714, -0.2829076310106073, -0.21192642451354893, 0.08357356212333494, -0.49497493015916244, -0.13465066235337897, -0.3426489896871958, -0.4512792955594467, -0.25365030458715765, -0.05969811216100372, -0.43075707366197036, -0.3970681074422643, -0.4357283637187059, -0.17813945354635974, 0.3872937442271581, -0.2541906483362774, -0.06380581659710645, 0.42927398532412303, -0.3720587042816559, 0.24401534836479097, 0.24899827042162284, -0.24862750610015966, -0.3779152616986167, -0.21669007656045036, -0.22766000935466096, 0.043022627579262424, -0.7593144385553374, -0.3121319702916294, 0.364036993654938, 0.2336429009885861, 0.2675754561042972, -0.2355701866620138, -0.1979759853978697, -0.5102395777331304, -0.16467008573657277, 0.019852693001216948, -0.08785547055539948, -0.21284299512316368, -0.4967435132208281, 0.059805615758392626, 0.08347310062773722, -0.3520832099693004, 0.2591636897786347, -0.4371550343661498, 0.0039122635844157875, 0.08441051243608756, 0.5116075318370583, 0.3076062425406169, -0.4890100401351021, -0.33901130208271135, -0.2685452536013768},
    {-0.5503385243840688, -0.13794585619016755, -0.26618637973563625, -0.03329799356407833, -0.2228990097976108, 0.30627248072354774, -0.5019039444503585, -0.27127428699033973, -0.5182225240623672, -0.35516056489347836, -0.08938992200979969, 0.42309474952026693, -0.01658867161145661, -0.3076468523573194, -0.23355872556396406, 0.08075879691769387, -0.07929812325791735, -0.31048225562141224, -0.14173356850160118, -0.29464864306498606, -0.4346693436683384, -0.42263608709059436, -0.2460646065106842, -0.5720136219614896, -0.4175901281545172, -0.36890681899169353, -0.06718395635307692, 0.1311420641270442, -0.32089613062604, -0.1550409259695933, 0.4467539461306518, -0.5661185137187025, 0.25112375734666303, 0.4678112099951609, -0.25465306903988755, -0.43123787561596827, -0.32103450302810815, -0.586496564621866, -0.17420479749614176, -0.4248004963294434, -0.4395691073333905, 0.224957246236236, 0.16173018575750944, 0.27612991781192375, -0.49336619507914886, -0.09768191772684814, -0.6949303849477163, -0.2815366129167471, -0.24485095587863276, 0.2513603883867833, -0.11095261941006128, -0.5244683383349115, 0.02722828826609985, 0.15909860794611708, -0.34138018041847173, 0.3808934729910576, -0.5305211226851715, 0.3098311972549082, 0.30159255769866183, 0.4913524109999906, 0.3069483392801093, -0.3998755858096452, -0.563964179491052, -0.31784752273227984},
    {-0.4556331472516473, 0.16547700433650417, -0.41305969083376853, 0.07321509672529458, -0.28669505349568003, 0.460362370998885, -0.5055627444967278, -0.16635253697801053, -0.34436772533966287, -0.32994909339258827, 0.04005835168771732, 0.22882878735529835, 0.18281345858474146, -0.22367355564026775, -0.16097358278273724, -0.21359260480548914, -0.10658018153434672, -0.3397185069762987, 0.19699310393097308, -0.3399558312639436, -0.36577005886780206, -0.21788273952620574, -0.3863815321461726, -0.47553999234091426, -0.6981832337877245, -0.22666943374145668, -0.40894986110791154, 0.28482053691623654, -0.04432473254834304, -0.10140001867334483, 0.42776617341574635, -0.5964550408115142, 0.3756208596527358, 0.4544012806048381, -0.3622595366745118, -0.517132316738628, -0.03178551412520129, -0.5376368700318936, -0.2066948466813411, -0.7618369845493503, -0.5046294558355043, 0.3756894794175353, -0.07110152636177952, 0.2543611671577433, -0.4268270571669157, -0.0010772107755846402, -0.5053437148500791, -0.2986040117558203, -0.03515056048198771, -0.09913465279147338, -0.1891812728874571, -0.28479052366248175, -0.174363127845591, 0.21689898741360567, -0.01690545199922264, 0.6027770222693088, -0.37864960001654524, 0.262744534866578, 0.2807956640887868, 0.3156603679251325, 0.3811995751859784, -0.37806837266203025, -0.46005055675570217, -0.06739275451118014},
    {-0.6072534368945862, -0.050866766795452927, -0.3670184069770227, -0.020597506211572338, -0.15141427527898707, 0.7518617256848233, -0.5517203120844034, -0.11340316284764376, -0.14982718680643156, -0.4324792653878379, 0.08575201226143249, 0.577435936727062, 0.13549653694344077, -0.11401020285405854, -0.07725883170840872, 0.05494120771629308, 0.1866182745124573, -0.26419969696411916, -0.030582130030754717, -0.5128026087230694, -0.11435276227363976, -0.29235929462770993, -0.21926198357636184, -0.276052901000563, -0.510647045528241, -0.10765316498557996, -0.21734795552801583, 0.34663742774949047, -0.14549498222367138, 0.11579021163380952, 0.6682385916705469, -0.480395881490054, 0.25948194353058074, 0.22611437011513497, -0.12200866401930159, -0.3374905023036059, -0.07443278421429907, -0.38555819585943624, 0.09962641416482143, -0.48736259277102456, -0.41445193663790597, 0.37160075053785113, 0.19570273751092493, 0.48221701460690963, -0.35086638993228714, -0.061547535691708864, -0.6613314108832278, -0.35848201549669606, 0.10131430104202906, 0.18298275251223978, -0.3529552080720732, -0.2334637722319146, 0.11252025384827503, 0.3283214951387072, -0.06765208447927332, 0.6650915820794226, -0.05565188173547718, 0.10214667100935501, 0.1564002028042305, 0.41949214595974854, 0.2628628393695687, -0.7054530427049864, -0.26766647047573616, -0.23227989296696008}
};

static const float b1[64] = {0.6975241073912023, 0.6829508658071282, 0.6676300862128965, 0.6343560795771759, 0.4857449790250424, 0.7050138765917383, 0.6862659420509727, 0.6713105108280024, 0.5735062398497773, 0.5881309721942771, 0.6570060562111606, 0.639813396039556, 0.6424472823836889, 0.6364505306169344, 0.6082349772677851, 0.6979902465255879, 0.6757671334608633, 0.6347177679189379, 0.5005052777363824, 0.6803615132426002, 0.6762585493862766, 0.6898727607792804, 0.5218292279391495, 0.6412572663374119, 0.6936989500793673, 0.6736749288190541, 0.6054268170893201, 0.5254451185885999, 0.66542176711442, 0.6890609624356189, 0.5748973641010676, 0.6322476822877985, 0.7137004455364693, 0.6926015332367984, 0.7092442873160909, 0.6509415035562951, 0.6508762016555556, 0.6780873828088663, 0.5378020232562606, 0.6823643863669939, 0.668555464815455, 0.706803421262945, 0.6027020608878887, 0.6064738952119957, 0.5938662970416756, 0.6125057267447418, 0.7052693861425461, 0.5415797585585105, 0.6566644480379915, 0.6188959608248447, 0.6405533770365923, 0.6831312729359386, 0.6526857956275419, 0.6706089391413504, 0.6344316509778365, 0.6626553809669178, 0.6899142950202526, 0.5437925929722675, 0.5682583788431809, 0.6601692964509435, 0.7040240040661692, 0.5819086435226737, 0.6071400353759334, 0.6756559908724215};

static const float w2[64][32] = {
    {0.4736218406839314, 0.7491480225751143, 0.8572803587392414, 0.32971033011949036, 0.29341186396380053, 0.44394495056490363, 0.16567545243769838, 0.5872443333199034, 0.45241394505503413, 0.4752622185461622, 0.4389584887997341, 0.47215388099820355, -0.16526998701894102, 0.4550591719529805, 0.702136661906132, 0.676317010296685, 0.5681902639877707, 0.7079036556766689, 0.7226938845732324, 0.7919637366159824, 0.4817685532816354, 0.7616103113020685, 0.4664068299244574, 0.8189067344152814, 0.47730901461301534, 0.34268521945644564, 0.7887591488019975, 0.517628978885075, 0.5455668504985969, 0.8660922307915774, 0.20837599356319644, 0.3445601407033908},
    {0.40782904796769226, 0.6588702430193477, 0.4756633301854753, 0.3570302643313998, 0.42553631009496423, 0.7003467128686112, 0.2578179253633768, 0.7409172631384403, 0.7499774648579972, 0.6932825733049889, 0.16182096423554446, 0.30067457550118154, -0.09237094055516312, 0.48460522580520654, 0.47983755116160637, 0.5629655067801198, 0.7136640531753154, 0.4859556809319658, 0.33336498498567246, 0.4831991237563113, 0.7847640184928003, 0.7606020297845356, 0.7737424076276163, 0.4010092364741308, 0.4027942950660695, 0.6408567266390218, 0.41335835558537476, 0.24192742494619734, 0.6927416790754185, 0.5478212595285726, 0.17558922690591672, 0.3721126004915594},
    {0.3753226460250965, 0.629534018518165, 0.5180266767498464, 0.4809045080835937, 0.6916087353046633, 0.47887872479145305, 0.5053972046232428, 0.447818982455704, 0.301113270258034, 0.6709324281305484, 0.1304161342795185, 0.6717961022405428, 0.11884190859213023, 0.5418920001789628, 0.6959003330684682, 0.8529211603075887, 0.6947862553274167, 0.5540778266901107, 0.4804343343499251, 0.6607282519164217, 0.42396916382470823, 0.5281768916328772, 0.6287080785873377, 0.7996439957933771, 0.41587734074137717, 0.5758541440395244, 0.6588479675219773, 0.08537853654754786, 0.5831948012255123, 0.826384783225659, -0.07636526060546155, 0.5001852552538357},
    {0.3513127628120671, 0.5561892225333085, 0.378357616455129, 0.6472462112990621, 0.5377450479896425, 0.37274672397734687, 0.3505557509292452, 0.36751184681245025, 0.6925888662585634, 0.590489045994644, 0.55212145687246, 0.5680707605702037, -0.1467656307050166, 0.7480487493822803, 0.7676263723240832, 0.5780696285156125, 0.671068124367326, 0.5687063399906881, 0.7294490673468985, 0.7477924175560997, 0.3670114259989752, 0.5192336393416164, 0.5633780860497865, 0.7935288892584461, 0.39751382240437916, 0.660942127583702, 0.6665895950261709, 0.18620302670588684, 0.6013217048441627, 0.5536901099687869, 0.1449307512578752, 0.6692917216477264},
    {0.45074860346445866, 0.784875318828276, 0.394076844973529, 0.44932202924394726, 0.5708806746176069, 0.5721798089269897, 0.6835187930118299, 0.47793592181000166, 0.706068522332535, 0.43267815532764015, 0.5640597862651303, 0.7310208156962384, -0.19174816514552892, 0.48218814098474916, 0.41040673976012954, 0.7156717489380221, 0.585737221961447, 0.7721385957764823, 0.4742163901893649, 0.4159509516815553, 0.7423790630217171, 0.46778163346167095, 0.7989731326387772, 0.4042610318261102, 0.4794086379760377, 0.7469070551262063, 0.4226870510173639, 0.301814880195793, 0.39439074150170095, 0.5040995671243785, 0.08177633727734471, 0.6777576417785585},
    {0.37819613439524935, 0.3724982100419226, 0.8133564011071606, 0.41265950886616615, 0.4319213046633257, 0.469588565045917, 0.6353341343175777, 0.5058481268738566, 0.6140345735326613, 0.5344255767717266, 0.364069597752593, 0.6303368090050773, -0.13810274797396085, 0.5440603228459202, 0.8160718381171207, 0.3680786293365124, 0.7168275463615345, 0.36489658370248523, 0.720105137481381, 0.5199875013106923, 0.811509533436749, 0.5839734022012876, 0.7780058929087031, 0.8502332402807512, 0.7986035827280942, 0.5713866150440927, 0.7980404986943783, 0.5820784599910253, 0.6174131220682311, 0.6772873791111266, 0.45816792160749287, 0.5546694755801189},
    {0.6188861830949607, 0.5759182053618729, 0.7834005962888639, 0.60039621880233, 0.23660016545726198, 0.4602468105675734, 0.28000873809742954, 0.7729444835831848, 0.4554372408391076, 0.6941552698184179, 0.4115870369135865, 0.48439409153801366, -0.03034179252389523, 0.553572607076571, 0.5650597882423455, 0.3976151011614568, 0.6285733427412186, 0.5300900688963143, 0.5355547398574185, 0.5834099013133699, 0.6797134362270757, 0.5434806063019352, 0.8703579756985054, 0.8128297019625571, 0.7469818673800205, 0.7223076694568424, 0.8326255820032513, 0.21164121052201942, 0.7821584079207439, 0.4814485800541929, 0.29077709296449933, 0.409449078264442},
    {0.40087365689821075, 0.6338971560703421, 0.7967628044983599, 0.4831912596212093, 0.5177280636122675, 0.6138519591288518, 0.42609592131939955, 0.48125179533036144, 0.6082643287745186, 0.36199754228988923, 0.22247277489255565, 0.5741589426363509, -0.07832209717962108, 0.4681327490121046, 0.7035236434289412, 0.5693311525258109, 0.7777170753417594, 0.6955876944003788, 0.37753346325117376, 0.3900022631568887, 0.6774578997013195, 0.3942125720800071, 0.7422068550856509, 0.41404544787848446, 0.7744972693195112, 0.40725201794448546, 0.362672032017283, 0.09386270708230746, 0.8100502051362471, 0.5596503439954134, 0.23433205063289955, 0.6287678798660781},
    {0.34490878533856034, 0.7563462639336282, 0.6936732756554667, 0.42341656961446017, 0.5578912751951927, 0.3064081193242789, 0.692174416728653, 0.6857721124224634, 0.5468334880829222, 0.5598809315586548, 0.4823011915213265, 0.5936332461894305, -0.0899425767171309, 0.6004539396836878, 0.4208981496346685, 0.3603976856421328, 0.686598931524139, 0.7011258868622592, 0.4548910166117828, 0.7903159158881057, 0.4509539998593978, 0.4629722394638515, 0.4064513907852283, 0.586807290841925, 0.40645550053535967, 0.6914176523078469, 0.6355358612910432, 0.3511668981375152, 0.6090724424317087, 0.45270717853307385, 0.05878999815111207, 0.6403620378586471},
    {0.5372164654414325, 0.8090153897040268, 0.4270437195000674, 0.5058239590499419, 0.7706899214010088, 0.43438395000929886, 0.4109104405219028, 0.7201346328792015, 0.48437748111193213, 0.47398096727493866, 0.5064237525853864, 0.5679801358240515, 0.06867322160005267, 0.6989411045707061, 0.6554979635831938, 0.8522739198471377, 0.5436666032613835, 0.803650519454997, 0.5777181786989131, 0.6547158027363864, 0.4181414889972765, 0.7408675088201493, 0.40243996435951584, 0.5887433294840195, 0.41144867211958824, 0.5357732408467829, 0.48593047156979335, 0.3056390161404142, 0.783777571692912, 0.6785560067164471, 0.1521366541500205, 0.4636461501560344},
    {0.5428476065059135, 0.42305397779105647, 0.7398696353813182, 0.7659467393101101, 0.5140590982986014, 0.6197906707976314, 0.6271833585970312, 0.37065895307219243, 0.4476913614144493, 0.3224637172630159, 0.3308149602456892, 0.5068304747012569, -0.016957091749221997, 0.372935617117992, 0.77780104706708, 0.7690001354048465, 0.6921683312753547, 0.6672043366678754, 0.23396792312880288, 0.5386901788513189, 0.5994769148673406, 0.8625469449275389, 0.43500526505570797, 0.7776535703322331, 0.5349015260263957, 0.4706152678848326, 0.8214823311421079, 0.0867591355924524, 0.5007117351857437, 0.44019759835062316, 0.41849030816285104, 0.6005809708173572},
    {0.2878771816150258, 0.4201948964317982, 0.41079909212862886, 0.7633015359337166, 0.7304842223265317, 0.7021551213579562, 0.4537027164601211, 0.3957194252212171, 0.4829888183104495, 0.4876364562184482, 0.3446889417909789, 0.6056442161309956, -0.029509596542657366, 0.6145506568433231, 0.7526419145081319, 0.4266267562849793, 0.7118531440361215, 0.36536573994284066, 0.7212204499145125, 0.4964999853647193, 0.755435589354157, 0.5622899564876703, 0.6239517427547052, 0.825192680907948, 0.8006487869681254, 0.5372743868137344, 0.5241467717048691, 0.5615136823912369, 0.8047415857987262, 0.5357072070851504, 0.23806411139416403, 0.5648480470262381},
    {0.34669065926125264, 0.6874402580596395, 0.5050476231166768, 0.6967398907454723, 0.7163474695399493, 0.5634993064490217, 0.5218596753654151, 0.5706007980377468, 0.5809907476291172, 0.8316642194867816, 0.39791694858490406, 0.5158715010927789, -0.10789201145315788, 0.38795696179316563, 0.7303394454399676, 0.39142970298354984, 0.613010626149864, 0.348905494786201, 0.4076665481132229, 0.7397223871970894, 0.5440105609792343, 0.6117028891668556, 0.6580024955656192, 0.7238391724672492, 0.4351233708900586, 0.6998928795011908, 0.7802850048982656, 0.42063239625460275, 0.4479970121580168, 0.6635177302375774, 0.06026000781611329, 0.4232965686688269},
    {0.5872891876587178, 0.47700231549472105, 0.7545910821469725, 0.7919472244498617, 0.4846221421576594, 0.37701766555882593, 0.6269925256341703, 0.5839262814492165, 0.2841688199138354, 0.48494021569461404, 0.25867014668550437, 0.8163754592902288, -0.034219762863653136, 0.7501349571485697, 0.685831168586114, 0.6751975463089499, 0.48614853580822887, 0.6681424270677757, 0.7534214765777043, 0.373966945146943, 0.5607378195725088, 0.6986385036693119, 0.4608429542392589, 0.44337259372279525, 0.5931085567279887, 0.7889053124824666, 0.6270233507382603, 0.26394698983759574, 0.7249829066093846, 0.6317880757882037, 0.027632501043811486, 0.7523973706504297},
    {0.7382566611395764, 0.7841374934838858, 0.40128825178692906, 0.40906998889688007, 0.4931694719388387, 0.7509754686218109, 0.5413793600047699, 0.43679900226680735, 0.4215997305437546, 0.5864846599425401, 0.23494435494657412, 0.49969738658528096, -0.13920194577649503, 0.4802324719791586, 0.8560166304496764, 0.5211646944359839, 0.5518320318468162, 0.6402737897478687, 0.31298220735170706, 0.529664943447958, 0.7198026057573318, 0.45359090927020945, 0.3927125764466259, 0.7737172762939672, 0.5054501675696718, 0.8078982503915656, 0.5900630134224749, 0.4867597461223629, 0.5463893171220465, 0.5528797940778816, 0.06996493088077353, 0.3157814953988664},
    {0.36778120218056576, 0.4440861376094582, 0.5281250101393523, 0.41164191231611535, 0.4906909197453598, 0.37897064090073534, 0.5656095708197595, 0.6282844196880794, 0.6753173353941814, 0.8035686613374048, 0.5381429789836603, 0.6646166053797488, -0.22379377953406507, 0.509726055312797, 0.6219665077059453, 0.507859729770837, 0.4696444718424124, 0.4544716596461826, 0.6232365183803613, 0.6201737578093304, 0.3602774434638043, 0.7822220723676295, 0.8545193937114971, 0.5653320111488307, 0.5507758938181663, 0.7708503629049823, 0.8196680076569672, 0.46180373533103736, 0.5856728363558155, 0.6120195314934038, 0.09706439802811269, 0.4461956505740358},
    {0.40636517030773195, 0.4141361039869762, 0.7101886810618876, 0.80040325254629, 0.2511305365562573, 0.34558015749159615, 0.3696290858688026, 0.8034081140802752, 0.5468021363640302, 0.6438629811679843, 0.15605697745547079, 0.3450400345673129, 0.030351932030343323, 0.4345092529474303, 0.46360047113807074, 0.42254439115229003, 0.35206289682547515, 0.4181646913764416, 0.334224424156176, 0.45046623310265604, 0.7540152917386862, 0.8089872841194208, 0.789909620633937, 0.6838231892471984, 0.502702181316094, 0.40860138013518876, 0.4983554164264262, 0.27173978082985895, 0.49167812820877893, 0.41075650423048515, 0.0503854543849314, 0.527391332063436},
    {0.31052510528316696, 0.44590710094931196, 0.5265096191252024, 0.48990708369865305, 0.4381677959041394, 0.6017960668086826, 0.36236541994058175, 0.6707001333888947, 0.5472212535323906, 0.5768562757131475, 0.29072983297139304, 0.8365466708588023, 0.11272240488263077, 0.4296227893754597, 0.8386619007727579, 0.6402778908346998, 0.7035615965089673, 0.5282052200755171, 0.33274124877098715, 0.3883492035130665, 0.504187421542238, 0.5128086704570933, 0.6862059677786759, 0.5302278577697187, 0.5920525204723197, 0.6444199894342776, 0.8746724028008324, 0.5458240847289627, 0.7525732229197952, 0.4877816007389333, 0.10218124418248775, 0.6869515426644998},
    {0.4294893993395996, 0.6187277018025704, 0.3913841822661331, 0.6695876583377349, 0.6936470570390867, 0.6284436880654425, 0.4493577238007597, 0.4432437660813667, 0.4531658971474479, 0.7267781461557232, 0.3838273483297096, 0.37667368231213594, -0.23038797491701882, 0.6127696868941703, 0.5626390498811752, 0.7062946257697166, 0.2962293986400416, 0.6781131230835331, 0.5275337432723602, 0.5897082379156017, 0.8301721753972668, 0.4842419271685417, 0.38235465490198367, 0.5806948585314671, 0.46457278768708604, 0.4996314214398412, 0.4735004466670873, 0.17233812335656573, 0.48848198942910964, 0.49629423499459735, 0.31170836889121256, 0.4965486424322245},
    {0.6337265984539459, 0.7657051963540294, 0.7151203945757231, 0.2900299045565804, 0.3982367042841382, 0.3091264305751186, 0.6164856953975167, 0.5978044958478309, 0.5898593934873244, 0.32128617850282976, 0.23236870226080353, 0.5639846881929674, 0.1636114679725388, 0.3748235448181137, 0.46335626265149576, 0.6132400139345685, 0.2740501217770142, 0.555434051419174, 0.4396017780945182, 0.837143978873672, 0.4165355273077596, 0.6942988427537544, 0.4673300995297624, 0.4674624004438098, 0.4405835415385344, 0.809462128247662, 0.8228739824550396, 0.14962281643539313, 0.6538844446364237, 0.7638258069925814, 0.4356767818661221, 0.7323508071424706},
    {0.464792028442895, 0.6424556761978654, 0.5884313769332574, 0.6512258083168103, 0.6533383482664994, 0.3884991999333579, 0.3421783070453854, 0.7586729887308501, 0.7136148456262202, 0.5689284084103478, 0.2723118589717283, 0.40216184806675864, -0.09153617553407202, 0.43777225478513865, 0.45094216539919396, 0.8151326354663403, 0.7832985798292782, 0.6971495138848208, 0.44620415273175895, 0.5901001835261634, 0.6085349884320229, 0.829333778323041, 0.567428514265128, 0.4071901932692685, 0.4263437959547227, 0.7980739537236218, 0.902770045991431, 0.20056941647344342, 0.4911754697381114, 0.6964931968560896, 0.2597543643553148, 0.45897089323946905},
    {0.6945965303660514, 0.8021832060118068, 0.7668374579076265, 0.3220497662391435, 0.6657099754658702, 0.4004211688507106, 0.6123583757701753, 0.6347008803441155, 0.42155661936092453, 0.662948031627751, 0.3425252926227687, 0.36011868907308214, 0.07700965453781188, 0.3050289640688261, 0.551321567147953, 0.704061774657941, 0.33475490135590014, 0.7695584997754847, 0.3986721805868517, 0.44370303781016845, 0.7408592502166913, 0.40038510863200183, 0.3783791137184555, 0.6446650910166283, 0.6602506029390054, 0.29159255458882355, 0.5471304338008927, 0.2434547864032059, 0.7526840315440393, 0.5171374213932876, 0.14434123464905405, 0.7371209242017873},
    {0.7333707340755848, 0.6055180918886207, 0.38285151791406763, 0.5528492965179432, 0.7113490289762479, 0.6009586930314883, 0.208938332294202, 0.587046653804734, 0.5425217938806428, 0.4414653989698222, 0.24081063532692143, 0.33428099126456473, -0.21514579548002252, 0.42887672841903934, 0.4555986087854744, 0.8195092023796663, 0.5854604192812581, 0.5374877817711212, 0.25983718362791985, 0.3705896814944689, 0.6348660356260212, 0.48412833364172164, 0.4423646767980116, 0.6963569355965457, 0.7281987675512923, 0.6212528315108143, 0.5920691429258539, 0.5168451185947143, 0.5859866150328221, 0.6829259814774137, 0.31908217731046923, 0.272757573022438},
    {0.2803249444118886, 0.5165539497195726, 0.5339058723348815, 0.3284283401324095, 0.5009667212097841, 0.3117899838929816, 0.30257960378510257, 0.7889274049360894, 0.39489497577443855, 0.6179369439427288, 0.4634720170691206, 0.5309628343213251, -0.14677126465890658, 0.6369605532574064, 0.590758355217035, 0.6014964323197727, 0.6551557717104696, 0.7139682004549914, 0.33733286616386127, 0.7638901657388579, 0.8258987763518214, 0.38178625402100613, 0.8654699907826926, 0.47531100216858824, 0.6306593614918687, 0.6088658990274501, 0.6858238818218143, 0.26508850212115065, 0.6088828851780917, 0.4330792631663739, 0.10749229919874588, 0.7077996068032721},
    {0.6797586401025899, 0.3690412480423884, 0.7167261598788631, 0.7028349581054849, 0.2705034849755368, 0.5739895414923362, 0.48332196696108354, 0.6396277956247364, 0.3635775811778444, 0.523688576741448, 0.24793413944185247, 0.492610464610371, 0.12022483979366269, 0.6614025236958884, 0.8203548892131691, 0.40728110930726974, 0.5733821700801005, 0.5819574847740016, 0.5572152864406165, 0.7086289786403592, 0.639271215342329, 0.7280872425682455, 0.5298615145857477, 0.6273466265843188, 0.3942276812226609, 0.657901441319401, 0.5323860033764665, 0.15372759116569407, 0.5761736751444316, 0.8556900850302879, 0.39047433201968074, 0.4148163813291589},
    {0.41702927799969974, 0.7550641702097614, 0.5894699840852564, 0.6258443290760769, 0.5591140545512605, 0.6345417255781466, 0.2434337185443829, 0.5342270646705557, 0.41258450293493165, 0.4441009137595511, 0.0980092876999552, 0.31849519439174023, 0.012735841906016357, 0.3967799402457205, 0.5674696111108538, 0.6613889557741409, 0.5004558360706183, 0.6964809126132926, 0.4342038894184766, 0.5233989237286695, 0.7694942401178745, 0.5436257055274484, 0.7691586164607038, 0.5845675304719247, 0.39837770585792015, 0.5599696604084523, 0.6813539167767372, 0.5522694419858268, 0.6534898526968881, 0.8187693101059422, 0.09339237749119582, 0.6374612740528101},
    {0.24956764110122823, 0.5434381091067585, 0.48089581968327794, 0.7440499391368952, 0.46327609916328866, 0.6361755891651423, 0.1968928261983484, 0.7766535614940577, 0.32113647654839783, 0.6118344713511197, 0.15181432590139898, 0.6670058055687496, 0.051070476963999294, 0.6992383820711691, 0.5042506700341327, 0.5518355392775681, 0.628285130189527, 0.4105458383802858, 0.38825823897406697, 0.518165977570387, 0.38896994076373903, 0.43030310496826013, 0.7356197500186014, 0.7888440763697857, 0.6905398549635211, 0.4275878365502282, 0.7469309250287032, 0.29927094816131394, 0.5114748061323902, 0.7989121023467495, 0.2264879653801404, 0.5227015658292467},
    {0.30114447356999846, 0.3512574042739717, 0.5531117342301187, 0.35876327723917956, 0.35037432967358295, 0.430073781438023, 0.5679677199717738, 0.3812760301374907, 0.7645562823454273, 0.46616549739093865, 0.26417594556947827, 0.3465482423127229, -0.07948548877102352, 0.41811093386284465, 0.658703056676097, 0.8132022650351582, 0.3063437848999716, 0.7275259733097005, 0.2841439469594364, 0.6283837185530263, 0.5196148996059242, 0.42211430393558735, 0.42977266601774855, 0.37307113396206404, 0.3693261653683838, 0.581180752556383, 0.4857268813998376, 0.45070489408476855, 0.5901194341914475, 0.6786289879977108, 0.31062885254232514, 0.27228908806432495},
    {0.6082544909431221, 0.44694038232184446, 0.6801664237146964, 0.775894244798538, 0.25207917767402493, 0.7252662406386555, 0.35875084617099356, 0.6410688127976951, 0.6446384788403902, 0.47343321566354024, 0.14180201806458356, 0.43969852013207367, -0.16489683189647872, 0.4712176825657437, 0.8161246051757778, 0.563361431455749, 0.7260714011366525, 0.47789202387818663, 0.37223955371914674, 0.3935546135245834, 0.7284246194488209, 0.5797967137023381, 0.7168240648101734, 0.5694193270835063, 0.7486950268875243, 0.6687192607400287, 0.4041454841037882, 0.5100780970490832, 0.598465444755283, 0.5994757611988151, 0.43576896777792407, 0.4066049197840367},
    {0.38179146947868087, 0.6728195525876697, 0.5870472835500229, 0.4993501655489078, 0.6712976940346346, 0.8085191878614814, 0.20451674933367192, 0.7491659850576186, 0.4241925864975442, 0.40212340940017616, 0.5563703401756974, 0.4132967085758477, -0.15159664894870295, 0.6895268947946935, 0.5440277619386915, 0.7597462406394789, 0.4847219967725961, 0.3527761096940954, 0.6417106400193682, 0.5979449577826728, 0.4234017299380709, 0.8435567840120356, 0.623408765455971, 0.7029543419460559, 0.6547895573525976, 0.387472117427059, 0.7424471354831378, 0.2590046177093683, 0.5125678229779976, 0.6227144220735518, 0.022683980490897978, 0.6663226953463584},
    {0.3166229967096472, 0.5697567531655916, 0.622702216530312, 0.5237813944263322, 0.42867265238641294, 0.42597546065276753, 0.5782056885566342, 0.5849890079428809, 0.685709484743788, 0.7593360555275565, 0.539806465472853, 0.42540323008263153, -0.22497476496627958, 0.4417917611294416, 0.6691401691014632, 0.606091395015629, 0.764487210261721, 0.33778979709600376, 0.37197979480916965, 0.4872760600909577, 0.7214612395801208, 0.40721613396279177, 0.42277701516046756, 0.5857349445868463, 0.5698039369621442, 0.5013947688235956, 0.5225298815709902, 0.4126662605464101, 0.40577733073840094, 0.586500600575014, 0.2773975391273318, 0.5658660117794743},
    {0.4197575789994072, 0.792795902731007, 0.6304895850315898, 0.48481190071954466, 0.6948005362930605, 0.4820852721265334, 0.5621799514214916, 0.7877189020142914, 0.4251620813072985, 0.5695330248817531, 0.2065098906899361, 0.7261323924140511, -0.1923236989419353, 0.6906533146730387, 0.7294530442169986, 0.5981527441835001, 0.4395220400809513, 0.41926636465089007, 0.7686336118706524, 0.46977513511908664, 0.39442542754993287, 0.4197379417785755, 0.4479376604863265, 0.8518103417576053, 0.5273413531346431, 0.45996878796523144, 0.6804928073792618, 0.6048844160965258, 0.6258825240043937, 0.584883118714662, 0.4508416153954191, 0.38546798837429963},
    {0.4460748349945752, 0.3957673953474289, 0.8680913901964478, 0.7017433063123962, 0.3648781571117654, 0.3494125194598182, 0.5714018737902476, 0.8268089809417825, 0.546675312656563, 0.5939987033240406, 0.3058433697501492, 0.6148003318586847, 0.19759774076031222, 0.39133234128970534, 0.6697173058244604, 0.5101444613543106, 0.6486919263262534, 0.8044241830468662, 0.6224025991062473, 0.7378505802630025, 0.7082619631575446, 0.860122574541297, 0.7097919439627334, 0.6076983437194473, 0.5781759460426894, 0.7586098329941005, 0.3882184544288996, 0.2867396178705151, 0.402571616723307, 0.5882863996476209, 0.14109095636066554, 0.7614603829580586},
    {0.6776427697453284, 0.39499036976607177, 0.6096032470681827, 0.7436668626560963, 0.33692262525575245, 0.3507531989210537, 0.5917592258344611, 0.494380552376318, 0.3868609312612139, 0.5491085947787729, 0.4894906963831571, 0.7996628594837157, 0.15358360198359802, 0.45513246711164973, 0.6558891427471, 0.4392814451461988, 0.6869738717398586, 0.44522687679858525, 0.43815105937192106, 0.7884343212324374, 0.7544952497138498, 0.615449378261406, 0.8074156265590874, 0.8327395392002924, 0.7806328418773085, 0.3726149457240048, 0.4331413224455814, 0.2732220545891447, 0.7455968903750562, 0.4946651546434513, 0.08461198323631727, 0.6678001683323764},
    {0.4577897465596369, 0.43927474424067287, 0.7150791718862602, 0.7982137425873779, 0.6448843257557728, 0.62811088783874, 0.6829632913879636, 0.6740283818925052, 0.3706304834934072, 0.626834646310217, 0.5820972513100332, 0.6682413362544086, -0.08739964690884396, 0.6529327867637932, 0.7758963588727852, 0.8320798063974717, 0.4576631927176982, 0.6838284680328867, 0.5457014605243444, 0.4890482349141335, 0.7718515099225781, 0.8046531729461454, 0.8519840595307862, 0.49027497878943926, 0.5382344166713537, 0.4009436743697753, 0.8363471594399204, 0.20946763571571844, 0.7428526123518264, 0.4811612648119304, 0.330543614407494, 0.4188684609499983},
    {0.39323404532973594, 0.6501444766383232, 0.7037891787499818, 0.787897867682278, 0.29433002539391095, 0.7266809394665023, 0.5012029813387596, 0.7549973965076542, 0.28458939364815666, 0.36413414744363704, 0.22978521494093992, 0.693908814525453, -0.11049898302386253, 0.41955240476504774, 0.5544913132596146, 0.5858722461108994, 0.5821725307848904, 0.443954030266757, 0.7179553269973868, 0.8630053653363722, 0.4989179279971456, 0.47098091440623174, 0.7680486143743711, 0.7186546088323211, 0.35356148977821306, 0.4490938754646109, 0.5965576531259137, 0.2927794911392312, 0.440958918139551, 0.4431779455467283, 0.4080152924835492, 0.5590521803633647},
    {0.5895840116489777, 0.4691059778448107, 0.6713620600409673, 0.572559161300094, 0.6037876750150706, 0.5309750092535311, 0.4523488707392857, 0.457095343867363, 0.6458123036917317, 0.8164054456755615, 0.4498161296437389, 0.4411860529755906, -0.18452413543282326, 0.7097182115689705, 0.678976589395404, 0.4614941090110809, 0.4529436392149622, 0.8215727217598792, 0.7414533601639739, 0.793097964586486, 0.44109085605494264, 0.5021082473938421, 0.4265671360388527, 0.6800616089483991, 0.6107575430034955, 0.6882109233202288, 0.6761714415692346, 0.14700952917010882, 0.6175097680721874, 0.77717109777772, 0.28213062924006643, 0.6055528462130245},
    {0.47893333128985566, 0.595638848378353, 0.39612357037798185, 0.4852815088782206, 0.5638089914981813, 0.6960244583040931, 0.2803426159265073, 0.7620477793563522, 0.6271477526685632, 0.7748108034526805, 0.25334638336893944, 0.5985392425265796, 0.10939771270452463, 0.5730714832538369, 0.4489865069963463, 0.6165422890655171, 0.5655500601066454, 0.7477408110311525, 0.3811585826237988, 0.5780344012843769, 0.42645395381976997, 0.6583617444197121, 0.8375226061469593, 0.7419442122732574, 0.49564058703796626, 0.6292939086820105, 0.652837598430196, 0.17453430079601895, 0.8652731485376003, 0.663240925782396, 0.3299621421604763, 0.37367130019858547},
    {0.41062122023364955, 0.41552828848424567, 0.3825780491427801, 0.5285256536529915, 0.6105354799488428, 0.3983872099966608, 0.3798845965076179, 0.42908649325976117, 0.42585980070453494, 0.7604497986519576, 0.11510025520215034, 0.48794726827695084, -0.18939560025707428, 0.4943202740051363, 0.450477917064077, 0.5060571321731733, 0.5505972921411701, 0.7122530231796943, 0.419473487879265, 0.564003144547593, 0.6705700508403365, 0.3817969881704337, 0.40978811829368356, 0.5223753559173726, 0.31423181859399474, 0.604609007474949, 0.7071279589140081, 0.24284181993551496, 0.569352479809815, 0.3626366632970918, 0.0346131735442995, 0.551031410193003},
    {0.25892132644874793, 0.3951801887339838, 0.6120404809471287, 0.6516931742400249, 0.5674944516041434, 0.5727469527154223, 0.5031243066971309, 0.7506236394790757, 0.2878106167988697, 0.47284208232877317, 0.3807153581822972, 0.8463407304528514, 0.12610915194376526, 0.5836604254107639, 0.4461421340740667, 0.5358437546289262, 0.5866401469832027, 0.7848973310136848, 0.3478517556674511, 0.8236672425309932, 0.8079405271026184, 0.7162824724834834, 0.7557912108664147, 0.8359721400083727, 0.5949917180664941, 0.5380323996301283, 0.6403898033577996, 0.33045537073511905, 0.6016500506912689, 0.7195769535563609, -0.0072339887616524184, 0.45670196561537574},
    {0.7373705554530111, 0.3810349163626019, 0.7535345604856369, 0.6901292665966877, 0.5837787316218382, 0.6276081470875295, 0.5150024349976118, 0.8344975560936992, 0.5208871056026004, 0.6407506583580812, 0.30019311193800535, 0.40866192204095875, 0.14925657573329526, 0.6952315217915525, 0.4883995157595048, 0.47695235497922467, 0.5905581203826582, 0.7968139651534935, 0.5061963754023091, 0.47571063862760155, 0.7037315746698061, 0.8541705652701814, 0.6977709747512564, 0.580404382702694, 0.5699815006717459, 0.36399487483198445, 0.8085461993101462, 0.5302627541787132, 0.6941367920380389, 0.4392859584500895, 0.02993079352293583, 0.3534198049174453},
    {0.7514933473610624, 0.6844823871620114, 0.8053537581553524, 0.6330978344272984, 0.7369672022300896, 0.3930770867041054, 0.27967759462898584, 0.45774558865774573, 0.4748669539794524, 0.815328798922057, 0.34748334875220216, 0.42853840590158626, 0.06323700515439179, 0.7220515987309929, 0.7870561547829632, 0.6641916830095461, 0.3407093304769671, 0.6203378962591065, 0.31037512355064045, 0.7899907591652816, 0.5067798570085056, 0.6724246972937193, 0.5322659068836222, 0.655077536854659, 0.605279543324772, 0.3637650773159995, 0.4847743574503066, 0.13214011584132435, 0.5464943947290947, 0.8742800679586875, 0.10799770872340174, 0.48701105050111565},
    {0.2828781690944493, 0.5565224655913688, 0.6496849947141756, 0.5870533369907078, 0.6314054540068482, 0.328119633134874, 0.3612906692079293, 0.49523467413933114, 0.6311006016968289, 0.6772937620222105, 0.4107195316911861, 0.7522301745319379, -0.010638746814849607, 0.8012599590839137, 0.4578290584742273, 0.7029453134090892, 0.8063028562661052, 0.41947436349775247, 0.4524329568186074, 0.5652632111546826, 0.6153366913928275, 0.5988942306035644, 0.5923133227707869, 0.4930524920680227, 0.7743251278008932, 0.692139199048475, 0.8347733160076563, 0.5792230318372447, 0.8376808522253675, 0.6712382553891705, 0.13341114424440847, 0.631496186623525},
    {0.6839763526056349, 0.7513175691179675, 0.4899241565116218, 0.5135809480223932, 0.2854670164157003, 0.6399356469781994, 0.3273995358202509, 0.8771854298663946, 0.32981849930199225, 0.6706659576123671, 0.5071047966452551, 0.49368116053363875, -0.23919135138255007, 0.5994368743861048, 0.43745331288224615, 0.47862658552016357, 0.4378944893337632, 0.3750302620117498, 0.27082774212443894, 0.6978751705343801, 0.7868697535293017, 0.8205548621835635, 0.511311916203257, 0.4888335707976043, 0.720971667960894, 0.671524932482611, 0.5778628043532451, 0.4666025312004808, 0.617299120072597, 0.8445525238030254, 0.3041647426324341, 0.5155776099929515},
    {0.26898251263288225, 0.8061160659763629, 0.48994383766855465, 0.7513440087140295, 0.5220556559609345, 0.6953019585301349, 0.603662734954293, 0.5097705047976243, 0.31535795574430425, 0.7282689660228697, 0.19903919602614972, 0.7576317871614895, 0.055193603787428075, 0.7573572517082764, 0.8262507583865739, 0.44623764876353933, 0.7004958639518245, 0.35058407021521115, 0.29343685267482117, 0.525512177453041, 0.4336405268499902, 0.6937207115456352, 0.8454098557560559, 0.47084799851577436, 0.3711199442155538, 0.2865427122985728, 0.8361734694025628, 0.5150535741530193, 0.5225611193549682, 0.46307207553629487, 0.2586134719719808, 0.5441211672000122},
    {0.6321771870546241, 0.32425511625373665, 0.6354651954154122, 0.46364641888343916, 0.3873013790017529, 0.3006078202585964, 0.6274334690307354, 0.5424321141861015, 0.3975087349348928, 0.7100143757431352, 0.5330939719608391, 0.44380570052110285, 0.05451094968691135, 0.41961986824650976, 0.8211749407989348, 0.8077341479132991, 0.37441465488737247, 0.7937395066106367, 0.6263191285173754, 0.4702922421185351, 0.5519866966341453, 0.4759992092193293, 0.4478170546765716, 0.43974702970909185, 0.5682197339031322, 0.5392227291960111, 0.7676874320921359, 0.4225126056846415, 0.4345716572772375, 0.5600686378738519, 0.06885870021417756, 0.7470794616974653},
    {0.7805551525123425, 0.48374654980536275, 0.5978010517687486, 0.4083143968102094, 0.48778320820706866, 0.4189870275943517, 0.4630087379677324, 0.8392913794816346, 0.4975696235612192, 0.633516715691497, 0.298271290428765, 0.6941806404638078, -0.05262931085475501, 0.33367237747940187, 0.7625063393529878, 0.6296170850956696, 0.7349261188925541, 0.7333325014437434, 0.5095661120604692, 0.7040545094950872, 0.7789013786715858, 0.8364694708102635, 0.5563815515885042, 0.7150133202879592, 0.774900279340452, 0.5889211323942073, 0.6120795568945714, 0.28854483273095455, 0.8401623542346821, 0.5974153137211529, 0.08153425717865115, 0.648909836354683},
    {0.3044691966111127, 0.7107835596185011, 0.6581124894073939, 0.42468145035782434, 0.5978710419362897, 0.6444792443770512, 0.41853237239917535, 0.5472627220794773, 0.6092405891198949, 0.7345640594800855, 0.5251134701626778, 0.5180574385115347, -0.13490673071798806, 0.4365214129736719, 0.5253547701014745, 0.44451273546355435, 0.5418841049987575, 0.6447175744909277, 0.6820745764911784, 0.5374760035167981, 0.5004249839058212, 0.6026636702332065, 0.5004630164394837, 0.4237454630524012, 0.4103229697092834, 0.3319359833440586, 0.637916178000622, 0.5524711341157833, 0.4377207546610624, 0.8368881149736626, 0.36557309510098757, 0.2801337379346627},
    {0.26206440408589593, 0.4423335691203436, 0.5807276783880534, 0.6432603979898539, 0.5968254998496504, 0.738277788079795, 0.20438226848956723, 0.7458898371769033, 0.6274826149478153, 0.734153367916702, 0.2637465209446862, 0.7015776222629458, -0.09292390520678587, 0.744740226080271, 0.7358930470997845, 0.7806642370988064, 0.4461872863269376, 0.7037216467238352, 0.5619358684191826, 0.5095137425945102, 0.4669592007881466, 0.6115288661233055, 0.5117301581798569, 0.6774120446530454, 0.7692964075941761, 0.3896729904129936, 0.44540547407425096, 0.1049220858862989, 0.659284897714504, 0.5868969328047187, 0.15064009959152075, 0.3822345791016152},
    {0.391908100038445, 0.4956589932378888, 0.5774442278111241, 0.4689383699558937, 0.42835490165528023, 0.24961546174585808, 0.3094940688156425, 0.41057570738283805, 0.6167174556329492, 0.698740647343076, 0.19023926019825485, 0.422403904381109, 0.154440738414454, 0.3659219029123444, 0.45912891267573713, 0.4579735534316321, 0.5193429947254974, 0.6838146010633295, 0.45556327415496617, 0.6443638640546078, 0.726416178261155, 0.4766936613647056, 0.5261106644307826, 0.5346665525998969, 0.3585643134889286, 0.5406617873160044, 0.765127932236513, 0.31010909680705895, 0.5822713010004046, 0.4348508800021778, 0.09811477333569442, 0.5486720637902943},
    {0.4507120062603743, 0.646640099495666, 0.4429183537232095, 0.6519109694906756, 0.270835332820708, 0.5705242767672163, 0.45336802294316814, 0.5269951718475258, 0.3349806092034218, 0.276793811919689, 0.21613740245410543, 0.7384297336448575, -0.08612710929714522, 0.591789318437999, 0.8259071519470154, 0.4544846405515213, 0.3221517420842806, 0.5116328328823849, 0.6107436966401127, 0.7412020235970268, 0.5733161240788759, 0.5265666535851057, 0.54141199437669, 0.41064180984183607, 0.4405747589417666, 0.6280256335091553, 0.4635634796479561, 0.4113455128402838, 0.42335283951016467, 0.3735388059532267, 0.17639920726271135, 0.655726582709281},
    {0.3169160145491335, 0.43774179219373016, 0.6494866929306675, 0.6376192799510525, 0.695803200454138, 0.5896175764878916, 0.26377744104378326, 0.4265936954656872, 0.37297851769306783, 0.43759339036810385, 0.4256174795528041, 0.31575406626573993, -0.07629864011790238, 0.5881690750643432, 0.8291603685138834, 0.8251046557521216, 0.5002198272493968, 0.5112103958139452, 0.2406871434591308, 0.5851538367031216, 0.7181469876148926, 0.6859055421938326, 0.8773574749902396, 0.7737769196745012, 0.39888021070054713, 0.3211909161489629, 0.44738892158440685, 0.5464291405900318, 0.8571636791693159, 0.5563016219006064, 0.18117588835586787, 0.34960428266193205},
    {0.49431503031188706, 0.5198463252944447, 0.6916026085990847, 0.3220650010113955, 0.5952953384288454, 0.7468508423258386, 0.5209934889766982, 0.8079303130469396, 0.6596139588803642, 0.655963788402046, 0.34506270749637663, 0.39888783605550593, 0.09642610869528245, 0.6967567108294405, 0.8185385432538094, 0.787436539110459, 0.6452156239961438, 0.7242119555058677, 0.28647013426804746, 0.36777529201540243, 0.5247902169318673, 0.7421993323659806, 0.6616979873259835, 0.5199378800768699, 0.6002071767065054, 0.497742005033747, 0.5973285069905496, 0.45389502428542555, 0.7799007331553264, 0.5142766371818276, -0.0512494089672167, 0.5955045619412619},
    {0.6456673434936621, 0.7736691138434533, 0.48101837804126785, 0.756950046162128, 0.5783168244119173, 0.30000786880656777, 0.5327903399759675, 0.8527035448542405, 0.5951217801823004, 0.4842648334949443, 0.3789663964525973, 0.6409130555184662, -0.1826479328865089, 0.6564678472729596, 0.8621091088860244, 0.6146173422416352, 0.7773410093786565, 0.43268187801311314, 0.4492369075626287, 0.7640951683095711, 0.46611185082376416, 0.5575706430082917, 0.6259931537479384, 0.7251742057074723, 0.7047719221113203, 0.37237185373429976, 0.5679427187385812, 0.3384450634341122, 0.794576026756871, 0.5910641803663299, -0.05987642074875266, 0.6341448188311878},
    {0.3054164693300161, 0.4429410587530934, 0.6566586545590107, 0.3584816984433126, 0.624119358535487, 0.5182160960557721, 0.34073949395281355, 0.3858456317775313, 0.4706752981696298, 0.4141650757038079, 0.34486539044248166, 0.6845793126914091, -0.10251895647438136, 0.5249918281494409, 0.6721447764352261, 0.5458965208094767, 0.7975472460204155, 0.34229018209074474, 0.5706358506831374, 0.37740973257588395, 0.8379135549919686, 0.44208647625806563, 0.8567430442316303, 0.8582701728948025, 0.5527426468107842, 0.3342866433063578, 0.504880573043229, 0.2242823184097208, 0.6977797740790448, 0.527391157468566, 0.2967877797567556, 0.7452403491448067},
    {0.5715242362977497, 0.5901905138830604, 0.8354980923504279, 0.3735704018844078, 0.5323802688244765, 0.6455350329229871, 0.3931143594320105, 0.5002368925328184, 0.4620287985297038, 0.45911102655631764, 0.47628990465489374, 0.7994489883515113, -0.11650990989302905, 0.6217534433639643, 0.6376855812753277, 0.4503556913075731, 0.5847396891348753, 0.35616878603203983, 0.36856659005902964, 0.6860707446986594, 0.597690040644272, 0.7239173064886161, 0.5538201673798578, 0.7197343345700417, 0.3956833531282509, 0.5080213036983693, 0.4147087280388766, 0.3242743821356492, 0.6104279805375511, 0.5479206662170966, 0.39816842419990706, 0.5455957557278628},
    {0.2654783612886693, 0.49387233919633955, 0.8272431746788732, 0.34130527941289807, 0.48132132599624516, 0.4718925053798128, 0.5355087947968458, 0.8626476867089542, 0.28183846305111343, 0.7697158597683046, 0.4326519092512972, 0.37438051701478275, -0.08646944690825084, 0.4033083903579372, 0.7006384903657942, 0.4447686724009957, 0.5651027238371135, 0.4852273424631542, 0.30971513151765684, 0.6354294273068926, 0.7363485552286106, 0.8591675424745425, 0.5192491176529676, 0.8062011042132529, 0.5172167997726438, 0.39516043241256704, 0.5141247721319347, 0.36905329503892326, 0.7921150941997567, 0.38986816401195534, -0.04188444432732716, 0.39697108618409155},
    {0.3243443908646948, 0.5874193519431798, 0.5769478553433814, 0.35636095857532135, 0.5072954636739054, 0.48508465706798604, 0.5606101092380048, 0.447708846183749, 0.585807606134317, 0.5610347565765628, 0.45703713245863364, 0.6091928780580785, -0.19235611933416671, 0.5335190326274636, 0.46048079796100455, 0.3093253337077748, 0.4459265529190324, 0.5002343303096435, 0.5723805203989785, 0.3959677991001906, 0.5039145784366379, 0.5004882092740071, 0.6230506512339884, 0.5397319124849161, 0.6002170413519728, 0.5830129804023515, 0.4512168122128272, 0.4513084198288175, 0.4874552706297891, 0.5829219187323295, 0.4041363961041691, 0.6998173107789407},
    {0.4314766328155926, 0.684031180913293, 0.5795017083307155, 0.41537146353136106, 0.48815509621354747, 0.5501262799422977, 0.275211449541984, 0.47323725491188984, 0.269006130300134, 0.7833298377176071, 0.4446521634692219, 0.5178164308098641, -0.20469713215667446, 0.46929207036112747, 0.4580035293003759, 0.5947652875275531, 0.6223802443981865, 0.4423718669872784, 0.5137894939711423, 0.7300815881456272, 0.431101739559992, 0.4823991574712591, 0.6236776030294293, 0.8412116744734921, 0.711311372014663, 0.5841453963562669, 0.5376616141340805, 0.5303921523190399, 0.5390689253964254, 0.43095173684112703, 0.05818901093387057, 0.7615625795497116},
    {0.2728481181913205, 0.3607877576895669, 0.5996073512406572, 0.41158436380586055, 0.40042766956119036, 0.4093162905382534, 0.4280996206091052, 0.7482664956318397, 0.3007766754367737, 0.5921963497061246, 0.49458693872611237, 0.5764707220265114, -0.03823269601070409, 0.74946941008488, 0.8092496260163545, 0.5552794390896548, 0.39141006393145333, 0.3940057197020647, 0.3811269737441548, 0.4783757306995264, 0.49992377332399063, 0.41641619478590336, 0.44242686720953767, 0.3301552703186786, 0.5073464469429189, 0.70947432237221, 0.434139307057404, 0.5704873879780832, 0.5078316947279201, 0.4175012315686122, -0.013876149136478779, 0.6960571907175},
    {0.47287793502665637, 0.4057519917380299, 0.8628353771987126, 0.4981019696949025, 0.584494721321329, 0.30491286710151344, 0.18419937714015808, 0.7489574483442858, 0.7187079969368203, 0.46364243172976066, 0.4884784391796978, 0.6465783818420171, -0.28244783329140116, 0.3318872554325025, 0.5331441165497882, 0.4041731316426133, 0.6502419898658988, 0.4309553985870875, 0.28417078843623605, 0.5147041991404007, 0.8042512517268847, 0.7996133176361647, 0.376485051262566, 0.5266447022621392, 0.7409211022369787, 0.7396222925476691, 0.374832732454465, 0.442918336384891, 0.8247370558597567, 0.5627614166831009, 0.08855871034466677, 0.5421655166123989},
    {0.5297768256475245, 0.3487111855617181, 0.4949069251581189, 0.6734020638307708, 0.5287973074092984, 0.659277452472076, 0.5223814384293385, 0.702094678945977, 0.4099928285804705, 0.41971958874948495, 0.26037948857310755, 0.713511973843219, -0.2466886731976903, 0.4402126288201302, 0.4934196172041533, 0.6165045056385788, 0.49576609164082514, 0.7384222303800877, 0.341416821226778, 0.7815297804501322, 0.5891617872963526, 0.4270350545225914, 0.5776060476626972, 0.7191284417999931, 0.6379236726068003, 0.5671146988004709, 0.45009051012620144, 0.31133941731577386, 0.5495927208888317, 0.8020355029405026, 0.360808591202022, 0.5844604058014564},
    {0.42490865413091167, 0.5024323366819042, 0.5017154535601146, 0.6538035963385987, 0.746510300612842, 0.36849378998445803, 0.3026769801686276, 0.5503527086281306, 0.38430027293336544, 0.6968111066959439, 0.27986086968690504, 0.8274820063256189, -0.03440155331993984, 0.6969023792324325, 0.48401873206360496, 0.4974675657742647, 0.5308195584535065, 0.7568627543430593, 0.7562293234143341, 0.4612642700546623, 0.49670430445382585, 0.8497219724589176, 0.7583722727748411, 0.4134889714651756, 0.49920803444626677, 0.7414008224554253, 0.720372714726895, 0.2571721968018679, 0.6824516780223974, 0.853528353938275, 0.4524353930439134, 0.6699983459617973},
    {0.44252420493896133, 0.8009915879382475, 0.7242342661137788, 0.7717137925407875, 0.41533170594062924, 0.6111418589090686, 0.40729829041717835, 0.5716949405612965, 0.5446339788969145, 0.6829600568607688, 0.44462180932881396, 0.3609099279730225, 0.03911384463439424, 0.7434341673000296, 0.7108175796839499, 0.7671355063327358, 0.43566076992664243, 0.7453644134695461, 0.46290387868899224, 0.7895855017233229, 0.6639133379702371, 0.7175832647364846, 0.8647224936938969, 0.36165169565626143, 0.5952615678816402, 0.3123108352098124, 0.5643508395418533, 0.4534064871064072, 0.6460439731040338, 0.8078962429255274, -0.06152677958236922, 0.2932131322167301}
};

static const float b2[32] = {0.5184100120034447, 0.5451620263539741, 0.5742376065087794, 0.5298095783354858, 0.5026789872478443, 0.5473022489210924, 0.43239242791477667, 0.6092383686169515, 0.5340125778023068, 0.5301542752250343, 0.3667480074898499, 0.54917166030313, -0.024357608813284085, 0.5238110849661339, 0.579760636141715, 0.5814107746818936, 0.5193093054519236, 0.5233519962696683, 0.5102580939692349, 0.5663764387160323, 0.6112583975050088, 0.5960707222846914, 0.6066698752563908, 0.5735181803031948, 0.5972456597658452, 0.5210164048498231, 0.61422028026247, 0.37720844978164436, 0.6185671345740024, 0.5887559848029629, 0.19990981857829304, 0.48655301435746307};

static const float w3[32][16] = {
    {0.013866477188107107, 0.6437084629275539, 0.5916008828522065, 0.27420332844132816, 0.5409856067266455, 0.25170077615108366, 0.3162437260903369, 0.5058367257861082, 0.8089488769072256, 0.0397974924525116, 0.8578248037354091, 0.7321420749604073, -0.010675863004940658, 0.8409106617002715, 0.7540941269266631, 0.5248357579479647},
    {-0.14808094358089546, 0.5937924677517209, 0.6888172960998636, 0.7655433520596686, 0.4697391580664103, 0.4790032826597571, 0.9537425826843479, 0.33263774875765073, 0.8156204717604595, 0.3131485861308134, 0.8845672021008308, 0.5910803305279495, -0.2556965950544036, 0.7742603204540599, 0.260372527806702, 0.9327180234793133},
    {-0.334432101319698, 0.8965885954631378, 0.9193944611744493, 0.42973809593369994, 0.022450720007349073, 0.2857802853791542, 0.9637318344024685, 0.7043693977606758, 0.8339887692251845, -0.07045237731315808, 0.621827370236218, 0.34635196999104306, -0.3574858304994235, 0.643970908239341, 0.3762832056045968, 0.9153565384531451},
    {0.19471751499687562, 0.6610303588723242, 0.37886252669468884, 0.7304507120848691, 0.4817659334112718, 0.2640782670533838, 1.0010153922246565, 0.32584322042661557, 0.717109685810391, -0.1420914941825356, 0.45275098890289317, 0.639998712028879, 0.020979064078568543, 0.9586467835177687, 0.28364887860134647, 0.5457980252053365},
    {0.2889856616243108, 0.7184496973244071, 0.5088277131350257, 0.4695348584879447, 0.25741842288094613, 0.663246244455242, 0.471612036485876, 0.5866534533463281, 0.8148174672047361, 0.14751037966659747, 0.726671471847004, 0.42360586088170493, -0.18279252923650205, 0.7278758240281034, 0.7392038520925669, 0.6750369271556347},
    {-0.11303353471673068, 0.5971086481837315, 0.38925301181662764, 0.4877822024030779, 0.3237625135573131, 0.4666508624508954, 0.4558969977318137, 0.9512322404257136, 0.5134614224127086, 0.03448721068046975, 0.9639478140019458, 0.9079230516130077, -0.31879756799029224, 0.29832767704139135, 0.3844939393706936, 0.3851979192662902},
    {-0.37423125850382355, 0.5679190310014237, 0.30503185156217794, 0.3068693916801585, 0.15368191722580998, 0.7852347490650722, 0.5416226433514296, 0.38088017525022927, 0.5971618376350469, 0.21781089974351503, 0.42936745859881176, 0.69753492987082, 0.0910231683474025, 0.2527675003162311, 0.7257043699597983, 0.7608730490664978},
    {0.2290423940474258, 0.8773976783875113, 1.0227241994906568, 0.5280982366187404, 0.006101177695012327, 0.46932672621751065, 0.7939704991306659, 0.5424345475595996, 0.5358050228684506, 0.002938149741394795, 0.48514550919782967, 0.40153767503926147, 0.10562607908716394, 0.8200438968143335, 0.6592712893106342, 0.3784418609416925},
    {0.1963621322447113, 0.3280807631407054, 0.8192914155751869, 0.8412091953511155, 0.09654653449489838, 0.4276411105563799, 0.4459345103815446, 0.4400079374013022, 0.831049958926594, -0.30559362154328257, 0.7101853245446822, 0.603174643039507, -0.04326936839266908, 0.8687009357482904, 0.3958681975976687, 0.8653436791557314},
    {0.295705337237726, 0.8369963399135829, 0.3455035025333603, 0.9205877361689534, 0.40617933706376996, 0.4605280024998289, 0.6201278523229908, 0.48325750774692144, 0.5797098257038605, -0.10642779095837952, 1.0006197562056964, 0.8548112703463544, -0.21795021672023684, 0.7949541320748221, 0.8123668678117708, 0.9114571277928422},
    {0.12787816336613422, 0.6656276794649884, 0.34607428649609506, 0.43282414798270163, 0.40977595682463186, 0.30465605531845924, 0.3120319512728851, 0.7984264511546336, 0.18419045595709657, 0.28005844460689466, 0.7107414418667558, 0.31874194719093324, 0.04050426164124695, 0.38382434687106753, 0.27380055179266055, 0.4990926135293973},
    {0.04990503154539842, 0.7353612744931106, 0.5970844329435506, 0.7858490729008679, 0.49558312117451786, 0.48520665464796825, 0.6336080107560398, 0.8621232308884181, 0.27671522454539416, -0.08717753662945722, 0.39845938898277705, 0.9422517061339465, -0.17860365154465252, 0.4469620455871721, 0.8204020858301816, 0.6388872074710208},
    {0.2828955914686605, 0.22181223482983375, -0.12762130791764736, -0.062252752675439935, 0.17867433569812485, 0.24524216901886492, -0.24017613914289054, 0.07934003307024894, 0.08530969120854964, -0.2987193059350512, -0.17947670738340785, 0.2931361551637966, 0.3111274873902024, -0.2478395248658232, -0.1126038194525846, -0.2696528731417575},
    {0.061230690578714275, 0.7075850358286498, 0.6711781396490414, 0.7999413337987704, 0.6139219091026644, 0.553529622847651, 0.6092044895187372, 0.5766769140521677, 0.8731535864861323, 0.1840234201893219, 0.847683902306458, 0.6128825962857507, 0.2914941672795355, 0.7628888936034769, 0.8566768975951771, 0.555898907343793},
    {-0.11278456327239095, 0.8986251612055381, 0.6940131356018638, 0.41664856019569774, 0.2465890588189671, 0.8855341143002693, 0.3795204995014815, 0.8101681787538447, 0.9367566421872018, -0.0925929200867448, 0.9112996629808917, 0.8179156071889994, 0.06893156189677152, 0.7391899566576204, 0.6102621566638047, 0.2796931508665618},
    {-0.3629580849247077, 0.4418020922107235, 0.7087629060723039, 0.48988036337068447, 0.5129629582677002, 0.756761180556953, 0.8272648511017592, 0.8156987283985476, 0.6663270960041663, 0.12307747481293664, 0.9433445136670922, 0.5906343256802145, 0.12959489200118549, 0.73691613021724, 0.2787365236161416, 0.6491454677727244},
    {-0.15556245151432757, 0.560080652507473, 0.5848980251650263, 0.8985229365286053, 0.5713941221283143, 0.8225724432407697, 0.8143953946648704, 0.45195582923448685, 0.6528662406450642, 0.27807682251743526, 0.5401833448501361, 0.7520026599919942, -0.28285436555973537, 0.42708887159956344, 0.71606736178584, 0.7992342375799949},
    {0.10832279631551062, 0.9003983174059494, 0.6521213785023261, 0.6925730701865718, 0.597242548299426, 0.5528186656176193, 0.5637252882514812, 0.7251368031063674, 0.7020659301645307, 0.013012991811921662, 0.8445649335316839, 0.9431972013566085, -0.019077609987471843, 0.6649037668789906, 0.30338041138990396, 0.3848045668355631},
    {-0.09200981983116753, 0.7355158328882742, 0.6321102657892858, 0.7412256077645518, 0.5665331230253756, 0.29708416582471564, 0.8603318285130483, 0.44066588392405026, 0.28042611002737805, 0.18887538087824268, 0.5868326823313516, 0.6391858240637179, -0.1049064622280354, 0.3353414561921425, 0.33260712288799926, 0.2937336029897044},
    {0.07988489315188921, 0.7920248958839062, 0.7615801685295054, 0.647132861065592, 0.031704912266954474, 0.8188449662441543, 0.3819716326242885, 0.422425549332136, 0.44384861630830225, -0.3485268490877895, 0.6520448156787652, 0.7837830818151172, -0.028954418306708665, 0.8368873998384616, 0.8729610534041056, 0.8433765842189772},
    {0.15117540027809812, 0.785663450595429, 0.9245290644093863, 0.850604201612228, 0.25622423335797795, 0.6083124210295716, 0.4669064335078236, 0.2962331109281953, 0.6756638609430003, -0.31513611365068017, 0.9782098752470578, 0.5798002032136597, 0.11048434304708298, 0.8375045721953877, 0.46109563703851725, 0.907677667401108},
    {-0.36296293485114545, 0.3765324718354729, 1.0174950067157087, 0.9163732668135074, -0.008579780784395374, 0.8579335995538505, 0.7564214427365101, 0.5292318420905717, 0.8959663550583842, 0.003031026499262311, 0.5044729538771542, 0.764044927114217, -0.2993734827558965, 0.5173638450876333, 0.3961752225200242, 0.6645575920269419},
    {-0.22013888689858382, 0.8445657072033497, 0.8467407282532456, 0.6716380163512083, 0.3768464353030104, 0.32836826991015344, 0.6023081854639056, 0.5465561979479493, 0.5553572995952638, -0.3519520957164704, 0.9728538739569683, 0.6247507490290429, -0.23021025804799855, 0.3676144126761664, 0.2796840744537819, 0.4360222662537243},
    {-0.11226162589456935, 1.0192390811766532, 0.6167736709454958, 0.6364790379562185, 0.33228391332783436, 0.8267400559261988, 0.5109143908380854, 0.8256778577057786, 0.881334763823497, -0.09060913126374423, 0.7459957995009727, 0.6864896964084071, 0.17374248055906522, 0.33295869558797125, 0.3431667921264723, 0.42031222654159567},
    {0.28387888819075996, 0.45695733493728713, 0.3360150821802436, 0.6406839593895889, 0.11668480418081703, 0.6102554676142855, 0.886830049995538, 0.6844541336573771, 0.41166691622494095, -0.18849724613248414, 0.8995586081971512, 0.679037976391722, 0.038651316925436115, 0.7809653322313377, 0.6970984321839154, 0.459570365880969},
    {-0.019231453221680614, 0.432618352218678, 0.8897683363193967, 0.7428516989385695, 0.1635941588627508, 0.3846099925523619, 0.5904492445261595, 0.5592060265577081, 0.36991266934290695, 0.25782729961061696, 0.5304639852899407, 0.9542119632738814, -0.3370375759560649, 0.26186592656039154, 0.9029461528966407, 0.28615620669109654},
    {-0.16782825307764726, 0.47201767501801406, 0.9685113847174303, 0.24868253837169163, 0.03622901677952887, 0.44753304245054215, 0.5950603165485217, 0.5427960116559741, 0.8979018761644728, -0.2637413283314569, 0.8193328162431988, 0.617159938652117, 0.06372944629812051, 0.7448111093130162, 0.3801169827239993, 0.4928692692572216},
    {0.3084308876637793, 0.21648221167396953, 0.23971512558651062, 0.16263571880556024, 0.5101649403220351, 0.7109292579909867, 0.7454602406977625, 0.699991419211726, 0.4277200655156014, 0.32398870160498017, 0.2924174117684324, 0.4468494587186473, 0.15240071357159118, 0.26857895285235395, 0.45096725267582727, 0.8061353037690814},
    {-0.3095151369821214, 0.709011761394442, 0.7218522476846717, 0.576153874383853, 0.6023591078024327, 0.6034067318085443, 0.6754531933255834, 1.0115109704419065, 0.3988885766346833, -0.2555711290353467, 0.9037878806810805, 0.3475691364459, -0.2300651913672552, 0.7811397278655379, 0.6109310064178524, 0.5315186823325847},
    {0.19682339288085893, 0.8566182025828828, 0.9592748808871576, 0.5209132858603649, 0.24663210908983446, 0.9669451456893952, 0.5392580371714802, 0.6590768199852078, 0.6805499848530181, -0.0677710722039497, 0.6606663327723258, 0.4650329353800432, 0.20591545389096277, 0.5622865374691036, 0.8690854156159931, 0.6736915897605873},
    {-0.09468681816507518, 0.2011146253622417, 0.12649157202305245, 0.6026769505282596, 0.3911882459076565, 0.3694892339644951, 0.26472431012321324, 0.40635465804402665, 0.5253626913593297, 0.2545068037605324, 0.25596292413615024, 0.6394296087579084, -0.18496406295584328, 0.18239344602941468, 0.19237166037394884, 0.15127486931479714},
    {0.14462292274165217, 0.6503930381109343, 0.4939532219197297, 0.7650141918750382, 0.49349506636373536, 0.7160020332606103, 0.49175981137673075, 0.7007078050116117, 0.7986800183206703, 0.0671651114604597, 0.3527917062149342, 0.8502836031727764, 0.16728885343026112, 0.8591143314760807, 0.6271586819902717, 0.45128380919569616}
};

static const float b3[16] = {-0.04217162450489493, 0.4236639711775363, 0.4286731338186738, 0.40682612601500856, 0.11051557752116574, 0.48230396481128746, 0.41619092278378633, 0.5006706792927934, 0.38056230696540516, -0.018624438908542772, 0.4447490102408334, 0.4165200007360004, -0.043227236911209686, 0.44505770359990393, 0.45521527607997264, 0.4826086193343433};

static const float w4[16][12] = {
    {0.38615765832655174, 0.36611971014680705, -0.21712621770133758, 0.40288869883443157, 0.2518793800075931, -0.12723535026895455, 0.27688232436221283, 0.014391451491905554, 0.10349688390567888, -0.2821356483886389, -0.18328245559713693, -0.16720627056903115},
    {-0.2910394028586303, -0.9669895976980963, -0.4602774782129714, -0.7966684948883722, -0.6858389649000083, -0.5178104374030793, -0.6521904416063296, -0.23916993451674984, -0.3590944289583679, -0.6355456612566427, -0.8369906584463958, -0.30207925181395456},
    {-0.7943039766891593, -0.3754107113654514, -0.4211425571818862, -0.9305281935598826, -0.23924465010059973, -0.9355112785556122, -0.3990040270632095, -0.3791713038018503, -0.9112453367045056, -0.6841395319258834, -0.4798013558203709, -0.5438358350427603},
    {-0.7852496117126262, -0.6515357059891458, -0.5616005742131186, -0.4197854074922805, -0.49076806501248615, -0.41560605909392767, -0.8974605668337569, -0.42655390619742156, -0.37256988677294284, -0.09340036106874525, -0.08676960824367047, -0.47979877832606355},
    {-0.1050482967493662, -0.8049717798576477, -0.6758400357510028, -0.11294587680196627, -0.21600234918092195, -0.08825447324822835, 0.0008271368366981534, 0.11203684351441949, -0.13744100426554767, -0.1548114360355759, -0.8026873623729945, 0.04442877033087363},
    {-0.9011668595189058, -0.7673725547119896, -0.3584850065153743, -0.19376812990486075, -0.5315502314706156, -0.7504032408708606, -0.9009274754525535, -0.9542711552239759, -0.3952841848296778, -0.2883515711131774, -0.5221790890924869, -0.3580661662898766},
    {-0.4036427120844027, -0.46770733613985366, -1.02667628028794, -0.47548733472112625, -0.9080892477301583, -0.802156662410212, -0.49205201470525056, -0.6525056873293883, -0.7470444904612368, -0.30105820731886845, -0.9256370883721934, -0.5815770741763976},
    {-0.8754319676019551, -0.5562734912063019, -0.5621275493209233, -0.5348615778845671, -0.5055506281820891, -0.26094546009232, -0.13826295220744741, -0.6993501587514259, -0.9278706803857981, -0.6197658855595557, -0.793905774173284, -0.8343587640699963},
    {-0.2231020018871438, -0.12122280948488383, -0.6149191831110741, -0.39805053132717266, -0.6631290566684743, -0.2109293704342617, -0.22159378132183216, -0.830859512683439, -0.8860624205264975, -0.8580917939073657, -0.41152706962198626, -0.7750831648629429},
    {0.3557018020728661, -0.4501749555670149, 0.4079570436996507, -0.472394589708664, 0.2655926163600647, 0.4320682098695214, -0.0352241241374722, 0.3870169456222558, -0.30759354674952294, -0.04684531925109622, -0.1439983025170771, 0.3211331081459219},
    {-0.17196721794758357, -0.991043026195562, -0.714148520661262, -0.30887133130586053, -0.3436852291036856, -0.6235259482227812, -0.8517339293892343, -0.57191376074584, -0.19528789228111396, -0.5042052469521776, -0.627196467805079, -0.7012294881678621},
    {-0.2072905064279652, -0.29547727715801914, -0.6980265272406351, -0.46940350212017834, -0.9126573509477819, -0.5128403996379686, -0.7378670757699182, -0.33999734018295974, -0.45830254275040433, -0.3185873740582884, -0.6044505241529525, -0.5150217314698671},
    {-0.42604542967384623, -0.32479687365685794, 0.21719748968348876, 0.24011570599480886, -0.03995805557670103, -0.08070497666132226, 0.3541028557126057, 0.25498367237286196, 0.21019207078996494, -0.21283339426808803, 0.12421276742370159, -0.19892563302073063},
    {-0.8463678391367355, -0.22303594515651107, -0.15844794736454107, -0.908924367449694, -0.7290103025759532, -0.652984581497678, -0.43820659062872686, -0.759007719582327, -0.4476407792250784, -0.6122836126522938, -0.6184152018241913, -0.7089115450819272},
    {-0.8178678623945199, -0.1817040553792045, -0.7446512065095121, -0.8346429978613719, -0.351407969896646, -0.6855171828961116, -0.12308078942528494, -0.32237203956961635, -0.7565122534487491, -1.009261484985407, -0.24477719248827157, -0.15606199568680537},
    {-0.6448065316336364, -0.7771310148603778, -0.17996780012698724, -0.5084606108825602, -0.38456051018754583, -0.4261447622553336, -0.9634418973418237, -0.7985299708450236, -0.35489211922981667, -0.8904882575654904, -0.2689503616061274, -0.8106099845043915}
};

static const float b4[12] = {-0.127658895462966, -0.25962085309034894, -0.20724029137977112, -0.23543583910995283, -0.1495530854682385, -0.18976662090893442, -0.22278308272005423, -0.18485878437623274, -0.183726286937613, -0.25378610321157913, -0.21661423141505498, -0.2016534794613359};

    // Input Layer 
    float z1[64];
    for (int i = 0; i < 64; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[32];
    for (int i = 0; i < 32; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 64; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Hidden Layers 
    float z3[16];
    for (int i = 0; i < 16; i++)
    {
        z3[i] = b3[i];
        for (int j = 0; j < 32; j++)
        {
            z3[i] += z2[j] * w3[j][i];
        }
        z3[i] = relu(z3[i]);
    }

    // Output Layer
    float z4[12];
    for (int k = 0; k < 12; k++)
    {
        z4[k] = b4[k];
        for (int j = 0; j < 16; j++)
        {
            z4[k] += z3[j] * w4[j][k];
        }
    }
    softmax(z4, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
