#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][32] = {
    {-4.574258047033353, -4.881383193012728, -3.741105795071839, -4.157367703893352, -4.626632432146406, 0.987466127886793, -4.699271396565165, 2.9565369639292736, -3.8735280507716574, 0.49494806379238016, -4.639235850739102, -3.0740495191347184, -4.1778521648822045, -2.563183054941234, -4.336884742212856, -3.795785188275701, -2.9639297721366886, -4.4121923631872235, -3.7607251629983245, 3.5833448766328044, -2.9500301391927946, 2.436209138159612, -4.639434443737952, -4.184540412248534, -4.66981294058454, -4.25498417832798, -0.9212451476475981, -3.800277033409775, 4.203376630620968, -2.866221014911828, -3.819285284076822, -4.1636531295675905},
    {1.879307614306076, 1.4862859026863513, 1.7595487504762817, 3.7215743946388344, 3.9704790007717565, 0.5736936073057266, 2.7283887664318818, -1.0827063581377163, 2.0852383373988377, 0.398807736742546, 1.8829729390808085, 1.466864306817889, 3.0418003721765103, 3.990437393062101, 1.3603048399828357, 1.8427755077806827, 0.0036003105254910996, 0.9777958013683261, 2.2761559698669886, -1.8800479612028627, 1.3886008308871747, -1.1713856688096935, 2.020274827001293, 1.9840809825419132, 2.532948229851022, -0.19412263938653698, 1.3133158018334772, 3.5766413468423632, -2.66277616780403, 0.9623308983460047, -0.5379343503613075, 2.6214145010147303},
    {3.614005325010315, 3.2978816461650817, 4.065315173918749, 3.589226535953701, 3.592214335758114, 1.3051265609682265, 3.0990153136969463, 2.540735920202498, 4.571399221818738, 1.1693590879627727, 4.237762734789287, 4.61276006411776, 4.33382084538636, -1.1753605359102084, 4.076107003021137, 4.58353927316208, 3.82395464503945, 2.8957355148542137, 3.253114262406885, 1.743815286352004, 5.007612485695492, 4.233579295323683, 4.652172175137045, 4.520614508802294, 3.8476106086224102, 2.4511723567185135, 3.520625853810584, 3.6708529057562505, 0.9113060626734151, 0.3230049156698732, 0.7908247256872476, 4.2451959907788925},
    {2.7474215043939227, 3.808375670902124, 3.5280275487184327, 1.1049747180408551, 0.23290566155730769, 0.7550140982491508, 1.987793208653817, 3.8309371078835626, 2.643455036484724, 2.4553643559505955, 3.430914953743952, 3.6802812010792443, 2.4761764156248893, -3.369702995466444, 4.670706702045861, 2.90232487802115, 2.933939325989899, 3.390611151350466, 1.4753972520951206, 2.8774230376519645, 4.179380786418676, 3.9986993601407748, 3.263559209807509, 3.1502461937744903, 2.349025390151377, 3.896923216943935, 2.8821135936395765, 2.2239586264408855, 1.0934578127734007, -0.18157529135041023, 3.651450457128482, 2.252512593471202},
    {3.9278975254755566, 2.502467906025925, 1.5941568019623626, 2.0678112356870777, 1.9448701254651568, -0.381549064021618, 3.2539507748792365, 1.0559883174628646, 3.2369688467172293, -1.184269547509747, 3.9467131519605285, 3.8548782834901747, 3.8894579720619697, -2.819780430757926, 3.336795765932392, 3.857401844018031, 4.428437009307758, 3.587829199725291, 2.7600732074635435, -0.6954906454645337, 4.68543294243371, 3.5920241306861085, 3.758275180311145, 4.181539270025809, 3.230832273485025, 2.7011319293937244, 3.6030476518171244, 0.07539406930126465, -0.45191684022380124, 0.1412168232644259, 2.3340355584026846, 2.4385442183183956},
    {6.452619537603504, 5.647089701594332, 5.005854901245803, 5.662724516020596, 4.845465746511692, 4.764183268825862, 5.786052427363273, 2.0471600960329144, 5.821697917268406, 3.2663563572706296, 5.952566700828511, 5.769754056348415, 5.772217528542526, -2.865003140031387, 5.2101508094385816, 5.829036248293882, 5.43025400810103, 5.770525131773302, 5.105235079733423, -1.3759438937184505, 5.941387076498046, 4.841919719003845, 5.99198692335144, 5.904419657646006, 6.235203924873315, 5.510967178690646, 4.316960096450836, 4.5630790574656706, -1.5550054881050996, 2.9329003203938684, 4.9272897639338735, 5.909271024578668},
    {6.262886092582021, 5.818200021940707, 5.595258213096101, 5.373036860620532, 4.459622813665122, 4.3047019016669585, 5.768865647779167, 2.857313305483718, 5.521281987267153, 3.9876127742678773, 5.958038366314153, 5.705279440220819, 5.275392303242907, -2.734981103248072, 5.732047545613066, 5.648531854438849, 4.458315467265953, 5.8759646993588674, 4.433138243565518, -0.09674857584209774, 5.831930437809758, 4.209394635545249, 5.950277928667422, 5.7011357075072, 6.129520967438146, 6.141930478156846, 3.5450498622355067, 4.928702034270101, -1.110271839271145, 2.6156547487938626, 5.727237943880478, 5.913094926890822},
    {2.480599555083767, 1.9109822670045447, 1.788551851812654, 1.588808233513182, 2.695528062274672, 0.34214684644821597, 2.3322928236924705, 0.992764011925097, 2.117652366437062, -0.1070659247418001, 2.4807222267899776, 3.0446011199141827, 3.1763329407842686, -1.2849035491766245, 2.2303708509788644, 2.446264952183184, 1.9632841130225207, 2.0385873927108618, 1.774939744150061, 0.20115252773329773, 2.5085372573596523, 2.4801697528290787, 2.5148662662254355, 2.797846158033225, 2.6159942053619933, 2.0306839795699525, 2.9986681403795084, 1.3904749748238256, -1.8727758554367258, -0.8937927488532869, 1.2854387530177571, 1.640043812584327},
    {2.1313768592327262, 2.0535630370525806, 2.4327789650526364, 2.291197740806367, 1.9865073025717421, 2.4134539496938863, 2.4837077494583073, 0.814906941357296, 2.717939619791297, 0.9838148045250973, 3.370597833286708, 3.1543039432124145, 3.937902536738621, -2.3976874222159896, 2.116701528556409, 3.2207916984691214, 0.4453630563947479, 2.0489527702565207, 2.2854820086747623, 1.2095988564840114, 2.8203686813583717, 2.026873741635361, 2.9573026519937953, 2.668441259527242, 3.3046289671448728, 1.473407369675534, 3.4234027824504762, 2.9855980754478173, 0.4521167960238878, 0.9893224553984845, 0.5879915452816213, 2.3956608678828974},
    {-1.0349910914631508, -0.6026959313581173, -0.45022933721339636, 0.9771366483018958, 2.139068277247174, 1.5048911719152203, -0.7609232842811995, -0.43720388613418143, -1.4138415794620092, 2.0845362012007835, -1.6993079741578743, -1.2232148208857714, 2.018081087114736, 2.702886365407846, -1.5552500256698616, -0.9991678097359373, 0.16685055062634124, -1.9530046350934454, -0.5149536792926289, -1.401973270446794, -2.923211280008937, -2.4041539676521193, -0.759741643314012, -0.9658927569458418, -0.42998673373718604, -1.1551594387723592, 2.6436098732240643, 1.122052688539172, -1.412136629808626, -1.8812530947015564, -1.2748025112573402, -0.8941980139616487},
    {-0.9181312770178891, 0.1631011563901058, -0.5957505419730939, 0.7810936731047783, 1.1035811326962408, 1.5864070964687356, 0.15100280984436332, -0.4985448563505194, -0.5615974614358388, 2.37667292541352, -1.395089431271452, -0.9023348639174845, 0.2668684982330012, -0.266155769644458, -1.0901802188387777, -1.5689562233021928, -0.07493274011851353, -0.8405490068881194, -1.5780086247030727, -2.3658220396134544, -2.422587549007933, -2.5732147026004077, -0.8325483858676611, -1.6916580563625456, -0.34743080208824745, 0.7535761445211642, 0.39356541948991214, 0.4651846470640178, -2.708169608672291, -2.5310152792433716, 0.7776548245967272, -0.010245096487100161},
    {-0.5359423436209124, -0.04633117944516733, 1.8446670981579818, 1.3789131356344084, 0.22271310710699024, 1.2746144863033595, -0.19502427096258734, 1.0216205291333964, 0.29290050759150194, 0.9568601690681433, 0.4126332260630441, 0.9185016259289646, 1.3408107082337382, 1.1552772465156598, 1.1471516849308316, 0.5860048461707188, -0.2220919763915033, -0.19511264813472715, 0.16095006753001334, 1.8386483007408592, 0.4018138180418595, 1.1364062723850636, 0.9085652836697962, -0.022901282354966433, 0.27409883323127815, -1.432266621603729, 1.0726755608766374, 2.850755343648346, 1.7400108236701577, 1.4712786653813754, -1.8860358574942433, 1.3601049015729958},
    {0.9096176626158661, 0.06323914857356971, -0.07804945900391493, 2.047360014161506, 2.25084381312387, 1.7807408560319182, 2.31553624220001, -3.7293659865639364, 2.0351634435120003, -0.7432307717975776, 0.8588978883473245, -0.33867161987932926, -0.6074773035688463, 2.9195041661298498, -0.7813212796245771, 1.1325913755910149, -1.9772905172847952, 0.02016860316188502, 2.293931367073821, -3.1895519147226516, -1.3674076683264953, -2.8962164384505704, 0.8306031007149085, 0.4373084689067217, 1.5985100306114688, 0.042105653663920335, -2.1236245331075714, 1.3000386400936759, -2.261929431942487, 2.4325775686337563, -0.6284243007696924, 2.3590125901496277},
    {3.5401009930998835, 4.264705970335709, 4.366688851920029, 3.451054159259831, 0.2938821109465931, 4.227106262648961, 2.1069482509683826, 1.9604554518140418, 1.612774317529892, 3.625068259912654, 2.6401297335447493, 3.1688387049999274, 1.2924641317050074, -2.295469810907005, 4.177212457568478, 0.9134697465007721, -2.2866447913467285, 3.966833130736097, 1.662746399317024, -0.08166787486930839, 1.6378412515584961, -0.4562853894230964, 2.735296810222551, 0.37716574270183956, 2.6561385935193886, 4.698063676991094, -0.783648209732933, 4.211957270267548, -2.3926855802322744, 2.296464142877592, 4.7411772762129365, 2.842913122994772},
    {3.1082332261906793, 3.2614330223645007, 3.3949449567993453, 0.5001525520428324, -3.4917622521727325, 2.6291877251646603, 2.025768025799296, -0.5674974220850681, 0.8036719759317753, 0.1634618898895332, 2.211281903020045, 2.089445076233177, -2.0348404197122543, -4.5827637085885575, 2.8618807029439557, 0.08234764504450957, -3.9662285871195517, 4.034554084273244, 0.04223254952100146, -0.9744823061927987, 0.8137588480869927, -1.1710166632944845, 1.7090399834539132, -0.4862603686431532, 2.7628311413166293, 5.496016944349584, -3.926262799468642, 1.7397592355882456, -2.467581616992838, 4.187468077388288, 4.927667609654557, 1.081317785756738},
    {2.3837577302954123, 1.8886300651279706, 2.4403872272028924, 2.249755982328967, -0.5723574219865333, 3.01427625438343, 2.6414646144482044, -3.650166988764472, 2.284756192086792, -0.82099123698282, 2.0480270269116962, 1.8326246556815005, -1.9264730636791596, -0.03626548668725694, 0.7509972508540214, 0.7141696298826979, -4.468620140936504, 2.4199576830636196, 2.190380946257406, -2.6256125885418515, 0.06304586374112557, -3.6302051325764753, 0.9397269886693143, 0.1677337051136342, 2.6040429250550288, 3.5042962414493544, -4.119728845802024, 2.711385186487225, -2.649612572317436, 4.310790471633005, 2.687194973843879, 2.3485739530041547},
    {5.050358881960648, 5.5004623609811265, 5.122079887431133, 3.6813418931854884, 0.7254681331027473, 3.316310018341782, 4.180307661037857, 2.0369641286174107, 3.367811431264526, 4.43377376320626, 4.308359551836413, 4.195133955601969, 2.153396410174608, -2.6004614269040807, 5.38054119100967, 2.403774578811531, -1.65213308992442, 5.091480981225008, 2.2394946960083697, -0.3096709314875351, 3.753202133367772, 0.16772593658614962, 4.330210276917917, 2.7565536739247944, 4.767037435420476, 5.854162882588711, -0.4863139731987036, 4.177543580079531, -3.2950089887304626, 3.6291612454412876, 5.827683653916989, 3.6872617812093385},
    {4.19490969867962, 3.883017899827363, 3.779205648021388, 3.799695966277228, 1.4215603491123745, 3.833969122821516, 3.4543580126258746, 0.440649608916604, 2.578010277582898, 3.6918445644128552, 3.4293082088625666, 3.2677272949267753, 2.095087323778684, -1.407088227562404, 3.832828780002734, 2.0280890873521114, -1.0555503844397152, 3.677083355542992, 2.2472508164431013, -1.878456841528289, 2.308372582019347, -0.6655384108762575, 3.399993236903893, 2.17381203723301, 3.9512861633790566, 4.292818058086866, -0.7336811887767575, 3.8844995649860987, -1.5758695115612633, 3.8118380724664553, 3.973034936390853, 3.332051771809433},
    {2.536160646665116, 2.6568509426490254, 3.263261875198653, 1.513464372721734, -0.06978036641429299, 0.48354548785784685, 2.8568502349980878, 0.7098880179699999, 2.2194957187577273, 1.0267779245533122, 2.7707856550258905, 2.29195281083303, 0.8445511931641431, -1.1457674799068562, 3.725452886113491, 1.8868560727339063, -0.9944751364573546, 3.528573663728715, 1.3899356627656387, 0.46864874565347386, 2.1983685101615698, 0.7828897597300484, 2.8672172135942184, 1.8508335324201044, 2.3074920610293326, 3.542894541981373, -1.2551021029496996, 2.7659114797944784, -0.5944861380970295, 3.0718751055389264, 3.3380363758914897, 2.069300911200285},
    {-0.344253904232496, 2.3449368180039807, 1.8526116308552962, 0.8674164157417055, -0.12580433597011467, -0.4653468957450809, -0.030377780264683102, 2.9826120682458876, -0.6409462821346261, 3.4669529805509556, -1.0064818537440738, -0.29101543151848924, -0.9136745993256754, 1.0223166496275273, 2.306946748043437, -1.2330566426046845, -0.23352926023518572, 0.5204773511743008, -0.67824617638025, 1.1032319926581875, -0.8516636838006761, -0.530974237878343, -0.7839070926699999, -0.6756257495581265, 0.061949788326350855, 2.7907637997378005, -0.3830162405057131, 0.9086908232741254, -1.6183618540063411, -0.777178560869727, 3.0640772380985393, -0.03682144548017607},
    {1.0618649433409186, 2.495239440774391, 1.803158121405526, -1.3799926241208331, -1.6526813712948438, -1.7094018788588812, -0.40412215959933195, 1.7947771120333456, -0.41473624519603824, 0.46211442275004894, 0.36408782692637687, -0.38867211297569065, -1.322790129225962, 0.3103787374719685, 3.031729262728865, -0.47442910106173725, -1.3599822605663565, 2.188432286331855, -0.9854328545942043, 1.6962481194712684, 0.5195036048491525, -0.8502390582948053, -0.08367849066367103, -0.17161045262836086, 0.6077871624019092, 3.9253127608665968, -2.7521082280432423, 0.6759838502381929, -0.5638241993349816, 1.9056118376126148, 4.074450980256458, -0.2117133072913596},
    {-0.37921372349025634, 1.161838012839223, 0.6470357401908031, -2.2629851849349194, -2.977364753756533, -1.4702159541168334, -2.0700238949594336, 0.004055565145511408, -3.2578661892615206, -0.03281905369694502, -1.4425928993049089, -2.063737792505135, -2.7542824522475473, -1.9186163220276944, 1.2365100547000247, -3.3057128910287026, -3.3114290885602435, 1.515240792788098, -2.9376659930545093, -1.2136300010413938, -2.1041141316761913, -3.3800296989661556, -2.3532874864364297, -3.419704211279359, -1.8718358946801767, 3.486222840909651, -3.3788519666579107, -1.3186724466795812, -3.2701648803969, -1.0847559706645649, 3.7657706920106317, -2.332302023903767},
    {0.7330606521307824, 2.4058212157419336, 1.7316341568471163, -0.9958186102334531, -1.2238678859548378, -3.010699327754415, -0.7848352213608983, 0.3875421880057213, -1.2710834321088131, 0.26441457678477404, -0.036560220101402634, -1.7036151657892795, -2.736343013108518, 1.6477741185582544, 3.340134926368467, -1.2845533061300343, -2.3089796918003045, 2.234024447861127, -0.9392535527312037, 0.8058436871872222, 0.48289355123837535, -3.388818167322077, -0.5609578311192353, -1.3271736489049477, -0.3262773462386612, 2.8987593338102333, -4.1402782126987425, 0.6707927257713115, -1.6036546551507835, 2.1610906529019243, 3.9914340816133396, -0.3177618922982408},
    {-2.0447497667140295, -0.519720428519414, -0.9611795094808556, -3.3894613370084845, -1.2571520475598905, -4.728351933431975, -2.8863206521809825, -0.013963774234720712, -3.455829043460324, -0.7215126988933425, -2.7689000434399516, -3.3352349395784517, -2.4622710426063823, 2.626132660258512, 0.0018326588899378346, -3.6076544157787644, -0.1465924115639304, -1.081806569819991, -3.219722146176665, 0.2809417078627557, -2.5168961280651123, -3.219561182644052, -3.2204119236986912, -3.068410571454642, -3.2835202252069897, -0.14247494032249633, -2.095868439180117, -3.0645396642835907, -1.8503794055509462, -2.775796264159147, 1.097309949690055, -3.212286387753053},
    {0.07946967465787927, 1.7621709891050366, 1.55352518581829, -0.11562793945323585, -0.6905073087316338, -0.5654323909100508, -1.460862257046654, 4.910600835888895, -1.3524780799751315, 4.275646617315481, -1.1092200406945518, -0.446611229572157, 0.7208311068475264, -0.2909550130764808, 2.246693215836472, -1.9061609357106943, 2.440567332262546, 0.8508945151699567, -1.7553631985509945, 4.094604848398828, 0.6964577114793616, 1.1348984923550998, -0.37007881094137457, -0.8702393374730171, -1.6689592246551774, 1.5306095226170857, 1.163535903492214, -0.48929604751106864, 1.5413562028134762, -2.1254822768913786, 2.6598481620762655, -0.985898738771452},
    {-3.5850204786879742, -1.7092318789219263, -1.7470741444009643, -3.6838618070208637, -2.26819525464273, -4.163582576959735, -3.805362028125643, 4.142363459766393, -3.692934199261897, 2.234045094430933, -3.921493441159506, -3.4242326474140006, -0.9837260367508041, 1.8197077954713003, -0.8555337235174195, -3.46558018079576, 1.8894352960842122, -2.829631464979165, -3.406730518797746, 4.563544648261837, -2.4316322431819315, 0.36823063877167506, -3.4225952898610297, -2.458885366611969, -4.0175926671391, -1.6826642774857605, 0.752311109984961, -3.3149561709245208, 3.1683553068166592, -3.506966544115264, -0.426274234596479, -3.8785301728039294},
    {-4.74104313645692, -2.06794389868848, -3.238622983200497, -5.300586577641852, -4.684938528957972, -4.771829613700347, -4.710810962756739, 0.18434231897577197, -5.858546141912932, -0.1686352708264274, -5.442660372408457, -5.347291955099668, -4.613921710827241, 0.6317296108892275, -2.7959619758160055, -5.367274530764158, -2.670573098356583, -3.4430434947418154, -5.032815281506637, 0.7045609519745416, -5.206148718450205, -4.100400077227174, -5.2118991758263915, -4.8866106493217005, -5.170406985008135, -1.4558040598398976, -3.166282298558622, -4.476252354290148, -0.481439691625054, -3.2367568437783376, 0.11904234570054006, -5.684483550331929},
    {-1.6359016103100175, -0.24793249800909334, -1.3562262042896593, -1.777865978866367, -0.982546927668452, -3.727404905578313, -1.2763380039872378, 0.9874043408924108, -1.499185393497079, -0.4394575529460164, -1.4282394618089094, -1.9695638181547592, -1.372930691593417, 1.267572164500845, 0.08534083876201928, -0.9275964102135517, 2.4363908374708743, -0.8122809561790133, -1.9914470799660469, 0.9188488707116134, -0.0815190385880256, 0.19754282573213677, -1.4725639621951636, -0.3976686992010695, -2.317059026656806, -0.7073080196645671, -1.0681644727357946, -2.659592354802568, 0.1382751587632821, -1.8517940193611482, 0.4793243038857813, -1.7878153646032446},
    {-1.2850647822796006, 0.9447540517548312, 0.5418615277881721, -1.7467694897409007, -2.52930059805169, -2.4844059745100395, -2.4916773703923876, 2.6418091649091053, -2.7374533254855993, 2.4971919569727676, -1.9849578160178345, -1.3800058885900852, -0.6648492576952864, -1.7922464939160268, 2.0325949905453404, -3.0371015024585484, 0.9782709439870563, 0.24130903681243945, -3.217912765158778, 1.0742057194885595, -0.9220686949681551, -0.2705957806048573, -1.6267584530826402, -2.140533434281406, -1.7647039224299417, 1.429336562345107, -0.20007828623413612, -0.5572003690975228, -0.9586122623115424, -2.7856438672401977, 2.5204098421340997, -2.23479320673391},
    {0.6511863324626199, 0.4942600968231163, 0.056130869729574415, -1.5010480516069988, -2.948154455313868, -1.6336815436202632, -0.37614563878651863, 0.5225706410990716, -1.213950539175289, -0.039077187345562606, -0.4353147799976172, -1.20685710616336, -0.04515207734803979, -2.5329610715667075, 1.6396574979031246, -0.7842674880409493, -1.3690031456750749, 1.182739618254142, -2.1154169078490734, 0.3423100601473578, -0.026227523131606693, -0.4010293947852103, -0.22147809531802556, -0.7966148084573055, -1.0106837277481833, 1.2015933360285114, -1.4406954253263622, -0.7050114986951972, -1.4871600783452716, -0.14916280738627274, 1.8609723222606689, -0.7536776476285917},
    {-5.053374310650873, -5.109569995948822, -4.960688085569528, -5.134080536268954, -5.710820192020383, 1.6164462929414902, -4.964064585037321, 3.1935346514727057, -4.910280346393356, 2.455580308715189, -5.178898888629105, -3.71687977804025, -5.033558974592734, -5.723923555059449, -5.084925146939747, -5.882125710657547, -3.170071933193475, -4.760048710208806, -5.822903270671608, 2.838608879436928, -3.155893324141291, 2.455590839516323, -5.194169951927916, -5.708476474921351, -5.576313156699771, -3.7154899245701403, 1.3619016501941894, -4.5429531122691005, 2.1070601553447466, -5.959151891325874, -3.528680020101105, -5.042602502070363},
    {-4.711956324970309, -3.576154858625421, -2.708897792376675, -3.8408463240218316, -4.948575547053106, 2.1515276195457718, -4.639064339571614, 4.56054314795734, -3.7358080030192125, 3.6615317004528434, -3.8043568932684226, -2.0910364301205906, -2.1134567744703965, -4.471946126993473, -3.0140617615507925, -4.268592083642717, -1.316043077146489, -4.277963219625715, -4.802364013845828, 4.793250404829677, -2.5852527356948456, 3.606847412953823, -3.5539851601648342, -3.9770978106338877, -4.165351873133247, -2.234440608629403, 2.4975150656434337, -1.9619749137362508, 4.0743221174393796, -5.038508859113441, -2.8480371676687843, -4.0042288252825164},
    {-3.41534962363065, -4.19145244480502, -2.898556210985485, -1.3092874237692573, -1.1247133253159112, 2.5984588752358118, -3.2855478953853643, 3.43662462508777, -2.0317266987069003, 2.55246640882187, -2.820735207736578, -1.025231577629148, -1.4150346923218118, -2.6601109229222826, -3.0785535271175584, -2.155594074667519, 1.0798031815078202, -3.841645451795284, -2.6974489081943807, 3.558634009168279, 0.17567077264129255, 2.9964822611787896, -2.525482507019289, -2.1616695506345773, -3.2262243871893452, -3.5579331927113653, 1.9183297111673434, -1.717724822249213, 3.8649804090243243, -3.2940823678133913, -3.6303161892538953, -2.0121320069046233},
    {-2.692263643869598, -3.819043497335003, -2.5357471035560035, -0.9843020259486734, -1.6231199186728433, 2.5056638437055345, -3.4979835704848194, 3.007276826614475, -1.8533375067487812, 1.872243020346634, -3.0552498984575442, -0.5753410712301169, -0.18376996840940868, -2.023896818649933, -3.0723141187366925, -1.3921519285364095, 1.3411715676150926, -3.090839456974673, -3.189088740523983, 3.836589696387299, -0.5122978183926887, 3.2139809859140405, -1.8029446018517268, -3.0473093238809112, -2.5228534348189102, -3.413984229633557, 2.9715731750517826, -1.018303332113555, 4.313327381420746, -2.572860348432249, -3.750661468178036, -1.830136224504812},
    {-1.8168318044353264, -2.441497557473113, -1.244550336580374, -0.38321661325843737, -1.7253883751515224, 0.18790175099655898, -1.3075668427867915, 3.551429913900873, -1.033593409483329, 2.5401125063129975, -2.3570920234389336, -0.701418621805779, -0.03385943688321255, -0.5795841292507229, -2.0824964774458015, -1.1121816733335006, 2.3214116425795353, -2.095169247703473, -2.3270573207484504, 3.717005439641486, -0.8386154019749147, 2.8410866574909344, -1.6624851151964333, -1.975331336625976, -2.745505750806, -0.7890780344166558, 3.4189286701155224, -2.096333850127907, 3.7006257295877023, -2.682967692145079, -1.3913599048542407, -1.3892009415217526},
    {-2.264734930687596, -2.382030944640698, -0.5006218117888087, 0.05149547995553234, 0.597608531840425, 1.0677064850447817, -1.937936734093911, 3.5653925553780237, -0.7922147147467887, 2.1761618219554824, -2.474928005280334, -0.6182064775196687, 1.2788943711451577, -1.7470630580248374, -2.289884488257843, -1.8569496448882419, 1.6855899928849298, -2.606648232754162, -2.973103929190555, 1.9214646517999339, -1.2237180098555496, 1.7732909707216764, -1.9259886759116946, -1.587795882500509, -2.3168939679523164, -2.1771445496448636, 2.433947764801044, -0.6551071012960453, 3.1034532737988054, -2.6401024803509507, -2.591134383111747, -0.2091670274735676},
    {-2.01796629644908, -2.570016741274918, -0.6424481369885289, -0.17714302536419532, -0.34648051235748756, 0.9409303084481689, -1.3448506046425146, 2.6801986523263013, -0.656086213346567, 1.7786584772820015, -1.811522864129016, -0.877142501003368, -0.10687534802410774, -1.1192544728632858, -1.8862546395482245, -0.21790644738090212, 2.1723588009799384, -2.481113722195956, -3.117452583987955, 2.6628880322175172, 0.18414170052262463, 1.8366309420926201, -0.8201637358742252, -2.251137488819247, -1.8651908491795177, -0.6485166581639004, 1.9645343663303212, 0.1333557848823933, 3.841791535240697, -1.0625781412982245, -1.6010705125099074, -0.0018419167963083798},
    {-1.6365736739299337, -3.0596393021834887, 0.1561981134184503, -0.9094334379604632, -3.5297752484779306, 0.9938429184485619, -1.524705956239669, 2.362542596576182, -0.5307664951893256, -0.466396360796587, -1.4615096091894122, -1.698404801874794, -0.5260148611898281, -3.589337584258367, -1.4548636047813168, -2.2217738869189643, -0.32481793273414106, -1.3384407200439565, -3.1167878834432328, 1.0664697542421766, -0.03537890794585058, 0.38961060646120055, -1.9915628496983795, -2.4375277418434576, -2.3187665917909697, -1.099274139393059, 0.813479142287697, -2.0531566138762396, 1.5472028169931376, -1.5249424756096877, -1.1660987874498505, -1.1711845066787931},
    {-1.5666351509855945, -2.422847709433341, 0.045843413857433915, 0.05476384052396821, -1.4457919550212244, 0.5909772312667371, -1.677895766014093, 2.5095788256937173, -1.2175551924296224, 1.346721429330846, -1.5041612658616792, -0.13232397868475948, -0.5567393813014743, -3.7724285630490013, -0.9799754052339186, -2.6702675499437403, -1.1187466848472618, -0.9002861720104305, -2.455462578681234, 3.209152173665536, -0.12773157822250802, 1.1561055432652303, -2.0407901226214884, -2.4548817973990116, -1.3717917101310455, -1.1534368195200102, 0.8079459149752045, -0.9650314498324731, 2.120363683015526, -2.64998929298281, -0.7305339386016899, -1.129273071548558},
    {-1.4931748200402863, -0.9885747131447659, 0.2605447814429167, 0.09174497681052038, -0.13809319276299833, 0.09535394777170142, 0.40895877086411214, 0.9623018524232806, -1.208589825721325, -0.3353680394894062, -0.9849099840916552, 0.88835146065991, 0.8805778670708352, -1.6477972876766975, -1.6269787110327605, -0.3826590148004066, 0.9548577600100439, -0.639117171951162, -1.2511323815625677, 1.2618926747541395, -0.42537494728307834, 0.6793543403703114, -1.2870605017664194, -0.7980723002686028, -0.5856488549909505, 0.027768568350597114, 0.6436638144832482, 0.15659787010661658, 1.1934052467541665, -1.3190216343199999, 0.022091875863064048, -0.5060278903398137},
    {-1.647872682810146, -1.4036580638506344, -0.5181785207319246, -0.18296520003536412, -0.5648573830371678, 1.4944823330000236, -0.9492082958893361, -0.9602065684722559, -0.644880850310456, -0.7280340372401006, -1.1915556597311783, 0.5155013888671945, 0.5691158564144825, 0.674812315812095, -1.214764810354619, -0.010686278552156918, 1.483451787928745, -1.5808286178370008, 0.5448898841476518, 1.7879892153605677, 0.1383065617979627, 0.9241141614154132, -1.6444112287969044, -1.0547536929637344, -1.6193281406431923, -0.971143745697655, 1.0654799678199172, 0.009014030966608634, 2.2705613141030754, -0.09078430171195519, -2.8875843419651925, -0.28408003618043437},
    {-0.765265568628962, -0.822170685740061, -0.7473800864847865, -0.629365877523519, 0.9947792042337236, -0.2122857036188225, -1.232945785744916, 0.7851007612872553, 0.473592321082808, -0.6986842886085598, -0.4533679765048399, -1.252480390784047, 0.0068347526505474175, 0.9021224587437364, -0.718306187872803, -0.02397060105046707, 0.8868506930584037, -0.7015637162127427, -1.6492604964925854, 0.20415893284092607, 0.25465323617599855, 0.15476097561094734, -0.8084321086376658, -0.25559384934400164, -1.389255231288197, -0.9034710912760476, -0.3446121790357973, -0.11556389006189359, 0.1404775434594099, -1.2013818262887657, -0.7707113813812382, 0.3820302746678636},
    {-0.2831041175215891, 0.4408242340125922, 0.6604892099493272, 0.9110835376937757, -1.0800504927733214, 1.1611678269810335, -1.3610931618384807, 1.6915196548730278, -0.5124061024175607, -1.5510184174195674, -0.4684914747330994, 0.8055981259293243, 0.7446571679878177, -2.5825598201008515, -0.08538389410232047, -0.18956676527070804, 0.022694815729127255, 0.6565802217434779, -0.7307854665516037, 2.1497193302286424, 0.6738780736150164, 2.175724984887663, -0.06836588008455767, -0.2635134875189943, -0.2670849567489154, -0.45297367077526607, 1.8764539862185277, 0.4159662935743207, -0.17057501395465988, -1.128192974188461, -0.9480116088804866, -0.3299360959981224},
    {-0.6307576694334697, -1.6355581586430956, 0.0022437407219970404, -0.6081973495415172, -0.9193503300592571, -0.9565349154410728, -1.5952863028996458, -0.08465851934857915, -0.16307250759921507, 0.6912606747893683, -0.5537585896875223, -1.3703058741217031, -0.7373531263549438, 0.14216485251300065, -0.583929420401899, -1.3658624767265033, -1.4108684052884335, -1.3651736287262626, -0.8277869857682102, 0.3631279671755496, -0.5336332072169206, -1.26487565897793, -1.5692105477618497, -2.3950447840088334, -1.313595945504644, -0.3793615486742419, 0.3491239129232827, -1.3641059443878605, 2.0121046772559334, -0.884476869959004, -0.11371607558420121, -1.0323736388002485},
    {0.14680015076154307, 0.601946226025171, 1.459707168505925, 1.5123945439470603, 1.2365247906811339, 0.4695721769212029, -0.7109281477659551, 1.9327356445982595, 1.198948281075313, 0.3348900775079594, 0.9844033103432569, -0.05717729045083215, 2.312558335988803, -0.9935335308360945, 0.2715215984829281, 0.534817205824027, 0.9440964585904192, -0.050801617875671556, 1.0833483392579506, 1.15621722004726, 1.2685317423546432, 0.9536201109930503, -0.3930142090073335, -0.19242843293223988, 0.5588500031354497, -0.5874537853356113, 1.7068071793823227, -0.5824147898560295, 0.4369171894858252, -0.7395140341370203, -0.9263867173051753, 0.5226517982310943},
    {0.22832150995880054, 1.2015590530427878, 0.4294259682213398, -0.015725776682528163, 0.3788204219666084, -1.5101100813439243, -0.9720611871396333, 2.088325093582715, -0.4902959807644983, 1.1035160154390884, 0.615069843595154, 1.5426682328288512, 1.1875375953921274, -0.8181179100441114, 0.9193175018964342, -0.8247732694922039, 0.5463169816548996, -0.4784831245368136, -0.497736185495413, 1.6074599022615947, 0.7993723625690621, 0.9578344953787044, 0.6554679449856258, -0.3739991075071616, -0.3046658183607508, 0.42706013944501764, 2.0552613807389117, 0.8025000142640036, -0.3578195597972505, -2.2735744178827546, 0.0032522311129738407, -0.271844617919876},
    {0.6270326996281372, -0.5017874143206444, 1.6630928341916975, 0.5337183436191643, 0.29769535248098994, 0.24401906100734191, -0.08196518608033007, 1.4116248445746116, 0.49286244907737525, 1.6209106322766826, 1.1784427791862997, 1.39929208534195, 0.9282400025979307, -0.2613051066214018, 0.445971764832282, 0.16833518763144173, 0.8838659014241406, 0.061735305854876514, 0.5353090430508711, 1.753625789812119, 0.9026198507083559, 0.8241796067335815, 0.01573019274264708, -0.08564560818938767, 0.4644805104924279, 0.5806576411138016, 1.8140027755863717, 1.1864696498567318, 1.7952325602465826, 0.12477453446859739, 0.14668072880458044, 1.6423981063554247},
    {-0.6962388831341543, 0.04611912191612233, 0.40363576976455057, 1.4837919080631938, 0.45350828559861806, -0.09768463827945009, -0.0996605199611928, 1.1708039578759537, 1.127326663547105, 0.47738446861553746, 0.35112578366899017, 1.6190342768492592, 1.6064752046922257, 0.8813779513363648, 0.016153333815017167, 1.1320709084473697, 1.013431892771218, -0.8889939546123351, 0.5865902600209285, 0.08913025746258169, 0.08209182019120559, 0.9954897473391466, -0.10460034409898611, 1.0062829458277855, -0.20397977590084213, -1.7760987468996343, 1.5077913156410174, -0.006749861255626286, 0.8353728540103038, -1.225090469950943, -1.7953208888795753, 0.5546267520416078},
    {-0.11753551290951028, -1.2336893938405182, 1.4741105944459987, 2.0258125314411966, 1.9523603578481836, 2.7099675772832543, -0.35146790186431043, 1.8706807398548262, 1.667611160301779, 0.7783377969594032, 0.2780370259763831, 1.8707108006588604, 1.2244526995021623, 0.772976583316006, -0.8181238679922347, 0.4812688496076251, 1.249844158495439, -0.42651785449435753, 1.8987759302606964, 1.4961526862927796, 1.6682734547087814, 1.9484185659342932, 0.3294027361415717, 0.4230700276058138, 0.14442206354762988, -0.0925810137034822, 2.657877570158031, 0.6467058106804624, 1.2952829890492692, -0.0005609821255764258, -2.3208113175126517, 0.8269259362977414},
    {-0.07445205621843723, -0.9917817012949655, 0.9207092625216581, 1.919015304469956, 2.4057472145802445, 0.3964609511944677, 0.18289276572308785, 0.6270552100749858, 1.4349995646321119, -0.929113185177841, 0.7997708749352808, 0.41104761184605676, 0.6414594581256137, 2.763180387011659, -0.09730610297300055, 0.9048665346034074, 1.689550160278652, 0.0215665355079374, 1.1097964292447422, 0.23407291607458072, 1.3359279928856396, 2.267924301675571, 1.0021989828737863, 0.8707613206097671, -0.11306692662341072, -1.0782566007307672, 0.49173144360983867, 1.3875373055957774, 1.206423244934787, 0.42573547153788327, -1.3809878972965257, 0.852489076905754},
    {1.3010409090070665, -0.13397256423440038, 1.7395582745681726, 2.124158610824422, 2.6799274735490406, 1.1541444275299504, 0.8620076825879411, 1.7473092857556336, 2.0399400153817986, -0.2785816554163676, 1.4540218566350234, 2.2982540426548406, 2.3322386246767417, 0.692002284185818, 0.7939025366611989, 1.5389544988927555, 1.7185488606748143, 0.644207329725199, 1.5287711105312707, 1.4606065503232002, 2.1154299687927107, 2.034098181181344, 2.091686747369523, 2.1311056370429804, 1.2144819647944198, -0.5289017913064804, 1.56823497353157, 2.070455536455303, 0.8191997058503653, 0.9764974386950096, -1.896080458877319, 2.1654630889492243},
    {0.9281306737642597, 0.8850831992040478, 1.7082005964767482, 1.9012212123908943, 1.6471531576639848, 1.5489973233913197, 0.6033388920018049, 0.27921606356189865, 0.7696556872523997, 0.2721158294765989, 1.3574252707548666, 1.5547270780723146, 1.663704998578959, -0.00106727046671383, 0.6290244555723289, 0.6522684721762979, 1.9704354946681844, 0.3613239370578497, 0.5524301640947913, 1.3898775142707347, 1.2044508268532872, 1.609399575202284, 1.1951526258564336, 1.328438989779283, 1.0824305178329219, 0.05350634587060953, 2.0174771969094984, 1.3914793326904313, 0.8040859092481693, 0.7140474099951064, -1.4612317892867133, 1.3642302073728783},
    {0.2954185111206116, -0.47249817769284513, 1.089970942058183, 1.1316685782330962, 0.8613534908561896, 1.0345745988022215, -0.20131245295234362, 0.9883922655722757, 1.2712547684048627, 0.2699716011089031, 0.13643969319520283, 1.4230793759358709, 0.6925956392783846, -1.348272822568286, -0.33737068186956526, 0.9446980187710774, 1.7096501516620015, -1.1918172785107075, -0.29588148890829336, 0.17141472665456675, 0.7758242947032621, -0.029338140133938033, -0.10811142064785953, 0.29160649132158134, 0.011815211121884224, -0.528228047236566, 1.7211102667400584, 0.5437060508404151, 1.3400889571463757, -0.6432159754882351, -1.0587170841603655, 1.2305086427718794},
    {-0.0005779578762230905, 1.1409756575789967, 1.735778782915781, 0.18160448326523673, 0.6954683663215417, 0.9854952867477124, 0.3200346068014663, -0.6604498911976702, -0.7069958266746714, 0.036842702911832406, -0.11534017316183046, 0.6035626096637545, 0.5435536069847595, -1.238061489285096, -0.17449557245853112, -0.1879035802593297, 0.5100735290822866, -0.43940816596902543, -0.18144274020833115, 0.1497452876398265, -0.3289599723362988, -1.352750599565392, 0.45950977244736696, 0.006705671455789386, 0.028173693250102917, 1.138261369573647, 0.4537820054650081, 1.2571029344970348, 0.3529217224802351, 0.8007086948907777, 0.23759158103541134, 0.5431483609886654},
    {0.2678216637769479, 0.6981916167748312, 1.3817782349349033, 0.07750411154341753, -1.7145343985618748, 0.647361492025902, 0.7693807436469243, -1.1596123302099766, -0.336095202301616, 0.5414874158863946, 0.0682043196383334, 1.2284047620496135, 0.5648745194217655, -2.491355154132117, 0.20179988316375508, 0.22421240252079608, -0.8233957089269116, 1.4192490730706582, 0.6891283932884468, 0.9386839502296268, -0.7030433845501124, -0.4613135301734206, 0.6310098981720526, -0.380984461571553, -0.4283786913568811, 1.7560521839544037, -0.5436606763920815, 0.565565450071621, -1.678682670550626, 1.0784679479903758, 0.4973843262134003, -0.21812386902214387},
    {0.10673101560244473, -0.5100252791718539, 0.09062166300880359, 0.472485390065693, 0.900171226458516, -1.4009774944236866, 0.23771261945216365, 0.6150021622474854, -0.5324408687730389, 0.33297739409254634, -0.6707600174480237, -0.6166764926301997, 1.289238092177091, -1.3533843617523447, 0.8168559116996181, -0.725431597658426, 0.9276734040297806, -0.060503441319113865, -0.8816396045960622, -1.5679304664154412, -0.6793950055859533, -1.0931708874384838, -1.2317161550428133, -0.05722186004289082, -0.3171824925412311, -0.7060117743065369, 0.5315360666403258, -0.9424366355856579, -1.45412047485405, -0.07193819195081816, 0.8957247869070332, -0.8538944058621327},
    {-0.6726326882274616, 0.2804668203473824, 0.04429965209650198, -0.1914439910534745, 1.0150630593091, 1.3690013802797827, -1.1743303297651637, 0.4644235557502737, -0.5521068989698876, 1.9219404602811685, -1.6674127097272695, -1.143282415409729, 0.11196364506057009, 0.17207045415350558, -0.30270125545321636, -0.7591532416776886, 0.8169469909880402, -0.6193612335973872, -1.350751357501805, 1.8228941414795363, -1.058280104867266, -0.024978847694480905, -1.1011758702069792, -1.4781322501960978, 0.09515904475823168, -0.3065593601582918, 1.0880910310141974, 0.6513767405841863, 1.6397175340002628, 0.1906411793016523, 0.26795169167170607, 0.27285191044833673},
    {-0.4176681157912771, 1.4987436518871229, 1.2259267696631841, 1.1906326331152994, 0.8869979717101827, -0.31377696747417855, -0.5120384817873926, 1.111983035776201, -1.3548796801264265, 1.3822523108032916, -0.48904093915177477, 0.32959711134673253, -0.3991383931114267, 0.7869612024949246, -0.1720259906499127, -0.41165211346994013, 0.9968063630204445, 0.2987586610384151, -0.80064581850996, 0.5451017401979132, -1.107550908968886, -1.492803090882349, -0.04949726329626238, -0.302001727464644, -0.4382678083968042, 0.6168485247301947, -0.16097632812712562, 0.16331042875666332, 0.9782606587454994, 0.5435246314310095, 1.199507013083231, -0.1330306763246775},
    {0.9512897465884578, 0.7164358466753196, 1.4395586418331174, 1.5430884791808663, 0.18554202749209042, -0.57958032353222, 0.7209129952438744, 2.0649666554247217, 0.42671815253612294, 1.585668836761835, 0.7791338461485324, 1.6207272623500726, 1.6217690602887385, -1.6669319158137623, 0.9608212715407516, -0.5616894943254501, 1.268926995287972, -0.02810478439214987, -0.03354219984529923, 1.7763577510624609, 0.5278289268621689, 1.5696484429093303, 0.3865022530103257, -0.31519249647846126, 1.3543171304109505, 0.017562253447910178, 2.192589621946207, 1.4314218431444354, 1.4131474930333239, -0.19482081403946197, 0.4155924712885104, 0.8058684875448684},
    {0.9023897428193346, 0.6186533382299787, 1.0023026541642543, 0.9940234072475298, -0.18931261987517833, 0.9578076929156801, 0.17124957977785424, 1.238883362301299, 0.6519694470895712, 0.533273948262102, 0.7506064394439921, 0.19183435261884116, 1.8316026633192646, -1.6224548780381045, 1.2674998602377863, 0.6207879935817852, 0.9237159343596338, 0.45959020125605166, -0.9068830945635774, 1.073108658301527, 1.417635196708515, -0.42834120112776286, 0.5924984024833488, 0.22806874467424273, 1.4167682238399233, 0.009014541491568452, 1.123232150730868, 2.097793085899845, 0.29674348908312637, 0.7824195171543955, 0.8202002710442157, 0.42633292636829434},
    {0.39165328882550715, 0.4177602220709794, 1.064568837759154, 0.7780252508895629, 0.062107389067848344, -0.7925306199663792, 1.6219031456251523, -0.31886130117398576, 0.9263792007237601, -0.32394913860315305, 0.708479295991976, 0.5167054404988406, 1.2785086367078942, 0.46183862522746466, 1.6340885773707554, 0.6665379445006894, 1.1871919916459115, 0.7633863032184485, -0.04887971998055592, -1.2104773349615718, 1.1069091878366721, -0.7848342323583851, 1.2616824328470575, 0.3405457213359994, 1.2771328862555575, 0.45292794238692313, -0.4758775348714139, 0.699876115799138, -1.6425789834681683, 0.7163363570466653, 1.2362521265149504, 0.29982971400667857},
    {0.3670936883117263, -0.5479397963209445, -0.25321943723429036, -0.6072100947295838, -1.0144269569636555, -0.8526256067244972, 0.9133903315040545, -0.3530983021073796, -0.1952631674178979, 0.7997139888661642, 0.6748579131067349, -0.14261522752591696, -0.30824503823425287, -0.05909339647786188, -0.23744614462007052, 0.8076848645284848, -0.4233266560442418, -0.34824620898706143, -0.05330261508307833, -0.9271212662784232, -0.08889637023884006, -0.49964699220882725, 0.5121919470141407, -0.007731143931619236, -0.19683949962978356, -0.7223988460552403, -1.1025850295221105, -0.9815293085143496, 0.30317548124547483, 1.1143116741242294, -0.4565132530589156, -0.7483447702613147},
    {-0.20873702878393108, -0.5267545802602382, -0.5015787800355658, -0.1951964449616791, -1.3483464542866332, -0.78411891712995, 0.6537970329397101, -0.06532203441548244, -1.6011013918527386, 0.43783608774621446, 0.35571152308252263, 0.27600125039594064, -0.9262375132098267, 0.17410268081662095, -0.8194355821013195, -0.3331724047488406, -0.4123817123265717, -0.5478177611343749, 0.2545958637774906, -0.5672225957015248, -0.45065684239128023, 0.33817548738511893, -0.7863234365854676, -0.4590223483934038, -0.23532630709355598, -0.0129908113683258, 0.23624236018797515, -0.3366419887501131, -0.3314249041336689, 0.3720500632926337, -0.6200854490512628, -0.9214817200001834},
    {0.2767171332970245, -0.05879704865906316, -0.29245213269860526, -0.39091024116525336, -0.04216829841734441, -0.2221686191536453, -0.43827726702919856, 0.0814465409704808, -0.7594251918455975, -0.6729878213918824, -1.1045681116911075, 0.01383256834926404, -0.7106263263610981, -0.43530689591027116, -0.2564239778341677, -0.530579352975858, -0.424770316467756, 0.3254923620793769, -0.9356603336595084, 0.7699155101234997, -0.3672160829295531, 0.5271156199953245, -0.8571805912813484, -0.6388008342217206, -0.30863031531366286, -0.19364243854410554, 0.8093443519770497, 0.4379670567157711, 0.5505479993707428, -0.7265808744554934, -0.2424165853892169, 0.3577768279687539},
    {-0.46908834487173695, -0.5125737995726607, -0.5879500108701355, -0.8171739246814183, -0.17238926066737467, 1.0848496355275972, -1.4692682778682489, -1.0222924159956615, 0.14917048697814067, -1.6011023025505788, -1.4528020217215853, -0.07218781380442932, 0.5725381143550523, -0.3914589488479036, -0.8450307781244996, -0.8051016453905219, -0.4182018545307969, -0.6940614527693322, -0.7161885140670401, 1.217753488242288, -0.7217884022596734, 1.1532268370575565, -0.38438053591149124, -0.7030497509471034, -0.19161572639021696, -1.0367599243286039, 0.165889735773476, 0.160626271057007, -0.16752186896060095, -0.20713498436511849, -0.6605585647604267, 0.06592823518802964},
    {0.11242057287753233, 0.6531479654146612, -0.6579790235394611, 0.20029624742399582, 0.8615488475679153, 1.1703458563713838, -1.2522066574583064, 0.41229856893367034, 0.8467174133763788, 0.0032845756551949695, -0.7710901910025392, -0.5452878767615564, 0.6199800175191501, 0.5535933290652796, 0.33536187217754415, -1.047301177075871, 0.8672070991624458, 0.3555116785941179, 0.777530218800015, 0.21211376954269912, -0.4827939030422036, 0.7742476737877573, -0.04594942917250469, 0.9770599615104986, -0.060886737971748796, 0.2833691928685732, -0.12163233748644967, -0.512854334262412, 0.19126768759818247, 0.23379157509952603, 0.1296996135420168, 0.32136174311854326},
    {-0.3375364114504092, 0.6016092165172404, -0.1260937273527496, 0.7041025951636293, 1.4221809071485816, 0.6250573190250711, -1.1880073640742157, 1.2984888520544857, 0.49365385336665335, 0.6396008987952723, -0.5140802348795236, -0.357939400759151, 0.2754117112720989, 0.882419663963146, -0.23802360315581508, -1.0554212596744004, 0.21827163261875296, 0.23962468650325136, 0.9809099531654099, 0.5142981573181268, 0.23139022781913204, 0.19079645615581609, -0.040964318476326415, 0.6243801202048648, -1.0220414552177841, 0.11173178233497749, 0.05636881692132357, -0.5418802014805958, 0.7942084417169579, -0.5314227006925819, -0.466983224328996, -0.3231407378892823},
    {-1.4847113867379194, -0.8929531294511144, -0.8377209531797778, -0.7444683076028243, -0.7339623339392711, 0.28510939180117506, -1.7141899242843732, -0.3484896014096671, -0.026422912598030347, -0.044085865190668636, -0.4187798489659812, -0.4500646056901992, -0.9363455041198858, -0.06281854959089703, -1.153022190032103, -1.2687836937476789, -1.4166246311858757, -1.0697393624585132, -0.2895128802708191, 0.14939907941993993, -0.9306415483592421, 0.1508555092178062, -1.320065466577933, -0.5231457251084051, -1.5100186795385007, -0.7227409452939249, 0.8114408038989159, -1.062058058445192, 0.05044263839162104, -1.4358464172904513, -0.7802635957962211, -1.0068920168503201},
    {-0.23253238777897872, 0.050675832506612756, -0.18658951779537686, -0.4262313569338153, 0.2061480609736529, 0.8130930070315023, -0.7292437882073326, -0.38142849113123506, -0.003405013704097696, -0.33486059068271695, 0.09319496537045534, 0.09201791016105752, -0.6655485929271128, 0.47629985653594087, -0.24648041022641654, 0.5506744408439896, 0.0732108378860305, -0.5133497545500657, -0.10300479070649461, 1.10325974779021, -0.5489205083130696, 0.010907923785383055, -0.5961764483483059, -0.26711851333183106, -0.24853577016754624, 0.0025926678587112266, 0.8253489883918519, -0.8800596048435217, 0.2929307713573942, -0.8009862072634311, 0.4236311000122304, 0.3828530577287742},
    {0.018265936978289564, -0.8118072095644316, 0.7258086575189439, -0.3762616446533618, 1.211359318759465, 0.2975649739376971, -0.0610086832320156, -1.250548538906478, -1.5932603749259793, -1.2849715442713343, 0.12778703623752358, 0.19468154710235747, -0.32375673174612407, 1.6901458399857874, -0.701645696868381, 0.2565943783151941, 1.1280391599619175, -0.20590632243462687, -0.5583194184823066, -0.07313525459998417, -1.0181657838517002, 0.08659171509540123, -0.3362259952073731, -0.16736003633194121, 0.3703134918980814, -0.487092271642746, 0.15192564067809858, -0.6838670128763626, 0.9879780915806355, 0.46119092946706847, 0.24491722898215398, -0.1039777125291038},
    {-0.7483247907046207, -0.46859904870507624, -0.2055472181565019, -0.14753777459338627, 1.4772943039071373, 0.26244228568683775, -0.5077583343889763, -0.5562549961011551, -1.2558438165934316, -1.0881423647433255, -0.2953633395160334, 0.11730135039066, -0.11702581361481858, 0.5213396525566549, -0.7157691394376676, -0.04326174800341859, 1.3326646446941155, -0.4314776256724128, -1.122029074696959, 0.02431099898546649, -0.9549696291720255, 1.8244858763792446, 0.6718814558752166, 0.004565358997604471, 0.040159266673649684, -0.2598369444505591, 0.8586075250648635, 0.7323281303555855, 2.1006133202274166, 0.5211411413198626, -0.5318367240384645, -0.20707624207956998},
    {-0.43353528132230107, 0.505037783859718, -0.7437421809249407, -0.5825789758760784, 1.0920601870149123, 0.01692005051521244, 0.2863767974894375, -0.29676136804606584, 0.1402932783493289, 0.5802081275393522, -0.2751275940194936, 0.3270350016354714, 0.8131699568511603, 0.5748522352089764, 0.45647476539062265, 0.32522534826905264, 0.26708541548072895, -0.5530972014321366, -0.5575461191605655, 1.1098107128423387, 0.5124989643928649, 0.44526951161589745, -0.15607185281963093, -0.08043778849187683, 0.4565013647788589, -0.14320434143002717, 0.045118550107408416, -0.01836764636163913, 1.3392866110947483, -0.27392578960331154, -0.5709752889065494, 0.7383982931151541},
    {0.7250562486346368, -0.2252386332157701, -0.724575240214452, 0.4411807326422183, -0.9007005172205618, -0.6971264958056808, 0.7746650087715294, 1.0617431423838064, 0.9295180594824395, 1.6017002157193438, 0.8658688443456587, 0.11082085975399682, -0.1316053478618463, -0.8259185565861024, -0.15524387916843074, 0.31348784768821586, -0.7122021880534931, 0.09835874167441153, 0.09349261765730857, 0.3003738227961267, 0.6631098241636493, -0.9463358999644498, 0.1452801233114219, 0.04230708910512187, 0.1514459377371769, -0.2440712611280516, -0.19417038558979868, -0.08392469798982757, 0.0690884205356881, -0.02007361888049535, -0.26560859044081514, 0.39677886862158374},
    {0.21613668471291195, -0.36359249925763315, -0.631775909449237, 0.1563156732502239, -1.1796339714229327, -0.8890346807202179, 0.04273153049405542, 0.47411347663887266, 0.38682951443383684, 1.355212720193501, 0.28168495945467825, -0.3366403689188869, -0.5492443171150216, 0.30696467737587135, 0.34266713518395053, 0.1721288205829788, -0.35187065067381496, 0.1717472619707777, -0.39906704820032063, -0.7153079865646609, 0.07039735174621221, -1.2875355795319448, -0.8239982247779631, -0.8702489852285625, -0.0681585059317545, 0.4999356384463464, 0.5742774197783136, 0.22606696285923275, 0.385699861201677, -0.3142472868350083, -0.4977168004177165, -0.35971925525979315},
    {0.4795749211906502, 0.46111647288282875, 0.5614429488705944, 0.2526303866149472, -0.553807904017724, 0.41391774757284994, 0.4378553236682156, -0.26236289813846614, 0.8062063030051855, -0.04854797453849817, 1.0019919079180308, 0.24482238384300545, -0.2757241412323329, 0.8214222068119325, 0.388680107282498, 0.7762841383101199, -0.2684389133718515, 0.7741845088877906, 1.7055103628603556, -0.7491940812385965, 1.0660456615596634, 0.7473997756196691, 0.08951264619239405, 0.2477633388036378, 0.5171069415545675, 0.7276083840522477, -0.4632876271300389, 0.4959154214123366, -0.05926375310669177, 1.1414446485715004, -0.3854994261835654, 0.07719485913303331},
    {0.3640756584794224, 0.3134230080340185, 0.11036321592115597, 0.43316090292867976, -0.14227218956581664, 0.942048042324716, 0.2443069576094794, 0.4277968979224315, 0.6308133174796321, -0.8259629404992632, 0.5826481115853055, 0.0363128423626637, 0.5276026165211534, 0.7599549733599283, -0.21314369737775832, 1.054322092368441, -0.6657017259426302, 0.3560016177962199, 0.9491065433900118, 0.3359117341157084, 0.2836855414725676, 0.7140303266473669, 0.3456682754893645, -0.19404997095544374, -0.2066968329226829, -0.22352173333933198, 0.03237264627051559, 0.2777509299413125, 0.2780139817159904, 0.3216483913771521, 0.27427577494706296, 0.39009862288737257},
    {0.33561529431092174, 1.0350305513128486, 0.05970194635748797, -0.48224744209904796, 1.1493074076089653, -0.47556171750166665, 0.7914217041785983, -0.5779282512778788, -0.18068908101831305, -0.4456747461133829, -0.04561155845441364, -0.3367647698120532, 0.053466086885010713, -0.17427107677277956, 1.1785832638838523, 0.7691032157758739, -0.5944442148707991, 0.5122074810603687, -0.03815402217043155, -1.2450011082420784, 0.13026042016765968, -2.10228541856955, 0.5481677474667311, 0.41437535519598356, -0.0926774372570543, 0.8635866319758, -0.7702227009799445, -0.21213453497032547, -2.2675006906502917, 0.5154762318329963, 1.2941033081483122, 0.33660442820006137},
    {-0.05720082575763441, -0.13163297480255834, -0.9222123883304726, 0.030933219281819472, -0.12565743918655442, -0.10742877718200125, -0.1274930206459671, 0.9543485747744028, -0.12184361245541811, 1.4355339285365614, -0.5307652953955528, -0.5497835222993118, 0.41001101547101926, -0.6330562559436629, 0.2493881912962762, 0.011889911801674959, -0.7936157439122815, 0.08923532041053342, -0.20924676862978137, 0.7483684468898308, 0.24830765978672173, -0.15728434940409292, 0.009966202216538352, -0.22864068777744775, 0.057720614399191066, 0.46518075768552536, 0.1564150625313019, -0.09304504558668912, 0.8396261270921054, 0.03897735705793523, 0.04267905451253183, -0.4627783567793036},
    {-0.11893030663665541, 0.7833916681690051, -0.40963834803780497, 0.0028510874079569573, 0.16442778772228608, 0.3360237189029795, 0.839089140402504, 1.2073795926603512, 0.8150837819032614, 1.6786417938761915, -0.2220623344491148, -0.5507305653315371, 0.3798634539423154, -0.2555870065406498, 0.48701890776480194, 0.18242510170909113, -0.9456392703438216, 0.581880411580949, 0.3225658215182049, 0.49921864319864845, -0.1895014678638165, 0.2572644153773236, -0.365764372023206, 0.27994033182774747, -0.09720758702421892, 0.7326044080382991, 0.060859947002036126, 0.16211622636014134, 0.8853185971469325, -0.6656617568672509, 0.15423083792487338, -0.2855677711980134},
    {0.2532550549158826, 0.4338279760647744, -0.13191401459374344, 0.5004658399978278, -0.11023089605641168, 0.6063154437492881, -0.22320883031921446, 1.1012261926729734, -0.38992335975879916, -0.421008636996778, -0.013051496791612702, 0.37745962144089207, 0.1613554472107835, 0.6977945107937213, 0.6109289785150349, -0.29160217013176487, -0.034899215254002316, 0.08313794313048664, -0.24305417736395243, 0.9425296901362908, -0.030325593162356338, 1.3538674453250426, 0.22758699321732326, -0.048222880462777, -0.523797149191868, 0.051154963216356736, 0.1053105812087533, 0.11064306519847635, 0.3666897202456902, 0.1428966632594047, -0.083185720474586, 0.08369575140354178},
    {-0.526277414957687, 0.005388380667851983, 0.06880440506782402, -0.0272563240533243, 0.24271595911564298, -0.15158599225055486, -0.6375272669418125, -0.8962134308603676, -0.8494382207453819, -1.036288894844151, -0.44808154095624986, -0.14897061062723693, 0.039577184529195564, 0.2880420771112679, -0.22677034422540343, -0.20144584464536003, -0.5781233633041492, 0.4198278860505548, 0.34645215527418516, -0.2097160677224191, -0.554659957771446, 0.6007830389957171, 0.10638426447291281, 0.24180459810381857, -0.24559970664162184, -0.04914300619516611, -0.7244009948180364, -0.4132994075622395, -0.8933249786783637, 0.4038097959474218, 0.545915786212302, -0.7669515324227418},
    {-0.386363623989521, -0.3279411984443332, -0.27933008600249226, 0.34269870438426453, -0.004143888207383415, 0.7468609603402483, -0.0887554362373153, 0.22621957775641188, -0.2458605183967043, 0.16284616338840985, 0.13206939522336852, 0.6186012725463447, -0.15289069338048772, -0.09307819891907182, 0.418112078980599, 0.5611803280283836, 0.6450986395041026, -0.3428523717656299, 0.7579022419269345, -0.08489254817176223, 0.29373970582874687, 1.3421579354420792, -0.1517826934831587, -0.22049789478585208, -0.2487967968779108, -0.13664809866559668, -0.33124881190535244, 0.44823134911829293, -0.6435856703750631, -0.9060718989355697, -0.4421889240334979, -0.24042796222752075},
    {0.37557513338108833, 0.3324318166026735, 0.6368156620823529, 0.06543238466283434, 0.8447592402830508, 0.6851464909078143, 0.46861981223206056, -0.7775194145076556, -0.5340898350474812, -0.4170706088442631, 0.701502651134368, 0.6408244787426749, -0.06793841358423804, 0.7083659461711079, -0.012559069293696285, -0.35664129342115963, 0.7503194259869093, -0.08649618967047903, -0.3028500522000374, 0.8615678013913833, 0.14716271265458467, 0.49992707265944464, 0.15187088493827608, -0.0013618892059868496, 0.9492739465770725, -0.54679578275288, 0.22293402957559438, 0.21216776083234828, 0.6208276812046392, -0.3449777654379446, 0.33843962345929746, 0.47398240731976826},
    {0.5756851423413989, 0.2479476542922189, -0.757078678098361, 0.2768443989556921, 1.0977492421484416, -0.2709709099912887, 0.16660678853497474, -1.202442147631752, 0.12371282440860847, -0.7572949804809959, -0.4698208875214082, -0.3306061549960397, 0.19235417224119497, -0.09743773751511889, 0.22955401575302256, -0.8345236523861861, 0.018642497951253268, -0.17993673688659706, -0.09460141156950314, -0.22150460723734663, 0.22187155589583374, -1.4323454636608437, -0.3368328755688829, 0.7062333005540301, 0.3946966008337338, -0.8301452420860013, -1.3584770735689498, 0.17156494443951384, -0.044383810371082764, 0.466692723989274, -0.14382284173642368, -0.052893721593635055},
    {-0.5025862212244091, -0.21838564622015003, 0.4960640776480108, -0.6211217821062799, -0.5049230571930581, 0.2495004439484937, -0.8267028852694506, 1.0455265859402632, -0.3699246268401033, -0.6315641096766488, -0.43580618057715803, -0.17521522381578997, 0.9139023066417794, -0.5690691752638452, -0.40120981694522256, -0.5833858425243146, -0.017614832157924722, -0.47359601363346837, -1.2798643419404991, -0.11365618434777924, -0.27674237467853996, -0.5156684244894751, -0.8584305110988311, -0.3237068209184761, -0.5539630911913692, -0.23249518443097053, -0.22864907505029153, -0.34611350269451974, 0.22186509424915213, -0.9614308252290357, -0.8230200371270245, -0.3360683584515368},
    {-0.7733280897974614, -0.9584973058131326, 0.27009343254468193, -0.3581862550632157, 0.5502278645123917, -0.8047957748471507, 0.4570204722062196, -0.139717144042383, -0.7522447906324617, -0.13017059967760894, -0.6316304504738077, -0.6552980587682578, 0.11132880819557217, -0.49445188786779376, -1.2643016194917773, 0.01854396319843124, 1.074566090873606, -0.2993608156928352, -0.18492111121012877, 0.4478317375314016, -0.1769473925327375, 0.0524001542837381, -1.1591368942334457, -0.7348490556185626, -0.3692496482310415, -1.1203482462110266, -0.3033552695213146, 0.06705762446300575, -0.23840060480833455, 0.0010599705958369502, -0.41966896698478157, -0.20397253100491114},
    {-1.080267366395944, -1.088234791942191, -0.43717651568379073, -1.0863343478965295, -1.4477701432958106, -0.8194195856827464, -0.47463762909838536, 0.9388741869920053, -0.6527818545841979, 0.056684202940677546, -1.7964067147788736, -0.37909782668430453, -0.6592609447538791, -1.4382439633154773, -1.1720318562238916, -1.3371036537537504, 0.6201039134714948, -0.6426479628027628, -0.23962603407510585, 1.303708817232626, -0.991095987232688, 0.8592154953341903, -0.2507220342646776, -0.6864469579107568, -0.8461746485216417, -1.2120025039474156, 0.6316432493419262, -0.38922409193642205, -0.5231191004371714, -0.5827352165208087, -0.38850430666276103, -0.7693263702523884},
    {0.8575123378499413, 0.28732425099208403, 1.3753070436764607, 0.5621401214407148, 0.5674754280107275, 0.8290193567303101, -0.1781102190393726, -0.2868510857191018, 0.7118299382810503, 0.6214762676564443, 0.7483884129466792, 0.8813389857566114, 0.5040651633952744, 1.0407023252346488, 0.26591934897436115, -0.3176192434765123, 0.06382563149541745, 0.37062453623252894, 1.0413275550032275, -0.7312697657708334, 0.7159328331690263, -0.7291206675739452, 0.14492851488679673, 0.350728703732115, 0.20168489851229243, 0.729761704825072, -0.1626272434172302, 0.5362979479601285, 0.839080068606198, 1.0433290559547754, 0.19804827298312788, 0.2938122695795089},
    {-1.0553957601170425, -0.8357303083949125, -0.9724243344984047, -0.2743082784911923, 0.6137007142228883, 0.6048787368074438, -1.044170847877743, -1.1088085635424365, -0.47962585027383475, -0.5240138791211615, -0.28262603987976376, 0.08789057052063541, -0.16180955725692608, 0.9454813554577636, -0.7725824358741014, -1.4913964433406193, -0.38120478069214264, -1.2126461799667243, -0.3657257173911378, -0.034422114629805343, -0.002982935479760862, -0.6814319822562246, -1.0679303954047175, -0.19632074579480727, 0.05605394076927666, -0.5307012598474563, -0.5821044096579743, -0.07810036666518733, 0.17273129955497576, 0.013050796806500946, -1.0991859711423797, -0.1609327252125054},
    {-0.5220174450726023, -0.4191278084661651, -0.629737865092285, 0.018907519025003205, 0.28810842506677287, -0.8362797095939486, 0.03013338624227156, 0.8526156808529033, -0.28012626796914414, 1.12098570459574, -0.08930903951889756, 0.3249612693514668, -0.854195849447397, -0.49097365608972665, -0.29229060024174275, -0.5362424314957527, -0.03652871437843714, -0.07744040671483154, -0.44828707605284074, 0.5653929966211336, 1.0544447000079824, 0.15766660416061365, -0.25655049225488297, 0.2459657793836769, -0.2126321521733605, -0.20403495249618475, -0.4495785085899631, 0.21471552482431833, 0.6986766431767234, -0.01804110077764582, -0.2040277398385407, -0.3684221529196927},
    {-4.454844188539201, -3.712101921849654, -4.138354737145341, -3.920622346757662, -4.1835455948812585, 1.5841921491659152, -4.24682914094991, 3.454979300030712, -4.691811239797954, 2.8747074966776003, -4.69262573511103, -3.2254726061724592, -3.606957845715301, -3.9001490140841057, -4.125498368771758, -5.30039983608242, -1.7797924693007252, -3.9696003211631323, -5.023436499074782, 3.116810573268504, -3.345067402329672, 2.154807289749406, -4.370660068172321, -4.820036617112141, -4.55313010873308, -2.061324497842173, 1.9512355285771803, -3.3736991750377796, 1.9143516712748483, -5.523784144424926, -2.145114949595851, -4.743294853755646},
    {-4.680954301991331, -2.0952137254062677, -2.6521168101875876, -3.931977851196092, -5.011932656816949, 0.33461467327005207, -4.350385762388638, 3.799584499061227, -4.551494230238888, 3.082261825696947, -4.568078705880279, -3.3426886388527146, -2.510733823275679, -3.6616146259109517, -2.6925177628998833, -4.8296338449580904, -2.3732346941175213, -3.534359531817079, -5.057033933318158, 4.314883192394586, -4.136928640209316, 1.9343562068103899, -3.915856910443883, -4.346674654570197, -4.297297293628071, -0.7361826489097083, 1.6736871345313402, -2.061452070638321, 2.421716376795271, -5.001975500696905, -1.4791381199106743, -4.573389090173912},
    {-3.4040302234792077, -3.127879136534469, -2.79772123351013, -1.8330481614936238, -1.1530671860349786, 1.5854821209815488, -3.4820414641568957, 2.5628621767441593, -2.7770738433601374, 2.13079832628279, -3.123003405310374, -1.3236115800594952, -1.9435759935537167, -0.8384658175178157, -2.539881283465582, -2.7438823392729397, 0.8938024546826934, -3.5205391013651015, -3.294605540148364, 2.6379942148277715, -0.5151064575659661, 1.873946463938651, -2.599470712267756, -2.3804250001689047, -2.976085196954239, -2.62209231541669, 1.3774427866817733, -1.6811148516962635, 3.4444847292212986, -3.208265980861005, -2.4091815142197626, -2.6830250056775253},
    {-1.999457312901749, -2.911390265838476, -2.6144450187793153, -0.5111616189820772, -1.2558425250233785, 1.8162630203618364, -3.0347354718501194, 2.6476575428248976, -1.6707853814708415, 1.031872321616218, -2.6244601455226433, -1.0955818078474295, -0.02616740443943093, -1.291068748716165, -3.003069379448693, -1.5786616725866542, 1.6917203626349067, -2.2658996318802695, -2.601839615136062, 3.360113080335688, -0.5911703303110136, 2.437504167638603, -1.4782850305579376, -2.64471132234621, -2.1015311671828036, -2.6888887953969887, 2.921678646786987, -0.9417244225985538, 3.807450991115404, -2.170792257557567, -3.1393182532989083, -1.8352837483113098},
    {-1.3903620549119313, -2.4267529379359285, -0.9204090884331649, 0.4391277726520836, -1.857651453503431, 0.056180886416539455, -1.0893382243634484, 3.10472284573861, -0.8100615919256665, 2.1807954951500528, -2.3149478674916146, -0.9287546695861926, -0.5957008853298786, -0.9083293856444109, -1.6475156512481401, -1.1428192851385284, 1.1415101076521332, -1.8034880561462534, -2.3467814400577436, 2.3885971673342445, -0.6912365907884265, 2.288965176732389, -1.8414118038956198, -1.9922629780768168, -2.2906270924104954, -0.36589466728495773, 2.677430529254835, -1.70475029268438, 2.0737877826729636, -2.431144849134821, -0.8268449446149208, -1.4522141525498262},
    {-2.230202805791107, -2.286741894676276, -0.25348307968972467, -0.5988610934620006, -0.25697686850778284, 1.0742176085811295, -2.0855635570593365, 2.443333868863096, -1.3749051300694144, 1.52138209616262, -2.5758141310878884, -0.6422135263507388, 0.756382596540031, -2.3439804272685762, -2.2233248881849925, -1.91403272423918, -0.0495165444395411, -2.43017623960392, -3.1677593068125245, 1.2247141526572747, -1.8529217116688972, 0.9802938800148476, -1.9552749530703606, -2.788351629586795, -2.0757730273834225, -1.259389369748625, 1.5391678997058744, -0.6200552370566836, 1.8980579624847767, -2.6225981952242927, -1.8361765488980408, -0.8833809932446891},
    {-1.1728583398234207, -1.2655318493477576, -0.15561183426051498, 0.6712196490894777, -1.4252592689356456, 0.6558433121614674, -0.9942730920271872, 2.1359968469731814, -0.39707405131848844, 1.6811762800562697, -0.8811134418692167, -0.7537261220734066, 0.4110636098078922, -2.1456262146346177, -0.8342795594853601, 0.13614237782766686, 0.36261400278960293, -1.3048134739176835, -2.9408218163562676, 1.4274043618987702, 0.6886715128605215, 0.8477585507073512, -0.00018568075168949344, -2.383877185476282, -0.637345583666876, 0.442472250451786, 1.245539601611405, 0.8176081164523736, 2.628691227582976, -0.19602781808291586, -0.5032128052963681, 0.4697409186525914},
    {-0.9978679693034698, -1.7825897185916655, 1.2541063590255743, 0.4149001482188205, -2.677963153430821, 1.7154103562830607, -0.7787258301932632, 2.944382473260328, 0.1773230768383733, 0.18799925250877766, -1.335552007390265, -0.8174977721451748, 0.8716857841665555, -3.174210904347042, -0.40967941620169057, -1.5834539907253427, -0.7097381606768609, -0.628107230456337, -2.509711213285338, 1.6458850626458323, 0.3986147478047399, 0.8789068862294231, -1.493564972369987, -2.027627271847193, -1.7675267614920203, 0.29598412457814205, 1.267731093021907, -0.6867047400229502, 0.8935600303140473, -1.7099608698201436, -0.028906818335861173, -0.3818309540962967},
    {-0.6230833402572178, -0.9421999268632146, 0.5253583658088904, 0.1387020448846168, -1.2159599816632563, 0.9333446430125172, -1.221354209629037, 2.5602633206133882, -0.9416472190305213, 1.1095459875904825, -0.8838921993534371, 0.25184523667203296, 0.30999917434230045, -3.842693571078401, -0.7144795588500908, -2.533631948803626, -1.5359744113136318, -0.7567148816732454, -2.06133204217286, 3.024034111201144, -0.47357269737071783, 0.7778195881592338, -1.4230542790710223, -1.5245854471147062, -1.156910697242294, -0.07830479990257318, 0.8459872169252061, 0.06948246887145054, 1.0679443220878222, -2.371189019132565, 0.214098310546164, -0.9354962640259532},
    {-1.2645236005341076, -0.41411142605362683, 0.29916894796613475, 0.10321236588843219, -0.07843120003996024, 0.5795309189206737, 0.38975197673461043, 0.8179007609673006, -1.1065233023075818, -0.06675607662679738, -0.5495947095801984, 0.9588414420394553, 0.5145809426869219, -2.03807111915349, -1.5938536103404515, -0.8895042237010349, 0.29381028429631606, -0.8121929405667427, -0.957392798412717, 1.0866283645427042, -0.5666486461106426, 0.2822533694664171, -1.011754243361307, -0.49886479204793605, -0.4674919473563978, 0.2514580563488983, 0.776823000529253, 0.3266565836859074, 1.1091190069561414, -0.5183690148305686, -0.028233439051138832, -0.0001187693369206388},
    {-1.0461222566263024, -0.3420930449869074, -0.17219313983497117, -0.6432844414442499, -0.854483197149415, 1.0395965884792115, -0.39307702304981396, -0.631028476831298, -0.7589028412013201, -0.12685655961968134, -1.3252686619497775, 0.13341221745687765, 0.16871750598024698, -0.0938101224640552, -1.1319987644104605, -0.36531665833983, 1.7185524727734867, -0.8390365016502763, 0.14118029154677764, 2.224275468571609, -0.5543829240556326, 0.8008822344773843, -1.5220353924689751, -0.863340363910829, -1.724134005997119, -0.019177026548038996, 1.2001646324127777, -0.5019114102490656, 1.6337397712036181, -0.9976537630547875, -1.8401820917685867, -0.7419689397833603},
    {-0.23196479979365958, -0.8887928132511871, -0.5508729046596826, -0.7096400569511394, 1.0585903035191588, 0.35529151730073605, -0.8696925492865611, 0.8956532572843741, 0.3323733914747397, -0.31939199125706713, -0.10378093965171399, -1.5949104509547534, 0.460697886901056, 0.15584180833089753, -0.03802305546180062, 0.2922258274460182, 1.559200907257735, -0.27613993103167456, -1.7285090573193902, 0.18866057781284545, 0.11182075835486452, 0.12874672323905384, -0.6994850476602815, 0.31514846789583295, -0.5584748010898437, -0.2999978314822843, 0.07934188010762183, -0.5843220361396452, 0.16151916223012214, -1.1541348144499064, -0.21352960836970095, 0.33796372001924035},
    {-0.4031277473455762, 0.11308380716991799, 0.3945616598284519, 0.5986124076559095, -2.051967742517985, 0.9526279889947236, -1.4005023192484234, 1.7360966907892577, -0.5962787794991129, -1.7646909354983205, -0.5639825613499329, -0.1446789069617625, 0.155230245826906, -2.312658783192827, -0.735061865928591, -0.7061786089292322, -0.7691138602472308, -0.2507238874267493, -1.667479540440683, 2.184982834441239, 0.576469226031053, 1.7489031924006282, -0.14362451636856371, -0.6015204658175952, -0.3962793002985283, -0.8756747668430966, 2.0127383652147444, -0.14893584966520287, 0.015578068324188222, -1.1905370184475148, -1.670694374990361, -1.102186543813891},
    {-1.0893746294134334, -1.8556025556895865, -0.2858815615149713, -1.236263480288304, -0.9474625725450554, -0.734623887632241, -1.604808156188311, 0.05886193917979991, -1.0393261604954829, 1.2058364025878845, -1.0181930973226254, -1.0368401136688077, -1.1832414851804465, 0.4529700925560193, -0.6518593158450507, -1.647395306503066, -1.7462697702102106, -1.7340390800974763, -0.8951278495576, 1.1334581983636103, -0.34985686185378173, -0.8431955651550758, -1.40786701063836, -2.5606566533995023, -1.3057829680789172, -0.36253838512774533, 0.5616600865636986, -1.4476477665932839, 2.080750350930808, -1.288463485640941, -0.7299823397440097, -1.040176759760728},
    {-0.221439553599549, 0.1764002195558209, 0.5134226380040857, 0.6902825647812502, 0.2470608456586671, -0.22495210718101044, -1.3695276096847497, 0.7964593515378906, -0.14678598888643782, -0.691903388194138, -0.5090308918434396, -1.2789407970140483, 0.8346877608337783, -1.8164157828755334, -0.7200065081748183, -1.0160773288188556, -0.8350232940013983, -1.0875826149853232, 0.4081370746079047, 0.009539700997113208, -0.18120431670115178, -0.6649664068495843, -1.256368050899913, -1.203619059489375, -0.45474867717304107, -0.8864422359989899, 0.420623060435344, -1.3074688632509206, -1.5186919847524643, -1.1546314273990292, -1.183478253322895, -0.5746819622310669},
    {0.3579857893713676, 1.0266998693036826, 0.04616552650241375, 0.22032667615921425, -0.3185256630805167, -0.47569231747527524, -0.7367370030715689, 1.459595135709911, -0.8220636263883395, 1.505436883544122, 0.2171614327830165, 1.1302591457585036, 0.30630458317137516, -1.4751834594562203, 0.31501712675636695, -1.9670102781197691, -1.5036996215671319, -0.37664267304996235, -1.0320443562761985, 1.2416991386437515, 0.3045119653453113, -0.24137999903362134, 0.14798299205708076, -0.7886171576639951, -0.4809988756145028, 0.4719690328545033, 0.8320821522977723, 0.14481210142672848, -1.5425243734477159, -2.017818006346758, -0.07529530659815932, -0.6519123368822042},
    {-1.3054260050999353, -1.8080109194146763, 0.037493618158411894, -0.8512283016988531, -0.5801824175760406, -0.8128117549929624, -1.3331962140868314, 1.0556232313775784, -1.7933207372276845, 1.0815223582285454, -1.3956620503318167, -0.3955111696333422, -0.4618664289059593, -1.4799798987665946, -1.552839324824343, -1.8622961754162441, -0.8790804852807818, -1.809265839215169, -1.735523968230309, 1.5511437737432159, -1.2881745834927705, -0.9558904367571106, -1.7381467162464106, -2.3441845451740724, -1.057577746479851, -0.3240716614885476, 0.8054792686608676, -0.332454369217765, 1.0943454612428496, -2.2571739708390695, -0.3125671249090813, -0.23176209243207543},
    {-1.3502705469595038, -0.2473531449722405, -0.837460687294346, 0.17908235584498433, -0.6287303694726317, -0.5803722918368408, -1.3161006434772948, 0.9265375741436799, -0.38253817760361175, -0.14769419345440943, -0.5811799687841437, 0.02723413277035491, 0.6476826470843133, 0.48251075040334246, -1.2220515738430404, 0.006919839041829738, -0.5637882605729054, -1.9171363983190064, -0.4237271561714451, -0.33228482516921887, -1.5929171096889208, 0.41700681204960416, -1.545839654013542, -0.06997434058269784, -1.3560753013605216, -2.0375219317129316, 0.8241427897072667, -0.8472486119551607, 1.290490407035644, -1.7021074557547036, -1.1877464906943644, -0.9509880521581774},
    {-0.27070002288068024, -1.9368342849635294, 0.5241334702514154, 0.17915927575483204, 0.5352008008189312, 2.1752003378294007, -1.145115312014541, 1.222835016424581, 0.28237887885761076, 1.0368957157305811, -0.48436375641673557, 0.6335788514686426, 0.44769393133249347, 0.24236410835508476, -1.4053889963368804, -1.0338426967169847, 0.6329782184117696, -0.544938610299194, 0.6407183733163501, 1.6158338588551895, 0.732383460402931, 0.8446683742795701, -0.9398071166145273, -0.3284843337027743, -0.861658325553692, -0.6062387413325919, 2.0915663207495108, -0.5578899715494052, 1.0029070434278113, -0.8492852285337724, -2.153364079672992, -0.4869173466146812},
    {-1.7608773092202588, -1.6843165670555507, -0.8671862197196665, 0.7160297298184481, 0.9881099703538425, -0.5557533075909997, -0.8743732052779336, 0.4076596229534092, -0.006975695642054524, -1.2982978284017308, -1.288094976858139, -0.6749717970314667, -0.018658156860772598, 1.7911257657524728, -1.0040698163529003, -1.025884050941316, 1.7481303285752856, -1.2940014913106483, -0.3560104706330996, 0.5262890867017538, -0.525784019479527, 1.7035904085018065, -0.5973606747255313, -0.7197948220276337, -1.2048124863741951, -1.690898154472092, 0.11032392802941418, 0.37981691319902233, 1.3736292160411745, -1.1191428021115022, -1.8033579417616334, -0.7757745660271858},
    {-0.5308002569151272, -0.9696002754150465, -0.4930087039176719, 0.2018916586594922, 1.5548650473628074, -0.4096072365553773, -0.713391171668912, 1.3852466032809303, -0.25067510299884316, -0.9092546632581626, -0.5984076060681197, 0.3451115583067105, 1.239609516640874, 1.099530199420439, -1.2730420231425879, -0.5096625704759828, 0.9716359878380335, -1.0647266695093085, -0.32482958092719955, 1.3962530721724737, 0.01603477566274926, 1.0424888353129274, -0.4752507909463912, 0.6863324812817224, -0.4544057739870871, -2.0927890020058073, 0.9408516755988611, 0.6070851628664842, 0.8355589784755495, -1.122746702928606, -2.6406525749654444, 0.10603590398479162},
    {0.10154831358898736, 0.5327474624652869, 0.7320508495125356, 1.0257918213364308, 0.6977084833484851, 1.2678558275385072, 0.18410795411274125, -0.09807994576347823, 0.297695662256541, -0.23634626732084324, 0.36849436824608495, 0.4151156478860371, 0.15664736200693447, 0.6089112397831129, -0.060827123181666276, -0.6052793199988974, 1.513928780990433, 0.0050507969300178064, 0.4545187425062199, 1.1851938828118165, 0.5689814712825956, 0.9576869053561972, -0.41898830085356625, 1.1496301196534275, -0.08107028920693339, 0.059813421497897305, 1.3419772650317785, 0.21157221563085762, 0.185694560351539, 0.07231259073748911, -0.6585225859891253, 0.6727769002791014},
    {-0.27648079077591875, -0.3908703145310603, 0.409979004812286, 0.10548195894649946, 0.2054635583205519, 0.6124470574856226, -1.203629803868232, 0.6326190748562096, 0.2965709874234109, 0.1931548142968225, -0.025669595976849424, 0.8306937466004339, 0.5446250418680332, -0.5790335011683007, -0.30898309603800644, 0.12597719810016927, 0.9034952514804664, -1.1996180003705295, -0.3721531773089196, 0.770576389848906, 0.22153896276502566, -0.8206537397395866, -0.2318238847839547, -0.5456853504638606, -0.7298829151539592, -0.5597499754604008, 0.8181226202072273, 0.41199571996137174, 0.4594786644784436, -0.7137455190004507, -0.844025878822677, -0.015697029210031167},
    {-0.021904127341630858, 0.13894221562073478, 0.4694038213842456, -0.28631819075133136, 0.45442060719178834, 0.458634537040015, -0.3326160335293611, -0.731233524468373, -0.8516441351262499, -0.8045640796010798, 0.07947693445557923, 0.4020488034814812, -0.033957320511987785, -0.40409831417307834, -0.8898214901096255, -0.3281307838692895, 0.4299491004014425, -0.6401659967985651, 0.2412399900648648, 0.018527488589700165, -0.34320039194904284, -0.8494546258500383, 0.3045027666399018, 0.2614011744043577, 0.015744991117381726, -0.07364444340074788, 0.4416867315584388, -0.09710249264177112, 0.454764771305389, -0.29244310019166314, -0.5633469870918748, -0.4690284026545143},
    {-1.306569306007953, -1.2612927735845365, 0.4817953252402335, -0.5778367647304827, -2.166161675449531, 0.5299733174948217, -0.9134234289520454, -0.9445067616800957, -1.5810062517186392, -0.08611214725923368, -0.9503962379047146, 0.3796823767998776, -0.7258717644253033, -2.5277427652329836, -1.3765075282597707, -0.9732604489411624, -0.803172741552176, -0.06613342226183896, -0.06491866184988669, 0.894928065024839, -1.4026341600404495, -0.5570524343463581, -0.5003329142704375, -0.9428534147719333, -1.5317937536671222, 0.3137366977084098, -0.27165646548893896, -0.9236776607957033, -1.0515095851450755, -0.7720269007816243, -0.591703141668815, -1.1565244647567603},
    {-0.5762774879446048, -0.4201598393078766, 0.10033713295914311, -0.02323711323493639, -0.016966379792388873, -0.17514664846965003, -0.36300897359124285, 0.7821393721003764, -0.9205798657243679, 1.1725308892934656, -1.1104924991404075, -1.007825609676152, 1.0991660054530858, -0.7430415870118917, -0.25651803415266144, -1.074534659526148, 0.16251028211504404, -0.9302603179494333, -0.7518991961225757, -1.0749261672332335, -1.5379294442118994, -1.7657861489118931, -1.844864936762848, -0.346449037982551, -1.3745773989960473, -0.7209113429030136, 0.6430538427542267, -1.0876869649018848, -1.434865775213539, -0.6528898713322153, 0.3786315292234315, -1.4213315094041288},
    {-1.2059135809465384, 0.0006439689119484753, -0.6656292299900624, -1.4855116174455263, -0.2517368845939828, 0.37326905003371835, -1.8110730525837506, 0.5489814536091175, -1.1616659852858024, 1.1189375793622958, -2.5105930335932802, -1.8472575988908302, 0.032476298090109434, -0.23983740809762566, -1.5500016241276775, -1.3274490992839916, 0.2692630126389634, -1.6736275749763263, -2.0535728578108774, 1.2442193372540182, -2.624247983719927, -0.25108803829641263, -1.9700545276135142, -2.2568173266208844, -0.825517068068242, -1.1058599788460446, 0.4751949695633732, -0.12579118108307594, 0.9487709701026321, -0.6035318064819367, 0.24343248522315508, -0.5387774481312909},
    {-0.9050369722878842, 0.43686611840337297, 0.45166948135954027, 0.5348027209179294, 0.8258171344243495, -1.8936994767009343, -0.9377615041948539, 0.3403356175676175, -1.6043203469101635, 0.4842323281652122, -1.2432320598928202, -0.07430674614107456, -0.5812745304776211, 0.38379809718557534, -0.6115939117235997, -0.25112196517497315, 0.2953158154001185, -1.175745220794444, -0.5936730260208779, 0.3796993319936153, -1.4260632269898765, -1.6143144859286271, -0.31320799415023143, -0.9820138459182111, -0.9731409546136901, -0.5304535211519537, -0.5006695870233829, -0.9104300113771321, 0.9985654894814832, -0.32892175136501, -0.49260224981423134, -0.5648015073399537},
    {-0.43547668917733134, -0.5477086449669724, -0.15984043655366212, 0.7492823879984004, -0.36549004193371065, -1.0252381604351035, -0.038546257125553464, 0.42615611497376027, 0.38242828856928995, 0.5523069359674405, -0.6786120545952425, 0.6204110475672692, 0.591505865587172, -1.8529667352005421, -0.4679219156231847, -1.2856168544765836, 0.05035160112639643, -1.078090918496099, -1.029989122812467, 1.0643039520983095, -0.2643561801754185, 1.1312281612181008, -0.7033460535260014, -1.7297866821280614, 0.5825770187576113, -0.6974069346890974, 1.1582763668321407, 0.5620305973025653, 0.4838655579285684, -0.9671697662613898, -0.5995926911077425, 0.019758147886116836},
    {0.2911766891924519, 0.2998789526921168, 0.32821775212954674, 0.27378762915072496, 0.19217600643820765, 1.1102150735781704, -0.06371965953388767, 0.05518259268658676, 0.6469710817548695, -0.23489688104080042, -0.11220795318326417, -0.5437453328022817, 1.2879303711647034, -1.8269238472220677, 0.7225705698261546, 0.3704619573331103, -0.013230682414739372, -0.6628272644386743, -1.4810413843908032, 0.5916436066399455, 0.507260119557368, -0.8488056581255528, 0.4156927694556147, 0.18417947795964534, 1.100210784815537, -0.7121072898756692, 0.7685860101687866, 1.828467023195373, -0.30428230408074824, -0.11092748242420537, 0.025228459912688978, 0.03617521741269354}
};

static const float b1[32] = {7.446838448089249, 7.559709181720537, 7.589629952409594, 7.464482139977385, 7.530534989619561, 7.486340947044529, 7.352379053702987, 7.792356442359364, 7.429617333654022, 7.613065801078073, 7.437445951734535, 7.413513135840993, 7.573573377032099, 7.3933239591551185, 7.61348853579596, 7.439178488406275, 7.878606503785525, 7.373019095571774, 7.370218516465545, 7.780506236631913, 7.399383029422575, 7.62997704700649, 7.301784715334441, 7.4490010772595285, 7.419598483861571, 7.636903796117904, 7.3855147447012905, 7.243444085309318, 7.829195103957023, 7.220196773505496, 7.620373205961953, 7.269932540253025};

static const float w2[32][16] = {
    {6.766908278322702, 6.3656735708986245, 6.597024027096101, 6.17476807904552, 6.7620440992477375, 6.382231273500091, 6.42698928328821, 6.1569306485992366, 6.5056505252791235, 6.732474286136107, 6.843715712286933, 6.435978743538856, 6.6308485795820005, 6.148025667517127, 6.755654858850646, 6.626378249883802},
    {6.801630137249817, 6.470169317785489, 7.0357579121657094, 6.309736229655778, 7.000380175039744, 6.529795077841973, 6.676719167600516, 6.232871328417547, 6.698708553737121, 6.771405010888737, 6.77888616636884, 6.818190550844343, 6.754860314151331, 6.153479583644159, 6.925401482340002, 6.5135842799612735},
    {7.175109085719118, 6.728442363115087, 6.876609202438527, 6.419202967963412, 6.9791024721046195, 6.5963323307502195, 6.552906296582742, 6.360829239635864, 6.985598115385072, 7.079894412754544, 7.146737375622084, 6.907746010016012, 6.563335186909189, 6.285490233017477, 6.557838239024322, 6.820699148031348},
    {6.806198202701841, 6.676371274236126, 6.905029171755982, 6.426458311644496, 7.044722535142265, 6.508754475137514, 6.44654543816958, 6.391340615739096, 7.1338556540974345, 6.991002207907888, 6.744858364658373, 6.581726413037132, 6.558981176144926, 6.578433383430671, 6.9083612081753385, 6.793894284377149},
    {7.0795786394929445, 6.356503154164968, 6.934085282630834, 5.986007840737835, 7.14913808731701, 6.899399820373063, 6.814051920670657, 6.674408088736816, 7.224710529895841, 7.030935168507108, 6.816678237026993, 6.918969322913229, 6.92069886440811, 6.492082376713024, 6.738369930337386, 6.885791916344604},
    {6.35235122156794, 6.482020855609602, 6.604705909828182, 6.094320617718163, 6.716826162680767, 6.982685758799578, 6.626534256331818, 6.359556042637408, 6.524457184568185, 6.926846053521931, 6.562594635737209, 6.566607615576088, 6.406166714170974, 6.6210692574461865, 6.83201124754426, 6.807251330966049},
    {6.8382346204063555, 6.569123246990608, 6.515221804768234, 6.025013681091372, 6.8492406191685085, 6.9749473887163855, 6.594914530942596, 6.011236950601333, 6.988929084839224, 6.80889511208644, 6.210208184489228, 6.861346473868869, 6.906221163323073, 6.497666401928622, 6.859366341406057, 6.366118338015582},
    {6.6591817104862665, 6.9411216387795855, 6.811616597663817, 6.0388640193097896, 6.987700761546572, 6.830466813808506, 7.031777489132366, 6.533261513373498, 7.091274718231834, 6.701862694683531, 7.111062400793666, 7.1751548380927535, 6.799496586892128, 6.450836026928276, 6.695771314790776, 7.093632931235839},
    {6.833771501482367, 6.500057928238143, 6.332794862906055, 6.397884753738415, 6.380236854116577, 6.7466996158907735, 6.5509669742962595, 6.085146810752273, 6.830827805251469, 6.844921214553418, 6.8466654291000735, 6.8433592921312485, 6.945218744048009, 6.310238714744452, 6.648593909849902, 6.567433804049601},
    {6.917756467059654, 6.915726998791042, 7.259720522265194, 6.814913523187132, 7.164108490320274, 6.88393143015366, 6.76792480649696, 6.789137931223279, 6.9549388956650295, 6.768796250070443, 7.101460467250691, 6.9710235128721765, 6.868005448376557, 6.959653242350054, 6.705291452228309, 7.347844276373713},
    {6.696461706068146, 6.329464195383085, 6.676385961737014, 5.911829266731846, 6.840345610021538, 6.758732407344267, 6.740354082791968, 6.111248342308945, 6.575208119880687, 6.529707995629177, 6.569078698191998, 6.5418032453932495, 6.473632213996537, 6.237030267141479, 6.310747361655893, 6.269787577901854},
    {6.451930630861793, 6.903047716395697, 6.415449827685965, 6.378245419918221, 6.912502062829184, 6.51904569083522, 6.826730492407328, 6.3423407829917755, 6.517077911476761, 6.831725896275253, 6.765005657694455, 7.119850058976944, 6.737500217141131, 6.052741642814241, 6.673041891317397, 6.853141725312561},
    {7.148509175408566, 6.4641990311681266, 6.802836058542901, 6.256404375117079, 6.9891471816795505, 6.6435622593496015, 6.951949552053658, 7.080239660637759, 7.040704231914337, 6.731296160767087, 6.582573908178735, 6.604094908507568, 6.800284143452975, 6.789366596125191, 6.499399392541812, 7.01931725098969},
    {7.457077795676761, 7.296877128080908, 6.985044644532749, 6.917157608078306, 7.2611158632120985, 7.653658577922786, 7.038315932471691, 6.547934499773133, 7.510743687249728, 6.876649848303751, 6.855748145528946, 7.549564192286313, 6.914999040538077, 6.672265403270034, 7.175685839789553, 6.992753358827112},
    {7.190427776771881, 7.05344597774544, 7.110656941831232, 6.095059747520258, 6.718093664555946, 7.113693833855011, 6.674308253905082, 6.50498020351541, 6.69506853667249, 7.006981001545775, 6.983716105625222, 6.988344307748148, 6.742867297811341, 6.308462144362192, 6.680315852684738, 6.4873555068229996},
    {6.340991768419877, 6.669452196422936, 6.441587343454862, 6.077892139021976, 6.442913453997301, 6.671799320389477, 6.782454513731782, 6.205271060390873, 6.774396121686373, 6.899879448956901, 6.439886491941237, 6.858923198478402, 6.838481713266774, 5.809687297856036, 6.86274654160209, 6.748862370582477},
    {7.196621249309654, 7.149147923581595, 6.962378129337787, 6.641062065726203, 6.805403152919098, 6.8413036350672245, 6.800226768206701, 7.293618811252008, 7.252597086360116, 6.926743525219136, 7.078207684544504, 7.109125953796984, 7.281090749277206, 6.383733869259215, 6.683126577904942, 7.298357654468938},
    {6.888174851905512, 6.3473654140948925, 6.418193434170789, 6.382249418686887, 7.059693510531598, 6.789825891047796, 7.054148380974396, 6.586801956257917, 6.458223433941388, 6.514016310572257, 7.053344326788638, 6.976309975537878, 6.965990168332787, 6.635112617312632, 6.978730985052382, 6.866984603171312},
    {6.713801459447785, 6.3416851623341275, 6.459661361744052, 5.840396972090161, 6.755407702393482, 6.887470930141354, 6.658801386154384, 6.026175527850997, 6.937312489194013, 6.566135011878439, 6.47104225658754, 6.7544120081403, 6.752185457941037, 5.739450185604934, 6.532310149252342, 6.626923672253587},
    {6.923618776086172, 6.762023226870054, 6.964763906541238, 6.1529180527804535, 6.708378772601213, 7.112554555371053, 6.540181147008384, 6.58480296989023, 7.2181329457314245, 6.651361586303382, 6.87781188257349, 7.255028588437813, 6.748100097742484, 6.252161617185062, 6.545556526995107, 6.986767719028944},
    {7.126722679432461, 6.934761360988405, 7.016996968165691, 6.368812890821273, 6.926800196319018, 6.515364124335862, 6.470409008957533, 6.460296107849751, 6.643506472245202, 6.90966042450365, 6.609846217453987, 6.67113422458746, 6.546464603830664, 6.478997240537267, 6.987826951260355, 6.808773855661566},
    {7.041778336474656, 6.610611336184936, 6.950942030662775, 6.194717339094317, 6.454895022420761, 6.762609204534297, 6.542240990060904, 6.641972367620786, 6.539247626865391, 6.981437726744245, 6.59203304422261, 6.805655126614722, 6.8311115342902475, 6.192579135659432, 7.053375153101595, 6.701828371141931},
    {7.021543290976587, 6.804612445477682, 6.931951186013937, 6.04313654002463, 6.522874738275924, 6.961083898236986, 6.561315011988458, 6.393865471798418, 7.000495433141401, 6.832918376877945, 6.532694248207754, 6.955652680881821, 6.681989978422338, 6.115744265562873, 6.822875283753103, 6.765272330089578},
    {6.758575366765832, 6.800403920650701, 6.663910147833569, 6.438185646580078, 6.35283006930301, 6.838681392982698, 6.772212778703006, 6.316862575178326, 6.8842247558397105, 6.812134153896984, 6.430804586951592, 6.827311000571928, 6.479634974768416, 5.964727748402464, 6.662489611640732, 6.5689547891557},
    {6.601237267736369, 6.265757191689594, 6.413818874240704, 6.170598687911982, 6.667238360172823, 6.478948147550387, 6.375467958635479, 6.241359787548964, 6.671672609235939, 6.656977419610106, 6.457821753421311, 6.655362847180631, 6.902852272150845, 6.468310689327654, 6.424397280602504, 6.570023248358044},
    {6.610612626003698, 6.785755548353688, 7.142826422291386, 6.337837182383031, 7.048136572524659, 6.779204408943143, 6.487735383628856, 6.8924594864718065, 6.5877843131882825, 6.723387363680688, 6.564183682317448, 6.733078036619427, 6.836305401304055, 6.626174341846609, 6.56175701763217, 6.467760416738375},
    {7.014584520232927, 7.089812252333994, 6.9512514523378055, 6.288941422739023, 6.712732294978148, 7.115575304023752, 6.7194029920343175, 6.595258098022169, 6.988583879762634, 6.632985142716613, 6.6954917539645535, 6.662732060832283, 6.642709740268251, 6.754669371032564, 7.13768413898792, 7.120098156582661},
    {6.708114588321538, 6.701644798308194, 6.814421648288891, 6.485797698462634, 6.923611058674337, 7.174195650929224, 6.631198541802344, 6.4557785974027775, 6.597603858849277, 6.557594678252352, 6.771570868709855, 6.931434919756473, 6.516722679571226, 6.538368778756609, 6.990118415396786, 6.574004889969612},
    {6.4789082535922455, 6.4632218294580825, 6.627576866688168, 6.03321973976731, 6.524697846189079, 6.792177898422611, 6.690722307808913, 6.3203790632810035, 7.073528774012443, 6.765553517561668, 6.962502229691123, 6.914673843985518, 6.460997822112816, 6.611163272498246, 6.85130444118394, 6.851806989026663},
    {6.684470853246452, 6.915703201379519, 6.525404011544428, 6.1120240726787625, 6.77277960693758, 6.919698098854721, 6.617986573511077, 6.6590448658923735, 6.479977321028907, 6.449834476071411, 7.136178635900655, 6.748336159649535, 6.842450321165499, 6.314090976592982, 6.530084522856001, 6.703034723044363},
    {6.8410747523195665, 6.741294570521389, 6.775794169398682, 6.3902420527001755, 7.14509667797533, 6.6806517946236195, 7.099850280653367, 6.985990603017816, 6.7911120280966975, 6.870793329220135, 7.225485457062755, 7.17559306253097, 6.941214537774244, 6.529241711550058, 6.9785788802857045, 7.125723296823333},
    {6.914765338731615, 7.026393729847456, 7.096581160787649, 6.316936649355713, 7.08395930396922, 7.012007456094741, 7.139278529564002, 6.496826864073456, 6.881523003264378, 6.751367310654526, 6.465031859487132, 6.6523345009593156, 6.497478851005771, 5.995894274690411, 7.04864182912723, 6.698849447922562}
};

static const float b2[16] = {6.439324143316304, 6.39498014314235, 6.331618408167472, 6.252806605314386, 6.456706292219262, 6.45744601468439, 6.350594322682022, 6.6037648470325845, 6.459938996087505, 6.186142862645917, 6.349795187917366, 6.425675707365109, 6.243520912397878, 6.498264937060524, 6.400321402425408, 6.326632195635836};

static const float w3[16][12] = {
    {-4.430847024596571, -4.895456199245481, -4.31275778239668, -4.252782516512365, -4.277128533272447, -4.541110649635347, -4.339671264833697, -4.920440029286345, -4.592447336821513, -4.499672682965317, -4.513406411680666, -4.619220459436039},
    {-4.497857915103465, -4.794885854127384, -4.200548688696792, -4.8172228996693045, -4.193171298834612, -4.113036013387224, -4.831264336782292, -4.959306139691245, -4.377096186359661, -3.924204114699485, -4.495899626032566, -4.46758516096587},
    {-4.975046662105239, -4.785933697709278, -4.8032982269827045, -4.577313875086731, -4.5198490711380295, -4.5562209552741475, -4.473105125636717, -4.868404803367757, -4.289164232056259, -4.773233895187167, -4.231524299780917, -4.124365454604172},
    {-3.625682607935317, -3.7789268463485572, -4.36475298029859, -4.144959483830303, -4.007842212049495, -4.2026531902303645, -4.389902070182773, -4.052051391842121, -4.184533819875787, -3.676356711204841, -3.7263880962569225, -4.284567855578294},
    {-4.289269355179141, -4.402439332116192, -4.670439556339615, -4.214855475155788, -4.550639776507779, -4.702144743135385, -4.727051758441454, -4.711736574022969, -4.402330005207763, -4.680612677800107, -4.971189881987168, -4.384946909105404},
    {-4.779930022183991, -4.505296310878773, -4.93088845595197, -4.397381159658086, -4.589836670555512, -4.587088495527959, -4.6998976468220395, -4.191752774462342, -4.368898599166015, -4.6725167189252765, -4.834549736938792, -4.3031286551918635},
    {-4.830405493190107, -4.9897395203468005, -4.698779604710575, -4.354865815101681, -4.788355860108047, -4.421732049699274, -4.335992580769582, -4.188661125100799, -4.902240857514745, -4.887203500129814, -5.031825684725845, -4.854448656328538},
    {-4.7639606626561, -4.521191429314644, -4.2107303150132465, -4.668080789677029, -4.208229077383531, -4.12899418172906, -4.782923167959204, -4.671563541623017, -4.5696274097373175, -4.754220937733641, -3.7761345155720636, -4.37427072313045},
    {-4.925665179402241, -4.825959661816659, -5.012798682449739, -4.233524865753588, -4.53714834004946, -4.848868807058778, -4.4912558095813955, -4.114838012717339, -4.244941564670014, -4.6910455958844635, -4.280443591064867, -4.719279311005036},
    {-4.027452975718298, -4.286207290356059, -4.456837263802342, -4.781369291636085, -4.879708531880686, -4.456794439442063, -4.211408354939788, -4.885520011165955, -4.746154012600607, -4.193797372519764, -4.453602375477226, -4.763869852094716},
    {-4.355806675910823, -4.7302948233333195, -4.294534467003968, -5.131489172854734, -5.022381427290358, -4.711717635819722, -4.515329178677944, -4.221641483180111, -4.114002908784946, -4.146065865410489, -5.000293158645941, -4.699219756094054},
    {-4.414020520952429, -4.617062881245612, -4.340602462292097, -4.688898133023474, -4.516501771202749, -4.261503924088714, -4.51819351680913, -4.401082961496827, -4.303097674051993, -4.819835530478447, -4.876108129302595, -4.77563841684194},
    {-4.642090195387803, -4.670003538452716, -4.30649144126567, -4.844320248710814, -5.039750835062151, -4.778269720362179, -4.3546924202448345, -4.210598193233806, -4.645060152044945, -4.894346517787607, -4.473237734480326, -4.728204256064025},
    {-4.568777717425564, -3.824912749734869, -4.149959822862493, -4.389777339315101, -4.15631350500056, -4.397232224659597, -4.091705721468315, -4.358870159130372, -4.699988961262699, -4.640948108873027, -4.084130254959348, -4.462848958867894},
    {-4.640386421421153, -4.145143608567385, -4.685407171339463, -4.267654969454943, -4.304095576659536, -4.65364151288089, -4.790649917122765, -4.48406857461899, -4.834112540959595, -4.148276980725969, -5.061669558576408, -3.99844422185633},
    {-4.3510115003748, -4.157331148836775, -4.602101340761021, -4.412643755340023, -4.457560517902855, -4.72820210197816, -4.543930546863807, -4.898888427639039, -4.860749994759448, -4.718836556497928, -4.225232758848815, -4.5106100654906935}
};

static const float b3[12] = {-2.639566633643286, -2.4785740179103053, -2.0286892789995825, -1.7864279386721293, -3.209644679339623, -3.1492862427776918, -2.9165885634686584, -2.0109459073057003, -2.554424213908394, -2.9392438527423366, -1.4167399245483259, -3.0951773365514965};

    // Input Layer 
    float z1[32];
    for (int i = 0; i < 32; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[16];
    for (int i = 0; i < 16; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 32; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Output Layer
    float z3[12];
    for (int k = 0; k < 12; k++)
    {
        z3[k] = b3[k];
        for (int j = 0; j < 16; j++)
        {
            z3[k] += z2[j] * w3[j][k];
        }
    }
    softmax(z3, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
