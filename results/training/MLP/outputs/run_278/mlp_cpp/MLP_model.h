#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][64] = {
    {0.683885075055884, -1.5482657629278163, -1.3326538720115275, 0.9283682243264383, 0.7144046484169342, 0.7204918072281424, 0.8036828511906952, 0.8949075158719528, -0.16513717813014114, 1.2958668724090647, -0.2976068831015662, 0.8831581227586193, -1.316160501418673, 1.627691896427361, -0.9805707016506469, -0.33143667079823347, -0.2535587687473125, 0.8089648343814358, -0.9294046527442157, -1.0338635247570118, -0.9046172816016534, -0.49113048595257947, 0.7342105830521107, -0.4004811718816828, -0.6718004650324232, 0.478899637645032, -0.9024551354705425, 1.3897751827126918, 0.4327623226117994, -0.504123517472912, 0.2404211699241794, 0.6070332397509808, 1.4461513438438227, -1.0729530368652667, -1.4853912069835933, 0.6552411420265063, 0.031559638276137385, 0.4697263590232845, -0.25263391381020556, 0.5408021691672457, -0.4107394284397523, -0.03897612063453734, 0.7357296615172717, 0.37144332862022084, -0.7901730761567636, 0.4353063862715732, -0.6409958309915552, -0.23768164024493196, -0.9585881995388295, -0.6559139597819387, -0.6484087023379271, -0.8776046512071703, -0.9332696438993504, 1.0074405106710846, -0.936891622947266, 0.028454035550931057, 0.16097154674790856, -0.09185866612786346, -0.17423316877934933, -0.5262232658473367, -1.2208626126878075, -0.7405481053145961, -0.7621978322074353, -0.09526722084300954},
    {0.9988512835599888, -1.271610504734041, -0.5805552481226557, 0.8034429849959708, -0.391680022286907, -0.8873624839499038, -0.4783113576908326, 0.40718316743763866, -0.497897525148855, -0.06425984820677892, -0.09002306787657775, 0.26889032202164453, -0.233621249818329, 1.391004257237066, 0.6817510065607113, -0.27607996069792967, -0.62553263734318, 0.3466824780957903, -1.0906016468915916, -1.0219000169761634, 1.1493064072159327, -0.8627456139002266, 0.34035541252970225, 1.0507372769850964, -0.38900648367249746, -0.587619535032663, -1.013933796859808, 0.9149078285549802, 0.23320620290341865, 0.9308104442132147, -1.1467355326971054, -0.2217368274147839, 1.4840689157951186, 0.7456584313924505, -0.48898224734429097, 1.1216588298772856, -0.2679030874132649, -0.8731744536515563, -1.6671490539991294, 1.357726026782453, -0.439449623258281, 0.0072985111239561775, -0.31312813236851816, -0.46811502143534, -1.1111661361435747, 0.1629344829455509, 0.17265049847719616, 0.32923398659357467, -1.480144985257881, 1.277480468293895, 0.7598102907360395, 0.2740431254403968, -0.09690437047956788, 0.5652445829166052, -0.17684170980033115, 0.370285075879746, 0.046775043465616666, 0.08212965352628797, -0.4999451483795607, 0.642571051014142, 0.2519472058691352, -0.31726083424842066, -1.312430227003509, -0.03509656689097689},
    {-0.43984025554773193, -1.7708845689063923, -1.4962251216066635, 1.022944423616689, -0.19087179797902412, 0.8374257453635606, -0.7970591548484616, 1.1527569708323522, 0.21949152606899294, 0.6662803968014024, 0.30627874015771783, -0.9768851927622828, -0.7106491091015331, 1.3458991017682698, 0.3009538604684236, -0.5810544595538535, -1.007718824891831, 0.6861539383538052, 0.7525078498739795, -0.30311855662790754, 0.5102087449607794, 0.9762647661964796, -0.8200849427994511, 0.9990140564425348, -0.6450759626595359, 0.5795629395766223, 0.640934009672288, 0.5019797361700269, -0.01291846689628775, 0.19261433896583316, 0.563487916069787, 0.2515122374462216, 0.9626787626330408, -0.11988428489585291, -0.7286464097415253, -0.3468915361767298, -0.8360664930624192, -0.2030628761833657, -1.438822499940818, 0.17683616599696564, -1.1196203641335851, -0.06597601171493556, -0.9534840666941896, -0.5513613877847431, -0.7571100299392262, 0.3835719861362086, 1.1875200640363455, -0.9085263768715607, -0.5132629885068904, -0.23477632523562308, 0.5370287279353408, -0.8995617893184225, 0.2208655201314578, 1.0781335083511927, 0.7516756145975477, -1.567256718418233, -0.8444699291330825, -0.06662433834431439, 0.44193719076315635, -0.12223673327020732, 0.9681627952900319, 0.542669469366353, -1.373247303513548, -0.49970472508295216},
    {0.6473959656905628, -1.7879408028164891, -1.1997919956121785, 1.1846383571030563, -0.033577744014720856, 0.14870998419183543, -0.9054736723990738, -0.3911444080555513, -0.21083571869664994, 1.8650621586837095, 0.2171293154424989, 0.12393190107193296, -1.6332354156128661, -0.13206763425404006, -1.6545835285152088, 0.42113816510281116, -1.2670983829386984, -0.2596210517428984, -1.0641435872158467, -0.011410488796948514, -0.7003922002136815, -0.26327326071638524, 0.7047002937653806, 0.4091502057213831, -0.07602995330681873, -0.04095981534693589, 0.10095027513916804, 1.2758562541195615, 0.9604567022580461, 1.0523589163276224, -1.0208357440249778, 0.3322161893266321, 0.5893588284245124, 0.925509776545928, -0.3136145251570673, 0.17951399609783714, -1.7875558663257336, -1.7940550577826353, -1.8018283259258696, 0.0568019840137966, -0.20059442138881595, 0.18682650906073262, -1.1907812114074756, 0.22190316142685468, -0.04569933453318888, -0.5074110346853548, 1.420773247531976, 0.326389802196155, -1.1797494795927552, 0.10489101734797635, 0.13289956035687472, -0.9846500455028344, -1.1848328762302884, -0.11279472330522569, 0.5585240613059801, -0.4329572150083981, -1.0906537622483103, 0.9015015336627802, -1.3863122932231835, 0.4176237777682259, 0.42738658897587395, -0.07323384865867984, -0.11899077209905712, 0.6432348698638443},
    {0.23211291439842044, -0.5766345498531552, -0.6100741911336366, 0.6471952058217677, 1.48868690471136, -0.8317711899674325, -1.0654000409004172, 0.5518950691607164, -1.4724120016392503, 0.4861529908317501, 1.055475758831283, -0.7228833496587015, -1.9864496049636031, 0.6829756663895843, -1.4602210934067448, 0.8350738378863974, 0.31044560049485004, -1.3598220203134757, 0.4270635693715419, -1.5166651160099194, -0.7684272516508919, 0.07519074701846182, 0.5497786039504217, 0.4025023483982957, -1.2071483856899075, 0.805770568282789, -0.5099893495991192, 0.23757903571076683, -0.5793329381999782, -0.542692740363271, 0.7109710281874666, 0.41494583000791396, 0.3031998246034982, -0.10986051276246911, -0.5497258603145836, 1.1922900945428496, -0.38102025713612553, -0.12384596325208665, -0.7898577982646747, 0.22882047484189372, -0.5417394300191113, -0.33561233819818426, -0.5683205170158621, -0.48928002292418765, -0.3601418959321678, 0.8618679585582568, 0.8563151922416291, -0.8124752128224237, 0.03445712749379867, 1.2061771051864343, -0.7099972551298905, -0.3753352687182807, -0.6908346586833044, 0.033948222940170254, -0.7739166483457175, -1.2257427434245636, -0.3719020152437665, 0.6232818929541534, -0.039272039137529455, 1.142770880335196, 0.3197517846612197, 0.41758373182919895, -1.5178159277176775, 0.530268745228596},
    {-0.6681880333074984, -1.9380796520220578, -0.441764431461209, 0.49413639268870574, 0.8253018061114261, -0.06099123132725516, 0.06448758915721185, -0.3917127359931515, -0.6400058350692497, 1.480843053154189, 1.0011785392413455, 0.13191917791225338, -1.5177844534018388, -0.5695404513180742, -1.405120835856918, -0.8030900892766977, 0.096902853500321, -1.2870531603499755, 0.1975019430528234, -0.9697731804555995, 0.5074925878038636, -1.5156345692570141, 0.7126311181893346, 1.0683773659570022, -1.2644341046103587, 0.04228920614652505, -1.2759585387935066, 1.0872069920906224, -0.12137299179769892, 1.1020709630914611, -0.9482737531401751, 0.11526935387744587, -0.6000405784774511, 0.2995258157871374, -1.2608939968017403, 1.0367136632583953, -1.6231291080202266, -0.8959329678551468, -1.001686689221053, 0.9109876124532404, -0.2944526880009748, 0.35210588931687686, -1.1584893407091874, -0.33899776488651834, 0.1276082285761126, -0.7579817906896157, 0.5606562026087065, -0.8124551958449098, 0.22099863082318666, -0.19802374536576928, -0.04856177570572516, -1.1191150969716046, -1.6352405760009594, 0.177515659612556, 0.2760270447152808, -1.3410641578096187, -0.9778265649462857, -0.9377998713882523, -0.5226468143062969, 0.13438439118953005, 0.6787830477189895, 0.5236866262967534, -0.41604851733099374, 0.3929820837891158},
    {-0.2417671343443761, -1.0161984417951684, -0.860907141900061, 1.0171254733506927, 0.8212535282898451, 0.005929475802393232, -0.08955588789932407, -0.38668392180087047, -0.1186840916298179, 1.348684100618321, -0.41201910389808455, -0.6850254191910323, -0.4630693610776416, 0.006841659638737891, -1.5021558543746014, 0.06275802861069946, -0.30384541316563296, -0.4540052231431947, 0.9386583181110878, -0.25311430608906244, 0.06390500796231738, -0.3307275746429923, 0.7136666202376616, 0.5486162649540847, -1.4667921318483006, 0.5783125248672807, -0.9636862129125789, -0.18693665661619324, 0.29145255756188115, 0.499226610734557, 0.5446796884417736, -0.03392262834614256, 1.1023115969715656, 0.8757319867361446, -1.240780788636662, 1.1461760115988506, -1.5703341696180222, -1.4107840740960431, -1.1128396174565804, 0.33283714879943965, -0.8201196436404072, -0.04640007905957765, -1.269655906767484, -0.7297414191045595, -0.8833924943469467, -0.19490354118379957, -0.0840457934572878, -0.19285798367035345, -0.35879603808579935, 0.9961448560880986, -0.06982953282918143, -1.509240149739392, -0.8969169280266548, 0.7290393694524044, -0.8958159163312686, -0.4042970462377851, 0.24621117591474959, -0.6711659105854242, 0.43862345339623693, 0.17502630357374988, -0.6085324690906554, -0.9976380585627649, -1.2317773024418872, 0.8197761374251475},
    {0.02823423110844924, -1.3300629657515477, -1.1695161551874536, -0.08248976110110953, 0.6678650691289656, -0.6394155149769306, -0.6909267857463244, 1.197181405862762, 0.414716513958224, 0.9597089312581037, 0.015881655015811, -0.7254822598852326, -1.0532712058637232, 0.3481996487408474, -1.7392649238268585, -0.2693172151803707, -0.24597750031638688, -0.6488911591873732, -0.0935276008423542, -1.7565161900434425, -0.9811973684825497, -1.7077464989132467, -0.34551900491386156, 0.9983920675553658, -1.1538913183866832, 1.1621320752516793, -0.4345589290069941, 0.573529875557431, 0.3946190835612869, -0.36675026492399176, 0.8276085062205828, -1.3613393101809257, -0.07114608001260753, -0.5415691615451006, 0.08669753828428223, 1.0299462017816545, -1.0352161651253542, -1.5239046343933729, -0.8389992029050651, -0.23355769825097908, -0.634719723625901, -0.536579170928763, -1.7211286941364188, -0.8973797645733194, -0.8532400876357149, -0.24344610206991993, 1.0181017683305167, -1.4169647052971073, -0.2735569873320227, -0.014915950838421012, 0.3963060951685448, -0.1696547849976699, -1.3153741344689431, 1.2496914858758894, 0.3998526739709568, -1.8957892855879945, -0.02590539066316109, -0.4955603309708664, -0.22811829795691288, -0.07215522793265201, -0.0048065430916198445, -0.6797537449232102, -0.6382256436700978, -0.045065339658295886},
    {0.6674473147713235, -1.6032878811671136, 0.25421654270686533, 1.1625889442140915, 0.7176092889218985, 0.47235244053896436, -1.3135686142024785, 0.8319658806625152, -0.5545029897990531, -0.19754307676475288, 0.06578261244666786, -1.2140730163809044, -1.5620070274542517, 0.6204325243518273, -0.9757743277773341, 0.5198332392968176, -0.10579855618375524, -1.4343091753691772, -1.0104083534239716, -1.2711370903023531, 0.5018848460783237, -1.7232323769724411, 0.048170991266098244, 0.8116483260461022, -1.2873894109203965, 0.9728385307127495, -1.0759985243323036, 0.5631477334548383, 0.6090856862257986, 0.6837517234969067, 0.3511419310271691, -0.46697573865315734, 1.3373868626335332, 0.2824018876144932, -1.5501017331059517, 0.8683358606909101, -0.18114296149121534, -1.3027921739998714, -1.1142901962478529, 0.23190579187822855, 0.17789501143301217, 0.5811396752550957, -1.8243348568024669, -1.0891204892616162, -1.2318867926073847, -0.5446836972325857, -0.24993578566948732, -0.3533360566462535, -1.6714160007823755, -0.674686317469984, -0.7681924680007147, -1.356887707363362, -1.6328463538275602, 0.24829187722000295, -0.9334635535464844, -1.8796553284546662, -0.4119823369163167, 0.07139151257179707, -1.0827211135853938, 0.3817653313162231, -0.5109512167054114, 0.39870089775011464, -1.000140576116174, 0.41591675794524774},
    {-0.4692282417652803, -0.6355724415137957, -1.1926196860235745, 1.0526908280448977, 0.14012122702035765, -1.3780196860448328, -1.5374347439842504, 0.5651932800833762, -0.4311542657780756, 0.28146128298697426, 0.6194269576115019, -0.45009591375045205, -1.2779746245090535, 1.0211266661090312, 0.27750266580663807, 1.054030320867557, -1.4443027280516834, -1.5571656418650357, 0.20424102097461402, -1.0801790443609873, 0.7517973367203503, -0.9444389416895115, -0.5104745370032366, 0.7193812233384, -1.844846309115763, 1.3800001454657183, -0.8238415222443684, 0.8160075007988574, -0.28965937336126596, 0.31708096939786595, 0.22216435406761104, 0.09724497749728886, 0.8747527244722751, 1.0022712424427866, -0.3461325166052987, 0.691704502614024, -1.8110999164170483, -0.4995855327585844, -1.1053706337577403, 0.9333995363412453, -0.5522671057923684, 0.8557367710107571, 0.10190590292945603, -0.3790086046578044, -0.04323565627771742, -0.7909433937128486, 0.5222445926823235, 0.05509833971540396, -0.13728357513449524, 1.1169449660408772, -0.20831678958884886, -0.2742193742955588, -1.2272610150372867, 0.6410787542506415, -1.0737127976038083, -1.4447422708765278, -0.2912449783092439, -0.2862773704881434, -1.6441640338252095, -0.41291753606063675, 0.5144431905840561, -0.7700112418719096, -1.7413855230259823, -0.38622789790881296},
    {-0.7504516413398927, -0.9181384776191895, -1.5342300959610868, 1.3132728507141909, -0.6137126531847105, -0.5083971044195041, 0.31850265998417365, -0.3727582054586926, -0.6631024287399062, -0.20968465981154275, 0.00176420570869183, -0.10459959128136444, 0.02939088135992192, 0.9585637489352298, -1.1081022929503204, 0.08966551850984511, -0.619618936937747, -0.08077955315610515, -0.8662810525661304, -0.9401789858710319, -0.06418243560760116, -1.5588848481190831, 0.25895657247131637, -0.14817476998956342, -1.3436288044867557, 0.2547998170567934, 0.6028384066700586, 0.6490942767544378, 0.661659207673582, 0.8502292476153224, -0.17591858915326541, 0.03039472653352514, -0.05302627162982651, -0.8351025089783495, -1.6934059737651095, 0.7374155718257409, -0.9516425954381394, -1.8706540465352939, -0.5551570637366444, 0.8192743042240102, -1.0779194078687913, 0.4184061326829122, -0.9868569312258159, 0.12773575902121076, -0.6510166827627334, 0.5497609791660751, 1.4444912649154806, -1.2495087281035897, -0.8910220788183716, 0.34848031597388646, 0.202387327525693, 0.26542315227886604, -2.0123626552394005, -0.10331461234765243, 0.38732223243849634, -0.48618942771990475, -0.9231473376855271, 0.7191050052823916, -1.5417096173885136, 0.7077014186846494, 0.5570856524961055, 0.07759588176478283, -1.367569436753486, -0.26987563400564074},
    {0.32026736985803217, -0.25293252597279214, 0.21057514184783332, 1.1805801723931832, 0.7212356367028103, -1.3605261590367683, -0.1926290777413224, 1.1922372654019273, -0.19847161254396067, 1.1388568848702556, 0.8150928715837074, -0.9746197754612033, -1.2365212777657366, 0.4918096265439705, -1.5000890112598442, -0.36239439351497466, -0.47464431828473846, -1.5845531131342045, -1.071908028486322, -1.5338017102150983, 0.685634499202833, -0.6026187450860522, 0.2764858856169408, 1.0379742731031987, -0.8376672030972242, -0.017562356788608437, 0.3860110375920292, -0.2857553671111336, -0.2826798921553316, 0.44898783984200114, 0.2365929897967707, -0.6171442511928505, 0.576642977216976, -0.014277458907692818, -1.372545788006432, 0.10627371894513701, -0.9425123826465155, -1.142078113193946, -0.33842850798936297, -0.6929949809695044, -0.2533031423490222, 0.5568274656710636, -0.879162414100197, -1.4387264183236665, -0.6536377801047479, 0.49595557244758015, 0.7200845127027267, -0.19482459092138352, -1.3751545336363364, 1.3361523019160468, -0.6101488101448646, -1.7560222680135207, -1.625678223067097, 0.7851565637033469, -0.8694092251715664, -1.0674306745219289, -0.45015493218033303, 0.46224247190351886, -0.10865990199050839, 0.6467718724645959, -1.0351097802236209, -1.219543100595083, -0.34089114527155956, 0.6621911070667047},
    {-0.3259257272929148, -0.6798644538362756, -0.3073998881613995, 0.09691054003667954, 0.5470068791784741, -0.2804391296439823, -1.3147294281288207, 1.0138473573978413, -1.398689534298243, -0.03293152004397414, -0.42506983435430046, -0.48612841924341144, 0.13482160962482503, -0.3393667025789247, -1.190019308088356, -0.4602110864685587, -0.3141516584316894, -0.8717905545179534, 0.0028993892155449734, -0.9569737888392968, -0.9537370592917549, -0.04443721643232584, 0.9881154750849886, 1.1510564480957468, -0.6409771529699639, 0.9870590422637383, -0.6499717051263624, 0.1341357381809939, 1.2579105234569237, -0.5664496312688914, -0.3369181482665915, -0.42666202555988375, 0.4486161344533742, 0.3688877583485621, -1.2503043159985578, 0.4787119112446655, -2.003851504426938, -0.35245947129438543, -1.1208387728299978, 0.8132856576423731, 0.2774676732072535, 0.8298115077305724, -1.32855324245371, 0.41639716961045664, -0.9352951055006865, -0.3135845887060375, 0.6899788332745254, -0.22221855046226754, -0.14213383917132524, 1.1512401974177295, 0.7968682182491401, -0.5442714225988102, -1.067917801039874, 0.7431787634112412, -0.4799408244439633, -0.4313153023883938, -1.6646715686632099, -1.0420873075060473, -1.767015173450651, -0.26346318651850414, -0.04684271600403789, -1.19652889703102, -0.7646507523368709, 0.7242056779743818},
    {0.12186734962787003, -1.59952163296322, -1.5254792568428508, 0.6684130535507602, -0.4410775605248607, -0.7161674091475021, -1.218135927466969, -0.3273537579147051, -1.3666050269387655, 0.13599003745903776, -0.1556319511696536, -1.3511561483144328, -1.4647654972926745, 0.10862434186869001, -1.122128252151255, -0.8711652564600396, -0.9660955492057199, -0.7473996070164247, -0.4117800534258519, -0.07963682552942908, -0.18745676502973865, -0.44030834911550865, -0.6802740309871872, 1.0070360368412936, -0.3340080728306684, 0.8316422439851789, -0.5758868196702287, 1.0927154883888603, -0.5797687916174393, 0.06427966877860826, -0.8904741450079801, -0.5615709151736044, -0.04866406199040952, -0.48223418908008714, -0.4020744492180819, 1.236510350992516, -1.2639513009379062, -1.3780690327143725, -0.9234738992559821, -0.23730890416802855, -1.186961420279887, 0.5306282068467936, -1.3663515173117613, -0.8541286087548019, -0.8539892370442109, -0.9048881194972316, 0.8239093956904997, -1.3526284399696893, 0.08954484132130636, 0.4733584107599213, -0.06471963327909384, -0.8251990584352831, -1.1250384675755374, 0.3630630659315834, -0.41226517697439824, -0.6582470297116051, -0.8577298467428378, -0.7987290735932874, -1.649154639377503, -0.15103922575497727, -0.057266482797208404, -1.3130771302968736, -0.04310622817176044, 0.11013800033430454},
    {-0.8063517741637357, -1.2359452393973216, -0.20965272220361686, 1.4037279992423655, -0.5017385208475209, 0.18337742431667295, -0.6097003398321886, -0.6001493190377373, -0.2566240306249776, 0.13070443634687198, 1.4135796940211445, -1.657672221809268, -0.8171716625640794, 0.12476247486349412, 0.08019987308583394, 0.6278896392481794, -1.7361423808527232, -1.6099254497394715, -0.2423517451808912, -1.3363790554948312, -0.44591566456797976, -1.5942391884826332, 0.956743490404283, 0.30329997600567843, -0.666809466725536, 1.4836802626593546, 0.6182168362625812, 0.7664858654198901, 0.974102213693432, 0.08715060907377715, 0.6436428901572382, -0.47883042460897446, 1.1930145888440638, -0.6495972038965911, 0.06410680401839684, 0.37689555532670727, -0.7743996592588197, -0.3185528648436121, -0.20966610321788703, 0.9772386675510326, -0.4174448273600813, -0.8036219770229912, -1.2856664094059063, -1.2556897836469882, -0.4601531389835835, -0.2625394308400435, 0.9511155132344952, -0.07944636481910487, -0.3430827788117218, 1.4191038400736977, 0.7841800267896482, -1.1833232584236382, -1.836575976065356, -0.07920439939007488, 0.3302328067059359, -0.8737894811839292, -1.5849955827738351, 0.7625604609872921, -1.3448451420478773, 0.06367372262961744, -0.8793755977064925, 0.0871049957755336, -0.2541399039265884, -0.054587878316155185},
    {0.88587228806794, -0.47681053177549804, -0.8353510129250482, 0.9423958252476383, 0.978213344650415, -1.4737690627879119, -0.8787909080806754, 1.3463970273659358, -0.9895420401074976, 0.8404885746622212, 0.4384782114181168, -0.2791359763188369, -1.8096758286027115, 0.42148163659561716, -1.2326484013946077, 0.3106423776273504, -0.23923551818827124, -1.3899084319290798, 0.6234118959439184, -1.3115834788027754, 0.25563363253315213, -1.4243165771375867, 2.54441744451304e-05, -0.26283728447366245, -1.2650723204123728, 0.21650326607050083, -0.17246320413405672, -0.040190744714498745, 1.3550289853312614, 0.8320107642312693, -0.6349101657774223, -0.8832354474639501, -0.360957346222608, -0.5754433535272202, -1.2536315145221482, 1.0777203173221055, -1.6034032888875165, -1.896783831918879, -1.991762606858752, 0.7168980453173817, -0.40802135515170657, 0.5530846657129256, 0.13891769987134084, -0.37263573508843456, -0.8381912797119518, 0.6722271470823337, 0.54331855348355, -1.4394906630381477, -0.8476403456620611, 0.798079667983736, 0.23660784016947284, -1.5848438085266134, -0.5892189071239999, 0.9735736305457297, -0.516836788196478, -0.8098848054797603, -1.353610358938814, -0.9281050147530491, -0.6843250373586511, 1.181296706044235, 0.5776069004519989, 0.5139129988252308, -1.5872923760411184, 0.4737214971485741},
    {-0.37194808097615145, -0.9988950470133051, -0.7072469753485324, 0.6300283077402697, 0.26614686442432534, -1.1997482839030011, -1.4151924810103336, 0.8439066590469934, -1.3608265323449897, -0.15776636758683268, 0.7947409958972594, -0.7728003800294665, -0.2841318831552087, -0.3034830001864237, -1.5356764625899764, 0.17543108608015598, -1.3302895018353713, -0.5701682667349337, -0.1272907189577345, -0.21835021813852623, -0.07713323774784507, -0.10651064425492801, -0.7498450957147647, 1.4066383062147472, -1.0419662419785487, -0.19059202417285426, 0.6874746633658353, 0.4673827493949114, 0.11856498463325216, -0.6400518867687567, 0.7371600017219208, 0.5427999849188886, 1.2264716042770045, 0.6786253602022385, -1.0992236353760505, 0.40093058825115996, -1.0238354059458175, -0.4356822559188713, -0.8555045374091969, 0.5107449746692048, 0.40894436683970614, 0.7896747513119085, -1.4917536264725029, 0.15915922603903557, -0.5947314952368083, -0.49295114783436916, 0.735354454102527, -0.7787649918449452, -0.7860468612420461, -0.3177808669968153, -0.2190089442815928, -1.6437186652672695, -0.9820579933982436, 1.4905316895963991, 0.8535699449760407, -0.445033329206328, -1.4877128952443561, -0.08939291354304327, -1.3382373397245064, -0.6992782199636697, 0.41131416042567337, -0.5776635111206689, -0.3240769327719987, 0.39072224530716004},
    {-0.11203771975720223, -0.8529681713343685, -0.49272854368664404, -0.08512349573656504, 0.2517201238137197, -0.4022393472880445, -0.6148357289676506, -0.25152081575469243, -0.37837334337906137, 1.5179871930965732, 0.9115727577356996, -1.1036425636162004, -0.34966515886073896, 1.3539056946104564, -0.6119136662305641, 0.6094352050519266, -1.3123594014228945, -0.7812316645674365, -0.9548379862793257, -1.1617424432479242, -0.5661949852294678, -1.3331257046838303, -0.509911289204905, 1.1492923333572553, -1.3734724845583186, 1.6582085294027191, -0.9399666289868234, 1.7547272866506374, 1.1554926248449193, 0.12515045652398848, -0.2175641468216761, -1.2788267823291413, 0.8182648742959434, 0.6823678499861174, -1.5339594120465463, 0.8789084707003347, -1.3329132769407837, 0.2312090969245191, -0.03272357292531015, 1.4397999981733545, 0.51043443430948, 0.09750749067853004, 0.016101579247124617, -0.06388736552482215, -1.134899128961476, 0.7070060049209073, 0.037425075609527104, -0.5554625591119841, -1.3535279881219813, 1.7537801070433838, 0.07186628507471025, -0.7545223100680472, -1.4233462613916623, 1.0162189484204132, 0.8708561198513352, -0.6720397469065199, -1.0921045384167647, 0.2456738496870666, 0.23387080075515135, 0.5973583811712515, 0.5131172391929876, 0.04370729278868125, -0.9540056547282315, -0.26752089891195374},
    {-0.48934977215234843, -0.01542870081302221, -0.2953175321138314, 1.227723081681174, 0.34800600495945266, 0.18290383072998906, 0.41604633535302155, -0.004822232851129847, 0.1763763826123821, 1.6788115202099192, 0.3871511622785703, -0.7263110515881327, -1.5591840942382524, 1.1504913311302152, 0.5327180510070345, -0.5785649556973022, -0.8308123204594697, 0.056126494220272806, 0.7853283885530549, -0.11562078949720159, 0.8051858603906179, 0.45141052577628693, 0.14938796108018823, 0.5071904563730227, -0.872768464634579, 1.5083746835812144, -0.9596651350619454, 0.02788174117999087, -0.33745305515588053, 0.513876003633252, -0.8398330085253898, -1.011105412777077, 1.5128289027547543, 0.8985181345988619, 0.2197197862998157, 0.15404250900877645, -0.9490628782730373, -1.5646945656490128, -0.5725917583572327, 1.275933481644977, -0.46200857461475586, -0.9117396765164615, -1.236541469441867, -0.47296861803883267, -0.8516411538179495, 0.0021074157100000887, 0.5776355696819576, -1.5720497942358749, -1.2995029468514225, -0.2653299769506682, 0.5571057739987689, 0.3319301755215945, -0.6454147325274712, 1.0587400873390733, -0.06513882943919848, -0.9472361103128207, -0.87917935432919, -0.02186157278933878, -1.395046461128518, 0.10835285840203962, -0.04239009535219106, 0.21350740785070862, 0.1600631965123395, 0.1000994930606928},
    {-0.6787397233102903, -1.2626911434197619, 0.28571505279243925, 1.3819460305560378, 1.256699984959974, -1.0054589873132587, 0.4180707137934596, 0.09393764381244753, 0.01431123642296275, 1.830040495283116, -0.2935429731180973, 0.1474596365898572, 0.04924984472014532, 1.1093580858100376, -0.011965975372872603, -0.308870836216833, 0.010475977969458549, -1.4328004001586108, -1.1164874594840175, -0.5531462859943432, 0.7089026212108246, 0.08464294791911876, -0.637846151865163, -0.1979745445294426, -1.3488666024371951, 0.12223793758007807, 0.07477592803216643, 1.7693579454257229, 1.0621612405366168, -0.5600858616527905, -0.762582937330587, -0.9939257630975106, 0.9336249081118714, 0.21777121765686594, -0.07605935111189886, 0.14374946052433005, -0.32779331613600676, -1.033649686876882, -0.5758426062968051, 0.0021256385485977384, -0.8127291691693219, -0.40476316083247554, -0.4158681989185777, 0.6281951185979684, -0.6196332862022806, 0.33612890654809796, -0.2958840207230915, 0.05270796087147315, -1.3000439335178735, 1.3231898185533073, -0.5577226656786776, -0.6970898135099608, -1.0640104042274103, 1.1064890419358195, -0.1271417733996602, -1.4432485927899532, -1.1288887729360313, 0.5405787117595359, 0.23343321941979644, 0.9170285379389076, -0.32698621743880396, -0.935544309422975, -0.6652456888136739, 0.770295064195584},
    {0.7465148047434641, -1.840228797540945, -0.7635396541152901, 0.3052678667316646, -0.4182794295192033, -0.05384146130061184, -0.04675353762409153, 0.8659124849851043, -0.8942254181001457, 0.9655500732728473, 1.1076062595905327, -1.0478645439258993, -0.691654940691535, 0.03755153419791901, 0.20127343778037632, 0.3413492424560502, -1.3990091571081917, -0.05838781356781624, -0.728470013498716, -1.0943055767618666, -0.5852542648568922, -0.9621023005267438, -0.1244542784605402, 0.6377963198954257, -0.1641429280401968, -0.004147974470760562, 0.5385759241532745, 0.8707435552978704, -0.2175397869728416, 0.506346604070059, 0.5984012032794517, -0.07861458831418239, 1.2465162658648006, 1.2421686767485034, -1.1005313984622498, 1.1476691092793165, -0.7403397224253101, -0.7773544649670351, -1.7502925001785639, 0.18528093502178042, -1.2311897809310683, 0.39254747367409226, -1.4636618909485402, -0.07420639603311306, -1.1945619359246569, -0.22206574688357683, 1.1158294282522945, -0.7391198294495218, -0.6251691223177247, 1.1592385251136206, 0.017045048578622612, -1.0552581499029647, -0.7665887900172135, 1.623759977479909, -0.5388340488376597, -0.5351139759504565, -1.4538071538425563, 0.9699307378547195, -1.0897476056409974, -0.4549364760000857, 0.49704497299902933, 0.33739839054926163, -1.0481076887994378, -0.54344715850366},
    {0.23602390319358035, -0.7553857499118122, 0.35093189650774126, -0.08893534923214624, 0.9134594187112954, -0.24210962985579254, 0.29471559507649175, 0.8802540335184565, -0.9483333579207808, 1.449690515406597, 1.7086778619578855, 0.18328791229628982, -1.1911542912901056, 1.609108481768054, 0.6771043485065315, 0.28289976045996124, -1.3415277867854298, -0.7654108753615568, 0.8086668734824, -0.066708540781078, -0.14291306886960792, -0.9548572708790335, -0.1754317826389314, 0.24461318242549593, -0.09159549998829268, 1.433229060735387, 0.2298681807611096, 1.7862669654711876, 1.191751659583233, 0.838264966095984, 0.10129578264122265, -0.06096140142142187, 1.244045392186302, 0.33990717417568433, 0.12352495071380115, 1.6169856944299543, -1.8646624054661334, -1.5603381518522166, -1.1430628865631474, -0.21856926061285878, -0.03398028244426632, -0.8763270739734846, -1.5096131011258882, 0.06535799735649742, -0.3756244839016313, 1.26389102317, 0.07894458598775224, -0.294967480153003, 0.09067083777331006, 1.696001613218779, 0.9579986054811058, 0.11178244459920542, -1.1913247738401491, -0.10864716239413355, 0.7828580826232423, 0.18139688931006448, -0.055593177335875876, -0.8314492003666045, -1.6531404360513988, -0.06725926420505322, 0.19270540734501027, 0.9930547590184795, -0.0258207881924141, -0.3908986835754036},
    {0.9491797614731186, -1.1598528253904312, -0.752399827498152, 0.024694384094643425, -0.011281578015519456, -1.233814984008702, -0.48873315994956323, 0.6903348123290461, -0.1528508940081072, 1.8817622226774775, 1.4733555572476158, -0.22421789638000014, 0.08423683470162927, 1.632166023123786, -0.9704138146455754, -0.6942800845805456, -1.2892598935379067, -0.305890082746949, -0.6681659999145005, 0.6416911240834436, -0.21642485718746832, -0.4966217876816634, 0.8475435575332128, 0.9463100786416352, -1.0903300117102912, -0.3666017327841547, -0.0842647044982393, 0.8665974705206075, 0.6698230109983169, -0.35785680451115665, 0.6725416822723083, -0.8622313173170553, 0.4473229200191502, -0.5657810898396345, -1.1064812930706336, 0.7853780742436662, -0.764080321798518, -1.539320806073169, 0.2742597410930865, 0.5931472821948636, -0.2929619222118999, -0.9811606673576376, -1.3967635632983535, -0.6730219305174754, -0.3353980946864751, 1.1140569601267443, 1.4139336696194862, -0.11638838198176346, -1.4813545888346427, 1.50813349454593, 0.04441244639007499, -0.1194386888073803, -1.500005540655051, 1.5958256356806775, 0.6217202836502645, -0.8600256047889506, -1.6539839542140122, -0.603482925114024, -1.67944513042528, -0.2086114978456356, 0.059401082579278085, 0.30212273628651076, -0.534601029627859, -0.17107839782324613},
    {1.0015719870098925, -1.8397200526026103, -0.7584314468085084, 0.26644335687405307, 0.9760388778672, -1.0121788242522207, -0.291396315003023, 1.1787399358373587, -0.03319947484628693, 0.6820298323937942, 1.2176720908546594, 0.26867983430613185, -1.4508956755262656, 1.009608082040876, -0.6328201384815844, -0.6808473175713349, -1.3812248848174669, -1.1862474193322872, -0.62320310276297, -1.2920388374359735, 0.609033784410594, -0.1306670444268456, -0.8806265256886421, 0.7759947709616541, -0.37723799293388205, 1.3234082675593306, 0.24551046952642763, 0.8683121414370867, 1.5360614803940977, 0.595088994912869, -0.626163264637929, -1.0541471474839745, 1.2752473116329672, 0.7981364437248688, -0.15562726485829959, 1.3317577135207943, -0.5393269961251904, -0.9651855331938703, -0.9947727908961517, 0.6778904178828113, 0.5469429104092768, -0.5215285652471069, -0.28476551381422455, -1.1677287101830844, -0.6909601239922337, 0.1481934142365118, 1.5455129677541681, -0.619014689574524, -1.2413489450215902, 0.7452256061074699, -0.018308554353524402, -0.8576092735811054, -0.5219386299202333, 0.473337422472295, 0.9602250107738025, -0.1098216990812593, -1.8136038128541978, -0.26000127729226985, -0.3788480548644081, 0.021069271614259005, 0.7362354283626655, -0.07065434085637932, -1.3390618253682507, -0.5355035295351224},
    {0.7322971406452142, -1.1163217063665438, 0.29896143949747045, 1.225673488649155, 1.1906037117020933, 0.2698270559401438, -0.5598766438845757, -0.5050663474219005, -0.1879485321858453, 0.630136009543157, 0.23615169851245268, -0.8061381580012631, -0.8436721921204864, 0.2396507393071838, 0.5321495297280554, -0.06176486294884756, -1.7714069469200733, -0.5588317565090972, -1.3552141978815069, -0.23267326769672642, -0.024907916617186915, -0.0922042593221237, 0.7182845073593616, 0.6318607370102086, 0.13323982994886538, -0.12661377520721753, -0.5648748906600823, 1.651241499002913, 1.3035942036741937, 0.5381627256386996, 0.21787997079942217, -1.3023373611278606, 0.2444892329795015, -0.35590576766225457, -0.11051223832976706, 0.40729677764249356, -1.1964750751886504, -0.9536347163646905, -1.8192638528005802, 1.3629317929715363, -1.4999852417688893, 0.07488067280291252, 0.10088563325120903, 0.22166638265687813, 0.34879829976669136, -0.061525496452210456, 0.734469583350146, -0.5825041784028853, -0.6713360475019958, 1.2942749898957273, 0.3243688236198982, 0.143703875613295, -0.7891726573361417, 0.32974625809200725, -0.6478541882227487, 0.2837909780341785, -1.7075959645982381, 0.9302804562987906, -1.7382975815012016, 0.30013634570006603, 0.5757340352682155, -0.028280161708932897, -0.4845696215921666, -0.13622267728730653},
    {0.5810448139568198, -0.23724972768660954, -1.1285505429810505, -0.18258830280892888, 1.2401237314165967, -1.2900585798205337, -1.1120648585941484, 0.029347382307366065, -1.1924010957724047, 1.3616898364221812, 0.9670541604423337, -0.28641430927059053, -0.5645013335311669, -0.16644739466796882, -0.4330786619426872, 0.03868802205712049, -0.7215260190851375, 0.035904650683620816, -0.6684220062318392, -1.0064095436129066, 0.837164529822234, -0.3566765437480315, 0.8294129343369749, 0.06051133387300684, -0.6122753249295183, 0.758033270787248, -0.20332337701224143, 1.7178969287755141, 1.5317827824025232, -0.006434063286025204, -1.1349517732596024, -0.2094640887744168, 1.182650226188099, 0.5792753209701053, -0.8739583028221792, 0.30012937333561124, -1.4939576310941258, -1.0585952681031339, -1.1624625199945604, 0.09601258702384957, 0.5735010262235544, -0.6164229954388795, -0.5073106811895886, -0.7965656901784071, -0.6055048580478005, 0.4636048207741777, 0.9013815037613755, -1.3109743199310087, 0.02809604915814872, 1.2226914328108087, 0.702894150698602, -0.2522118808311844, -1.508303565294326, 0.6374223257581902, -0.14539387149768715, -1.2640159405709066, -0.6088351284337457, -0.35486793551165186, -0.8092254315172869, 1.1391747804081787, -0.13591626893414502, -0.6700721838326954, -1.2492838891600895, -0.4315636161918941},
    {0.6222226532642215, -0.9941537158262825, -0.21186929265362123, 1.2099433875322565, 0.8944369793919853, -1.2470153264434383, -0.9058219489167042, 1.244688674859875, 0.325933563974734, 1.492765811383522, 1.350336341675649, -0.7795356091043801, -0.1671143822329805, 1.4392702119095144, -0.0790468817312067, 0.41326085620406267, 0.11599795346553848, 0.0914793586214314, -0.39239808025960826, 0.11683391655164967, 0.8504836532361447, -0.7103630814398672, -0.21441639627105633, 0.2130309575971785, -0.10329973371594285, 0.7463088364510452, 0.3210248356590868, 0.6180203190413897, 1.4174446663117457, 1.29803738693172, -0.4364269183898932, -0.021862080840111254, 0.8980777341615857, 0.4838129864897793, -1.0800519884807895, 1.2305312295255024, -1.4596811483400811, -1.3398492785069331, -1.368107678559679, 0.8259609050808461, -1.3279995641117246, 0.18233615222419589, 0.13384531671796934, -0.506932553709838, -0.31840581813421115, 0.21062969620400807, 1.0698287968610936, -1.3468801952792706, -0.3300024815218501, 1.1848831970287603, -0.047267858547146005, -0.2909846574768458, -0.9804907465453429, 1.7673241248019746, 0.2493612134611604, -1.048001606726213, -1.585395766169293, -0.5251399443902192, -1.4850944364702292, 0.38552908974518085, -0.2696232258117755, -1.0315774598733445, -0.3479016347595725, -0.9824350258845675},
    {0.801054990835324, -0.5137910833018228, -0.9138752418352468, -0.3306251273340435, 0.4465707270301644, -1.4042745243246673, -0.7294299616887024, 1.236707750244277, -0.7679282940392091, 1.082519660293262, 0.08437211881789071, 0.13486616105069882, -1.130630261393509, -0.1718805230391232, -1.0063725447086458, 0.9976660273312546, -0.49151048562337846, -1.2904314122949068, -1.0381244773835605, 0.03006262633419783, 0.8759645626132001, 0.5609780845376032, 0.8971329462774013, 1.2057257221376503, -0.7197758752385753, 0.9253337112707715, -0.958120601855562, 0.6094575230904259, 0.7479212970544975, -0.16715486534923096, -0.7464456590883767, -0.00519606408391219, 1.1740250541408124, 0.5841686516133313, -0.8528579971157345, 0.6327321343811045, -1.7468318274778198, -0.49758375574622454, -0.1511487240765515, 0.008512973020139444, 0.10718351167740432, 0.4409039679853623, 0.437330286043695, 0.5069282811300632, -0.10108607328399062, 0.6378250432368324, 1.355961108806726, -0.8475012743650132, -0.8205585388053008, 1.5963884930050602, 1.1491883127002862, -1.611857738040494, -2.022130835171065, 0.48481869837732955, 0.3199920066087291, -1.4679628065426062, -1.2194731974119943, -0.9797470338506299, 0.09686220542690088, 0.23807385945942539, -0.6455212426850335, 0.1674702019091932, -0.316991373281898, -0.27973144545009065},
    {0.8129351949395758, -1.5808700414760668, -0.3619312825265362, -0.19829521752805168, 1.1002085980269036, 0.24314868214196414, -0.8482884818601782, 0.20769801749597291, -1.0059588405496664, 0.7662054116038233, 0.577485944992188, -0.5245101581892246, 0.4850407367569579, -0.27632124291131316, -0.649506558540304, -0.0778538893236009, -1.447642524106174, 0.004204988623185333, -1.2748009264609779, -0.596622992976026, 0.7457025646790231, -0.04749810748143406, 0.0322245440961033, 0.6898440056975778, -0.5987439345477765, -0.09472394585586236, 0.6821796359967254, 1.7562934754584874, 1.2010527420466537, 0.6919603019863044, -0.10977434217765494, -0.1630150309574819, 0.7483936072510972, 0.8708386182877459, -0.2965650846869151, 0.2036357190346615, -1.1479072730791822, -1.1444741093811546, -1.1425061637252527, 0.018706452695835582, 0.0032820362654921585, 0.8800235304378492, -1.3946970070191884, -0.8765778841736228, -1.1326841626686124, -0.0562686438296292, -0.22975263114207506, -1.354497821718477, -1.5959512613650513, 0.4466691417442673, 0.3343929655432514, -1.06220668706708, -1.2522743811132186, 1.5265975663252023, 1.024910864312814, -0.16227014814312976, -1.878456805502401, 0.9143371044789733, -1.447841695482587, 0.856494120932367, 0.1331055318669106, 0.3659362126908662, -1.1458281446639103, -0.6922412441532001},
    {-0.3465151736542182, -1.4119201458986987, -0.6783367148302474, -0.272273807158432, 1.2344170226949134, -0.592833057898587, -0.9240548310715333, 0.9818384090392509, -0.4486870361917376, 0.3352956133912164, 1.6352876352314138, -0.6697593921805646, 0.3450815592311077, 1.2363472740048638, 0.08514842125927533, 0.5099640951891512, -0.9835626758237356, -0.9732871346171147, -1.3279818988989975, 0.39816949749560493, -0.4630663344682562, -1.2104016579172903, -0.15973528450655142, 0.5549538262015228, -1.15901668887664, 0.1678334346757856, -0.5504965286389638, 1.7699266867534704, -0.12479182862992934, 0.12652025947201276, 0.6933738412741507, -0.8079794782168219, 1.0376105106475555, 0.2563861256454502, -1.093486844807922, 0.17069860940941298, -0.9522815607543917, -1.5519380744232416, -0.7458939069997138, -0.1014297034954053, -0.3294660236040564, -0.4754792919314623, -0.6345718130648276, 0.2159224687738957, 0.11267112877444821, 0.6684972627638315, 0.3697079652495474, 0.2779286858263948, 0.3008644840117569, 1.4791660102418154, -0.6018166776993162, -0.8007689743937053, -1.8974222718589742, 0.5370380148902018, 0.5815914332869101, -0.30253788643776713, -0.7504854237429427, 0.5633134451174665, -1.59753722214143, 1.017262905404746, 0.42796831545755204, -0.8972140156217676, -1.4566372683421163, -0.014627621552451769},
    {0.9963695800659512, 0.8950549685044817, 0.5248284425719034, -0.9853853999826541, -0.078469612078977, -0.9061685882007557, 0.2751932311198548, -1.2028802292140548, 0.8811550043143382, -0.13924174542465767, -0.693667142436004, 0.07537127359347298, 1.346749394099162, -0.5342703456898555, 1.3488468745626336, 0.7466083528582292, 0.22929944023640764, 0.13782901407185838, 0.5385873591447156, 0.9954054766987578, 0.7335682638745384, 0.28440562044969664, -0.8784574375857377, -0.08778618347538501, 0.35770808158768463, -0.2267462729924394, 0.560092264276852, -1.0666530048548337, -0.9570412887629361, -0.043271715316698156, 1.2799227710230139, 0.0003372841604422168, -0.360492821912894, -1.3776358204438592, 0.9907216192495909, -0.3101625156719509, -0.09309103224770164, -1.0830443198421107, 0.5996363980764305, -1.5650339800401174, -0.7811806222129434, 0.03256171182332552, -0.6539589741480473, 1.3039640128688916, 0.8248741481608112, 0.5256284763358859, -1.038537601147577, 0.9838978433138333, -0.09066744495048677, 0.28022891924763776, -0.287039658114219, -0.19160559699998164, -0.4257901287018916, -1.0336917405408617, -0.43142267550419194, 0.8850067760124682, 0.6565132960158172, 0.09386692086912293, 1.182626673421965, -0.24132919395798483, 0.6231144687610694, 0.3579483753059955, 1.3589052190395459, -0.36996091194448033},
    {-0.24920631717076905, -1.2063014644899852, -1.1348244670425123, -0.3500663541326122, -0.7086408151615667, -0.8725938635075838, -0.5893777719259583, 0.5700894513965306, -1.1261587417940258, 0.8813943781781849, 0.5969405858008451, 0.07572989439203466, -0.9096045552638952, -0.6678495946554271, 0.44639595229122336, 0.247584531585797, -0.8568278451506582, 0.7052256078624316, -0.6959235961155849, 0.5918164650830805, -1.1277301688461623, -1.0810734180969064, -0.5850740089422016, 0.2075563020022248, 0.33253970538435945, 0.9534920044017721, -1.3571781173120057, 0.6618737117052585, 0.2873183785794244, 1.0504963902786177, 0.5653863397021949, -0.20496924044809717, 0.4599332831538615, 0.9647181107002231, -0.20335604503273363, -0.019739465851975613, 0.011971426874009122, -1.277206706250249, 0.33612082097645346, 0.27790125934956633, -0.13990872763747778, 0.8976770852082296, 0.4781392388166996, 0.6195186128658062, 0.6238874905284619, 0.4913362898375965, 0.06312353315640258, -1.2069350321371972, -0.46177869839482694, -0.2693184334629556, -0.7930760758679494, -0.6232916564763847, -0.967960223986968, 0.8207998791068257, -1.194127409907565, 0.2674714648392036, -1.2643213279273768, -1.3409731486158298, -1.1387900777728677, -0.18457486769334475, -0.6570437407107976, -0.01651769762180974, 0.8398275553160671, 0.4746539767100589},
    {-0.12103756016361243, 0.2689375942997679, 0.6784724129141249, 0.8034522160075414, -1.5325410328321787, -1.2927600750595474, 0.2515572403920212, 0.5745681870370228, 0.39531423331449944, 0.06006740411608854, 0.9521090668800083, -1.0282384195666359, 0.045521201410876094, 0.6726038809174902, -0.8987933359132922, -0.9521477972750182, 0.04314789092144718, -0.10848596143112063, -0.5021534142723156, 0.3104512541715588, 0.2731293517709064, -0.3748734531019007, -0.18784328584521445, -0.2630812886403828, 0.4151520941607868, -0.2685299189745669, -0.08059619934303579, 0.2890124083784188, -0.5331707575221819, -0.3505490336983616, 0.026483530328622374, 0.6743555870568273, 0.010819660485971357, -0.9084929766217544, 0.431411319855851, -0.6203980677442759, 0.5872692733277827, 0.29072294875867305, -1.109335830274196, -1.0285586134946672, -0.005735733642088153, -0.22387209090267665, -0.5634954671269771, 0.23561101269548743, -0.008237068640729686, 0.44688761449155084, -0.05074760521438956, 0.6525644587359677, -0.5208529911678892, -0.08096082423977247, -1.0899859575950703, -1.190581333982491, -0.8627845856159858, 0.01087062480622564, 0.6166827528893565, 0.3935965356962214, -0.07764612384820802, -0.9549414881477499, 0.20944800726467774, 0.4358984379327237, 0.15357900619360873, -1.569003056307499, 0.42354169912351697, -1.0454427980383012},
    {-1.3589080075503612, -0.20832346017764186, -0.40337527814104185, -1.3064831972502364, -0.09319955518840499, -0.5883453059731053, -1.402778923683918, 0.4547814545552021, 0.72828850057028, 0.20734894613883895, 0.638273571902964, -1.146661869752047, -0.8361068522765897, -0.09203329388347266, -0.9247144134369543, -1.069226696008986, 0.7749486213615299, -0.14942011413589934, -1.1116661417355325, -1.0303710261827048, -1.3723036641861854, -1.2812789823722974, 0.2689805709588852, -0.47158774136089215, 0.7565615503497011, -0.672427282858179, -0.16869456170774852, -0.4158717441815619, -0.811836310357996, 0.6767501611048656, -0.5749650209331346, -0.1945434343432991, -0.49814674099326045, -0.7687746352391187, 0.12489638527888608, -0.17769934080031333, 0.7794164959238291, -0.2089671501474322, -0.4843926282338878, -0.28594112992662735, 0.9379950754422589, -1.2118171718346693, -1.1571304968037444, 0.11485621901701205, 0.31324071905526313, -1.526753182804636, -0.7953409284467158, 0.387328909063726, 0.3799913019870723, 0.37140778821888265, -1.3621248812298699, -0.37445628999798114, -0.9565267106763391, 0.6294941385685573, 0.40791159557284834, 0.9758724207834881, -0.9357911944441444, -0.6900400637584242, -0.7435080995717519, -0.5190407976153788, 0.6288196942666959, -1.3546040304384082, -1.1669221681136879, 0.08608553649283888},
    {-1.3518372003845716, 0.2145431163970521, -0.9975368613414944, 0.77569112159499, -0.09452386138066823, -0.6566980144059549, -0.4360484792762113, 0.61486691709792, -0.06608541237702734, 0.1641536568247098, 0.39729823646556184, -0.9240741615518141, -0.8504097946861177, 0.4850227145431615, -0.07183700846470226, 0.34495458185730227, -1.205626333141476, 0.3798033461266082, -0.17936199598327512, -1.2106981805263066, -0.7054353489240466, -0.20751869677771062, 0.3696632770781073, -0.014370866489966685, 0.16400108988936518, -0.7000900416442009, -1.3613706091992133, 0.304688374189716, 0.06602876970908778, -0.36465122561860647, -0.8002465133638923, -0.20290690464632724, -0.22312339061610842, 0.5053697509839846, -1.286823412917237, 0.6799315851725162, -1.1886680324519134, -0.06952399165221923, -0.2487778597935769, 0.2900125912647468, -1.2901994055701198, -1.190374644043538, -1.3599764353932162, 0.9732806143764926, 0.19852505090904207, 0.13201607289330788, -0.1144898314852014, -0.233141488171615, 0.49837022787893526, -1.1618726230936245, -0.8899897512961812, 0.6697491024354192, -0.17610624295634822, 0.6195893696289813, 0.7444394945927066, 0.5168555605426843, -0.020698150376299348, 0.4507054567148765, -1.110254342975222, -0.869662699495016, -0.5496569809873384, 0.6322464757261144, -0.7108061336401212, -1.5461500225438038},
    {0.3044519686834769, -1.1905910710129288, 0.8217610891957648, 0.7696700050771333, -0.06722109869652262, -0.40262498456366136, 0.5836062028835876, -1.054776349296119, -0.7498004196213283, 0.518825969332485, -0.18181875599089298, -0.14625055276530358, -0.4940794908656877, -0.6845204070331253, -1.572556442025185, -0.8695592875305657, -0.44465183045229373, 0.23825326240557618, -0.8829368979387927, 0.40954546734305003, -1.660822449483388, -0.5316914111735509, 0.4022698640221807, 0.2697999250119243, -0.5504351988474113, -0.11615531898611195, -0.7140448222740393, -0.30050210152343265, 0.2603659621233172, -0.5439818863414952, 0.17786323227164177, 0.5771930345499008, -0.026378017113774868, 0.46773090197407374, 0.11384904337773012, 0.641780335596908, 0.5506130040418075, -0.3692778498051677, -0.4482323116389781, 0.33097015410898856, 0.07476195031336877, -1.2569931975101345, -0.6090032433058431, 0.384650245481284, -0.04966024211422125, -0.9429174641747496, 0.7463554052382648, 0.5473042687596901, 0.38099315957298924, -0.20149055044871303, -1.1109612620628921, 0.10692161514061238, -0.5653827192532451, -1.1034435843657733, -0.4868560165114653, -1.3120204105589293, 0.7139231785806424, -1.3245456621417282, -0.48358061132349556, -0.8751267764775545, -1.1469604840229726, 0.25026388987322196, 0.4884006152582685, -0.5403162832415574},
    {-1.383261374156922, -1.277824145722709, -0.1220360351491805, -0.8171318391354891, -1.3687366334353805, 0.5939796263832131, -0.27555264656370076, -0.19767658016688394, -0.8808259164525731, 0.5646111539335436, -0.7587132100220421, 0.24578394997119465, 0.42414421918016476, -1.0505933838651735, -1.095958796176323, 0.4958106452253149, -1.2993127964879014, -0.39497812726451553, -0.14647124272132936, -0.0776774076312263, 0.19964503605176798, -1.1551522162611025, -0.8802440825852955, -0.529418191466449, -1.4194293209952693, 0.4315275729949349, -1.097811093227579, 0.7633520835844217, 0.6646703063244779, 0.20652540742682576, 0.6633805080035423, 0.44696179974881317, 0.5808966992904274, 0.32847444140418597, 0.28977127567482774, -0.5951161197502968, -1.303507118244166, -1.0852960591248062, -0.19917553803980959, -1.2136013956247884, -1.2542238856796464, -0.4730270406379833, -1.5516930121774064, 0.8427136782732401, -0.6276097953080583, -0.7851076607557772, 0.2822710735989043, 0.15990124461445288, 0.5029248379648211, -1.2410800452206379, -0.953108681009485, 0.6918011807381143, -0.009034347584980432, 0.44980606615486945, -0.6413971979919495, -0.8385342158175858, 0.42178830594208067, -0.3260045047495624, 0.3026263089344294, -0.7147231361911035, -0.8269636186750866, -0.035500281093903574, -0.37998585094086407, 0.1353752505344783},
    {-0.5638789017034117, -0.7508325212230158, -0.9136661278743398, 0.5976490331375909, -1.0177296077197147, -1.4010864647349195, 0.13700232494775352, -1.1371950700097573, -0.9448078562388583, -0.8058411709565049, 0.01173184944868891, 0.12102638467089993, -1.0863851328283938, 0.781584730733251, -0.3288031201147728, -1.47737996569041, 0.517135009245359, -0.30720299627719877, -0.013961579112166493, 0.5824102445866587, -1.0658071632763741, -0.09102554614076887, 0.8700094407881829, -0.8129024984569864, -0.4472553701553852, -0.4578900191587985, -1.2356405335036544, -0.4029632241506195, -0.7065013481430152, -0.19790311266945787, 0.4353053416436096, -0.45745588158908157, 0.023034630912847305, -0.00010275354338419885, 0.27689840171480096, 0.39089349376186383, 0.010645279871134958, -1.1265675357880836, 0.18382243833719325, -0.8562245543538215, -0.44759515000633926, -1.1595706510874442, -0.27370102070331137, 0.4915908198339795, 0.6770981901176123, -0.373573251198767, -1.3237187104752564, -0.879791014289062, -0.4432826272159286, 0.08282386189067312, 0.25133622229358404, 0.3710750184418623, -0.7219817152697902, -0.7833574262090286, 0.5443348690392962, 0.8292700075441873, -0.27076522876942316, 0.276598449238748, -0.31666117443722525, -0.3962575326051256, -0.42269693043277295, -0.4968468748114312, -0.040635026342146024, -0.39118622594248303},
    {0.23575838540750618, -0.13211093605348337, -0.258566529739707, 0.5041668161765682, -0.7357032464683408, -0.6693568272078837, -0.2237087461304982, -0.6548697114072333, 0.15986082583840852, -0.7570015387156461, -0.1833293745403928, -1.2107770580158044, -1.1256323781427877, -0.003969508732695416, 0.3858351599672384, -1.357420430168307, 0.5862433670990715, -0.7372547773153316, -0.2398017699175982, 0.27042813011956524, -1.2295036867356135, -0.052520014965453596, 0.024908388561429948, -1.0022206387775878, 0.7342723027212626, -0.03873732649114456, -1.3466379562538384, -0.7631415444658369, 0.1331859599199855, 0.5556640953607229, 0.03062823229546758, -1.4047099369197764, 0.2304036170418899, -0.6422015204868367, -0.311981175396402, -0.32051672306398826, -0.5674242808682641, -1.2854095217406847, -1.1139627527376073, 0.7431849175094967, 0.7986803951041127, 0.5013555291579712, 0.2661147348284893, 0.3718557937288155, -1.4906751611103934, -0.46781785043151025, -0.10719690784775193, -1.3332069378774762, -0.4521833357066702, 0.6033902259916835, 0.09373841935635419, -1.0894955896394198, -0.13247482393462384, 0.6630913168261533, -0.9977213707255944, 0.4893538557841325, -0.9053536925448794, -0.9662392452123358, 0.5853410935655389, -0.4550440146731989, -0.966455465839316, -1.2190080640676544, 0.38052584879867735, -0.6086191719474535},
    {-1.2105697031708729, -0.43988398080464886, -0.6746821065421645, 0.6126211081980372, 0.04760885701812081, -0.6589637788686884, -0.33617239516538283, -0.6767560269224752, -0.06390076375084063, -0.7767769679929172, -0.4962322948437605, -0.6701538681982594, -0.11416251075259107, 0.383884082404149, 0.1079771839835106, 0.17157954224038682, -0.42188273306908614, -1.106662905337714, -0.35749536133256865, -1.484850855537401, -0.15385157872627223, -0.1279316804240652, 0.4997427258013576, 0.04063581475501429, -0.7851809859222051, -0.45529845134308594, -1.0823914497504117, -0.13987023252920658, 0.5904641356318756, 0.5268336142351672, -1.0146687105080818, 0.5218875740999973, -0.2353483775871557, 0.43253282273723354, -0.6576402870147889, 1.0654076916196302, 0.4279666411084887, 0.5304295350617355, -1.0772984627178994, -0.43661932032956613, 0.07164723401752872, -0.45424561172055783, -1.4180814316231478, -0.7804591228337382, -0.3523473615199622, 0.5743366765098078, 0.19395496893626601, 0.3587544652178146, -0.7401080661324123, 0.09686994619497397, -1.4038714402622037, 0.6712975867125414, 0.031824210752798905, 0.11684922609407758, 0.13916410785083932, 0.28353041763030373, 0.6690231951753403, -0.6982892648339019, -0.9917798145956411, -0.4341845100643582, 0.23441937743649052, 0.07692977734143072, 0.34328585371274467, -0.5246058457190919},
    {-0.20668047290516223, -0.6268898310007501, -0.16969333170843, 0.8173688915497529, 0.030470101371281946, 0.5895400002550883, 0.4381458365124117, -0.3635815466254183, -0.9003939831281033, 0.031902568343315854, 0.8951553078851774, 0.08840395810594899, -1.2307050492626315, 0.4053061307696088, 0.19879526555075078, -0.40839335750273903, 0.2914678233556672, -0.6488229633442489, 0.423603524718331, 0.1747197540913379, -0.12603358724441147, -0.22541038453851786, -0.21506909403645677, 0.30374400157434733, 0.7604327977201081, 0.6586247153178661, -0.9072852312947716, -0.1429123101780739, -1.0499368377123883, 0.6281429973119236, 0.07731415702573494, 0.4837676515063559, -1.140969849039751, -0.21549054962508518, 0.4840605362445319, -0.161647390838211, 0.07153308420331288, 0.21286788056556347, -0.6482669585112419, -0.803724105322886, 0.38976458347917126, -0.2718641597425538, -0.17460003432192125, 0.2861310517542131, -0.9957252661188553, 0.8921450557609358, -0.5870595796726379, -0.4720330223843117, -0.6079780405079084, -1.4284050881267065, 0.42598144150226164, -0.7250789959411483, 0.6633950789515771, 0.08730061290593266, -0.36044613606940784, 0.7590630987448705, 0.44000120663126735, -0.0594735547608551, -1.1264228136555121, 0.5333916517454512, -0.35949607977490916, 0.02680211764597816, -1.3822026181198235, 0.2841112238969555},
    {0.40817607914689064, -1.2042693622606078, -0.17913970645387223, 0.48095346755764334, 0.3906475379554656, -0.7130010849091978, 0.39766935598781666, -0.1725108136363561, -0.4059404078201481, 0.8572493832257138, -0.17478560421038172, -1.2287428657337534, -0.7392062952556977, -0.2812763148708469, 0.2784661746856912, -1.0291469367362682, 0.6717620418897348, -1.3480907070981776, 0.5625615973649231, -0.16866578993243966, -0.8984839146786863, -1.1004736256620071, -0.21751248043362378, -0.8669050169741342, -0.21524523327017034, -0.6338233725660734, -1.3331270109800153, -0.8918001918742875, -0.1339684384620084, -0.9649664566280258, 0.9765276454332302, -1.1088016430117478, 0.5812063200519343, -0.1028330976743514, -1.4735641293210702, -0.8775401233830148, -0.24695367837761242, 0.2529436189330151, 0.13201364600753307, -0.8552961232536, 0.060795765162349955, -0.3388271096373139, -0.6304708735992126, 0.5123560237545556, -0.40384248193883404, -0.2284659458220316, 0.304939227640969, 0.7323064235010449, -1.1068705607121012, -1.5650230372209328, -0.5184581576730963, -0.05082696566217047, -0.5593477834103171, -0.8800503594963044, -0.6985346864965598, -1.3224726186005946, 0.21560370188458208, -0.5063934484164855, 0.6165321034485514, -0.15396909562383004, -0.4344152150041317, 0.0017378907630078411, -1.4699764063033052, -1.2857742795173766},
    {-0.8999446819619443, -0.7244343694523713, 0.006452548672220135, 0.762200283027521, 0.7679759879576354, -0.6743411325885184, -0.49472936145981883, -0.12509338242532614, -0.11072460264940176, -0.05539972193865068, -0.5239051527908286, -0.31246549549222724, -1.151273618665871, 0.057982602308519024, -0.5134795960680498, -0.04268515283795277, -0.6771440368862502, -1.0758662884316337, -0.1956949090158458, -1.5591596550806384, -0.8582311920708097, -0.1957953889615258, 0.003003276641234876, 0.16270677666172145, 0.5175031738097459, -0.7540448334653176, -1.0594819192631177, 0.7872758774614774, -1.128673112644736, 0.16744084031644396, 0.5031503253340792, 0.4066226092942264, 0.6798233959883921, -1.326447910330594, 0.24143927224240289, 0.7216970655026694, 0.37207877318694166, -0.1885849480992946, 0.39172154124106484, -1.010322219870294, 0.12504562140720096, -0.4486539779022138, -0.5077415974028565, 0.5072121240958603, 0.386038996404405, 0.040165314730682036, -0.7369771449633089, -0.7430833395856343, 0.3210225273359592, 0.03333148656864232, -0.32306254161514014, -1.3634763290786052, -1.0572333056427825, 0.5928947595378163, -0.3567910307510403, -0.8951443365865599, -0.9729858808308266, 0.2304915557529641, -0.9054695491746079, -1.449071659255825, -0.14680974259676405, -1.0843802755703764, 0.04144414420576621, -1.1797616319121547},
    {-0.09772965538344351, -1.3286779064821628, 0.5294752722358895, -1.3261544508063687, 0.5663189116933324, -1.3049390957917903, 0.6102084098662857, 0.2580849841019481, -0.6256078048892312, 0.2682217108328109, -0.3734815894736446, -0.4927441653178343, -0.9009294916299053, 0.8509837500060077, -0.34169786599077273, -0.5151518856958807, -1.4259012011472598, -0.14560195861368463, -0.29684563553647003, -1.434260808410834, -0.0498124740362897, -1.1345539134818472, -0.2925597401910356, -0.6996148546018502, -0.8902550852577613, 0.10329872722101753, -1.4278623206389, 0.4341008123321091, 0.18529853050665065, -0.027683693452724183, -0.2980404960997328, 0.18547213655115172, -1.0906746954805642, 0.02261327841255419, -0.6379750502339878, -0.4286843470570181, -0.05272239393547259, -0.14429522211030868, -1.4997277547581478, -0.06738477233109012, -0.26521343199801173, -0.3277769072611778, -1.5052234808745217, -0.42150821884685086, -0.7803453619091271, 0.015548771377875118, -0.13122526857022632, -0.37514058172304754, 0.026016706109214496, 0.32398161792853053, -0.25757411455203255, 0.22671921540444367, -0.6035823558881879, -0.29574041116093613, -0.4772902675213112, -1.111292872902384, 0.2581560513939117, -0.38274945972153007, 0.2455230791139242, -1.1917952370389675, 0.17245922980242284, -0.5206755802469855, -0.32830295595724807, -1.535578577006812},
    {-1.3806779742074788, -1.0706773000037189, -0.18665412631080217, -1.2143083345160748, -0.39063943437820736, 0.3239058950701831, -0.11410955325536187, -0.4606043021745924, 0.267780966703986, 0.40944209676770865, 0.1794383949191168, -0.02490539855892012, -1.6190202237438505, -0.06690501136810036, -0.7696787131652323, -0.6723788158373187, -0.43372930310328456, -1.137526807497478, -0.2452585163722999, -0.9297150407504932, 0.10900633115552323, 0.25032681035091997, 0.4527127620741151, -0.5955612568760978, -0.7493821560024679, 0.4966934003802211, -1.186307859679973, -0.2503321927985857, -0.5904018019933065, 0.6572890773379477, 0.49660927871032384, -0.26097284050281744, 0.14502821999212623, 0.04204937458597337, -0.5429560212993545, 0.6313116239059674, -0.39076970009862205, 0.36744844257203485, -0.12533349901249582, -0.6582918854554914, -0.34340679742350927, -1.1485160823292944, -0.28896053370578817, -0.5882574379896215, 0.5493123994732083, -0.09010380812085811, -1.2926702223724014, 0.07755123142395622, -0.6096484380664022, -0.812876989916086, -1.4313860880761657, 0.2870249482076841, -0.8917299264984884, -1.2043481260426514, 0.11320072497036518, 0.05225499511264211, -0.8576403140339995, -0.2511178037573659, -0.7583900797978992, 0.4907421252283222, -0.7560397357106624, 0.2526026240239981, -0.4631583840280442, 0.3899893463541843},
    {0.24706451163296456, 0.16447276944425923, -0.6241502859989898, 0.6478085798888299, -0.3489316389623238, -0.9823051619827251, -0.31168432326431744, -0.3246777296667133, 0.46667616543092405, -0.23580810861786505, 0.4653161298684065, -0.06894258329560247, 0.09673156655351069, -0.8420186992602382, -0.4926945486519262, -1.3404941008088949, -1.2505266752883881, 0.316377928570539, 0.041294480107173175, -0.24971109894362886, -0.6319971604267526, -0.31902000237460015, 0.6595974372995812, -0.14837795921186667, -1.0013600968740226, -0.7422432725878989, -0.32795499191213334, -0.3067235165866331, -0.16915458561004407, -0.9323792931360798, 0.5912553032654505, -0.6886919362458745, -0.5221836653031466, -1.1613230383990292, -0.29065725856905555, -0.931946576403888, 0.24119811447658177, -0.7139829942836069, -0.3261856844092767, 0.4081748295778935, -0.36814956505586977, -0.10615683562554235, -0.8786344895055519, -0.897201533611441, -0.2555203011883093, -0.3969433218462501, -0.41136340989002257, -0.3542849693184198, -1.3157719595032749, 0.3856052454546338, -0.4622565856832153, -0.97995840996964, -0.0423986459448457, -0.6815071919715089, -0.8630361378979792, 0.21346148394309936, -0.644457491012014, -1.137672966290218, 0.813676458005323, 0.39121764985622004, -1.7588059118745702, -1.5751681009609262, -0.9655803819346063, -0.8880466202493216},
    {-0.6620985603706645, -0.1823144734755961, 0.3538747333808012, -0.11759658378186433, -0.6874721287032399, -0.5551834471915994, -1.012779144337616, -0.8094443981655006, -0.6542673507415318, -0.1884061131190948, 0.6234300345200992, -1.5759279313542498, -0.838983638004334, 0.6461314512882154, 0.38484712814155764, -0.18691810503101153, -0.9922439008236702, -1.2822819013267928, -0.21988571864335596, 0.06361034384342082, -1.2319186032134122, -1.33408930834485, 0.6496259968756215, 0.15793374202010513, -1.109244009070491, -0.051927800063560015, -1.6687255388222306, -0.8366820585164395, -0.42443850506875, 0.6047177068450534, -0.9455772066648942, -1.130448581860472, 0.4515849732647685, -0.04168709494364807, -1.0622087954123107, 0.5407265127196058, -1.521066392406657, 0.5936810096575194, -1.4066946212015965, -0.11284013144194022, -0.991943104179653, -1.6034797225008703, -0.23253705721283527, -0.9475293061655217, -1.3491442715538706, -0.5282301532048155, 0.3492386618198494, 0.27212699040516203, 0.7344708147822112, -0.9794415202368286, -0.9743393244883748, 0.44205734242622113, -1.1328533123884619, -0.7963584420272289, -0.8708087914069937, -1.075784517479202, -0.961703690350427, -0.25295760368502407, -1.014900151459649, -0.8388475981479077, -1.2858215644607123, -0.18089986295808833, -0.5197690989863846, 0.2204844976952001},
    {-0.5738944063631585, -1.329530036522772, 0.2719248622756248, -0.37779828283188654, -1.3113732059893883, -0.479493134892004, -0.4319686092555401, -0.6227078570838875, -0.48676722629954067, -0.36240679536984904, -0.4150125879373309, 0.16339339136310568, -0.512702092785086, 0.44893827049909485, -1.4804758589147393, -1.2169139319298987, -0.8727268740016615, 0.7149969973402991, 0.5559579428501676, -0.8827031418433611, -1.2158379499141816, -0.23631812783578135, 0.91206846515072, -1.1960084553190093, -0.9720204230645307, -0.5957855414977565, -0.5690612320070588, -0.5690372671091026, 0.0751128689323235, -0.9179797645548193, -0.09117972296981103, -1.1715996230119738, 0.5577515298208535, -0.09299805581439897, -0.22646525076241447, 0.758022642167481, 0.06837997789905334, -0.42815372283826614, 0.01091900701959652, -0.11287041239365013, 0.49170662899227074, -1.5108533331885814, -0.3598382622625724, -0.9715827344296216, -1.2329766334353802, 0.08568540713114926, -1.3483894295514467, -0.3333957958070948, 0.5717780578060403, -0.33154958034135273, -0.13597189606863974, -0.32988749696213826, -0.8480817066041645, 0.11903128226068967, 0.029952806086299924, -0.5863998745865762, -1.1727041029260132, -1.455380710476225, -0.32019208010237143, -1.1362401338481212, -0.20562884970319587, -1.1451983133340276, -0.7751800300051404, -1.5997011336219118},
    {-1.065753351462406, 0.20599716824635822, 0.5723089718700795, 0.18195993990943132, -0.9463163425656198, -1.371298680261928, 0.03357971369305634, 0.08704414059368722, 0.2337942001370056, 0.3516397537115861, 0.38647446447257866, -1.3487002325927864, -1.2138308743618949, -0.9845648268138063, -1.7079794775901125, -1.2119348840070594, 0.2228649217410696, -0.07453855456866279, -0.21583656544838176, -0.9656991800317806, -1.3747322587678439, 0.3684462583856859, 0.10710989878562487, -1.0763483922394568, -1.2550087539654788, 1.058381580874283, -0.34332703949838406, -1.458281539100391, -0.711447333916198, -1.3817933353574703, -0.6447409198942021, -0.9467985895678169, -0.7418205836537305, -1.0387934698130141, -1.0931967381336087, -0.1545667132060367, -0.9720749427441144, 0.48172363136848434, -0.35373364114301087, -0.8990723043717296, 0.8542650876913523, -1.4129915419446182, -0.25762610936276564, 0.5171842512077555, -0.9679125366320256, -0.363855844469436, -0.8183148667886585, 0.5157761755685147, -1.0987093477612422, -1.037864500839434, -0.1959439733983926, -0.36908668844985576, 0.1082702268756379, -0.840393690851769, 0.9139201647839414, 0.1852743425698687, 0.006485830649325934, -0.23259829507395136, -0.41348541789606275, -0.434949836093903, -0.4894613331079941, -1.3416402911682, -1.1249964133919843, -0.8835056377204069},
    {-1.5163662226157855, 0.3634238885508539, 0.5514676823346634, 0.5924184719960317, -1.4329956634331698, -0.6686540874240796, 0.669725031750623, -0.0065315875204304446, 0.16415662381620003, -0.3048897223176186, -0.8924969255355213, 0.221373808297371, -1.1033427149055557, 0.9522631311915273, -0.9652608517195848, -1.6062564321107144, -0.9659623750704042, -1.5727811261211444, 0.40032690754892425, -0.6078390710341411, -1.6031746451606774, -0.021344749200303218, -0.2975639668099303, 0.562452151691894, 0.12995090762751058, -0.14005554938283896, -0.9890169102216552, -0.9517310372350415, 0.591692271411183, 0.5167269659614049, 1.0011634906116187, -0.013529677357967661, -0.08455374479721751, -0.17301750730682236, -0.11450558524315209, -0.8773534428877738, -0.23729256159851014, -0.0663180464033949, -0.2618085443400483, 0.451684614684688, -1.043944657275403, -0.36182470326976435, -0.018372104225542443, -1.0411934703875296, 0.039664176726981214, 0.48922977602773526, 0.09090196629673239, -1.0868615433700557, 0.3026675881977001, -0.5780778814555357, -0.27619149388334263, 0.306125798010822, -0.7997815917739661, -0.45282385825033333, -0.2967143428053017, -0.7700362965501947, 0.19495682640474934, -1.3458577584793148, -0.907832280576995, -0.6304541114998932, -0.641178600514907, -1.2421118807691718, -0.628392533948417, -0.1651916847118951},
    {-1.3412078541810928, -0.9284772318397657, -0.04719574467465884, 0.5564965899060552, 0.47548039117744223, -0.1354608786226303, 0.40807059996915174, 0.5969456135878967, -0.7766566634680755, 0.18546297469786818, 0.07114725381051747, -1.3402156348836116, 0.03335941005783654, 0.4889908861330094, -1.2216834754734096, -0.4299579281322876, 0.5373235628002405, 0.2694597643917365, -0.04997926092808014, -0.39004128114236547, -0.23975888677982463, -1.0129424752279648, -0.11391034182505688, -0.8464684790692908, 0.47396757201488127, -0.4785683363291748, -1.6883959098312726, -0.7075684375000785, 0.6068540717631676, -0.7091837956873702, 0.5588060989551868, -0.4465526682737939, 0.3985224756647677, -1.264661630238528, -0.7289622774299832, 0.7662400948607117, -0.39252379409116056, 0.474686975685908, -0.4187964137133279, -0.17797801141836028, 0.49953978280737266, -0.12738126583533502, -1.5353923034552641, -0.15113144824209376, -1.117067192284167, -0.06919382936468632, 0.4175598335650472, 0.611074957610028, -0.6579493011094053, -0.3552703564434788, -0.9776891531167847, -0.8285037733515824, -0.7035756132029206, -0.5546859971210487, 0.07482850356027716, 0.06536040709878142, 0.5052422090400231, 0.3347265833261148, -0.9725093643827941, 0.5583590959364159, -0.6647706552314443, -1.2644826049786524, -1.626473505355189, 0.23577760285038651},
    {0.1629134568349465, -0.6608583172459331, -0.07909916931948231, 0.9322707880832093, -0.8127462529002603, 0.5426383608093721, -0.8929581502545986, -0.49928015606902904, -0.5868102568842413, 1.1178085331560241, -0.9385812600962314, 0.3125695506382519, -0.7312018825489461, 0.16202294020781047, -1.5742181105331854, -1.5884649826097899, 0.4154522626039612, -0.7311332250073915, 0.7786480698788733, -0.29965948052959446, -1.097716756569095, -1.0630744153673806, 0.5707626535380914, -1.154203978969959, 0.7462733807108152, 1.3284516887107196, -0.2893132715434121, -0.32993799665198814, 0.8585078250011232, -0.08480577495831197, 1.0957772296486492, -1.282403642255337, 0.3097993585123632, -0.49180785477429506, -1.32547102144479, 0.6972653953385245, 0.3145147110450439, 0.49370800530762365, 0.15479658422530077, 0.4841509553377777, -1.102128610957478, 0.0367342737911355, -1.713761947944625, -0.6725685049990446, -1.313219933429104, -1.1218951332010492, -1.356630654721817, -1.1395590131288764, -0.5589915878875892, 0.09425830319530679, -0.6336485612619038, 0.040617315090615246, 0.14367533192876555, 0.28120169744876045, -0.4570807075067442, -1.361906064009561, 0.05749115330269242, -0.3463893888284185, -1.0299758580334442, 0.8547801302325511, -0.6258026998746017, 0.0732392302946909, -0.3376775016410325, -1.207393648862229},
    {0.13070312212996976, -1.1342596760278472, -0.9312686621989797, -0.26027993988092124, 0.051002211272349836, 0.33639071334321335, 0.46685754937240637, 0.5506324273496915, 0.3935367830806447, 0.5242821067779061, -1.0824679805768873, -1.1644159583966875, -1.0815139654775696, 0.469060673110998, 0.18770095545948678, -0.25958256582692907, -0.5224715609600943, 0.21772150922470504, 0.7435064880849169, -0.3145228863136956, -1.1860218950778214, 0.3239902784344109, 0.00016887475195394733, -1.1079499612955972, 0.997510885598751, 0.5204218705764804, -1.3236730808797705, 0.48913909351165585, -0.8930897446837429, -0.5297562980140709, 0.6188347564061641, -0.09941909902992896, -1.1952541377541241, -0.3313278561233349, 0.23471729666082555, 0.523338271357516, -0.6211024074461953, 0.5183230503280728, 1.0969046824532112, -0.9845532842169532, 0.4615572519301773, -1.1016610494327446, -0.589806312891004, 0.7540629781380945, -0.4954346467846655, -0.436814409091784, -0.974987504509461, -0.08333406703033779, -0.6146107180314537, -1.1609232708477775, -1.7712201759775297, -0.441488334688702, 0.9924478627214314, 0.3342672675169051, 1.008968038061433, -0.593958702510165, -0.3916509577014772, -1.1627759939397888, 1.1323584640291153, 0.876165892151872, -1.3563340481380235, -1.3888303390242005, -0.912609728276575, -0.3885486792052108},
    {-1.4563404681440801, -0.21980151421224609, -0.9594656566393348, -0.3492048815027395, -1.1755853099326603, -1.2646237654845875, 0.05707662823715831, -0.9277459253802036, 0.3340695185328656, -0.635692343407705, -0.01734486214769411, -1.2171878750765182, -0.32248459611625707, 1.1349210188070273, -1.1509792029947288, -1.2065371597540502, 0.7731802677423151, 0.16063740004339866, 0.78507453578971, -1.7604533054411944, -0.23520693678410962, 0.15108726366462205, 0.3070327201551468, -1.0800769498575444, -0.20654236255685177, -0.2768213402232247, -0.5512883836496091, 0.5710945530192731, -0.22022876975604727, 0.29214423237642434, 1.3008405171180726, -0.6157171268792223, -0.2361122030811183, -1.703532854530311, -0.8612676837189521, 0.9511569567584728, -0.9454275059879048, 0.36474692485326765, 0.347334077777525, -1.0272860167675057, -0.589482647807977, -1.0783427120467652, -0.8053284869262618, 0.9566246696111493, 0.44524239518772596, -1.576735099620043, -0.5104992943966764, -0.1387488309727444, 0.4589113868385447, -1.5451839025721845, -0.2419574401462063, 0.17318572685127834, -0.8227139285067734, -0.9707662909082662, -1.0480651349005852, -0.9189759404413049, 0.405963154678385, -1.0493946951750082, -0.7925863452954017, -0.90686619040101, 0.42908153213326505, -0.28825778886209846, -0.6671690411703158, -0.5725200514307522},
    {-1.3403246618399747, -1.328416713941628, -1.2048447418402402, 0.14336489927895976, 0.2572456697813095, -1.430501587397768, 0.1828197072091728, 0.7323673779574407, -0.08726917286223783, 0.5865520867634512, 0.01873050092009066, -0.7698376005429703, -1.4067737216648968, -0.8915264694952116, 0.1432677476590011, -0.30298604017250846, -0.7501144302299727, 0.5657126772177051, -0.19175573337609966, -1.3920414640519154, -1.439606848552197, 0.007195736583516602, 0.02812976178794487, -0.07745251142770353, 0.7656411898960739, 0.8293689932745237, -1.8164741751551072, -0.9936931944834262, -0.7854831603794697, -1.2251946568064729, 0.48906017197670526, -1.5871480632821877, -1.4121707350429595, -0.6095683534841198, 0.10352570666791756, -0.932038253862836, 0.35171608228343326, -0.13483274951826474, -1.103608161462189, -0.8115448125918123, -0.8602501725497127, -1.3341544468404294, -0.13021504458289618, -0.07609250703235318, -1.5008263177684222, -0.02518553843004171, -1.581268859034811, -0.14090167076783383, 0.4701888928993093, -0.23304283195117775, -1.903245645277988, -0.7501514968061731, -1.3841970748434407, 0.44387972357788286, 0.34871557380025053, -0.4437561882037762, 0.020586026673752138, -1.6967022443948692, -0.7435503294814159, 0.21165383485092445, -0.6897972235978503, 0.02352516493658448, -0.13107584615667292, 0.010805377612794232},
    {-0.3488399844559732, -0.8492917783666893, -0.29596475534889555, 0.7341180487313743, -0.6245123290140006, -0.5101781122921262, -0.4326665230249054, -1.0253585782536236, 0.24111564644485328, 0.5741404058443846, -0.9260405101882485, -0.6689686866630346, -0.01192681246149805, 0.2195088485258705, 0.1922841510444721, -0.8861862416292549, 0.2296257954631628, 0.25128024530929155, 0.6412291555023074, -1.2613198461890551, -0.5050161278955659, -0.033014604283999896, 0.2650888908730454, -1.3597640847947359, 0.30004425337268026, -0.11140815891793225, -0.8163492105684512, -0.22104091225294178, -0.8711263524822713, 0.4966103433764737, 0.7078569312532429, 0.12080393345103295, -1.499276758068229, -1.0764217878873112, 0.6945190494199914, -0.668317729911777, 0.7320054035705719, 0.6226340199921048, 0.6683217612662352, 0.20314238099908666, 0.4736802677320624, -0.614408966787085, -1.6420543944578145, 0.6432896365321599, 0.2887018280732742, -0.697406445272413, -1.2806551611088037, 0.0804473316013651, 0.46116412371764576, -1.506115576411133, -1.8524355304497586, 0.7464172481961131, 0.7351487899577182, -1.38183602775584, 0.552383320613036, -0.4843452839735848, -0.701560872025688, 0.06448023874909337, -0.32502044916263556, -0.052996365562888836, -0.9923258197559671, -1.048679218376544, 0.06702693273496688, -1.5290414133949417},
    {-0.7927156803840492, -1.366437003804777, -1.0783959011091284, -0.4468572065363799, -0.612793005022499, -1.0985898125896085, -0.915346389976325, -0.5808008770393975, -0.38032499346054977, 0.4168317553592848, -0.6659429989647351, -0.0913685493016014, -1.0402028198556028, 0.8288301914051931, -1.5912256923199903, -1.5165342878219452, 1.0463823138836754, 0.5756734882699202, 1.231744568777638, -0.37594258038704076, -1.3415740661964062, -1.0744862728203026, -0.2188626556556886, -0.2623284139331074, -0.5467385660056577, 0.31397620367009293, -0.9017603729475118, 0.5527375543872742, -0.35829646062363624, 0.7910008259415802, 1.3379508719379145, -0.9015788145346109, -1.0159898158088176, -0.46856471458243437, -0.8326597255999291, 0.34967152683722896, -0.04908656202369261, 0.7634534435039816, 0.009661872502834096, -0.40522608429886486, 0.8021161285842111, -0.03519198646839764, -0.07528508054239222, -0.7855585222557867, -0.14538490869557966, -0.8752968905716767, -0.9711710782493939, 0.34474073564711394, -0.7161692708343639, -1.2675027895218385, 0.1229839913720282, -0.6317453322892287, -0.4403607212391971, -0.851957808803948, 0.8232540308202697, -0.7601182016574767, 0.767530017737933, -0.05206966458737608, -0.7673761714343307, 0.12385968222023755, -0.12542059107955816, -1.5198802753757896, 0.5873913766906683, 0.3793669053606556},
    {0.07002974443388027, 0.26261355694098415, -1.2584045020713366, -0.7759395524282416, 0.1253513651789566, -0.22741429276526998, -0.8986145163970444, -0.9898256992300181, -0.5004362536348426, 0.8753570101861468, 0.543838087356216, -1.4452144979455894, 0.5275208442206708, -0.1951950665796411, -1.3463659681458668, -1.365533775200232, -0.5207428763298553, -0.042359374496835626, -0.7679212146816504, -1.5701226168974658, -0.46486972945377925, 0.3586791093264413, 0.34328894333565935, -0.7163064669540941, -1.0600267365835165, 0.5959551541796739, -0.463935123824081, -0.37759271109230247, -1.2200359789544326, -0.32892477744782006, 0.6140980402216919, -0.10766010832846117, -0.8632274984106405, -1.5502206378482541, -0.05558991464058775, 0.7258318194293778, -0.576132495992345, -0.9555175032273727, -0.3160632884307434, -0.8351365347097525, -0.8522230975530687, -1.0761576690115124, -0.39209178582671816, -0.8702757951462464, -0.2724947973907009, -1.4365622128816602, -1.5906612219463594, -1.6130843660596146, -0.16140796128947493, -0.6831276692956767, -1.8542952312973757, -0.895752418557672, 0.6476461016257187, -0.8803557554694678, 0.5208482365649091, -1.1042234333679997, -0.9198815573577147, -1.826069386252783, -0.9265688637644993, -0.9710402040115336, 0.19451185744954338, -1.3350442905158215, -0.7055211008738852, -0.9963675605638228},
    {0.35758506863541506, -0.747337707213895, -0.4561668301578492, -1.0822166855727968, -1.3575581267355072, -1.0391016188154973, 0.19197064039599107, -0.5048772292298622, 0.7316969647871654, 0.9038709673256585, -0.6106363665491695, -1.1812027408659969, -0.129626407384772, 0.015731385933644426, -0.46045671630157714, -1.5061209859068725, 0.23871999306026548, 0.36466611300333407, 0.7119824523063808, -1.5554375918466306, -0.3619108530048549, 0.1481536348081368, 0.9296502693047168, -1.3782960815389549, -0.19578803868762534, 1.0248090324853643, -0.22454294413091438, 0.6097916424724821, -0.8813039326308596, 0.0283648991827138, -0.6844247846349203, -0.09088718616299117, -1.2367447010682113, -0.6021116310136765, -0.7285262877055171, 0.3941008806895996, 0.11136505124140596, -1.2322929573706427, -0.6678896016495943, -0.11415607828520237, 0.8442056660413297, -1.0093340786312666, -0.6534436900676251, 0.9765512552786368, -0.7921738301103655, -1.4870238556946211, -1.6378346880486072, -0.7773537262853507, -0.009986356445852976, -0.4679033277786089, -0.6564085428944033, 0.6363221328880854, 0.12277511934165, -0.6818804772574225, -0.47962156880640117, -1.0483078640271826, -0.4210821575835655, -0.9034337002699758, -0.5122390703355838, 0.7295624899614404, 0.3142356105978104, -1.3772130400813016, -0.10851394094983871, -0.8668537555128519},
    {0.11991117134222977, -0.9635074163707293, -0.7984195295661503, -0.531715091276896, -0.24983598355713074, 0.27663647429228233, 0.6244912507759774, -0.6717436922095646, 0.30765308205598557, -0.4584103222654069, -0.45804693058489904, -0.563045841040508, -1.3049947466361873, 1.2554984755565726, 0.24055425480835874, -1.9336465661724218, 1.0525823792692113, -0.3330104954760729, -0.29657858815122123, -0.41907278060775716, -0.5426452325588826, -0.1688025957659397, -0.7409941141215756, -0.5713679916144003, -0.7993672984028097, -0.67259675432587, -1.1560715578665486, 0.5760127855929158, 0.7209746989263323, -1.096160814188923, -0.31713856730843326, -1.3174104320038837, -0.18028934713730882, -1.2376938763224379, 0.6586861564414691, -0.9359938681963861, -0.6526529245993441, -1.002861179577762, -0.2883447843840178, -1.7486609010785612, 0.5397321822051666, -1.7941392490729267, -0.8350663469916916, -0.4297449471099675, 0.767804726056305, -0.5860049202311465, -1.4554686294702417, 0.5631642793334747, -1.3060820921293446, 0.17221539075880005, -1.7165320747169368, -0.07390224752993634, 0.38012134159035804, 0.22837609810239243, 0.8888680459250956, -0.8047123592423732, 0.2971561856983166, -0.055103531992579176, -0.14014313235231826, 0.5399108696236317, 0.2598987806547027, -0.06356929144450338, 0.3901478876702964, -0.4910633035658666},
    {0.8771139733194311, 0.28511189103433215, -0.09865018280394222, 0.8137532151442859, 0.6916059888208695, 0.6101144051999838, -0.18453439874318528, 0.07736024546585041, -0.785493318526781, -0.7289832147627596, 1.099542665840818, -0.41364277223878587, -0.341465065565029, -0.44290616941058114, -0.2548646968337831, 1.2736717681387175, -0.9296267298710873, -0.9573565643049113, 0.6312279115776567, -0.13813266410776565, 0.5339587454094079, 0.7126167388654002, -0.2961795780514619, 0.9539222000280215, 0.6581888515369131, -0.3388232378304756, 1.1677846767210625, -0.6247418943753369, -0.797866461712076, -1.4503989448330192, 0.6979381895679331, 0.4329285819840785, 0.9431081759850254, 0.7712334455181776, 0.4898808418064506, 0.32810020015113595, -0.07845021756236727, -0.6785248754917846, -0.7512559362985542, 0.922215199351344, -0.6534272278046285, -0.8356874614861609, 0.4651657638483412, 0.93517302843177, -1.230201832200565, -0.6244868703938269, 0.6979095350594048, 0.8408416348937828, 0.16784602977409557, 0.5050525590452615, 0.9946188048909353, 0.7546095990921597, 0.4233139586639122, -0.9098959131140815, 0.9655363147765869, 0.17874285426114148, 0.16867725833132313, 0.1852288327732151, 1.0262461825871292, 0.5199803939721533, 0.7636878749050499, -0.47676346959659943, 1.2210551646892733, -0.34456935082704077},
    {0.5476627775736509, 0.873883365546649, 0.16910100937212005, -0.561589898867787, 0.29116743426439456, 1.146696604160951, -0.8545029138297177, 0.3343111238033696, 0.5685047484474083, -0.10175930509081028, -0.8743278005486418, -0.817947195154849, -0.21488666277574636, -0.9519561832436472, -0.8199818385046775, 0.0012018070535497864, 0.667117971631998, -0.6347402956353806, -1.1408176516603712, 0.8862398129001321, 0.060570096847551685, 0.2304310843902114, 0.4265715459137609, -0.17465263720062704, -1.3244962068203212, 0.3878126402282213, -0.44269610375262025, 0.6351699527394827, -1.2707076705239893, -1.5525411337987558, 0.7522381805053738, -0.2350126067664687, 0.6382731496228202, 0.8960988325280056, -0.017549774651807525, -1.1430094997442108, -0.7745508960967027, -1.0863681309154625, -1.3468828361031728, 0.9658453321281928, 1.1816106867209197, 0.3653468924553551, 0.4276266571864035, -0.7679580897530589, 0.3510583504103963, 0.7994022195605972, 0.36178153966052384, -0.8233626493589228, 1.1629398049326232, 1.125800350049891, 0.4218775725911867, -0.3393185618611097, 0.29894018164255376, -0.14564776807203994, 0.34772936850747344, 0.3017390772870133, 0.5845205473546201, 0.742503271486682, 0.050598961291747076, -0.71579478090804, 0.6526513424303586, -0.2567102861925363, 0.7669972517826749, 0.2664185725778844},
    {0.9248694413935695, 0.7142972136731723, -0.28649134116026437, -0.18323962314570003, -0.7333754028819005, -0.28076615370171193, 0.43761344571134053, -0.3186104753438061, -0.3660551969596136, -1.0400969586068856, 0.6362417428553467, -0.2778984461892718, -0.8366281289614375, -0.3358053835714935, -0.9057614917957748, -0.6517367785566401, -0.3837782481769245, 0.7691972348114068, -0.940808873218062, 0.4263885914158446, 0.9021765914571065, 0.46244476486958863, -0.722165351489528, -0.9330604517385447, -1.3196295401814535, 0.6600203004994246, -0.45517698257700423, -0.16269324378454808, -1.0675693939518267, -1.6579582612789971, 1.0786031525381863, 0.5594462738597321, 1.0531174410527164, -1.2430025051820452, -0.03484534474662071, -0.6647384559332744, 0.8090703334835483, 0.10521140398791172, 0.4434748561682969, -0.3342666892757265, 1.256789431255759, 0.1344693903037632, -0.347048063278402, -1.3624703368353426, -0.8878788709688041, -0.5099591354094462, -0.3496075402597619, -1.0840823237253108, 0.8550971176120357, -0.27688485326357254, 0.08610258230833757, -0.7333206847073993, 0.5159649750797013, -0.9742260629097417, 0.6222151093867685, -0.3728202058261451, -0.28362217910226767, -0.661671408074044, 1.2084533098526966, -0.5314848552004162, -0.335564282552454, -0.534491197758573, 0.03191691814254874, 1.0301338553607968},
    {-0.5275397405081386, -0.9202930409493737, 0.08160894730184463, 0.9947098944150092, -1.0693856504580537, 0.7302024731241102, -1.417943221536108, 0.022108520937438803, 0.4590818482066106, -0.16874635610790728, -0.9037342153721657, 0.14997639573752472, -0.7522811369653094, -0.8217749110104199, 0.31528437760302375, 0.9810908033732835, 0.985866295821419, -1.0557662868684277, -0.42767658716186485, -0.7674491971323872, 1.1306814584382148, -0.4862555722911176, -0.7741930040897996, 0.21047220232470423, -0.5381303707651435, -0.5079861992469904, 1.0091850322893738, -0.07596299852608297, 0.11661428865066327, -0.6629181949354562, -0.3964482342410331, 1.286659705173887, -0.4615610362800414, -0.36473065817046907, -0.5582889754500769, -0.8104766103087399, 0.7566078327012601, 0.3938479974750779, -1.087057906773376, -0.9873774732880959, 1.4903679364394695, 0.9234922332062665, 1.2330735128305823, 0.30196713802813263, -0.9668323682355715, 1.1623791681474047, -0.7845537088056611, -1.1840412013558985, 1.1923047440083152, -0.30767703393854795, 1.4790205499350628, 1.1873923782481257, 0.6595720253135704, -0.44470480059914774, 0.7946790731182476, 0.549314683512767, 0.38917547922159057, -0.3528081428766093, -0.32624436872152685, -0.20596429180036063, -0.07999943342209977, 0.5402544691762744, -0.11673937033234935, 0.9015932153377655},
    {0.0009038195536110793, -0.017850552518915132, 0.1878650626796801, -0.9458679208656824, -0.9783884513220736, 0.19147128295372742, -0.1959986361067211, 0.10885490893128957, 1.05423397129883, 0.19917377383224863, -0.10450655344702864, -0.8173880176435251, 0.702420733214972, 0.6733396241044365, 1.171807743530669, 0.8601489797102378, -0.44431406237349785, -0.37604193917042683, -0.6036790623751341, -0.2168934816835857, -0.5450188436647323, -0.47985976972871747, 0.05352679854416246, 0.3530374608700963, -1.0374918143044372, -0.28538397442455876, 0.5831802207899103, -0.12455524319975364, -0.9868381378567351, -1.5391394303812331, 0.20790055466836263, 1.35398566640948, -0.7877575735421232, -0.9923177639304628, 0.43873901599843906, -0.02860425072993993, 0.7773570041585273, -0.24098730482986322, -1.084421094282724, 1.1879367170207975, 1.2915890823864802, 1.041258889122224, 0.5306345103672341, -0.442128920812959, -0.7884686872556251, -0.2566898209004706, -0.32183946009392406, -1.0844413714045864, 1.1532976803026591, -0.9504041854483226, 1.3943640626950196, 0.9047170730580413, -0.6234886446114624, -1.148186400925798, 1.0644815099064486, 0.2107341559118511, 1.1385612989989111, 0.5427067256452299, 0.9226474874958153, 0.04562554018076912, -0.567797040349839, 0.823102010164806, 0.7452028267520897, 0.047949764050742145},
    {0.19863922474369688, -0.4062776705863105, 0.6352946131376898, -1.468110074339899, -1.355880110283321, -0.5795833639852864, -1.5720378371032278, 0.6467262938174649, 1.390519306537454, -1.0733896772720877, 0.7077184163623624, 0.17583493381398208, -0.3000134939155257, -1.1185734830797132, 0.7037323632418676, 0.42954037542522383, 0.9923389905090821, 0.8902350074563072, 0.6529465169745717, 0.14435643691036826, 0.3735116862542341, -0.5635957424323936, -0.7046508605815541, -0.9929089814136751, -1.452454064277702, 0.8600354154005174, -0.6101858996223177, -0.05393523741372558, -0.19466369777867917, -0.39374321185981176, 0.2769466638066062, -0.24992584894574543, 0.048363175599736304, -0.010313791835756606, 0.8317051550693522, -0.14551447253179722, 0.45776095903594594, -0.3604783251890197, 0.16721987330546062, 0.20694167806479763, 1.338494384441558, 1.0227141145063166, 0.47859255699060027, -0.6503296521734275, 0.13685840441658972, -0.7003075839733904, -0.9222795480122732, -0.09792373455609744, 0.3711832143149155, 0.5529680499882614, 0.5848607959529591, 0.3571910083866659, 1.029692630177017, -0.4194903063348697, 0.7845238910617947, -0.666728997463598, 0.7488874417899279, 0.6094816741798779, 1.180007477422535, -0.01720177191522378, -1.2169914722355464, 1.144765590985978, -0.6938766897103952, -0.438892335125978},
    {-0.25726873397320105, 0.546504373362218, 0.004632289151713441, -0.8082686011869507, -0.15685753782837117, 0.6954129714486107, -1.0737074980730785, 0.3415034825893897, 1.0999962570755024, -0.5754475620346946, -0.27471308284922136, 0.9172202783830444, -0.10446180023358352, -1.2524506285480281, -0.13957126446283652, 1.227712373051898, 0.5566737966400422, -0.5173084092133493, -0.4069688098336946, 0.4086429888583087, 0.5655129491150772, -0.8700076877693681, -0.6285068108546592, -1.295985972465142, 0.12645856965785907, 0.8081451199657379, 0.3932215885279849, -0.616028918038632, 0.23789305834991603, -1.3123317337169365, -0.7963115361770664, 0.4879723941305026, 0.7417776018562658, 0.6276500371002365, -0.5800079163851016, -0.7977068128929625, -0.22292306646734678, -0.22942602846634402, -0.874538940231502, 0.24614681902115382, -0.27041895241606523, 1.1127252622426824, 0.18874395217110193, 0.617636616213469, 0.4365260088336256, 0.6510311135037957, -0.4458139759990165, 0.44667768572375205, -0.533127341624219, 1.0569390624736077, 0.970187139568504, -0.7715000739334918, 0.295331681517181, -1.282768723054214, -0.6480401696431235, -0.30526205489442504, -0.06892210083673471, 0.9838204253782517, -0.23725059597329246, 0.600678219842122, -0.017710226809822302, 1.1506170822094461, 0.021837586996449315, 0.7776440277450184},
    {1.3415618963552551, -0.3479171362129762, -0.6591018723347584, -1.3578586241906676, -1.300157913325666, 1.2347671065814172, -0.9054499728033336, -0.8071632753265311, 0.9964388017462587, -1.1090358108981633, -0.012465112585967998, 0.6620195900663136, -0.8392990938883873, 0.5605294184866637, 0.949587366892645, -0.5720268715816889, 0.19082418067344767, -1.1174176328082903, -0.3393885893336289, -0.42503583902486775, 0.9167562795410233, -0.05983777888706943, 0.6551129057156404, -1.1318575880247614, -0.31879255424819847, -0.27850991238104, 0.1954822634960232, -1.2688434565687527, -1.3403696693514244, 0.08590487238030137, 0.6700525243702469, 1.595049360076696, 0.6892564289322138, 0.48424347411004615, -0.5205252796204822, -1.1528600107618006, 0.17387635508654162, 0.13716821637375254, -0.7307088677903324, 1.1141475543679737, 1.3595811392252082, 0.820601537388735, 1.327018013871129, -1.323144638821964, -1.2669988061364168, 0.03613305947630255, -0.8414320224618708, 0.3452536361244238, 1.1925077599220701, 0.432216338120679, -0.6674934213740809, -0.46449219677045067, 0.18773892937264816, 0.35723509328546094, 0.27576552301255863, 0.40467073671020554, -0.8955867804751317, 1.1030010627588205, 0.747376327462165, -0.38117167784577066, -0.0270399178159064, 0.5521647095881839, 0.7340108246003507, 1.1631929004845067},
    {0.4851009821267007, 0.689640541307999, 0.6047852274048136, -0.35542252851384964, -0.6968989282199028, 1.1999806109795617, -0.7888564016170656, 0.7384357466329379, -0.6936383929111057, -0.004182045194096302, 0.5349492051647057, -0.77833670565623, -0.474555302325571, -0.7990845393694692, -0.230452604579801, -0.41450917140409266, 1.041410075506381, -1.1330352230372394, -0.5957125905877217, -0.3063634374305529, -0.03765184406830715, 0.49592026252868215, -0.1808057844350322, 0.23644900360281773, -1.3440192867428353, -0.9360177110991528, 0.3072082213337669, -1.066210113147421, -0.8419907596978455, -0.11166853743480326, 0.29426677083284297, 1.760111809470239, -0.9938353704779401, -0.5367754446847716, 0.5293069830753865, 0.7944316840211616, -0.18356696462701577, -0.9638795369158787, -0.2573825754444258, 0.5732672243229873, 1.5519703298784508, 0.4509197119498605, 0.36258229999732333, 0.481160464325482, -0.6295936174890179, -0.6016764572074894, -0.7702136821688924, -1.3205509343971609, -0.31085974880225736, -0.7081953489115224, 1.3718784366080254, -0.7446353443047157, 0.9086334725720645, -0.3869729580734372, -0.195820342102934, -0.5256280429753141, 0.9721059257614093, 0.6152964831902799, -0.3558394031207122, 0.025499882707486144, -0.20367988463493952, 0.1554884791857418, 0.20969548534814558, 0.47129390367018},
    {1.4416761476511124, -0.6787695601791097, 1.3664568578248006, -0.9395674783667977, -0.13519049581634854, 0.8859805361881696, 0.37324958064469305, -0.3628823923004511, -0.5554541729910296, -0.4102315688125606, -0.02156153765548911, 0.8985620532931365, -0.513127792824097, -0.3270298768775508, -0.7254339548933356, -0.18211431479107773, 0.4487859499471287, 0.27825802720549686, 0.7190501472221705, -0.8726403763017738, 0.08749498769347491, -0.8702888001760318, 0.538707484724807, -0.6801060186815207, -0.7814360333700999, -0.05113335589308578, -0.6602318927927581, -0.9355082990408696, -1.4172438455394771, -0.682997012704396, 0.6276472395435823, 1.086588049072288, -0.7208961016552469, -0.3909344982354983, 0.5932151286258516, 0.12110498719991665, -0.32705254493294855, 0.5861454908257961, 0.42816224643061335, -0.3579246871900213, 1.3313387401146097, 0.984887709325563, 1.3192944533746798, -1.2793208562636287, -0.3558981120337651, 0.7177764315446615, -0.7799677577037362, -0.06960415610168111, 0.08648476605322838, -0.14866432947707103, 0.24592986961518998, -0.42935863442390604, -0.5810267159418513, -0.9105280037393647, 0.8638704990590984, 0.6446710641843465, 0.42482136585174884, 0.25078122838353173, 0.9255534386179077, -0.8992854126680642, 0.739403915585449, -0.4782264088178781, 0.8517024496163447, 1.3498447850335238},
    {1.3258608635536553, -0.4135028243208026, -0.8750594879360672, -0.20995152074823173, -0.07410884114677498, 1.2332834071440817, -1.385061475540202, 0.26472399607011027, 0.6122817295573623, 0.21864634736262553, 0.027990917182407933, 0.3916319298973981, 0.5984320792190813, -0.9876977366630896, 1.0245228204788503, -0.033859759545032966, -0.19390767877891454, -0.854101134619858, -0.9500834891784625, -0.9272290406388833, 1.293490505574293, -1.2368736467674553, 0.11790202073623124, -0.0844707362036028, -0.611623138549412, 0.10810760035274608, 0.8217997818952617, 0.916410264317789, -0.15325630498378343, -0.9178962087461268, 1.3220650657565405, 0.32579622788203, -0.5491619767460636, -0.10672277560280768, 1.4130937440833218, -0.9310599178259462, -0.1203713906887913, -0.7458303921030984, -1.1006135854780819, 0.82894213777539, 1.46831142425524, 0.632021418442462, -0.7465428049689976, 0.6520399801751974, 0.849891680590171, 0.731538256921592, 0.425289242521322, -0.8288568272272759, -1.118069722131362, 0.5521104474325277, 0.3354043740935742, 0.07574722761183163, 0.016441876909831246, -0.019465754182470128, -0.1708227683780972, 1.1083528376940197, -0.21159560229600852, 0.8260294041449714, -0.00929398058693362, 0.46353002093815093, -0.7341302130073665, -0.3928859990372661, 0.3995053727656488, -0.3462042935973541},
    {0.3954241367653336, 0.3248784113710196, -0.5897684596261508, -1.0782541806939887, 0.1658552774225413, -0.48882138321783164, -1.7085823961120807, -0.9167106097349569, -0.503975671859051, 0.14386986459438383, -0.5808649872541917, -0.8236511412106243, -0.141062050049957, -0.2751855358293354, 0.5185400774567682, 0.5374685523988184, 0.11461454503040482, -0.3106006747619458, -0.001976651030742678, 0.744061574496839, -0.03431676447507571, 0.10441385574041691, 0.4867937576749917, -0.8298856838913072, -0.030181031391076283, -0.4560789933189987, -0.07872315256711097, 0.47627802663601027, -0.7415240764663876, -0.6551858524323457, 0.5765919564458487, 1.6323976381007064, 0.7508990046914947, -0.511715988445994, 0.1079394109885454, -0.8439479558083898, 0.32776593881964483, 0.7892526956808269, -1.0237166026499631, 0.31225073831742073, 1.197867421793983, 0.2597381141251404, 0.22056459510574475, -0.3627777355991873, -0.6478319030812959, -0.43342527038409423, 1.062688462623938, -0.05973417469974583, -0.5351452392893805, -0.9268657489927813, 0.31021727485223066, 1.1629102485845808, 0.5985716730465876, -0.3804765090750739, -0.41321777976453333, -0.6411319920784485, 0.6109481297422186, -0.20236039852332094, 0.3861630506547294, -0.2768516320749735, -0.9874127918393982, -0.9277563699317806, 0.8477018642137161, -0.22666411204493567},
    {-0.19288411594969174, -0.8459516855512255, 1.139729946114619, -0.4498936876039989, -1.2086969482960697, 0.23695138483685466, -0.39773831952372607, -0.27749755242699853, 0.6501404940399746, -0.7786242643932878, 0.15469490499197025, -0.15489820397681728, -0.7112665122599356, 0.6591261913510857, -0.5295830977128109, 1.0804181637580108, -0.24937183348099187, 0.8846699449744485, -1.233654133404602, 0.8807549641093998, 1.0400253781648006, 0.5605395573259219, 0.09863648681779133, -0.622406591309195, -1.0582025485014723, -0.772079101536384, 0.9096163762173989, 0.7839349742309987, 0.22858404638500987, 0.04305884766053346, -0.3291507754883532, 0.8240023721601322, 0.18602290699012555, -0.6757580882688046, 1.1341070986248363, 0.4438402617199886, 0.4247898360530962, 0.892103428571737, -0.9360488120642005, -0.2708936758209335, 1.0917322606900315, -0.11995026543911896, -0.5231382859418466, -0.45587517388747395, 0.10061029910695964, -0.8272120055030464, 0.9639190373727828, -1.4698278321321032, 0.42680486567964043, -0.8727216927847029, 1.1286502632189255, -0.0947652732550805, -0.7945974680526832, -0.162826472545724, 1.1633985633259165, 1.1184933842840188, 1.2041030320662622, -0.5268941228052795, -0.32717430100933176, -0.9080178493238403, 0.13779040341027246, -0.0199245187156692, 0.04873701140355926, 1.3208375311386402},
    {0.708258704421787, 0.8366133395479167, 0.6373580302029472, -1.1654855208902706, -0.9814790766776169, 0.6559684819359015, -1.4642749577356957, 0.027996474994212137, 0.871475373639262, 0.12544386583140282, 0.6177211712934849, -0.89462216242553, 0.6778914961025853, 0.45783255798685574, 0.13399630123025985, 1.35724854570578, 0.7624250141709065, -0.5465303355956926, -0.9101424957473051, -0.13333347864830003, 0.7663051692182719, -0.6674003879627469, 0.750866168042178, 0.2545160074048859, 0.6769830183465051, -0.5051489090444478, 0.815506688267756, -0.2890138993050887, -1.2037300581547072, -1.4361334385709843, -0.15437059035084152, 0.1781753449948365, -0.7997503130244219, -1.1207724134006127, -0.243482827993974, -0.7194859873071925, -1.0511780331031506, 0.09690707815584813, 0.6352107085403008, -0.17292664341301944, -0.09827975390889077, 0.9766017913669388, 0.6730405107397831, -0.241847252657368, 0.5316078355502135, 0.1273826561902181, 0.9295530398944641, -1.4852586951937963, -0.7622323479853111, -0.5843414514675032, -0.17785605010124342, -0.26215393752655886, 0.8522071973305361, -0.4161120841863738, 0.18076266204508815, -0.9080451286776634, 0.9182754223985352, -0.24527773647041004, -0.14959178376973387, -0.06854849837533547, 0.6963489062958994, 0.45892969799044175, -0.6296350895171018, -0.31569854007060477},
    {1.1394951658769905, 0.3800969765550366, 0.4018816576805182, 0.5215100799354865, -0.24029830821298911, -0.3195077439694494, -0.5680519514563916, -1.3572758598613113, -0.1376635486491272, -0.7233981191492875, 0.916983665695543, -0.6432792503239074, 0.5003818278678559, -1.0445630038656764, -0.08005209365594106, 0.011356869358726176, -0.14806816436990436, 0.9488736649238995, -0.39427757974242394, -0.20782699740456018, -0.027666201756348187, -1.1116155203682305, 0.7543458948281373, 0.41468806098952116, -0.9954107952224134, -1.0172390356689227, 0.2961991885184823, 0.48363589226810005, 0.18262161943895502, -1.624368858855556, -0.045110814907682976, 1.3041971727087998, -0.2575651938564911, -0.5367243981068979, 0.5562790827177039, -1.1957227502246208, 0.024978003924310665, 0.8045762779335113, -0.749628348251183, 0.5060811884409162, 0.3799106845339562, 0.6636121337388374, 0.17706843274891323, 0.2786285190857136, 0.20016307437077244, -0.23262286735210055, -0.5350736763407029, 0.13929573767477837, -0.8786487769048563, 0.08873235702098729, -0.4087343719175212, 0.8075293478753673, 0.15084014626663225, -1.0892866219990218, 1.221435879021638, -0.8868435047098765, -0.13320082644605918, 0.6254161918638355, -0.6216101815918479, -1.2148225189590545, 0.4105972351864563, 0.424214338455454, -0.03741609360809847, 0.6803081079187489},
    {1.462835128809784, -0.1753891839788104, -0.6745648350270357, 1.004606865537478, 0.5323889673910968, 1.1585932063522713, -0.8586021231985507, -0.5570520717660119, -0.2789943778318313, -1.3225496191678698, 0.9466842429831592, 1.091214716425509, 0.2118807491989935, -0.6400241712311177, 0.9421019998773734, -0.03439203647193751, -0.21704987780415616, 0.6183933661480362, -0.4726527017501025, 0.3411712571582398, 0.0684135453017795, -0.24566479099938307, -0.5360929534894665, -0.03218089141855314, 0.5388735397311617, 0.13973035844048223, -0.6831232537840818, -0.4888237425043812, -0.9999687544078442, 0.45855787569480366, -0.7483138870478083, 0.909815659554759, -0.7928252087142756, -0.012910333484570331, 1.184107547165222, -1.031126378531458, -1.1573998307539148, 0.1573572680382262, -0.683377757825859, -0.9864069498446927, 0.5500251708709948, -0.25554884970939884, -0.6599116555114767, -1.1252786627146298, -0.016402128171940308, -0.0047870939834358936, -0.1967955053163904, -1.2243602333003738, 1.1794390217447286, -0.6402142499455629, -0.18996803831068734, 1.066030348992418, 0.1948726075909209, -0.4671800333006626, -0.6777390478934258, 0.9277793695525297, 0.06399424491451611, 1.1734245567153692, -0.13931652864949054, 0.23160571760803209, -0.6151029206911186, -0.4406966310099636, -0.27113830237571135, -0.46907088028948274},
    {0.015813252313652472, -0.09107392979955031, 1.035270802085803, 0.8181640991078012, -0.6631831535304732, 0.5585671978235808, -0.16634785626519732, 0.2224104823516151, 0.8996161580647594, 0.08928074439102382, -0.7468056628359999, 1.074445603512068, -0.9090255192075531, 0.1855533087572183, -0.35220243482222136, 0.1732456325451788, -0.23995859755411314, 0.9006568866334933, -0.5149840924535449, 0.027155902682138282, 1.1348719703012908, -1.155965410953413, 0.37655431317851, 0.7586428201267036, 0.38339554188138464, 0.052073779420866106, 0.7765009228588529, -0.17158522291458278, -0.6904429634520262, 0.23849965618387464, 0.15442601279643814, 0.4287448459308951, 0.3910406050993487, -0.37201855508739134, 0.6662700244575956, 0.0247895259761268, -0.4863485897882395, -0.5195570814155414, -1.4363806153807035, -0.3412853783680786, -0.19114107515862352, 1.1664526725412434, 1.054472559323228, -0.20865432602272507, -1.0749511613590899, -0.13645941286041344, 0.6381855783178882, 0.3218695683763684, -0.5472218985285652, -0.39316590391213, 0.964665129401406, 0.15216570068493387, -0.39259623959739576, -0.1365288570510572, 1.1429478411285527, 0.1761544655386321, 1.01907554599274, 1.1235595079174205, 0.9478421577402958, -0.8371973648594724, 0.20254549647525322, 0.5411155150123409, 0.21726281193143068, 0.1806736134918338},
    {-0.06494859228901798, -0.3072453904629296, 0.34753871389672475, -0.010842815920437695, -0.8667852820232872, -0.12071720307377469, -1.3893808661772364, -1.2233317191971418, -0.38966549530065075, 0.0025374317682276856, 0.8749547833016825, -0.5626092550968559, 0.04477097999618861, 0.8338775274120511, -0.7133546179184637, -0.17684070854106473, 1.0133674914504034, -0.14726882141643508, 0.7239920629787592, 0.3732068000291465, 0.5119888784446864, -1.4205471457217174, 0.47504987557290085, 1.0493994739424988, 0.14877124486230558, 0.838521551105428, -0.18087996339513918, -0.5822287651294469, -0.6944438543051747, -0.3905209322727723, 1.0339655609755454, 1.308829549991596, -1.0386699240520472, 0.042768631993675615, -0.0972816579684761, 0.2194692372094547, -0.968413651342175, 0.6545345073551462, 0.21132086051124813, -0.4135053184886571, 1.1104788120313203, 1.471772280295395, 0.01179294813709016, -1.2040594207784374, -0.5980235810809821, 0.9480062588329675, -0.3608684799796442, -1.0094743454424968, 0.8795042220539975, -0.18048492314676137, -0.10287723773770577, 1.3009235385894484, 0.40333422025727333, -0.7000379673439562, -0.688450999393326, 0.7723659328064704, -0.18202570505831425, -0.21179662436822377, 1.1874888413775042, 0.07417292280116573, -1.0887225735232382, 1.0618950572382742, -0.5796002133368435, -0.367486625417021},
    {1.1420531031715035, 0.7776130343956502, 0.04634728780150547, 0.18490495151882674, -0.5536794579240842, 0.20406114050462903, -0.8202169171471538, -0.0038233260100209924, 0.7893564245566302, -0.9763829612906126, 0.005627745596728366, 0.9816657976401576, 0.8728837685696138, -0.6115751316739525, -0.681661347321093, 0.420323668426467, 0.1812178087302554, 0.2111892868133902, -0.2760139177502101, 0.8979980189680726, 1.2644118439509475, -0.9512527511738361, 0.5048131593178351, 0.12644775603788272, -1.0488803318527429, 0.4291537656202971, 0.776740698261783, 0.08661776248876556, -1.1424903284739105, -0.4965011708618985, 1.200423626050718, 0.3393885224947325, -0.7978780724091928, -0.1799182566175079, 1.5283973923552991, -0.11589355096763618, -1.220555042966663, 0.693936068223579, 0.5600734545868145, -0.7674437845520642, 0.17076088738173859, 0.23498497907639607, 1.2192203557694103, -0.878237363327607, -0.6643433376308255, 0.9918459458408001, -0.7996025760487423, -0.5761406673392168, 0.6351594846175825, 0.1280978595795098, 1.277565077432014, 0.9211454039529172, 0.8081698761105369, 0.8235258268152259, 0.26510793284039424, 0.5996806165696984, 0.16395562547956952, 0.5787193574857126, -0.46335124695905966, -1.591055101882045, -1.0181887735839157, 0.19950635393596278, -0.5465363683881164, 0.047760505730506504},
    {0.6484928655199069, -0.15264535405179325, 1.2769434514853863, -0.9254962041520736, -0.4278499272459985, 0.6956642363443416, -1.3047828193929163, -0.7389798251199418, 0.3534732047760316, -0.4439266975968411, 1.1717499450390998, -0.7403387392322307, -0.4614150003534835, 0.6414434067581257, -0.4703518268553735, 1.12254991448228, 0.29492634094659176, -0.28463291431855225, -0.5193643048268968, 1.0879418414736572, 0.9677256539742897, -1.5072606201434826, 0.2349161120508089, 0.25589715155564435, -0.18823628644992785, 0.5235837288586973, 0.15993441951964135, -0.7136930030499398, -0.9257018257896292, -1.0651007704684243, 0.8946791565506312, 0.248024834520658, 1.2116543680682859, -0.2462464632806251, 0.6615103480276656, 0.5596539130054905, 0.642990732442121, 1.1749967555886454, -1.3060847551798471, 0.8498566256651177, 0.025863568213474217, 0.8009820145786755, -0.5485188249003404, -1.3509491129984423, -0.6169999540702162, 0.4561158202204156, -0.8575407925758091, -0.7410142069011586, -0.4848554990925497, 0.6819374090565791, 0.12299648963047956, 0.13732302474483957, 1.0226573854714236, -0.1443554547465514, 1.0572780044661987, 0.7491429962011108, 1.0265307025437391, 0.7020054116045965, 0.5457211917651958, -1.1970641201064134, -0.9792190259246919, -0.6266098830689009, -0.36376839701235075, 0.8022567545936329},
    {1.4294087373893134, -0.8294193588930042, 0.9797522483646567, 0.6123938526638951, -0.28890442384024406, 0.007483317987588513, -0.21591828736583746, -0.929018764098762, 0.8819760122216838, -0.013618648745881866, -0.30352483889407567, -0.14249758457388573, -1.0803483579422624, -0.07870680434090493, -0.7804142422991303, 1.2464346462019529, -0.9364373233424613, 1.2314264771328984, -0.20601673533546583, -0.2004922507862108, -0.23701960429230812, -0.5942269271451966, 0.6914831658619303, -0.5762730887198991, -0.34727394706756065, -0.7879006935034858, 1.392225409813053, -0.40169333664625667, -1.0862126738689082, -1.1651864011034523, 0.23730941445305329, 0.6522075226648846, 0.6035428535128172, -1.2927314229170674, 0.026697926852747494, -0.8748115956582072, -0.4539096405867204, -0.3983777398540407, -1.0355977341430924, 0.6908928654946035, -0.4237019142368877, 1.0178206565976768, 0.07032869153003742, -0.4061225287957615, 0.10248053175566466, -0.772876643134452, 0.49921499982059303, -1.1359777281584247, 0.7219588761137089, -0.8482556573947876, 1.5321726540841474, 0.9456056147057333, 0.5397553529902815, 0.40482270513715135, 1.0999841564508817, -0.25301677739400597, 0.6215298388889043, 1.0924418975725048, 0.11326153905761926, -1.0318275967578823, -1.0872767588545675, 0.030224081371247418, 0.7901084110027284, 0.020117434948860303},
    {-0.27208345069940976, 0.03759967546287074, -0.004816919581707551, 1.2134644151757148, -0.9325112438661026, 0.5096395279186258, -1.7042676792493965, -0.6603757330332872, -0.7617364080868455, -0.2787552190849364, -0.11546195435051404, 1.469742703624439, 0.6549519393525157, 0.6763056693600965, 0.8942643210003048, 0.22330185530421667, -0.6725933244890626, -0.26736755404926255, -0.023406686768594878, -0.5011045882353339, 0.277741636348013, -1.2732501724763883, 0.4099909883321683, 0.44864620083740947, -0.6205505627740806, -0.8756255618798636, -0.014139327840662694, -0.6987497541406116, -1.4384531879596456, -0.6254650292979438, 1.1189940047759774, 1.1436126911379565, 0.07516649087685662, -1.2452532074671192, 0.7730380311542111, -0.3668048628685871, -0.8818870738420294, -0.1662066331427409, -0.9123142637414102, 0.5661969610183294, 0.2727859868273926, 1.4437702013114424, -0.5127317433842721, -1.2845487704119398, 0.47714907693714365, 1.4597416098991511, 1.111533168044173, 0.1244685747840902, 0.6704085111511904, -0.042860952231879273, 1.1121817104115201, 1.5400612104351024, 0.3924025571557399, 0.37087520444315475, -0.25872117442492765, 0.08443736545955834, -1.0329199260643307, -0.2216065405103556, 0.6064024092212148, -0.7445680368400098, -1.4207276410337242, 0.24937629281689178, 0.33272275702904947, -0.329301838253525},
    {-0.05200347053259306, 0.8931926611951829, 1.0026905059315816, 0.42096566817498465, -1.2165323365492469, 0.2675655642515955, -1.0925515530254584, -0.837517874612909, -0.00952870838498029, -0.24689227562805963, -0.5512300767092257, 1.1913712189072123, -0.3182407789194334, 0.939020673250121, -0.06284561704023912, -0.21268800521443562, -0.7691028854130835, 1.1321378586263717, 0.3005032485550268, -0.31288790086566215, -0.433300780708554, -1.1465431756547224, -0.7705238045213093, 0.6446778746446463, -1.3208852801101998, -0.9500797569863829, 0.8709076473011764, -1.2177493558203902, -1.3839722301508295, -0.3442642003609794, -0.2431122468824352, 1.4091665414022234, -0.43390784149930334, -0.8199004443149991, 1.0264442602384647, -0.2149898620792579, 0.11967053613235658, -0.5844688124427181, 0.2732430998053, 1.0233896317481876, -0.7116094662450065, 0.6937454113046606, -0.1595862951374193, -0.4923638507468214, -0.35646313225072057, 1.4858071142449003, 0.1663801549609171, -0.47978393716753903, 0.9768873918507751, -0.21795829568191497, 0.8363498262503227, 1.5169978441556515, -0.0041362759084760245, -0.08307013013532628, 1.158224374082214, 0.6109576652237758, -1.060542720417177, 1.1616444699520274, 0.5052193233318287, 0.347037116613531, -0.28238333246895436, 0.3270354940031679, 1.2294088977456277, 0.6363932322250805},
    {0.19806668427190788, -0.005750905148428705, 1.402388574686744, 0.6860088897737446, -1.4130917189007013, 0.15203327745072703, -1.14911649063191, -0.6936468724165588, 0.9027775606762832, -0.8465843204797412, -0.23285170493626592, 1.4607227653236425, 0.3382239111626452, -0.1053709275892858, 1.0698059251042804, 0.7905391747985671, 0.2326757362194389, 1.3245735959002916, -0.5043464451500184, 0.8613936771554573, 0.6143274565483829, -1.177210987583216, 0.2654770245205027, -0.12280200754017763, 0.13454379022239574, 0.6516284121091578, 0.798328497620204, 0.10899799120241632, -1.1422629033142906, -1.343017969132691, 0.9235147564685953, 1.36043208957395, 0.6367952674941348, -0.8236499368884378, 1.506732597745928, -0.568126277153874, 0.5569192215789661, 1.0042084487621807, -0.14672146712250383, 0.8362811313382101, 0.44028448701943657, -0.029468981782753322, 0.4116019344732963, -0.4961434872473676, -1.404795091687931, 0.45494381220561636, -0.395723042887986, 0.5417826554496855, 0.32309231126256066, 1.0734169950842678, 0.43019426733471033, 0.6004447936870634, 1.2578376676116902, -0.9918210991073311, 0.6504525251568057, -0.8105557340835274, -0.36915440932397153, 1.1267054943676795, 0.5410044019809485, -1.6298052717588156, 0.4372237928233855, 0.7125782039026213, -0.0009076195857778547, 0.7361876495545441},
    {1.1184612727187504, 0.8269510362128657, 0.8681107701801378, 0.33677567181970475, -0.45711134123947045, 0.92535764086004, -1.6718307978869777, -0.11461125939035671, -0.2913175948354912, -0.15626678797261556, 0.8168665914848127, 0.985028765449254, 0.14128196080809555, -1.168501105753332, 0.956522353150714, 0.7338755126805391, 0.8327968443131685, 1.0865681962331681, -1.0216307247039902, -0.7797932728369332, 1.1397855018279353, -0.04398827340294984, 0.06283738728519193, -0.4212340974011562, -1.046117709907686, -0.056582205564232366, 0.4811031013664041, -0.9998726297135065, -1.5388541444075932, -1.399248844812955, -0.6874859909771776, 1.420465401180169, 0.31283769001549966, -0.48166068311931876, 0.8403330890117181, -0.03833168276227708, -0.7435540396029717, -0.4998066037400095, -0.2894229527760531, -0.8326567776931465, 0.13394342728125744, 0.6349942524009067, -0.5930832229373347, -1.325543243518625, -0.10427301052210075, 0.945480231554013, 0.0993924853870575, -1.1029358831578275, 1.0475603025268485, 0.7421714094456834, -0.07407723432587772, 1.4213662591780043, -0.06978738362779394, -0.8714344843617925, 0.9186925048873216, -0.5778675171328626, -0.5640688746981873, 1.1580737599471629, 0.15097766219721762, -0.6014468079117469, 0.015873980582342944, -0.9259356927513707, 0.10218127132586313, 0.37534956381451245},
    {1.5282841889466328, 0.6480413200252368, -0.3968774704628554, 0.36165343064297817, 0.33293875343132007, 1.0993317760382757, -1.393560495283385, -0.2395382664129812, 0.029772104914667467, -1.0075582128256577, 0.6007197957986588, 1.1221584921635892, -1.1944242505576053, 0.3025697567556978, 0.08057685959629587, 0.8139389349374785, 0.5651438861480254, 1.0418933032294295, -1.342479501189157, -0.7376237058979512, 1.3470752557117265, -0.9685538338109987, -0.19800514985267076, -0.005655259771689374, -0.7761448436944648, 0.02096320909955233, 0.17473489001677095, -1.0996148530337897, -0.27100133377731844, 0.12083400544920804, 0.7649441480310835, 0.3312125851228471, -0.21883949794551738, -1.2281499981297495, 0.5518312550187594, 0.10423868694126198, 0.46766013681516866, -0.856551454263632, 0.4977903290242586, -0.7100479843008125, -0.03675089421845629, 0.7566295569507605, 0.6167038650620758, -1.1152122865534957, 0.22767422359914374, 0.4238512492279446, -0.4161804544117314, 0.23938275991583577, -0.8016566497723148, 0.44076212852903573, 0.8828282003839906, 1.0135297464550492, 0.32973545698388446, -1.3786210644088528, 1.3310556776474505, 0.3595416016094618, 0.3559372276295435, 0.22449324856832215, 0.30796526651548256, -1.3567288232522048, -0.5420014813990033, -1.0236941086553997, -0.5022541145976395, -0.26574987265467287},
    {0.2654893811717563, 0.4878255685985535, 1.5132648556594634, -0.45878059043250974, -1.0646669427121171, 1.4192694425301533, -1.8811009165885204, -0.8139533849561468, 0.9720333696476642, -0.5741742988416169, -0.6844422421143903, 1.4758615412702383, -0.814388816402333, -0.9595039806575942, 0.9938349762783345, -0.0792838088581481, -0.8353809552782349, 0.01888115183107895, 0.1270448600744337, 0.23136044657532145, 0.6765337269103877, -0.9494734818013689, -0.015827158535294917, 0.6219211963414881, -1.085867092951462, 0.5987042495819652, 1.1035103749746733, 0.7646255541387847, 0.4281162361906117, -0.3405354155579988, -1.0524494977678849, 1.350611454065433, -0.7331046094576459, 0.3023322395440711, 0.6922683506955934, -0.677324191057002, -0.16182785077162287, 0.1335134674882583, -1.3692681988235944, -2.3227602862408106e-05, 0.012222245092584539, 0.164203723244829, 0.47703631378853817, 0.5909738847806211, 0.3726819070932453, 0.23285137789549545, 0.6443118018016563, -1.5189788554031303, -0.19510444159635684, 0.49834346555637205, 1.0098484505659753, 1.3265048091377343, 0.0670537882488873, 0.25509994440510825, 0.4035613827034256, 0.9456748306702895, -0.8992264824763515, -0.05687988151517372, -0.33779679451022193, -0.27556808632804686, -1.1942570425022137, -0.29548653138927944, 0.17794318644055698, -0.0238247282200035},
    {-0.043856432802514445, -0.32720867834650064, 0.65097307262889, 1.1796815081009882, 0.1628993864419839, 0.7558584515769885, -1.8467789316599685, -0.6956171793198289, -0.6029954941756566, -0.3128437614082023, 0.8124026011662872, 0.5318621711662868, 0.18974332498337695, 0.09953486957574376, 0.8173997162808712, 0.36460045233961536, 0.519390040805423, -0.8231589357146161, -1.2012063944581468, -0.8577174613018519, 0.07379096515852705, 0.38076595256355206, -0.03696792804506138, -0.0134264642216855, 0.057268514492724305, -0.007820309103609719, 1.1115460849663577, -0.16401125648014134, -0.8361075323975009, 0.179196440899272, -0.9508012603801222, 0.1906196250424198, 0.1291204322546942, -1.149178888989959, 1.0974904630005526, -0.8416718631892747, 0.22589376797079555, 0.4925919697543247, -1.0535140755153716, 0.31250023404777133, -0.38952744794408517, 0.7370455155289943, -0.5075900968740441, -0.3005100822960531, -0.8708881461023208, 0.16100877708227573, -0.8296282175634214, -1.5500139678980906, -0.47856787934597667, 0.9329352768107421, 0.5806396441331434, 0.6500757316712593, 0.7393497199668941, 0.2257659051116152, 0.029114100134285503, -0.12819852418970812, -0.22030126334054026, 0.7962843171855777, 0.235375859029718, -1.4820620541861316, -0.9985642102461129, -0.7281750378778289, -0.11059670415772799, 0.5222916681903848},
    {0.44449926764337344, 1.0480965727451739, 1.6347617498079685, -0.1851644480270732, -0.721411858048164, 0.8195146178214803, -1.8029851502282186, -1.0370951701684157, -1.068045890147744, 0.4309768542959326, -0.3792106897132689, 1.351909751205703, -0.6887341632529859, 0.08385625956391367, -0.6386640942626467, 0.13121020133503486, 0.3865440189281659, 1.1577928687172112, -0.5933158959553952, 0.02897686082974046, 0.9879988713297894, -1.2890813074329905, -0.2740892161748246, -1.1315390041613607, 0.5959078444459831, 0.001104071587011823, -0.5417002917795902, -0.8879308723335698, -1.366001318896679, 0.3242994091259296, -0.9022642829091145, 0.6576550268287688, 0.7813803351759372, -1.2446253572944388, 0.24000535460982464, -0.1548360760677942, 0.386705253231928, 0.33891636650135565, -0.9526502186300494, 1.063474751676675, -0.17673002804849572, 1.2407520419635212, -0.1985694828264053, -0.5519428224871579, -0.9343856215086347, 0.43356514546046654, 0.42497075647745364, -0.3788067410922185, 0.18085821234427785, -0.06364796462698871, 0.2226101519951471, 1.36306159568607, 1.1612688791439456, 0.6858711921406199, 0.34416049718016023, 0.7330272734771562, -1.063492662991706, -0.36753431243526385, 0.28900391376989726, -1.4034422782787286, -0.6876169946620033, 0.8105843350132466, 0.10621191387133984, 0.6939410645122682},
    {0.2583454639442514, -0.6325354833338134, 1.0546599614459164, 0.4970191103641914, -1.4965089010318715, 0.4037747489663967, -1.5457423584876389, -1.469675853148437, -0.5408055014411245, -1.1681564672898561, -0.720642672821544, 1.5175310783716012, -0.19400605874656077, 0.24106011675058292, 1.0578948476944208, -0.723868374312936, 0.20535578343717378, 0.42410199087832595, -1.274686399786002, 0.9625919083405431, 0.9816123669932527, -0.7398251888879511, 0.1802370334294104, 0.19259814199225864, -1.1217276862220928, -0.08477673245903676, 0.8298820520979582, -0.711113648252892, -0.4740900612751762, -1.032276883665332, -0.10879515249413625, 1.8003574630768124, 0.46618079058763273, -0.4344559411778386, 1.0067527034715829, -1.196280842290751, -0.12217409117848717, 0.3399283450025522, -1.4444690064445835, 0.5982861039380603, -0.7920969479573058, 1.333937495283346, -0.47641833053948346, -0.8804218218877579, -0.5861050904557634, 0.5547254098189077, -1.0551196035161132, -0.5857946709398035, 0.6648555850175706, -0.6340046684067039, 1.164052309908502, 0.29731127384003403, 0.801005723775476, -0.9865902013056074, 0.4684830812518914, -0.5806984034034121, -1.0383344856296697, 0.32934881466948757, 0.8629448563842568, -1.4473342180930902, -0.5732949255229689, -1.1196990575688563, 0.9061341801821182, -0.3682071672795157},
    {0.7123716021766038, 1.186848329976734, -0.5875086897969303, -0.8329063850953704, -1.1852836263256998, -1.3299029244235636, -0.8821062209632542, -0.7939021958884371, -0.4290017060983208, -1.1325947763250466, -0.7808224731299939, 0.9080140572987657, 0.15695116087222477, -0.4159431211314627, -0.1549714934797031, -0.7744863130802269, 1.1879871953031567, -0.5577428459110093, -0.8143499848108801, -0.639286475820478, -0.10699994276062187, 0.3356410659564003, 0.12149478243274714, -0.21005741414651166, 1.2976918876892203, -0.679647520743617, 0.543628719944308, -0.07237442570192477, 0.40452785158566906, 0.5023960188521475, 1.1269401031267479, 0.30390693231796784, -0.016026005965324955, -0.5316738000059874, 0.86414418574663, -0.054880721811812125, 0.5843409175654765, -0.8382318988394666, 0.3062859578180947, -0.2609802814442358, -0.4375548090871575, -0.34709253419296926, 0.5168564003247224, -0.47732924170657426, 0.8215416407090405, -1.006163795998503, 0.17047293772665043, 0.21494381017186112, -0.4693884776235758, -0.015832052043222494, 0.06372110200106425, 0.1757911886090452, 0.849957033259643, -0.08659824501057718, -0.5838283204294922, 1.1210291199123417, -0.33335247735798323, -0.759024137291994, -0.032800204916273445, 0.8147173584493054, 1.106857245157576, -0.855527561245356, -0.0960163197791486, -0.062310882994041465},
    {0.7839645293972543, -0.17159469672208136, -0.38263524074355415, -0.12947948589197852, 0.28013164008188285, -1.2478150238468542, 0.32516587511318434, 0.5951986022620702, 0.4120972629743893, 0.5256303611066869, 0.20963641312082432, -0.8297734681975346, 0.8353875706946784, 0.7197078301778076, -0.3422181216256597, -0.04766337692063645, 1.0689232451035882, -0.27361775084359463, 0.4153618125486092, 0.8696340440952987, -0.3900858606604044, 0.012524585478844396, -0.7723560737604768, -0.30747942507226617, -0.4109591687561998, -0.2618011979944176, 0.03616221561434553, 1.0064847640295893, -0.5020932957638075, 0.8993453558257797, -0.838579017438299, 0.4891384861676942, 0.13603823642362006, 0.425316750877478, -0.23532302729989776, 0.8088298837167436, 0.01148558504014247, 0.06577230195346291, 0.48205058878661294, 0.8751349813720616, 0.2527870418943758, 0.6447922127450803, 0.5960293640224894, 1.2257448671970774, 1.2334517067833712, -0.5372103743517949, -0.03316205549480662, -1.1458959404161697, 0.6699026084779787, -0.40955651215648176, 0.22000150091421686, 0.12087087738362219, -0.41705604284401615, 0.5797028327273747, -0.4359238511050098, -0.6747526274918977, 0.37724983615765795, -0.5957202012861049, 1.0778980105838871, 0.3310848549511657, 0.8779650554106266, -0.010222034751701574, 1.0157718520511672, -1.173165871171209},
    {-0.5003372156552583, -1.0290511369407034, -0.29052762419531114, 0.6619145611605971, 0.42721405646662064, -0.32127858401294573, -1.1776344735327977, -0.3930582577046082, -0.9038843378295183, 0.5057550564802769, 0.5065741893064908, -0.4647631052140431, -0.5655252466700559, 0.22923335124208552, -0.4492897092812197, -1.5238546168422082, -0.6289021343355533, -0.9546111513733736, -0.6003139070838778, 0.47441975745812054, -0.2240275197520163, -0.7080050003651587, 0.8346306930026887, 0.229444596228596, -0.7085034327478175, 0.06307955063728747, -0.0496087421786048, -0.793858875127641, -0.4826731646966164, 0.7761941480755085, 0.690007199303566, 0.4876506995884596, -0.1034343879196733, -1.1041753653214865, 0.748678582127582, 0.1119037836906421, -1.070242851846594, 0.41402085016292856, -1.1328136272428129, 0.4294024632780512, -0.16988601719093435, -0.6275754197769892, -1.0391051785224628, 0.7949646687791904, 0.7106192838236522, -0.9647196114596741, -0.9050115793286617, -0.4888061776254501, -0.2064404479479622, -0.30426678758050224, -0.9059205378362635, -0.2635960474662072, -0.7215967229905753, -0.5845844982712698, 0.0857647458274361, 0.6341049283998944, 0.9729153527428727, -0.24556709412369368, 0.8735307684820524, -0.8181263714379703, -0.9432185985129685, -1.5171801108752363, 0.9994888450124935, -0.6574385265347485},
    {-0.1479331771731971, 0.39745518596671425, 0.35099230142399, -1.2975161629093377, -1.0172160073576497, 0.026944239342488338, -0.7868396648035926, 0.5051630140304882, 0.7689669285771453, -1.3963499035061686, 0.6152962678520195, 0.3369282871314441, -0.20425300491730514, 0.021791900623923124, -1.1822355690945334, -1.5357936378558892, -0.47868608220761893, -0.397724948980097, -0.8087443317045165, -0.2029176061751185, -1.5656790089509243, -0.321092130050602, 0.6086027079095434, -0.27377070423496624, 1.0230813164539911, -0.07388878024426059, -1.0936879843836202, -1.3265444631973344, 0.4638525276340885, -1.1614373719079751, -0.31960773367341794, -0.332767647385024, -1.148586458819301, -0.22052626175500112, -0.39991024439431505, -0.10563710526792773, 0.4556836972856873, -0.12555372419106992, 0.12130948043430836, 0.0708568284876466, 0.738638197292629, 0.4748799219837955, -1.1771584915272078, 0.30672030548104623, 0.8568413740299551, -1.1984783740437581, -0.11849105252810942, -0.5868596005164679, -0.5580338506485139, -0.550647731295711, -0.13920706535721447, 0.02148940959376203, 0.2533112109257597, 0.6623190318183805, -0.56525707122439, 0.9986292307773729, 0.027073721656905473, 0.16924531251904584, 0.6994174326113798, -1.3509893732152323, 0.7852295472100651, -0.9268385539118017, -0.7352534718018788, 0.18512452373216942},
    {-0.3460572289507394, -1.4483602428351448, -0.19669226572285636, -0.21700532523924457, -0.7867560788899836, -0.6658252244947808, 0.03477792744714437, -0.3317893098039662, 0.2690337363387925, -0.8575130361330202, -0.8252191490413441, -1.056524312567531, 0.12671361795208144, 0.6479475702369488, -1.3691605197225178, -0.8542402836703514, -0.911640931930163, -0.28258428770240507, -0.28729808671912094, -0.8599896176944773, -1.2679086191429965, 0.5145778188364967, 0.8617195574673351, 0.1358682568545863, 0.2692155131338636, -0.736064303995086, -1.0260506269164884, -1.175970916714633, 0.5127506055713716, -0.4423311141799678, 0.6777924352083469, -0.3491433618583913, -0.3547052206247125, 0.5682160634737431, -0.9203087505616401, -0.017304270298949043, 0.2902049898952434, -0.6988410056020441, -0.3011026444152257, -1.1317492541872098, 0.07414278453071588, -0.5320450465408688, -0.25484691949870086, -0.17719137862114154, 0.44816860824205995, -1.1402026901500135, 0.38435155022146794, -0.6859951433150688, 0.06874701732890279, -0.9914142355979394, 0.4728107310112379, 0.7188866567861751, -0.8099283673982843, -0.018420932851691024, 0.22839298065766941, 0.5242408052340535, -0.9641356172569916, -0.5773326228906025, 0.8893620232751214, 0.17589309809158843, -0.5942159970848846, -0.492472568257961, -1.1995867367286506, -0.9399790953114504},
    {-0.6658057112046647, 0.3639499161005269, 0.6610400643827228, 1.0159186313126722, -1.023506714074696, -0.4377554159828652, -0.8718390458954862, -0.08956919242932937, 0.14873363184198082, -0.5524017238839316, -0.1471873171565624, -0.34611449682583534, 0.2807504645806856, -0.9572470495040895, -0.8166619287758422, 0.5562622193244466, 0.8616195030711257, 0.07945521361693555, -0.7867310162634528, -0.6261139755690094, -1.412917677412099, -0.26274709751964803, 0.5727122854962363, 0.35439258984849875, -0.8825596785074133, -0.29505942891243214, -1.4463133661583203, -0.0624139118222326, -0.931002783378275, -0.5792853426922647, -1.085441553005737, 0.032631257887783635, 0.49409301037657677, 0.25202198298779416, -0.21266424708161324, 0.44717869489383566, 0.8141172803250312, -0.347791312857901, 0.7848891691741285, 0.2124635190412352, -0.9975227103707632, -0.2741166621004401, -0.47497541137393334, -0.09226028519122374, 0.6774092129030121, -1.5152946728381973, 0.8035663397206582, 0.8132757005687665, 0.8112078385107554, -0.7013550680094423, -1.5677874983669013, -1.00465627890133, 0.7232915195219642, -0.7613587511164885, 0.6161918519028785, 0.5329821885898153, -0.30894974313659246, -1.3189344986215905, -0.5103518639495352, -0.18343280127872436, -0.08741216820312646, -0.44923846512499627, -0.08286652265143366, -0.16573865233122875},
    {-0.08305047725308, 0.29929150304568913, -0.43323553525437813, -0.09654864247258403, -0.12208391699893573, -0.42371995774942295, -0.6992652027650444, -0.112812572797714, 0.6234150041066914, -0.8964192930017725, 0.8799364492161812, -0.3365301263097289, -0.825364551426831, -1.0564811922936856, -0.8287506089199338, 0.16197183036391608, -0.33700536862678954, -0.5386006368017269, 0.38249183642493656, 0.06327174278425497, -1.1266123855118644, -0.5638578835390564, 0.9612976340138248, -0.11401099546372681, -0.9033695190691198, -0.4412709735820223, 0.15116849621765788, -0.6731751879047472, 0.6116802575118444, 0.09829085660403362, 0.501899577067966, 0.21620873835857998, 0.6770717240147048, -0.0720363390843141, -1.0072577933358065, -0.23612912250283227, 0.1811043209662492, 0.06888695836333418, 0.9087474861032425, 0.4334983334492583, -0.5168794581130511, 0.20729932067124787, -1.3488362941894654, -0.02420568500233585, 0.16369967677011568, -0.3728266054732914, -0.7364380680492993, 0.23837214347764235, 0.6697053691553909, -0.16055029422534495, -1.1213375634870002, 0.33543779561890485, 0.745278874458799, -0.9581443657128481, 0.2329652092321144, -0.5742173746696659, -0.12944057673167064, 0.09773808097672163, 0.20761332311047673, 0.05232518697672311, -0.496447602902089, -0.5776137100290355, 0.286334631609363, -0.2999211419577766},
    {-0.9111886000476759, 0.42661588977685644, -0.8473649289149163, 0.571469511117057, -1.0216891867198885, 0.6075908047868971, -1.0817143468065287, -1.027705157215616, 0.574734035535809, -1.2763719325066398, 0.2915402829406606, -1.2254521333659785, -0.5606401010994582, -0.931417212450732, 0.01265903054373597, -0.5705472276011133, 0.017557248427982543, 0.5496238931955185, 0.8416709398118118, -0.7030369545865801, 0.24812751743133818, 0.3956107183867975, 0.6070252533921984, -0.42116198665925103, 0.04250024578383325, -0.2295962306840356, 0.09168308843154531, -1.1480722608065597, -1.192901002298347, -0.34527922393248833, 0.34899180447681116, 0.5407811677137132, 0.2769572301718708, -0.08122981452917821, -1.0662197775587547, -0.3782979314504334, 0.15368375491182096, 0.867071243785621, 0.2744853179935939, -0.005956697694357788, 1.071454788546485, -0.03940473206180422, 0.7098493544672346, -0.9232913320349779, 0.8494794037409104, -0.8517810988802947, -1.1308824834335074, -1.2057162255100085, -0.3505529632660531, -0.14141991747698485, -0.6602799794291777, -0.7368753473335137, 0.052813809135688845, -0.16571136915200382, 0.8329206314646542, 0.036946265213085965, 0.4739642228774331, 0.19530406511327045, -0.625899390928623, -1.184846934987227, -0.07388102861204855, -0.28409854111348876, -0.6631649203870679, 0.2664768093123937},
    {0.002501702477398604, -0.7236296631833226, -1.3050433469203058, -0.8687312307297719, 0.2365110703379055, -0.7697847084153115, 0.5134575516031299, -0.3179146695465578, 0.1996972083556833, -0.06930184126183989, -0.211800249337993, -0.35895253616957623, -0.5723162313562559, 0.7663413419696301, -1.1717138523754618, -0.34417536554076616, 0.5191589794689099, 0.5860852013622403, 0.980494287043796, -0.5878938072276992, 0.44542631539707794, -0.09482896775234757, -0.7440307384679704, -0.4646876641354585, 0.869962264388353, -0.1684964617479258, -1.4284578751743837, -0.9217979926316873, 0.36871961978851653, -0.10193526249288697, 0.2339895049706863, -1.244211799049645, -0.8108066521099498, -0.1435655082051342, -0.6130128859306488, 0.8057999266119258, -0.8742774801706795, 0.2992900933807821, -0.8322979998380343, -0.1392661701591699, -0.4529138542940645, -0.21086065255332356, -1.0722387680527572, 0.015689348123575125, 0.09252319050058624, 0.7821693677385292, -1.0606504412076514, -0.3583050848287854, -0.5472380874614753, -0.15511537662650976, -0.10431768804563357, 0.6264238610937685, 0.6207788827695325, -0.4725021120873546, 0.4544600498166095, 0.5367176917188619, -1.0904018523795063, -0.17457128276584624, 1.0039390426723305, 0.07800193801652093, -0.8920088979353029, 0.08448387703113446, 0.69856638341674, 0.8519406733186154},
    {-0.3248336008625833, -0.6679015916090829, -1.0695535835228802, -0.7729527660849947, -0.47412305902328167, -0.0298483490671398, -0.3344900549239594, -1.0000706917778917, -0.051760795460309844, 0.1691987994435014, -0.28264613825732854, -1.139934826777742, -0.15254492184744672, -0.10192896750362361, -0.5748170336056726, 0.4086950208699321, 1.0050143462891483, -0.20529365445369022, -0.11674845745069821, -1.2078985722109248, -0.988931124814546, 0.1797480434796749, 0.7974664025714829, -1.168992202613784, 0.8087312216622321, 0.662471516641842, -0.3462787494670384, 0.3697065617130845, 0.8505547232400703, -0.017610077714121822, -0.43571142051641176, -0.7630368435968574, -0.478475490725945, -0.301159504696516, -0.21786585061762712, -0.5243824339136566, -0.876424047083635, -0.3606212002614707, -0.05320760550684559, 0.5483958061035078, 0.06147278053556616, -0.4697476298573976, 0.014331591075579093, -0.6037477578572641, -0.4532373991281767, 1.0358602615704786, 0.35235838712032097, -0.9670313100036262, -0.4800652446634023, -0.3869010216904397, -0.9009669729792614, -0.806353935518384, 0.8556323375769854, -0.7037326566312031, 0.6863060038462456, 0.9143637826458394, 0.8819965507063673, -1.0409577706573927, 1.0254380679338722, 0.6149585241803486, -0.9808671149221144, -0.5582349972007161, -0.3071078686608416, -0.9178440445807347},
    {-0.7555112053947395, -0.31284171160461655, -0.9513774262760671, -1.1453189491669904, -0.5434627683727516, 0.8573675108918221, 0.9627704297752885, 0.3935769463447844, -0.5051469084072979, -0.6983587229312538, -0.25990173678076767, 0.21921919804688667, 0.9154883290417599, 0.9680042215666499, -0.703488227019245, -1.0870785937185166, -0.5555329238929915, -0.9625543789142287, 0.9037104501699816, 0.042916025721326474, -1.4023171832553591, 0.5014899729251493, 0.48876491568529407, -1.1119249372327549, 0.8360344613288114, 0.1868704887037903, -1.3667509212059317, 0.8072403962136145, -0.3379392521379374, -0.3985490965807964, 0.4502758422072498, -0.5333364432758249, 0.10840384180449937, -0.3803602654626171, -0.816634595937216, 0.34744357845276624, 0.09896570157514663, -0.21553954705813916, 0.24720630636572838, -0.953011323964589, -0.7741506987899952, 0.3963598031097028, -0.011522021593086955, 1.0740176713225242, -0.9385115077954065, 0.4092676113246961, -0.6938406853111184, 0.05340089058962137, 0.5427980258610905, -1.3103282703067485, -1.2278376780799372, 0.37897653324479375, 0.11788790563661797, -1.1054041258362206, -0.07233509154853433, 0.16266938601095227, -0.4963806243596145, 0.6670271046913223, -0.14725553997963337, -1.1018054876990326, -0.007238050495083803, -0.2605007411082367, -0.2750594257545158, 0.37860698528377656},
    {-0.5542450074392967, 0.6522392855547375, 0.8264828379760993, -0.16425388215698386, -0.02413951229132056, -0.346449759089624, 0.6039580351171298, -0.930653601951684, 0.9257477255543068, -0.682645926401235, -0.9631846134959295, 0.4874701169230691, 0.6706697747476337, 0.9053133561879496, -0.6534224397053192, -0.3293093844072504, 0.9153975894695358, -1.1123309167173059, 0.36404898666288193, -0.16780073970703005, -1.1367280164294897, -0.7954249875977046, 0.6852021322849622, -0.07120644136506805, 0.12825140995949869, -0.042131991363491085, -0.13216526671795792, 0.015109941744971607, -0.9675634847637148, -1.0884624179301896, -0.38149627729286656, 0.0775700537744982, 0.38256271980854506, -0.7360262374591053, 0.42062431957159074, -0.9098998493194862, 0.598873604150943, 0.06491676435837687, -0.998369200646586, -1.3104193148627472, 0.48564975274477584, 0.7043150881549892, 0.12896330260267766, 0.07741508661678943, -0.5315860476993192, 0.5677566959113967, -0.007523826849142225, 0.7928311860547893, -0.7496320217036408, -1.47777803639008, -1.084650904820872, -1.1744588543794288, 0.3065706513246185, -1.3333377915890998, -1.0996635550362783, -0.5491553916698134, -0.7968371675881694, -0.9919814500955788, 0.34616239447935726, -0.3059663226515594, 0.37084377412704217, -1.1950999029302993, -0.5842600900044062, -1.1387511438373052},
    {-0.2916659109410291, -1.246425847287642, 0.47145300464993223, -0.05209405967595075, 0.6313461627887703, 0.48553609767869255, 0.13949275328877545, -1.1194516072091991, -1.1879268928473592, 0.22516122364529284, -1.0796145008956233, -0.12628042201444092, -1.2642741000415625, 0.8551711091666403, -0.46965295148173275, 0.008013599319512165, 0.2102545534664102, 0.39069081085052315, 1.0216321046735106, -0.7159934792384587, -0.83102294587086, 0.5053220925939106, 0.38546316969977895, -1.144448126546886, 1.1404658897136628, 0.39136276374575596, -1.1528948039855085, 0.5531336595711769, -0.8765390852555421, 0.7349842151866953, 0.41677201977205874, -0.5454679781180618, -0.41865604278231094, 0.044551821038053156, -0.9375909757905553, -0.54352363892074, 0.8396258720564714, -0.6263017014530501, 0.9574679250399193, -1.1913561614831232, -0.7949836495933222, 0.4523687492932908, -0.5052669303496139, -0.5481238694653882, -0.9992056973349955, -1.2670014699629715, 0.4004994750785742, -0.7674809666621403, -0.2559081003279911, 0.3316865698017267, 0.6252668111035522, 0.42240840099977767, -0.8558854326434735, -0.8117862172452748, -1.0356802342692024, -1.0528360494114155, 0.006620805452309828, -0.3232005162026711, 0.6462224079591907, -0.2531128707703689, 0.635830690258876, 0.6098590593349088, -0.9251193457696083, -0.9825437560967545},
    {-0.9206346616777612, -1.069014334610295, -0.16970665408049285, -0.21019364524512496, 0.03243108949427187, 0.09162179543021229, -0.3901750966267558, -0.49745592575890607, -1.266859182113143, -0.32798611874334266, 0.48904469408642903, 0.3400794380138292, -1.352835848202966, 0.436028249838058, -0.996572190764759, -1.3997342000093835, 0.08732514315749491, -0.7030429490583344, 0.36202812240177445, -1.3432781095132584, -0.24766617515452355, -0.17518935166867697, 0.48198621153648336, 0.623699196061759, 0.7592397736028275, -0.45865687935794935, -0.9832093863085665, 0.5865494024921926, 0.6620676870647574, -0.4059231008642989, 0.24898845902993127, -0.000877495098219754, -0.6961823549516891, -0.8555940066952783, -1.2641159342473813, 0.208732185246031, 0.5744033250794843, -0.542690398058441, -0.2531395214547302, -0.08483885861343307, -0.45969416158618587, 0.397017334329791, -0.7995923718279113, -1.0208057481125699, 0.15117851888607486, -1.2580926789447233, -0.14593924859397592, 0.005853414995540325, 0.6015549964812569, 0.3768731161796967, -1.5739830141457731, 0.3697252796364388, 0.050493596701407906, -0.7852959270205067, 0.14364471429283115, -0.8445775343608924, 0.2655326477706708, 0.2024582478050329, 0.8298513235726416, -0.7935838061352716, 0.20386078132391358, 0.1780642035575785, 0.3806572126911057, -0.834407418365054},
    {-1.3096528403511718, 0.4815181430681431, 0.8338079187124532, -0.5827768305940754, 0.7107127215662069, -1.2055787612954798, -0.7018793709757319, -0.8436307378247926, -0.6613307936120697, -0.5276389556639762, -0.6624176488185121, 0.49985812499733384, 0.18055183796603919, 1.1573882109760916, -0.1975603055448829, 0.435686212496971, -1.0557434430683759, 0.38284758600065716, 0.7380448357104084, -1.3143030188109521, 0.36585811117466177, -0.9178599713522668, -0.8054702223766889, -0.3882442469477738, -0.4533907331420527, 0.027711053338690894, -1.1955940358155706, 0.042631377080687254, 0.42535707876557377, -0.680764998501318, 1.3460881632764434, 0.05162971490729395, 0.6704831916418751, -1.459822977903445, -0.8511623002966631, 0.7060701894720379, -0.2467863723573184, -0.8455934785636329, 0.08872873056238906, 0.4980239624566913, 0.8201711356512791, -0.006047785418676668, -0.7934227844309306, -0.7059039351166325, 0.6489528480900579, 0.3994330467790507, -0.8637700333549686, 0.10083554379617657, -0.16588840227765744, -0.6594355060775129, 0.29109539684298275, -0.23817376262522444, -0.6990731296436319, 0.5263009831108385, 0.1833902895077698, 0.3683586213197767, -0.12216012891881708, -1.3482396216595103, 0.6352666182499032, -0.8051660240897709, -0.6268860731126316, -0.401096351719168, 0.7138966911289581, -0.4004210758478284},
    {-0.16605298520460177, 0.8037325432665666, -0.22364338169622647, -0.004216386205565638, -1.0860516143967627, -0.5276728927702038, 0.8592206417425683, 0.010515842147355094, -1.0511492550348343, -0.007691365987192178, 0.615130440098387, -0.9159471846174941, -0.6349987340213464, -0.6448686335793531, -0.19782009177256143, -1.2119951220642355, 0.9798311762225973, 0.25683387918255773, -0.41922999210998557, -0.413185865537958, 0.3984913530315651, -0.41188894337586396, 0.04414486569174734, -0.2460406556824701, 0.4642447843075609, 0.37959618786927307, -0.3345921405254726, -1.2101027199449694, -0.9757565791272459, -0.9647581232854106, 1.3987251695356993, -0.5097116609349127, -0.6725741415589924, 0.3530423010823345, 0.7529990375701713, 0.8048366659473785, 0.5080178650543177, -0.512586447716199, 0.8415066593609268, -0.1394885388663063, -0.7365923510311424, 0.6662141559133263, -1.0214970265704824, 0.26160819122251944, 0.9318540431542548, 0.5482778659564044, -1.447545840614619, 0.7235937934289551, -0.7458998665386104, -0.056463357415635, -1.2718176019302667, -0.30056798470859136, -0.5953375176566257, -0.4916959929640401, 0.7820672345053016, -0.12343073957701675, 0.48671744688912283, -0.9562572625430932, 0.6657914618698797, -0.33185631620623324, -0.9709503564913752, -1.6286495243626165, 0.28383407548044076, 0.6939660582758709},
    {0.605296213973247, 0.6186344350050714, 0.987657178880765, -0.17769688480183812, -0.8890300589070971, -0.9983597646762565, -0.7891302951284161, 0.01819853135266886, 0.4338871247515101, 0.6441512803148997, -0.06561829188267837, -0.9299540321263803, -0.9278979408468229, 1.0190679086223977, -0.39709650335803454, -0.7527190268590408, 1.0940199621055735, 0.8939551258784566, -0.1418477368326801, -1.0919327389030418, -0.2698514809620655, -1.3752941456277559, -0.032259086853757245, -1.2432415829266872, 0.6462456285771445, 0.3145922930281921, -0.7393436641502797, -1.1650330357807321, 0.15586112934386276, 0.43656288804637905, 1.1108992831558182, -0.0784906374588799, -0.2217174209320514, -0.227080940445476, 0.08466362134178106, 0.901521566922226, 0.1873587480942838, 0.5552334239957597, -0.663264924732201, -0.897937476565818, 0.05859096964113489, -1.504366737089238, -1.205938184629795, 0.8070717331891613, -0.6852345551584067, -1.083524599889668, 0.1811473843501118, -0.5205462116504537, -1.127616274550261, -1.6222978893317093, 0.12721028516615854, -0.8334254967175044, -0.22325684378503377, -0.8621055064045772, -0.6667584917736951, -1.1255106233386842, -0.31513592639451177, -0.8510879979973064, 0.8078123835764581, -0.40602884365217917, -1.4550131884977484, -1.184451398229851, -1.0778011426581868, 0.6160492761875449},
    {-0.9376818976014769, -0.2360355126034039, -0.42480788819972387, -1.0404858168926616, -0.36273094122701005, -0.5416924216026401, -0.6021160902189683, -1.0111874411287787, 1.152290364202905, 0.8991197229246636, 0.12668800368305008, -1.0622444815705598, 0.30356079499127503, 0.01565811931582473, -0.23983630651383112, 0.00627068230694266, -0.7192800258999638, -0.5314066665274416, -0.07872084610592459, -1.1259246489996246, -1.0481931516884313, 0.4675593168813896, 0.8152172767981556, 0.4111519125626745, 0.8314226628222019, 1.1915292987948354, -1.6320436577305197, -0.17742238483243739, -1.0924891897236018, 0.6926905952489737, 0.5616738810950204, -1.2215036369733274, -1.3999058021480895, -0.3737588071611295, -0.21607570909876417, -0.13837027207028138, -1.1453103961007187, -0.8084406116153118, -0.6204519490168302, -0.42200554244696975, -0.18316715008182397, -0.7237725528513679, -0.22636082152949924, 0.10748060241108842, -0.24605988717490387, -0.37098846551149006, 0.32309360189204633, -1.136330521828819, 0.4132351797694702, 0.23739016831970286, 0.09853157231167692, 0.5380148918783091, 0.920008973431732, -0.7926005261406113, 0.08860495268871627, -0.8243855985449898, 0.7226599989859797, -1.5254904779512573, 1.0448524338083225, 0.17220396383628056, 0.5601907891484184, 0.24033097524834188, -0.348505964986375, -1.4220457747207922},
    {-1.3048611951217344, -1.0753643471139591, 0.48200076444067275, 0.9778046379329483, 0.579394714754944, -1.0486940885561815, -0.5505720823287594, 0.8382095220880633, -0.2891236707884984, 0.5819278929564672, 0.5359521695725685, -0.6204479760777593, 0.7124483941802741, -0.04434071962850219, -1.4479240831862261, -1.555167852412317, -0.8389880545152146, -0.06786345598908232, 1.103622521135463, 0.0634864440730813, -0.5101965813767487, -1.135477589740637, 0.6332453947144203, -0.6446436885421756, -0.4342375517976425, -0.6346138314351236, -1.1317508691982074, -0.28676326713006844, -0.7113444325368117, -0.27381785559872546, -0.43357880674647853, -1.320608007819856, -0.912287079252628, -0.45531051152519936, 1.0629468350753444, -0.1648455462543787, -0.17682622224448413, 0.8974325672536442, 0.3723089132454756, -0.7569878631772865, -0.26127656509352637, -1.229380286997633, -0.5766976071301202, 1.1924971307375407, -1.413052846714687, 0.3890604543876726, -0.03775250567904355, -0.7421156537813733, 0.5292714052542684, -1.2472698869482226, -1.2565728453972294, 0.778275044492833, 0.8817044781500014, 0.5746104856660298, 1.152515510808502, 0.31429814147380597, 0.04815146383988325, 0.016368673962449457, 0.8777371626480066, -0.1443553917960389, 0.3658018467951866, -0.09029243793507008, -0.5058610732399088, 0.5068303482028432},
    {-0.4417627691716636, 0.4139562630318906, -0.16790044547744157, -0.05208793931519289, -0.360344954518067, -1.4470312731243178, 0.054300847013079745, -0.43708818756890083, 0.14035540459861662, 0.5707223812106289, -1.0877988127337985, -1.1649547966285216, -0.2086300260156181, 0.314461281367316, -1.3286518601232478, 0.3743411515150231, 0.5929465051219339, -0.9239690505495696, 1.2391576589655655, 0.39960774036571606, -0.5632904830860288, 0.23667539227887557, -0.2995640834290959, 0.24842878701854063, 0.969587737098689, 0.2172970740992912, -1.7040197860428854, -1.2815903503702282, -0.0722764748400317, -0.342897768214048, 0.6686471303288898, -1.0557942151252018, -0.13020884190086124, -0.059743645401182655, -0.01951413357373048, -0.07097621176053293, -0.1571782073631197, -0.18325746913670599, 0.6327537431964838, -1.0224990833553271, -0.1219401583061788, 0.29883348020606443, -1.1130536521292589, 0.4697856532619395, -0.8958617970346405, 0.20831587367918106, 0.5141945388306778, 0.7564578938136948, -1.0076471542956216, 0.3970982794527283, 0.22807275433854812, -1.1070855325744122, 0.5482127539046486, -1.4565377856286805, -0.6786448133090736, -0.18373502295089839, -0.48457787405741287, -0.6745942896446699, 0.7820635155876364, -0.7566716098813022, -0.7583359997332939, -1.3296732441960422, -0.019251565675762774, -0.19591255290820908},
    {-0.17693854085930333, -1.4569779096928586, 0.29182608209782657, -0.2950797455471038, 0.31237020577179936, -0.04717852206257766, 0.7598142176678088, -0.6151030879482273, -0.940950606874967, 0.5186734882069222, -0.579993326585965, -0.6152967567196246, -1.0563878128512023, 0.8959938789116213, -1.0219465213430292, -0.8163310300150867, -0.5091759390797991, -1.160315243251326, -0.2544585167955167, -1.4735039850017178, -1.1247963693650416, 0.1932352810091738, 0.2632499640113511, -0.3579123707494314, -0.8708569846825356, 0.2411670717399959, -0.7775217981813359, -0.09283216784981128, -0.0353778383662694, -1.116268524266056, 0.2154987130104191, -0.6589457711749095, -1.5700527985675965, -0.8709634360551322, 0.39413159023177885, -0.3103523539989455, 0.13413256103446466, 0.7667813292899305, -0.8635737843567696, 0.3651310380211411, 0.9120821283635631, -0.4656825256490162, -0.5385758354877258, 0.9476308197873352, -0.13282177655575547, 0.3111726842752049, -1.0835138758172624, 0.7815739619511772, 0.5368322451465061, -1.1938877069584686, -0.9156974293073742, 0.9138800883441, 0.7183445047206369, -1.4171072049505395, -0.928967517968651, 0.524844111219265, -0.7275863281337616, -1.3477933971198515, 0.7552695134550981, 0.39473011459861096, -0.5172683792341191, -1.5168393484211236, -1.020765596377545, 0.07688832021639436},
    {0.371154260182256, 0.36558976352221545, -0.986263097090789, 0.7446294247583258, -1.1320807323647513, -0.6545011756508686, 0.25560631824574737, -0.09752601925691295, 1.0182692545787821, 0.8008523391549742, -0.9324197813651609, 0.3967087740795538, -1.1123524925284856, 0.36332782351165815, -1.6168285157526838, -1.0636091559859935, 1.3042262630954076, 0.8730146017173166, 0.4161639394003332, -1.4415600461150169, 0.0608616448843861, 0.45700112819511385, 0.17089793569917622, -1.0788094493303655, 0.4504817067573685, 0.35154683893613364, -1.3349951040421166, 0.5428263573469341, -1.0246557749041156, 0.12557361538952047, 1.3677276611381215, -0.47360657331357897, -0.344041688620516, -1.3466998457927106, -0.007793397042824018, 1.0648684294392694, 0.5744654533783906, 1.1465271187554664, 0.9395160341435981, -0.2980663305158408, 0.2626727759643526, -0.5285383663808039, -1.1342652884482907, 0.33506854573103956, -0.4916566744234169, -0.8672503074804614, -1.0078984370650355, 0.662191362984918, 0.6647269556842462, -1.463687874112118, 0.018801878546908426, 0.7645743082193439, 1.2371253795016874, -0.5564312807947591, 1.1162229147120868, 0.6290268402712382, 0.8756845848895051, -1.119488673173503, 1.368443547723979, 0.9070285898933468, 0.645800425354031, -0.38693542105014894, 0.8264441675720616, -0.23203005795833911},
    {-0.14844813246528987, 0.293247090064114, 0.6154670943797738, -0.5993837564451401, -1.4615584385566764, -1.1033795878070338, -0.7528700931052561, 0.12564562104209148, -0.4134838493854166, -0.9412152923338456, 0.10686647643429727, 0.7998062258047641, -1.1626717503703259, 1.3742074233986739, -1.7162192972452661, -1.3590100801432974, 0.07297147972005395, 0.7667245475875125, 0.9944145234693644, -0.47808508280403617, -1.0539382609591847, -0.01834441372472846, -0.6607578383003301, -1.0407599101070428, 0.3160490947680139, 0.04554887179083953, -1.3553586109903486, -0.7868962299740232, -0.7758445434871677, -0.18348462110416489, 0.5790185189071422, -1.0900766560232173, -1.5711217368562143, -1.5023721325891388, -0.348415358344289, 0.6154825966275259, -0.6985651516898317, 0.23479684486248595, -0.058380112301528245, -1.7287910900153551, 1.4528480864427153, -1.6049701589866758, -1.582260371125705, -0.43842755613660556, -0.9551341418515579, -1.6309901410901366, -1.7278565949847617, -0.28549485387674406, 0.3149427091442912, -1.9430552186906196, -1.4884322851343752, 0.34013242594851256, 1.0373853153242314, 0.16860840653824286, 1.0398134845841593, -0.3954600455278008, 1.407694053308254, -0.3629830287810713, 1.147916940708743, -1.0335695588108935, 0.4282014341647541, -1.0907174715191776, 0.16008460852449188, -0.776328581033272},
    {0.3921983004788738, 0.06434642354621335, 0.9837409892309162, 0.03720737385562042, -0.13676919489761308, 0.17968306039032006, 0.5715073043638257, -0.3948984004141059, 0.8933843285165989, 0.6604968270855611, 0.348646235304052, -1.1007779571302867, -0.9183061883197251, 1.198069165107013, 0.13724024466164286, -1.9329542359727667, 1.4236505051242274, 0.3887460690424319, -0.17464353022538734, -1.6957324034923529, -1.3793460950236642, 0.3266153556179819, 0.7046615791169596, -1.2341646427129462, 0.5861685383376789, -0.4849523791385023, -1.5186137833569948, -0.491109836277907, 0.19983560360417654, -0.9644712993682466, 0.9532805737421063, -1.1241306840495162, -0.222567570930031, -1.4463659560204567, 0.8340357889606713, 0.667675710300111, 0.5048433154700693, -0.13734842279236303, 0.6428769855281368, -1.2316924081307468, -0.32162349819905556, -1.5126551556454162, 0.36631445196978585, 0.4554181554468038, 0.7999473139721666, -0.1922296164068317, -0.10091747428845042, -0.7521444537231372, 0.6350027953519447, -0.7190267750782778, -1.5271887325501585, -0.6709933146730046, -0.0494452380913609, -0.0017200424674526683, 0.7936828106775681, 0.13008974420875036, -0.3520694487068312, -0.3069217293773262, -0.20991755553470862, -1.0793896071352607, 0.02444285625835608, -0.20493026523465754, 0.5375966179410169, -1.2148310895784398},
    {0.5892922498922705, -1.3426310119521905, 0.6216989471858584, 0.15542143149001153, -0.7498201820252434, 0.3971730147709076, 0.2693511736729476, -0.20326858483337132, 0.11827867366704177, 0.021045710958836637, -0.9214961174100972, -1.4526067178656692, -1.0375645130879234, 0.9250227028758834, 0.12813737373632178, -1.8232505829425507, -0.5264119373533924, 0.3213619942408109, -0.18876871720734864, -1.1790270642553113, -0.8382436446051871, -1.004386993765214, -0.1323591688187397, -0.19159468684227146, -0.18865983880675435, 1.1381955318383579, -0.7798495188189062, -0.5610287623486035, -0.8262841858558614, -0.9310540837124824, 0.04043593465126603, 0.12698098568044155, -0.6967747578719495, -1.4631984429838825, 0.4279723007963854, -0.3265012095305739, -1.0186159376355044, -1.042546115871019, -1.012214257884721, -1.5774578442708396, -0.11381856444532515, -0.5780547833836449, -0.3713285572045483, 0.3853412744722773, -0.961010694374653, -0.688940590207081, -1.3967430372849678, -0.6891513058706255, -1.260356354948239, -0.9516236144411857, -1.9534834728403303, 0.7360270971128268, 1.0543626154104349, -1.1537130747210094, -0.11017911295144332, 0.49534932300468254, 0.056513957824254106, -0.4878098814756573, 1.0141145398688318, -0.3797672520965798, -0.8704513726942694, -0.33209365713943084, -0.6237197857230466, -0.9130962741863821},
    {-0.6316819098543739, -0.007680321896901081, 0.40511695733158504, 0.3119216558725486, -0.004601121126263578, -0.9291386672983483, 0.40429930735754005, 0.5173235139151541, 1.185586599819002, -0.6977283518986321, -0.7940926885992069, -0.8649880430962889, -0.11195649255499465, 1.2446207387274677, 0.12896647179457088, -0.4949676528318796, 0.7913282627259031, 0.511012022950886, 1.227333130619559, -1.118809524936992, -1.1930371410431697, -0.679882321183626, 0.0217653915262446, -1.6809705467439027, -0.162317779424768, 0.9347594018945813, -0.7298069823638439, -1.0721973137217924, -0.4707123986436881, -1.0074886550919169, 1.0924394998350389, 0.7543205229980031, -1.0494075503957292, -1.8654663705497285, 0.769867869767259, -0.2464089829268998, -0.053910332412092435, -0.4611847611593886, 1.162319696758852, -0.7453466516573458, 1.1918543193452027, 0.2324482134380073, -1.102714118202917, -0.15962018521941718, 0.46420839276096476, -1.654171435597787, -1.7438203732828186, -0.5038832495619756, -0.7731946646317622, -1.0706764064575962, -0.6347533310567015, 0.6296751187999479, -0.0981394990699787, -0.3121402159179352, 0.013878240669108432, 0.22984422806730267, 0.8876133235959994, -1.127723882993062, 0.8409573273344726, 0.8098726864332879, -0.17850579695302327, -1.5202898765924393, -0.22428761819738882, 0.5615264379163454},
    {-0.2751092310408558, -0.2838329448221322, 0.9025686024505976, -0.33640061506963315, -0.7474212876837215, -0.38561844542732904, 0.007722273406484065, -0.6842393583160659, -0.7747867355581379, -0.9367390620352224, -0.856516274144287, 0.7883919819170357, 0.1350676588108205, 1.2335491693219693, -0.70907985890259, -1.1199468526316134, -0.033837858994683896, 0.6397856189090853, 1.4252701800051533, -0.9402595456029611, -0.5144260002548355, -0.8636123261685457, 0.689810566171762, -1.6492043170944932, 0.6058177740516283, -0.4627329818337781, -0.08199821143891449, -0.26159839011345787, -0.1751241524783274, -0.05071484488214958, 0.7847766295361036, -1.2145352927893118, -0.1846414702026568, -2.0028025897787654, 0.6634288176437783, -0.40481545177326494, -0.9579823877668376, 0.6745160804863662, 1.052101541091114, -1.036427433518697, 1.261845808478873, 0.2646844505751641, -0.46619148463021376, 1.2473965593391818, 0.6502268368619204, -0.9075933207769638, -1.4532972721134467, -0.9905963182851846, -0.23940302500481161, -1.623354962332409, -1.6592063341402352, 0.4887048645695583, -0.13028498208081923, -1.013044491702108, -0.22403922303211565, -0.7678084604208052, 0.474886296641842, -0.5744668951706006, 0.2017621905417691, 0.5265061327678197, 0.8607856749372774, 0.05866318664115236, 0.06201351387756672, -1.3837410451830972},
    {-0.27868727774633195, 0.3581674836925304, -0.9325547773983703, 0.6287824560218177, -0.21743539847578877, -0.2859001169080394, -0.005061582576252087, -1.1139322340855558, -0.8120666685840537, -0.41100553282591984, 0.08220180714703118, -0.58361119850555, 0.37828738336346346, 0.7032014749127012, -1.343459967629349, -0.907339467759522, 1.1605253572325451, -0.5981558194907193, 1.056946639577242, -1.7255654035441965, 0.15670305947484287, 0.3930720135229464, -0.6395059292181289, -0.8691378395538613, -0.42512361389378805, -0.5538701036500151, -0.2694768350870289, -0.09801397517378721, -0.270731161085942, -0.276636123544612, 0.6785173376420977, 0.20806058128939992, -0.33675569892526175, -1.1548915043608388, -0.29023967592115457, -0.370696698880246, 0.011176861415270469, 0.23218065136716984, -0.14449651737052815, 0.13640891891378978, 0.6530954521313416, -1.5647344683875108, -0.03289382230792176, 0.3924707945783359, -0.42143095576213285, -0.8431821634893429, -1.5159446984508578, -0.5806871818560899, -0.3440466075214687, -1.4534966483800607, -1.0565008595603713, 0.7390756508712036, 0.37017673288940495, -1.0448176464954648, 1.0805203340432246, 0.6678639487924349, 0.692566126524811, -0.5128249946374084, 0.406426145380732, 0.40882473296126726, 0.6735002604294614, 0.07008627751111728, -0.06265645980880845, -0.24992431862054956},
    {0.08383398080535892, -0.9158817950313809, -0.6999610375142323, 0.5105320732926975, -1.595822297497686, -0.7399366659106478, -0.7478518579201389, -0.5883938474572316, -0.8056325219011536, -0.6945030798092815, 0.05412407659102334, 0.7079164126341794, -0.9848760365788577, 0.4260935991524201, -1.0917089653248817, -1.3946808248913916, 1.3595707865117934, -0.4414547970671359, 0.5126267409467801, -1.7441748308148917, 0.32384494907227723, -0.8872362103560705, 0.9151561596616897, -1.5841072094239657, 1.071706049044899, -0.13963464074588752, -1.6451694498167044, -0.8370017532627388, -1.3051557175706092, -0.12114468310385484, 0.4486972510934229, 0.6008378522634704, -1.5552270111611344, -1.2997679090922396, 0.9088057672049891, -0.04655646639009491, -0.5918674209014267, -0.27884851085071216, 0.7850155993044464, -1.0588841550776102, 1.268625488788769, -1.3701091303569297, -0.9198613807126518, 1.1295018011497062, 0.8481312675511997, -1.901783195892425, -0.39459530672917287, -0.4135355894802155, 0.26090383839591474, -1.8464775628974395, -0.5692052169764297, 0.47945291611443575, 1.0441066313162983, 0.2240591154018172, -0.6560935672538977, 0.3494430130129914, -0.17754702548658802, -1.204812831894934, 0.1995587580802099, -0.592331668853594, -0.9330512837557045, -1.6124862351051776, 1.083218509940916, -1.0123808624295048},
    {0.29608252188156625, -0.7560027261926433, 0.29231741207181844, 0.3135877553831213, -0.8910194341081271, 0.3402798808591117, 0.8864122425624649, -0.5132834244975094, -0.5577711299685038, 0.12606838245255114, 0.4180933043097117, -0.6699779831010375, -0.9956838982417426, -0.4418975738873553, -1.2883279206961316, -1.67353209066753, 0.6498024353600123, -0.7124036163002658, -0.015261678669533122, -1.3536987772807592, -1.438113022576455, -0.600506185710895, -0.21999141161681313, -0.7521826282393584, 1.03444452134952, 0.40892953764518053, -0.2237158440348433, -0.42091433184167454, -0.5436625262780529, -1.2516088423863234, 0.5058329678439981, -0.5549909402449441, -1.7023253304935837, -1.0337823641735164, -0.07892687813311083, -0.32193634519474945, -0.11452251484036892, -0.08800556710458034, 0.8296417381679115, -1.632990526858161, 0.633040082732359, -1.194989916520587, -0.7918158850461526, 0.6403754110101182, 0.6974153126082184, -0.3144239751367619, -1.3319711238856065, 0.25656601559413333, -0.12731216156515016, 0.02431309222021147, -1.4780202219092053, -0.29812962807770355, 0.6474207271961717, -0.2712027429224756, -0.38823554723770426, -0.771904112942234, 0.8751579469515759, -0.6941164488272296, 0.6282460762232408, 0.1277358797596848, -0.7027502355355985, -0.2244539473984838, -0.9236704058851025, -0.7124576827416783}
};

static const float b1[64] = {1.4089435685337055, 1.4619124914061883, 1.2798737042284478, 1.4395160865788144, 1.4031049306522168, 1.295069345035505, 1.416346575637156, 0.9902623862804482, 1.0337488111782733, 1.415542425907211, 0.6453399069189699, 1.3578630978009458, 1.299343370950441, 1.1555864902817459, 1.4347820576341337, 1.359041902480859, 1.2565323395214705, 1.4864750250643466, 0.8990647040208314, 1.2791598742585935, 1.4424776806457498, 1.2196650548647248, -0.27378703997801546, 1.0799466959904185, 1.3695883096884784, 0.6108757368287016, 1.606910638439903, 1.3041530046505119, 1.2482346456050661, 1.3096553739838563, 1.281993103399369, 1.4558533119385364, 1.2243797825305134, 1.389970184267315, 1.3062356082212518, 0.7955721182839317, 1.3305636207382066, 1.4023627146219622, 1.410311685697673, 1.3432466918926442, 1.2664794200249418, 1.4187358600795057, 1.4332236401824063, 1.1631624823436377, 1.430521810136955, 1.4782683079270353, 1.2549029532370946, 1.3745199392586338, 1.3157605698098498, 1.4642831092080766, 1.51893802044006, 1.28406510931788, 1.5436493347102391, 1.2892082459635592, 0.9316108781661571, 1.197939468243453, 1.3098812345511452, 1.2779075690073, 1.3190053121007026, 1.4388618670744808, 1.311776925946997, 1.3224867413382033, 1.2216813169574878, 1.2096700443702242};

static const float w2[64][32] = {
    {-0.6400944310391486, 1.8050592063008726, -0.4507443514662223, 0.20894773023685306, 2.125151183382668, -0.19851309464487815, 1.9437972386482043, 1.343535187843756, -0.8053837105674178, 1.7042592581861344, 1.2140914715954751, 0.7598714239291994, 1.4362841379685174, 0.6207452435045949, 1.4707530438804808, -0.8050990325525621, -0.689537090850767, 1.4719036950899012, 1.165282860186589, 1.8069607055238401, -0.14970754611130502, 1.3603381321436756, 0.8250111681865612, 0.2781476510401182, 1.0674474744134665, 2.01076974320197, 0.9875832558133147, 0.7275649964965588, 1.2327855931784406, -0.4197173539433381, 1.7675527136701517, -1.0339394923942467},
    {-0.41772567117668474, 1.0827202718757287, -1.0033973083019776, -1.07662253323784, 1.924207926767695, -0.48633845764594485, 1.8924459125838466, 1.483094459949403, -0.9043686600615128, 0.0468287748454621, 0.6272920621735498, 1.0464238609627068, 2.007976402082448, 1.6298647580387389, 0.13888268944953008, 0.4635604743122794, 0.07451051107429797, 0.09752950333984672, 1.1864618746775042, 0.6273005742318564, 0.6575805460318925, 1.076866453042756, 0.4823166281490195, 1.438374257977077, 0.9597324952127261, 0.9348340720731504, 1.1410502136543959, 1.3705537119162614, 1.702786893708719, 0.7599314241783524, 0.6343998635953881, 0.40576302161357847},
    {0.17916516360671406, 0.844373705005033, 0.8737420674240213, -0.30752278275232975, 1.3946133497768407, -0.27678841166552454, 1.9016070369847096, 1.3856514574643863, 0.010515661625223322, 0.3218333437417455, 0.5572540407288477, 1.5828052910712858, 1.3936417647312225, 1.3684074825740962, 0.6471380297940722, 0.9733747251306327, 0.6060603089069247, 0.6731928150269645, 0.6953744200518134, 1.5284994914536882, 0.4468833965812199, 0.7795216372231796, -0.47000063657609176, 1.8413011367350818, 0.7774208999939094, 1.0372638286720048, 1.0529754360591401, 0.9165801060772276, 1.8945082953272776, 0.8220914285659221, 1.1410685866682815, 0.08755595012781152},
    {-0.7277755107608663, 2.0351003139387225, -0.34940041470057615, 0.4807934037551275, 1.7877488057392392, -0.45514167828382807, 0.513728925240121, 0.55201665065345, 0.6613628034885453, 1.108194040457546, 0.5238229171335829, -0.21314688770825593, 1.8069514181220676, 0.6805258084832589, 0.716476585696633, 0.8793465365487858, -0.05099146562526275, 0.7006694115806399, 0.09285648132710479, 0.9414269612261291, -0.6042940638675672, 1.079429050313726, 0.42165369018396565, 1.5197697766207876, 1.3837263192530316, 0.7427092501726176, 0.5894165313833316, 1.4743083744954748, 1.8425729907169388, -0.19373124311721648, 1.0600752455680134, 0.5384424003729709},
    {0.5630689743015908, 1.8340725688127846, -0.16400926834501228, -1.154909564158675, 1.4615194306946926, 0.08043956293633146, 1.4510999122226764, 0.5204781096361055, -0.13078993511667214, 0.3722229312523019, 0.4620138014547168, -0.31350887478549416, 0.5963021541439552, 1.6002482181500008, 0.15226219302162253, -0.5929461370179057, -1.0260541793786504, 1.482172234104212, 1.1378236886669986, 0.8645070605550272, 0.2766654931673185, 0.6983583441887535, -0.31744527818275925, 1.3597180366779935, 1.4015380749410857, 0.24000222347492364, 1.2507994178955, 0.757532065605929, 0.9877537402503708, -0.3043679898109265, 0.664978333385656, -0.06952859343594309},
    {-1.0305120416622475, 1.6980094407121182, -0.6178783215302451, -0.5271237268434674, 0.4887268318434111, 0.7478957415717533, 1.7370377703203272, 1.966973655183848, 0.21522835976788665, 1.6321034928077183, 0.9553616451049345, 1.2332402087382643, 0.9074432298407862, 1.4194658681487997, 1.2351173526837171, -0.1508923293079605, 0.4642742480410544, -0.0181922721979461, 1.5876159265032275, 0.30673062636843623, 0.7632417678732483, 0.5473848043958635, 0.02409373871561539, 1.056307124372384, 1.6021007948563495, 1.922548881495749, 0.2578059828912354, 1.037263245594447, 1.9116753474449113, -0.7241081574670045, 0.1303452374125954, 0.6848984543580244},
    {-0.19965561785415312, 1.2757730688766558, 0.6750464354903062, -0.6520043895747509, 0.7695884652822348, -0.8744431391153337, 1.1795047913698689, 1.4605036422811417, -0.6489823273940704, 1.9794235730206806, -0.3863944101793384, 0.6836760155732748, 1.8658479846196891, 0.43617145815877356, -0.025082316014973547, -0.22552039158230386, -0.7911420749427872, 0.8026114360766696, 0.801726948683504, 1.381390554623463, -0.8653153931667691, 0.35261345755728657, 0.49726703068561473, 0.13565037947624803, 0.31632892183776395, 1.3792918702159516, 1.4845188902039035, 1.6032003768916148, 1.8590282121189605, -0.8808399624316526, 1.0869609571639978, -0.12972978044873967},
    {0.22119089435528957, 1.403125806258719, -0.2918052164748787, 0.1671751269925941, 1.3242486003287048, -0.6971846269131228, 0.32928568172041595, 0.1818337947653715, -0.9567635553124136, 0.6129292361305861, 1.3342498186004765, -0.37080375595967335, 0.18180077789168586, 0.3413056928767098, 0.35722430223634705, 0.35901318869723775, 0.7860645153571948, 1.299962051269806, 1.025014433411271, 1.3691279886236671, -0.49980185647495345, 1.0849866849187009, 0.32280884228685475, 1.2413290816354448, 0.5108826733208446, 0.9730762756229345, 0.9243163253744238, 1.943470962851114, 0.5139461908175412, -0.9842157220398774, 1.6588564126572858, -1.1008850084989545},
    {-0.5445125348239297, 2.191999685184391, 0.1022893955014615, 0.5721687053301812, 0.27787109441545305, 0.0250532095260094, 1.3810900770010388, 1.3745120835022921, 0.023090886745963542, 1.3095666477277785, 0.6184368231531131, -0.1340138220062075, 0.23283113919280102, 1.1654613523079493, 0.402823194144701, -0.15887098202603486, -0.665120575563023, 0.35125242091505593, 1.285758635497381, 0.07659644766155531, -0.10151036448675849, -0.032501995063182874, 0.6505060777095314, 0.8868348794447499, 0.4268554215865644, 1.8259928820224232, 1.2342874337917176, 0.2226250105859553, 1.2439325216304955, 0.0132605871376196, 0.929458035335427, 0.10559599609756415},
    {-0.8012452063906013, 2.1646610300192317, -0.004116373002041699, 0.21532800127492316, 1.9263511522510124, 0.45313466954601483, 1.6204640293826502, 0.8595101923039036, -0.6250811166994475, 0.6284759649953672, 1.2314243089250048, -0.42817229802373835, 1.0706196677334958, 1.1917943845178223, 1.300777397665549, 0.833423475566127, 0.33172113673087317, 1.615353789967069, 0.16066643179227919, 1.59629872141237, 0.1892962530117991, 0.7442505991606528, -0.2334723989335397, 0.8591338510133977, 1.6134087547041904, 1.1396217998365405, 1.4434509321986586, 1.3623060826152276, 2.066348451391711, 0.47155337344474924, 0.14570534359465698, -0.8868175692911826},
    {-0.00262412374141926, 0.8423466465943545, -0.14781163519481663, -0.2104518798918882, 1.2331916096924034, 0.7356360819605189, 0.13266436495247377, 0.6230121488782882, -0.821843895177338, 1.277302914373438, 1.3699745400467873, 0.33025181511715673, 0.06582926472015674, 1.4144765792545213, 1.5996978936102488, -0.8841605136485474, 0.6433412156219507, 1.7321175853340556, 0.0013049848444868916, 0.743981398655324, 0.23041226998617315, 0.22924039409517616, -0.45643295002434264, 0.5888861978086102, 1.878403882073544, 0.1632484831129522, -0.0817861583022945, 1.3631858001831358, 0.3424590244757223, 0.49802121751369816, 0.7192537134385989, 0.6295343196336878},
    {-0.9966433467140642, 1.6225269422377813, -0.7893677586687656, -0.3758110633045636, 1.8796976992410084, -1.0854446618867548, 0.17326375967421187, 0.6887857513325802, -0.5975576333564558, 1.9367147557907278, 0.6498076221269578, 0.2500472757987286, 1.8098706436184544, 0.18910564928075302, 1.4844593014951237, -0.5306243094101528, -0.31232354126122075, 0.8263902199172884, 1.679346923792718, 1.8456722526023535, -0.5094500850376783, 0.14825193153760974, 0.0011179894889388358, 0.6155447032767505, 1.4519550638199952, 0.33127204657854564, 1.896129510842198, 0.2927491872163799, 0.46564027003129965, 0.039160475893428706, 1.3588709694895813, 0.04323968081474753},
    {0.09413739283468917, 1.0394833498845122, -0.6890823462449958, 0.6945142139083533, 1.7107633182038569, 0.6712349238845035, 1.0656348862749274, 1.5454463426985305, -0.7044352307819252, 1.8113836100247025, 0.8388939941489668, -0.41531831168417915, 1.3321259955976246, 0.48016043698049277, 1.566049518943158, -0.6128131310222139, -0.2189325113241979, 1.2669525728368465, 0.28093492900421546, 0.9880526466949275, 0.5671472188678949, 0.1186501651736071, -0.46640368745709676, 0.8832191391564981, 0.25151597068366877, 0.43928741970380986, 1.30553807768876, 1.5609113588707084, 1.705901073880115, 0.6386937067328131, 1.6941528132483554, -0.2855128521557679},
    {-0.7368822394576428, 1.1824056834405372, -0.2231534581083053, -0.8213428632075722, 0.5735911654558877, -0.024888804429413342, -0.08249982392584866, 0.9932105765981636, 0.1937540720797178, 0.28554285661715406, 0.45589853887888726, 0.7651496428888784, 1.3953933687240336, 0.28891139640400265, 1.006869687018014, 0.25600217315624785, -1.0866799686956357, 1.2269792209533075, 0.12210990038885142, 0.07754652666904072, 0.46607397554317476, 0.7687417192758264, -0.2474678143824472, 1.101195431081573, 0.7942017989210096, 0.4471179473146899, 0.8714899461486602, 0.8697074059087848, 0.22131197114305134, -0.9218752064040204, 0.100680926438077, -0.8171113688866505},
    {-0.5379619536637534, 1.5121061463904704, -0.5673463022555819, -0.19976759864964938, 1.2006038363096652, -1.018481556438149, 1.6481374738788057, 1.4520315593539548, -0.30383765345725056, 0.9510344916561115, 1.2855874829823686, 0.43894851858501654, 1.989557963384307, 0.7217416626566265, 1.2053263373251397, -0.7353667752939448, -0.11645169400691185, 0.5454080831702101, 1.0132472337096563, 0.9391623292733182, -0.02176231274139609, 1.251208483050852, 0.8660334727577542, 1.0186241815866113, 1.434369652512409, 1.2301996211709034, 1.4839480040795958, 1.7929763692308174, 0.45564722019665477, -0.3352551571649516, 1.1221808852933985, 0.23181012575062934},
    {0.7641986669738865, 0.985462899652703, -0.29302218957007403, 0.42278793264437026, 1.064317159737417, -1.032455469812693, 1.0896904711397966, 1.2729569491386856, 0.06840182377299543, 0.21191814235364617, 0.45507353888809593, 0.029209653658112674, 2.0486476910734543, 0.8456786525530161, 1.5710529142142493, -0.5011218697466777, 0.5422609105248181, 0.9150938261833592, 0.3811800512381464, 0.5142474008329967, 0.5993861575813512, 1.7522091458454556, 0.24906054374106168, 1.6102377767357858, 1.8258778889106522, 0.5500111084358428, 0.8571826047874913, 1.710832231078413, 1.2752224720476097, 0.14799193864975863, 1.189988580033401, -0.7917572655484076},
    {-0.8946741447580832, 1.8204005876420308, 0.861393649729225, 0.1759516729625608, 0.5483001928218447, -0.9406524172645353, 0.4230208356271135, 1.4094406842780736, 0.5489327147271782, 1.3437515532583382, -0.1036039950693642, 0.4317257383452035, 0.9102338608017775, 1.3495346883868362, 0.5134570774828604, 0.04434313077874351, 0.42394290396758827, 1.1518806514661406, 1.2117169040333229, 0.42266593905485894, -0.3017501034175699, 0.5495165504401537, -0.8534717171556203, 0.7582561544919051, 1.1146675405510298, 1.147814832661731, 1.279840677778007, 1.9703591359461665, 0.5371536693053599, 0.4224968921379096, 1.1615759779071695, 0.4432427578103356},
    {0.057135515323395884, 2.2619897929712396, -0.9157622630867938, -0.43959817565231896, 1.5608441079866482, -0.4233604722753538, 1.046691223164076, 0.9399672350517015, -0.09404854760314738, 0.46824023574417034, 0.6621823780035399, 0.631236810273816, 0.2714624164046611, 0.3506635970004486, 0.43561934532012725, -0.398095182043597, -0.25600111153596283, 0.8230664089460898, 1.7098048643686805, 1.0318645620628608, -0.3603093814750401, 0.19408598539148258, -0.06420524261691729, 1.4148952563650403, 0.8731586434294257, 1.1333291809827208, 0.0900803640619461, 1.808046439859851, 1.4271335929940046, 0.5632925672533659, 0.3216327120860523, 0.5309931306323409},
    {-0.15307702670233508, 2.0202211014368427, -0.3552406420936936, -0.6145462901115843, 0.16573646813309695, 0.7664585084188894, -0.029106225168646558, 0.6149779929958761, 0.7716038307493763, 0.8794211203455308, 0.3219218505326675, 0.5994256207713946, 0.5905557564847709, 1.6188045373550028, 1.646087795007627, 0.47745111148426594, 0.6479132031394277, 0.23495098832315697, 0.08531817606164094, 0.01916941397905493, 0.11181515613557959, 0.18184469324973027, -0.3844169449914191, 0.9967172784330098, 0.3226590459135331, 1.2704994266645133, 0.14145695746284528, 0.11811982359952347, 1.4939179923988082, 0.3323736884167227, 1.0987528029361278, 0.38518613645698463},
    {0.510472035552135, 0.48693200892065697, 0.4452736213101385, 0.6708764589616057, 1.4507910506007289, 0.38988676774515724, 1.91482216302043, 1.976857636396198, -0.4170895762310816, 0.35364787036325224, 0.6981902895852132, 1.2680661518169012, 1.5017494218673932, 1.1722045870754325, 0.5756145687821062, -0.8371118370558799, -0.9906199611022993, 1.7301317094073547, 0.8759524818310102, 0.3277589877887626, 0.3951408957414589, 1.5397382887841262, -0.39386206125869005, 1.4881176009140198, 0.7087308243740555, 0.8833950929125349, 1.460902862421205, 0.8195817628170493, 1.5552098997386095, -0.8256479948088622, 0.5623945919307368, -0.3490548804437388},
    {0.07970232331911765, 1.6468527847572114, -0.4977487740912931, 0.3393857601537319, 2.271234404098253, -0.3755153211163481, 1.7670097013665949, 0.5913769827234412, 0.3715388632285807, 0.4403271612452428, -0.026618493970566547, 1.27895732153216, 1.5645786123041292, 1.4568523582810118, 1.4842739672990062, -0.623790148848264, -0.8031909164116732, 1.8141403701805703, 0.467733597626863, 1.1006223118715783, -0.9957109239109745, 0.1343360211002006, -0.7776417541226189, 0.45210279004467085, 0.7440091690366618, 0.5528823766831074, 0.24854168778259572, 2.0175781312648633, 1.2744653771271117, -1.0653894322835988, 0.19939637174914263, -0.3386974252208716},
    {0.3071156843871743, 1.1895091739397754, -0.49515076448926026, 0.6323551486941075, 0.6278519027855678, -0.13145426408402752, 1.2430228506686718, 0.1574437495902698, 0.022080148996810458, 1.7305706665185274, -0.18847552383244875, 0.23501630337542692, 2.038324148591291, 1.2593094176864164, 1.5456804554482468, 0.7153347897170282, -0.07915367517701463, 1.4704136512520756, 0.1749205789004016, 1.6971271003193829, -0.21278330096182368, 1.740738059992836, 0.7919602244111814, 1.7890832881245964, 0.614839472638267, 0.5614603654613667, 0.9144248173540869, 2.024847857677484, 1.2394978351009036, 0.6703925758702705, 1.963371844945905, 0.5052323981324744},
    {-0.9684716259316185, 0.11423104932315885, -0.5935392089650336, -0.8515714293344957, -0.0426628834187497, -0.5969554298295676, 0.04488917558321988, 0.5761500986272814, -0.11504988402499755, -0.16242640829280866, -0.4585508018036907, -0.594753932681829, 0.31074610889875987, 0.5845134490570773, -0.023390043012633713, -0.22006739207521117, -0.39246713379002035, 0.33090856460950957, 0.3625223260424696, -0.27295825244327676, 0.2597954236989694, 1.5333694162056952, 0.7970174943355541, -0.07160900727749027, 0.18760918016180853, 0.5830203940777451, 0.05378362779719827, -0.09857137371694004, 0.9131981783661836, 0.2847372092233607, 0.009763716283448746, -0.34329687578712414},
    {0.5242539052938099, 0.8434644168685249, -0.06913108348911677, -0.5168496793573398, 0.8641393546429158, -0.947149988965707, 1.7361610467665507, 1.3523925209369976, -0.4165031337616117, 1.6139488017341677, 0.6487631755616537, 1.1647294070630205, 0.36355763287880544, 0.5999996502690076, 1.6842932809317883, -0.4124163849722787, -0.3619572215115681, -0.11966392966900433, 1.6031956788188733, 1.4700240623875618, -0.6191725229021293, 0.7363538642828475, -0.6969671486678296, 1.0501280727688405, 1.3559195956814012, 1.8114242911785579, 0.4686404604437266, 1.2183717085396424, 0.8909372846998493, 0.32680339276832987, 0.5079432661561855, 0.8750878533224478},
    {0.564552679148287, 2.1602754125865373, 0.8438944150235849, 0.6461064796102912, 0.8645239804337899, 0.6693180072746108, 1.2512423298733715, 0.8694132508164311, -0.9475304887545424, 0.2220604410179891, 0.26152439567275443, -0.17340144339804922, 1.301077785277231, 0.39558994555582977, 0.9806471385496656, -0.9102040305783147, 0.7810012474613135, 0.9217165843321746, 0.7154726686644338, -0.005662630349766523, -0.6583084422327574, -0.0006495229751556553, 0.8443109488317533, 2.006485638272717, 1.0403070966225951, 1.1948528848607214, 1.0162453859128389, 1.5120788650682009, 1.5353496156874886, -0.24290467349209033, 0.4716957701820985, 0.2895605761593772},
    {0.46476233212891804, 0.5573296167307745, 0.1389511724039916, -0.35217896058049336, 0.9551679987484675, 0.3668266138341049, 0.212342228660823, -0.03143739482611282, -0.8800827747455277, 0.37780308981503263, -0.44286775530920824, 0.9649158119372541, 0.6088489179112372, 0.5186049418987388, 1.6677594170319543, 0.26443297584312875, 0.056744289479924354, 0.8743170537141751, -0.2238497142737776, 1.237491914356208, 0.054730892021629694, 0.8841642683285523, -0.03363063533342308, -0.028982285762486397, 0.7206491465930351, 0.5043604910477482, 0.4507531398574528, 1.1115799627393865, 1.3858780536530029, -0.011210076069705078, 1.0136286203823168, 0.36662215422629274},
    {0.6251735734768469, 0.8799817877133796, -0.8625468880717682, -1.1437005165235996, 2.135852856144786, 0.1576226659075479, 1.5766170019003596, 0.6170296432713758, -0.7049914814067015, 0.8668277795782986, 0.028896908759808503, 0.13898694394492572, 1.5497654375547871, 0.7563416578430624, 0.9840015906070386, 0.9444928680096445, 0.22762368300231198, 0.5524803701040203, 0.40982982317248706, 1.1581322844171271, -0.13301273784571363, 1.1786692173141964, -0.13954319052777428, 0.7781537267396801, 1.2471431104916508, 0.41794047286083585, 0.41911318871554964, 1.7510887330896188, 0.4984497744957351, -0.4407489801901776, 0.5084203824141063, -0.36817531043995977},
    {-0.8587659856213766, 0.3737531774237233, 0.2967051889898805, 0.6391003356462959, 1.8105759374316934, -0.0686633230617294, 2.009412464495639, 1.9241027881956188, -0.9204786131946308, 1.1266210630703792, 0.23459079869602406, -0.4111159353651926, 1.706242985492802, 1.6758359419460722, 1.4696989223146397, 0.6016592631444986, -0.3375967410307147, 0.948399169120204, 1.0119505125883188, 1.585650607017452, 0.762127905270426, 1.307981031432654, 0.5892336073546212, 0.5678096135048903, 2.060198556859822, 1.1594984634098742, 1.0286740607155842, 1.5220499001803611, 1.1012972932120424, 0.37177655262735615, 1.5213256486127251, -0.5367181586943353},
    {0.5809579182848431, 0.5950808502860437, 0.08251070789676937, 0.45980534202083506, 1.584311289469267, -0.9996684154353139, 1.0198578207540314, 0.35729112086397125, -0.6605562862846226, 0.4291439715438749, 1.2721847649713418, -0.03081386258334702, 1.610365211371023, 1.253615048541467, 1.273398302988932, -0.29079446963523564, -0.9900830021392272, 0.1878054373875374, 1.692720429402733, 1.8696389831711355, -0.6370056479541284, 1.6272601454332214, -0.5858175554424472, 1.5892098112321316, 1.1760931740215133, 0.30335632587536926, 0.7296712407871818, 1.880703920684665, 0.5632717352870478, 0.038732705850307046, 0.8939422135248428, -0.19023298811919515},
    {-1.0746243948880467, 1.1197135496304673, -0.5207273489390063, 0.2330039511083404, 1.943329100664773, -0.020926867802355323, 1.4316630218114141, 0.32669525168419306, 0.9341569402324792, 1.2919010360709293, -0.3319593503202788, -0.38502094712835255, 0.39336134983039317, 1.239737035838961, 1.4668018974788568, 0.8741383501916051, 0.045507447085795225, 0.5298759339505542, 0.6957818934576587, 1.3849523011576834, 0.5961462743872622, 1.829787818743334, 0.07341001313896407, 1.6608664653518883, 0.669909504070447, 0.5233902800434147, 0.9988835924313597, 0.8274933980179264, 2.195909573230684, 0.8164665503299819, 0.9122849157814633, 0.4582194115168403},
    {0.7677114308142486, 0.5716151386475601, 0.5401367368255751, 0.5396880690099182, 0.4784962781237325, -1.1000270024533914, 0.9938333270184476, 1.7897244095743607, 0.3286604578739763, 1.5970780751337834, 1.177011354557991, -0.313243546796932, 1.1591497491772544, 0.3247456521139128, 0.32495710353213025, -0.6214933829215066, -0.31863518619851233, 0.9942057823197326, 0.5769007841378476, 1.3577079545150266, -0.8678040433533682, 0.5993675982177428, 0.769922076365524, 1.6089120570033382, 0.5673404167657506, 1.4029274267883136, 1.2989643423097932, 1.0013777133329624, 1.4471517197675905, 0.5227767745222571, 0.45224273509679996, -0.7478159856093737},
    {0.20098704511991863, 1.7342190698406537, 0.41113917418157314, -0.7216653783517132, 1.827364125116387, 0.38431960736414617, 1.102389522761975, 0.7298952385767087, -0.19999847756942193, 0.16882584696584282, 0.46943833460572, 0.5342917436602327, 1.2083362359148169, 0.8983633071863446, 1.6841438878511026, -0.31914384559657116, -0.2345891262670839, 1.2768703082651884, 0.3848477366401911, 0.046650615384676374, -0.5458591715888509, 0.611217278761973, 0.32118031044977036, 1.2868759282194913, 1.6790089078169843, 1.5401649615622564, 0.6994608956865958, 0.8697170655224856, 1.6266639336083417, -0.6425787695946688, 0.7986456261116993, -0.028800171070164228},
    {0.397138484385929, 0.9507714342389949, 0.6032341771931611, -0.7069232529551894, 0.5065359509450682, 0.4441933845563109, 1.7426758636231663, 1.899842110521668, -0.6299173625143637, 1.4636864126596623, 1.0636618237194648, -0.1506842909304764, 1.4449251670212597, 0.6858508230640432, 1.3987072000208844, 0.17456630494519051, -0.5499540324609208, 0.5910924454665456, 0.2246390935423873, 1.0602020126767129, 0.7087036128013898, 1.1573111729017995, -0.8034926250206483, 0.9953935876154519, 1.2397866501651646, 1.323758847307016, 0.17357599173839663, 1.1930534140842475, 0.9108489441450921, -0.9206527729582629, 1.6603055784095357, -0.5764172215198821},
    {-0.6888138725697427, 2.2533139023155675, 0.173612588991534, -0.3422318036753214, 0.9774807660708903, 0.3938615952042496, 0.7013084000703274, 1.6712888843017513, 0.5287920160483277, 1.7178235573061946, 0.010445184160041834, 0.011319547978461878, 1.4371411787160795, 0.7398368456161617, 1.515780380227953, -0.7361115454051164, -0.22595858669830213, 1.0470312326579658, 1.1183219817793209, 1.3187630340192156, -0.05316951000713116, 1.2039660263798335, 0.2831513349365984, 0.367832374247471, 1.1745538137689986, 1.8947621681559204, 1.1573920639942892, 1.2996564356074924, 0.556198837686614, -0.8145995518724217, 1.229165637737708, -0.38489353850347213},
    {-0.37566086865026727, 0.9911359299887659, -0.44607860264701543, -0.6270318385456354, 0.5139308794385931, -0.806846576783688, 0.375548392164878, 0.8326545954219653, -0.06536106858517854, 0.1366592818436284, 1.0001896219358666, 0.33340265755355636, 1.7717167832914684, 1.7460251128977917, 1.9167582649209245, -0.8380789815985621, 0.04896116834286599, 1.6390014670101096, 0.5896884059414261, 1.588246120161315, -0.5794398271272767, 0.3399312847933023, -0.6177058466911027, 1.780974333688194, 2.0095657197995536, 0.5734503585536489, 0.31445754887604915, 1.4138390578193514, 1.5932634598643856, -0.41419028326544055, 0.9884393772155345, -0.4693864494261927},
    {0.705623414333842, 0.8292109581567918, -0.5405138730720893, 0.3034714957818756, 0.4557421137486281, 0.20838022398756378, 0.3254700569744708, 1.6856011054812245, -1.0282769498372315, 0.9375849260346948, 0.8641301736168573, -0.18565124610530337, 1.183134931638627, 1.147022729465564, 0.5449282584220408, -0.9124804506616551, 0.43989988732825397, 0.4349396973167087, -0.04868359239587185, 1.7746062436102483, -0.3882501452870316, 1.5072732802067814, 0.020919244824171103, 1.6383639231161546, 0.6702501331621427, 0.6342878339966167, -0.07420444931531157, 0.2902346243584803, 0.13095370137180107, -0.9957227088325118, 0.8332044941006262, 0.08582893490780397},
    {-0.369586958850258, 2.197588496290404, -0.41393656915903415, 0.7750772761967445, 1.6633611914682398, -0.35355242689287797, 0.470775824677843, 1.8924023588041279, -0.9378146273967524, 1.9412175519545476, 0.36919879514887816, 1.2610160981203555, 1.9616131178251237, 1.0811714130828094, 0.304264527626308, -0.37844950983180925, -1.00544620612157, 0.8729641902282108, 1.594721342406263, 1.6051061169764007, -0.964916695895534, 0.5063541334394871, 0.878092185822805, 0.03552264598655847, 1.3603824082034128, 1.544470912277852, 0.6068551815127579, 1.4978828064675385, 0.940641903529672, -0.504913243315081, 0.24702008896849786, 0.038772184484584284},
    {0.3033504680102156, 2.063773731887536, 0.9017158121748662, -0.7305667142759923, 1.3176273747476968, -0.17785802503970397, 1.876842106542858, 0.8884845462584852, 0.08739033535310303, 1.507909154652157, -0.039307924435849365, -0.10262237828545553, 1.3428789532289953, 1.7628020727989044, -0.09192194831114195, 0.927320682593281, -0.6533560113254863, 0.8213930383176691, 0.6971087962827823, 1.8912175423784905, -0.4782345866913482, 1.4157909025866766, -0.1632667702943711, 1.6718054445438164, 0.24877876522808776, 1.561944304545371, 0.9904058889440989, 0.16155654616342283, 1.011069798704621, -0.5411392522224142, 1.484141782626536, 0.029712402926027996},
    {0.5590848326900684, 0.4240376185221601, -0.381789699773767, -0.9971942340853517, 0.31587282911280756, 0.5400539485773928, 2.021496636973209, 1.77125972042992, 0.6003898300197297, 1.9101478396463731, -0.4033373114372005, 1.388804656329054, 1.215578987349412, 0.9554378078405606, -0.0021119854200800543, -0.7917884882230191, -0.35856371611854154, 0.9092226729457492, 0.26678924586846336, -0.013931623477767692, -0.03486381436440608, 0.8033755458395813, 0.04900213972159, 1.7806969517551214, 0.7419053610735514, 1.3891944457351535, 1.7491562966447654, 1.4916752123246195, 2.127817561795338, -0.397836853599817, 0.4488421356113618, -0.606467958119113},
    {-0.8216703530706901, 1.3422873000045812, -0.14003654635645424, -1.0110366949172263, 0.6253919782676443, -0.7417987332316496, 1.1478058457214821, 1.3535669809080313, 0.2624021782394786, 1.812654372554834, 0.5492395341646868, -0.32375948373155383, 0.3010791341285042, 1.3785615590144165, 1.627736547506909, 0.07940656056137732, 0.7612499904882112, 0.8541522094972633, 0.2122640183769671, 1.8715503160567395, -1.1124952204291543, 0.23543161225180714, 0.1467416585771159, 0.5116571512727704, 2.028568863647703, 1.4608059288902375, 0.6717296285203233, 1.9421208754544421, 1.2977117918524477, 0.04778104107334849, 0.4656734788391083, -0.3982462858676438},
    {-0.7330906390723053, 1.0599420242437403, 0.19974877726988968, -0.5591917950294144, 0.4587914377860371, -0.5109235867467089, 1.4957519119685878, 0.37661482815084746, 0.035006686503876984, 0.4380026478748546, -0.11325468968319259, 1.5125833869485485, 1.2195377780660337, 1.1868032173197323, 1.4952552623831212, -0.7965566562793442, -0.8674524122543469, 1.4397953459680044, 1.6385660944050466, 1.207968013132913, 0.638457965406414, 0.27551770241011025, 0.37569929958724685, 0.5650446386233576, 1.3052861139224414, 0.6943743798780905, 0.6539522330800817, 1.5894764885866297, 2.0397454266706356, -0.9028831221180298, 0.6658146488293601, 0.3833106427562728},
    {-0.7537003038015075, 0.634829543215425, -0.6853178482463388, 0.3371636095511714, 1.9723999622585247, 0.04853138178619162, 1.6259264320332856, 1.539258333156503, -0.8131768668496573, 2.0023182927009473, 0.9717639361862346, 1.066829349896088, 2.021992160442647, 0.2797812218650836, 1.0230977406596315, -0.8567934787992436, -0.2409285099472726, 1.5413451116777048, 1.6571757583168412, 0.9229380000914871, 0.0017461013125620543, 0.4493068205763805, -0.24815856612055812, 1.6908285171085193, 1.4214152938937503, 0.2920491024965141, 0.47156469503666754, 2.0266366278557757, 1.3871586595565693, 0.5542046041769721, 2.107207466500142, -0.8451002295160941},
    {-0.08165396189763602, 1.8350590315369433, 0.6517936384205302, 0.22891463715818006, 0.9818362229929608, 0.7854030036615389, 0.6115910430759087, 0.980113515219582, 0.6070720109685762, 0.12296227720710849, 1.1248124076684751, -0.33198226997305375, 0.4257333193360431, 0.2746630977128124, 0.12857477368656486, -0.2690910362851052, -0.5458105208825749, -0.04651030179144062, 0.3532465113478482, 1.7280702143875644, -0.6938335353611319, 1.5562263937902472, 0.7168800607871403, 1.983571086342283, 1.4677485191913404, 1.5547930259981468, 0.0846881853735991, 1.89144497533932, 0.987418800886721, -0.6313873141105134, 1.0897023381213635, 0.043032905356429195},
    {-0.6149894291078777, 1.3929159076488788, 0.29937682102885876, -0.8208723829760243, 1.3142442683563782, -0.9987387525158731, 1.8267626695589012, 1.3062590391879179, -0.9140758884353228, 0.7552666124181627, 0.8683997577745896, 0.8904961115324, 1.1239763828108926, 0.12195439200254485, 0.12610154027490442, -0.8033519472971697, -0.6057037005183741, 1.7428694500600086, 0.9548404551183882, 1.771437222602283, 0.41713946030282006, 0.6959260670062036, 0.9133616904086505, 1.9350728523257652, 0.1841895891709022, 1.341139443589142, 0.3058973093859826, 1.204483793111632, 0.30666865231066065, -0.07106536460822771, 0.20545796648680453, 0.3336613069010679},
    {-0.021008002168122576, 2.0187971600658474, -0.3511892266216536, 0.5021535920465671, 0.7445315493850342, 0.19038206989402992, 1.0679049235561293, 1.6974935786543246, -0.39533364997473136, 0.6782111715489928, 0.051466575344974876, 0.11363597519854704, 1.3280722364768547, 0.8918463103417347, 0.48353622901014937, -0.07048964671600894, -0.661496521570281, 0.02624196812312249, -0.20271776675294198, 0.5367873193496426, 0.21879355046060084, 0.3155830702048179, 0.91082190428828, 0.48496217464858987, 1.4104596486518883, 1.3190036520666366, 1.7598898918590904, 1.8634074998247077, 1.822416763294483, -0.35660698231976196, 0.7286443201455987, -0.8707942409892351},
    {-0.7822562201804847, 0.9699645544539575, -0.11452412230812073, 0.06528735456001794, 1.113628952995196, 0.39277878422885315, 1.0966450561828305, 1.0513450897985122, -0.7052641309881328, 1.052194277882152, 1.285134598166028, 1.3032339188151394, 2.0863562519077457, 0.6054607823065526, 0.13717268321899823, 0.307478863611474, 0.2110928066448722, 0.3969911497269026, 1.4543290092150534, 0.06466239551670254, 0.3572180874361827, 0.2978983853583653, -0.42274381020376467, 1.0934802583704637, 1.1051044754953772, 0.8135269530162206, 0.5240247585062087, 1.7677233015797842, 1.03140349977684, 0.1674136340414784, 0.39431018429592235, -0.9146405870005774},
    {0.436205341041844, 1.4262209532326409, 0.8334297444518469, -1.0300141134080603, 1.5774262904785457, 0.0034378929028525194, 0.5648310269566866, 1.1492439517414104, 0.45302856828574156, 0.1922109238982416, 1.3933126217905956, 1.4217614873610527, 1.856985905155368, 0.9188234217328493, 0.6069753578041028, -0.48910761384107193, -0.09922893002365298, 1.7435452645594411, 0.8809004386495894, 0.7305025756583458, 0.15061459709550443, 1.6462455103873626, 0.21587902149150318, 1.911777457350853, 1.5567662856869697, 0.4075304516993767, 0.1940090056888782, 0.3435630259806816, 1.1076607740669755, 0.1264364668743398, 1.2376182361587362, -0.008953950660151904},
    {0.019172920909434062, 0.5610070339122458, -0.7051984656720444, -0.7378727540281341, 2.002198763256328, -0.14060056210622623, 1.2117216472992847, 1.1679394193665606, -0.5495179727514079, 0.5159854851407376, 1.318870351770509, 0.33312351036542964, 0.942928989571509, 0.5660627632729469, 0.02682915081352779, -0.9489048196561493, -0.5576864155503022, 0.3065464441820272, 0.1666665751132153, 0.8653519371811413, 0.7668980492514017, 1.4248916813927888, -0.9323327318903684, 1.0880318997637035, 1.8489757753005072, 2.0643299529698367, 0.539114950569548, 0.9592742982294133, 1.6994045449905204, 0.3095022237495387, 1.5841239589963634, 0.5164958289886897},
    {0.6995481074092115, 0.29101980564437296, 0.08939041822689744, -0.2260867753825813, 0.8212315175408214, 0.36070938889514265, 1.9809607622780783, 1.703737554484524, 0.31611175202829833, 0.5838371129728688, -0.38112775062230886, -0.30644155620618396, 1.2317079470117118, 1.3868505128835178, 0.7134704072402775, -0.11268756016775511, 0.35676324563919914, 0.072785648597389, 0.6685063459908398, 1.7475460317248597, -0.015050777187600006, 0.5327763121043825, -0.3097746646938576, 1.7550489912456353, 0.9046976872944853, 0.35665531052441746, 1.748673645358503, 1.9407209228573328, 0.7545828267474176, 0.6200303822231584, 1.4732855830976823, -0.39131683104556375},
    {-0.5790402836672338, 0.35504239665213794, 0.045070798009391164, -0.6865121220951124, 1.7332056689898925, -0.06752944711364631, 1.3086441375625697, 0.281221564870747, 0.05809041501797438, 0.8949860291226512, 1.2002053411632583, 0.17641116603548612, 1.9490754844134075, 0.39266172507819014, 0.003930800602419481, 0.13035561467640278, -0.690492429165939, 0.9320705153218174, -0.07259541387968041, 0.9360584990930338, -0.7586826294463507, 1.0591544279903136, -0.029511319933357996, 1.5300686330706945, 1.4349203518248832, 1.3800839133671063, 0.9144485933355466, 1.3307606092454027, 1.6111988906290833, -0.428781376780243, 1.4312286694711243, 0.10793975878395314},
    {0.09950477919994387, 1.311582770503653, -0.19683343453644936, -0.6520551121927265, 2.315089804014037, -0.4359119168586994, 1.054087934077607, 1.6093062907613729, -0.7617601250015744, 1.4077565347651724, 0.1980932556957731, 0.982429311384977, 1.5262315579069177, 1.4037834553716853, 1.4777439879517857, -0.3801059921251762, -0.7122022026185073, 0.04001644264282536, 1.3910111923297497, 0.4141926799243386, -0.43211025822610893, 0.06866902937783899, -0.443896174184733, 0.33943164760360933, 2.047349823495004, 0.9966787708273845, 0.38155285692594787, 1.0542493103578845, 0.700988220736113, -0.8044016169554239, 0.22679821757840782, 0.04040160319190363},
    {0.38684644286468145, 1.0184539775321066, 0.18269755699137913, 0.10801655368534387, 1.3927706706916536, -0.6451313819504858, 1.8227509510107105, 0.9245775631591985, -0.4708143043972488, 0.19029522609452523, 1.558922369633298, 0.02759135499083077, 1.950783939014935, 1.8031635915269262, 0.20129774574930068, 0.26019198044333625, 0.1699473574601056, 1.3973432971687914, -0.0635867265277057, 1.9656433815846912, -0.7542552921989281, 0.840958898240404, 0.6900107489789399, 0.15449558232341337, 1.3065760757075195, 0.4222604827914831, 1.4842806646827964, 0.21065964343882815, 1.840140291816261, -0.12503963102758964, 0.13884092742705953, 0.026732090953985523},
    {0.1322187337546345, 2.1850294731573414, -0.17500767368326497, -0.5758963568303246, 1.094233803093128, -0.7226861623699976, 1.9192232465781627, 0.1755488346063273, -0.15461414116194286, 0.5007438378720556, 1.1803752234826943, 1.599107226817781, 0.5801086933996465, 1.2408921656847598, 0.7197317597407596, -0.5998251239530866, -0.35851813965235596, 1.3942651509965451, -0.052614774743519395, 0.6755253610929255, -0.43192712334092037, 0.18903518946792333, -0.8945566465442112, 0.8488200074836983, 1.2885218630890245, 1.9188347601284161, 0.40804806338766947, 1.918161163005342, 1.8872046132540736, -0.2490942863773988, 1.8312810860831792, -0.5909306365956322},
    {-0.05663461313016657, 0.7979312843606091, -0.08287202524599446, 0.2768950562270869, 1.5863017108002855, 0.09869826251351614, 0.42698058171654923, 0.9958542972397015, 0.16032375280872535, 0.3062458033708923, 1.0960353568840198, -0.05675952452992218, 1.8419194629469589, 0.8810667451162228, 1.6787879104858416, -0.9741103033710657, -0.04671359311671609, 0.6335131945201806, 1.2761439725279138, 1.6669166779546702, -0.6807752817675601, 0.2719582824145226, -0.7443196441194041, 1.6085059037337637, 2.1293049457294497, 0.25296459319640574, 1.753934077778711, 0.6701786635872355, 1.5221126729659267, -0.9811038258597192, 0.6286091507076358, -0.6611510792804205},
    {0.22536780654527658, 1.0750754403856, -0.4753739301692962, 0.5580480266140044, 1.940272718577751, -0.6048069535880741, 0.2600097737335581, 1.4901560227963955, -0.9940681378282181, 0.5737525908921967, 1.2935319748447554, 0.5327090561812348, 0.41773034311376517, 0.3159970950585953, 1.097330303943822, -0.7290300898634446, -1.0102447405720876, 0.5191514146733684, 1.2921762738210962, 0.46095762659080736, 0.6957998321680374, 1.6435475386014806, 0.4732571485515985, 0.23206771350635402, 0.3730073548687691, 1.5313588363176787, 0.5056767435875015, 0.7585882989903061, 1.0396361072176559, 0.07716107279639609, 0.2611583108425635, -1.0276743349455193},
    {0.44395703115355856, 0.9175694136199275, 0.3627317741492262, -0.7469541208584851, 1.2920213118992252, 0.1112623328185636, 1.9130854124984418, 0.3247145867987081, -0.9249033978882074, 0.5658321509743666, -0.2892959246895854, 0.20601247863738328, 1.3605428120513712, 0.7016978500508981, 1.7480500551749372, -0.519987638845376, 0.8298542775827957, 1.2020048954424385, 1.2816807282001055, 0.1413414331347098, -0.6104396851907122, 0.15245114364236, -0.8878066260194232, 1.7078540282179526, 0.3019874520849298, 1.0996527071227857, 0.8560310081289307, 0.6247441862288826, 1.4761271507663292, -0.9749412539967226, 1.2576666587270944, -0.14334011144074554},
    {-0.3977112359868284, 2.00023188671669, -1.0240462231147665, -0.2137662321472003, 1.458716312849007, 0.5460444218530691, 0.822407540261759, 0.8385593328398621, 0.8862153271745833, 0.5390350259765074, -0.19525299681729674, 0.5198646664620873, 1.5722823460887025, 1.6329302884088255, 1.7071481221421763, -0.36263690568234125, -0.4988635017369199, 0.013098358483274324, 0.8131352619704313, 1.2070615159063034, 0.6818019757455381, 0.09797243967917435, 0.059233603343124955, 1.950023289626951, 1.6624585470716686, 0.6793995129402333, 1.2103536273992448, 1.9744111217489917, 0.9552448598275097, 0.36113415054037035, 1.1432911969075874, -1.0559674282787175},
    {-0.29390899282206806, 0.7433024157119331, 0.8561572002043191, 0.09935885017273231, 1.273391062452361, 0.3103677558337838, 0.7508090628189218, 1.294595911426302, -0.550340232701718, 1.7915144021117864, 1.069517340684607, 0.5453883118374431, 1.7001447522413737, 0.2516442526993153, 0.4491797529015024, 0.28285901991149837, -0.09827921602355233, 0.9819221296298949, 0.9364404433308446, 0.6518754732363115, 0.6516465521448256, 0.6497366833375708, -0.9916624758286058, 0.3936768006354625, 1.9199278132846724, 0.3541560049568059, 0.029896482096535296, 0.3616048002263618, 1.612407842648637, -0.5021024883085884, 1.0184871385463807, 0.0666767954499649},
    {-1.2144172928553965, 1.4002033710851047, -0.8261980981009487, -0.24607734121256025, 1.7104432639397722, 0.5379881976975703, 1.455202159868014, 0.45621543198004577, -0.8069516234707772, 0.7183866668022497, 0.0823332510570014, 1.5674937966212121, 1.846795752816955, 1.5304068095081738, 1.593140951550151, -0.13728089570152407, 0.7246659912285939, -0.04007919203914805, 1.0776064476294218, 0.4921302436676886, -1.069043035358369, 1.2573071354670466, 0.37482499925275964, 1.905037552814867, 0.34858576365812777, 0.8440690092355486, 1.517139294934748, 1.5935017983586757, 0.6291089308584376, -0.38767891925358683, 0.30563895739876906, 0.24829450672703238},
    {0.3610479244803305, 2.1229596755774676, -0.38305560750077583, -0.02725262013705542, 0.40586476946574673, 0.054777316089635694, 1.1842912865392867, 1.2155532413144252, -0.9800774233576048, 1.2369517421809662, 0.5213117161938551, 1.5083581293492798, 0.7269867739726246, 0.5375459746700813, 0.3755346671955908, -1.0839360013505595, -0.8074456614021962, 0.1327368877870574, 1.42324944210516, 0.408229215278876, -0.7952098726463006, 2.027946584457091, 0.6809144185083112, 1.640593771904727, 0.9849342048986747, 1.5135869982219512, 1.4760696494528247, 0.8213724440188462, 1.944488839915673, -0.729166233964064, 1.5161182763118188, -0.8688635549043401},
    {-1.1072986298228065, 0.5572296378304981, -0.8480923899626558, -0.42643760179683265, 1.911009401322827, -0.5706447484623578, 1.3385555717816287, 0.48309529454693634, -0.23144821612125308, 1.2540779925950005, 0.49967770163013947, 1.2606139884124623, 1.560967151193399, 0.3762069608953666, 1.1796523556928995, -0.5021736675862134, 0.6751968224034882, 0.42430708607698586, 0.9871638912497199, 0.24569095575532013, -0.854313387627872, 1.1979967510094602, 0.7730905100131448, 1.787014486384063, 0.4597024534631209, 1.7669792660397585, 2.0236789174716243, 2.1540327033104227, 0.6844795224802694, 0.5107461308468711, 1.3016114732874016, 0.5481176152382733},
    {-0.8204950494208496, 2.138803299296611, -1.0366410478781414, -0.09461733825672441, 0.4234372260872361, 0.03567446953364191, 1.0964912522593897, 0.4248491817621521, 0.10427998630291052, 0.6848088304602835, -0.19600495317267588, 0.3287915231972664, 1.0951524970394872, 1.4019346499049177, 1.7205915141679973, -0.28451559470671034, 0.2605325322415552, 1.858954617358968, 1.5203055679741089, 0.448297518812657, 0.2784173952326184, 1.58986020688187, -0.34443132354671524, 1.2553544375119592, 0.553731545578411, 1.6282182039623094, 1.6552610462624735, 2.152432796640067, 0.5808905424635523, 0.6775444092272733, 0.6540433701964692, -0.9592335772603549},
    {0.3850733661818877, 0.28854741582161875, -0.960601402231854, 0.0610404025882313, 1.65482361126977, -0.44597376879881123, 0.9169933386732598, 0.8544526615938629, 0.04788596880607172, 0.44293196356635745, 0.40343956083730437, -0.18036733294319524, 0.4197358827498184, 1.2407677789372502, 1.7342836075491246, -0.1248520680925779, -0.08410027143651061, 0.5978295075937379, -0.07980426067934857, 0.5854739927492838, 0.1208953107153029, 1.438787037219995, -0.3320060601719081, 1.4527213242922437, 1.4478688037772018, 0.27467499064383283, 1.6527017834181337, 1.4738732063303424, 1.6026136305653074, -0.21616722469079142, 0.9563309831837322, 0.5187979122361189},
    {-0.8487181336619455, 0.4409576309772243, -0.13242197622651466, 0.07233290328084122, 1.162060236541622, 0.3788318353012357, 0.42292391841054244, 1.389218552561826, 0.8191945362062852, 0.2643844165327265, 1.5121767975462046, 0.2771695957357116, 1.3329452368691912, 0.8205676042417841, 0.5015480608698224, -0.26260556314167716, -0.466022855691233, 0.8548262600227585, 0.8447102222062995, 0.87555053362668, -0.4276308292354206, 0.597249487326754, -0.2679499770276997, 0.7157127444438566, 1.4375055610953242, 1.730861853060502, 1.1274186066798226, 0.6560715010849969, 1.023319991810236, -1.0289029433582235, 0.9501755781008103, -0.06383855498578761}
};

static const float b2[32] = {-0.26489387528132774, 1.3895781317101772, -0.1135806675168113, -0.2327804305145395, 1.4133984602946787, -0.19590819787975283, 1.1992676783199046, 1.2301031574182053, -0.08185969021258478, 1.313815528045449, 0.6123461731277194, 0.6817789337797412, 1.2119140163931958, 1.0778427046272847, 0.9764054626433945, -0.10038438018744014, -0.2596348376558641, 0.9118185551375342, 0.9271397514710917, 1.071447094599775, -0.2356537183106957, 1.180370886279125, -0.10631394020020804, 1.1250570128376753, 1.2936597991765681, 1.291517869342378, 1.1769472379752195, 1.2276087412221626, 1.358943158153214, -0.21401713491682534, 1.286963809457099, -0.21419351498937325};

static const float w3[32][16] = {
    {0.3748246997279201, -0.1932147545725493, 0.2815942264168532, -0.5783001325142454, -0.18235078574385383, -0.04808648378132904, 0.21284494088087832, -0.6046481542954855, 0.4743761404287807, -0.38804076912257646, -0.8429094958967593, -0.1244521008496191, -0.272152917423826, 0.08916126525273942, -0.5600799163961464, -0.5179564056006771},
    {0.1383014613606494, 2.088306288554145, -0.03694875282033339, 0.9302423234299857, 0.8313474637233823, 1.7403411913569464, 0.5811937312342734, -0.28460303887017036, 1.686031424967334, 0.9907592989911642, -0.11920550368584042, 0.43921653043292946, 1.8531135193465846, 1.1380794109938717, 0.3199970869177711, 0.5416653589042952},
    {0.11626921999078987, -0.19132927317316795, 0.9276547074416137, 0.9107233283824738, 0.46343757909312977, -0.4165144007634516, 0.37408507660430534, -0.9492697328329758, 0.2055568099944961, -0.0666610872518337, 0.26233777349549947, 0.655233136241449, -0.8232162808219604, -0.2512277811775215, -0.3874405037966817, -0.37255529292091827},
    {0.7839215195740011, -0.6935809804053068, 0.3803506431826989, -0.011839692529449218, 0.7564434404581928, -0.7774818074708096, 0.33439956684027516, 0.3600327980861748, -0.683811614139687, -0.1550682875952093, 0.7134059703237301, -0.3762827398369653, -0.2112796131876284, -0.5597554577042935, 0.8695906731054142, 0.616650809812962},
    {-0.9509785704026066, 2.0397753282050597, 0.38180779963737155, 0.9454243853268421, -0.8288589732827495, 1.6683197356287582, 1.0134875380886272, -0.47586952243638103, 1.812322951739658, 1.4847188118956702, -0.3928158597722067, 1.1774634841580387, 1.7768498213237898, 1.2601198415820956, -0.6644672002284273, -0.08503981753534501},
    {-0.5928492282258396, -0.07312436955384768, -0.13530182912079053, 0.0861012010720098, 0.48876764848948134, -0.2818050182671525, 0.34396954724835915, -0.8431061374855421, -0.2791775533205625, 0.322035664204465, 0.10976329166313632, -0.44063898067886653, -0.7700101186838025, -0.5328354571899848, 0.570140797518974, -0.4181593458767662},
    {-0.45742965464980895, 1.2932807295464097, -0.004098989330741135, 1.5474157202852403, 0.1407209695565992, 1.286092941148514, 0.8591555692406084, -0.7574678416562152, 1.6424378321345707, 1.5881044795550923, 1.1764541450837054, 0.2611171475967865, 2.0300513990952522, 0.24473081941258837, -0.21199774076486189, 0.5462465209357705},
    {0.13135548009588258, 2.084154566496778, 0.45005036693715, 1.4029058047547145, 0.290779408402012, 1.8061137147241526, 1.6980201941921764, -0.6446792911498781, 1.6458216235951524, 1.0060995515107758, 0.533256211032055, 1.0068587133977862, 1.0257483460161392, 1.3377978738614056, -0.23435228108696107, 0.9362837800276451},
    {0.6575309748484571, -0.5520877228914601, 0.32656771937919893, 0.12072028707186973, 0.9386742594746611, -0.629839726952849, -0.5490144759832359, -0.1726435252518186, 0.5095091532288216, -0.010719374540171306, 0.5991172638524437, -0.8408336139324262, 0.4960904667336814, -0.4495278337544536, -0.7370119645440943, -0.26066219385136724},
    {0.38619307050236296, 1.7122529576628578, -1.0327338478503767, 1.3221968493526612, -0.36032081468233235, 1.7595857147802039, 0.6474019153500861, -0.1255731820170716, 2.0496744609400936, 1.3325870287602268, 1.4448787075765013, 1.4640509799951773, 1.9459786914162644, 0.4659128164093403, -0.9704326729177895, 0.7473146885609471},
    {-0.6626734857039864, 0.803693378793437, 0.6813441510779493, 1.2993656368885023, -0.19007623134808432, 0.37494215422200106, 1.0859575640228614, 0.9206299361389824, 2.0639006364712733, 0.07885980035749643, -0.10621232021397074, 0.9617680048707459, 1.166114875151256, 0.0851776648286662, 0.9189184117171643, -0.5586423635770471},
    {0.4091466858332982, 0.14415837319717378, 0.7545314201145442, 0.8579137861326033, 0.967988996928341, 0.5914528057870592, 1.6861221568582478, 0.6227468386385252, 1.5521526986740304, 1.4505717061901142, 1.4412988331970649, 1.4845733016738079, 1.8681606625161922, 0.39704476096784636, 0.801996637300882, -0.6322896536044779},
    {0.13293819421917386, 2.3464135025748942, 0.11680291350239659, 1.3866391679518866, 0.29045065921315105, 1.525858155446269, 1.4262347347940372, 0.5166792683721717, 2.0259560167869526, 1.1553412860728307, 1.4092755962491206, 1.1026706160336337, 1.6482549695001723, 1.916251770610602, -1.0219685258525009, -0.22155000825244875},
    {-0.24191791867461396, 2.1137062865108027, -0.8120713697869427, 0.7896723473783195, -0.07536556395747436, 1.9294986557759541, 1.8469924910181543, -0.1740309759363485, 0.8441921285447875, 1.4751744383218188, 0.13220588331075717, 1.7113413728046984, 0.9667887637532716, 0.8051668165982572, 0.04382978415057697, 0.614875164600304},
    {0.6471545181407101, 1.0085386254327668, 0.4823483036474452, 1.533274880903283, -0.8845587425049226, 1.7416102621579994, 1.629144305415554, -0.9551894637807659, 1.944557940859059, 1.4530811451100496, 0.7142240236110853, 1.7999828900637802, 1.684514053057834, 0.7308508629299635, 0.04503767457039527, 0.58278677151889},
    {0.042696232458625596, 0.8923453769521991, 0.485473212049788, 0.9342151185530739, 0.3779244469306171, -0.3768810217881815, -0.5879198525375084, -0.7422178100371014, 0.2337388167591325, -0.15965413426942654, -0.5993114649529896, -0.3142908280730787, -0.6957655467687098, -0.6431756926421451, 0.680407605583698, 0.06368503506922737},
    {-0.23321412578953238, -0.026070812859256786, -0.0777443540127242, 0.008786515145269751, 0.6737428997714832, -0.2622365420745605, 0.6897933167869505, -0.5860288407953145, -0.9275911539254257, -0.8446320110177952, -0.5231379678922251, 0.7239537533682574, -0.8228467293975226, -0.7752262544674915, -0.5945340238027765, -0.1965269099365124},
    {0.25609041599975796, 1.5103933902441817, -0.929087765841851, 1.056863288563832, 0.11417284322065525, 0.8398893561165979, 1.356811189348687, 0.8105676158475853, 1.1646389807043156, 1.2385573553548774, 1.3755234060729615, 0.7765418994740316, 0.84735319038683, 1.31474398604359, -0.1412246490473806, 0.7107229382107606},
    {-0.3975567795459271, 1.08090831491817, -0.888410450734258, 0.8690689563592011, -0.6266678219517904, 0.5989466655933623, 1.4527533436369013, -0.3316021304674864, 2.176823746495524, 1.6397697568364789, 1.616479331055478, 1.6137881942767363, 0.8829867501459806, 0.5347407723449216, 0.27609228128573055, 0.13390319935719444},
    {0.7786934523781518, 1.7580698201549965, -1.0189779292581256, 1.7781449661852573, -0.48573407915125366, 1.2984014407544298, 1.5717442222730778, 0.887347185638632, 1.2850463419416756, 0.8836150028710037, 1.65084964244874, 1.9249503335045688, 1.8807580243149165, 0.43216219088521307, -0.04777595350614594, -0.8805811831506464},
    {0.07208858185550336, -0.37719121939324907, 0.42406100224651083, 0.33474439054496724, -0.6447985638917036, -0.04815687708365247, -0.8334917817593246, -0.6533447488323687, -0.6972413862769508, -0.7765828688115888, -0.7454771069212714, 0.6569274670045044, 0.10359247684824928, 0.7447286663850166, 0.7871349573092487, -0.8993160864918063},
    {0.09945518986372662, 1.8116263227006686, -0.3212205471567821, 0.9473964121518701, 0.4847585266452051, 0.36468556073230274, 1.5210706107103875, -0.5214945371376082, 1.42179187565854, 0.08422237261722934, -0.01348368377470278, 0.6099822317877841, 1.4259447752760321, 1.1857273031395643, -0.206629620290015, -0.3637238940501471},
    {-1.0993352336976419, -0.390081371965628, -1.0836360378229843, -0.6247560881746269, -0.19011670869634537, -0.521756142811403, 0.4728644937649819, -0.9876881800351285, 1.3553722872737222, 0.013725412109934899, -0.38659915214478896, 0.8139882901601391, 0.5161738091474438, 0.5476900958076983, 0.10779187454052246, 0.8274112391987667},
    {0.5873074520700645, 1.6687667799034525, -1.0152385746078436, 1.739912363194918, -0.05980952463981188, 1.3889299397418358, 0.9241421294371077, -1.0418135456076478, 2.212156944827382, 0.3983616649580766, 0.971055838828173, 1.4116217538539728, 1.7465157993581468, 0.6753024147857668, -0.8475481903149231, -0.7345943450333174},
    {-0.034382476599394536, 2.4068123709227778, -0.5848551204921575, 1.5642002490826643, 0.7453567065033011, 0.6549709334224764, 0.26026663026196156, -0.33665252720182215, 1.197875454744697, 0.5418179265155731, 1.3103474041160383, 1.4449095641454057, 1.2878276492003697, 1.7111542106468045, -1.0122142318857377, -0.9065223886726613},
    {-0.5174469743922011, 2.462715130621686, -0.43610300453654677, 2.0510014871753213, -0.6842593975654134, 0.9463542256175012, 1.3233191228445875, -0.856244151981374, 1.8368843259863417, 1.695031524367376, 1.109836429276405, 1.9398362246028258, 0.9334496465117751, 0.9814396591531165, 0.6694675947593345, -0.771845740034767},
    {-0.7830314980162347, 2.41250191187524, -0.9715752606065314, 0.7667299859116725, -0.25625485545886834, 1.1980441859794315, 0.8492224823998104, -0.9284860519159961, 0.9743178546421445, 1.2855687340195687, 0.3863572098230786, 1.4003771949236656, 0.5309760692712867, 1.703852264615164, -1.0111540021879937, 0.46426610985953853},
    {0.47553936553803783, 2.4236029675219584, -0.723333405511213, 1.6606221524152205, -0.8393797037880664, 1.252643537768633, 0.23905650492113967, 0.37860117215553074, 1.0306864779136353, 0.03947808395491523, 0.6424761083978644, 1.722063618153754, 2.0569847514438426, 1.3773224589516002, -0.9766906328926832, -0.5445642836141003},
    {-1.0452165255207317, 1.8911638909842516, 0.626727821866109, 1.4439857755665761, -0.3612018001378044, 0.8721437583782257, 1.1419881924056836, 0.30482330683060627, 2.2338824762702014, 1.3056705059201128, 0.4994838037667246, 0.6490869328358405, 2.002953993057989, 1.9132360405370523, -0.3690040823096285, -0.8392327164595959},
    {-0.4081235806917402, 0.03628824958723428, -0.24469281936705864, -0.02495271906775607, -0.4708088991309135, 0.24746207892448224, -0.5228061131247531, -0.5800094930606505, -0.6770500112564035, 0.024538913452244727, -0.7434642666344249, 0.7873922431994622, -0.22353340858911927, -0.18265111500828585, 0.8827488714472628, 0.3577846344697994},
    {-0.04398785904276733, 2.1724720038153613, -0.6595615205081187, 1.6019860173439908, 0.6057683569885829, 1.2921238200999914, 1.1723132244496237, 0.05037975776444999, 1.9886261098660196, 1.807152571227238, 1.5398880808213937, 0.8002866746959199, 1.6801009737631913, 1.4959883903303053, 0.42757949031261494, -0.8022107219149389},
    {-0.578822953770406, -0.644359112895676, 0.459347100052182, 0.5223706264515766, -0.18042356985792826, -0.5478065309659157, -0.787367413439119, -0.46652153021896736, 0.07989807226582243, -0.46942420929718864, 0.31349878962088096, -0.19958171601696498, -0.06914797690725703, 1.0230707241376207, 0.49897457409694873, 0.5687212300363477}
};

static const float b3[16] = {-0.16286480386264215, 0.9152378350024657, -0.15232266304470393, 0.7240374549174464, -0.09110934059422339, 0.716007931645264, 0.36682931558128046, -0.08040186929192608, 0.7903982074927671, 0.6817069949590999, 0.28637433552106834, 0.42498184638574776, 0.807911201326111, 0.6336645161188844, -0.05860968146141055, -0.07257604344013227};

static const float w4[16][12] = {
    {-0.13440410907123307, -0.19408411061740388, 0.6429560488625033, 0.5090015714845865, -0.7484386279368729, -0.011495972878341464, 0.8141828398834435, 0.16598867567433004, -0.582509260626973, -0.39304768376550026, -0.08563190787834137, -0.4233866477554728},
    {-1.0892026196430964, -1.526295073997999, -1.5671212199887121, -0.3988047366521974, -1.6940847068040563, -0.46369315511802417, -2.068352150344225, -0.27459653737825834, -1.9307483219327584, -1.389352869890121, -1.2742161256587836, -1.0853190946512257},
    {-0.22221881517516273, 0.035767532998210005, 0.028770188452929557, 0.012005210214680262, 0.514772748522792, 0.21499783001252012, 0.7750440973938468, 0.03045678390511669, 0.07524613192359125, -0.17710734361885008, -0.13022549697042443, -0.7052225572474915},
    {-1.6460966052568597, -0.8514939113210082, -1.6014091033514992, -1.8322411962062461, -0.411195400628464, -1.077482738700123, -0.41296683760512565, -1.712562799052049, -1.680519268890222, -0.061024733181806304, -0.7578839758061235, -0.2474727073520572},
    {-0.2518925789301362, -0.7052642976831927, -0.630673293897004, 0.2810724653806601, 0.4315582655293621, 0.26281327535920823, 0.021684413639394794, 0.2649498173470529, 0.7788065408506876, 0.4465679485984899, -0.7149033151040899, -0.9575237345336997},
    {-0.015522128452843847, -1.6118222712661963, -0.36913511643126157, -0.8732914898338002, -0.9151554498202906, -1.11093091008817, -0.7190841495048466, -1.160285450378882, -0.10371336157969578, -0.4935644428972839, -0.6698299143433749, -1.7448617064716332},
    {-1.2007956006658107, -0.30502953251240683, -0.26419026478676866, -0.06172901341244613, -1.7075209076799867, -0.6836226817857329, -1.7478075412086718, -0.8774453224182202, -0.04507842070336005, -1.351177095898438, -1.4640181604251141, -1.46399012377966},
    {-0.19441502598703797, 0.8122516187891397, -0.25727289398925257, -0.1206742253112472, -0.5350636431951522, -0.026516506190674135, 0.16786343261811873, 0.36507207852372486, 0.887568617379554, -0.31464285871488656, 0.10520901943755166, -0.6646788068278848},
    {-0.8762217092539101, -0.7569456610005381, -0.57504042882783, -1.5510947252347582, -1.3933152224887448, -0.8512924472541213, -0.41574163879767745, -1.6705412392468606, -1.1115024599308674, -0.8117293716125864, -0.6390577192833798, -1.6818141618721552},
    {-0.8539619898547096, -0.2784789100726462, -1.5162038476282478, -1.3867024224216784, -0.6163355092134364, -0.4406431736372769, -0.6550023395360159, -0.10332544496636174, -1.4103652274553378, -1.485758568596792, -1.336494554676763, -0.754804735961054},
    {-0.16863833892704339, -0.9686866890232143, -0.4258321027669284, -0.029393476601546703, -0.598221911733907, -0.7764061775180207, -0.574231094080034, -1.5355807480248986, -0.10207953552909808, -1.4659428082374162, -0.9269578910314722, -0.8290637960402655},
    {-0.8027821406217399, -0.7121412324204249, -1.05194883739976, -1.4806925734798773, -1.017066819608645, -1.2207443836309044, -0.5075121119477012, 0.030592221387463314, -0.8193417121747997, 0.02880263387770301, -1.419889098331708, -1.1955890588439801},
    {-1.832648898164717, -0.7108159432034427, -1.4684506688481287, -0.9816158074361641, -0.5886977136139822, -1.7855623943959322, -0.6305395048641405, -1.5645084089026124, -0.9657227334411108, -1.4523198227398562, -0.2174384166965046, -0.46411218635961726},
    {-0.6669449339513324, -1.5919607931302646, -0.3883087125486317, -0.7444223298341633, -0.2019576434817694, -1.269344839015446, -1.7498126189214975, -0.8136837618906444, -0.5913176964115876, -1.2734359739717036, -1.258852538213101, -0.028357571608947005},
    {0.9136740553183783, -0.06874602334506297, -0.06465001754785715, -0.32765192261968384, -0.40635670588242656, 0.6543498096020074, -0.8886378125111487, 0.7436628096149318, 0.8948416484349753, 0.21120283093094266, -0.6294877389821062, 0.2807977870580809},
    {-0.6065566481373067, 0.6020924552153697, -1.0424515982893097, -0.8860630031648411, 0.46220114300630977, -0.6131888143306496, 0.5511909232348797, 0.3284226925562862, -0.23924304745312805, 0.7560001335281965, 0.4297757134838477, -0.7008469631807223}
};

static const float b4[12] = {-0.6293553180189217, -0.5058919367020763, -0.5141945821188115, -0.46525046913952467, -0.5703414660270746, -0.5110624223052693, -0.48666496540930443, -0.43659312162461783, -0.4884212265255092, -0.4784673817309479, -0.366978940884742, -0.4783198547199446};

    // Input Layer 
    float z1[64];
    for (int i = 0; i < 64; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[32];
    for (int i = 0; i < 32; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 64; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Hidden Layers 
    float z3[16];
    for (int i = 0; i < 16; i++)
    {
        z3[i] = b3[i];
        for (int j = 0; j < 32; j++)
        {
            z3[i] += z2[j] * w3[j][i];
        }
        z3[i] = relu(z3[i]);
    }

    // Output Layer
    float z4[12];
    for (int k = 0; k < 12; k++)
    {
        z4[k] = b4[k];
        for (int j = 0; j < 16; j++)
        {
            z4[k] += z3[j] * w4[j][k];
        }
    }
    softmax(z4, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
