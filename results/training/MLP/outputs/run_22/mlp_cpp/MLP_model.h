#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][32] = {
    {-0.7477940949626084, -3.350295147537553, -1.0424011845126973, 0.20751086619928197, 0.1627255243259102, 2.4203000475459358, -5.2155620163734016, -2.0949126769459756, 0.9633147361317074, -3.3264663513647696, -4.896226993365593, -2.6251556444299817, -1.8585991373025128, -3.4170969045751076, -3.9178150131618574, -2.8844807569294413, -1.6265079544246228, -4.172313049874782, -3.040427786994835, 0.7955073941834414, -4.956180406817278, -4.100914623286106, -2.051103139740572, -2.7934665690459495, 0.44415543472103103, -0.9802460387046212, 0.5583377141818459, -0.028057319659939656, -2.899373913975667, 0.14402217210715054, -3.6636320587256654, -4.669565401671586},
    {1.8144762114881308, 0.5750121252447123, 0.3442986448553054, 0.25671148870226046, -3.651655016566405, -2.391151876499287, 0.27276350443103375, 0.22313189533394537, -2.1740189131005496, 2.5311301404587585, -0.8565900702086836, 1.5213722988933325, 1.2129289598373165, 0.5344828762721561, -1.1006687698480653, -1.5966597774295208, 0.3470005331295399, -0.3803889999312253, 0.3430558277758702, -2.2374048945465677, -0.792407023027928, 1.3842532572197996, -0.08107062164237358, 2.7601420082534247, -1.781113088764152, -1.760388562895229, -0.25827729092856877, -1.1967633324581635, 0.3084874024107555, 2.028599205630321, 2.1484274066893962, 2.3888265753111675},
    {3.1282975139043927, 0.703800749765847, 3.5591113248069206, 0.010308607490164805, -2.1186699396172637, 1.315939876574518, 3.515288130902948, 3.9442072823360967, 1.207165848145121, 3.856610818937233, 4.926265121503721, 0.6156686544659695, 2.4034684167451488, 1.1618639642336392, 2.750605830691312, 2.766437455630266, 5.019178159643637, 3.4400846926631736, 3.365942327245622, -0.2690850055248571, 2.89839457661112, 4.249016368326798, 0.1584699176780122, 2.2715800070048524, 0.879912573802778, 4.206533170250233, 2.1130580509884274, 0.24883481852389658, 0.6853022695306428, 0.29894323490304653, 2.9747450896006824, 2.408870816567037},
    {3.3486653562938016, 2.3862968594064604, 0.46098021607040374, -2.185548797602734, 0.567990506534777, 1.5804279194483064, 1.1075791139723172, 2.9820292220625335, 1.4246957415143504, 0.9377938827123649, 3.5087668438798953, -1.2314183310867863, 2.6057876330875565, 1.4437510193984684, 3.8230261924765023, 3.6407619463951586, 4.1831533863138, 3.5228049823409835, 4.276291476206879, 4.077601641813404, 3.3661546095830706, 2.7644556849078885, -0.3076143375647855, -1.719378714180198, 2.5147058405304956, 5.096917949112316, -1.0897087146851823, 2.102895912017859, 2.821475456308121, -1.0797960223344716, 1.8247425969203142, 3.4681855694977406},
    {0.845569821631168, 0.8903042648323086, 3.658642331300401, -2.0777108727682725, -1.1009897877846448, 0.7083723336469494, 4.533935555940146, 1.6726835525676473, 1.8533912092531712, 3.2206534585905846, 2.728295360844281, 1.07328430115742, 4.298580290779693, 1.3093420550706865, 1.7915933430997917, 2.9522755188632996, 3.1028629473104634, 4.233339638458425, 2.535457805009525, -0.6804926521499804, 4.0931759361983975, 3.2292605865148736, 0.38886548470742105, 1.3934434459015523, -0.7596972658718383, 1.4194058401080207, 1.8750838444115097, -0.23392113116869184, 3.386162522460189, -0.7934999314368488, 3.188673381253137, 1.852262523003369},
    {0.36149886686874033, -0.41330151067993887, 1.4848334427013674, -0.8077162449170273, -0.5462529942870525, -1.3045972209675663, 6.47074381232042, 2.0267259471661747, 3.1186387545400556, 5.559869004298022, 6.009998787718352, 3.6247486280601606, 3.9117921732796663, 3.914197268780403, 2.6901955172842555, 4.918126564242075, 2.9327859759526715, 5.429071164419427, 4.020034567694144, 0.30642017047701847, 5.880228479627907, 6.000101028309649, 2.9236120431073345, 2.042937823374585, 2.1348579013148177, 5.022874929982033, 2.660062524618957, 2.9167409979728918, 3.5331486375261356, -2.27309521967884, 3.974269845280769, 3.624616281691448},
    {0.9111208733949313, 0.3533513227311267, 2.091615111750999, -1.905197644592385, 0.4556726669896955, 0.028927197496519823, 5.991832262736359, 3.5309713109822596, 1.8558016459479274, 3.2978819345917465, 6.556006295335536, 1.831846266088454, 5.039119492018608, 3.8583661713875497, 2.8411205791871756, 4.999981846259736, 4.8240953152665895, 4.308287698114742, 5.073377033913432, 1.3116452246693646, 6.000455521861284, 5.640743698689331, 1.105643003156526, 0.9788598233882664, 3.975245575416936, 5.135965814056706, 2.6121667870981686, 1.4806581321628762, 5.138897248057343, -1.7386825166921365, 3.468673701935454, 3.0638616713123725},
    {1.5116361781453564, -0.9664209047483198, 0.18538665792774042, 0.36055071610958295, -3.1836593925999015, 1.234401898864531, 0.4133797726667173, 1.952173000999632, 0.04126633728380644, 2.709023315848375, 3.2493049531157205, 1.3231435472304638, 1.2422559963216815, 0.562685774398298, 1.2705734153776944, -0.33024941801558766, 1.6342231882911673, 2.158027628589161, 2.187033034381049, -0.36914142457846016, 2.2297707177805313, 3.0426167857288915, -1.3952929396519156, 0.3784380673534083, 0.9562032383816292, 0.825466191034653, 0.2975320598360682, -1.1334153169707935, 1.5494815962933814, 1.3872442658639623, 1.453282274694177, 2.866708453124939},
    {1.6740489960998395, 0.1710844111584022, 1.2129260045075734, -1.4168665789571728, -2.9212188170412134, -0.19009591059843567, 2.558308529160878, -0.4231792678619856, -0.1805904695829463, 2.362197117177637, 3.4919016710203925, 3.75914756180527, 2.864683655802934, 3.6149877030668156, 0.6180984193419501, 0.8975072837077637, 2.8604579648282646, 1.868453087227394, 0.4510087471686579, 1.5543364741945793, -0.01246054983704877, 3.2846615612781696, 1.3899137997991557, 1.1019674463801332, 0.4699086694947475, 0.7402959908975946, -1.060713612196433, 1.3622357855215894, -1.5743684167751755, 3.344227288889384, 1.2334233836966895, 2.871192484288291},
    {-0.9068197121220951, 0.7268319874301622, -1.4976795343923457, -1.4028521423186124, -2.699107480395706, -0.5967048496939653, -2.1123646733322374, -2.144853244332912, -0.6135567378044449, 2.283187085687498, -1.1134292908478085, 1.3078368755496872, 0.8812312387715794, 0.8620895693010997, -0.9686502460817366, -2.9153892426880312, -1.0633006163764254, -0.4129182477631857, -1.739746515545623, -1.003342855595984, -2.6427567610968237, 1.5391003885546415, -2.180955888580023, -0.08421078752341284, -0.4804389493514011, -2.1522057086508046, 1.0428004268571647, -2.3719085538662683, -2.591551989892866, 1.7143982380969973, -1.01071272803157, 0.5029749978560416},
    {1.1858291228865256, 1.063184450650633, -2.2651187090730445, 0.2267012654365549, -0.14587950754626536, -1.623106892370237, -0.5621036881868443, 0.9564837800927268, -0.24038583357539947, 2.5043098393560586, -0.1436421086055261, -0.9763009098898796, -1.427307949405803, 1.0184874213008808, 0.8153997951787967, -0.24204124633366397, -1.3275169108475167, -1.1325028019412715, -1.4609336138271358, -0.5346095627959193, -0.8725912587171413, 1.5268691160669459, -1.8129360502108547, 0.13864666283961155, -0.2171718621704976, -1.8834772190251208, -1.1975601708387105, -1.3205263225292576, 0.802519482362005, -0.2983071487039311, 0.7505549359486847, -0.2543505035396681},
    {2.794615850175726, 0.0041311512509104795, -0.5252168032029779, 1.387410725204614, 0.7034893436132781, 1.4637592805618123, -0.07218857540838781, 2.4021142066373145, -0.5308948696185486, 1.041332592111891, 0.9349204916309385, 2.2605820258354, 1.101406154358982, 0.9506840368137013, 0.2552234719975486, 0.7215747771042119, 2.38358571873653, -0.5749632453926136, -0.7602450431795081, 1.3786940934935143, -1.17005933776942, 0.0661567004393304, -0.42316655592052604, 1.9704638658121372, -0.5896412318249526, 2.621525193520577, 0.2761291001175113, 0.6453932481521099, -1.9360877074176819, 1.832583317655528, 0.004767535849512631, 2.313892582365938},
    {-0.3405989628334242, -2.5860120420584147, 1.1644845926163183, 3.3083158861701145, -1.7935919147724788, -3.13449968173821, 1.185690296957962, -1.822211326760251, -2.1866255241381176, 1.678549258819679, -2.5698627243380114, 2.1415349928718195, 0.33430669705833493, 2.726106705119592, -1.9488137151888474, -2.8809181291913784, -0.7457122946727409, -0.4884774240197165, -2.2597332682350926, -3.896919197943369, 0.12701190421755557, 2.321410929731414, -0.0965769709874368, 3.3832247779424613, -0.05113512325915383, -1.6971732240697681, 1.7922988355429081, -0.7777574082951251, -0.5689940232575017, 0.9615674056739004, 0.8359040099942253, -0.45628912533946864},
    {2.6927891753447573, 4.0430774044256435, -1.8449938655048073, -2.095855350388684, 2.2282051494307873, 1.7772681853167884, 2.768393285022746, 2.9882651243577696, 0.9432058910379967, 0.02921182048432545, 3.8186498700006513, 0.121965807899445, -1.2315351131020758, 1.7861020920436548, 3.0917320993278694, 3.4740881282749916, 1.6120457918486002, 2.0543299701293547, 0.2709725443556413, 3.0984209603298094, 0.2100910726669087, -0.9217510693392885, 0.09835813996499493, -1.6500911911729408, 2.148595870757257, 2.961330032051501, -2.2026221923361793, 0.23483226143553743, 3.71661262077622, -2.266530337603444, 0.6922764289045323, 2.972893056889286},
    {-0.7702453310869073, 2.2468654841495064, -3.936905924907287, -2.2008041765524524, 3.8623187007843405, -1.0273872779828326, 2.0117045742761146, 0.2633326192175456, 1.8843106564975092, -2.1932653605968806, 1.4975029425008513, 0.7185602012357546, 0.48664813328773737, 2.5817427153545913, 3.33864816400328, 3.8153114839927316, 1.992855914667947, 1.3029777971810008, -0.61451671997266, 4.31826295843448, 1.2103603379310233, -1.7646039532767859, 2.444307088660751, -1.9609626346640632, 3.487188005153278, 4.4852591806967705, -2.252792615354516, 2.9960358882467206, 1.755121014358045, -1.4862459260692717, 1.6454403766140384, 2.4327954591627763},
    {-3.0287280118422286, 1.233011925359557, -2.8933703705726717, 1.2865817856869954, -0.021945091998047235, -2.6476282414747403, 0.4447209832237019, -1.27707570679018, -0.38263139824243314, -0.40078337365924205, -2.2058804619171926, 2.755508484338987, -1.0767934360557423, 3.6486315899796633, 0.17272629226428593, -1.0500013617850192, 0.05060167409012477, -0.9523470214967531, -1.7071464828851237, 0.999451982415068, 0.7678576149855029, -1.4202242844236357, 3.2702817410139695, 2.650830903023426, 2.9200586678877483, -0.8485745510176084, 0.3197143408603237, 3.5655659852899597, -0.8773672904089025, -0.8003758301936327, 1.1213589878974355, 0.40446828073497987},
    {1.7816119445435983, 2.84714937260822, -4.282064863323807, -2.926064199092811, 2.6813198247613657, 2.0606737098185883, 3.0684920553740116, 3.4580609255664516, 0.8137232675984823, 0.7423205057527174, 3.3511797815927946, -0.4711173812288794, 1.5936340852425455, 1.691360957243811, 5.150997591089642, 3.8588179414320543, 2.9057975686733593, 1.3688880655949804, 2.8921821265781986, 4.843976262064085, 3.00867709945108, -0.14473147544729267, 2.4402338085801447, -1.3644153399230436, 4.345214395744546, 4.8879072649106075, -1.3019582339717204, 2.5684340491556594, 4.648057561625631, -0.2825755438596338, 2.574369457108422, 4.152153496344756},
    {0.7095775509853115, 0.4383709275460604, -3.0330670988787, -1.177676735360909, 1.8751217318931652, -0.603017967185469, 3.87443661192903, 1.8542694854504562, 0.9289877000785839, 0.15619664646073247, 2.69968820633394, 0.991869553755019, -0.6161224386700141, 2.3293973478699983, 3.240326350206843, 2.125453578792568, 0.5703869053251652, 2.8511466176428493, 0.5059135932208241, 3.370475848483555, 0.3218898043179651, 1.1528747835639672, 2.5718887697101835, 0.0542098107920075, 3.7224002980738877, 2.670569106089968, 0.3006485592523868, 3.427284003612904, 1.2972503899498729, -2.8819984658358027, 1.6968270608584457, 2.9019520179363645},
    {1.5031835587884046, 0.9577349169909023, -2.0813160433085907, -1.3078034621940333, 0.43914623432687855, -1.031863448288278, 2.1878839598907827, 2.195599923025678, 0.7968295582075684, -1.8146512196814182, 0.9029650461361962, 1.547383332789199, -1.3694617017853588, 1.6053690877713345, 1.4977567208959421, 2.2248124335065564, 1.6516909588830453, 0.6680655773824217, 0.4484046615695836, 1.7939991106424809, 1.5458982101204872, -0.5890264515683528, 1.53025637452685, -0.8471405927117776, 1.7818523114443108, 3.210553132981826, -0.9532620372388669, 1.0645901671957756, 1.5180585983218795, 0.1740742892471681, -0.10206671594998083, 0.4808160507050391},
    {0.5884901754202722, 1.6602049019572063, -0.8062105469843676, -0.31225878615981933, 1.96047882324761, 1.1217223681987523, -1.0309714721201, 2.1933027120595905, -1.3499856231560847, -0.42151045252027464, 0.8216247748527847, -1.4172707875016208, -1.2019154940058716, -1.3228105619556023, 1.6744277064727713, 2.2613219869235137, 2.1347560875576304, 0.6015888151261286, 1.7436194467432102, 2.8178284882582307, -0.15198758848314428, -0.016275604633394464, -1.072301775250522, -2.1179150936377256, 1.1094573933541936, 2.5443417463539966, -0.9934931150778102, -2.339609188608688, 2.2918864141185726, -1.1302544973620452, -0.7753603142269139, 0.29182777872981536},
    {0.8697682727405803, 2.4091486165109957, -1.6699343589624753, 0.08377689962887501, 4.198916560790343, -0.23107098491005176, -1.8160429540781207, 3.045569988249656, -0.6393875454253719, -3.3942477094937025, 0.08184752486166015, -1.6038836652470467, -3.3302814296814094, -2.0030263907260855, 1.6295223106349142, 3.5814411912366326, 0.3783978359371083, -0.8312443712793387, -0.022738153149187364, 4.447450979408602, -0.8427532371296118, -1.4872340463096616, 0.7081093794856406, -2.945049376273884, 1.4110052572562262, 3.3792184536101897, -3.6564831377523657, 1.7466730479321457, 1.7810716354308227, 0.16029551427365896, 0.9890260591489025, -0.3839221840879047},
    {-0.27306503367772456, 3.9034703915577516, -3.710630153840351, -3.370005416449954, 3.311798621849617, 2.0830398682302924, -1.933692220527674, 2.0670762261646445, -0.1175567785203816, -2.1571432903413106, -0.4592443933376168, -4.067045902205853, -3.485953346375421, -1.3966779780245964, 1.9548739823411803, 1.1342273713175643, -2.207291612437862, 1.551260934280928, 0.9816945334273017, 1.7887233667601048, -1.6985665694501646, -3.462438843079199, -1.5909658813895708, -3.9526667579271932, 0.3661097194659938, 1.248564775249423, -3.3482403197128137, -0.3741553944970105, 2.746365160993488, -1.0017545692829881, -0.4499410505817557, -1.2852190169025093},
    {-0.399908498505076, 1.7161976967447095, -1.8964965825382367, -0.0730330851829108, 4.065657077630791, 1.5811685688879522, -1.6491352858822308, 3.288754958082336, -1.1323532176300306, -2.845261962745047, -1.7877101422867137, -2.2515184019596375, -2.624609806059578, -2.7527669283754124, 2.7491554604387702, 2.464158295427885, 0.1531269760335437, 1.0173952920332276, 1.6067793944292486, 3.0196363925460097, -1.0595902764957021, -1.824006623164153, -1.4730937825889905, -1.7443148754748292, 1.9401172448024926, 2.969353275266251, -4.09060806607093, 0.5150505785541158, 2.413044064128545, -1.0302973049807858, -0.7569992627251141, -0.21335177394850802},
    {-1.382902630224733, 2.2318020335621545, -1.0291118377979032, -2.02210402819016, 3.2395112013186234, -0.2668344084442147, -2.1174228288839747, 0.6104601730406444, -1.6620716845698145, -2.654920179567792, -2.25616752286377, -4.583379319244266, -2.4524559308510807, -4.972134384359166, 0.016713692645785688, -0.35858939943835355, -2.2419376115954495, -2.202513561050218, 0.3781801851086984, -0.2822560770699771, -0.5561370534347878, -3.5138493929354877, -3.5841051892517717, -3.0405633793540643, -1.4042229375369075, -1.2674778463528977, -2.450349998870829, -2.4484731572938143, 0.8676375699606454, 0.16713925350194136, -3.269534587749092, -1.30317117454651},
    {1.929346150288998, 3.806666147011879, 0.08142047414688523, -3.563791250523617, 3.3763814411493422, 1.3091615231287552, -1.1850993368744374, 2.836062198222257, 0.12462472873268396, -3.0091645497245, 1.6787706906424198, -4.227970946939749, -2.1825319587121754, -3.3430411386369516, 2.102260825173067, 3.5890749877078147, 1.1932075782586031, 2.005549834105848, 1.7444028606130708, 4.9811198280201, -0.6866831746032406, -1.8143437999728276, -1.1036428923321402, -3.585113670408668, 2.7937426304155197, 3.460086573254867, -2.328342824254184, -1.1872146356005286, 2.2001188232803592, -2.044551701050343, -0.5523240411165636, -0.6508931344122921},
    {0.7745422047108459, 1.1441424416790722, -1.498079221460226, -1.3093501859078152, 2.7979654537149483, 3.353321309060657, -3.5322438069612905, 2.9066607145908057, -1.515764341163148, -3.0567065886309743, -1.4253126930422666, -3.875422143877247, -2.877264605886243, -4.092928752117414, 1.4111480033884347, -0.6854739178266075, 0.9089144347610173, -2.8210017910222467, 1.1579271884373654, 3.947183566475721, -0.7324429358656006, -3.138869804220766, -3.4279974711558854, -3.594062874880041, -0.14280734947305074, 0.20744033818065083, -3.010369530673632, -2.602203666058506, 1.6206249806835809, -0.8482630806413677, -3.159984137845229, -3.2200416091973416},
    {0.21239927997838653, 2.3544891327054174, -2.951733494645178, -3.984463908493918, 3.0130255713504845, 1.2996638843597494, -3.465665257001651, 1.9936546094948795, -0.9623204078673142, -5.594320959265878, -1.3979240924194152, -3.982808972015324, -3.069856116408215, -5.13954628922221, 0.1702048977496518, 0.3937125609616871, -0.7690112020161487, -3.6420483024795067, -1.3902181680892192, 3.203026146157311, -3.585390496287462, -4.498362645274128, -2.766934733790459, -5.156306488294566, -1.3040432863167166, -1.2282091930676715, -2.91968427106377, -1.1266009802805148, 0.6109179292776062, -1.5678243606634357, -3.1985466757887613, -2.9611831102161115},
    {-0.9891732737564415, 2.123470634760627, 1.7020872797600524, -1.150577945718436, 2.10594313484713, -1.8186175097833637, -1.246242095763803, 2.279924284305827, 0.8597547301131887, -2.28799658932949, -1.17087493278455, -2.948766696551428, -1.0165692190186533, -2.9469315271609866, 0.19141127926700544, 2.2427996355216817, 1.5626191531118006, 1.0375217957560596, 1.1965598191043467, 1.774449237294684, 1.6370971129681873, -1.098731234313859, -2.739095395475772, -0.5516824108483864, 0.41304016668433674, -0.21384591687905677, 0.8625674318268782, -1.7998179052231036, 0.15615544795926095, -2.1775410876025547, -1.9932041714302684, -1.6179700613440495},
    {1.958603063998968, 2.9485001173112377, -1.535421092143881, -4.181809326766797, 3.7045474148066866, 2.052527808748554, 0.2883770102529193, 4.340864861014646, 1.2053186099011146, -4.107918613615301, 1.1752968126035988, -3.1395267838055014, -2.6471490265987185, -3.5795783144718207, 3.259361005275326, 3.9265530875738937, 0.42290307815715694, -0.40156230242811997, 0.863852882869248, 3.1476283139554253, 1.2166892868139263, -0.4121360426967988, -1.604328577006746, -4.119697887944953, 0.40176833271662954, 2.712705967999526, -1.5281217401601477, -1.5340530323389654, 3.3715419816056804, -1.1174326943293942, -0.7952585192864617, -1.184145549215274},
    {1.2567783262707302, 3.6855713418175973, -2.1605016450760153, -2.0945202462948247, 3.383912805464305, -0.7367324957063902, 0.5454749617401379, 2.0380802134600464, 0.20457196713878992, -3.2178614530115244, 0.7797081911140528, -0.909994210320389, -1.797403885627099, -1.0534044994733414, 2.825965761654627, 3.709297579350687, 0.278782229570811, 1.0384446861653378, 1.3748949992265027, 2.30260593548972, 1.6944500838369154, 0.4274513237469798, 1.0766641597992905, -2.0281636812715895, 1.260668254336885, 0.8698840811304882, -2.224325186567293, 0.2826918003640875, 2.342513327833372, -1.3453986018305197, -0.2764830249200953, 0.7762060040772065},
    {0.4531707235382209, -4.504510791837187, -6.566894358464938, 0.8473323846899753, 1.6857399020617614, 0.16538563526649305, -5.728784154882789, -0.7210581539546126, 1.1595258453548012, -6.712555141436142, -4.277787155295108, -6.5612435347903455, -4.4615661791850965, -3.7617432398144146, -4.345606561699136, -3.772851237898706, -4.071831269747921, -4.158040415908361, -3.99709613377907, 2.5100541405007775, -4.155296396588759, -5.915611756900947, -3.836699400031461, -5.752070551979327, 0.6109820795309447, -2.9539213544291982, -0.5604561895370274, -1.5142694072450276, 0.3280754696498063, -0.21133089668074156, -5.191927195816762, -4.914478402706066},
    {2.7313996819553443, -1.365973644169344, -5.118134066065335, -0.777985316105362, 2.3517189697763183, 3.265965644754869, -3.8901397015015746, 1.323030097367104, -0.11747746634976458, -4.990782193709855, -0.9937712531603993, -5.136619732569846, -4.441585472602892, -3.3463968836827593, -1.1342197661253965, 0.5425026049125363, 0.24783316791478763, -4.057842177405993, -2.1515965257106155, 3.9682490652388385, -3.872387450880704, -1.5342940096777915, -1.9443277417294966, -4.102017777779797, 2.7442641486316397, -0.2347988641966437, -1.41069125361637, -2.925117915597873, -0.2962398951822849, 0.9727437957129436, -4.457494897536186, -3.431934006337303},
    {1.1032348434023018, -2.653079967578794, -0.2697952869603958, 0.9084117715833387, 0.7622634938196684, 2.370601347638518, -3.6101777219072853, -0.5897472196236679, 0.5693375120254827, -3.228047739960163, -1.1937184483654208, -2.5539712691850944, -1.0501641060876516, -3.1624468694223338, -1.8654394306871913, -2.2266747103869755, -0.41517487515511065, -3.4338245695614416, -3.7852596314851312, 0.5433828918512706, -3.216124643572541, -3.3661119040903684, -1.7268779085409622, -2.981782208208643, 0.8800762706920552, -0.09919325857805551, 1.3923890922671645, -2.7953799113799787, 0.12147580779390302, 0.8341178112534168, -4.426100009520707, -4.191191307499058},
    {2.282325332971813, -2.304425647102752, -1.5269879457203421, -0.6061746853603515, 2.000405926567785, 0.5401258316888234, -2.65878229709749, 1.2478367574282014, -1.5667376697611886, -3.588267584692288, -0.7585271550843192, -1.9687146688958652, -1.969084141848168, -2.996638421893027, -2.9056864049948135, -1.8297942193238599, -2.5528190338999335, -2.20332035385148, -3.5116073103857905, 1.3967717216498963, -2.7907203966008174, -1.9774792026921477, -2.445541486145407, -0.07508197878088671, 0.5648360842129047, -2.1771472564648806, 0.5856456123057132, -0.839879414325046, -0.48943617393648836, 1.5031705150219405, -3.0829706903720826, -3.9986187160400095},
    {0.5450360025126896, -3.035899908832242, -0.8507843015107069, -0.24230031379766423, 1.9623419889293872, 1.4250540015614421, -0.63765298500966, 2.388963622857374, 1.22040644066397, -2.0764549084931594, -2.503274005251525, -2.4028978744002547, -1.491428899151591, -0.5001702704145856, -0.43704483103856334, 0.20468259106659448, -1.621665559473184, -2.628804806172297, -2.1189665684994687, 2.0648271175223685, -0.0950153006978413, -1.513943209651325, -0.2243278467855324, -3.161270898001398, 1.7399663249656103, -0.8967538701691814, 1.614858267230086, -0.9673852966395797, 1.3760422901725642, -1.2136057587599065, -2.2964119887928423, -3.9397754531639833},
    {1.246795503810817, -3.2713076982313067, 1.079619297659381, -0.21080547659786733, 0.2057919799047353, 0.9531986691238072, -1.1556255477409196, 1.6632971092339344, 1.8260841578459825, 0.4360715186637492, 0.5238891298309951, -3.419616612646206, -1.4119671118678019, -2.5441066957263225, 0.39481088164200906, -1.3601056402042135, -1.3610320174323434, -2.632439565652955, -1.9659954672313327, 2.103608348129121, -1.0773331730431008, -0.6547442280324103, -1.8486231992992472, -1.0188611058590946, 0.6634188780561777, -0.44961132607833154, -0.22843578322356753, -2.6005739661586325, -0.018577579062418494, -1.9298164381534215, -2.713047144001125, -1.3430644282547186},
    {0.04722747671067255, -2.5359936429587524, 0.8540579058301901, 2.1989755504596515, 1.5766100261714024, 1.5692295379160894, 1.2760490905616209, 1.3730085539268881, -1.6975362243111691, -1.3443421059848406, 1.2110893173076689, -1.8764926501007284, -2.366116943958116, 1.0743272506085695, -2.301782242223384, -0.8459700494171293, -1.2642920215578024, 0.4715495120119052, 1.7012919940662, 0.8958204316593842, -0.4413533405026997, 1.2711165425481474, 0.06616740185397604, -0.4492784730087799, -0.8654104372687094, -1.206360824939224, -0.37742923589474336, 0.19170091424478705, 2.015680123860237, -3.309938440745501, -2.234215522338938, -3.298140188228982},
    {0.03343316172108297, 0.2639662226914492, -2.1733532951708927, -1.5065521678787854, 0.16190332540184468, 0.2545861767849653, -2.1417055549205974, -0.9425718101202784, 1.250644020033981, -1.8738144358339586, 0.007322251630569823, -1.6361996763702045, -0.3162209651869458, -2.629695122703452, -2.180100950731349, 1.2281817075130648, -0.6081773545783788, -0.9330453386939795, 0.4887986274527301, 1.364064179551995, -2.02465238301818, 1.1911252247990438, 0.776423100414183, -1.1880798585788248, -0.5162663224315669, -1.037719703270852, -2.720979062656662, -1.698993424899219, 2.841132852885812, 0.44768910308448706, -0.47194260872349886, -1.9901049863568456},
    {0.9334014949058423, -0.215535388120169, -2.3615624949651504, -1.9713404068915203, 1.698737791911251, 1.5214323794695106, -0.25578038062955066, 1.2866604267935497, -1.4288673371169818, -0.8028922326575385, -1.9477570428197852, -2.7904953438201283, -0.6572128722587814, -0.4460567001052479, -2.61762915124659, -1.129159913292856, -0.09394191788192026, -1.8524520301429224, -2.0648690365152156, 1.4068436710492302, -2.8588818318765084, -1.5224095028398916, -2.2747482668354375, -3.451405344527334, -1.0148656214858764, -0.2140724402641085, -2.588414350734391, -2.087426719250481, 0.038130625046795937, 2.363230977106857, -3.7696486743892814, -1.787814612429065},
    {0.41288602026881055, 0.6735766639727547, 0.5738901892268432, -3.0629694485205663, 0.724873770860643, -1.4963836491416815, -2.3274991904272224, 2.1879516492296225, -2.1576228505849944, -0.9708683448543585, 1.3189901183145174, -1.0231112158214408, 1.0164720412160373, 0.648308242811262, 1.0598596458814382, -1.64672374973008, -0.9469294979369384, -2.2433257192422458, -1.2608515662978572, 1.638216286561423, -1.5170430496974456, -1.6087255273332959, -1.5708684264089456, 0.47819521025538736, -2.1966871132997112, -0.8542913929024493, -0.21266061756846924, 1.488678127149784, -2.1104960979839325, 2.0814050063300704, 0.19722833607265158, 0.6328791510825956},
    {-1.6003075104166427, -0.624416576930172, 1.4409580342522954, -0.12389115345264506, 0.2517080920786754, 0.8706824747454024, -1.4367807937311168, -0.4607106482077349, -0.26445551882362683, -1.2082115207031046, -2.568567388173841, 0.20160471783651154, 0.6205646057223619, -1.6669153739552791, -1.5850085812728822, -0.8771678920320154, 0.11847754635984938, 0.7323608350773564, -1.6376039887063998, -2.450646508005938, -1.3460669878121423, -0.12553501038517675, -1.2576282858541732, 0.20212744111811828, 0.10894851425795557, 0.273512569018044, 0.7330580880399789, 0.4855970823787456, -2.563848245389607, -1.7555121757949206, 0.9392021219592639, 0.25820230445964354},
    {-1.005132825395276, 1.3498504904918498, 0.4807080275612144, 1.9054164870027852, 1.4191897743269384, -1.518352670990752, 0.35915500174606546, 2.5605928611590176, 0.7733494753484201, 1.6906788954294554, 0.10426718725540925, -0.38823627155755214, -0.8589396291784129, -2.2762460679909835, -2.7108770928169736, -0.6763627151767003, -1.6859556080783806, 0.8965160918697899, 0.13217544936275283, 1.0520367543605125, -1.4529900801451496, 1.4302359535167641, -2.321552793443959, -0.9066441973609483, -0.9097947737770675, -0.08805282684548657, -0.3763870142155793, -2.1196749407959716, -0.6341599820037672, -1.4553799617239613, -1.5039378692325696, -1.9352120549438028},
    {0.38719627483164526, 1.405586244749796, 0.8253661668831599, -1.2811021904381623, 0.3473631563101392, 1.7372483346223235, -0.36539609905074527, 1.9747643712092824, 0.22425327274179524, 0.8914147633553879, 2.620592124894546, -1.2369283780719882, 2.1191779117007763, -1.69546726344801, -0.983557122433817, 0.04944302371067478, -0.5493641596061111, 2.817405644762469, -0.150635830950427, 2.1079150517537215, 1.6165645045636723, 1.0877403701025479, 1.5338920709903376, 0.12944293648188632, -0.2982809165446132, 2.0501970738221873, -1.6316385244425182, -1.1860803568541527, 0.7009134311845865, 2.0718185862882628, -1.7738604284059334, 1.7254399494187342},
    {-0.9397935635621001, -2.348006905116276, -1.4609432273005585, -0.033745599191330564, 2.1177774999911176, 1.3623275775424228, -1.0013194661942553, 1.7335953684563372, -1.3679087850850788, -0.3055518867318633, -2.7091712778573935, 0.11918398158456789, -1.3018442021820513, -0.7038448458694463, -1.0288556079198343, -0.6312005352041444, 0.7493273938388902, -0.6312012486445727, 0.2698243459917631, 0.48836685660383944, -0.5430791730457346, -0.3803697161143027, 1.1030705134626841, 0.22368100425285434, -2.704265648323672, -1.2036447802560104, -1.0304518829167923, -0.14924783596604052, 1.4408953067064472, 0.30279153280855914, -0.5504226891255409, -1.2710797603836415},
    {-0.4657349585010408, 1.0216140414936017, -0.9093111039820496, -1.3747160815737631, 0.9490579157250398, 3.198697421278096, -0.44316465647999764, 2.3437927600807145, -0.6700732704132506, 1.2584312680417664, -0.11520733853373731, -0.8658427394364119, -0.10013189383147114, 0.1003532329560904, 0.17446756565711352, 1.4526011437278623, -0.4377953957609327, 2.2421616629325447, -0.11047436004227161, 1.168588034715679, -1.8270720019342273, 1.4686004159327892, -1.1614698603060318, 0.5363383284933032, -0.6974203594332654, -0.5074585810080017, 0.10648461013668194, 0.11628680649973369, 2.0407303835488233, 0.9121052455344235, -0.04247038022475459, -1.646193417894476},
    {0.3574250015895695, -1.6353040141755963, -2.390155032590389, -1.6314801353055266, 1.615132912309811, 1.4873780034868438, -0.8071437586994112, 1.1499988123253015, -1.1748320884826189, -0.9890182328430479, 0.37942774813597474, -2.101657676563926, 0.5450449257876461, 0.3351571879830408, 0.611333976712545, -1.6126306236327201, 0.26250912222957856, 0.8565197379645996, 0.19739362552234258, -0.9414747509480751, -1.406893678000523, -0.19942643510594735, -2.8935498485119786, -2.7486946769178826, 0.030990768867151828, 0.4605944548450269, -2.8119222645863773, -3.126959828062595, 0.8785042691514946, 0.26476242834903363, 0.33377388740971903, -1.0048003352964603},
    {-1.4792926331403538, -2.4651965247583854, 0.43273426219636085, 1.5815442185268833, -0.3518455690722027, 0.2617258757370251, -1.2748549383990468, 0.9789705242310747, 0.5216854085837489, 0.5922905958458641, -1.2575407813595159, 0.9813641327309054, 0.11291970744498711, 0.4063915638960722, -2.0573102256535982, -0.810618390108199, 1.292881086464779, 1.341245737050337, 0.7830606587314318, -0.516260475266177, 0.7404063475036557, -1.2196266840882122, 0.29189268152028297, -0.055501830213328364, -0.6287821275167462, 1.450543759224777, -0.6941339161943666, -0.31838063084656804, 2.0635485802018696, -0.1726951844895298, 0.1347225956586659, -0.751497725622458},
    {0.35436186153178956, -2.957026029401043, 1.6016472868695617, -1.3182744960408739, -1.1326549688637286, 1.7688743118126788, -0.9435706070531359, 0.12709160728407312, -3.4451322672919047, -0.09176402123706652, -1.4228444815542443, 1.0269040036740422, 0.5579868758278576, 1.2076780504588343, -0.8955823368252258, -2.4306327040126106, 1.308344148218676, 1.7424486374948738, -2.6024261355364104, -0.5123007194346654, 1.163494497375051, 1.1817344432979688, -1.880236143514234, 0.6886979806299163, 0.7135150156900869, 1.678077506624913, -1.027551614330167, -2.0385826295648797, -0.7040833182989934, 0.25517537732679, 0.662567909546139, -0.2649798613928091},
    {1.6864912863927093, -1.8007598553922537, 1.0759670648570963, 0.5138940023298315, -2.5965881374621436, -0.10166204893337462, -1.44930170475946, 2.440147935871756, -1.4002014238125562, 1.8551316453002045, 2.1477455129691694, -0.3574149793705639, -1.231816269588533, 0.358856746778198, 0.3155991471018288, -1.5196598098641025, 0.9256237842973536, 1.4692231700455671, -1.6602384056627901, -1.911381503291269, 1.0819146776707225, -0.5268399122552575, -1.4166029117117356, 2.9420406202464173, 0.5998026107826202, 2.248153380206274, 0.8836897208663697, -0.04865862758031025, 0.025086495567863167, 0.6125142923058078, 0.8972457186748911, 0.8942468880691551},
    {2.3044463427742663, -1.4097606182888927, -0.44526714485075203, -0.3171366125803247, -3.3815435162771417, -2.5698852740195433, -0.9737821967650941, 2.330909589270811, -2.2171433953089505, -0.05799779618224744, 0.9676117889790407, 0.9160455269256305, -1.0669318321162589, 1.7727653485519326, 1.6228148918436365, -2.1058280777054117, 3.119976222889848, -0.4639467785766323, -0.30078966323790685, -1.902998798958343, 0.8555786585124329, 0.005000295242500076, 1.055186117129212, 1.1307705863179671, 0.8998259106494926, 1.0653646723214303, 1.7894670545114475, 0.10806954442511724, 0.5637039184147727, 0.27776202226579794, -1.030715164361728, 1.557631851033453},
    {-0.22108029347215336, 0.9533565794166323, 2.5186033233491094, 2.3270228897395464, -2.057918968085431, 0.40914587224792254, 0.055314846401438335, 2.8082081995216805, 1.6155324823678425, 2.0499624465929975, 0.4828522182018465, -0.1448358631881532, 0.35653264987860783, 1.397842256330189, -0.46077134008754883, -0.08612758605199164, 2.585942715393941, 0.7523970101634387, -2.196874779432795, -1.4859139415137474, 2.4536984638837094, 1.4823071916411883, 0.30380285635870524, 0.13697888384996473, 1.292160665279275, 2.192926160465761, -1.2363286178256927, -1.342575644085346, -1.152869328011849, 1.5632915742679578, -0.009669282832817047, 2.4442638515168373},
    {1.4095753969382665, -1.212170975157831, 1.4259941945702035, 2.167977018317829, -0.4396918675078889, -1.3461264414436287, 0.4899868888548564, 1.9569701436278493, 1.9979811271301224, 2.5957520494701303, 0.652259318025522, -1.2909058400296853, -1.6652818345829867, 3.2136137829286247, 0.8378479357490545, -0.7209975583767462, -0.3897836693791979, 0.15944121512951603, -1.556187762736323, -0.9491782096932834, 1.0906393934393814, 1.3196331744635137, 0.8476016300953004, 1.0634633329286372, 2.3356337529349216, 0.4720725500194895, -1.5387453862843878, -1.4689769660337781, -2.002816982896367, 2.9919333480228096, 1.6934541749306897, 0.06081988710310207},
    {1.915012421846246, -2.297662207949901, -0.2732256389035607, 0.09677063985299608, 2.3533407263392867, 1.746345331430895, -1.2112860430615995, -0.48012425948152876, -2.248405653062243, 1.0476707130552494, 1.0450902486954896, -0.7832157241889944, 0.7933378633203292, -0.6061022267246721, -1.8140053756249965, 0.41157048801499957, 2.1293747007893113, -0.5592469066241057, -0.8945444480658482, 0.5267828502911003, -0.3643378240312415, 1.42709978468626, 0.07017040812426616, -0.07341638360124211, -0.14960972204769113, 1.5361912108753712, 0.21194645450517705, -1.7243185984143243, 2.4561023664459585, 1.1117281886925436, -2.141735216470121, -2.206435678982579},
    {0.7739528717411193, 0.19493711063453908, -0.17016181544831482, -1.0270030796090852, -1.26985528422125, 1.1171383380990045, 0.8230330761874535, 1.8727222404967272, -0.6593075190486126, 1.010214100230609, -0.043251826610747696, 0.9605856896879451, -0.7592167466125357, 1.0785391645954179, 0.7278759934906753, -1.6415127058773782, -0.617220996781271, -0.41455031033750744, 0.9991057221468321, -0.9825838707394975, 1.7234066155131558, 1.596683974031752, 1.066142251309628, -0.947237545469851, 1.6556582081998479, 0.10255405252401696, -2.3327948183036153, -1.814867326758814, 0.8496102494445359, 0.11396312730514804, -2.5576203465842147, -0.6298184975616853},
    {0.4757931453233596, -0.5710227438829152, 0.5950901334364427, -0.8704774193469179, 0.4029362693498761, -2.7557116573590243, 1.6740788060292369, -0.2261103783751872, -2.1413387127278036, -0.9298213653481148, 0.685956112260903, -0.831944757288025, -1.4840847963434771, 0.39242487515219, -0.9044554076725684, 1.837311360850922, 2.4100526767989163, -0.46737188769632954, -1.314078104962798, 1.437221629688149, 1.701255375507389, 1.418702875824257, 2.0591152048539088, -1.34292993510523, 1.7580489954695517, -0.01895025974269446, -0.7348603867797201, 1.7761093352008026, 1.1776817721601012, -1.6675588784618263, 1.5589626582701333, -1.8236060279046922},
    {-1.9536268559690055, 2.4205197401102962, 0.8134990063669526, -2.1614245383335366, -1.3194510936369517, 2.2819090566134936, -0.6245839044097803, -0.9667596478897229, 1.697595249649094, 2.2126901478002976, 1.3605866295443663, -0.5684052351886139, -1.2864948650844048, -0.24734713395156838, 2.3482217990047727, 1.7456303031885592, 0.9380894558289782, 2.2814159597826653, 1.1307903705406908, -2.2175374911901833, 0.452178187679727, 0.21235775415594757, 0.6431359376822143, 1.9469935787868877, -2.098366468681095, -0.846761770970667, -2.3807746805842163, 1.2948468216714808, 0.4575313882638834, -1.4637368927356245, -1.4491257805432398, 0.4884271206936525},
    {0.17688804548612816, 1.1498529202932728, -2.187024250458678, -2.029088755153137, -0.3941446327236956, 0.5442829811221123, -0.7885548579137964, 1.871766066689087, -1.9106439032412026, -1.7554986671791455, 0.2019075068903315, 1.0543486295559839, -2.976833461931988, 1.9874594372316892, 1.9482331904745112, 1.2264712627801486, 0.23521854914080786, -1.1295226956479238, -0.7392431784773302, 0.685083067621487, -1.2106488373165243, -1.9057074104391842, -1.876489727449967, 0.7626764564681096, -2.125248673343898, 0.4633044167456839, -1.6768797963825703, 2.3265003168734326, -1.2500659441839255, 1.7398082322171646, -0.3136136445590773, 0.669813737797555},
    {-2.0865434989375196, 0.5653792292214754, 0.5926045422304537, -0.772983701555728, 0.8036475775904086, -1.3005979770560903, -1.1946079415373831, 0.5778074386924666, -2.1963502421937915, -1.195819176423631, 1.541569922732876, -0.793623711046673, -2.6799361047856167, -1.2350296224645463, 0.07333382258485976, 1.360533113199341, 0.31376705305181674, 1.3200547212404028, 1.5995981529791619, -0.0321250593740204, -0.21552650722456215, 2.3329938119451845, 1.9012406355261504, 0.2704856685900487, 1.4543969502737208, 0.31298233470993186, -1.4826668281588, -0.357404884312949, -1.8271539840861566, 1.193981302904435, -0.29500333052166366, -0.9160498920510269},
    {1.598250612631364, -0.5502101984333025, -0.9388529407687463, -2.2599919881853605, 1.4256245807772465, 3.5227350608072046, 2.3868008760363435, 0.035490505013489305, -0.5121453804388454, -1.2148621085569828, 1.399242245447466, 1.4770880792663699, 1.2688195860687823, -1.1489206033675827, 0.9726316555604656, 1.8117499378878361, 2.782511871149804, -1.1124509911672427, 1.4138344341447364, 3.1000102151508306, -0.8144155661978396, 2.946459823547178, 2.3857069434511353, 0.48082300061680405, 0.9727981012173309, 0.08065311226860034, -0.7674543919248172, -0.9901740740522507, 0.1601598646427493, -1.4442670002730784, 0.8350019808647866, 2.094399459921145},
    {2.3906725621986316, 2.172626365168084, -0.8690311252919761, -1.1081201624118728, -0.8323746284958766, 2.399868635336533, 0.525598124951465, 2.645348463380075, 0.35717007196876943, -1.361884785402371, 2.02572371088626, 1.5673712443653547, 0.42847314062195385, 0.21539284663455213, 1.6357266528051682, 3.22371230016615, 0.5020617510255253, -0.22864407545195695, -1.112551240676562, 2.137478976032798, -0.20721213935585014, -0.1808619975540496, -1.3576986808856673, 0.7403811819953504, 1.6804573717641562, 2.4540176672202074, -2.289440045923231, -0.19518932367733519, -0.37091651575812945, 3.0820949539768567, 2.2566150796862994, 1.9695032559785925},
    {0.8928770505077543, -0.4943900123764882, -0.2265296540791368, 0.02538466445759428, -0.35475228130665004, -0.11403068514230011, 2.2184014929098193, 0.49300990168749037, -1.1563919945619219, -0.12886140031087395, 0.6271476714706363, 1.1045115417514326, 3.0363093726582417, 0.744677704376216, 1.648638375581505, 1.7946705854658223, 1.7737392610816898, -0.9091001561966221, 0.49658776232916163, -1.7792401139659582, -0.4171805845337324, 2.411230656436239, 1.6828929537754105, 1.5445364941544486, -1.7886202313192292, -0.8073627493086799, -0.025525026243292167, -2.208766717831781, -1.310946022714532, 0.8468672885017811, 1.0026724500495632, 0.6066138338080765},
    {0.37138110652782524, 1.1259628111943802, -0.6710767117941344, 0.005803270649499174, 0.8561526867135746, 0.5922266578013514, 0.6411805825844877, 0.12298001616563985, 2.4777159307677916, 0.32067547180225064, 1.493310837131139, -1.4265908736660033, -1.1732258652819672, 0.46955885122963037, -0.61365843879638, 0.3364570496160742, -0.5256062561018634, 0.42544807749646213, -1.9838816278744076, 0.28638763742412643, -0.23982714298556337, -1.4550342654360924, -0.0598259520581678, 0.3755142987524389, 0.8960801937680747, 0.02308755032118831, -0.5268980934396377, 2.2743959872631816, 2.5269157922279923, 0.28415217980048235, -1.2764309148315771, -0.8793599856781291},
    {1.5769004152657886, -1.5118565755609317, -0.7740300676876231, 0.12120341676593044, 1.2437377953119693, -1.564903499319707, -0.8604511554606594, 1.264989343073684, -1.6829143232934516, -0.8397108377931785, 1.4574314935350376, 0.9276295289774197, -1.391143115265695, 1.5866826189961045, 1.8161634048413116, 0.799735891579866, -1.7868943662148027, -0.7999938935555491, -0.03185085983896281, 1.113330796769023, 0.3637386790129553, 1.541489457991875, 0.4184598952738729, 1.1416289898090877, 1.433274021742734, -0.7741151336090234, -0.9035696883463246, 1.1725512757400258, -0.8069441230937596, 1.9621093666902067, 0.4431104294854399, -1.7245904261198273},
    {-0.5120571449898462, -1.0913258753406496, 0.9507578678567291, -1.0628745147999836, -0.9156619590689198, 0.3739587970886771, -1.9936104930202756, 1.1788107980216116, -1.224684177329363, -1.3048430959899333, 0.7396642324105185, 2.0300136524103887, -0.5804505452007496, -0.2952676930519556, -1.3217419993297193, -0.7538958625733707, 1.3167959613229296, -0.1914250128319854, -0.18571153411638316, 2.3383710650294707, -0.2462663812552438, 1.7668318743538034, -1.1166747665319028, 0.6437219545770413, 0.9410080830554752, -0.6723236095942663, 0.9741799699373268, 0.4271462615720021, -1.3270926823714582, 1.3690013425267007, 0.8868189320682387, -1.3576930081901573},
    {-0.03747566476428145, -2.1379217193120836, -1.8881157014278402, 0.21847370709852662, -0.7097252280744983, -0.782926058511621, -1.9506172928770842, -1.6009899943427728, -1.856899322091107, -0.22619358519573915, 0.8196855373375359, 1.728024603322857, -1.02113655651217, -0.46022902685077416, -1.8894909535242443, -0.7699115351760603, 0.9349825525391763, -1.2261618468104938, 1.2069123928050491, -0.3106786363580411, -1.6524796881578583, -1.2370315611835276, 0.9245577609781079, -1.9260106196989435, -0.4552292721604357, 0.5433533716785671, 0.9450689024430546, 0.8728635624494441, -1.0882295424649524, 1.0166969163731903, -1.4120169944380072, -1.2581613163584688},
    {0.3119237068252418, -1.1073816348302696, -1.3413432213576468, 0.8571344688512845, 0.33684087391035156, -1.5093962619345744, 1.8964891500834316, -1.071603334673254, 2.434709166864248, -0.4585319424116895, 0.8719464568091512, -1.3495401097112476, -1.8136871934896943, -1.6003308067115491, 1.2237538023654082, 2.292053121058055, 0.8855811642194945, 1.5122682305519661, -0.957756433219579, -0.12059558225452865, -0.6406762829232447, -0.679616615164749, 0.3446566816054815, -1.5473415722429105, -1.4373057550011124, 1.6290704815867574, -1.1572087764497714, -1.0964271874221836, -0.7488487868777631, -2.5269445949551352, 0.38749876436985137, 1.6070835473350384},
    {-1.383877947888652, 0.8081491016221392, -1.3727134653209896, -0.5528566868104446, 0.7074174190531516, 1.71188503675277, 0.7288232778987901, -1.3542049258052715, 1.3526085827316283, -0.9189395297650624, -1.4216218784686434, -1.634672683315402, -1.7846081126307591, 0.9232662408191701, -1.383176431359111, 1.6076219281339048, 1.2573886230101115, -1.0932746267552584, -1.6966882178081695, 0.3833984344605578, 1.4634295181744628, -1.0760717696247764, 0.11271456372723238, -0.7356870496667098, 0.6726131325386151, 1.44941737144637, 0.7477101343471081, -0.4566224007963908, 1.2909652984985027, -2.2708020362280465, -1.5010790502693843, 0.7085216208485785},
    {-2.437629057504382, -0.5378513003934301, -0.5080064498852617, -2.1134028583166, -1.6699770057257355, 2.2565163286797643, -1.9592789979151861, -0.7498071959950421, -2.193801876403119, -1.2662622442211162, -1.6479912158248617, 0.3847624412193689, 0.4473426445866602, 0.7884483859277042, 0.014728083078365836, -1.7314086829377773, 0.18083062016488882, -2.1615742126796196, -2.0906728970976993, 0.975625006706174, -0.8901944970913523, -2.1945961346601606, -0.2904842619614154, 1.412011077846297, -1.0916394709467383, -0.5806892682152729, 1.3095087147807696, 1.6082347251847944, -1.1838827167566321, 0.7163214343305221, -0.7493253061000966, -1.3561408849216485},
    {0.5675763814651498, -1.4151696727412184, -0.5270093224872985, -1.8184141051997027, -0.4844003801849744, -0.40917445863240537, 0.0289323715960715, -2.1840558833104327, -2.966793851172626, -0.30509992375209644, -0.9898262365091641, -1.6851866816574208, -1.4662656483424246, 0.320081203580235, 0.029455001672672714, 0.8590516443295346, 1.6406931036872945, 0.7745495607341948, 1.4678108076447005, 1.9672911466983536, 1.453007377610489, -1.1217288234619969, -0.49876641673367517, -0.5590827509793617, 0.9025833421757664, 1.249345600664676, -0.879024329113151, 1.186583922374887, -1.5476294255824785, -2.1929266064384816, -1.2295401917821502, 0.8724834637880284},
    {0.8320826865800499, -1.094627505736707, 1.155065942261491, 1.8189184429729257, 0.3467512096374343, -2.5712667012310124, 1.158414376041054, 0.8640612902830246, 0.10934918177703015, -1.065993680435939, -1.0642891072480083, -1.8282448692465936, -0.8119468301740784, -0.12034352815917566, 0.34266029606713944, -1.878639054212636, -1.6604010713074189, 1.6187741216052345, -0.9319376573097319, 1.6305010534266071, 0.07773533090423146, 0.04603840914238672, -0.4788920537291559, -1.2508700297440911, 1.2488910031128009, -0.9597253913536621, 0.9303255428558657, -0.13159819165083797, -1.8287569639494001, -1.9360817022312378, -0.8785348406731529, -0.03209396920751416},
    {-0.39421977968887306, 1.3611150107158791, 1.019717452343376, -0.7171862839835722, 0.12603898544767222, -1.1265341103395987, -1.1412687021036374, -1.3621995976983299, -0.05732197061550485, -1.1168348619386366, 0.18899151381907126, -1.189405519808076, -1.004753474945319, 0.715130461252992, -0.4080180781162508, -1.4353854007691744, -1.7533412989767825, 0.23331967034601825, 0.4985594398768242, -0.31448100418376795, -2.0741847294007365, -1.5317601268822647, -0.3484988064564238, 0.21689181647755443, 0.7468073688003429, -1.3954588423462624, 1.8701225782451465, -0.30842609372919527, 0.8344418634240985, -0.20506832610191067, 0.5672354285708406, 0.5158487861565526},
    {1.774520071061779, 1.5388694236090852, 0.6355336985802559, -0.7225962951517614, -1.206045777822897, 2.260717164339806, -0.7848492884301925, -0.8531856361336099, 2.657560736858432, 1.2715015794824782, -1.338001416836653, 1.6498881412246393, 0.8758595426096718, -0.5211679988035555, -1.9966342739057839, -1.1254578025389708, 0.9032216349433061, 0.21926859816830427, 1.4863316708596865, -1.0267490928190224, -0.9793857415788625, -0.7149716277470203, -0.9864090799961235, -0.9839390967342537, 1.6872670820192945, -1.4579910848109514, -1.2089607512394152, -0.13400377368072272, -1.0991519409045636, 1.1719319764646021, -1.1832113573304615, 1.4704947070041599},
    {1.0335000328544435, 0.5086117613913682, 1.3040055841927805, -1.221726861622725, -0.8734337363292608, 0.0006780421511423092, 1.1529945621578455, 0.7931323770021494, 0.8128056789844393, -1.256628725398182, -1.298943276133527, -1.3996203256167057, -0.6705319615685124, 0.706742349234268, 1.6604081049350379, -0.6365920637043022, -0.16400013800253896, 0.4530828563856371, 1.0342365637541857, -0.5853801321695588, -0.8191017194244414, -1.134642960110464, 0.23255979256801543, -0.5705807602138442, 1.7386102467101754, -0.6182073550129399, -1.7426904850118583, 1.912115869124132, 1.079895834227962, 2.150455259965352, -1.6890747696606363, -0.49116129659164914},
    {-0.9623859176044921, -1.1690294896224798, 0.8807392749594494, 1.6103262311982838, 0.8671732001112524, 1.0516463463505417, 0.15845757592749096, 0.03043749455105244, -0.5432838817432788, -1.457311256313621, 0.19209595058641216, -1.5517874552438946, -1.0647927076416597, 0.5152423498751088, 2.0110342797907177, -1.4572881810307525, 0.9950170718285015, -0.3718627593423003, 1.2925405756337456, 0.25014436605354595, 0.2423730801808987, -1.378471596280228, 0.4575861086318549, 1.060191715721759, 1.4910906547843685, 0.05370891458266453, -0.9912817125078156, -0.2790205895143501, -0.16315417601582255, 0.9428325955307914, -1.5791884830521143, -1.481586010727939},
    {-0.6177282507582114, -0.029568302500800427, 0.8612030192460678, 2.855669701782533, 0.9507228860327759, 0.5190704183605692, 0.7750305105369095, 0.09414222818789009, 0.37691675870815744, 0.5130241446174814, 0.6795148419975988, -1.3997292255647127, -1.1964493686608895, -1.1623820921587, 2.1371741226882066, 1.50473626206974, 1.9687864227428737, -0.2385986821837164, -0.9793120996410735, -1.53812629136153, 0.00024787306470594033, -0.8363258833632145, 0.1027412226200728, 0.05962130197158369, -1.180251627448342, -0.04359405456595693, 1.244160902920437, 1.948572439938448, -0.7832891033990824, -0.30805995967239375, -0.7421727755142087, 0.7976151964929473},
    {-1.4359530704734962, -0.5018419047785975, 0.10177840427456995, 0.43893166594747174, 0.8652032401755858, -1.7661241796530511, 1.3435555097439038, -1.364124746463672, 0.24892410586516125, 0.8505002909961669, -0.8668333195115377, 0.6222063213472301, -0.7555637015216693, 0.39353853225455304, 1.1783842858906226, 1.5725933512255095, 0.8181222494726099, 0.7750459741071755, -0.7365541921358012, -0.20589524143907065, -1.021858390364033, -0.24087558638268025, 1.2809181189369419, 1.5067217292232593, -0.4539268681561797, 0.6696919462267686, 0.6876756734002462, -0.6608450719803162, -0.9592912209861097, -1.134392228124261, 1.052776265257536, 0.7474248415331073},
    {0.12875505905788545, -0.47563585189985513, 1.092896197508829, -1.3678050510202937, 0.561150131697962, 0.23229235652665803, 2.059156381648514, 1.4322473999548417, 1.3842907218609677, -0.008910711314313143, -0.10948372373975626, -0.4982264224561897, 1.8989883666021945, 1.2133625063794544, 2.1689766841029336, 0.5451615314914129, -0.8748915603423426, 2.6767178825744904, 0.2746207939276712, 0.942168384418099, 1.8979832957446494, 1.8716963856263789, -0.8443402107306918, 2.041418785501185, -1.3808557780685584, 0.7038993860998181, -1.062964045123032, 0.6613760491438466, -0.12082629405912555, -0.3062352355629467, 1.89834046622319, 0.3005644036738809},
    {-1.2313133422726497, -1.1285818680423856, -0.025711967205844077, -1.1855874170887106, -0.46472386425641804, -0.9558255122844614, 0.7176054207279761, -0.7626003592522622, -0.8173767800802042, 1.0481509808164071, -0.42930740661691497, -1.3579349020520792, 1.8087784936999638, 1.6840633313813314, -1.005912474451725, 0.2244533790326301, -1.7412906321441555, 2.233581231634635, -1.364377091018418, 0.7353592231390653, 0.10436270420086129, 0.890537532186604, -1.8380296410451433, -1.9787526186681328, 0.029385141026339632, -0.030060923353753693, -2.341284823351538, 0.7078577874941766, 0.5492815316691965, -0.6086589706260733, 0.2067883499518341, 1.0671856315262285},
    {-0.43239667395805786, -0.8267075381879511, -1.4223718908972642, 1.9960972075035164, 0.9897831202188618, -1.8714588988495184, -0.984961496207441, -0.08489172770560964, 0.16034864134038104, -0.918648151898444, -0.6142218583630327, -0.7156328768311081, -0.4350846364053337, 1.5695084485888842, 0.11477980140812717, -0.30772626522368135, 1.0715974799253754, 0.568542367141508, 1.5063948357582981, -0.6230459861895681, 0.5443083061098952, 0.5863860505668905, 1.7019994985268598, -0.3889245445108444, -0.4162954958322848, -1.0977834699660836, 1.247679354109234, 0.6895060843328806, -0.1862263501326547, -1.1625513652971262, 0.23004962215910355, -0.6319220265667569},
    {-0.32565507611262523, 2.1775818527554858, -1.4625530269214586, 2.2226846179036186, 0.9494264439901091, 1.381625297319531, -1.9095626898803923, 1.9069010348958642, -1.2568814067805327, -0.7836333923144005, -0.7082947897586986, 0.31179066558545326, -0.7135124698887277, 0.6500534802424709, 0.31661794389408565, 0.6081852866516845, -0.49427889754654014, -1.1050097903868277, 0.5946093961971556, -1.1819125201796328, 1.2413048913900975, 2.037847476821589, -0.3289599267436721, -0.783436389669356, 0.7923538579393253, 0.12256026994540847, 1.0712790545096929, 1.5730240689958668, -2.413316748464248, 1.1482520277505737, -0.6041804033257083, -0.001510209707395075},
    {0.32391674693946115, 1.0556763352422944, 0.43221525969892294, 0.5230946786193006, -0.2468560491023844, 1.914568542278305, -1.159019445179544, -0.48574510171265145, -2.1845731225411185, -1.031249986217175, -0.576620611009339, -1.2255306799381982, -1.7613031200994054, 0.45148472257094946, 0.5767616219333409, 0.665725678109523, -1.3181824032243656, -1.6763765375741573, -1.129785541228479, -1.6955818184081182, 0.368432202485195, 0.8363131188407866, 1.699780052029219, 0.6013122677427866, 1.3362127668698716, 0.19665233042347138, 0.29919824024994085, -1.1321458563285518, -2.1676877743511063, 1.9290570500079944, -1.521585162225477, -0.5502023239109215},
    {0.9728875507154935, -1.5854764313874106, 0.6209848295044772, -0.08643154276834547, 0.4643021015243647, 1.9166313403772384, -1.586097511330758, 0.4841331076338137, -1.0117265003764544, 0.3650073568311214, 1.8542044475763084, 0.1960756446734128, 0.835340985576939, -1.2557212218206113, -1.9548436067390444, 1.2390588649217171, 1.6229987660330634, -1.451200730072168, -0.7681740931604213, -0.7152501802429702, 1.2302569800272665, 1.7801864865007122, 1.3301815115690288, 1.1840792391980135, 1.3993463619230018, -0.6823192434076929, 0.9575761184927091, -1.9759563358731602, -0.3388428818171256, -1.5472250868240565, 0.15778563905781884, 0.6181341009839864},
    {1.0004647934246271, 0.11870232927991892, 1.1642741504405223, -1.1713833349701743, 0.330158991133491, 1.9995118684489936, -0.001947805174629999, -1.6382072897158597, -0.3708705156639999, 1.6778842543448014, 0.7248269463494463, -1.246542670081024, 1.7472565530740485, -1.4261165311266233, -0.6837573778942881, -1.6854437561536215, 1.2375348328406854, 0.4958559158266374, 0.3720375537803791, -1.1347807437915207, 0.9264509461600143, -0.08640044635714626, -0.9362881297946303, -1.362450222662944, 0.973750588318937, -0.9890497656145676, 0.5231277087602579, -2.0943529231674085, 1.5333887448655434, -1.584602474617828, -1.7384202700789178, 0.6615376938008881},
    {-1.5462347163129742, 0.44264202169831474, -0.1694661628838713, -1.4923449792407366, 0.09714468847075299, -0.3786130503683169, -1.037302586786594, -1.4996346605560475, -1.498733391526849, 1.610971669984934, -1.5601106320175409, -1.1115668747594865, -0.6743860775571585, -1.1386225129026974, -0.9603718036985366, -0.8659726841190252, 2.009363431740326, -0.08084385162708627, 0.18104144510427586, -1.9950610897032217, -0.9839747378494647, 0.6592133676011452, -0.5884416998948846, -0.886374049045635, -0.4934372860550939, 0.07560092930759657, -1.564538192679812, 1.3290742774917845, 1.6970624263230374, -0.685240567504702, 0.4797380970804384, -1.3295656469596524},
    {-1.0373284615935034, -1.6699992620694368, 0.4555695550065448, -1.0091713545773482, 1.0811125884725301, 0.04927618290700296, -0.4892688967084019, -0.07179639638802734, 0.2991488905988216, -0.9438897162846029, -2.2439135859395636, -0.08398489754838882, -0.09740566307821134, -1.97156703584544, -1.4437187156808042, 0.36250640403090584, 1.6139007366308287, 0.04954054601020922, 0.9344106383180676, -0.2745462236844058, -1.927512453658395, -0.5613839576589127, 0.3472452379534972, -1.339078245928476, 0.8846898285333841, -1.5425322664110048, 0.24688641573975267, 0.39791185512622235, 0.8815282977983664, 0.47238499373088194, 1.3528806728547191, -1.2314585445045376},
    {1.1962139388140738, 1.0084728230072124, -0.5219783322773061, -1.0995379496128936, 0.029999380638204624, -1.3170981180389314, -1.691881746157392, 0.38120949174724406, -0.7622449709582668, 0.12723195882723567, -1.1975293833484328, -0.8036736929465235, 0.16095453334635423, -0.6576168474507686, 1.0445206787704728, 0.5806306112555126, -0.12764235647144792, -1.54774537166437, -0.13386099234793294, 1.2702224985238644, -0.10050788194125368, -0.4949026165843822, -0.6402680979613666, 0.13799388389074288, -0.6488721193686207, -1.7049053218884151, 1.190823188309496, 0.9853111723775758, 0.7863665054356775, -2.2080357712925998, -0.6627681933204114, -1.1168105078897712},
    {-1.3397725540376413, -1.6723167559064702, -0.35805899831124444, -1.296886566247594, -0.36296382983379905, -0.81008726341035, 0.9255468738080341, 0.20798848465252875, -1.8495256362060521, -1.9482003851174146, 1.1995342600929557, 1.4084289132525576, -2.344936223916225, -1.7728252241418376, -0.5023858662543865, 0.5123563221908646, -1.8596320971955713, -0.8493920626421704, -1.2401777523559816, -0.16991412328189756, -0.6336669484541854, 0.15542853777824592, -1.994294750782944, 0.16926232305639394, -2.3514162540814865, -0.7708818945165257, 0.8350075762341564, -0.6176727478590586, 1.4895869635165637, -1.163134522240035, 0.6743457833646049, -1.3140910069576082},
    {-2.054630618618349, -0.4084523801000127, -0.8790195329410831, 0.48180436432257245, -0.13445915679869946, 1.0260968062559777, 1.0938367162745264, -0.3027784165099543, 1.6461962344833805, -1.1066692651158327, 1.1578340645470921, 0.8183311420913096, -0.4101198256280317, 0.0840006812025109, 0.8694417650221611, 1.3533958926231162, -1.1294847178534655, -0.3458359854833845, 0.20630000544009672, 0.8598673001903099, 0.941610702766259, 0.5954390779735961, -1.2750284458519554, 0.3439439188453817, -0.6208737272418156, 0.07007892924635588, 0.7733297352916413, 0.38433291147103404, 2.2670844999566264, 0.40190488754526166, 1.4076026925235068, 0.32072783946835204},
    {0.7846254494900324, 1.021483793189106, 0.6904689990339399, -0.5429491296380407, -0.9168444008185813, 1.3425284191372828, 0.986476758097679, 1.0281900391036494, 1.2432662416434006, 0.024172235617594243, -1.3011650733450764, -1.0167686130236666, 1.1509689506379186, -1.768439593053663, 0.7931624084641383, -1.8086489805173045, -0.11478681776971922, 1.3030031041161165, -1.4265077049670525, -0.7753546534702843, 1.2409224052096963, -0.11640967729386956, 0.12117943310479416, -0.5972863513401194, 0.2858854993755358, -1.072051995522019, -0.30497138550264064, -0.8591926916106506, -1.7817021705836418, 0.9893679730277203, -2.2959525469166615, -1.050340805159019},
    {0.620688035398805, -0.33162807688069457, 0.5149883319971997, 0.9008856889647823, 1.4620164357649963, 0.815841871052901, -2.216170459896462, 1.7019028288103992, 0.5969024251258277, 1.5118067873489083, 0.3487577464496749, 0.7463271411038098, -1.5862364515546288, -0.8238997301894109, 0.9489373187888938, -1.0325682273703658, 0.40139758094868777, -0.4870416855113653, -1.4466708294605233, 0.18049062291842527, -1.2195478955335748, -0.6903474989015558, -0.5253160174218177, -1.1388743888981159, -1.1173528649748876, -0.0003797523194360367, -0.4757162113222461, 1.3923717395415958, -2.002577743955329, 0.21632414557381813, -0.821399908704986, -0.3969947775703017},
    {2.246189222191726, -2.949434133122167, -6.047295484136065, 0.5039647446911694, 1.3645519635631025, 0.46566514062143555, -4.173621618535194, 1.289061523914332, 0.9625931837629469, -5.408109443421379, -2.910467077351579, -3.9808630608860707, -4.76966028219942, -2.595919397472741, -1.7312112441636303, -2.3546614806603334, -2.915642483719575, -4.266448495125944, -1.3674334336184775, 1.4270325113486795, -4.544788119040965, -3.570828500752308, -3.733945282944221, -6.566641083337871, 0.35964031237858685, -2.058693542993028, 1.0099604366862134, -0.49135181105196624, 1.7308617899613623, 1.1949958944944885, -3.9687450786784075, -2.951155494171878},
    {2.0056942974360408, 1.105256537740834, -6.077948126821641, -1.9374849214085057, 1.8042402365024703, 1.921558135922998, -2.445429066693984, 0.9763822973401708, 0.4835040360154227, -4.943741325828171, -0.8303577683686668, -4.695745421392646, -4.463251643301713, -3.643789792345089, 0.7978456751609868, -0.4514862852977615, -1.3073225081750415, -4.090994741950368, -0.6733719765680234, 4.068375581722843, -4.533579433928208, -1.331347425466113, -2.9754823318460186, -5.238158584457305, 2.989687655343814, 0.16626934602787966, -1.8870860792712334, -0.42737258909843406, 0.8710914891679569, 2.6424561465573184, -1.9899388528334259, -0.7921387932994042},
    {1.4649344751519124, -0.8780759145495187, -0.6299417825614922, -0.9598761066870022, 1.85869233523258, 0.9029599993381013, -2.0337833366090923, -1.126982148903034, -1.284214701786151, -3.4647679152671773, -0.4068829196221884, -1.6588656730934563, -2.6669246033440945, -0.6423925209375262, -2.6490379405610462, -2.082114490505131, -0.505242149034948, -1.6966973583125382, -3.6364057312986753, 0.8978663126421621, -1.7160376422170993, -2.1197508226401016, -2.5544061364432884, -3.3211265044478226, -0.2444179341214232, -1.7996077985755337, 0.8908587054848668, -3.200391634450462, -0.6760566612970762, 1.2445127751189526, -3.9724436609779468, -3.1105368616797024},
    {2.2151124343420263, -2.7444953349308667, -0.031591614597754746, 1.4364238382117984, 2.489618451293935, 0.15478910570899315, -1.1364689825502725, 1.5042978852422277, -0.8259864394265772, -2.6461637292528417, -1.6349034574335684, -0.975193499168943, -0.7685155996812567, -2.6499812190185197, -2.2844378020927754, -2.506313830069003, -1.962614533959831, -2.486394285693757, -2.3038827356991693, 1.916383790578669, -2.1808917217898203, -0.15940657558293406, -0.19066814098758342, -0.5242056830904946, -1.092634906161756, -0.22349240243951288, 1.9346120720029751, -2.3105961137219193, 0.2500892058688779, 1.4917417515458136, -0.6662598084053999, -3.9808443002783576},
    {2.012190516853404, -1.595752743083054, 0.26323297489194375, 0.0627177827474364, 2.3470424600637427, -0.741221428231109, 0.31598992539280185, 2.0752217741142553, 0.9916024132149773, -2.3726194440171313, -1.9009993785505732, -0.7407833515700899, -1.79023937775023, -2.214050788935938, -0.941124245300208, 0.9322972249748003, -2.089972291935483, -1.0867309461407997, 0.22649596836095276, 0.44463826263872575, -0.6222064915867908, 0.35270557478307374, 0.05690681615574715, -2.2421749802362525, 0.4095731470318769, -2.0249570094913376, 1.671289009017726, 0.46852749350892864, 0.5918378811748185, -0.02984542069865633, -1.8745556461387045, -3.2487788728792233},
    {-0.41007288320826957, -1.5375329417677386, -1.1782840901768552, -1.8103667549112294, 1.2923391909747624, 1.2698082622259135, -2.2020945934656884, 1.404673938116882, 1.8106169718618856, -1.076815047472914, -1.283813189325039, -2.412571991330415, -0.5025651541376659, -2.5727134711534485, -1.4077296727232973, -2.6156856139312974, -1.742270623117126, -1.9509960524196197, -2.205372374827115, 0.44789960194705714, -1.9285336078986142, -0.30187493152878175, -2.6756303094545504, -2.6907597445072677, 1.3744880491882319, -0.8641943506646802, 0.39162271513458735, -1.464003357127521, 0.551255863568694, -1.840974481235139, -2.979350970724857, -1.2789645579466684},
    {2.0309500100216575, -2.403501782690173, -0.4538299927308995, 1.5900282785748394, 0.7063547398124763, 0.16253550324069113, 1.5509771835415023, 2.095829810474924, -1.3902669545858184, 0.4469365113507918, 1.9687108837675609, -1.0348791935302901, 0.4138559647689484, 1.0604185995765787, -0.4238434070952679, -0.48273502512314287, -1.2709751155867102, 0.9982236435282719, 2.2972053813179607, 2.2488079890959374, -0.7348926992791518, 1.2472019009856268, 0.4821565569267544, -1.913464442590057, -0.3990530881562368, -1.0715552347313217, -1.774420649425398, 1.43816046885712, 1.9931317852548815, -1.7830256680604102, -0.33133414685143403, -2.8665614800758386},
    {0.37562443953670815, 0.49567773675847737, -2.691235333280618, 0.48312268683977794, 0.38619962065333513, 1.309398375352403, -1.5001694648785588, 0.42495438510641403, 2.253424774609426, -0.4406784775267122, 0.4197265202013815, -0.5860047314055933, -0.6384841014153253, -1.8433222133991565, -1.0647498181585846, 1.4196230337605473, 0.12606002455180534, -0.3488695762390844, 0.8350857288700474, 0.7405646813091931, -2.2681112190841577, 0.21388479260804796, 1.8928782611058266, -2.1558835167297623, 1.1250241478377958, -0.760301947384089, -1.0232762818119967, 0.4890903944450038, 3.1796046535320204, 0.09816264489090538, 0.8276978618400626, 0.9693544651558453},
    {-0.24377257342032674, 0.5448518347084995, -3.520050224821906, -1.2353052186886864, -0.05216073751654516, -0.03764379398324705, 0.09096058686374867, 0.44756423909513027, 0.04467248099730341, -0.7551637351325352, -0.5125877654997041, -3.057430013523492, -2.6924316609961574, 0.599677185626317, -2.248930597946681, 0.7893125201268149, 0.9413102531276059, -2.8405101495417844, -0.7072613633404501, 1.4831242571829701, -2.767587608599888, -0.4258323626586136, -1.4792920032475019, -3.659734175780516, 1.4065410037506323, 0.584460612736071, -3.408656902141937, -1.0150619182816123, 0.508082678743351, 3.110251987090954, -3.4276591873473365, 0.15821800195203387},
    {2.214731481032935, -1.7830859051702554, 0.5218609246654382, -2.886136800945214, -1.1770353861754996, -0.9798414639307393, -1.1855015752458502, 1.609350783222569, -2.2508589194000326, -0.838242997172304, 0.1968383666802806, -1.2508477350287144, 0.5868350514403543, 2.181989111705766, -0.2482703439796195, -0.7142870578943885, 1.0612640943386058, -1.7809134182362683, -2.1356036767212396, 1.2372266322784053, -0.9572631122246339, 0.39987640112531014, 0.8268564870069471, 1.2159167786926743, -0.2811770659069736, -1.1250185212717183, 0.18717819391647955, -0.2514641506623044, -1.5962576545627856, -0.08913338163729909, 0.4309981730874965, 1.086982558726904},
    {-0.7299828394867179, -1.083862567883159, -0.06290646196979233, -1.532425268658329, 0.5238652210298378, 1.034701799370275, -2.3714121501944927, -0.24446540567763053, 0.22488585438345632, -0.5763392684379954, -2.70858131301154, -0.6330556729101016, 1.0152009445918733, 0.6392495053711238, -1.1265235068272959, 0.5698650286019983, 0.8701865432601005, -0.5101907563537901, -2.054176834665499, -2.368879157466984, -1.2073515836450532, -0.11067683830961737, -0.7777318571186189, -0.32981448923096945, -0.6587021980369806, -1.102536786498463, 1.5638211878764934, -1.5798612629213526, -0.9148181272508571, -1.68514922524578, 0.343585540371628, 0.06604842763125984},
    {-1.5254415325907666, 0.3906035169820248, -0.510944019741475, 0.47957909237592916, 2.146790468832327, -1.3425580826640688, -0.09918954509015641, 2.098831583588554, -0.462862546902783, 0.10836720016646369, -0.8508437404188633, -1.656036585906427, -2.017055776682371, -2.1570707572390018, -2.6333600636283965, -1.0570172269540246, -0.5537147080259489, -0.6139213229783556, -1.2805224553514085, 0.7875520775778799, 0.1924502095291858, 0.9876829192542426, -2.3236385401384294, -1.8161998560906456, -1.6797546616753447, 0.2465100848529644, -0.2919040360599076, -1.0955778447477276, 1.5523611767799717, -1.4412136071218271, -1.8195029717528604, -0.9522689170681276},
    {-0.4754208620974821, 0.5887067204854751, -0.5628953808212168, -0.631692766186942, 1.545877988215998, 1.2145678155887367, -1.7432121928002173, 1.7397444385637708, 1.5752038741330923, 0.7546273406187888, 1.736179383169695, -0.6944743241857544, 1.6708969714399264, -2.1674365962103033, -1.2104345064964737, 1.687144652421733, -0.7586271441027496, 2.1848049681224473, -1.2560959350159726, 1.9378166374835766, 1.1817815317495703, 0.05886226387597155, 0.02025835035025927, -2.0380087423979543, 0.35914023695531966, 1.0449982360929877, -1.6315192159889769, -0.04994463068537672, 0.8405848760929351, 1.8996408144817263, -2.1292203499347644, -0.04124617183506449},
    {-1.8333445318981514, -2.0181588133062003, -1.8497660399604177, 0.9852624909505348, 1.5258608448443294, -0.12895691316118946, -1.1583709678612832, 1.0333923517426427, 0.2272728085746505, -2.3925308793025843, -2.40475250116673, 0.09895481619896684, -2.7357812343676313, -2.5939109213350835, -0.6315492219729205, -1.6047701011712574, 1.2509814514016235, -2.1935838665786127, -0.6863670505287733, 0.159128264568681, -1.8631928769302548, -0.4844514537183543, -0.7976794769726965, -0.8189011362050772, -2.626060753904271, -1.7633170687316242, 0.685230620489396, -0.9524548047683262, 0.7440803654794423, 1.2663321577105984, -1.93285890844059, -0.9698678525620138},
    {-1.2807055051560285, 1.4015848428487194, -1.2946957710098475, -1.0553020270356086, 0.9030955255164993, 2.42298420858161, -0.23608888982612747, 1.5525256598481552, 0.2848558988631842, -0.5364983050261438, -0.8006946183135819, -0.07811585933264503, -1.7247443898785375, 0.5850407727002174, -0.2987139388624918, 2.016855396921721, -1.6610834970691961, 1.2006067481977807, -1.2233235734585028, -0.7040047040156068, -1.904790903414486, 0.26949476754219415, -1.5492809089015491, 0.21489302251647158, -0.7020409643793286, -0.8900380521300655, -0.25844204031047513, 0.9303772801559611, 0.7297803540247055, 2.402377607821732, 1.6403060531195743, -0.6360378242854169},
    {0.5398716940481456, 0.5158143145566936, -2.9922838798871427, -2.1167792816588435, 0.9200072366097172, 2.0479007930589237, -1.7463636901169803, 0.22995670101691315, 0.23636716504898414, -1.0860307116581154, -0.8455724257513106, -2.1901913332450818, -1.374550910051184, 0.6201358143589881, -0.7604932469566952, -1.1693205344878177, 0.2544754983331843, -0.9614737116709026, -1.914399290057503, -0.007176367903139703, -1.4843139565302506, -1.4180463878049798, -2.6963042389267193, -2.590816520472935, 0.6667206224363461, 0.27222123495698386, -1.3525183164444843, -2.8744168297269064, 0.5210906054594376, 0.9769111518363028, -1.0776453270820179, -1.8040472261163916},
    {-1.2256679814387825, -2.081511956998343, -0.5965369782231824, -0.7790771368284828, 1.2835694588593536, 1.5675459681970034, -2.0034178515315264, -1.1221274426889902, 0.033490153401340345, -1.2459184928529474, -2.6210552281970534, -0.28646743949426995, -2.455968611288153, 0.8054386230663736, -1.8191693338414314, -2.277774358947818, -1.1465993898269646, 0.5739945617350605, -0.8238643609408065, -1.0194024224961509, -1.784380916542403, 0.11371157139888478, 0.393403127867816, -2.3521236488021104, 0.5351776333443338, -1.6729573184772084, -2.4506009547547354, -1.093466615669975, -0.532539258818065, 0.5378718743375115, -1.068104464696996, 0.5089576569445364},
    {0.6597108410392172, -3.1337085654749255, -1.983056103063665, -2.4716232653173407, -2.4090025342280734, 1.849282575371832, -2.652930798233332, 0.10698722328534988, -4.124079649215697, -1.6333264396911873, -1.445113583406597, 0.7873526111944646, -0.3313394095756238, -0.40568363811673774, 0.07227652963453145, -2.6832409307143306, -0.4299245425302004, 0.04284919195949603, -3.25215167000565, 0.1747606989940558, -1.5256960125989705, -1.8184152653705277, -0.255796487328685, 0.9567690022264286, 1.036370460474647, 0.922320701219266, 0.03713377891263987, -1.307196522470304, -1.790587237272347, 0.08101616489503534, -1.8848279071328369, -2.223818304649469},
    {1.7275540832329812, -2.605288294031141, -1.7295920516228869, -1.4723676850137553, -2.169976278975494, -0.9773373008637662, 0.7576803295388139, 0.07316110203050832, -1.9421929331485286, 1.2252840682111537, 0.855071674012394, -1.5465126374541383, -2.393508604609246, 1.294071967275917, -0.6064640554316434, -1.1351434031744727, -1.1947377034957791, 0.4692700426263401, -2.100943148106158, -1.5458164592160313, 1.2562739050331067, -0.16394603861827292, -0.3350741310591295, 1.9410953067470833, 1.3783068255728146, 1.1277217250767493, 1.9487722702209063, 0.8332942881885486, -0.4953994569531221, -1.7816006031580043, -0.5565882034947621, 1.3232047056368361},
    {2.163206996027632, -0.04033457634227605, -0.5740898717194762, -1.8866711682483412, -2.5762569955724692, -1.9699703203139758, -1.6477598982140744, 1.5464817599226581, -2.5951394411930204, -0.1785880852795271, 0.21824124241946236, -1.7529885086970054, -0.17208006083984165, 0.803108935760337, -0.8098186826700706, -2.038559549589985, 2.316407864029477, -0.5846218421084903, -2.232855381405328, -0.7396083711492366, 0.5020289572974811, -1.6117361608527727, -1.6658191711112853, 1.3392082647065633, 0.233617044858943, 1.352278764557665, 1.5402175567183025, -1.4389642136101697, -1.7861511259897556, 0.43018050699420374, -1.1735414615086648, 0.0689942058054959},
    {0.04585159584879782, 1.3315465671065774, 2.0208503133026996, 0.8954638985677108, -1.7872974323100939, -0.006522661045596884, -1.619130893362461, 1.2463741281031453, 0.6178184064732052, 1.0542087789438022, -0.003507281480191718, -0.12757441676163755, -0.18225072461588976, -0.3959931474903158, -2.218739003167699, -0.6416140560033333, 0.40291878426426864, 1.5994361245050908, -2.5618946247246748, -1.4018417678281094, 1.9159076071462633, 1.2461751345325374, -0.5895233053768986, -1.1547550188622504, 1.8397461829571196, 1.1047639987217521, -0.8057665351984058, -2.151922228193889, -2.2914075273319314, 1.1243792099919303, -1.5247341765850737, 1.0457452595429242},
    {0.25977726112460003, -1.8793440031803483, 1.3867971878296388, 0.2527177032607534, -1.901965251470282, 1.3442276308991452, -1.2001807309294399, 2.1183588309066503, 0.40413288191117247, 1.3287883830063285, 1.8428505543787619, -1.9268796820948415, -1.33172361238338, 2.533705833278071, -0.038300075589378785, -1.5700956206010948, -1.3998106722542678, -1.6010861276717905, -1.3163553404664299, -0.9480429333868836, 0.6428099244735502, 0.9745587875083322, -1.8469193418718703, 0.334247955031852, 0.4043767488459635, 0.5673254528617674, -2.0392979936243667, -0.7101041819618028, -1.89810392433929, 2.227014088656985, -0.8607728420508748, -0.9095940365802959},
    {2.2236479858586677, -1.5683722427036335, 1.7646094738872713, 0.5261984967516131, 2.4023098015263757, 2.8289544168134553, -2.0565647919253367, -0.41070391917996735, -1.5122476457762053, 1.6813167873754433, 0.6078695260813122, -0.33541248613311814, 0.45605826459653304, -0.934552451900765, -1.0090406710375701, -0.48082158096901795, 0.3800842260349627, 1.0370328312255481, -1.5787284917020605, 1.3070344515428018, -0.9374909823441296, 1.9301847294702277, 0.16586984655603984, 1.2203492056800342, -1.3938185474283384, 0.2924800119575477, -1.1151477172651558, -1.2100875975910705, 1.644955221386752, -0.6089549125027416, -2.6804739188736226, -2.5848645225588833},
    {1.1889901014970594, 1.2224242586508334, 0.09685087413837719, -2.0128899303007524, -0.9812566970523379, 1.5716171653807198, 1.326753994435585, 1.247358629550307, -0.4186560856427668, 0.012999733825419831, -0.08313950973174614, -1.4174246638693746, -1.6339104327203398, -0.30798030839022283, 1.2672424877488224, -1.960281089435992, -1.359702922874171, -0.0550547901932822, -1.0396982244823587, -2.3744921512377477, 0.3657584462143356, -0.3511858372760869, 1.5636740234351458, -0.4517270146773908, -0.051533490927483674, -0.10664365522913996, -1.8301657469031853, -0.8822494279953317, 0.9510003697526899, 0.9939293222872867, -2.8299493115806538, 0.6108194985576829},
    {0.20548930703121196, -0.16796359478125686, -0.618892643628296, -2.0348861092790513, 1.3044250620069353, -3.142158597000739, 1.4290541886595138, -0.008761018738007083, -2.6854701363655034, -2.1757441730261746, -0.9065886192279649, 0.6904314567584204, -1.07227357130009, 0.8322249324011151, -0.42952208313080387, -0.776996159045392, -0.0710362490934887, -0.2545700712105231, -0.18405798469321738, -0.5074004595769871, 0.17906820823027045, 1.3052926506201916, 0.4640625106694124, -0.39372867258452415, -1.006516578735349, -1.900497002932513, 0.5668461634020038, 0.9614182812857529, 0.9529730512279287, -0.6496872101405197, -0.15488375036951257, -2.6935233806564693},
    {-2.4164963488687015, 0.8680325723525375, 0.7765071797889685, -1.9414908017292685, -0.3008482835599548, 1.3708670881394214, -0.12037713868491012, -0.35669252741859525, 1.1489641559645665, 1.8072210964979307, -0.16789924838358755, -0.7524849388713483, -0.4617220300389932, 0.8513123591429304, 1.494968498901931, 1.6753992056683054, 1.1642050310934329, 0.612673118790717, 0.6807504250766323, -1.8635084070188097, 0.9555571398780428, 0.9033676502957017, -1.0319657896320396, 1.2329899319456037, -3.2779548936151666, -0.2068940253783709, -2.6916314358608404, 0.7987493077882097, 0.027434365244581725, -2.3396226393839483, -2.1004301731702624, -1.0467297411129335},
    {0.28412555040714066, 0.31160649531062673, -0.9654326409339354, -0.08901678284245829, 1.739978369634351, 1.8612414418206453, -0.9999278613842939, 1.7944586592210792, -0.11367243736894732, -1.0395144482738397, 0.4945174544699615, 1.4794170191491116, -3.018564377896375, 0.37206630121662176, 1.0766350631994785, -0.702036291568257, -1.1761025371973857, -2.3834313127616404, -0.8347895930617036, -0.4620223831804289, -2.4984437948276734, -0.7767463819396636, -0.7205939606761568, 0.3265710613471166, -2.323176794086328, -0.8277498314048245, -0.856437482594773, 1.7654962071373805, -1.395066019904381, 1.2063783000823056, 0.00492199533618346, -1.148457390085216},
    {-1.532060302339343, -0.7467401331449762, 0.11543517031459247, 1.9632277070039, 0.0002948737951040904, -1.0490212964937082, -1.5441715050726623, 0.4305761215196622, -2.9656578875665267, 0.3548168801520577, 0.48660120907417975, -2.1771718081486853, -2.3218938219014613, 0.3637950423317474, 0.6321425431394101, -0.0025289812190276203, 1.4618933497685977, 0.3468749714135198, -0.18919243876123973, -0.8961890629358319, 0.0925534020812394, 2.1385616524773297, 0.20985229384865994, -1.4512960453076043, 0.03893318167533213, 0.22086978822749515, -0.28801449654106837, -0.5344403339992366, -1.5429145170095306, -0.851851261679238, -1.601494206529368, -0.393675220003018},
    {1.807124727834877, 0.21718866657312333, 1.1636437754064515, -1.6666917978129692, 0.009399857827851408, 2.3542099250054584, 2.3330447074059593, 0.46027631481732356, 1.262413135043462, -1.9178093318727039, 1.7428252367607833, 0.8096784345445444, -1.008193574066169, -0.6367033179028853, -0.8143450408859768, 0.21900631110783866, 2.078358622343939, -0.21911959155596408, 0.9009032372530468, 1.3744770106091435, -1.7423290089756172, 2.1821864169190066, 1.6012800791894033, -0.08935189815916997, 1.3064068330733702, 0.08154494864773144, -1.127638102435719, -0.38978601087574993, -0.15500040436611953, -0.9887105613935603, -1.6172814383950804, -0.24518755186968538},
    {0.19593019088848987, 1.6023073652356006, 0.32222335523324724, -1.8244520797638044, -1.0358864909848624, 1.1352895049860428, -1.6442340082593603, 1.8068802033893434, -0.3407658685586198, 0.2347469334442364, 0.7364480694298711, 0.1383131387150663, 0.4123193399451742, -0.2657407812805616, -0.8218150519383541, 1.6065717501365708, 0.5438304891574706, 1.2898683269370512, -0.8325427565236146, 1.823267729821861, -0.7028069680419962, 0.5508782126281945, -1.8956271693168592, 0.9026767841284457, -0.13559003551545942, 2.6209234474885292, -2.4130803373325627, 0.8690753545111537, -1.4535580813828861, 2.5439720314352696, 0.958783876427729, 0.1533554716756661}
};

static const float b1[32] = {7.590104562035263, 8.10774618096849, 7.946186991146232, 8.19904240266488, 8.36396661366565, 7.851137560883909, 8.49436157812265, 7.824222079239183, 7.593110943438002, 8.48202701261983, 8.515807997146467, 8.420535263910137, 8.455618635762402, 8.268214896687729, 8.629919867061927, 8.195672833849969, 8.294152234434604, 8.536177434678944, 8.173813518321417, 8.137002011906198, 7.998802527152872, 8.593666513744093, 7.0719388414657915, 8.471143100714494, 8.222963507164494, 8.140199794514453, 8.003079807362438, 7.804016228008811, 8.383640857200785, 8.209842305127076, 8.124605893502318, 8.137030747779006};

static const float w2[32][16] = {
    {6.289532240161512, 5.309668626377627, 7.188825229104128, 6.451731040250189, 6.216640277200909, -0.7432110307410724, -0.2902242586830042, -0.33800561396071876, 6.6345029183988355, 2.2142759251008552, 3.636040829572457, 5.751139396633404, 7.148527936118737, 7.260317305157323, 5.937448490506795, 5.933191738024609},
    {7.747976126697917, 5.208617027307096, 7.0410157350767095, 7.976943424301624, 7.473169032134911, -0.5234990444696437, -0.23035778263969933, -0.3688036455399279, 6.307541673043957, 2.2809965418471463, 3.771824729845311, 6.0092591852446295, 7.135401910889007, 6.920572489790756, 5.883988128179207, 6.902540189628174},
    {6.210009201299808, 5.021130905580751, 7.165368313122352, 6.477417222954437, 7.247855979840968, -1.0820950883450016, 0.9050247431614261, -0.460826417855049, 5.57414742265863, 2.5643924519935792, 3.8042479874367556, 6.211475443734124, 6.278428925025011, 6.616103027634121, 7.642693471365993, 6.329259996822804},
    {6.919857303115804, 3.803795293135637, 7.392728071440179, 7.0104313713323, 6.512435371703407, -0.286068455809616, -0.8785707952737181, 0.18014855474992714, 5.926832519889622, 2.2354056044026622, 3.682221658571191, 5.769549819738495, 7.136823602035977, 6.037014615065361, 6.488015721086252, 7.450840770246014},
    {7.173092273304945, 5.431936985143528, 5.81116047605987, 7.388598721041567, 6.856294317162039, -1.049474895395139, -0.12234622654207154, -0.9669727587194232, 6.303148862183272, 3.200962080543392, 2.218286542431375, 5.552581316297675, 6.292942477429558, 5.912206974467593, 6.689878631251976, 6.523860262701773},
    {6.518935357675244, 5.4244039391959795, 6.902415778199152, 6.703487739030133, 7.2636475038361565, -0.39822728217123954, 0.4025113666254852, 0.1373756663819268, 5.795272161731355, 2.552220205266547, 3.8986854331471896, 6.692688173758532, 6.949394133147006, 7.12350001798532, 6.57675086312498, 7.234058162072421},
    {6.940249660763544, 4.156501333927906, 7.352733161620108, 7.740066296024478, 7.446804548678803, -0.046379965428456606, -0.7050319121379031, -0.35606784943475966, 5.30252533494612, 2.0103509214826736, 3.240622050026484, 7.315459834279266, 6.5980597254937905, 7.4705108568887635, 6.519464419968946, 7.906085850645491},
    {6.82813118384864, 4.896487420577573, 6.707739431470197, 6.571831644948807, 6.36062910135388, -0.24903339112686862, 0.22990239151804465, 0.6407368863023328, 5.804252768001759, 3.7788624668143522, 3.973788671223517, 6.212347706373119, 6.195167960611051, 7.253443014755586, 6.690269641324003, 6.4480191940424785},
    {5.984796865122777, 4.038895582336495, 6.998115742541808, 6.009368549234212, 5.997447868501664, -0.8001667589219233, -0.7149572858759224, -0.9828328782413617, 5.584295582166584, 2.6196341425309173, 3.1659210327996177, 6.9152844361434544, 6.1789747058503774, 7.556306979917184, 6.2847886470819665, 6.7899484566021675},
    {7.0861519956834265, 4.341406980733188, 5.952817487101884, 7.26284660373488, 7.128947209658544, 0.42204760161321414, 0.4524518468582768, -0.7227888897770909, 5.496424311457189, 3.366615451038589, 3.2541206323613356, 7.498541723572956, 6.6352671884632475, 6.233969875946631, 7.100115387307223, 6.473872421447763},
    {7.020616337541665, 5.600443909544217, 7.204153022694197, 7.839759420223405, 7.076816755814544, -0.6836783485750169, -0.3673672163638964, -0.9170068778138227, 5.4836173837215165, 2.176005706467598, 2.895653094612083, 7.059625405858709, 7.192102000752947, 6.244037494999579, 7.046782574223368, 7.708479115106994},
    {6.9498096816778725, 4.757313194728936, 7.303231559080942, 7.976187830466592, 7.1843921967187985, -0.6572216010216689, -0.6001297898044191, 0.30385319001371525, 5.711459230959763, 2.7034713047148187, 3.352583982149878, 7.303920176888785, 5.952567255387523, 6.589184971607682, 7.792480238224244, 6.362871039430594},
    {7.822489942749015, 4.274567991372981, 6.607857944757944, 6.743737300632459, 7.291358968509935, -0.6442903150871904, -0.21867607508343911, -1.1318173900261541, 5.1717551090117135, 2.229094707147393, 4.280852792350358, 6.113273320899979, 6.908250621767492, 6.6022728717716435, 7.06399021772202, 7.321080439575904},
    {6.713835987544452, 4.153219748438321, 5.834645620227333, 6.401268936596347, 7.00022794885419, 0.5299930528992995, -0.6393479332105684, -0.05951505662454779, 4.915283897049554, 2.3125127080214933, 3.2380215817581197, 6.104793584001476, 6.659721476133082, 7.5367717207059695, 6.887166748584023, 6.963437023315542},
    {6.194007444375423, 4.09411142379813, 6.2460205966938585, 7.102332766855803, 7.350709310266224, -1.0804997990770002, -0.22247121327714492, -1.033400851883793, 6.342189280409993, 2.9301367386730908, 3.5801752423251334, 5.786438931162457, 6.1915149854356955, 7.611689129734062, 6.816510151468642, 6.363665456681441},
    {6.059427107612467, 3.987423083405076, 5.967488996416813, 7.2269409359254775, 7.162438580374078, -0.5061468326948595, -0.045226742998520524, -1.0352639251960176, 5.687242077359117, 3.806280445385727, 4.160841173639364, 5.948755758491121, 6.899325023163597, 7.834559721909197, 7.636329748163954, 6.569308696679867},
    {6.48739127272312, 5.284490473486324, 7.049475556580827, 7.313366477070339, 5.969055911318698, -0.14110530181498793, -0.9212246465082232, -0.765895354474376, 5.648292543532076, 2.9319873894655903, 2.625584359667646, 6.491171236361427, 6.999394698500587, 7.633709779568144, 6.542750565590264, 7.898100535954937},
    {6.281795614478888, 4.253142823678967, 7.676461617855217, 7.310447017196478, 6.666645717567057, -0.12707905574902068, -0.7012912426556525, -0.8393509090095483, 5.298061533605862, 3.2901028409299187, 2.6239804974674183, 6.3963722673864964, 7.370844973895871, 6.891853050326423, 6.722119639281387, 6.806928894424622},
    {7.376236214534956, 5.526451176467701, 6.192935041689436, 6.445522158629368, 7.059322616082018, 0.1939813722945351, -0.8639973201085219, -0.3137464594332962, 5.6980892549037145, 2.7956400110689237, 2.921599994593552, 7.156512692626122, 6.819527382980918, 8.03903641913259, 6.606878491501933, 7.698489058074671},
    {5.745620248339089, 3.955319843908245, 6.992656516159661, 7.397991983526501, 7.235970864246177, -0.8399125069573965, 0.737841199963752, -1.0188268851315785, 5.322141360598315, 2.8623010272256377, 3.649550991620065, 5.365222870731435, 6.869104990721439, 5.992611253440019, 5.890616507193546, 6.533852154023666},
    {6.913944673579511, 4.293027718159248, 6.715466542221597, 6.817536901435087, 6.75032525941468, -0.7581955959293885, 0.6702337603082613, 0.4192127195674368, 6.851983942519669, 2.3390487252438787, 3.9605742333496234, 6.192377556886622, 7.414071728512397, 7.575729005483399, 6.681259943389154, 7.026224204566765},
    {7.166155926097604, 4.531916509290197, 6.938272777244467, 6.430229515040738, 7.582869823308336, -0.28141369464619154, 0.20021530503339055, -0.6309635885621311, 5.996027662771595, 1.85486968092065, 3.268789332942612, 6.75358422301898, 6.519311877314335, 8.16475476483096, 6.763295111500837, 7.417030017101593},
    {6.358909976926892, 3.832192790692431, 6.239513966467265, 5.9958436194889115, 6.47852547083229, 0.3355704918811104, 0.43103339567749405, -0.5163063695434239, 5.197761195730803, 2.5531426848597283, 4.445073434059898, 6.354618953926235, 6.139466037364501, 7.073638611027773, 5.951197683759084, 6.088646984303304},
    {8.027077722779778, 4.000618492097738, 7.301037653016471, 7.5669761496909524, 6.750199188439331, -0.2452279988851563, -0.5506331323593129, 0.044422480135995354, 6.335310362875132, 2.623641865211865, 2.937387356610184, 7.52393876601239, 6.589563854262284, 6.835819219069463, 6.407122210639782, 6.534934128234337},
    {7.199157398987596, 5.601731639935329, 5.953043078319914, 7.102779185068646, 6.4364427267926745, -0.5679489211253824, -1.0313376073883207, -0.15349047297356383, 5.724021097991245, 2.8631943624164347, 3.531604649158827, 7.102144554756353, 6.039841402986634, 6.10343521108701, 7.493066932078739, 6.263638538724565},
    {7.823029577748674, 5.705623502795227, 6.650700224619348, 6.532839463811385, 7.662731464328665, 0.5559110595195462, -0.09290422358915641, 0.3533967020680433, 7.121044322431349, 2.855026152867911, 3.1269311418015207, 6.254419786044287, 6.263103633207889, 6.293688179558256, 6.705211252873945, 7.458291787619736},
    {7.1099069553473, 4.831573183420161, 6.276900344012054, 6.15988968973062, 7.395623454532265, 0.4689314589185161, -0.9595753382461524, 0.38856653301120275, 5.2217368228248935, 1.979690102178844, 3.770521620209033, 6.356432049437778, 7.033594473788628, 6.365673271510795, 7.523888724610875, 6.003447289417651},
    {7.029860488793598, 4.966088563384353, 7.202201473792199, 6.199461396260285, 7.1017979620353575, -1.0452469504725919, 0.4333640156666485, -0.9934586513631646, 6.79853473571124, 1.8790789881602357, 4.341907481929435, 6.535574063847216, 6.481426282877341, 6.361559988278523, 6.336126878296563, 7.5424771630411085},
    {6.484649940744084, 4.539865751035559, 5.896352404986165, 6.820569693691262, 7.0865226364383025, -0.07459646766902589, -0.6506641007653143, 0.8552683477177875, 6.276922488306297, 1.9451163072906847, 3.8112342042344522, 6.067590358063956, 6.393251314166666, 7.202268883667364, 7.0236013684289205, 6.8873796140208166},
    {6.008370352925501, 3.872169949187656, 6.945471430637637, 6.578267953185198, 6.832517124199626, -0.3352728363878864, -0.1466518392442463, 0.2661701686113043, 5.148146669769206, 2.1966763852265134, 2.4747519707007126, 6.979030328455683, 6.917956090310328, 7.181364857613628, 7.473870900939033, 7.293204447018617},
    {6.875966804793334, 5.284000304106944, 7.359426158418437, 7.340247862552054, 7.263228200361166, 0.6732572055522269, -0.3741628877792164, 0.10818620975358946, 5.291762629870278, 2.0501236150570836, 3.787659693411273, 6.5208845605135455, 7.116673760273239, 6.080235879123881, 6.26738390263264, 7.1319019299622015},
    {7.2240994476884985, 4.92698318650618, 5.918038050533999, 6.646271396780817, 6.8878024166183724, -0.38748511499603744, 0.5805588775643862, 0.21406441232682794, 6.1887482907496185, 2.030902009750083, 3.1782663420724004, 6.346575334683905, 6.707009985181149, 7.002868205286048, 7.338050685953816, 6.778044528886103}
};

static const float b2[16] = {7.33067412347833, 5.34724961373644, 7.018918625425376, 7.233515069381291, 6.9232186853959705, -0.2851831845541852, -0.14252332279855012, -0.288706302206066, 6.556828137950306, 3.4098655757609664, 4.044843056301636, 6.938404341614761, 6.811700527719976, 7.1782658309747855, 7.282911975606932, 7.114739838087724};

static const float w3[16][12] = {
    {-4.415618461223888, -4.750660231030326, -5.128515280846653, -5.090118351823552, -3.789570849791117, -4.370155141913737, -5.3030470755998875, -4.604082309727965, -5.0368902875900945, -3.933613123978465, -6.136837739579525, -5.771231635283557},
    {-4.678717673728292, -3.208299922015054, -3.4028891059821342, -4.410970499835918, -3.1438284098551486, -4.345103798319709, -2.847803945582027, -3.6424093872894576, -2.582931666447239, -3.3816487602644636, -2.843880126639785, -3.2181680214926924},
    {-5.511879438732926, -5.773464462072458, -4.634583279186285, -5.187157992876243, -4.625110237778249, -4.706071304100847, -4.714908784637964, -4.321171259612846, -5.733021340891002, -5.241339696752222, -5.517282145507031, -4.100018516932117},
    {-3.8957168309459744, -4.751360692529165, -5.023856760046543, -4.008912330803027, -4.0781453462767745, -5.37260179355255, -5.6331276902810865, -5.710760093700813, -4.912265770919779, -5.162267308144257, -6.118536731944548, -5.303251747579077},
    {-4.993053623135037, -4.5881010907260595, -5.402702969071342, -5.953529839055388, -5.589230258051395, -4.975110921651459, -4.144774142505655, -4.866760318659665, -4.982779890068664, -5.837456603736259, -4.250545023901846, -5.347262557335789},
    {-0.12887566937192277, 0.7423530176283271, -0.1512252141927316, 0.04691364121268606, 0.7233961621326337, 0.17460123558915533, -0.2911878039936532, 0.33446758718585284, 0.16634020398500327, -0.7007901692656542, -0.3702416526607261, -0.6198283019505183},
    {-0.008892831050643563, 0.28898285545816693, -1.4300109482836172, -0.2557635872823442, -1.2080380509008415, -0.442876984799007, 0.08026975956417627, -0.4577606407227118, -1.0354782972346754, -0.1826645260960337, 0.561351364212574, -0.05125064331929111},
    {-1.1883008429839983, -0.7573053859769187, 0.3644056593321359, 0.024815509376960893, 0.3860473686039645, -0.9196604771340786, 0.1594510129350953, -0.8500240817014338, 0.6301802503876328, 0.4085476155511013, 0.09239471698809396, 0.6432310237953138},
    {-4.74293703503803, -3.7670083266055476, -3.843542132280396, -3.9200184026169818, -5.158509050607582, -3.616533729391434, -4.182607192818257, -4.177316597570862, -4.7904769898042865, -4.818421019070145, -3.43282197075562, -4.437985486744589},
    {-1.6913614898851659, -2.6388952116123483, -1.950775884738608, -2.840654347829133, -2.09186359025681, -1.7017563245844844, -3.141642190481975, -1.5151070755935017, -1.2576033442337213, -2.1870676391746895, -1.8417816157655276, -2.0321767790463636},
    {-2.325304012418931, -3.440969989781593, -2.1051109029225334, -2.816753237252484, -2.0453504142899814, -3.390295676071917, -2.878123622232309, -1.6492292765984413, -2.7162911921976067, -2.7473742908651606, -2.424712376858454, -2.0159374437713473},
    {-4.763393856062689, -5.2277755285818674, -4.364781896294377, -4.37998371025939, -4.900450893280405, -4.659130629295333, -4.297131029046903, -4.631409736401011, -4.361003258621853, -5.2876474649703775, -4.16285741936538, -5.303619472440685},
    {-5.0450513549427995, -5.205447051591788, -4.324044863908243, -4.44754480834159, -5.6478143259093745, -5.683366596390132, -5.241788014508269, -5.534335728432274, -4.353283573694193, -5.591560842074705, -4.113618722496341, -4.680628000811773},
    {-5.4123918979709575, -4.756733557964007, -4.834215957335489, -4.804929702057751, -5.018624921202106, -4.855031773452081, -5.2274404331532685, -5.381365326142272, -4.828155276310685, -4.3305835847494105, -4.849830967458135, -4.4119612406045325},
    {-4.913020737310625, -4.136359377466475, -6.0845416040894245, -4.164374407262133, -5.2066459015564, -4.620095065817018, -5.574091628729074, -5.33471754486303, -5.412307913657315, -4.488028866061204, -4.493503820880073, -4.811082344902569},
    {-4.4219781431906915, -5.14628557968659, -5.119534426531696, -5.473245947959558, -5.152042876840691, -4.767056916134011, -4.087876281145779, -4.528130091471034, -5.084566497649607, -3.999558883312288, -5.913345710740673, -4.90152316686936}
};

static const float b3[12] = {-3.1855642560654354, -3.2872730761602895, -3.1081546991393925, -3.0079450818083737, -3.537134981073103, -3.7895806496670326, -3.2900103863874595, -2.767762591004946, -3.1891411900220983, -3.3223670815231774, -2.196994649353052, -3.2416865253066547};

    // Input Layer 
    float z1[32];
    for (int i = 0; i < 32; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[16];
    for (int i = 0; i < 16; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 32; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Output Layer
    float z3[12];
    for (int k = 0; k < 12; k++)
    {
        z3[k] = b3[k];
        for (int j = 0; j < 16; j++)
        {
            z3[k] += z2[j] * w3[j][k];
        }
    }
    softmax(z3, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
