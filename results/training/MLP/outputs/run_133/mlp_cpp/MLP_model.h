#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][16] = {
    {-0.17575743087402843, -1.4153288493440956, 0.4188102881175354, 1.47025922452385, -1.6563348341647426, 0.9092949333671112, -1.7735241087346933, 0.37934756509500644, 0.94904992610409, -1.5825277809875895, -0.16798357031243114, 1.3762668730962544, 0.3925274211583119, -0.3311351771760425, -1.5211704872798049, -0.6828008636364591},
    {0.49088535207031986, 0.17671408415348888, -0.28121548974293914, -0.690706875550499, 0.6344665767584345, -1.7988065939383835, 1.7214853420045269, -1.8315577011011577, -0.376457427274143, 1.1479041465968067, -0.5434763262589863, -1.7665089504892242, 0.912281916164837, 0.9632535645837024, -0.09602154687459773, 0.05729448547205625},
    {-0.4019293168091721, 0.5719323921139964, -0.6182707184969057, -0.07810141566297217, -1.5408037774091023, -1.733370379510729, 0.5095087840169977, 0.6166715555870851, -0.4794370138786606, -0.2959718341077979, 0.7354557642844363, -2.433408554401463, -0.36625178994206087, 1.0313138318721229, 0.08561721628107376, -0.0004653731993607248},
    {-0.19795902212292163, -0.3547920036805684, -0.39278312022340994, 0.05003755249238928, -0.6534552192011669, -1.856458457730475, -0.8532233565003736, 0.3770132328323725, 0.19574867828440767, -1.1039863512835937, -0.2039465487824159, -1.0655779609921199, 0.9611138583890267, -0.33623611898338646, -0.7404522478643337, -0.1699515648359501},
    {0.15985976287289952, -0.6968173290403537, -0.830917461250488, -1.6940789482771748, -1.0888277833763538, -1.2361448570828144, 0.9763469875904376, 1.354530722622387, -1.4334982897770283, 0.45481513380484084, 0.5056491068485652, -0.4846892385525581, 0.2393038778546336, 0.5862500567551022, 1.394983454630715, 0.7346271059923063},
    {0.4553650544134774, 1.5897774508116038, -0.3504622009908784, -1.48342983439564, -0.9354245207185113, -0.6219152925715864, 1.3119189875620825, 0.9278862779358197, 0.23551431322527158, 0.8766089671037798, 0.6743692509162346, 0.6556255254363513, 0.2207091223938772, 0.5607427146824804, 0.8676159465385196, 1.6522032503401263},
    {-0.7858023672299118, 1.5645171618983276, -0.5360675555856301, -1.180968537608583, -0.8111336720124062, -0.9283593395578549, 0.8605771807829576, 1.0047841380811968, 0.6815190781686671, 0.4124487040440975, 0.2619416381678102, -0.7059992672965074, 0.9850510196349501, -0.17149240044267572, -0.15570580349603813, 1.2467179956342664},
    {0.07624828197576546, -0.8852299077739217, -0.5690471702634383, -0.8772146307471022, -0.017463919075657794, -0.771261538645576, 0.6685912693914196, 0.3188381585822392, -0.5712511362405491, -0.05015011478900071, 0.26917564566861885, -0.8335752711395077, 0.8060109625005714, 0.7846478073076424, 0.054705224575685676, 0.298283142294334},
    {0.3952580205378259, -0.7432031194977539, -1.0296564459910074, -0.763056968988143, -0.9617931120257766, -1.1702426604075082, 0.5882534871997277, -0.4582303806216244, 0.7703504093000543, -1.3400953467538084, -0.301988762342815, -1.5335684114544113, 0.5086745617277543, 0.1845383979657489, 0.4052380815205806, -0.2558732432076621},
    {-0.6521241870463504, 0.24904562859402515, 0.7814913308640291, -0.3266626574661719, 1.1928523176503938, 0.9430306490384837, 0.07120145019207866, -1.4298174594826032, 0.6462696247076712, 0.8195726493446347, -0.47448095629013537, 0.4205314230143526, 0.8423970009747582, 0.3511692934438485, -0.14732029147682077, -0.803588796454405},
    {-1.2951915011526, -0.35311628958948077, -0.8817650315009189, -0.9714094583792554, -0.054317859597977025, -0.3560713991635697, -0.2265844030317571, 0.009784810142029785, -1.0226978109107936, 0.47095539158157823, -0.16177895374702242, -0.09480668789035251, 0.7719787702573903, -0.7566567690567929, 0.1907612428408296, -0.03633974945369835},
    {0.3887943642561153, 0.035699786288805664, -0.6626119167410669, -0.6902784535561395, -1.4143575279713463, -1.1890551795051794, -0.38809867357717887, -1.0223538355973893, -0.5133183351618316, -1.232619252550101, -0.9780967553440194, -1.3062055676334845, -0.16214205083942274, 0.4900345468464889, -0.32385976282633067, -1.0429877344568832},
    {-0.19178022576133005, 1.3954605097682704, -0.40013866902800505, 0.009607549455541887, 0.45323043239125593, 0.3297736070178292, 0.8499778782015281, -0.4989465367054062, -0.386635186089679, 0.44333575615436926, -0.2837035206952587, -1.601407381841333, 0.2972794420568301, -0.3877669771704269, 0.9006916543121969, 0.44402764314561777},
    {-0.2768225654415161, 0.8923818003566735, -0.24447239113411715, 0.34508586721159695, 0.4058467220957259, -0.8989134072887021, 0.7775921496593435, -0.5583647569880925, 0.3040017786234079, -0.403561364748732, 0.2055319005709949, 0.9216398048347116, 1.2940489065867309, -0.5333897715960791, -0.1692924227305892, 0.884413485286605},
    {1.121070155468985, 1.2011487844636852, -1.6327245166061821, 0.48058538385758165, -1.499172303111503, -0.4429594429682389, -0.640861599906293, 0.8085124223319509, 0.027056127278974898, -1.2152628995989128, -0.45520591809425925, 0.1593236490248306, 0.03158228257944035, -1.2207487012339084, -0.5227905455243546, 1.1251136463702414},
    {0.8080154442425483, 1.6689200016057157, -0.5662764358185538, 0.6931756308913861, 0.3775359185108952, 0.4372014302880188, 0.6771245402894817, -0.1895505974105432, 1.094833068429339, -0.35702199323145456, -0.07898834960763712, -0.5261068537945857, -0.020133933567182058, -0.727135242106064, 0.2574038016491833, 1.604105152227321},
    {0.2296601480210793, 1.0836586848890948, -1.2915324630706337, -0.5463059290589004, -0.4118090906745683, -1.1929330175317916, 0.5008089813351543, -0.0372977485143207, -0.20102772776791195, 0.18533054293574405, -0.394228080864703, 0.1953653297598335, 1.0625923370923742, -0.26768852302278645, -0.6668559511828616, 0.6834362522398664},
    {-0.135372314171982, 0.44608877188065554, -0.12913237968701868, -0.5216151129872401, -0.6324079310168336, -0.42962873929982726, -0.06952647150756143, -0.03459212093628325, 0.2551020884965395, -0.43394418101743953, -0.1713447364818434, 0.26346836187747397, 0.4079329051966583, -0.428614735629085, -0.995153858018584, -0.13646887719580858},
    {0.32670630173563103, -0.04403347657300005, -1.0630953497034061, -0.47105784076469015, -0.41837307427836906, -1.2153143377658437, 0.4837688471191327, 0.44908269037165915, -0.2610087705651209, -0.6211452630812986, -0.35530145897186216, -0.6940700039045219, -0.3986748380803007, 0.308070811382758, 0.21528921990573666, -0.18103741497433873},
    {-0.2659964118218609, -0.588492153973923, -0.16072203535972515, 0.42953216112382175, -0.03206121357869634, -0.5906008215239728, -0.24628411123149635, 0.33370655055076903, -0.17147095577848243, -0.3324051117453035, -0.8361617632515547, 0.21410723378586344, 0.5139674282084813, 0.1810449459485467, -0.3511410655472579, -0.172049568036436},
    {-0.09681521121480557, -0.48458563308214203, -0.4818910782292713, 0.39107180721735446, -0.11565410513079448, -0.3710943373044381, -0.28574195770156713, 0.3725552810024491, -0.012520664350134202, -0.873346252253681, -0.15271095104591556, -0.009861080114611946, 0.3440754808185258, -0.46009541913939234, -0.6840064254069549, 0.11328798335604327},
    {-1.0013494734418351, -0.4016878064065097, -0.3921368611175703, 0.2845223547651643, 0.867016576316273, -0.1594420848433067, -0.2337353536448935, -0.12430675166974106, -0.04524236919182615, -0.573036591336783, -0.780996072921716, 1.4920535541484985, 0.8106324855418732, -1.1511517200100425, -0.30277942541805963, -0.2416647685228441},
    {-0.47027117406809554, 0.689014306751802, -0.21418419752086107, 1.2875560061635198, 1.0544617589414096, 0.18146120204267066, -0.06461883846229473, 0.5707411350452211, -0.36852749725770706, -0.9822147636978991, 0.159689987109518, 0.08428931629857093, -0.08237027039389866, 0.011532360992775435, -0.7367835991547881, 0.23176350256881298},
    {-0.1040842041811966, -0.5044534945917268, -0.0311925852073767, 0.261269501055508, 1.4109013106963983, 0.00869997860883151, 0.4459952860795963, -0.3169431370234611, -0.8787342433785952, 0.5914196078739345, -0.12304947612518335, 1.594090156727272, -0.1597148327894515, 0.37275987727121274, 0.6999639383163953, -0.7942064568686483},
    {-0.6603793632323254, -0.19884702148415664, 0.08592120486428458, 0.9066342623122343, -0.0962016433313881, 0.013105621554439803, 0.20510030464122014, 0.12668540061749792, -0.3516856323973626, 0.08302448403296234, 0.2896858912316803, 1.0898891860626447, 0.4726416108401866, 0.6207179358852933, -0.6540482081587203, -0.5295464957887001},
    {-0.6896755322946477, -1.193659207834673, 0.5800655136244212, 0.5989410909657938, 0.5402184210962283, -0.32382680107291784, -0.32690353471579664, -0.022313606612461213, -0.41201326381669257, -0.4546637011468469, -1.1839726447535999, 0.18347593122005554, -0.546619775673633, 0.7033587422952632, -0.6732420039570216, -0.8425540345881127},
    {-0.9170391834392789, -0.3409572741316238, 0.45884112142636346, 0.23869798744634352, 0.6643781817296367, 0.6202560109166659, -1.0334940948873883, -0.4097647711867106, -0.8647630749695967, -0.004293468690186548, -1.195004088565129, 0.6680581443549467, 0.22154123521686514, -1.2111000167283257, -0.49815357551787676, -1.2142876684982968},
    {-0.49644567292840075, 0.10396925854890432, 0.48383451280119083, 1.1995137054463862, 1.0622166621045983, 0.8906568473168026, 0.6226040262385629, 0.4406667581293247, 0.5080079264597368, 0.43080568270422515, 0.8592546681915101, 0.36011024003622133, -0.5164839385742245, 0.2977288771411153, 0.8968454356752348, -0.9043518960598407},
    {-1.0049798870348983, -0.2356546836777414, -0.08593832002323384, -0.8609960551059699, 0.2850640020782509, -1.0542385055360448, -0.8792941250240601, -0.3780645625017515, -1.3298323788706075, -0.2789074584458015, -0.7336381746176928, 0.42527968267508653, -0.13329032344632147, -0.2974545818048965, -0.46975008598099055, -1.1298368462191124},
    {-0.32071724233750665, -0.09083894158807895, -1.4148481268043358, -1.6242037380817358, -0.5435026993391108, -1.011819964841989, 0.3208982998532918, 0.38156983944405604, -0.9303044338203035, -0.15659137269598059, -0.2894829365522962, -0.24300459328565033, -0.18772960801101937, 0.16201921187686738, 0.9033765036861084, -0.6189185263631751},
    {-1.3202721587986788, -0.9619157885537456, 1.189851670990344, 1.751871228129379, 0.04276571825018102, 1.639452753746115, -1.2700281718810622, -0.5019582261872095, 1.6515012856684022, -0.7073092522791378, 0.6176877428499459, 2.1170707490735037, 0.05241044128900004, -0.3250832321802624, -1.0436131662560122, -0.08665377563325796},
    {-1.1838556996983403, -1.2117115274609842, 1.6912194819581967, 2.4128464312551876, 0.4771220212789433, 2.0579926557710158, -0.6859300058139123, -0.2571112849313443, 1.8325332557749197, -1.7076071639650598, 0.5788592754635592, 1.3025489123947955, 0.5116684851868079, -0.20029164646351796, -0.6444972625519367, -0.96012989900874},
    {-1.049465990840487, -0.11839685809983998, 1.423801834943472, 1.598792183724856, 0.6173630635158339, 1.7202223462107575, -0.05335393290788804, -0.3154910566481358, 1.1328573744390251, -0.32954608507546335, 0.7779250526247117, 1.2457458012218818, -0.22587697093545842, 0.16033737682633006, -0.40988656008726637, -0.010225309257727229},
    {-0.9244739153513066, -0.2915548746261323, 1.3871101425950394, 1.8002864664111358, 0.4130531352037438, 1.509838344307159, -0.2939274832200875, -0.29028471467686195, 1.5201122727198109, -0.4414128927469853, 1.068126965374558, 1.365467145869352, -0.298920348904709, 0.01806658519356524, -0.10138485369682955, -0.8094467968967881},
    {-0.49137678344312175, -0.05020380655772581, 0.9003323753153828, 1.2830188411074348, 0.3199400059801726, 1.1421982850155736, -0.1712014090964579, 0.19369987689282778, 1.0562276898804157, 0.11594952310939577, 0.89199915432299, 0.877317018511473, -0.1367524156950161, 0.29992747132157555, -0.2437085610980865, -0.12220422488851101},
    {-0.4731112749657566, 0.11659538989626843, 0.9425187685661427, 1.1530231324609888, 0.42183548183699016, 1.3056260264517314, -0.17491149489518545, -0.14262548813540923, 0.9419081372276397, 0.17105812431735337, 0.7390120988548039, 1.006384587547914, -0.0032715491250433965, 0.3591463726604282, 0.07258266032113098, 0.3159450476655714},
    {-0.4835836506666724, 0.5940951410055971, 1.1393210044447717, 1.2514067339821593, 0.46726819951575765, 1.449063018547629, -0.2736186455888938, 0.15396510364671212, 0.8748349389212862, -0.30911547140544515, 0.8026235628966318, 1.0854349824869038, -0.21448509587986372, 0.07633547542525526, -0.3655459108715651, -0.6261143735135536},
    {-0.45941857328312036, 0.10452378399339492, 0.24260400012117994, 0.2554898395802415, -0.2518356068519341, -0.3108657400821816, -0.1548168125683902, 0.6475223043004138, 0.04363635296578461, -0.4232102818993777, 0.058105968965305704, 0.26236399087749585, -0.4410746178033643, -0.12008350885024807, 0.11184444507495288, 0.09765685764616494},
    {-0.5163546670312541, -0.6855196072721795, 0.4417487287907671, 0.888215456764156, -0.589471175883042, 0.053875657661969015, -0.41387019847598006, -0.30860278106148403, 0.23659810190508804, -0.599651514245706, 0.006348735659988455, 0.14351837651587274, -0.45589924481828864, -0.39109359320001, 0.05039646101563626, 0.044776107395604586},
    {-0.03263630165953347, -0.213835225697633, 0.4473270961336823, 0.9368939654328359, 0.06328842402774958, 0.34150706812512693, -0.05365179095151244, -0.24767341316314628, 0.3663881430605884, -0.17671151176294883, 0.20201078317139143, 0.3415425331237413, -0.37223456576658137, -0.21926504132176258, -0.2318509831308085, 0.1691577740260468},
    {0.14071069124250826, 0.007656955139235481, 0.1444836792370469, 0.15787574131303111, -0.47551104879655187, 0.19921983221112688, -0.13585641810616347, 0.028973008759926342, -0.027747043981593052, 0.22998583215937524, -0.2976570767858781, -0.17880297208743187, 0.0836581529676254, 0.16870736747741608, 0.0667636593649321, -0.7465108672801852},
    {-0.31547473134912224, 0.16553523420103308, 0.9737362181895889, 1.2449601099689207, 0.7130763402111477, 0.9795222409696785, -0.031741255849626934, -0.15220514516529082, 0.9997534066454911, -0.3043732515149322, 1.4472002668411288, 0.9323584381370086, -0.0966443040927149, -0.23238133452181953, -0.1201050748869676, -0.18597256629099082},
    {0.23316395235431045, -0.3558831957628516, -0.516569942487063, -0.495049037109875, -0.30982052334595334, -1.2141975078878788, -0.2588635004600046, -0.43277897696928186, -0.5172003745438897, -0.3462045234080638, -0.2245665124920263, -0.39970135122957434, -0.03561415871833345, -0.06838751122755743, 0.3931531461771813, 0.2775019574174685},
    {0.0050298344127021385, -0.05732336484975567, -0.48517207354074404, -0.6373676149850422, -0.25732322497095755, -0.523707421947154, 0.1409945618692184, 0.20701012369170946, -0.3865063767854283, -0.15794486403845456, -0.8713124060898318, -0.3888166027981741, -0.24933985125268998, -0.2217820647963413, 0.170196800119783, -0.2745749658058966},
    {-0.20450202553136593, -0.2152896227621419, -0.5025280469641148, -0.09329496598672951, -0.07044232029471997, -0.19941481829626942, 0.09379924191769523, 0.12475086098626786, 0.4154622459122278, 0.11458553554082028, 0.10188737284250544, 0.041085215264623526, -0.16012481921963245, 0.38898139826163364, 0.08431230320310779, -0.11095563981492836},
    {-0.4963830053077513, -0.06301728867059476, 0.8488548508887576, 1.2256103442789807, 0.6308546445941916, 0.7537216557299579, -0.2767298287154523, -0.26424335679269245, 0.6660239024982307, -0.40607128953052174, 0.9610714884481032, 0.4957283543182844, -0.23366846521084836, 0.11851599303524067, -0.1250799420532211, -0.6537149899621866},
    {0.3982194757674532, -0.0694354932700787, -0.7599180466682665, -0.7715979423179021, -0.4172788566948174, -0.9031079399347658, 0.15128777591673798, 0.3266781684136607, -0.7709038985247896, 0.18837698835544991, -0.5398867649691784, -0.7965954072714976, -0.02264974224666862, 0.2659898780024007, -0.17022245450336326, 0.4284449040484552},
    {-0.3825856998491966, -0.1762861543986319, -0.7646454621955132, -0.9405024206211349, -0.4832527499201636, -0.3888312435515089, 0.0681089388584979, -0.18517654770519387, -0.825849725644402, 0.043828920596799235, 0.5197925939322622, -0.8317228800062428, -0.1516464250684922, 0.4295741165164945, 0.15411039804425183, 0.20801200793657965},
    {0.3950615145299695, 0.11484857861438404, 0.7034940620948302, 0.525701649372021, -0.06164088728559549, -0.03948004964421601, -0.02448931601900234, -0.06472539590417782, 0.21820180297234712, -0.04791708316328744, 0.3730534881345353, 0.12010791181797476, -0.03149732064704287, 0.40054470371572065, -0.07482784446326841, 0.17937800027846346},
    {0.13124664171830894, 0.13153182635553404, -0.20935012563476577, -0.03916479960023267, -0.37398698612187126, -0.25559084912759295, 0.22981846465170536, -0.024116916930681118, -0.513822706365751, 0.07047371278038968, -0.03694024758348585, -0.19839158588252123, -0.1593042775797208, 0.3954493752327757, 0.0454311706678878, 1.101500345329656},
    {0.026864675310562226, 0.0951225113893329, 0.7312568251659086, 0.5571651440870868, 0.41417039497396324, 0.5555244264343953, 0.20823145215111238, 0.11866528663844311, 0.5051042527401322, 0.03201247989762044, 0.9492524550417348, 0.31346991995654877, -0.20751476599773175, 0.27568978370026515, -0.07223668733209002, 0.4002346042483153},
    {0.016900731023695933, 0.043480401102660556, -0.06648819357094521, 0.2609715629525141, 0.3494157411941051, 0.5434636669318158, 0.38594176356774, 0.1620799890252058, 0.2713059648847094, 0.29470631250986756, 1.3665214492832969, 0.049085850159105306, -0.07117303913866321, 0.4590987452903086, 0.2206909359735331, 0.22513769403041858},
    {0.12900566639022829, -0.01230730959367729, 0.3965695486724134, 0.37201137930190575, -0.17271695843394508, 0.3272854449591291, 0.042901926727356425, 0.3746463861666975, 0.27453538407023703, 0.5201699873184941, 0.7465691299742437, 0.04536829236660056, 0.18129014795116521, 0.21561999816093763, -0.12896786706298985, 0.09707377758011386},
    {0.17698112627617424, 0.2230449279746737, 0.2901486436522269, 0.1583664706366365, -0.06224256580435884, -0.07712464449890598, -0.08913018250327029, 0.025699406501697476, 0.02792269515934647, -0.06142603688157842, 0.025637960167392355, -0.08954668744223454, -0.054438527516457315, -0.026353751408055365, -0.08466720063402905, 0.34153173806402254},
    {-0.274202214508654, -0.007407979494961393, -0.1360861094472437, 0.10449106985828373, 0.005937452944632288, 0.17827030092544183, -0.1434485198450918, -0.15419298262460532, 0.07343494190225808, -0.3974403362350195, 0.18561758787884622, 0.017963708421544662, -0.41581673275279557, 0.03585156914558473, -0.13106005454069336, 0.1994884371945341},
    {-0.02236463984721703, -0.4612483430997551, -0.17180691253791724, 0.07566781237729381, 0.14446996360645029, -0.23791185299344936, 0.2552606570925196, 0.1385422780830528, 0.09250476616614799, 0.2787469977209023, 0.7544354943305426, 0.1483559632250162, 0.08251537468679301, -0.32045361598549277, -0.020393014630782767, -0.27786261697583337},
    {-0.20439141650835835, 0.07867214076595012, -0.2689318661478495, -0.36826850073973094, -0.520444071567695, -0.6821654946298872, -0.21338944869986148, 0.11551232335592812, -0.12271239331265615, -0.5029624729719595, -0.6878543811787086, -0.37889545646054607, -0.2968388455535198, -0.25316404947907706, -0.5536175453179747, -0.4421010063574504},
    {-0.24315152662012524, 0.1442961374559205, -0.5870077570376027, -0.46488331626894497, -0.4794250200076901, -0.4138660133395149, -0.35978753694692006, 0.20921691531683428, -0.4230325565046486, -0.22892198955669893, -0.9854213500789905, -0.608730970087944, -0.21683826386086708, -0.04386416519276267, -0.3133181317988965, -0.08226481575279775},
    {0.20096380359659086, 0.46819031848486825, 0.8694721074357885, 0.6063429535842972, 0.31901317748926433, 0.9652797930815029, 0.43804745480510615, 0.16764010479425537, 0.7727298371822399, 0.28396871975867977, 0.8435697212421408, 0.8704575642302267, 0.28903666373367554, 0.5922881217246582, -0.16466312486605744, 0.10136889904659425},
    {0.17128154072932975, -0.0679038566425471, -0.21844734047986955, 0.026293412020317434, -0.18554380317694302, -0.13572471711569772, -0.35773922329409624, -0.13519746128102136, 0.23668303026608015, -0.2267840703711002, 0.029519698375866443, 0.14723497201036756, 0.20333526641906444, 0.04034783131034919, 0.016522393581378678, 0.4158278290061154},
    {0.30802043439018634, -0.028392932301163073, -1.0120787129709587, -1.4305669203037772, -0.18054833386049982, -0.871387487440815, 0.5465791249532478, 0.3274539965358315, -0.5658171385686133, -0.33844387304544077, -0.8337184411145852, -0.8014241628204588, 0.17561801470073513, -0.08248013702561632, 0.030722959535622315, -0.4164771963413373},
    {-0.04217767344251586, 0.11046276455538738, 0.04033660942795712, -0.1348271387566586, -0.5526148006576619, -0.33036992035188334, 0.2010313427229629, -0.08883888174596466, -0.3147569438162995, -0.5395702052000854, -0.7039272949321094, -0.24040482954092465, -0.13846383804960466, -0.2947879562504772, 0.034923820189158, -0.012166728338339625},
    {-0.5916618207401714, 0.2378559114685656, 0.5610167856659231, 0.5716354619447416, -0.23868898676010905, 0.09121816904727945, 0.005877612371621614, -0.16263923967995925, -0.1836082644120132, -0.394927658839147, -0.37483965418756426, 0.005902823189322847, -0.11380768984524044, -0.08653670099365308, -0.12984798437709727, 0.23157779007308882},
    {0.08423234568939365, 0.09915445721100728, 0.6803803003243003, 1.0478801764394932, 0.4080614062086926, 0.6424830207415775, -0.07387947235128757, 0.1774242286902552, 0.7239013441342479, 0.09121702454886632, 0.6754159962689139, 0.7671075501858513, 0.07720052011677042, -0.08636314892479575, 0.12259681063818612, 0.09145477835376843},
    {0.16925297031037967, 0.1804976837005772, -0.2383626693836583, -0.3112364376639691, -0.4626157487538038, -0.45088505331101175, 0.16949972520572698, 0.06945612827027044, -0.5879496290496732, -0.13346349805998048, 0.2380414136303624, -0.5460416722535458, 0.01856060088273025, -0.010972435273222593, 0.22315260105437304, 0.28947344743186326},
    {-0.11612229397506522, -0.0900382829448858, 0.4411057181689781, 0.061281842278667606, 0.04971666967857506, 0.05505614192379562, 0.1273208980236161, 0.24020654038373287, 0.035883589136963184, 0.3570647259057257, 0.5407968756194109, 0.09488647347911854, 0.03085260039014788, -0.020971894173585408, 0.3492850490804079, 0.24324123907951883},
    {0.14347461015642768, 0.4249158455199405, -0.16887120052254342, 0.2905934290947825, 0.5421317594011571, 0.26520382686467336, 0.1366777793810948, -0.08335324593971434, 0.17556855544126843, 0.3720460436748436, 0.9841542040219371, -0.11004653547920319, 0.19133071213448252, 0.6082825211655112, 0.675724250115626, 0.2817286379700486},
    {0.13642687476105247, -0.15372005158319021, -0.1459193260116639, -0.4714541958128306, -0.0028388513626325263, -0.33932142781980307, -0.174380698100427, -0.25337048741574436, -0.2780967946089764, -0.008629979925881846, 0.10765454924613145, -0.36990154313615703, -0.04432902003500927, -0.06286861457706795, 0.3696826307768589, 0.31088967596772293},
    {0.20985687802317354, -0.11909713525255367, -0.3583202071654215, 0.05962964315467637, -0.7274427412630287, -0.5410105466459751, 0.2452915040303608, 0.010948052472104066, -0.11781340271422282, 0.44196843906531813, -0.42008953473215893, -0.5411829995609565, 0.023525523400287456, -0.4139459415687344, 0.022849211764003726, 0.45321303436319116},
    {0.37352806775606, -0.02182516041137887, 0.3669284639053302, 0.48177803306002276, 0.43853920117534706, 0.3330867433343452, 0.35298848704180136, 0.3547939707259674, 0.3061896789712188, 0.32404951721086034, -0.06297853985955966, 0.5385533684164572, 0.2077846827757601, 0.007688104398405932, -0.1423684212625927, 0.41540585929860213},
    {0.3938522344235138, -0.05610172196395431, 0.38615197320220557, 0.49296997305488277, 0.7001261962270686, 0.30545332890423177, 0.12428796543512989, 0.27238573165557584, 0.47824865239891556, 0.09241908779103788, 0.21815359234178028, 0.3169346775518469, -0.07481368572051669, -0.14167799555162952, 0.39570686884817075, 0.10762117633077},
    {-0.4241315430936608, -0.037988977350545995, 0.5744435673255278, 0.5922520888046636, 0.7027658226513039, 0.6228359536629933, -0.2133251837991133, 0.05621801785879854, 0.5013476764666261, -0.4168821824851057, 0.5708562135961157, 0.2145605795834561, 0.3887910266047639, 0.39839136131174124, -0.20286632441448202, -0.28260206835188334},
    {-0.12846931963392932, -0.4443521564488618, -0.36297651218672167, -0.3137420235598448, -0.17375144284081748, -0.1897620189179576, 0.02046947903239555, 0.17469256151467602, -0.15251304036121527, 0.02852368809496493, -0.6613447577704455, -0.4886636604349796, 0.23917994024550335, 0.2370532107054045, 0.30841019104341466, -0.20055039455690013},
    {-0.42128359555826445, -0.2043111048664393, -0.14387465598079632, -0.21772372691280875, 0.11966159300907672, 0.2680867697906667, -0.22512877383278854, -0.18077691063788717, 0.30732365328456396, -0.5469000279685324, -0.3634350536245797, 0.08413427251222483, -0.26510105086825136, -0.6253523374961251, -0.4701446377738849, -0.2994833327951273},
    {0.06310743548995817, 0.04811777765525681, -0.6122380012284733, -0.5947003794133746, -0.28188403524004774, -0.5429506259986314, 0.035735255475120034, -0.2421583582373368, -0.49870932649153155, -0.3751949092750768, -0.7448449858863726, -0.28483319222138354, 0.18498542664128959, -0.44097194349970364, -0.35057142504704303, -0.21532439424437108},
    {0.07819727228377195, 0.24471582150514318, 0.3194035825585455, 1.100104341443302, 0.39480568035561603, 0.4989053230348705, -0.41368616887008547, -0.06341901744440809, 0.5607595137133617, -0.04744770687867006, 0.22139183318173583, 0.543553384796369, -0.00886107114810764, 0.3734465626479299, 0.017365866812757626, 0.011326060981895519},
    {-0.23361642361793497, 0.009970530567923906, 0.2218865647807143, 0.20180672583303694, -0.13691519349956524, 0.2492523534677282, 0.0939104343781122, 0.1956717582851722, 0.19169557526105366, 0.5258489908821156, -0.0016619018910116212, 0.29903732841814706, -0.2701189028129493, -0.10471851092505968, -0.25154658477706965, -0.3286257164963267},
    {0.07240811111564856, -0.3615245994254606, 0.5990677290726049, 0.48702645761624613, -0.30124386235267214, 0.23306123951983443, 0.10609731208241216, 0.02153524040373685, 0.348766069039779, 0.02904778041871445, 0.3908805042814499, 0.37468881351200856, -0.14656859932700195, -0.5330100015987799, -0.41780648806119114, 0.1509556339890046},
    {-0.11484539820401346, -0.14734890143699295, 0.13466737846460977, -0.3058854219272359, 0.011109447149595938, -0.17745812308727937, 0.10315262448073288, -0.2307658426428936, 0.11798395155179213, -0.06975282223187021, -0.28040358457753783, -0.09361057807569119, -0.0803965329247577, -0.3871242490072494, -0.47267895651969516, 0.10134287276241587},
    {-0.13710850288988724, -0.05408971253034223, 0.6957235755651024, 1.4650428339927881, 0.42397948451522444, 0.9464753344380725, 0.04591404688142049, 0.18922886187490826, 0.5771148467150231, -0.14545282962469902, 1.0710548240171678, 0.8162096592902496, -0.21417093350948435, 0.01251537879694612, -0.13538032558004318, 0.10350046679095906},
    {0.19130534932454407, 0.26045978743415127, 1.1644859653997424, 1.3108969951646383, 0.436427534816447, 1.1048654136476137, 0.07431918765905793, 0.027030292097211934, 0.7159319949961361, -0.20793723969931419, 0.7395432234068378, 0.854096208714151, 0.06878806666659276, -0.08946150275302346, 0.10142543205128675, -0.2587237147277171},
    {-0.29927486034211775, -0.04639303879859318, -0.07909397566971625, 0.07163552192002111, -0.3511320557956001, -0.02368263675275081, -0.26374838272487167, 0.01912776543668756, 0.08632947000558616, -0.1511733206907352, -0.20126225788943133, 0.1453321729277551, 0.1282704729778816, -0.07215715761364483, 0.20791944830144093, -0.09720641262873737},
    {-0.44054505390076854, -0.1308885153544316, 0.44519129855534173, 0.4111805932552935, 0.570941264043867, 0.5147781465887471, -0.1058600510529955, -0.21671344409200943, 0.7657857046833816, -0.13752360850143125, 0.7808119048964812, 0.5931546018977153, 0.02170529591797876, -0.016855874927720945, -0.08713506165848624, -0.12693623532949394},
    {0.15450750138431504, 0.19029627640058966, 0.7290336209597664, 0.21131732198873407, 0.19294514322057005, 0.39946148389404257, 0.0791912025304931, 0.11844115625571934, 0.16910046551576915, 0.6278203641260386, 0.4428236650227721, 0.2764681070029575, -0.08052212614710624, -0.04051965641359295, -0.026046230743986893, 0.3186570909705595},
    {-0.031413046277077146, 0.09228159754869075, 0.6509192370891425, 0.5204555109316092, 0.21103825573909332, 0.4373465803919076, 0.2730942068958642, -0.20357216387238114, 0.35647928873519613, -0.22967908435355372, 0.43517262086961356, 0.7295324422714758, 0.14929235965315094, 0.047943190878430055, -0.011336188281709757, -0.19256953762462084},
    {-0.9645489687855527, -0.38949543017014987, 0.18514267228916587, -0.10258420672434147, 0.13381750773418843, 0.5113867176972237, -0.19754384655706592, -0.07962580855837825, -0.026659512687130855, -0.7716320407345488, -0.007909142146747707, 0.08293663579948514, -0.1507718372031503, -0.1762437530096438, -0.5111986413949028, -0.04398441330209688},
    {-0.24272580056271773, -0.15240978465274252, 0.24932562633167604, 0.1788418004587019, 0.3276012330935021, 0.045721297153686946, -0.04378471618752483, -0.02521159791305512, -0.10783185681877068, 0.22504688915094895, 0.14053518105891832, -0.01430836760603858, -0.09667407042815647, -0.06274369290756193, 0.17591953775209407, -0.07125214465201946},
    {0.3866365104826057, 0.19638865562237767, -0.2151395346361701, -0.08108086393532198, -0.04839404360476683, 0.05053075033065502, 0.3500526380680049, 0.46576676989414717, -0.019336048116003594, 0.16254436664687164, -0.17936969192574623, -0.2461097127631972, 0.07356102446088691, 0.3365901425674637, 0.10476158509542348, 0.7758364648487467},
    {-0.2502779820712886, -0.19401046437507707, -0.4056956192258602, 0.05540676558647199, 0.03923325749509541, -0.39638016515758107, -0.015068301437053311, 0.15554948136108235, -0.2863538079510338, -0.12727361726815548, -0.5610711789915966, -0.5407849208114177, -0.03759117752940599, 0.05981755072977369, -0.11007113056705185, -0.008911724102745718},
    {-0.49322937132631384, 0.1174034122356881, 0.11847036369363707, -0.09398979300202523, 0.30792378384207814, 0.41827229943371064, -0.12967450375878709, -0.013275957540038366, -0.18627011056732382, 0.026478662496898033, 0.06826390801660438, 0.10404447026401556, 0.18505248197490565, 0.35894186947542245, 0.18908900400734824, -0.43960158159269774},
    {-0.41373577888030727, -0.2674126539806018, 1.5459757981816882, 2.0642626005931386, 0.3779486028078213, 2.0644576250241236, -0.682596271626463, -0.798269292678219, 2.1523706630442043, 0.1667595830988021, 0.7726060437584725, 1.8603019334536648, 0.5031738627995234, -0.668356773806715, -1.0660889021257256, -0.15431400242333362},
    {-0.7481823751192886, -0.4188061824765351, 1.8346205837080896, 2.1408652563072548, 1.0154101002615255, 2.206244724631277, -0.7234525635835285, -1.0458515820065137, 2.2104888101218982, -0.9684366326370357, 0.13096916896024796, 1.3879011578150882, 0.8481280781113668, -0.6940399975669688, -0.9483674439760494, -1.7660834953044786},
    {-0.7101066478734146, 0.05905472260797767, 1.2819420617806374, 1.536572191152535, 0.8197065039394237, 1.429232088866611, -0.21411261931076883, -0.17546400430364037, 1.143516237013694, -1.087608004836705, 0.316653150055408, 1.4990552605754204, -0.11813517884663387, -0.37654584713578987, -0.1196429484462644, -0.3702116995820465},
    {-0.8533174430044512, -0.1956238122413078, 1.4485061366440213, 2.044501825717609, 1.0206897571130435, 1.8722874530423494, -0.28926097420148605, -0.28746487749548, 1.507181956439622, -0.32497161277284026, 1.015147567894833, 1.4886730716303147, 0.046634644704147556, 0.06745153965062921, -0.18630410950619802, -0.3325080188506855},
    {0.1291125468934595, 0.1439540938112039, 0.7582735399645343, 1.1810648109716575, 0.6578344994102228, 1.0909875022856292, 0.15079422395512085, -0.2711965490894407, 0.9035847261111831, 0.050531114554026445, 0.718395106896635, 0.9854874864712304, -0.06419674545941356, -0.14296057601192105, 0.13065870770012605, 0.07557772831910275},
    {-0.26183568570673116, 0.23243776928296972, 0.8183534987749765, 1.1264219821826473, 0.3228070778493594, 1.5661015820469728, -0.17518132260150657, -0.12398892571416543, 0.965868770184725, 0.20490297123392812, 0.703763679224742, 1.0660048289573922, 0.041058950579374545, 0.1748990125105779, -0.2249452620640075, -0.03560402346673432},
    {0.04786948696622511, 0.5402059683448621, 0.146203646088441, 0.5275672288852218, 0.18508234899127685, 0.41589041248374053, -0.4062007837007487, -0.0761340181548308, 0.484276979349024, -0.22332265184425276, 0.3645024725806547, 0.372895693494212, 0.21928858044560023, 0.43514611506575235, 0.240882602879275, -0.6492089231338628},
    {0.2645059328252677, -0.07035989766860233, 0.06636147162859297, 0.45812080875807293, -0.20588737483462674, -0.17028409638931571, 0.17015901365043673, 0.0016363170580188052, 0.006917015775921431, -0.04158893942832766, -0.11935620646846325, 0.3294809915781797, 0.04467701345523527, -0.2036459634110649, -0.11719649603324366, 0.2120982216107721},
    {-0.12761635407481717, -0.03637855439498325, 0.6814588697242394, 1.0465856328124357, -0.0839214135980732, 0.9063188728474898, -0.22765023306316193, -0.7851382794530355, 0.826875988034551, -0.4150194352306422, 0.19706557437397204, 0.48819848267858457, -0.3589349877066169, -0.5320590333424572, -0.3953595461813003, 0.010304190663286878},
    {0.28532750713994504, 0.26844427212649824, 0.6684931017022377, 0.8003368149565002, 0.42458310502363417, 0.7827958245372504, 0.1705251290520331, 0.06445618922828891, 0.9361120246809226, 0.3287195774042576, 0.9367931352780621, 0.9442936933182785, 0.35762500782957657, 0.028312969624314253, 0.11101712842192751, -0.2428466169800996},
    {-0.4352397849263153, -0.424703349323005, -0.1423067959826901, -0.49577197164935066, -0.3078658723191406, -0.37760359861234166, -0.4057548276310858, 0.1380191858649589, -0.41414272271553526, -0.006210046286050896, -0.3769213346513626, 0.05988391132226689, -0.06203379135535351, 0.036927569666898155, -0.4489132030146949, -0.5102005426038253},
    {0.04225082707651972, 0.028537636970644986, 0.5474714497523505, 1.0270140545022972, 0.9130636880899089, 0.9273262829708595, -0.17480788662260036, 0.18295676301168948, 0.9317964192021344, 0.13038562002503154, 1.2107743106158853, 0.4850365971158162, -0.0077284241516946284, 0.16025820468036503, -0.0734504698601077, -0.2933045944516317},
    {0.06887653050172192, 0.10183720824613728, 0.7369478757802874, 0.5464613105696176, 0.14207704487893646, 0.7614407646070952, 0.026466881228059205, -0.09870455407144384, 0.5571782516062181, 0.23060705438415863, 0.7911793713328846, 0.6777354201835748, 0.17993648759970413, -0.19976154459034545, -0.07020665125955247, 0.09472723490263617},
    {-0.41146491698956655, -0.17720841004313986, 0.15451799612352002, 0.17513845411178183, 0.5436774895452381, 0.3934573735445706, -0.14795919356732293, -0.309717377546692, 0.13817620210943027, -0.15711131715661175, -0.6083484360142845, 0.2805873094260582, -0.1641103988382801, -0.28068075666225584, -0.2838481553051488, 0.07990329812097015},
    {-0.20160064367224295, 0.054327072757876634, -0.39097344933688916, -0.41266841659638726, 0.2914518134764988, -0.13687182580025078, -0.2410322231628682, -0.665923610398294, -0.17564957832922398, -0.2426587217860705, -0.6388524828850876, -0.11024924316822814, -0.17825512495587734, -0.14723092231769863, -0.016394494421946633, -0.37479766330800807},
    {-0.34706184505561233, -0.26772672224212024, 0.30172482439032383, 0.7274147527823376, 0.38994405277719174, 0.6533131754164324, -0.10747501979060757, -0.5384272214187896, 0.27167906212712706, -0.4451847696440726, 0.35668103691275205, 0.5098144587163755, 0.1880572387228362, -0.23444122952072227, -0.3157181604795987, -0.058089322734649035},
    {0.4605075737509837, -0.08520625898065923, -0.39878513902328716, -0.6233303678318145, -0.3281455152707196, -0.784195608856883, 0.08090582981023278, 0.18308724899341677, -0.41760162499394254, 0.24042687742235694, -1.12972513746202, -0.5257114236792907, -0.027475666108571585, -0.30300844125304516, 0.01986180634673889, -0.03510328840843262},
    {-0.19433325773131854, -0.40138694322650803, -0.3163880184966316, -0.5330837051202125, -0.36195811211119605, -0.40491928582044306, -0.5433631649473227, -0.8690717914468058, -0.24010462221054704, -0.02387176499325969, -0.02353707751117513, -0.6775010596204604, -0.23403558854666554, -0.6376654981434048, -0.04935689979470437, -0.6492295929576258},
    {0.27496446427347454, 0.15994973749435318, 0.3985101869511866, 0.08125435215351955, 0.14111382220233698, 0.6178416278307167, -0.1056298825787671, -0.274270697398783, 0.41099472801667775, 0.2803883753316265, 0.6873637416952469, 0.5265064893509893, 0.4288409802580885, 0.15640963303230168, 0.3730973444580784, -0.2948006523605462},
    {-0.23644738951581876, -0.3890392196342054, -0.07347769190837461, -0.1299615065157678, -0.13189623454509863, -0.3737700918127288, -0.2608894869873235, -0.38404027661069734, -0.17729143434588218, 0.20104482375430224, -0.1507473912775014, -0.2975022844956169, -0.20270575584622513, -0.12170946562112385, -0.11381619803630444, -0.16908012096816497},
    {-0.12891438827835638, 0.004114038932002782, 0.7809859559028217, 0.9002100976627082, 0.5980810930199273, 1.004935846600567, -0.14711230340399542, -0.016611844821650897, 0.6790429441331524, 0.18615858855851472, 0.8949264640998573, 0.7434573432501261, 0.15692423098111433, -0.07712001066054602, 0.06823864656210205, -0.06379696460162947},
    {-0.16317129141674516, 0.004550056809207035, 0.59740059109382, 0.4406645144486405, 0.6299489277529546, 0.6525518374150812, -0.22265263455625003, 0.029702150590017642, 0.5080814421841937, -0.1361877289129654, 0.38847042761830836, 0.571885593049398, 0.025240971997104587, -0.06770041097835901, 0.10433285507190136, -0.29235791364149905},
    {0.22673296128492434, 0.18566975400067676, 0.25429855404212476, 0.8711027916675722, 0.018580198632267588, 0.39991567728241983, 0.05189379969769852, -0.08043966199507302, 0.4424544411926261, 0.14222549491980643, 0.42294458037568744, 0.44834515172250866, -0.29855639740616013, -0.11999873788856205, -0.1603837713032296, -0.09446732737771359},
    {0.07097159759853107, -0.04535697013693235, 0.718836052426104, 1.0242574602805674, 0.22904613822568948, 0.5072958779620282, 0.12055866011922474, 0.27777630562450584, 0.44788396868285457, 0.0880693040987484, 0.22956459549722663, 0.3788962643862474, 0.23527697532521982, 0.1455906273056194, -0.18690681358776656, -0.314085398411744},
    {-0.3363651249516424, -0.2203090801783548, -0.20879722104544696, -0.3504875198084195, 0.4309464334337033, -0.13917840284404628, -0.3923693898042292, -0.35495898088178834, -0.08807302760885671, -0.4313293213747475, -0.4457632892524494, -0.005474210484220926, -0.022433287766379175, 0.029992550408313993, -0.43913760816491754, -0.4305227717411141},
    {-0.14766662465528096, -0.18966438796691584, -0.34140294997367066, -0.6533719720383544, -0.5092479231380141, -0.18013499422674248, -0.14355970824956363, -0.15976990668599236, -0.5775897385006956, 0.25153631391376463, 0.07146010930331265, -0.4411960368989448, -0.04105640244969269, -0.3993304230876528, -0.13796112852280185, -0.3738211904294785},
    {0.45323925953792565, -0.2037994429870908, 0.11158374082673714, 0.023117384279101597, -0.41235225521888114, -0.030171590482627998, -0.24456228068375108, -0.2320135724381666, -0.31147980467228653, -0.06045718213400156, -0.24431701525715982, 0.22235968181767257, 0.21265563894409886, -0.15519465635611615, -0.03767718046375001, -0.18847619539618568},
    {-0.7115389387829787, -0.3971338216005854, -0.7258972227441831, -0.5950770319339826, -0.2529900623567473, -0.7395509873640259, -0.47864717290076897, -0.2644912489595871, -0.3365740288039186, -0.2075996579415652, -1.342000103980118, -0.30500892682316416, -0.3956617355098784, 0.14619354735749787, -0.30912437106383855, -0.7516319638637688},
    {-0.12325661391882546, 0.28532163563981855, 0.16592145010355425, 0.013193832918648497, 0.10196498530197969, 0.38332380842741787, -0.1334795914647778, -0.014820067084132032, 0.1045507176177039, 0.442955182443736, 0.4956966925856129, 0.04342443174528659, 0.09721591395238079, 0.027434962496693405, 0.2441484206217236, -0.28221646959998187},
    {0.14731615343443213, 0.27209705675396845, 0.4151805913757649, -0.17190934204838382, 0.11015808233765415, 0.040591081086885375, 0.1745317884281376, -0.13355318066845576, 0.14774850780472928, -0.21995050272573774, 0.2584029829235534, -0.23514895608059566, -0.04410398899910183, -0.0635003852773536, -0.19061159203490932, -0.15291721961304702}
};

static const float b1[16] = {2.037129432980985, 1.8285104361435562, 2.015927303795277, 3.01683387478041, 2.51576657647561, 3.023003830480577, 1.7475028216181399, 1.613186857401778, 2.0996441035846787, 1.8929824711546979, 2.536649628172527, 2.981461073732966, 0.6400755492135121, 1.9989847969565093, 1.5697700168566646, 1.704444918423572};

static const float w2[16][12] = {
    {-1.9187229282462313, -1.515251437137045, -0.9561882412964999, -1.1357846124271342, -1.2079934288340926, -0.5439036678926733, -1.007511401132246, 0.18674320867282337, -1.267993549935972, -1.7030039329328626, -1.4905646465455473, -0.7854616980025644},
    {0.05213015527025857, -1.0437817780915843, -1.3045836981761751, -1.7683601252424024, -0.8452473026644458, -0.6751168488625008, -2.2723104108530516, -1.5272439567901268, -1.6819949729017933, -0.13003816965702736, -1.6549719823500824, -1.410436366348844},
    {-1.0299806240934575, -2.28082565103821, -1.452688374606582, -0.6479751822759198, -1.8199935342853057, -1.1735625756083092, -2.105164651869135, -2.0830431540456047, -1.5441150774369385, -2.1593792125637514, -0.5759779490293614, -0.8800341562008208},
    {-2.2350830069640737, -2.169554230976603, -2.0129408469066337, -1.53396521153704, -1.3996063726217778, -1.958263557182549, -1.2083275090220598, -1.59225981137959, -0.7552950907975586, -1.3442588274042766, -2.2925624611165105, -1.3048863793185226},
    {-0.9411846923858211, -1.935439311562423, -1.3667429469429992, -0.7137347510556612, -1.1903338749634411, -1.8436313676442693, -1.9687708091826506, -1.6373929205211855, -0.7587940002126535, -2.3593072934287997, -0.9680824713679467, -1.6847939859855385},
    {-1.5171756514718193, -1.065687039417523, -2.662894843558725, -1.701851177960638, -1.4534802627865349, -2.4404212652366892, -2.3242066457670205, -0.49347072093353533, -2.040565889838767, -0.9674601795264505, -1.347699322795976, -2.278755742910321},
    {-0.7272808499628146, -1.0344966744401556, -2.695676542533398, -0.30370346947414495, -0.1489622841463689, -0.47800678154496923, -1.042087857239761, -1.9508536463451454, -1.1683299423934945, -1.3849747108794264, -1.5689495848054835, -0.7178567167364195},
    {-1.811557012279544, -1.3389993376830787, -0.13940367947981028, -1.5660893232211628, -1.0869756034803768, -1.6081088868040891, -0.06313002806714259, -1.6908671063470289, -0.8665889565815673, -0.14671869944395854, -0.9287034034492357, -1.5685841074475189},
    {-1.3744165018884016, -1.7895425401317804, -1.675903257653176, -1.8635560975142662, -1.9932554540225527, 0.08077418690579985, -0.9278922442741702, -1.6815997557699363, -2.2092976313898993, -1.7490179834665398, -2.353361644258004, -1.6152260316019016},
    {-0.4866917518469062, -0.8143169249771897, -1.2432995373754396, -0.9121117388257088, -1.264493450886364, -1.6648838016586085, -2.417034774724713, -0.9144826046741197, -1.1662875198382392, -1.286771562662232, -0.027230723988991883, -0.9799609749673805},
    {-1.635065812273521, -1.3990096583833245, -1.2231679459152902, -1.8150040749590755, -1.2654137779032202, -1.616018159339142, -0.8920980085659103, -1.6010206273280025, -1.6996426910016549, -1.1777933639358178, -1.5347856791766912, -1.1654564311068798},
    {-2.0045287662389155, -0.6496004437525206, -0.17470016405078512, -2.381180313452489, -1.6053917911132962, -1.9710538347269524, -1.6646598728270525, -2.2187458807053466, -1.9129164140720663, -1.8980157251873375, -1.4306972262695692, -1.9641625992051657},
    {-0.15729212564177514, 0.9588740759544622, -1.0730792586431879, -1.110084467303224, -2.3220581398000553, -0.14641347700892124, -0.36386249403611765, -1.5240594306062003, 0.3714361061640767, -1.2929299936272585, -1.4008920929550677, -1.0767366774167748},
    {-2.1718956308779207, -1.4294986532365148, -1.5314439383918421, -1.0070147618634622, -0.6396274388241853, -1.2660477696369659, -0.649716254059104, -1.1707295741100194, -2.0614300364570615, -1.4804594948897918, -0.8798923205407541, 0.5012685335862129},
    {-1.591830508216609, -1.564076336602364, -0.3136718650990702, -0.16283526469740764, -0.8544037270752156, -0.9070589728092316, -1.1023469675105793, -0.7645169911602128, -1.0247927081301602, -0.5923304521984653, -1.3829248121669067, -2.302713369458923},
    {-0.7797062904897738, -0.7529430212611125, -1.2868542880957023, -1.6935201674855846, -0.818878848072195, -1.201402252982388, -0.5652699699830285, -1.157554688549257, -1.3894406581668732, -0.9423681279709739, -1.4929376195249602, -1.3001640930741125}
};

static const float b2[12] = {-1.2487450849168649, -1.1722811047809223, -0.4624408167933475, -1.2369611851805553, -1.4470142236011634, -0.655685551238633, -1.0512330085942296, -1.122354891026535, -0.6840652902659778, -1.0411523848023143, -0.6716756722218274, -0.7320425506272166};

    // Input Layer 
    float z1[16];
    for (int i = 0; i < 16; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Output Layer
    float z2[12];
    for (int k = 0; k < 12; k++)
    {
        z2[k] = b2[k];
        for (int j = 0; j < 16; j++)
        {
            z2[k] += z1[j] * w2[j][k];
        }
    }
    softmax(z2, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
