#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][64] = {
    {0.34742040816993264, -0.13415318534184068, -0.48214475209291763, 0.40448675086806885, -0.08971256268809884, -0.45019031406799714, 0.5519461380796546, 0.5552443596166932, 0.6042941648503372, 0.5565424103282242, 0.2268514116261923, -0.48830990448478634, 0.13677038594949273, -0.38618583313561583, 0.49974238131849497, 0.5639239301093405, -0.004823027974823529, 0.5457041477639079, 0.6428618559356386, 0.03273108069039234, -0.37094991092608853, -0.32512327166637955, 0.4964895516964491, -0.2038701825289733, -0.17611275193590692, 0.17330590095264464, -0.1908106925153657, 0.1300031175328292, -0.03404281283947624, -0.21593505243577252, -0.35133060909438285, -0.09297949517751732, 0.11555508769607242, -0.22249275297975354, 0.4593016045687998, 0.09537104943907171, 0.2833555087959976, -0.39960390548631264, -0.38722045561172713, -0.17527809113280063, -0.1849669606090016, -0.3519306110947129, 0.07427915655468963, 0.3406839690947592, -0.28341840452614525, 0.3000032603168269, -0.06046320139193384, 0.19964856780317977, -0.033707648711531, -0.48854155309965747, -0.06957803877276106, 0.4873016522251746, -0.454521767026466, 0.49950295536699046, -0.0617165113883158, 0.42447663036247785, -0.1916713047038957, 0.2504696530128249, -0.01852589933297349, 0.3895061662085584, 0.34084059397130023, -0.4680585122259821, 0.055141878308878386, 0.052777270039582665},
    {0.6703326872222879, -0.08066910690967179, -0.4658938891891746, 0.402626346527149, -0.48759731353146263, -0.6191979038064614, 0.3922762010408408, 0.4818687175375008, 0.6741417813312789, 0.09292630974893311, 0.4966965060844791, -0.5618318126715179, 0.4489059266408148, -0.6848790286944606, 0.4321343693888059, 0.36886597039616154, 0.25247910387666395, 0.3969012572829978, 0.26814579049825066, -0.5810353770543152, -0.2986178638271754, -0.13577303878759905, 0.5179983890627938, -0.3707908678452668, -0.6597605492489683, 0.28909877458715183, -0.12143968189246857, -0.18206754730736563, -0.12127449769708333, -0.31766738145412515, -0.5950223411466073, -0.6946723260386182, 0.30808200930082125, -0.09819100000374667, 0.4032467270334434, 0.07649804811897967, 0.3886422970298297, -0.549417668855772, -0.328401107629296, 0.14381529512519747, -0.4029897755728363, -0.16474240992938677, -0.040937148701510856, 0.23580357684066433, -0.4643966119894703, 0.44182410056783844, -0.0744876767299917, 0.1981489283541152, -0.3618240106368761, -0.40546995782995277, -0.38856171772266695, 0.6606315520855823, -0.7077647665685011, 0.25603907745078186, 0.2232790062198989, 0.5631430756545976, 0.028693036942139986, 0.5009080695179299, -0.3835551790213224, 0.5996399668046504, 0.20806651287894248, -0.42726216035039527, -0.016638236790883627, 0.48064321794639386},
    {0.6263620102530498, -0.34907597007792823, -0.5340575596554792, 0.4885073329251228, -0.5532061988004027, -0.4257941909034049, 0.5615399922408877, 0.6773486990465608, 0.6498034386779579, 0.4066063792208879, 0.38427274811589196, -0.6043211571488604, 0.525406830864174, -0.5375222461875983, 0.6558105983235935, 0.36245326600221095, 0.2719958970844217, 0.7294893819992444, 0.6393102138575784, -0.4157309632608205, -0.2705074314671705, -0.00024981828492192965, 0.40904616689502044, -0.35871540623894044, -0.5669866294151128, 0.13756848780593975, -0.10162401595644512, -0.056502418981979205, -0.2955332008319994, -0.3834307897145596, -0.5310305203013224, -0.3656491263729556, 0.1771868560558892, -0.23148610926678867, 0.5745397942767106, 0.014906867473620963, 0.6428006543245234, -0.5804253214473938, -0.3136212896755818, 0.06724246638641103, -0.47936489012443356, -0.2961199371129681, -0.21434164285949817, 0.4091539489272498, -0.28619796511417817, 0.6995898758712689, 0.004885190564819552, 0.3248038815398249, -0.11141269360683134, -0.2635488966759659, -0.4318443710280472, 0.6507232265285061, -0.6414548807643328, 0.4980642391751399, 0.28495308580539686, 0.3890674360438629, 0.15359391127512925, 0.34975825154572887, -0.3357264429743223, 0.6799527181910302, 0.40913510268154435, -0.1594269105173392, -0.09585868082147583, 0.583874327946484},
    {0.3158823386459052, -0.366318092261058, -0.5927271120459529, 0.17322265389646407, -0.6804016237435412, -0.5985176986786, 0.34791861611996644, 0.4542298321443491, 0.35723250380594695, 0.44470949306061663, 0.492959914739583, -0.4752002189867787, 0.40922484643917895, -0.6057867593987185, 0.7645266611175447, 0.5122063667238343, -0.23746698122317408, 0.615873724918845, 0.43135844068912454, -0.45452726998912635, -0.6151841003983946, -0.3091153201669768, 0.3395592605203081, -0.6763404673814298, -0.5488628765954875, 0.0026191478977338725, -0.4582999090407165, -0.5283055444003716, -0.4044677318723733, -0.6881294182433332, -0.6908108450904777, -0.46897628729686713, -0.25670849609371094, -0.6870251699042185, 0.5457681086384675, -0.37854197051947747, 0.6904754814395591, -0.5112886911382086, -0.44573009382357026, -0.21927242769209862, -0.5392549775143142, -0.3092003163817634, -0.4705929014189274, 0.5360723163511779, -0.6512430807241505, 0.5803536346592153, -0.1324959173125507, -0.20411993837593623, -0.5742404503763231, -0.5481708691870465, -0.5019393642276511, 0.5152901289056441, -0.4993168356082758, 0.38900523458292297, 0.031516946765805035, 0.4187218927350645, -0.21343379467827434, 0.5181062232801233, -0.5497528841105048, 0.6909745159611933, 0.37806162831838247, -0.5780454619184546, -0.18545897643452253, 0.2630679871075622},
    {0.2917736931193578, -0.4035259470077056, -0.5479962250533779, 0.19332311491838836, -0.37430478116703186, -0.725306282464111, 0.18511315179571852, 0.6377086673961098, 0.5747331685618976, 0.40803214389392334, 0.13381347265585777, -0.8043702299055759, 0.34116656640800563, -0.7557306540668561, 0.5909787557983052, 0.4050504761711425, -0.2710862455800442, 0.2393082082485753, 0.20486725557920316, -0.43806923073849324, -0.6085427750966348, -0.37020417603847044, 0.4594735885782212, -0.42497369649833033, -0.8103206116296366, -0.035885707968870584, -0.7285575011433343, -0.3988464998902103, -0.4596774810788495, -0.49545535325991247, -0.6542325782687545, -0.5488926078989657, -0.1959416039325536, -0.680888894598184, 0.4122324021603945, -0.5533703661773837, 0.5489563841900074, -0.7109606750044637, -0.619222324741777, -0.2524401102071392, -0.6878290171527477, -0.6695116845999884, -0.6682544361711361, 0.5738339153235094, -0.6851347040637747, 0.3212089400179129, -0.2592892844995166, -0.12370926162659286, -0.7301429350360535, -0.6148294285769869, -0.7266211265152822, 0.5261554023762046, -0.5797198253860125, 0.14350075139057603, -0.16538601452592297, 0.3416753617882346, -0.28030836647273044, 0.5751373359891184, -0.5753924514397487, 0.6792015570945953, 0.24871731810476588, -0.5910522411949987, -0.5349236926431897, -0.11898435563451856},
    {0.11187044148374131, -0.44864439323954414, -0.6248660744675856, 0.24350936052619157, -0.3592828372347374, -0.4363063940648217, 0.36829175603290726, 0.296132269625093, 0.13873837828319277, 0.25302015009148615, 0.02384232042800573, -0.7237644391937207, 0.38905371424974056, -0.49029825332920873, 0.5652748787198134, 0.47130671466392177, -0.2238873111031281, 0.3211496499968561, -0.0004604453127362748, -0.4584373215444627, -0.4198534912419135, -0.44022187862178486, 0.17375835710823107, -0.42617367237762177, -0.789088944469187, -0.03143447756657389, -0.6030933003255982, -0.3234749019682648, -0.6757516872026228, -0.5511670386807663, -0.4236859475895973, -0.4369453074010492, -0.23323696666681215, -0.6755331028147888, 0.18682294909522582, -0.5893107798492873, 0.6048237973646186, -0.686288365108063, -0.424929765542994, -0.6560525419855646, -0.5586440431416988, -0.544262113271201, -0.6576149033756317, 0.23288022078393825, -0.4712560640880813, 0.3109078460514376, -0.5096104468201185, -0.31585107232599074, -0.5877037554806799, -0.7290872595861624, -0.7083204072115145, 0.5281750170840583, -0.5593107271907327, 0.1680570285127891, -0.02852983397519089, 0.36164677743374546, -0.4410508922997332, 0.49108140650545407, -0.4473042621085823, 0.5624014805028225, 0.15830281387090292, -0.4236771446663317, -0.7111917975417477, -0.2685728182061919},
    {0.14104485452744003, -0.6112926032056503, -0.7417527466237109, -0.03256341345299901, -0.45114854018782546, -0.6264134370702512, 0.4363386428789995, 0.25111621370109344, 0.3811941918622487, 0.20126938641804326, -0.010903779958655248, -0.5979435271683557, 0.46341591535510507, -0.6047499531261552, 0.4540162197494175, 0.3556563774898506, -0.3511308458126805, -0.009617563783750725, 0.2722440365108344, -0.5318851201867685, -0.6407559949919981, -0.44088930325166037, 0.2815947784726457, -0.585732667927521, -0.8028489737421861, -0.028311703337572283, -0.646105639570745, -0.5066877590717485, -0.6846204930413979, -0.4942733161396143, -0.7684333362524202, -0.6819503170206528, -0.5684708497541041, -0.5593357028738064, -0.09459022481865972, -0.6396777023095902, 0.529649679616218, -0.7237933319738037, -0.6225401522873902, -0.323959872582492, -0.6656984275957714, -0.5679444914119822, -0.7242930573215678, 0.5131763008263844, -0.5574331139048063, 0.04086054342027264, -0.4570188436799406, -0.2229688158630909, -0.5776394901963683, -0.7063119618195401, -0.37953639307395076, 0.5885283432042229, -0.44953679748136327, -0.1636158049762905, -0.19329183031670114, 0.2607706250409701, -0.41773934655163414, 0.16034424781578696, -0.6021978308664094, 0.4614073171710271, 0.3147897019282172, -0.6567249863312954, -0.596089248715568, -0.02524657380017298},
    {0.19332781674911356, -0.6501736289291316, -0.7755022789370273, 0.25928663799883794, -0.46438965855155484, -0.6386589467409162, 0.16900142561907847, 0.4678502840667914, 0.33795142368604086, 0.49692924682628287, 0.13146675039344152, -0.5288236247980961, 0.5689303221809158, -0.5592000607387613, 0.4266576920939632, 0.3549273063789116, -0.4533891406051604, 0.15472194609940051, 0.058116265441658314, -0.4369125188267696, -0.7182694893948424, -0.28911220221104805, 0.11510965922281931, -0.7102154592221669, -0.8028313589489185, -0.11965394257300063, -0.5220326320583141, -0.5726164740108634, -0.7515983618377791, -0.6539154073050858, -0.6960462214046249, -0.6495981899260932, -0.5447339779502842, -0.711962232392797, 0.23493046036163015, -0.3169310337021588, 0.21491174123701035, -0.6360989235365525, -0.7689368680314967, -0.3414667276128752, -0.7561317073559394, -0.46725350136117166, -0.7754048725578281, 0.3937662706424888, -0.6970307089319113, 0.09353115531842675, -0.4980039456960597, -0.10528498993495579, -0.5231113631346697, -0.6988511519834348, -0.7297306895071066, 0.41418369435687735, -0.43476895218050426, 0.13349138438170075, -0.1948908376243744, 0.36609597618866546, -0.3602003350256656, 0.3843588638392694, -0.6301199741653281, 0.27710239985262936, 0.17347433960336692, -0.7516061756955138, -0.5774110806635219, -0.11533040506449661},
    {0.12971503351048103, -0.5259801134083333, -0.4874198586721721, 0.2860465882630353, -0.6459932640126899, -0.6653594238859619, 0.23022715612852798, 0.6317400539463031, 0.3400287924488828, 0.5225059022108857, 0.22565230682480145, -0.787834224035175, 0.3363772956814196, -0.6841547954673851, 0.3690761475389569, 0.41969446278789174, -0.1254489341379885, 0.358196457872625, 0.2104558923208413, -0.4920859563646184, -0.6710316345874531, -0.3191420247856162, 0.46998997655687275, -0.7845184803580619, -0.6749677258102472, -0.13339583018282372, -0.6884500803851376, -0.6106678826958082, -0.6656330208317095, -0.5264122638501427, -0.782485021434616, -0.5082613805346313, -0.265223665152211, -0.6721813644705996, 0.4753753504873258, -0.418477963073954, 0.4174209083913301, -0.5726430658135981, -0.54373806596779, -0.44458376510920977, -0.6989223774412124, -0.38543236984811663, -0.560567905552174, 0.16378658044206157, -0.6228696602746203, 0.44592356420117985, -0.43319122467311694, -0.04476852103681458, -0.383495539087184, -0.5495812467211484, -0.5407184758359986, 0.4206706708396738, -0.43237757376929875, 0.1683582187093424, 0.15354692929946437, 0.3974777232738633, -0.34845347619794415, 0.46353707791335497, -0.632155267017123, 0.5048875153350096, 0.33739056478759055, -0.7732488033851105, -0.5015651813723553, 0.09973167603251039},
    {0.5541218324890855, -0.6131077326284337, -0.4455431455798507, 0.364004133819604, -0.33041491860660643, -0.6996756661253352, 0.5086953976747528, 0.47407181089429196, 0.5608909852341822, 0.2996917067236568, 0.34387068830431305, -0.5566809476089104, 0.5912170431372119, -0.545133721137573, 0.4905833116310552, 0.5120689921306852, -0.14134681424610235, 0.24356229589135014, 0.10961223575065777, -0.7172907435245646, -0.5904539242672415, -0.11636282479626467, 0.32245755907083795, -0.679338426751031, -0.63246966534797, 0.1399164099629315, -0.5301998416799018, -0.5798401561867977, -0.7495766408093361, -0.703391668972498, -0.6983124790967415, -0.6237080446480895, -0.24752836303226, -0.533790922084981, 0.43092066356384684, -0.26469678938692015, 0.5472604168441432, -0.5130183165583404, -0.6322399683274947, -0.32880359852689095, -0.7486309578630889, -0.43298014084441977, -0.5310522083393355, 0.14607005375832127, -0.4124431060219776, 0.3225749005949333, -0.26203616696117277, 0.008206624839276677, -0.5578755413104817, -0.6075437661033138, -0.6130380523092319, 0.7076322085015571, -0.7485734969211083, 0.40593293507591915, 0.15307783027671773, 0.6895919939618405, -0.11757160488332902, 0.24942453686446067, -0.7485685481613936, 0.3564720241962081, 0.1744592396652155, -0.7045857173609223, -0.552776440066044, 0.2628917676937915},
    {0.25114255878214004, -0.45899573002694577, -0.5269175838816131, 0.02286592288029759, -0.35855663158560336, -0.7586698383726144, 0.43157823035156884, 0.5990988599758532, 0.5179125044082689, 0.19034233593364383, 0.05738909963032258, -0.535678073647709, 0.3877478238299194, -0.6298185464866097, 0.31305661204908014, 0.35258912857613434, -0.3267694440853288, 0.19336556049789183, 0.021193049418754214, -0.3838305552805113, -0.7570740856361313, -0.24127776649867438, 0.3098819657177391, -0.5043304514741173, -0.5604756358701023, -0.2148663944907489, -0.5996661289865017, -0.5611575670836078, -0.6672198602883093, -0.5979765820438601, -0.7314848105433387, -0.4613492239808734, -0.10029928408524737, -0.44289742141702587, 0.17072374552438963, -0.284569233102613, 0.18845708806808875, -0.5928158613987332, -0.6871073137072521, -0.3871699181231367, -0.7079833359247738, -0.5905058742724743, -0.4083966973998263, 0.15113668410219602, -0.4540589999820096, 0.2149632388270061, -0.23750036005115543, -0.3614477552453982, -0.6060278259479965, -0.47820331857663045, -0.604094956293411, 0.39471317846412685, -0.6037488829733494, 0.2993845395237194, 0.022387040108530584, 0.5111732297008098, 0.08866180598229659, 0.25706142531960835, -0.3905010811208842, 0.3228062366508665, 0.1626469461597782, -0.6967871771831898, -0.39394875364901755, 0.21759448192956576},
    {0.14555487957327903, -0.5871106732612887, -0.3588668516572092, 0.4296707894807892, -0.4473903263468163, -0.727717403917978, 0.4499731458504661, 0.5759014052491276, 0.4311263617641595, 0.27921901293776136, 0.04681726436727379, -0.6980071326165299, 0.5394847765998105, -0.42740451693224807, 0.4047755908876556, 0.1037375967640228, -0.02619624682664394, 0.36427553859930767, -0.018642390976229235, -0.2995984695919647, -0.6885141834272874, -0.023155951681672213, 0.28155636397288925, -0.5616241274628538, -0.5527880890783807, -0.31439429613505776, -0.5281165847145995, -0.5603827056657811, -0.7001176533200535, -0.5473715055573181, -0.5547168699383304, -0.5367648370530124, -0.08748234167349736, -0.31385904097374884, 0.272015242581163, -0.44992310167905897, 0.3888548659684811, -0.7083387034738935, -0.4158636497247321, 0.01537725384735815, -0.7726526895436924, -0.3117155148097741, -0.6622716715190622, 0.1480892394085592, -0.43681986823677105, 0.3314749970943746, -0.0970931908494834, -0.23220936953622423, -0.6278968772291398, -0.635497396532513, -0.5196115727860171, 0.31313145123967956, -0.7106685134085738, 0.30192157851057344, -0.152303493200511, 0.5592339767790864, 0.004022250231238167, 0.48914692233256785, -0.5115610758444076, 0.5778502082506333, 0.3510476298315861, -0.7568757831688611, -0.2940361215471408, 0.253298032387912},
    {0.3487032567476928, -0.5124148604895121, -0.6809637707935482, 0.40267148278072584, -0.5530025729683616, -0.7138367071547961, 0.4198702395517519, 0.5778392960081626, 0.5189661481371832, 0.2486580674403461, 0.470007010717268, -0.715253067813789, 0.6352775064895357, -0.638990847546969, 0.4197279623000179, 0.46957581809479826, -0.05958581294624233, 0.44853191846197166, 0.25768837335632033, -0.35316593915310773, -0.7466438846366182, -0.0421159263050383, 0.352263728182512, -0.3822535657306765, -0.7500533412454911, -0.27335941389954715, -0.4293788729682992, -0.5576762506249273, -0.40788307674791835, -0.44890900123990624, -0.7649363585293223, -0.6950800403434279, -0.1666948870649393, -0.29425691373328955, 0.47628319999670166, -0.20613559850516652, 0.192434468571643, -0.6525206372204725, -0.6305834304057469, 0.03152010734319886, -0.5751171441888544, -0.2215169199794648, -0.5089401535515821, 0.5045678968012923, -0.5126641803517559, 0.4934307203244607, -0.09794799241542117, 0.03324476393768398, -0.5272316697074984, -0.42747455429173786, -0.6073111820150764, 0.35901661601795865, -0.7034284682064147, 0.39025747420665696, -0.05041134703220404, 0.5698506395961797, 0.04224322160163303, 0.45065859809941633, -0.645631348678493, 0.32685919550460885, 0.19003526953411978, -0.4596743618913246, -0.13355670204232237, 0.2768488785746006},
    {0.3345703515173206, -0.3008289153834135, -0.5630082438702357, 0.42786330690580143, -0.43665961299280365, -0.7625090068179812, 0.5041891793575322, 0.4048037497030202, 0.530125380163619, 0.30505857961543903, 0.4590657703879748, -0.569298803189565, 0.36593575049045335, -0.781608412466306, 0.5199426277035436, 0.37347724587685954, -0.0475177216972503, 0.4401673057073223, 0.046120721421553594, -0.45749718754117513, -0.6289306701111966, -0.19021970646950087, 0.43254960039508394, -0.5966796628486293, -0.6593730723220165, -0.16085458556369508, -0.40621430630585253, -0.5918522280360614, -0.6734499748891505, -0.5169525150918569, -0.5549075877666527, -0.7005664504958968, -0.24329306457878475, -0.6070678327680432, 0.22964606797835327, -0.22507285229013319, 0.14222425412156917, -0.5421577748669496, -0.5238410106696557, -0.12726315996075552, -0.5076711077442382, -0.34189444291464416, -0.3232490389731687, 0.4627864611133537, -0.6991369290634486, 0.33427454457311695, -0.11568535497337328, -0.09839506481825765, -0.40877151622142965, -0.5522080785644106, -0.6624724622666264, 0.37481829117261056, -0.48563029274218567, 0.4614216597853762, 0.2316903447662159, 0.3079933153416875, 0.0187427803984584, 0.37024979698310684, -0.517457521153816, 0.49458068064522953, 0.23530931888780057, -0.6075939957708493, -0.27035187556559526, 0.05738038749425442},
    {0.4808538108967212, -0.5387030317352661, -0.5083155003280273, 0.29926204913636695, -0.5488431682572444, -0.7382641658180275, 0.2508145131060377, 0.3022104215891126, 0.5268485367512162, 0.4159178286494056, 0.2586144250172007, -0.7266092305343195, 0.4611130153940793, -0.5175181737074893, 0.2961015335921286, 0.2011009320373557, 0.15083286996123021, 0.5110500953262433, 0.2597137811737069, -0.36064941819119445, -0.6377845372122186, -0.07481093497122258, 0.4155244184746711, -0.5951248288012341, -0.6217264733881775, -0.0061974206861916, -0.6789879256133871, -0.5135156537605032, -0.3499010083262593, -0.4506021220442104, -0.5050597954123582, -0.5882275505560915, -0.07468894053706268, -0.3965297293761363, 0.3001630291643233, -0.35916436315241634, 0.3438998705655971, -0.7930029792277853, -0.5005059747345348, 0.04801589126585186, -0.6290379928082762, -0.28794438233753195, -0.5182372442150781, 0.2499832817387931, -0.6715554188643702, 0.4653161510846848, -0.12137049888719925, -0.1643940968302096, -0.6375773250098804, -0.6444398197218056, -0.4307629653032914, 0.5717524616587852, -0.6283434717845728, 0.37891928959557764, 0.008028894604844891, 0.5561825793254237, 0.12196900879573853, 0.33988283283408677, -0.3292330293788732, 0.4651806823836592, 0.513858346292561, -0.6641547479618943, -0.3146766947388486, 0.26755776123998665},
    {0.3417120414490749, -0.6300022598793209, -0.4402162373525062, 0.4687491019132495, -0.6441425342839361, -0.6687945403418105, 0.44342927344459154, 0.41530609741507685, 0.2689117279330062, 0.5397149740617602, 0.4767756503446029, -0.8246759179434979, 0.5868600435541984, -0.7586176022629721, 0.4829956184057185, 0.45089223077794316, 0.14320229257772574, 0.35215010619556125, 0.14689581637955018, -0.47229260520093824, -0.6402482989997488, 0.05224689015156214, 0.2777020413829132, -0.45575191380195673, -0.5230018072370696, -0.04831946131651305, -0.6510017791115278, -0.5869183598228945, -0.4415416821587656, -0.5095757041066581, -0.6266214493918053, -0.5761175226582258, -0.06722471506356083, -0.3665115669551079, 0.5333792011121432, -0.013989423925527936, 0.5326552335328525, -0.8131413105139966, -0.49303535694071887, -0.1707306141651477, -0.7560968987964077, -0.5820267522885595, -0.33826663400121426, 0.37238548291836876, -0.5275829804340909, 0.2626774793740603, -0.14987944872601522, 0.1006209577155027, -0.5140599475014593, -0.6954121126305487, -0.7072545981763613, 0.6855290629384154, -0.757088032971459, 0.266049734886897, 0.19601769729553015, 0.5546595083193927, -0.03552341374981927, 0.24031434205858196, -0.6503148413579672, 0.5896566018764576, 0.3459662570926846, -0.6924361421009892, -0.45913417046496496, 0.44634821474601105},
    {0.48301801578345854, -0.4982629848513707, -0.41705468054934225, 0.5293927276794187, -0.4595832095389546, -0.7333344381304882, 0.5540352583985464, 0.5257176816628014, 0.4283437608116258, 0.3613137399220158, 0.30225397574405355, -0.7792864617359815, 0.689319283873902, -0.7843561945800905, 0.663773590726584, 0.6226572114067033, 0.19036042762671102, 0.38429188583434903, 0.4905023082537058, -0.6600502443763199, -0.5691060836780163, -0.07297846186469473, 0.42290659442032924, -0.32226813324894027, -0.681385403848817, 0.24838156147618876, -0.4717619489928475, -0.4284104550598192, -0.49550197689089454, -0.6830124328248723, -0.4810786294438726, -0.5854973732677748, -0.030600657305602137, -0.5518338969595139, 0.5452082367208024, -0.17049300693612157, 0.6828914730426441, -0.600081785313606, -0.5082259350641418, 0.01952391273104799, -0.4518173436504746, -0.215381119213826, -0.5649469844917326, 0.3713548875248055, -0.509492693303137, 0.5813292214682021, -0.14382866350512255, 0.0724642264983221, -0.3057003320588322, -0.644950947998013, -0.5035790559086473, 0.4526786419537002, -0.5535995811874421, 0.36966389699565705, 0.17512513605722954, 0.44199633531341503, 0.24652494657344734, 0.6124635366268395, -0.532755368932097, 0.5771912335672661, 0.5032890162727198, -0.5437112690131659, -0.19125800114468544, 0.3948266377747659},
    {0.48137005810508104, -0.1560917184293032, -0.18229790504965573, 0.6996266771632603, -0.5941735968695253, -0.544088494390641, 0.5275897916979714, 0.7348349611066921, 0.5982175123054237, 0.5567493963615886, 0.3648628041183358, -0.36054820254898223, 0.6686925285789234, -0.5778307480988539, 0.4734555306180882, 0.4854530527204298, 0.10943338380351866, 0.6646537893546829, 0.3224847742546425, -0.40182654550514474, -0.457291487198914, 0.19217753751637784, 0.5512344798344598, -0.1637343582613527, -0.49039042333782895, 0.1169617655847513, -0.4479577403090236, -0.24674380437108334, -0.3662731444957655, -0.48064501270442195, -0.32599694590638434, -0.26528198452324164, 0.026220084101904115, -0.1485234053269333, 0.8132753309109784, 0.12806209585856262, 0.41987291959326384, -0.6492532784750362, -0.5096781316901331, 0.03483343427269303, -0.5308747146117856, -0.08401940066019442, -0.23063484325692285, 0.5539205407560037, -0.3628996921149906, 0.7118796760975807, 0.05269293104357726, 0.28749050947738836, -0.4911239063804935, -0.5944747963931344, -0.22867461681786436, 0.5811610417709521, -0.5463547520455574, 0.48142013903625763, 0.27728052785777046, 0.6262000394006076, 0.0635045989356426, 0.49288631799138605, -0.18470505614063587, 0.6096308202649013, 0.6170409002448465, -0.34268486251885016, -0.06599563305321492, 0.3835129514944285},
    {0.36624023400790984, -0.2922007664753237, -0.35002454953068796, 0.6298548157971987, -0.5482084811778999, -0.536724441621822, 0.4301034740110821, 0.6604316168653958, 0.5397394279671157, 0.7402685373063986, 0.43442419603943255, -0.4062532844302257, 0.44393449578564087, -0.6864092872664118, 0.5165262522660277, 0.5525455323289503, -0.030678437592508108, 0.580437373208445, 0.27442280492221066, -0.3952976952006642, -0.39391869194468854, -0.058142902800381764, 0.48252515338496293, -0.1310390140603309, -0.683946968779119, 0.07438834362739648, -0.36192516657826856, -0.02361268664151352, -0.38751943019661, -0.46978722186144856, -0.6200138339885569, -0.5312294403556587, -0.17800260513560076, -0.27369603861116604, 0.6717241026294783, 0.015250082808671227, 0.5724675961231862, -0.684221436511999, -0.46292839106717654, -0.13205777386810152, -0.6640944165374921, -0.35729164239898353, -0.2934616405248592, 0.6347856927464, -0.32387995726004637, 0.7225926808302502, 0.053531281688818017, 0.03215886508663842, -0.4824957985794281, -0.5238735644390511, -0.2478648769866311, 0.687565953644052, -0.5141894360486433, 0.5928596071096448, 0.1444534875801382, 0.5137205160701666, 0.042205677162847004, 0.5901243449854667, -0.452960083263435, 0.43175842127047315, 0.4572302025080441, -0.4044784846425857, -0.1192511804928852, 0.22259903619636157},
    {0.6260185895652984, -0.43319279305113645, -0.49601382454841764, 0.3714930157723311, -0.5637546201315261, -0.455062816878077, 0.6137917317575061, 0.41073035676429803, 0.37306684055677836, 0.38126990757213114, 0.328803615065093, -0.63950887199261, 0.6765171782668323, -0.6925710061655989, 0.6989017303274686, 0.5532170230611213, -0.20485778520709766, 0.6289439686368059, 0.2085288566460132, -0.43751111176839474, -0.5827646501354506, -0.1784567971850735, 0.5628491016236561, -0.34049792468241175, -0.5439388146979354, 0.07393682763448968, -0.662509084575976, -0.3345383328353953, -0.6533080999921493, -0.7235805425753815, -0.7687516336924562, -0.41706787687508495, -0.04334599108409742, -0.5234940691623197, 0.5650947296303587, -0.007563566058455611, 0.4541175328659041, -0.7112151770630498, -0.5340042076769379, -0.2329571339362197, -0.675775134606695, -0.26558680826664827, -0.4307025450029415, 0.44214750071771763, -0.6633379210930613, 0.583304645511652, -0.021204170602638524, 0.13828400099260538, -0.3488208182132322, -0.37295906877172197, -0.5967284621845583, 0.7570149145475688, -0.45448607112916284, 0.4563972661042671, 0.05458527647840331, 0.6222299636686864, -0.06044651570031115, 0.37577059674819663, -0.4905761631309048, 0.44575719777403144, 0.4016702132438783, -0.6344165785067801, -0.40682401282174974, 0.13016768959448813},
    {0.6532869967687115, -0.542310604276213, -0.5811552013262585, 0.5988843288094376, -0.6291124258955291, -0.5162431715772722, 0.48826097548518754, 0.5108089833759115, 0.3928057015706654, 0.2943176700070477, 0.5311963548744999, -0.4070215591043002, 0.41132399671570696, -0.5959160248785539, 0.545801063535548, 0.4520617935217344, 0.07097235841604535, 0.597118556535645, 0.41500061002175453, -0.4309096558216672, -0.66139988568494, -0.09340584087335545, 0.6001685749880407, -0.27768460491985847, -0.7161385728785986, 0.19711042921039287, -0.4846340146058493, -0.3379998036722013, -0.3092430165803869, -0.6523619888075962, -0.5797327296847258, -0.7498076527561145, 0.06574222429657758, -0.4135487611474718, 0.6795132019351902, -0.20975653459454927, 0.49075172473268447, -0.7586182573800376, -0.6066780469658647, 0.02892755659477614, -0.6364747153159701, -0.389824540907775, -0.19976239846919192, 0.3114001684837678, -0.4851012819184027, 0.4226662399450798, -0.004771137794020574, -0.10148166495499004, -0.6058209265322024, -0.6226988790861758, -0.5875866426252375, 0.758823806475574, -0.4546576251351672, 0.4933425221367543, 0.19568019358846628, 0.5714982361693968, 0.20471693219514606, 0.47869455490334956, -0.38460526974637843, 0.3663986868605245, 0.2321397661659537, -0.6729834690174132, -0.05344451508179682, 0.368632943216473},
    {0.7028305299921519, -0.09086016965038585, -0.18854294350770523, 0.6046866883905387, -0.32882062713599236, -0.48931763938587647, 0.5897184630733563, 0.46777308928022454, 0.7328626995669227, 0.5941454324752495, 0.6489741746833879, -0.4966377627501337, 0.5717451342241058, -0.7363153393828961, 0.7710447529444241, 0.6365404055520026, 0.1785211071645176, 0.6924027232726998, 0.6736232191238177, -0.5382812270394509, -0.3877804618105091, -0.16098496838561202, 0.5187932397620424, -0.17221697171466085, -0.5392801874916375, 0.22125417602521116, -0.46299731170635167, 0.03496907139562155, -0.22591600835555414, -0.44099965547314784, -0.5234943411300779, -0.6733301254771634, 0.06290819016335583, -0.23526257167290307, 0.5999678171296402, -0.09099520333258629, 0.5316268119959466, -0.4321638142038167, -0.3010232312000208, 0.012606582321705882, -0.6030201227961904, -0.19668672200840542, -0.09712038813310869, 0.4451590348643241, -0.3369753895957972, 0.6359221826998995, 0.06919279084199748, 0.0227313579655634, -0.5445318811698407, -0.2840829969030938, -0.3931311077428977, 0.5115473810203434, -0.6018569445777117, 0.6153101233850244, 0.19756670149139588, 0.443484688702626, -0.07527563801391217, 0.49704274804503057, -0.32196108733095163, 0.5707548290877772, 0.34056108022498577, -0.30891284469301367, -0.22620163211358169, 0.41050973626845255},
    {0.37379880896164536, 0.028805663801081773, -0.3773483818588822, 0.7448545502843539, -0.3185358402737604, -0.37206662427566917, 0.37487372869217633, 0.46268435874188063, 0.6057938572702094, 0.668883589776254, 0.4801200820205762, -0.48398239754789607, 0.5399351444093253, -0.44790363344647977, 0.5468769038638127, 0.5296744243669183, 0.15186481708148128, 0.6743644328597992, 0.5838170099738359, -0.28596308165744516, -0.3756372385543566, 0.15399356503559808, 0.5548044286981972, -0.12373079413909101, -0.3836621552945626, 0.2187926683331414, -0.03292734247333035, 0.11589268904643678, -0.25593546945685725, -0.4560991721327107, -0.5717273512655637, -0.2686926074985275, 0.07460674512310463, -0.19532979146861013, 0.48400634294833106, 0.28397073691662067, 0.7136931233559921, -0.3599284778425012, -0.42000838985306643, 0.030789779108992093, -0.40222049895409784, -0.17375322294801235, -0.20117245351662752, 0.48805243812958493, -0.2366699415475799, 0.6701105929200728, -0.10095966866245322, 0.09854750375722483, -0.0863224209710165, -0.23524885945513038, -0.32509200515911796, 0.6942160540323188, -0.7107906190679443, 0.6717903709056682, 0.3788122523092007, 0.6484829939254427, 0.11774452139744661, 0.5023524819910012, -0.01509879634327868, 0.6596184233149094, 0.5889666452400312, -0.3625121489650471, -0.03859765360571416, 0.5666497834032471},
    {0.5670412087529129, -0.3306865329210865, -0.317083619736475, 0.5075131819485357, -0.5263439365920873, -0.6999166437066119, 0.5745850500992543, 0.42445142478643105, 0.5850897893484337, 0.3917168042349744, 0.6469448396240339, -0.40695257966340764, 0.4504583477012185, -0.6948474998927249, 0.5029478808092973, 0.6690257242599937, 0.11182946846009802, 0.779201382396844, 0.3790036056778038, -0.5308058113940757, -0.43277636150546606, 0.1805218686156895, 0.674575043397579, -0.18396419919128598, -0.6333409575718838, 0.21978336339241705, -0.4872161687579279, 0.07887998082492387, -0.14681677513980604, -0.5208769859214321, -0.501299145159155, -0.5936938200612127, -0.07121131571225572, -0.46338446379520376, 0.688476939788627, -0.0727247391968161, 0.3339385072945797, -0.46110597134162307, -0.3343577686834675, -0.033293942382983825, -0.5432888786639992, -0.13111813741818626, -0.024308809693170702, 0.3755570017214372, -0.1877587217790889, 0.6126823534933022, -0.14121722784272744, 0.027298677201416537, -0.5014749218751484, -0.3429472868542076, -0.40005511035603625, 0.7213649018586328, -0.5285260030837513, 0.6147670854705259, 0.08992062798411957, 0.6957111824733411, 0.07505171883382553, 0.5618174284126038, -0.18783527600250885, 0.42990026578870066, 0.38482447822524657, -0.2772315892576663, 0.0032163065181863132, 0.3662891989820342},
    {0.5510927806705415, -0.24567369791813823, -0.41253720033749336, 0.39034173854299914, -0.6696509339230616, -0.5312604592310158, 0.45465054202723537, 0.5679860568070826, 0.35399069011178036, 0.39963197797099004, 0.29822899694477045, -0.5378560477479365, 0.6488596717728919, -0.6066892486312145, 0.5300714237132632, 0.5335842865349262, -0.09011530806466862, 0.717614555548001, 0.2543414312711962, -0.5254981290446942, -0.48204817692747143, 0.09605189665395238, 0.48510200595702213, -0.3444300195244729, -0.5853329095421147, 0.18654940367096617, -0.5269799487018261, -0.23879809358616985, -0.24335194365283488, -0.4600061561187056, -0.6687052968383422, -0.5708060536215076, 0.14714409861637193, -0.30332461910797787, 0.5387886053071002, 0.14207611768140904, 0.5495490704276023, -0.6678521229096452, -0.5854106148409847, -0.056008004088164524, -0.5865016294122638, -0.45205022548717133, -0.23958912152472794, 0.37194230156188135, -0.49795926446403016, 0.48583643920657477, 0.06747573485233235, 0.1039227715753818, -0.6301851168052812, -0.5591998175155226, -0.6327420641888977, 0.6381850525321213, -0.6557460866911186, 0.5440071069502858, 0.13798958953909815, 0.42797776715943026, 0.17640371456715714, 0.4411722580134357, -0.570951319474713, 0.3563420597807341, 0.42805745782309207, -0.5164015854964908, -0.0021678258201025895, 0.26091892251399856},
    {0.6185648378994956, -0.08327683783514189, -0.380626892566374, 0.3696564229279802, -0.4918801397395851, -0.6671378433192229, 0.47665316403125724, 0.6117505612080706, 0.3659631903641846, 0.43347851429880796, 0.33855996670439786, -0.4536287063723, 0.6965348880567979, -0.7382385548880332, 0.6044052218908428, 0.5396612088215442, 0.22741339154568713, 0.6732320392094593, 0.316271059381164, -0.34408483851497407, -0.6140336736234709, 0.09671668942441297, 0.4900711929521354, -0.40782118115551236, -0.612594290516899, -0.03943071041504961, -0.423150708756479, -0.3156010042188033, -0.14963875350010014, -0.4966828456877332, -0.6782286844141905, -0.5257570255537786, 0.22553547245919714, -0.18926627814179275, 0.7161885437564062, 0.1482263770890327, 0.5944775970554217, -0.4722944213908411, -0.5829518946210568, 0.18671464150940822, -0.5721115996245449, -0.2788850523267017, -0.07581452118240009, 0.3746421217103356, -0.5260180220123473, 0.51485176754406, -0.08528956163684757, 0.24056840326668388, -0.5822005612225589, -0.44835884288578104, -0.2139781640681844, 0.4766351049951945, -0.646487678391572, 0.31449466122583314, 0.2661541297556771, 0.39157743818655444, 0.07144333603120115, 0.6609725371286757, -0.4297913246830767, 0.5432212225525933, 0.42119036671858345, -0.4187330898490053, 0.03460604978993085, 0.15807906964912002},
    {0.43122560570563206, -0.356195966029488, -0.42492031440300027, 0.40291713616339886, -0.2793881252710537, -0.6202607655858785, 0.4954757042453152, 0.6905730058547735, 0.4857085436478321, 0.5498105240032055, 0.650508054943808, -0.6642661851768586, 0.561438926516607, -0.5819882982012152, 0.4325938063362845, 0.6051320497029343, 0.12807089622841938, 0.6848299994954341, 0.5545176049410754, -0.5240431933326072, -0.615176515095134, 0.23944285455348568, 0.3980863256401906, -0.3098365556766336, -0.5805385939672565, 0.28657553269741753, -0.36554378927701003, -0.046987756185064095, -0.07622406264024872, -0.3972559755913742, -0.5646585680161765, -0.37142404888259856, -0.011187920058609663, -0.044215133105177766, 0.7218547069559327, 0.04428094797323008, 0.6292696620697754, -0.6744149368308885, -0.4581428308817918, -0.0036504754318384216, -0.3797034890504606, -0.25006407389790836, -0.07366193433244722, 0.36467950000108407, -0.19589160410507447, 0.5430953143352528, 0.05740635150648848, 0.2670071757961604, -0.5393451768399785, -0.5184515577401821, -0.26971521977726465, 0.5974560157282535, -0.7536011421113414, 0.3572022765454692, 0.12854415967871188, 0.3822887852265937, 0.28689973493997917, 0.51293816200675, -0.23222801472171392, 0.4007486678337457, 0.3607599807370569, -0.43799318918754937, -0.11570918461713463, 0.42062648293001625},
    {0.5459030378889659, -0.39345767034239754, -0.3369466689716319, 0.30322741741567394, -0.3417706026070958, -0.4962958903943662, 0.5556690921196243, 0.7055801117169321, 0.6090749831189586, 0.5182377244373098, 0.6393607236148425, -0.5212031119123219, 0.7209872791332976, -0.6597398127012367, 0.6747288483783611, 0.48661425929357605, -0.09328105112381448, 0.5758338752611334, 0.5893163833372506, -0.4510441334243196, -0.6533858430173859, -0.03886756656623177, 0.6595424380571195, -0.5060652403929913, -0.5128673128904523, 0.13533029147092074, -0.2747916684540909, -0.04265293662381382, -0.2923877831987118, -0.6064791193630715, -0.6454361154956896, -0.46351464750255256, 0.1276159375394828, -0.2832240149540766, 0.4627994199472299, 0.020083630484681723, 0.3682618296279942, -0.5275210620410626, -0.5323021405757411, -0.07215075624978623, -0.7039769581263493, -0.4407758917408686, -0.28562084136731036, 0.5631998353428125, -0.3302051506701871, 0.6565489950656358, 0.11441200045714141, 0.06778901338155194, -0.4300244462934365, -0.47994296941400455, -0.4427438702300547, 0.47175593149883, -0.48910347689765515, 0.5042133392810482, 0.34941198385946964, 0.40252315800315486, 0.24161245951859026, 0.45474546090084983, -0.3302762445842017, 0.6601540999636307, 0.34486192231368096, -0.2866335441935401, -0.04065142639069731, 0.24389447737565292},
    {0.709867351480545, -0.24321838576491134, -0.5043327352864125, 0.2873515963667167, -0.6756732289660898, -0.4211059577488078, 0.4462866646391452, 0.7472787988675892, 0.3670294910438502, 0.33815490536466125, 0.5085899610158263, -0.4300502638751098, 0.5211112254511026, -0.7255815756519558, 0.6248900883807926, 0.3913321162033259, 0.15510446325733987, 0.48892456696731607, 0.41410362456325817, -0.3840535337448317, -0.3680684384355883, -0.005327066109160175, 0.3926307548514439, -0.2552403061468284, -0.45437853121972827, 0.0938995183948362, -0.5067253060027842, -0.12141105585364781, -0.18613501296756021, -0.3717277973553028, -0.40723450520311016, -0.3733676346535656, 0.2738290024018759, -0.4202596188820885, 0.6052540843446177, -0.07644182822559374, 0.3016854875009163, -0.6857368078193662, -0.518211122712673, -0.02186459230988534, -0.4791629811283043, -0.41416352078097646, -0.35688765915701176, 0.2919442724944136, -0.5198545660726972, 0.35832960152048393, 0.12254089932441693, 0.27261620170628287, -0.6017559282741715, -0.6289041142716193, -0.5472155127714293, 0.598605163659224, -0.5522646271881372, 0.4852852485867357, 0.395959719923231, 0.654897653028338, 0.18409836446786035, 0.5720974493973243, -0.47146677712540197, 0.45362149813164016, 0.41212095598207477, -0.47674721142626125, 0.10806012339148041, 0.5938811060657565},
    {0.6597288719947823, -0.17330651629147176, -0.3617451612338915, 0.5069123575154914, -0.5097979283498386, -0.6377082217408231, 0.493614228456942, 0.6636806704332483, 0.6694742998069638, 0.554386541903453, 0.6041267324211768, -0.6798015946611616, 0.448521722582912, -0.4991970692450851, 0.6619373170535103, 0.354706248942035, 0.14980610543661474, 0.4987348224585505, 0.4262252583500266, -0.6766886835821124, -0.4704730708904459, 0.25290323914265195, 0.39733243579075583, -0.36531907099548605, -0.48106809949547374, -0.03216416740229845, -0.15739210028681275, 0.005185421607812373, -0.08448496152572574, -0.6292196507584144, -0.5984188198546677, -0.6355315535948679, 0.04849541839898449, -0.3034398694904476, 0.5907663204741228, 0.1503127756291955, 0.5884296003242115, -0.6338328786060904, -0.3840780459669167, 0.15273021996444247, -0.6148432142998433, -0.31772190053315685, -0.12445912302569784, 0.35175970653797994, -0.47617114385661996, 0.36685374137908633, 0.03533894610175127, 0.272620588152636, -0.26328763916214765, -0.5336907327914887, -0.3996115681050553, 0.7221148788242039, -0.787760388892576, 0.31135574796399046, 0.4114213220778635, 0.6801956201773811, 0.032393104861159906, 0.5721283530754953, -0.34152484727990684, 0.5795499516593636, 0.319195330815468, -0.2844630558855067, 0.024786595384256527, 0.3254180157330878},
    {-0.32237880262997864, 0.3183019159421707, 0.030879036388022182, 0.09434285606975222, 0.4500254309794923, 0.26042711276821734, 0.162639105229531, -0.39225333652075905, -0.11223105819410215, -0.15366488734127953, 0.014683771600227703, 0.24610172215116527, 0.2331479154353112, 0.3507471675051607, -0.23512098742453666, -0.3663009688443766, -0.23214104579948203, -0.6248568105371559, -0.29980037771332124, 0.20528490590557996, 0.05725010395684223, 0.02197680709928208, 0.043162542751344075, -0.04231990795818491, 0.09704036891073965, -0.37174959683548575, 0.16060743024065366, 0.08670868960519858, -0.0017001116875412724, 0.048527958376169, 0.4400602790606944, 0.11546929284758098, 0.22426944196224502, 0.5023736147032715, -0.5103229653490253, -0.0416855223812135, 0.1886291194247512, 0.33587385146404747, 0.45973079130194705, -0.16105637933291436, -0.003563180215143609, 0.25264117357959104, 0.3011569988454419, 0.24375729517084063, -0.028870493285309627, -0.07921869169521516, 0.08444513307159432, -0.32982981084442975, 0.4166401963419461, 0.49165391467472225, 0.3380706949317474, -0.2478700974650174, 0.16441507369064853, -0.25769327176028817, -0.19103083204916033, -0.1254971272048964, -0.013435675057460532, 0.006176519517392208, 0.35593443206786995, -0.47540032475586025, 0.04590363234376481, 0.4011427226769245, -0.3577024233447508, -0.33709615949935345},
    {-0.13479791677710418, -0.1283296702596834, -0.24617020148478164, -0.06808845655731784, -0.018161478056784086, -0.5838819022951055, 0.17651908686030948, 0.4172399904371242, 0.14197214157667304, 0.0621328831448788, -0.1066316448823235, -0.3674046746063158, -0.04303852954968365, -0.6264636470358416, 0.3468083015324283, 0.08510190774296647, -0.15127254488423206, 0.2391580957101827, 0.01474291778496797, -0.314103134762782, -0.3598825294531348, -0.6232842552578516, -0.18642140776403981, -0.3956128438753601, -0.616249113523571, -0.13641267679287772, -0.31773679470564653, -0.14670350968337428, -0.48874469938955306, -0.20921185368651238, -0.7003275424100168, -0.3216820097443593, -0.28598554641418816, -0.26781416266600916, -0.2802078296072681, -0.0424795117563936, 0.16517709203512768, -0.5840824352405648, -0.60747414880044, -0.5821167232836385, -0.36539759051742193, -0.3868586160846442, -0.23500223964954456, 0.3147155085410323, -0.18948954734024406, -0.20822255915175678, -0.5556812171515292, -0.287312044939267, -0.3947047007263812, -0.6905331076466412, -0.48504112636032337, 0.011058925577437375, -0.47377563057089445, -0.24049479124298825, -0.4239232943044003, 0.3288787278606852, -0.456651003526394, -0.05271069626657937, -0.19022792980984365, 0.4606226224144675, 0.25437705020379553, -0.3257941239710047, -0.4791475707388002, -0.193894915954941},
    {-0.4097557460832881, -0.4018016903052358, -0.11567951653980972, 0.27440926020184625, 0.3513506083919443, -0.2962217524771664, -0.19620365118187078, 0.07560798655163246, -0.08022703866324002, 0.19483884891521322, -0.29659156525781316, -0.0887290346785981, 0.2835497625186641, 0.0007879403093132357, -0.29102251950475616, 0.01998611278284282, -0.18104570463337513, -0.06784584385921509, 0.011244885735121224, 0.10160621846251168, -0.35049218164461726, -0.44836241693236994, -0.03181073745363323, -0.1816959986386717, -0.4632816443348522, -0.54430385871238, -0.17726926425019232, -0.24803831028598755, -0.6180931860513486, -0.4078798693052217, -0.14825318542966456, 0.2256048365502752, -0.4398233619777685, -0.3213137784580978, -0.41619578065405405, -0.6070250883885018, -0.32456673763062827, -0.05188569736916869, -0.4160299099037164, -0.4737393766477242, -0.4298615012871338, -0.0948520767699578, -0.3210660046411191, 0.13339544616232604, -0.25846855849279493, -0.10420753852251848, -0.5330894160038447, -0.4272246516083955, -0.09096783870446815, -0.22905919257992058, -0.2182463363514215, 0.00802754441045807, 0.19041980884733722, -0.308649940057722, -0.5283286968659121, -0.19890076617100844, -0.5853505421137564, 0.14463428173825374, -0.157993027698782, -0.01888230838806391, 0.2916074990428034, -0.3333887372658745, -0.5771769334884143, -0.5560325552855504},
    {-0.34796031528000937, -0.27535071214974577, -0.12168286498447672, 0.11316309514508277, 0.18896547458989077, -0.1140936307168395, -0.1857514411522096, 0.14250578732433838, -0.013701973726719953, 0.13738576819901546, -0.28220843721040206, -0.14632801253078143, 0.10749580936217333, -0.06469218501839857, -0.2056516679688575, 0.10652950360297811, -0.18514095955804427, -0.16652282343117494, 0.08394227977639383, 0.08894925491817392, -0.4403607961204737, -0.22558940789316517, 0.13214420491808374, -0.5275994605970995, -0.03016038039402238, -0.4541655528254891, -0.10585832540061285, -0.14980144890910257, -0.2854141203579798, -0.09112422794126739, -0.011465896657434681, -0.31736920794271367, -0.1673046554466982, -0.1417552786397326, -0.30014477953930846, -0.3408573075340606, -0.15774817925025222, -0.06865071559089138, -0.4695706058713386, -0.25366948174241855, -0.15866383792136995, -0.3245890326484167, -0.2379601758231817, 0.1293391234459238, -0.33334969622499205, -0.15375757163375087, -0.46528437979392573, -0.2648084431212508, -0.4366495931700546, -0.5644288619314717, -0.19981234910176168, -0.1917504862355135, -0.026346710554660664, -0.1280447630060859, -0.23921440224896967, -0.023174353372315073, -0.6487699564458034, 0.02803640238068499, -0.22556101488862268, 0.2070109941316521, -0.011515128636174765, -0.48679928063810274, -0.4599267232214971, -0.5562595513354961},
    {-0.04260297227417655, -0.6216525620831799, -0.31647198094775525, 0.20425301072649357, 0.05580735324965982, -0.3184466586666315, 0.29595887689825606, 0.3085526298513229, -0.06786230698458251, -0.0701227058793332, -0.2954030867538325, -0.38731798237157766, 0.11417035369614642, -0.28594219309423524, 0.14996608845486367, -0.0004047762162602757, -0.11859901149885906, 0.25167971553388696, 0.22325872371187427, -0.009995486891950156, -0.5204790045524925, -0.564898231712033, 0.23342768043175424, -0.49013181429994834, -0.3375157092910967, -0.14772382761276398, -0.6133668304249388, -0.4916123903158278, -0.5392990659594067, -0.5032175900391502, -0.395945699361083, -0.5880980794043155, -0.4014983494610074, -0.4946358392235049, -0.0016543154183238605, -0.4265700276704232, -0.22580952462437257, -0.5535166384232363, -0.38319914640103375, -0.5043077026919093, -0.5497180137911966, -0.6287507308559894, -0.3511295377049534, -0.0801503161816461, -0.580688243903977, -0.10400975144699882, -0.5400593414280425, -0.3526945462657822, -0.5183776677073864, -0.4574684735304268, -0.3743553296180251, 0.1202465677497719, -0.4313515077044881, -0.19200713906250771, -0.21536452211639406, 0.32933074180968214, -0.39513696467326564, -0.09955029664399812, -0.4304663855607749, 0.16864317066066845, 0.15430534362312728, -0.3412822448749125, -0.39256725322954433, -0.3716196374952235},
    {-0.37966204217363914, -0.3275915124493366, -0.32632879164887096, -0.04322350046289236, 0.07185554085886016, -0.32572474492876313, 0.15610254360904283, 0.22771752265179676, -0.019918186116843033, 0.003193194384627213, -0.12688677047463703, -0.2224714326876347, -0.09111225418661904, -0.3535683031803691, -0.08754902147395924, 0.15468247663551704, -0.1634039949114482, 0.13893210817747528, -0.13371600754434268, 0.03400988864649251, -0.4009508493004892, -0.6045694623623736, -0.05007102654520273, -0.5479571950317149, -0.5096857969526803, -0.3413630410109022, -0.5750474118007206, -0.5514927893004569, -0.4842525551871075, -0.33370223496339124, -0.3510440806443687, -0.27760926127589647, -0.44140422804364726, -0.449590515093251, -0.26354973150101857, -0.34245684826284795, -0.17181508454326794, -0.40596362782633766, -0.5365701701680564, -0.5382894322582634, -0.51829243562014, -0.3762551865368789, -0.28338566750204053, -0.06324186721824454, -0.37591572141816537, -0.023581353413606246, -0.36280775938642207, -0.4628719540560839, -0.17945857720691857, -0.3597335900561188, -0.0354489296199113, 0.052917472824184165, -0.21749107347838736, -0.10610994128554943, -0.23632944743589246, 0.22644733615320442, -0.28592476666027616, 0.08411603919427746, -0.5441018605204939, 0.3322117729421192, 0.29496058457067503, -0.5296811280219036, -0.2113227022103912, -0.5075752460966002},
    {-0.22759368679997782, -0.19931653560174128, -0.5123899648796452, -0.0815743731334992, -0.01360412804030487, -0.41976314342437254, 0.21398124399213636, 0.03169902513467716, -0.16923838910981867, -0.011065297212052844, -0.3687122792730073, -0.22587994970230174, -0.0615706504121413, -0.1785882453889765, 0.13402561996831716, 0.12319501752040621, -0.4144177565636523, -0.059926277682323004, 0.14305231487291423, -0.05896583713852009, -0.2260460324327511, -0.49295377910853394, 0.18397178876222958, -0.36205956731766115, -0.5537705906793184, -0.35467132278868524, -0.6728764248726086, -0.3400331315460979, -0.42818123538818587, -0.3596981492476698, -0.33977935832853623, -0.20072041023603218, -0.2845023969090845, -0.4764274159793843, -0.3625493475001178, -0.40134366265546495, 0.03405671905908416, -0.26025199766586904, -0.17548501920782186, -0.3486329139715268, -0.29328082502758107, -0.35389406505722804, -0.40055408951586174, -0.20137653331180183, -0.30359951288889986, -0.03492710623166018, -0.29475006558189626, -0.5772413478812847, -0.222060544958075, -0.5004495987106029, -0.14627726847274303, 0.20862396941791014, -0.3752450039676764, -0.3582285449563212, -0.668356610275375, 0.3052489149391839, -0.5653086084482525, 0.13815012159785153, -0.4634420229685569, 0.1851663394722089, 0.3052337249686808, -0.21993001890231395, -0.3940058840026382, -0.5139970803609415},
    {-0.2054633888224857, -0.22402860337167096, -0.570715396896278, 0.3748946438609313, 0.14411475395630646, -0.5550361638878444, 0.22881739348664087, -0.02173974504158569, 0.01598696727563351, -0.023144519644809715, -0.13794173647228772, -0.35810938943948956, -0.14150577811513965, -0.3035016545075297, 0.14404340154221806, -0.14411685579981728, -0.39947166035796106, 0.2008415337483972, -0.006774321607219497, -0.20332800608767712, -0.6639902830471943, -0.39834239607334615, 0.23642066664239839, -0.23210803130338475, -0.6097438297238302, -0.4234578265874099, -0.633184827099377, -0.40566955385008474, -0.20996986840700477, -0.4123987908186666, -0.2930936375349002, -0.3986600179397813, -0.40480835412463556, -0.13775987781578192, -0.09458946138958182, -0.28902082199107354, 0.11120398951160215, -0.4738863079260592, -0.2541838944009653, -0.3138992378353902, -0.3010196155864241, -0.60672730240699, -0.5414185357158802, 0.20065926878363097, -0.3386069632907361, -0.08946725473857797, -0.35448664560281967, -0.1730065001475982, -0.5083230759576917, -0.464340406165077, -0.1536317658041663, 0.34740874589312404, -0.13891261999911542, -0.3911540136177258, -0.5046462349080738, 0.2703158955610762, -0.35877565601118677, -0.09056863628388834, -0.45998628913873474, 0.03735726833845267, 0.12997918460244412, -0.34077082738302067, -0.3519662521383251, -0.5150088779126559},
    {-0.19798511803514984, -0.7128190643164258, -0.6335758932474852, 0.3518638748030646, 0.19446629931565376, -0.42707529449455967, -0.11314014272030447, 0.3054238606454644, -0.2916541813800697, 0.12098350022041253, -0.34922805946221225, -0.6115463358486031, 0.26177496807698575, -0.2866302297673616, 0.28045208543662453, 0.11233352894602322, -0.5286052742040777, -0.0709185323949716, -0.12721567635870434, -0.24247751055594793, -0.618698737023196, -0.6595887558072528, -0.10463961168448915, -0.2270329722099079, -0.6297294555161023, -0.45591686875117976, -0.41782821718915236, -0.24917437451274885, -0.29152135953313424, -0.5309266364074419, -0.4936820165830934, -0.39374781835503997, -0.527321164744851, -0.6216189815209365, -0.0841213591501551, -0.6541340791211369, 0.11068969671574432, -0.5897604664965024, -0.4990932524552043, -0.4979410474024639, -0.6830866950013575, -0.5003112722961991, -0.6883770938706837, 0.23555564525439052, -0.43823448894989453, -0.18104308709716604, -0.441989151137265, -0.47009738071723944, -0.216056276155854, -0.5879230296008067, -0.4604507360971477, 0.15179905042627168, -0.12636935377193426, -0.3397060656837987, -0.5769684987049968, 0.36729909006223826, -0.6708229636258021, -0.08394701602074003, -0.30171391351615073, 0.3821020290498449, 0.3014872837911463, -0.5497642918849377, -0.5981817941412371, -0.5506838334480751},
    {0.011425168468583947, -0.5252860342163376, -0.5098714052537688, 0.3257615652192093, -0.001960376008769196, -0.22354606970434204, 0.22711210637405252, 0.2881262076891233, -0.13785316072192444, 0.27993472846396034, -0.37980891106615294, -0.577611254201458, 0.3639958517801975, -0.5020715986487582, 0.4101289340448506, 0.30876387155821916, -0.40302062707339426, 0.18828512941615375, 0.19204905845842346, -0.1796479708348547, -0.6033846090166365, -0.3355287915385474, 0.021515722462120617, -0.5927616748814477, -0.37762187513485357, -0.4065327419836822, -0.40186892173113575, -0.4744558141307266, -0.5097952276986679, -0.46337284110453764, -0.5795934793290226, -0.2943893616387179, -0.4028290496538647, -0.5105952830566789, 0.003994064437029814, -0.2971693948265292, 0.08478149344050469, -0.481225715619459, -0.5310999945719177, -0.7142081580850843, -0.6514261383889443, -0.2891128614781454, -0.5884752087349175, 0.1724436336960566, -0.6234189082273628, 0.02457575702177927, -0.5514989363478319, -0.05906253336609463, -0.16802364377740608, -0.3548601367510939, -0.3787813804180028, 0.335180910829947, -0.40468657377756057, -0.11507324088457405, -0.3006827799897074, 0.3957941665588633, -0.2935912125335059, 0.2617856507290788, -0.3810685805517458, 0.14961356504141363, 0.09833556466751238, -0.24783964191845842, -0.5785245602085511, -0.3350783784694124},
    {-0.17814083410580428, -0.604045619159507, -0.42350284658585813, 0.05788172623384616, 0.08828318038740858, -0.17877149027201822, -0.22163956683100328, -0.19217972372099829, -0.4415604537249638, -0.3588040505208081, -0.24951889793874896, -0.46765837581310554, -0.14000493023864896, -0.15401398653019763, 0.1841327548243788, -0.12719494348483745, -0.41808067316463315, -0.21824416243140662, -0.12445694582366201, 0.040805303034687934, -0.31848551037415745, -0.46255473921058077, 0.04921272495712651, -0.26630697099597334, -0.3119972028542041, -0.20975826419907, -0.2515629593991, -0.3733594941316451, -0.3781087728195707, -0.5781855602403768, -0.5188056479169129, -0.5962611338017131, -0.5529570043075505, -0.24606377698285065, -0.4291474534096055, -0.27986608015092096, -0.2919353832863587, -0.32756205825328766, -0.37254100185059774, -0.4854140667792133, -0.648478161512933, -0.6497610268087934, -0.6121994870461237, -0.19220789396165927, -0.46716623874142305, -0.276725313129172, -0.5015388267918617, -0.35265162697454416, -0.07549493856934018, -0.5011964305394593, -0.06745972823008173, 0.01910533103829002, -0.382908995394235, -0.5409564122827588, -0.6592367339119052, -0.21741056246846382, -0.307471541190015, -0.26167493786030155, -0.3679983568726914, -0.13624964018474392, -0.24094660848492294, -0.4278146950957519, -0.3489197670777272, -0.6353263512485621},
    {-0.1978888891705075, -0.35110328349798153, -0.5715941494099621, -0.11069256384103665, 0.06757298114219532, -0.43239311962047344, 0.1059079707526495, -0.09503109654331704, -0.16009772996953348, -0.2508342073759588, -0.4349295353687176, -0.5054531127989216, -0.11004049500979907, -0.1969147985590017, 0.3534598531701163, 0.14591843423897288, -0.44626959866450483, 0.11876508416212607, 0.1048193511952248, 0.12715616377369682, -0.5034673452317283, -0.3257164734661725, -0.0849529233962345, -0.43183855960922324, -0.3060926828686837, -0.32661912685841527, -0.5055979400238598, -0.28551872470526285, -0.25414687254303997, -0.34554891738907373, -0.22027682568109538, -0.5615682304192555, -0.5568337220023314, -0.2706887100226029, -0.2475481654725078, -0.2810439225132116, -0.06060800803923673, -0.36531562025429315, -0.20291077788659162, -0.4963487428593436, -0.33840668182262823, -0.6103754358872615, -0.4191708567887301, -0.19445082908784356, -0.3588866973334936, -0.004523526265491975, -0.4114692897918994, -0.2634382838342146, -0.20266356439710786, -0.5501797604787756, -0.1463026651725635, 0.13358143862555516, -0.17998789495496834, -0.38693091586899553, -0.608362267165111, 0.23971256939199756, -0.6447180735227679, -0.07540709267124923, -0.2393630302704356, 0.1717411613380454, 0.17715049359587595, -0.6225626264542087, -0.633116289684915, -0.4048958451838639},
    {-0.14477658144425917, -0.3580468597986252, -0.4975548384525641, 0.08944338526573709, -0.0245430341266373, -0.4408728711303235, 0.2481657508688728, 0.030052601777793675, -0.46578822086696886, 0.07229754736689908, -0.2032680982829366, -0.36854608033930963, -0.19938327100760986, -0.19949409635072926, 0.22545805610081868, 0.21869705861453417, -0.6043725387026824, 0.06818859286719693, 0.05472993122171072, -0.32465557797548944, -0.2883897991798856, -0.6076770522912228, 0.1089471763838787, -0.28950939397443215, -0.594108501886134, -0.5892466678224871, -0.5477377216682832, -0.3322715533191055, -0.5439818128273263, -0.45218388142702504, -0.27346482905403924, -0.6196096537378387, -0.3688171209632867, -0.20990073822030839, -0.14476394068342588, -0.6491515605365726, 0.04052379694607551, -0.37271806711843364, -0.3360035813528942, -0.613754926633438, -0.521964196377979, -0.47476106616641167, -0.6168958828886029, 0.18873329123218918, -0.6147418270080438, -0.09948721657260118, -0.7170446946700362, -0.4230284916529027, -0.5259419541558255, -0.4136444925407215, -0.4028484552583202, 0.2667735610443074, -0.11958221710235599, -0.16526488163704028, -0.5449131380703358, -0.015551853863570548, -0.5185561553007235, -0.026535434076549704, -0.32372746004391684, 0.02515203003233615, 0.20147849116696276, -0.5235261037461678, -0.4763352607419459, -0.49061030439636466},
    {-0.32498173241672573, -0.4271171787477743, -0.53977301527664, 0.12414150558653209, -0.20662865685798676, -0.1917410069990014, -0.012008769571651524, -0.1378271549387925, -0.3582310921247332, 0.02445540575726251, -0.28129456096118965, -0.6748293190694725, 0.07543442938388562, -0.36254451248524805, 0.08242118499342424, 0.03831206935289111, -0.5576413101545692, -0.07745753721534043, -0.17647628004266988, -0.3795788302611849, -0.48256191865402576, -0.6037254982756151, -0.0767485007134296, -0.35920023573675763, -0.36809210275461046, -0.5328801889353423, -0.590694275456806, -0.5862380118826903, -0.5461470921233125, -0.500811296542633, -0.27928202836982513, -0.28318619045388754, -0.4998443338632312, -0.4230609052390928, -0.4513528693743188, -0.5599515630339065, -0.11823449395605609, -0.3845947983572398, -0.34647604088011924, -0.44577912298345573, -0.3538729855942612, -0.4309702533313466, -0.6111514050891188, -0.15620913349808843, -0.46798870792781055, 0.0396780233367246, -0.7160350140060726, -0.397663135991937, -0.32538251937119966, -0.382374059395824, -0.32825498464375974, 0.09911712644491177, -0.2854960050353457, -0.5396594628434502, -0.5222939601737603, 0.26200196104908036, -0.43364168588911145, 0.1954222920930669, -0.6369173051162303, 0.05369893554801053, -0.1764734694143595, -0.368883824535999, -0.6448384294094588, -0.5409705529313126},
    {-0.4933119614558791, -0.5769302709589607, -0.6498452113509683, 0.22067770384874097, 0.0945536236957734, -0.13204589352985663, -0.14390653496444822, 0.21994587282692896, -0.3769714632661684, -0.05832144633981518, -0.5373507698228519, -0.5838034921432225, -0.05238380011576396, -0.3798250694038653, 0.16286591438123937, 0.09478451709118149, -0.5761392353158374, -0.052226667075775335, 0.13686765486724506, -0.11894066848956367, -0.5726663664209835, -0.6342134621683398, -0.08498158074332475, -0.5888630372726874, -0.5399059103789466, -0.6345085532621261, -0.37751985202572336, -0.5858326978019178, -0.6064438860477694, -0.6558274799126674, -0.3707698138494091, -0.26672165187219965, -0.5788976015481456, -0.49326700654019, -0.48898618914488384, -0.48508579475937846, 0.1124747969120833, -0.41976158974665506, -0.5138139090752284, -0.7889390588336767, -0.35729657028765077, -0.5035260505700414, -0.4993620105970153, 0.018384587920847614, -0.3594685193412032, 0.0797291276635632, -0.7384543501300082, -0.34065476751377827, -0.28016664650490514, -0.3902606412853764, -0.48748625568409604, 0.2179375475382048, -0.09518208321193089, -0.5740749990956083, -0.7031181922122859, 0.25494638860141744, -0.51152422592672, 0.1509004055181481, -0.6296130116854998, -0.1233383809395373, -0.023686318142395434, -0.5911403928720387, -0.44006624384973014, -0.6720594394091661},
    {-0.4890311396063227, -0.4149247948752203, -0.406958851147505, 0.2997648765099904, 0.02661807846046339, -0.13308576212756348, -0.15744063052346094, 0.08574599732623324, -0.2388967972558047, 0.12460402407106032, -0.6189645422825985, -0.6764758420136832, -0.13744763910840843, -0.39635876743091175, -0.012223995053685429, 0.07518633556229817, -0.3352800587998038, 0.008679972648329292, 0.20824441182773457, 0.06854047572202418, -0.503761931543415, -0.6141826760177659, -0.14064088050181986, -0.5770956658779467, -0.5887651699484228, -0.6496577585643947, -0.3182075438270706, -0.4897400616511927, -0.6374257446185108, -0.47171366116208313, -0.3954058483228467, -0.28693321919561104, -0.4382230581060311, -0.26180326263470194, -0.34914138722367355, -0.4678672534167752, 0.1455564893233455, -0.3093149679018457, -0.4322267788501975, -0.7224214303127864, -0.5241425159279463, -0.39110850371818257, -0.4242915914417114, 0.19826302031504264, -0.3429338840018818, -0.06346424948660377, -0.48936546502033984, -0.5979206087531075, -0.3169898725021208, -0.3431732117979689, -0.4267758320774099, 0.08326008004690733, -0.13584353916713485, -0.5372503699529575, -0.5658177617233252, 0.07443020972596649, -0.7166320568312521, 0.042716945305822346, -0.44468140338914963, 0.08851797223838885, 0.11738583735596594, -0.6792859994556447, -0.6567837899051048, -0.5065188474235733},
    {-0.2970067904475694, -0.5327342516606114, -0.44884685367392446, 0.3671745287176381, 0.0747806162910222, -0.27619234198901643, 0.10365911929905615, -0.007279954070189284, -0.0024910588878739796, 0.062134688670254554, -0.18110117841266438, -0.19854126314640105, -0.035807639226280205, -0.30987520773051835, -0.020603711280780024, 0.0830989488577366, -0.184595211164612, 0.1552459504598356, 0.06250021274381756, 0.19517577977595235, -0.2512857965772902, -0.2654806576573513, -0.13817962951867882, -0.5948115152983603, -0.37176234685661125, -0.2854168641105013, -0.29814340440962256, -0.3600357400761273, -0.43232279396307927, -0.27618871894411257, -0.10468393119106227, -0.49278920347000943, -0.481486052080486, -0.14213244541487435, 0.05036775916473916, -0.5382995723706765, 0.014899621829490416, -0.4485604983457901, -0.35833193361619053, -0.4626399573825714, -0.625421849769157, -0.2927858258603377, -0.4535072526759729, -0.012382939596980192, -0.2999384119549268, 0.14147190805638668, -0.3049860196764321, -0.4381106918518279, -0.07995045433360534, -0.5529900338955746, -0.205376641014443, 0.12579440158232108, -0.22618750114012515, -0.09360801700920798, -0.598130406804705, 0.17005333171457854, -0.6089853260592472, 0.24786624196215587, -0.2040858683743763, 0.02110335823429997, 0.14877103775331726, -0.5359305983422562, -0.3090699715597444, -0.5255899901425823},
    {-0.1423109430103195, -0.23883052588722123, -0.5579340752796742, 0.16924318377466735, 0.21940714285933452, -0.05820617360907833, 0.21834364460126823, 0.16832195157696128, -0.14240468182217073, 0.12201275084020441, -0.19507190440789818, -0.2975040775653571, 0.08899189867422595, -0.1101560030000214, 0.33448679381442636, 0.01971801238549713, -0.1305185146122619, 0.09858689348354026, 0.329429116005979, 0.11490597046140498, -0.21154798621963425, -0.45697764009080155, 0.0487153584406145, -0.19940222618626158, -0.3079040390082654, -0.463640117342728, -0.41307412366879176, -0.40083680848366987, -0.14319669336919716, -0.20530960191575548, -0.37275555978709235, -0.2605651498792317, -0.3832712062829729, -0.012101592651310033, 0.11449009998815834, -0.20193669450780707, -0.17491558171615162, -0.20033439529256988, -0.4245872312041064, -0.5836315129575416, -0.33597485018436846, -0.4458911896047786, -0.3920884479053949, -0.04471418269020663, -0.32860107610945394, 0.3473477536879713, -0.37241313193883857, -0.5504527316552564, -0.17496054552994225, -0.21718745757262994, 0.08352810879383364, 0.3799237583470857, -0.015029630759397143, 0.21489774475692064, -0.19537828371189941, 0.2934604879394341, -0.5192490064342906, -0.017085816928962064, -0.27724365101947623, 0.012233789997358246, 0.11000889907234844, -0.48340258711755973, -0.47724866798084475, -0.22982134095692483},
    {-0.2478349941458523, -0.4368655122918066, -0.3645693164292779, 0.1418649572457207, -0.04154978533950222, -0.3053036250663886, 0.038527055869849156, 0.024451416381176497, -0.41181989930170954, 0.1291342205492112, -0.554492479162562, -0.22591527058775768, 0.09251327091455795, -0.21650530626884282, 0.17730477405178627, 0.05960862038625165, -0.23450378244249792, 0.07201849019007454, 0.00017403932442722274, 0.13385321052756805, -0.3372171794075525, -0.6737528215383062, 0.13956616909439667, -0.487435931216739, -0.5964596219802368, -0.2757401040240863, -0.4449481563888723, -0.24760298197460306, -0.2976736638948131, -0.1377055047436579, -0.12655810932612682, -0.2138991802339155, -0.49348159105076705, -0.4377663441973752, -0.34544476030662835, -0.5659366502592574, -0.34583454640779726, -0.18427077685930215, -0.11766466664970542, -0.5912713159335155, -0.43912672199455155, -0.48562185177082884, -0.3778618019020709, -0.10617790796112743, -0.15327714117703153, 0.06564861583254847, -0.45218024155605313, -0.618800298029131, -0.07910501970413861, -0.38344277781959596, -0.05230716169484213, -0.1577605189716546, -0.12181098183866082, -0.28070483599774837, -0.41119141549044236, -0.1509011977377586, -0.391807987356312, -0.16977328982818737, -0.4109644576680801, -0.016633497772377975, 0.21777988623281017, -0.25316049367787585, -0.37642590024117073, -0.6752459102838615},
    {-0.39583392230788367, -0.7033564254790104, -0.5189036892842778, -0.06886445028159957, -0.026989455300687727, -0.29088819501461993, -0.08990961014458891, -0.0225105096712504, -0.4050368939770317, -0.04293838227582338, -0.642734201921363, -0.3500998502500198, 0.008419293586170606, -0.07363013976365777, 0.20333888903394587, -0.14806956650190217, -0.5552353993599196, -0.25601290446506275, -0.20679419555870873, 0.009806978169610675, -0.15685858078405512, -0.5029785739311919, 0.11767477560677177, -0.3511671611304967, -0.5939494849160579, -0.33596236726009215, -0.35594606241223337, -0.5861991685230447, -0.5703576784090044, -0.43409683877961597, -0.23541359752276816, -0.6558156659833161, -0.6287184945004087, -0.46231143721216705, -0.21758886803530056, -0.31678262250538264, -0.17953601247191026, -0.3167504281722586, -0.499073663022863, -0.6325248557613673, -0.6951712856434021, -0.6089376750889316, -0.47191450563583476, 0.015400315905896257, -0.656980462550632, 0.05052963643221817, -0.5267755091116288, -0.49502810062063374, -0.47310235111844845, -0.5747373366451909, -0.4250903700154565, 0.2258177115787683, -0.08736276471515213, -0.54331473768784, -0.6443280004946733, -0.017452639846244875, -0.42718501159478917, 0.07650721522223891, -0.6091127296179668, 0.18543798840954198, 0.27714608342999547, -0.6227867469077837, -0.5107021434348081, -0.6292665432213485},
    {-0.2263357109794086, -0.6450923714334295, -0.4468832114338896, 0.2999945223356522, 0.11858887036978072, -0.15022742226188618, -0.03550413420481108, 0.28299374042599135, -0.18669943432725958, -0.12214838997613606, -0.5568307506178691, -0.4660810380971003, 0.03572315110094364, -0.2712912078002659, 0.30374832368171006, 0.0635855741391392, -0.4809743080566032, 0.01401384361963144, -0.1654991358780334, 0.01923044119482001, -0.28097960206892236, -0.3669635964536764, 0.21276536479624972, -0.6003946716775653, -0.6287944360954418, -0.2594270852658844, -0.5071572847839588, -0.2922266734424803, -0.5927999914123943, -0.5703172927805793, -0.3385628234198235, -0.5885278557900199, -0.4275234833210765, -0.3147481939134596, -0.2223478536372742, -0.6861594899510941, 0.09991092057971683, -0.2510142680758481, -0.41368122900642035, -0.4034947292384522, -0.3979550634185986, -0.645688620021294, -0.43948611973211565, 0.022471654802757823, -0.5582515671029089, 0.21485927792845305, -0.6661553238965116, -0.44400474566161924, -0.48125712158792805, -0.5532615261213423, -0.2927154637842709, 0.3157663382713567, -0.1070578951445177, -0.48622340928048896, -0.5405877108363912, 0.3213385893115464, -0.4260523020246283, 0.25844872435541333, -0.48032617512780285, 0.008056988763209967, 0.3702845629802017, -0.5748847188120189, -0.5694515697958276, -0.3847558247193035},
    {-0.14734131998705266, -0.6695230877305283, -0.5978261503701738, 0.18067812886815493, 0.17121386337769431, -0.10581306290330207, -0.02401844450567004, 0.3411061712967233, -0.07139899175296384, 0.3021915290656968, -0.4782842045678627, -0.6845182846590127, -0.02065573872695511, -0.435664870260259, 0.5509904028133347, 0.569118615149047, -0.3310744206282472, 0.1032685208497188, 0.3564081713982224, -0.11994142236699817, -0.32593941225287887, -0.38855837975688273, -0.03784544708745741, -0.3040404676232907, -0.7046070529546347, -0.4104089071264917, -0.3845021145535098, -0.46595920405814767, -0.5600133854818732, -0.2508955243854304, -0.15754777927481398, -0.33572453432281424, -0.5993542083855721, -0.14028444086002662, 0.0008702813647548218, -0.5564573559396913, 0.3680099961951161, -0.4060232474304272, -0.3735685039318065, -0.6394051122788161, -0.545915281773952, -0.5853209227717399, -0.47688936373290947, 0.12087183373360429, -0.47949582166154703, 0.04134020531679319, -0.6536159382702241, -0.4487380847073515, -0.43121106151002214, -0.25203138186730034, -0.15490023392627955, 0.28841054658286863, -0.38754653648161613, -0.17582298989979298, -0.5084318598049117, 0.22580843580004625, -0.6597313604248819, 0.03464885050652794, -0.30867978963503834, 0.25640823300593013, 0.16529617734772042, -0.49230089704505925, -0.6491714238141675, -0.5961354491498022},
    {-0.6579563395686343, -0.48743102698274454, -0.6204813261448296, 0.48939054293577966, 0.39279010208721715, -0.04759820838986629, 0.051255467203579236, 0.21248794998964943, 0.02064465521812804, 0.3761088515987915, -0.5558096264815285, -0.4512316983743645, 0.16757022114243608, 0.2042473394032611, 0.26290553802499417, 0.5109698960398873, -0.6307966808701709, -0.3279630402522334, 0.4517592364651422, 0.4423525811416884, 0.27443248460889014, -0.7220035977043389, 0.08288815808431824, -0.5282924538304542, -0.23477865488985464, -0.18944208181606786, 0.060769256005356195, -0.2223980748580543, -0.4833071830017872, 0.0019015184465506645, 0.3336456440319036, 0.2601286371052239, -0.6842191941175424, -0.2865053541708988, -0.2961625672527721, -0.6707554765188177, 0.16496604946599533, 0.1451498364059116, 0.13915619718601577, -0.4900662679493336, -0.4148192867703892, -0.35191113788034656, -0.4261614170672569, 0.17582548000038623, -0.14344753151112452, 0.2473336757350215, -0.7027334167859836, -0.4776267058185322, 0.15552601074779976, -0.2072357340859677, 0.022139203101712177, 0.13928024541289935, 0.16723872080743432, -0.31990465647149147, -0.444929715089192, 0.1494736978290493, -0.5568302879278194, 0.18415413637250064, -0.44031463537656096, 0.16730105526061637, 0.24051097018255085, -0.3135992122530653, -0.7632861387082853, -0.3730542274352084},
    {-0.6255140136908821, -0.43850814114982845, -0.6984530511503423, 0.3113668066650414, 0.31003616410105345, 0.14705161322757837, -0.031828620344695885, -0.18143325319324666, -0.18080666252326416, 0.20328073070239114, -0.6469489182674023, -0.26476921150071303, 0.1742783819314404, -0.1387248196479391, -0.025170663162520316, 0.11724398144426612, -0.5620576438885835, -0.09418231754102738, 0.18914365288891383, 0.08038351714157381, 0.008694987680571772, -0.7922672368902197, 0.04689679759833187, -0.5740174215079847, -0.3207007863013912, -0.5479895562734671, -0.4749814260502731, -0.48512264531707805, -0.47924771517706377, -0.16615488072130816, -0.047424131435514945, 0.07400840501862488, -0.44812936132090225, -0.23372631036182617, -0.4438083814695715, -0.49192824671001256, 0.17962941963685833, -0.06529330491822834, -0.2254838524194629, -0.7535158847203763, -0.5192296054723785, -0.6611814784754778, -0.4459724755216956, 0.15114778826209063, -0.5974794169932242, -0.010637568526836033, -0.42264862892322885, -0.47489033255159735, -0.007847926252647396, -0.1663928341269415, -0.1702657196159783, 0.18449552990024776, 0.28647938101343234, -0.36630865321670186, -0.6837201114344764, 0.2711688518174849, -0.446252537183842, 0.15556815561437706, -0.5476731574265625, 0.08050323701273895, 0.2878504388671001, -0.6543137204722921, -0.5786979704377845, -0.40145788962628126},
    {-0.5208334534524944, -0.620315097266406, -0.5873270017413997, 0.18491844703304636, 0.09515143959819578, -0.09884779639720173, 0.14472864283975728, -0.005963385150888224, -0.3318060859119422, 0.231579505643171, -0.5700244285876586, -0.5725042377424748, -0.1047211308355263, -0.11027943169398075, 0.18603825029321347, -0.11599281538907846, -0.4799014282545242, -0.16163584989839083, -0.11326220573349163, 0.054715063049353606, -0.2723016366954163, -0.6874721672071197, -0.03918842054218697, -0.31784087485830376, -0.6436488090737517, -0.5720346201116184, -0.3099371780889527, -0.41200391828341215, -0.5349725456433997, -0.6252115426486541, -0.13195826192770196, -0.47541616266022424, -0.4671320613644317, -0.5324078503589003, -0.4638612013843149, -0.5184938612585341, -0.019808126862121224, -0.20273800733790062, -0.5167330497350429, -0.7111351817552471, -0.6762905464423946, -0.5029950320246851, -0.6495785147352315, -0.0774426570772192, -0.470619177429335, -0.03899137878238806, -0.38781082189185695, -0.6707511430722196, -0.13852867364327412, -0.5005883223570937, -0.22000552786152794, -0.006810223194140224, -0.11621033107568124, -0.2985474281430195, -0.6508683976498283, 0.14058449676227514, -0.44848290510160077, -0.12980234624637568, -0.5060774928816772, -0.009595908250826365, 0.07314075356692595, -0.44448188532861505, -0.49430492287722977, -0.6138862831756231},
    {-0.5458968954026934, -0.3068644289334587, -0.4341207640338775, 0.38436610837149326, 0.2628745177484217, 0.30021753767843223, -0.15856895825224954, -0.19092655420952295, -0.49506753503026535, 0.059774157397353346, -0.5875327254809568, -0.2584072662894156, 0.09999656287865853, 0.26384296559790393, 0.09958972982959326, 0.2517755890582403, -0.3630191065352593, -0.06971455388283548, -0.04557463903228725, 0.38181996058696943, 0.032886298261960385, -0.5027315452891814, 0.01662907153337895, -0.2374301001695703, -0.23176861278947528, -0.6189186452862011, -0.395136537965132, -0.5155940689578686, -0.21236961467723003, -0.19565422035901703, 0.2898031753258536, -0.21296416655703132, -0.4337045780833265, -0.08661659389668636, -0.20944024590571278, -0.7091292140588865, -0.16221618014659325, -0.0420599351954667, -0.19475132706720638, -0.4404618457654013, -0.4090789717864671, -0.4309189341694717, -0.4036175333437885, -0.0413718947022052, -0.3959819528261452, 0.07477880674581226, -0.70327465897325, -0.4125135644873944, 0.03322840503130181, -0.03652196602311091, -0.014009120101770498, -0.009191772878265092, 0.32466162503591206, -0.44135767550741417, -0.39819214633049355, 0.28750203883919234, -0.6678170710407619, 0.11618457582008088, -0.2563724130725399, -0.17602649796494488, 0.23739133060663423, -0.26635254954587023, -0.6830473599754036, -0.7202716027236734},
    {-0.3246358270667219, -0.7034971096285833, -0.6162569008927257, 0.2258925995638634, 0.2726225295617831, -0.013238057775643677, -0.11025081717090596, -0.0599986331822077, -0.34780567101803955, 0.37860415044592327, -0.6594433752658274, -0.23037278220368076, -0.04296858747943147, 0.09102975373522039, 0.3839831973379605, 0.2714567096250693, -0.35647068571090396, -0.08343442655728069, 0.06823418536008924, 0.1948689025512137, -0.2342980116845475, -0.4766666064180664, 0.09189151047527276, -0.36177164934602407, -0.38279464006282443, -0.325717711996969, -0.08624751263311146, -0.5374365086111069, -0.5376825950988415, -0.12028833946177521, 0.01775951820834713, -0.04085777079110114, -0.5409234499351695, -0.07559158922957433, -0.31878841939659025, -0.623288158903409, -0.07512763373127757, -0.11741584891376691, -0.3060346332548264, -0.5827099993148149, -0.5954419199923175, -0.6918207970724242, -0.48298561422790465, 0.09479688771714777, -0.36047126974978594, -0.0792461641673399, -0.32185872052723136, -0.5739567413631911, 0.005711560548852247, -0.15403817951859747, 0.01865314771699728, 0.07778683591043563, -0.023488905962538317, -0.3899761752513025, -0.6729577558845354, 0.20256984635832395, -0.6831965572419154, -0.07887126138843757, -0.12211638290610884, 0.14723854441832265, 0.20246946081334907, -0.36828029558421466, -0.5043283586654621, -0.7387685109884161},
    {-0.614845657313042, -0.6808046159382511, -0.6525280311049946, 0.2022313015115784, 0.16946985996149397, -0.3355226578549034, -0.00045978467069834726, 0.2159701991687235, -0.18280958354039306, 0.23022063524725067, -0.38839249187636965, -0.34878125296388307, 0.013092661403493615, -0.3844332882031467, 0.28277639585706016, 0.17468840191962634, -0.5419737329603518, 0.04506055245256584, 0.23201109337077594, 0.046457697230162, -0.34462309279239484, -0.43991784247476223, -0.1613614558628621, -0.344563151159378, -0.5753488966992955, -0.46729225889133663, -0.15695317380169535, -0.601584193640866, -0.25624838323924426, -0.19530245894156475, -0.05352308127157592, -0.08784668925229262, -0.5200358390745399, -0.09610816983609796, -0.3060852464901645, -0.6011643399105269, -0.0606794866766721, -0.24136588921635832, -0.10642095181877201, -0.8006412087349875, -0.6082878382026013, -0.6846051284918622, -0.5591168149177075, -0.0853107708212708, -0.34584461426497415, -0.16232495058352567, -0.5462203577015331, -0.6404407226566864, -0.3086254666020089, -0.4498514519675483, -0.11456196327560828, 0.23065572456295746, -0.23614983635062503, -0.5004048670183928, -0.6104630109291009, 0.31637845522625135, -0.5617441679280661, 0.15655755500616986, -0.23073914390726472, 0.11089100708395548, 0.37969284368932177, -0.5198623770361601, -0.6687965294430541, -0.7013413924403263},
    {-0.5166827622023301, -0.6988629495293956, -0.3986242796513978, 0.2435894027382386, 0.13238463472390424, -0.03148395108843384, 0.02577398562150564, 0.14662633880179757, -0.29581179076371544, 0.13962326201149788, -0.592091548000469, -0.415700714313956, 0.13488610846526544, 0.035190939508270826, 0.15589010001963657, 0.3880463405463939, -0.6328510422021411, -0.0317112183274016, 0.239818812236279, 0.15375826182856758, 0.060648250219645546, -0.5318644784751387, 0.09813341301593814, -0.2737466483756794, -0.4261603621319176, -0.6262797473489836, -0.22443605960723773, -0.5743336717483879, -0.5004683793348581, -0.19409101040726212, 0.020397955621910616, -0.24246649536882728, -0.49209297338450775, -0.14498454979542827, -0.3676932886047922, -0.3815269896810707, -0.08583349502528335, -0.07719447988123028, -0.2810422272762784, -0.8044539787224134, -0.5999862034800368, -0.5779583763814011, -0.4789968129245061, -0.029879327298082077, -0.36656127441266906, -0.02439020908488858, -0.6162327885657127, -0.6167183123802729, -0.17851949515533982, -0.06375145555728326, -0.12093849963597882, -0.15775133457309048, -0.1551895856906848, -0.30256213062270715, -0.5962797668438483, 0.22936250328057944, -0.7015136204027639, -0.08441538121581596, -0.28549281000317084, -0.1472306708056552, 0.12996461267343234, -0.40146255972518985, -0.5390808664878208, -0.7692457535112117},
    {-0.36626661862339166, -0.5495923594458679, -0.5873522279675483, 0.24518047461208284, 0.18866338895061083, 0.016043138699628458, 0.2189589053661655, 0.0543052057871249, -0.09362723972915901, 0.15210211369477394, -0.3385079249589842, -0.30164903452987013, -0.0007855535287515367, -0.06233838938038929, 0.33651448721472504, 0.203950516008244, -0.5168363414037608, -0.04875359785249513, 0.27219250446763055, 0.44273620849193407, 0.06899590863485151, -0.610178257933579, 0.2591522069776849, -0.2947908507881233, -0.323993505761467, -0.6023206489533147, -0.27020116166737257, -0.4382347088467747, -0.2513310701896468, -0.18479623668269096, 0.05556950658890176, -0.25356918856208377, -0.5070062660229165, 0.012883416277297556, -0.02107293821127806, -0.6055759324110985, 0.3097685970531143, -0.0788925590501974, -0.05291771114987623, -0.5009917445477694, -0.2505925440116228, -0.57070087893619, -0.43432611426135687, 0.30100464014304756, -0.2946562817091878, 0.13415170445619853, -0.43059555211373124, -0.6576277310314809, -0.0747467711209625, 0.059347752081151756, -0.032885393085586676, 0.0958295907115615, -0.06152715186818701, -0.5063826291228761, -0.3679949800996296, 0.4725254999487462, -0.7464365825712865, 0.22421387328767972, -0.2701410344924785, -0.03142443947945833, 0.3242934956337868, -0.4246189413372668, -0.6177392624731551, -0.6982011547960255},
    {0.48692417853744435, 0.25786262607249977, -0.05994892773491049, -0.4013847587755694, 0.33961893745829075, -0.2240739973102795, -0.3061541744619937, -0.32851800925240765, 0.09243260076107723, -0.0354676203676084, -0.11032236162412758, -0.3244435040795033, -0.43136821869198705, -0.18496434828884772, 0.2941124064791468, 0.5058620965934819, 0.17607286638670777, -0.011202245757758765, 0.3154519710600989, -0.04779901418208158, -0.2614776986484047, -0.08772225369413819, -0.23460120985919475, -0.09077248487052315, 0.0027857850725568666, 0.45027144063091135, 0.12672677610003588, 0.1529692459123759, 0.4402819242021595, 0.19080267604608916, 0.14409743773054062, 0.16546145840580476, -0.23950018745149487, -0.10881325023258064, 0.46505186591365794, -0.3791413841480531, -0.49952589029933553, -0.031270173206197835, -0.2296867727719354, -0.158982075692253, -0.14950127179796321, 0.39528452752830134, 0.5017057331337172, -0.3172606655335091, 0.29837333191669885, -0.1591134111686521, 0.28753122881098464, -0.26745457772563314, 0.40458974277246584, 0.024987745785154624, -0.48154485898747673, -0.3665450945523962, 0.060076878511543516, 0.22558928072761678, 0.3848707184612405, -0.15923784907065455, 0.001985753916520287, -0.41720503787099744, 0.2951441667544023, -0.3272385712706216, 0.3153186572665898, 0.2497119534847829, 0.10068549765369779, 0.09414668021070467},
    {0.07861961006601353, 0.43182803714987883, -0.06706714246065944, -0.4188395570289141, 0.25233172623289996, -0.2983171740244712, -0.09701476360866408, -0.09336520872584314, 0.4710615571515126, -0.3378347045663795, -0.1945976520943152, -0.3043968772750857, -0.20544400274027422, -0.16734971460317996, 0.12544060658011263, 0.5612036956885706, 0.5914145003074502, 0.05392665846521997, 0.47686496604999484, 0.18762432144495278, -0.05985493470750461, 0.023731234368512318, -0.14391219822354429, -0.43444974744385906, -0.12338892683029906, 0.4129925533410805, 0.2980408771821107, 0.4498990488093931, 0.1373771119300357, 0.41481690299969515, 0.1656486523529531, -0.050172236871288085, -0.41487315464378355, -0.2989047560041255, 0.1773481894051607, -0.19622110137678417, -0.028048541797362082, -0.19037304783673892, -0.14523043172526537, -0.05479538065364953, -0.08205147367160577, 0.20784661174223512, 0.5166836293725899, -0.6216123320159116, 0.09666904981905959, -0.471691277542338, 0.5861602748388997, -0.2255853329424262, 0.4121934021504213, 0.13455703382560974, -0.29250644338328874, 0.08867421989289286, -0.3416890331742688, 0.37671179637801794, 0.27327257811110994, -0.09433524170968766, -0.22846064216840764, -0.43854698155220523, 0.1401920564114025, -0.07850310808485085, 0.6232553027071116, 0.4673850656857729, 0.13861811201157015, 0.4083686529760506},
    {0.06879656241656343, 0.40160993348008667, 0.009724615602410443, -0.1938088781916874, 0.11799135923960126, -0.13025295425407038, -0.42030236894666906, -0.14597382632903205, 0.1627561133045727, -0.45931165970663246, -0.2604930340914045, -0.20879667470625873, -0.36311665896266904, -0.2089021144135569, 0.32597990098575325, 0.2964211252899595, 0.5703570450745192, -0.031457628333905446, 0.6751052484070086, 0.1864023789051266, 0.05910924136141856, 0.17179754759284432, -0.5247878581160492, -0.4258676945890071, -0.20282087845462235, 0.28291037724369517, 0.6312462660530107, 0.6370956552933922, 0.4113257529525474, 0.4967094786128932, -0.15965527216963876, 0.3176422949661197, -0.17952116937715148, -0.6020077093770339, 0.08966096308963539, -0.5333859679581006, -0.16998671565612916, 0.001195763193235222, -0.5049463902748409, 0.013529131753037374, 0.1594093186072867, 0.6045413002682772, 0.40526168158466486, -0.4599432668827732, 0.42568804842005004, -0.38101213070889045, 0.1905442572503303, -0.2640101734669121, 0.450381223709351, -0.04095355827531775, -0.5713282231044764, 0.049975570986397606, -0.3700821544345993, 0.5213702272673947, 0.2563438669955071, -0.3802074773211883, -0.46748453651803007, -0.5278939580169971, 0.3345248660259391, -0.3249691120873875, 0.6018752855512123, 0.3077505401193105, -0.12546190187345696, 0.13589438941617235},
    {0.10861711562732082, 0.11030538637985454, 0.04325352931486818, 0.03194097146499766, 0.4804768203566047, -0.362664963809739, -0.17345365510862687, -0.4436285085072123, -0.010318453886063993, -0.17327557074506714, -0.2307919142060877, -0.2940812546900983, -0.526172022150257, -0.24513822462072804, 0.07230058744767955, 0.5468806361915135, 0.6640024293139721, 0.17270401999592894, 0.5264739088107458, 0.33824375900291576, 0.26783900059149834, -0.1680324985658169, -0.46375623299571384, -0.47935521052520186, 0.07869468348975373, 0.5237864485398964, 0.5132589771787727, 0.5504488408951651, 0.5914701599658616, 0.4624650571990898, 0.05249612013421028, 0.28070514187689916, -0.13814785500168505, -0.5307156886424103, 0.11135040267674522, -0.16111961800705016, -0.37150412921091613, -0.16097201801454927, -0.4345311398380765, 0.26086417292905656, -0.039162230063241, 0.27815780731185114, 0.13475451936511532, -0.4732528923273979, 0.28791954286785204, -0.3930996805921457, 0.29492173519585185, -0.49646819867008835, 0.39534713580158787, -0.18976065229832065, -0.49323567818388125, 0.02828487318305108, -0.2782985989023049, 0.44461719739094563, 0.5438804933301608, -0.26007460359877543, -0.1284624694567154, -0.27183615773883685, 0.42539911178239465, -0.19292585806739637, 0.6221808438687956, 0.18853266856721376, -0.18376537791559303, 0.26949984249843856},
    {0.38923488614637647, 0.1795001539220173, 0.1643819729061535, -0.24692707815611784, 0.5099030390489689, -0.08687774195826971, -0.4406663418185335, -0.12261611834358088, -0.11502924423664736, -0.3855244531280675, -0.17645174508414463, -0.07210994497327772, -0.4830845179446988, -0.4453524518273479, 0.12345847866646666, 0.2844209385245534, 0.3894394082468949, 0.12300246669993066, 0.4474715470228849, 0.23663191943717954, 0.2734726807936537, -0.1706480811860119, -0.5237811888868974, -0.12358141786487113, 0.2558194103654674, 0.38038204357272015, 0.5687700174372139, 0.5850617609544275, 0.4604679891884954, 0.6425492943373041, -0.12666149525805548, 0.11568670224937297, -0.03847266662925142, -0.5241945258260161, 0.17727837831618698, -0.3954305878711693, -0.23398587418454495, 0.1201951627183943, -0.16069117744508327, 0.1377482663562144, -0.021177186991441114, 0.4637967991877423, 0.18931266999327595, -0.4247365172225462, 0.08883955407052833, -0.2898580367756723, 0.5347215909252641, -0.4047965856554486, 0.5854230964777061, -0.015551558563820513, -0.3872189833662466, 0.1720924214779108, -0.22682198602050943, 0.35889048242316635, 0.35440787395609513, -0.29800281635586195, -0.23942034836962806, -0.28507457053602403, 0.3468881995387368, -0.15092069638560823, 0.3479742163792594, 0.3995157873596129, -0.04947441053416979, 0.17406393608104753},
    {0.3961640476832978, 0.1282785908155082, -0.24790541109605857, -0.18631874199722334, 0.3445707297081228, -0.09422780243780879, -0.11720208289512932, -0.41080824960176127, -0.09163051555850435, -0.6315916431091049, -0.40828014754730135, -0.050195288642855246, -0.2789199123425047, -0.2494972261422068, -0.07243788942623725, 0.3089742007813349, 0.5406052180249873, 0.384605538575775, 0.5531245529435284, 0.25429352434602726, 0.38802899478365327, -0.049274851134589986, -0.1974699512768724, -0.4165443294075196, 0.0515697523801986, 0.5034088841391349, 0.5746721429164252, 0.3689663723190991, 0.3121254439684108, 0.32207042465161473, 0.29713883074423725, 0.0970774598876377, -0.10170075555266858, -0.46504661451236984, 0.4844957639497699, -0.3523787189262652, -0.21026064478462375, -0.011626172459571732, -0.27255876209119617, -0.16368317707713248, 0.22812170113588576, 0.6153044512434891, 0.5902975061474806, -0.5940830286534902, 0.299137264865271, -0.47466751076179053, 0.43752903399806126, -0.41215770369184845, 0.5445875801394418, 0.09467335040962413, -0.2996993739170546, 0.09179943751757962, -0.02597255776633771, 0.5961985936884834, 0.3460906495157082, 0.06245872398011767, -0.3098415853091622, -0.246173930184812, 0.5982394010808654, -0.06569942407232661, 0.6395701462955325, 0.22085586932372198, 0.09348337257001284, 0.20707031810017654},
    {0.3767576741801464, 0.1130796984841718, -0.3655490728859614, -0.08494989099785961, 0.46124985893197634, -0.11299093112463804, -0.38710579217085916, -0.39092514418139096, -0.08775699908801686, -0.6497429597915116, -0.4810889588683307, -0.38714866572833, -0.502555924569552, -0.2420691506094022, -0.12777841114068447, 0.46774455355942895, 0.302658939935882, 0.35609886967211, 0.4138236859492229, 0.4075346113315547, 0.29138382733017804, 0.0030596737797561595, -0.16436622861547917, -0.23326598827819905, 0.04895761202171056, 0.628243551318826, 0.29374235751449423, 0.40416002793782047, 0.49015148682712617, 0.5885491500936052, 0.02485741617530051, 0.3276667927588898, -0.35653085788537237, -0.49249208960397806, 0.4341922197499568, -0.4373943461142425, -0.32651051822309424, -0.011777238196454595, -0.3676604102980584, -0.0900278098772106, 0.2816504489399226, 0.3694110249702153, 0.4469453663278577, -0.7065619435120339, 0.3344465766708898, -0.40017603975841376, 0.19656755298716239, -0.5992054989926834, 0.15394654606726346, -0.3636788003560404, -0.3014681668076816, -0.2994194261275055, -0.09494751578094764, 0.5971676488065328, 0.4317246632535164, -0.1874900351427992, -0.4212941548717508, -0.3065981584116663, 0.5094451401662234, -0.14027547168844354, 0.4874447153497759, 0.3420577907736667, -0.31063638610404526, -0.012693300155611868},
    {0.3575945952641785, 0.08615937450943711, -0.01985684526034438, -0.400335328201616, 0.37323322306699314, -0.22492443486897418, -0.2506769766668627, -0.43247324753943295, 0.16844732475032523, -0.667933781163806, -0.31553445957883447, -0.4066058612088861, -0.5486439359641176, -0.17175125546525594, -0.14958646242635304, 0.10926025864480055, 0.2544940148460012, -0.030856612558186374, 0.5708490446588692, 0.27345571158639437, 0.2732613590311457, -0.03637826597207362, -0.28767591712904994, -0.3801078850656432, 0.24205497633460007, 0.25905653935450673, 0.6004172981899705, 0.48552074010911456, 0.39524369369812695, 0.6217496591483127, 0.35560067109317894, 0.3316838173331028, -0.18224292843465176, -0.29255607977283454, 0.14088515445825306, -0.3802851165108757, -0.47135070327834927, 0.060808430176776916, -0.49721550282887544, -0.19288654603419914, 0.29358316231283743, 0.6149533148431064, 0.5765755136636858, -0.6958620721265982, 0.43569592025950404, -0.4782407384461123, 0.4243082569255908, -0.5832721028034962, 0.29302084313625504, -0.33758876478421423, -0.3889135422687357, -0.1702649643404848, -0.030187528783796644, 0.5055796474646624, 0.5191139988768605, -0.14314958601380798, -0.3579752335773714, -0.22594452165180332, 0.46021224920746684, -0.2967749714146968, 0.4109698751425376, 0.6047057186247842, -0.14055121662388972, 0.4088170725672773},
    {0.16813257065238105, 0.48079333155561405, -0.4160329595485552, -0.37026563394468476, 0.5078690139373669, -0.47744308112654604, -0.21840017953832594, -0.44063083309107637, 0.4311651795633419, -0.6542729616043107, -0.4150858199418051, -0.19727755254198945, -0.4213122119310344, -0.36301091540665653, 0.19459208348345378, 0.16733723578968132, 0.20266280792981653, -0.08097902075161646, 0.42137473597917036, 0.5283878288377454, 0.11010287713143266, 0.26882606373772394, -0.34630340283537403, -0.5214229361158846, 0.2653256994255362, 0.6499260243145033, 0.4936611080612006, 0.7117924505637142, 0.512285228674098, 0.364562264979925, 0.26178191562569314, 0.23910261382319128, -0.2714621205712222, -0.5504729939687742, 0.28709948438627325, -0.38674929179531425, -0.3564972893329182, -0.023938964441321386, -0.5779622611847242, 0.15809166722697035, 0.1532578187120212, 0.5145682622530977, 0.5552981180471017, -0.6775863996870117, 0.3179861139924676, -0.368981262318704, 0.3560229685571128, -0.40898404780972597, 0.5968655216915474, -0.29204285060195145, -0.3476993250090445, -0.27319373175261247, -0.3156388081819579, 0.34211732758996605, 0.3977208623677957, -0.4251427302080925, -0.4619810332031033, -0.42631383921159816, 0.682313750050411, -0.32756653780949146, 0.4103403627076248, 0.5952634743069245, 0.003773399999149745, 0.2629781524894856},
    {0.5094514520284121, 0.42404810009912736, -0.227963742075428, -0.16736428620879587, 0.2801890231968095, -0.5241072342008685, -0.4437469719663642, -0.36529495094061226, 0.4650116049438483, -0.45158957814654416, -0.2469440896083093, -0.0685914022331905, -0.3444202018663636, -0.4717958174076247, -0.00905110607249901, 0.18280660053675657, 0.3235978276113074, 0.11483516868327412, 0.47620145826238175, 0.4316897954576128, 0.25583029353779757, 0.20595939757824677, -0.409614935395162, -0.5283880604991695, 0.07115665655412447, 0.4627701737918196, 0.5078095756630069, 0.6466315980710211, 0.18422071815923555, 0.23394389225037773, -0.00466738044832634, 0.3409889244870808, -0.05955989963509336, -0.5283562241793748, 0.32076002703233775, -0.5248411232097384, -0.45825494323175986, -0.30354894324942544, -0.6667854507866525, 0.1942148805223959, 0.10360692507459385, 0.360010222077804, 0.30460425881446646, -0.6538610155639345, 0.17680179501897156, -0.5163295126982503, 0.4456168034616267, -0.31681339996766356, 0.5708913587951454, -0.004197980566567807, -0.6347469718588966, -0.26223986480000766, -0.3177823251267286, 0.2748183650988585, 0.5147721542470786, -0.44276867360710903, -0.2660663411270135, -0.2977743166524128, 0.3816241125874611, -0.06028321864665395, 0.6923500197634125, 0.2937590907756297, -0.09188004398714422, 0.22349886019178564},
    {0.4321626584856387, 0.4549968913183789, -0.36862579067238255, 0.09868483812108889, 0.44261333423675825, -0.27816899467372175, -0.46481988723811946, -0.3683228152396773, 0.6023963915296332, -0.6322818209146716, -0.2549882087640301, -0.25975518541249154, -0.22144811207713783, -0.26357115769712197, 0.308122541301523, 0.13861423382034463, 0.5203685720431789, -0.15514960226324215, 0.6841930952102766, 0.5186592260246513, 0.032568921350491685, -0.10177796566079413, -0.616662705113963, -0.5456399493811096, 0.12286808721174623, 0.44147672061998233, 0.3178661000220181, 0.538675964739562, 0.20399047415857446, 0.27201018211423805, 0.014519548846606363, 0.3134254077334603, -0.4712222903447497, -0.5209490568116327, 0.23316635720553255, -0.1385920534714819, -0.2042745572735314, -0.33014760024420514, -0.48719682882481485, -0.21767218052725046, 0.12140326934094876, 0.448970788897709, 0.19646682938306623, -0.5387276951170653, 0.4527685617651862, -0.5206623617015954, 0.5053814476493018, -0.2466411338060914, 0.28898845091853, -0.16951666079628164, -0.6401967651660628, -0.06060774832560165, 0.09359460351511628, 0.453240488282197, 0.5601810191830962, 0.015107273263862802, -0.1086161084343861, -0.4521590269750872, 0.38484857277550344, -0.0292693635753505, 0.5609260412353243, 0.3112988734394831, -0.12495576620961504, 0.3556117384728261},
    {0.2790989224012284, 0.2714985274663023, -0.4056911566986926, -0.32671830538504326, 0.577596046872302, -0.09588553837445343, -0.41506089636431565, -0.11021710786464721, 0.357276629126348, -0.424059833424597, -0.3576571721754087, -0.15159626852937344, -0.4711603788198064, -0.12577247506725264, 0.462446901549916, 0.4226177875391098, 0.4550350189243692, -0.09243182503314712, 0.5484318036566556, 0.553350382483975, 0.3625295227541102, 0.33850523614062206, -0.49302387533095327, -0.5163144613475422, 0.09649259266753485, 0.5775057750745264, 0.4307111226037234, 0.4465231655640258, 0.38454150641009144, 0.5025826945938022, 0.26798120275995674, 0.44563817942763484, -0.5119570033432591, -0.36560216186467565, 0.5758939613785605, -0.5349493329569404, -0.5429186403604825, -0.19731176477465417, -0.5323864133390482, -0.12936470046372775, 0.1439206892649046, 0.358198151367869, 0.2897212906772939, -0.38970081795003664, 0.2809167463073619, -0.5129356776980051, 0.4178019101625276, -0.4656449744032825, 0.45106007987197266, 0.026000914852924908, -0.5920847262959347, -0.029819945699150533, -0.12649284804036698, 0.2682014723530276, 0.5910668211922951, -0.05680013647331123, -0.41856654462963844, -0.5626809941976166, 0.6923044321383988, -0.18122468306423684, 0.5559242258772729, 0.6147177409012209, 0.04752111175485847, 0.3619729072076526},
    {0.2507594897396245, 0.0990216272043406, -0.16655114555239553, -0.15531481316316612, 0.30787138380775625, -0.5185466897792839, -0.3593292164162221, -0.20051882950415242, 0.48196085984443365, -0.5255090174295786, -0.34116320709875053, -0.09255719822632383, -0.5262658224617242, -0.4627663852036345, 0.13808332052381234, 0.24480494588429477, 0.35638493261323656, 0.27868487603076314, 0.7000647584010327, 0.26469002889741305, 0.15375318561619303, 0.18137459371331016, -0.39581101116441003, -0.5904705100080307, -0.1297718808205791, 0.6439099801990328, 0.3705916693179553, 0.3843024620056526, 0.6167686957108982, 0.6187156842084047, 0.035166244622129916, 0.2543691887126081, -0.4464487855642857, -0.270033231659299, 0.26491036007558555, -0.34976503913783713, -0.352275439080349, -0.1372413885402009, -0.37727636901227507, -0.25554023160901795, 0.08001199605732441, 0.5267784200197658, 0.4141879517482761, -0.4513637583149019, 0.48114626200881605, -0.28571211274813446, 0.4389962596961406, -0.3526805505505196, 0.5294508089353885, -0.05937696894454486, -0.4368613043991362, -0.3630902336255539, -0.12380407496043525, 0.2117283000653867, 0.45862356939082677, -0.21270143203691735, -0.28120794107508645, -0.5262791218572319, 0.6713135061719667, -0.35493397362876783, 0.569412949298331, 0.3539099494447427, -0.09588442501626392, 0.4086053678794884},
    {0.2885010286284929, 0.2571487847245589, 0.009594431361007676, -0.26667856487085234, 0.28931068249771674, -0.4737962972338691, -0.29341539603161637, -0.374657738053326, 0.3129491172490216, -0.41924725203966545, -0.16524102675155147, -0.2909908001247227, -0.5134446972217818, -0.3665317902521166, 0.07722693331431482, 0.3137393208923138, 0.6044515965518245, 0.3020074693463675, 0.5982710067649296, 0.5787539158701789, 0.3288511445676423, 0.31050568262100436, -0.52663459170056, -0.4357882824535161, -0.10072999034552549, 0.6273782982005642, 0.35449522386469545, 0.39489682386910424, 0.6326235121235878, 0.3654396498671732, 0.018721335083134026, 0.1831726269241282, -0.5539756844209653, -0.4521007566890334, 0.5441109169708577, -0.36791266713191445, -0.48254879724496086, -0.24210504017163811, -0.2838587619860657, 0.028712099853526796, 0.09577890162838011, 0.6552085854260984, 0.35170011542724977, -0.5182973875343206, 0.3505102323281405, -0.6030573865305372, 0.23689964872303595, -0.521890123094764, 0.28982814610781094, -0.0764560025198611, -0.311789818757144, -0.029217270390397166, -0.1923460366537008, 0.37963596821820333, 0.5217940194326562, 0.04463792778747324, -0.057232456508566835, -0.3880710580660649, 0.47269678010050886, -0.32364163892201714, 0.6136013537548876, 0.49657952273740635, -0.2630160240358142, 0.08206930995944954},
    {0.133422112383155, 0.4446824476657086, -0.29007650844396415, -0.035048812141668044, 0.3938119290212578, -0.5805134274372996, -0.4710104808420514, -0.4083377948825184, 0.5575149534912147, -0.3852522577534552, -0.5280660027402376, -0.3598398175025023, -0.4558436164055969, -0.27184384735559225, 0.19383241309259971, 0.49761271140447755, 0.5679106922037781, 0.031691755373890886, 0.588578109422152, 0.5305679603797995, 0.18472492371165902, 0.12423604777398667, -0.4528920636143928, -0.3813475025861114, 0.25596990035124173, 0.6650976368535344, 0.5544142668042058, 0.36436493362414946, 0.5923110584397923, 0.6645362822726603, 0.2950040912265665, 0.09188744030064148, -0.5221898023918845, -0.6230335775645802, 0.5771466193509511, -0.5598123223377638, -0.5831020515559409, -0.37742121301043285, -0.5234835521940846, 0.21766120469327627, 0.3934383215645816, 0.448283758740092, 0.2804633658107137, -0.26442547577315234, 0.19541435098353693, -0.3109754981900318, 0.46800618376885245, -0.2282699656650662, 0.2559078295079381, -0.13052802979163342, -0.43641144385197744, -0.41933393673861974, -0.28663381204710264, 0.3909520960635778, 0.2443018494825419, -0.12417797466717861, -0.2861412600945213, -0.4501722458335527, 0.24960576796435327, -0.24331365002011, 0.36261350305867984, 0.2752773081583078, 0.12110766856674843, 0.32556748807983504},
    {0.2742108085089691, 0.07644668844647225, -0.15025773405700998, -0.2802715654589247, 0.32863409597749677, -0.4074037213098138, -0.3939260398742152, -0.1989056258201583, 0.23820856217273126, -0.2364997701474781, -0.552717219427354, -0.43542496458072294, -0.6279007954545399, -0.3346869623025838, 0.36334297042626756, 0.3296168503295593, 0.6319189124809692, -0.18762580306130136, 0.5483249118226363, 0.3031822928823905, 0.11265164350740071, -0.051310625453799, -0.3346666890598811, -0.4202865330744952, -0.19236126112909677, 0.5888321845693042, 0.5899726223347946, 0.26942067432372285, 0.42713526177673483, 0.5151359314909881, 0.09548921093989884, 0.25794603688104517, -0.4527595389004652, -0.607842583548856, 0.4760834302213208, -0.42233662642414876, -0.43277951325851755, -0.17104469214852697, -0.36588579371939145, 0.12190291124056223, 0.21306499801916662, 0.5047068288380279, 0.3312287438296123, -0.6377109117118336, 0.42761268967180904, -0.5909708717068919, 0.4399555694604688, -0.2979281145467029, 0.5751267431373542, -0.4570502266347087, -0.5247378387637297, -0.5071919078029078, -0.19194960506330963, 0.4816402120278438, 0.2569733179009599, -0.1396295824280552, -0.4706536745475111, -0.5830917272883585, 0.40260648584063463, -0.3049719830698603, 0.31931230593277954, 0.3757942886511685, 0.16773382950700344, 0.18675979451029961},
    {0.45480662651554404, 0.051514990020184795, -0.4712102603725215, 0.014188565395913122, 0.47220488435845664, -0.38243988752005376, -0.16339551836208122, -0.30432466510553324, 0.3116646624354624, -0.5106330101627831, -0.2573580963283389, -0.08568610562557397, -0.531575201024405, -0.5045798236228942, 0.43499281485917535, 0.2752561825007688, 0.46214519425236755, -0.10521061944032939, 0.5611748831073186, 0.30945302449110024, -0.1433824679955151, 0.04266235285573916, -0.5886022466778399, -0.4608407826639838, -0.04256647549621286, 0.4843570863883309, 0.7057336133005311, 0.6585424113434887, 0.506213866611401, 0.48513956477773956, -0.14932970472375698, 0.04483110986224307, -0.18236321568151367, -0.6034811954961948, 0.5297786951158664, -0.5809901282471613, -0.12087570658046028, -0.41234736584873427, -0.632070254636486, -0.028360471032399755, 0.17246750211110565, 0.2604444093173539, 0.34441937736061257, -0.6742274599361854, 0.5581023193488656, -0.5393154627848344, 0.5296163466257443, -0.39125505693161694, 0.4579625756029771, -0.14302816502583535, -0.36392548481451736, -0.5222497190421708, -0.0006731825836669314, 0.658585911430224, 0.39399849814116383, -0.1259955609527785, -0.45264125494687674, -0.43384837336855137, 0.48869947421165, -0.21376519962710597, 0.6283137620334144, 0.4487785738840018, -0.05073167132682268, 0.259391700726712},
    {0.1994706267903122, 0.04688087129777144, -0.19343543633966567, -0.3355195969266908, 0.1878283987514978, -0.5109059324084992, -0.21060168757464573, -0.33630344128342415, 0.3513101864963553, -0.1336466274801829, -0.4521644296375306, -0.00376044445115747, -0.29019327389950766, -0.5006739866097739, 0.48805777006905166, 0.6750997157184384, 0.21936746055758588, 0.20844953456030613, 0.66013076533122, 0.5327823676173082, -0.09394874749518346, 0.23547145203106665, -0.41624124586509026, -0.3014262770853606, 0.08989642613656244, 0.4270845933204616, 0.534189211019798, 0.3511063433800725, 0.34511147162218797, 0.47166867158241266, 0.21022135335336678, 0.2538263798521544, -0.32531753057145946, -0.41714235963961177, 0.5109497812224582, -0.4118563248393762, -0.1928466358088447, -0.09708500107521667, -0.5310702874062342, -0.04826866639576309, 0.06536208437490398, 0.5490795793431894, 0.28638374175698594, -0.42886125686959925, 0.5801961188768436, -0.5722405970653675, 0.6048052901621486, -0.48420551784654564, 0.3594625704485163, -0.42326659982292053, -0.26859265125483917, -0.22964846588234158, 0.017972005082904637, 0.46829120466342644, 0.40751255917246004, -0.25780861847631054, -0.2224495598546447, -0.6035031944822211, 0.6337976069163292, -0.17947063692829557, 0.47340166981755444, 0.6220106151052902, -0.027319412632493555, 0.3291772085060316},
    {0.5364227643400805, 0.39815142470899956, -0.47287119126158417, 0.06887142325271825, 0.4245693519308545, -0.573877060843978, -0.33483757874651887, -0.17260675759464753, 0.12170811385990223, -0.14626421321591226, -0.5305504907896191, 0.013908838845526725, -0.3116609043207719, -0.3102031643034588, 0.22583941394440846, 0.457943800243107, 0.38478821105488903, -0.022235354779616537, 0.7036082993548555, 0.3962680439856568, 0.07430506743454583, -0.006007748189623617, -0.608362823230174, -0.2415919183954762, 0.14212976532654856, 0.44089860277230297, 0.4355065673151377, 0.3684873953449873, 0.1809416104936707, 0.40549146051931795, 0.0035114953210467377, 0.3482437140722771, -0.3090126173332945, -0.4666080475559577, 0.6200591698002218, -0.48646492065473007, -0.5441601818425302, -0.18897884898459605, -0.6094706904502981, 0.11586234205793201, 0.13936115506721142, 0.5184660762256972, 0.15109552032643422, -0.3408756629928994, 0.5400341344488384, -0.45792790109557413, 0.2465321336834229, -0.49389487290258044, 0.5860412427472936, 0.044734026058920795, -0.3552867398595162, -0.3430646540820654, 0.09958934071506317, 0.4871108958951876, 0.4440620064059358, 0.0040272624419893715, -0.12324252408651867, -0.23720732850535617, 0.3790718595367644, -0.11758921925387276, 0.45003197438745196, 0.5614787282352286, 0.060559121432911915, 0.33426145379227473},
    {0.42537483626351413, 0.4637382534771374, -0.3656343215688824, 0.10200963079292467, 0.224616129219363, -0.2503307190580546, -0.36261249364633896, -0.4417854526177129, 0.45006320460271065, -0.39330113897108443, -0.3859613784988317, -0.01001079672163339, -0.5426419510145815, -0.3290611392675137, 0.17569371313379067, 0.28358569710970094, 0.4253680643620968, -0.02585174368489083, 0.518266058236431, 0.555318468530403, -0.2676106900180378, 0.018341898299889817, -0.40479230829902024, -0.4755635227165089, -0.10675437110425888, 0.6648716170373354, 0.32975762714576806, 0.40055293548067245, 0.5392257860130929, 0.5378680352029718, -0.1744397392856107, 0.32821375930045243, -0.06098094062766475, -0.2681835392527776, 0.5548334835511887, -0.24782383549852294, -0.5862285822753717, -0.31044359782683273, -0.5416800670540819, -0.22459796343005028, 0.3115233020237099, 0.4881986487889935, 0.506123341859477, -0.35335004217968075, 0.2114146643253132, -0.4956407539506207, 0.5365895749760645, -0.4973923670066558, 0.4713427668726287, -0.10974598652796626, -0.5730406789131521, -0.3230959647505091, -0.17488260251294965, 0.5470306868145747, 0.5089714819177633, 0.01604702728648979, -0.12276450094918841, -0.502053699951499, 0.6697675330597763, -0.36924883234093303, 0.33435836476690217, 0.5848563102009124, 0.023204256761622973, 0.24426911917149774},
    {0.5060256027577428, 0.3417332227119037, -0.06070065937296998, -0.27768178507834573, 0.29542502454236935, -0.4831386589899896, -0.29502538964141095, -0.44097263990662133, 0.489088501259484, -0.2359285368069982, -0.28018230405136313, -0.28739206060918043, -0.34353538861114497, -0.21921374721653114, 0.44312501112755226, 0.4206713676170272, 0.678996136302723, 0.2966448606995046, 0.35282961272208224, 0.5321119712656346, 0.01305096748606605, -0.19016067006520251, -0.5881970179985594, -0.15896538109423766, 0.31552701282153656, 0.554690060220886, 0.511210333767056, 0.5861703360233042, 0.3386203141223355, 0.26988849446470775, 0.09433438146604003, 0.15148937269413254, -0.1591386846475813, -0.5180100203762207, 0.44041163768854463, -0.3350105915759281, -0.41475443785891053, -0.25156753488707545, -0.3529651284810185, -0.07598796824155234, -0.03036818234475904, 0.5718597101918266, 0.5545567561892811, -0.4586434862810511, 0.3824485939738944, -0.6587821547268773, 0.4655108415965625, -0.5800948970167349, 0.5037393669464382, -0.17757289839095908, -0.664634759598369, -0.5243133651258587, -0.262402949762756, 0.39770226310240475, 0.48522128848954, -0.3933645167876311, -0.15991185800463015, -0.5093545480301684, 0.5057440764464503, -0.3780566432663149, 0.6806805956752082, 0.3895500130689099, 0.093720000539062, 0.062375197809865446},
    {0.5219518456141348, 0.37881321606488927, -0.16484989811361694, -0.2782117798612566, 0.3392418252117993, -0.41280975565779443, -0.49798818725195787, -0.36161525266750405, 0.46066821560014387, -0.5083022385963376, -0.3967337448478013, -0.17410979900074522, -0.5060388887652547, -0.31841756339851834, 0.1580036841753586, 0.5576941455387977, 0.3617329555303383, 0.26924608675864126, 0.6373594002638799, 0.6394201442216133, -0.10526645954036282, 0.08188659335792609, -0.34153670949293874, -0.2496327124612866, 0.23806246413877002, 0.5138900941879492, 0.7366581659733056, 0.6803250691817315, 0.5065935967870308, 0.2543377937476523, 0.2718343411150318, 0.44933961304179665, -0.5077787265271533, -0.3905910857108409, 0.27740165411761586, -0.32282115586622295, -0.5185308880089691, -0.24310210700800106, -0.30939812934944966, -0.12502043552473863, 0.2549889341044626, 0.6541742877691842, 0.3594822288871297, -0.31211458894856337, 0.5189118328998992, -0.6502305684216119, 0.5987995436818372, -0.6288545220634669, 0.6089286594338389, -0.2036652910980814, -0.40085099728140966, -0.46122469490786594, -0.2619491405761425, 0.6424241883879012, 0.2702745971620415, 0.03805771653310229, -0.12460420655268362, -0.3140023755495849, 0.39282451174829575, -0.0860224619545773, 0.3836699704544938, 0.5630854501096968, 0.13651925641870558, 0.04248997804629066},
    {0.24944354171393535, 0.5448962252355709, -0.21381055237169724, -0.3457979706419825, 0.3343925125352447, -0.5029580039749487, -0.5228208746219485, -0.49506849431969335, 0.4324372341283938, -0.49965872139535605, -0.4587038580305031, -0.3353763201049672, -0.5847438404234185, -0.3528648924706826, 0.2899618210762941, 0.6073560717916975, 0.7134718800928928, 0.20625549086873277, 0.4366879546447838, 0.35721375499627234, -0.06152298100997851, 0.10698237570129177, -0.592803731140537, -0.21025433336018678, 0.09629339526082663, 0.4632500682418283, 0.5789698184678881, 0.4761796042462187, 0.5153639428314941, 0.5975361158940585, 0.07352037011013475, 0.27345114890002364, -0.24395144659233928, -0.5265346712160506, 0.49508207961875017, -0.41176573758075297, -0.5654197543900762, 0.06380777705568016, -0.5403038865089416, -0.3299954606632163, 0.103808778545727, 0.5522952051294416, 0.4047464094943003, -0.35715993364856197, 0.46961478670910234, -0.6732656905159269, 0.41811446101247157, -0.6165684990519444, 0.24872878668829698, -0.39550195911300984, -0.500817555544892, -0.3042034547947023, 0.009705701769401562, 0.3185909914101317, 0.5281139057422009, -0.02536660773770404, -0.46339997637299196, -0.6426799914813797, 0.5093298790440981, -0.11752540343844821, 0.45455277517721315, 0.4034122759347525, -0.1901202015340235, 0.24801656522040996},
    {0.45212219367416373, 0.3643404545048301, -0.3827839540444881, -0.18668337751228142, 0.4882846380029055, -0.4777146118646685, -0.22827933148806603, -0.4368566296266717, 0.5979726911894179, -0.5100786853812455, -0.32025664097894047, -0.26574434016780313, -0.3701521412973624, -0.11840931178769844, 0.3373248801381395, 0.6252068456865897, 0.6794518958360534, 0.14676724253962167, 0.4503590493869274, 0.3284881062211984, -0.2709265845317733, -0.07847122362458317, -0.6635454612034043, -0.2113436597984231, 0.1744741113190405, 0.42365725653101843, 0.550476626801067, 0.6979332563157836, 0.29615768774481566, 0.3075964603929465, 0.04524874892550416, 0.13701081075889843, -0.33932062503030613, -0.4650708716401104, 0.5873191309929864, -0.5835809697034926, -0.40692820000876656, -0.3383064407909447, -0.3436735159777819, -0.20388487986330092, -0.044215207317405, 0.53849695348472, 0.27785961166233814, -0.3989856193752697, 0.33318742192503065, -0.661573350648596, 0.40511714078032207, -0.5116043630642553, 0.24533681305274446, -0.23682439381197815, -0.4270534429803809, -0.36365000976090567, -0.12278624663204238, 0.29135098188318964, 0.47189931791414674, -0.1585802505304521, -0.4779780636303575, -0.558342403413501, 0.6182815440876868, -0.3055380074730648, 0.38724718250594564, 0.3325540829329827, -0.22620903848295038, 0.39296704944462035},
    {0.244079158050561, 0.0959931186801656, -0.13237075112705768, -0.14367353959378518, 0.4357882557997458, -0.2013919263206929, -0.4359471562635127, -0.2472078611794774, 0.24596541508866218, -0.29064885702573995, -0.1632869015233114, -0.38986694677692757, -0.6595279376478308, -0.2611921825948554, 0.3198038805372564, 0.5856436849238926, 0.5953474763502311, 0.09217225428548899, 0.4216788974406867, 0.5061713375944356, -0.23196561174567545, 0.12456838194247127, -0.4509295157700536, -0.27551587890078494, 0.09180123892279893, 0.5576452283707783, 0.34206338549371074, 0.3869917479409655, 0.401915432528775, 0.4349738364924558, -0.07174324796863911, 0.3365544493377973, -0.13527323062686114, -0.45561044084356833, 0.5796147744332731, -0.47137580721397526, -0.5705017513566272, -0.27395559629805605, -0.523916653880779, -0.032683121501071, 0.005365604977547704, 0.49562171421505075, 0.34184856141063125, -0.425999879124857, 0.1663488478833402, -0.3784646976543823, 0.3064557704977754, -0.549091421315104, 0.3757830035572495, -0.08877539291854973, -0.34625694235665266, -0.4959837014401924, -0.35924283231844617, 0.585709963862936, 0.6610604770794151, -0.19727680326959213, -0.24518702206349516, -0.42694427941343177, 0.38507374061985145, -0.36053368809024194, 0.6642490476313256, 0.4781527473960311, -0.04713397499417526, 0.18252810431015776},
    {0.4429762406722296, 0.40134162241351967, -0.3052074138584283, -0.1359963086956352, 0.1933939454784227, -0.2377941565324812, -0.34649505563685384, -0.29480668759462836, 0.5638489752899303, -0.24167208923010045, -0.26425104885507783, -0.13886903326799233, -0.48486959171319954, -0.314502770808085, 0.4270666974453909, 0.2903046370818828, 0.6195946662139018, -0.03558508857418271, 0.4240299055132248, 0.5216164728207523, -0.11794966298119919, -0.09049094377304691, -0.38549855625633517, -0.43885558731392604, 0.12803652049030242, 0.6984908480205828, 0.6620847004014211, 0.6306161170225583, 0.24375023219980893, 0.3237611885283815, 0.1777109382640536, 0.4706578958525788, -0.1805760863899401, -0.3027734132383874, 0.3424242777421454, -0.4294804688310327, -0.35398527973464794, -0.23817388113392796, -0.389019649531828, -0.2433647112137056, 0.22992486845999657, 0.6308957316251813, 0.2553447093745499, -0.41133316778088325, 0.3194928979023422, -0.6748023667433934, 0.6481814956644623, -0.6805042490086868, 0.6243360594861213, -0.4806507577444196, -0.5434627528206333, -0.39647783129938596, -0.3455566549342963, 0.6315266000651065, 0.6945364024520667, -0.2768123011380395, -0.5167627171398689, -0.33247730285206173, 0.43800379197759126, -0.1945821366270032, 0.6078712689032669, 0.3108184576653809, -0.359120451634516, 0.09770089390166194},
    {0.3162053128729678, 0.3636665237942173, -0.33167659946668304, -0.06729375675647749, 0.4723976834488604, -0.199249451306764, -0.27020478616871774, -0.20476976653956902, 0.22169223038280414, -0.3124990078396095, -0.198641387118924, -0.21147461761975228, -0.4828068240205651, -0.23755529462909422, 0.16607515181926566, 0.4275527928188307, 0.41448841534010794, 0.1583024626084747, 0.6859551794602463, 0.6342324327619854, -0.20115179753380313, 0.20350579625234202, -0.48484405079214293, -0.5931682686279601, 0.04264435106151061, 0.4946890103061386, 0.48255290679790175, 0.42757195761768413, 0.2590971545386055, 0.4757564995753102, -0.12499176590890616, 0.17326680597071065, -0.5295868284670451, -0.6100228626450825, 0.4935519041213185, -0.48915191499587185, -0.6022536873315486, -0.2637901364455154, -0.6594647998003547, -0.21185419204261188, 0.3366562908645311, 0.43273458267662035, 0.6705003152057057, -0.5436431531083092, 0.5138753905560399, -0.6924686581381834, 0.5948664679602413, -0.4302542946723243, 0.602745830700012, -0.276186101685998, -0.5102573805582562, -0.2446476605314387, -0.3158688939284953, 0.3642782685020683, 0.48513525964459087, -0.367869929036232, -0.47551566022220604, -0.5036366786965891, 0.4792868552759079, -0.1869337318597291, 0.6270611447549096, 0.6847096539642711, -0.24801674756444902, 0.10918225307259086},
    {0.509393112657306, 0.07930224393196757, -0.38631667407659537, -0.24606350710218922, 0.24933851021241255, -0.41800999998094046, -0.43978056248679814, -0.4124947758908706, 0.36385348262396333, -0.2718186236724148, -0.5239075020418739, -0.30606084217226637, -0.5627788967308854, -0.2689624420221545, 0.25872932618623506, 0.6193620373346667, 0.29490992654747367, -0.2064210730961539, 0.6943456572799496, 0.44174888259953143, -0.1756918198172357, -0.10896772914853757, -0.49675575310943504, -0.3497891200232465, -0.0033153311123956977, 0.5202726631445543, 0.7164331721893602, 0.6820810441588026, 0.28313506540101957, 0.33302723702485276, 0.02523072655913491, 0.4929586232157543, -0.5373808112104721, -0.5166156639461458, 0.3515796132157128, -0.6541702520493098, -0.5851920300149929, -0.37481564596878647, -0.48235003707303686, -0.02678384823781007, -0.005929594726106806, 0.697608781869787, 0.413049085484412, -0.41374772578693003, 0.19559129178941104, -0.3868351888809519, 0.6639701985983123, -0.3369608064342308, 0.4993804977778534, -0.2388712536074154, -0.5782693757408957, -0.275427867931222, 0.05434856022315893, 0.40676332004849436, 0.5407903124395272, -0.22586357726019046, -0.3793092105547966, -0.44983880646730917, 0.5538508706532889, -0.34478572617319697, 0.6175122720785449, 0.5690543561246962, -0.03282117639055803, 0.09070085455726112},
    {0.5705501339075041, 0.19107989795385796, -0.310684404945863, -0.13020102061593133, 0.18696554163093893, -0.5851211538572781, -0.5189666350825126, -0.36969774974535485, 0.6479364969205755, -0.21512948085012532, -0.47342426894265316, -0.3410854624524374, -0.4113209263799972, -0.2726490756942831, 0.266577286697206, 0.5971704444174339, 0.2672389206981829, -0.10920084867117617, 0.43865332571623084, 0.5215205187947747, -0.13959025407355533, 0.07664435017961199, -0.41128435709325706, -0.4513028176205237, -0.11838215699011613, 0.6296169676493923, 0.6668127806758841, 0.6851492162046903, 0.5311951172414142, 0.6644776811187464, -0.19816654852423193, 0.4061930717810982, -0.18075284511793824, -0.3606732654113087, 0.6128592588691987, -0.5767490413132719, -0.43185693472203884, -0.07778185164588435, -0.5466713654239725, -0.10396485787447515, 0.027628772285651592, 0.535597151230645, 0.4894077161960388, -0.6188163132858753, 0.14219667126581922, -0.60206228033048, 0.6356572125551575, -0.587059796487348, 0.5098642963584593, -0.41246183616195337, -0.36060238778237824, -0.21319194134936026, 0.05991212626365238, 0.47728144790920624, 0.44881151548017156, -0.14930518204839363, -0.5573788502774284, -0.33258039644607057, 0.6195874001249655, -0.3265596684898657, 0.3383195260411652, 0.5616962406025656, -0.18018405112921962, 0.1088302344526582},
    {0.3506636262762379, 0.09229759142324698, -0.2869754278755394, -0.07911445580086542, 0.4638673685346706, -0.5153530642168955, -0.31239330524490083, -0.4718177950501808, 0.32724522483379165, -0.24380964208194197, -0.5844492743069861, -0.2744150488360315, -0.6427557154419906, -0.3595161006922276, 0.18972818112584303, 0.6842973968455002, 0.285028345905331, 0.11365230802995832, 0.5549025418133327, 0.40307642742696737, -0.1640876414884356, -0.19590970703548558, -0.6340541972950348, -0.4207393091791089, 0.21427203593384236, 0.40021561832145636, 0.47192504157862675, 0.4786515843021785, 0.34386362284379035, 0.43568910591532184, -0.08618381970620262, 0.106622948034605, -0.4082507758387198, -0.6351872642912809, 0.4764439452007794, -0.6568506129117366, -0.22713380985273704, -0.30553365761291024, -0.6437055201542639, -0.03374251845925205, -0.03423581479844392, 0.6857951875177108, 0.36653818323121645, -0.2758673532526612, 0.13937125000890618, -0.6114764888152949, 0.34045123968191626, -0.6263410458377121, 0.5338491743323333, -0.4532962410319317, -0.6235824426339094, -0.49588170384729313, -0.14928002056764525, 0.27563387444850473, 0.6392901859572051, -0.286030369318054, -0.318613054780396, -0.4527491178906664, 0.5897439034154763, -0.24942584909450352, 0.5744913254361277, 0.6090821776111155, -0.046224039206821305, 0.2708589332414349},
    {-0.4461688669923518, 0.2697169832710969, 0.22037469407561666, 0.2384867216078513, 0.5349139019002178, 0.2220556605731586, -0.18670399759432604, -0.48720762556742314, -0.08258574686862175, -0.10302396245531295, -0.13578649057113806, 0.41357155913513033, 0.11289118917511513, 0.2956393979692027, -0.44314476630171545, -0.3531489965693521, -0.12852991344618145, -0.56194348607727, -0.06169600367491811, 0.433835621374884, 0.25865941156139427, -0.06745684445496712, 0.14926543563989514, 0.20050693645657783, 0.22617107855862806, -0.4798895569597503, 0.38460068171026174, -0.06658420232788366, -0.13959060857816033, -0.04741073438974974, 0.5641240409417455, 0.17291981584849467, 0.018223439622471107, 0.5171678055154881, -0.526135433713658, -0.2817623864586004, 0.10924944120722227, 0.40842770841923887, 0.32468933304021086, 0.026884657630728313, 0.3487220160721922, 0.005826749101544286, 0.17256226436491168, 0.3408360680104029, 0.31461724829972487, -0.16379468501975358, -0.05829620681021732, -0.21909112017351265, 0.4270165673422116, 0.3734744282282531, 0.49955667624874983, -0.24460020876523106, 0.3690289032897008, -0.2751964856109911, -0.418761771552759, 0.009974482204673944, -0.35812227504244626, -0.07709517589294909, 0.22826853932092622, -0.28091391519481346, 0.20881047807039216, 0.3330406470582281, -0.2983618761513127, -0.3718504306830017},
    {-0.050236246054725854, 0.2618812733280953, -0.020029824450125827, 0.28816370299802824, 0.3931848352333616, 0.062177134130647196, -0.08151707252930052, 0.045971696438551264, -0.1936767794670315, 0.036955445363507984, 0.07453888163643135, 0.1419624123445674, 0.17807326322635092, 0.1452514670817645, 0.0718927744982851, 0.13323372211517004, 0.21409135265822904, -0.17949862183139315, 0.2276542447250344, 0.2755107127399036, -0.032543725508107454, -0.36931114774078433, 0.06300987075367011, 0.14939293588618724, 0.09398718182153624, -0.17151626083077218, 0.06465271943110096, -0.21926922989974962, -0.27566057995116183, 0.13878533448946512, 0.19470925910092599, 0.4909489564085062, -0.01674033712674226, 0.08643304253242987, -0.2138400071144499, -0.1558266815933168, -0.2826351219278343, 0.11714101561220157, -0.2241118759385387, -0.39412716635438827, 0.2964460107703975, 0.15016153417800962, -0.023327091237799087, 0.31615248538529905, -0.060880429166509244, 0.20921624627774832, -0.29410155985956615, -0.04220722323448112, 0.22535955514384096, 0.06806684289275955, -0.03850792301445211, -0.11490961603313807, 0.06454198853101956, -0.11090246980702831, -0.1850509266203286, -0.2381868607521078, -0.20323163343605014, -0.20814002982961233, -0.24301835927552884, 0.14577196356956085, -0.052674523190442836, -0.20371522991951574, -0.05726662434741192, -0.10035771184879608},
    {-0.5645393047130878, -0.22452605036439882, -0.30566744518869643, 0.44704566769938325, 0.35386027986459667, 0.0023246147347974564, 0.13684411513742398, -0.15158586535903223, -0.17825550813500018, 0.1474999328320676, -0.30951152951113386, -0.15467799116028114, 0.4196246166464295, 0.15543737640050198, -0.1458358593948972, 0.2593837568753037, -0.14126158519299123, -0.22287356205778477, -0.2958530361975601, 0.0967364897165355, -0.3754654300212892, -0.3076409709800515, 0.2590768183371953, -0.15516768476057535, -0.4635982508086404, -0.3606247839443122, -0.057067415052731565, -0.49677215502411176, -0.5920767429323556, -0.4641773779824749, -0.12151505891509394, -0.07656144337129894, -0.3008040171393073, 0.06817536932450832, -0.3534829369039266, -0.20158663790102468, -0.21682130418765255, 0.03164059349142646, -0.10895560228633701, -0.5491104044034654, -0.42221007729488474, -0.1267048500196005, -0.26982173462012327, 0.06288503351008004, -0.2222221547119077, 0.23772571444846285, -0.27737721522774655, -0.32917908240658256, -0.022840568783839558, -0.2283109929314956, -0.06930455535968241, 0.18490402349516796, -0.05885422890369208, -0.27799144257000175, -0.4358890138476997, -0.0968365997164532, -0.32803901194056373, -0.06343964554658509, -0.3776813072711234, 0.17186057894204693, 0.2660939492428302, -0.5407915877505187, -0.6100742157844287, -0.47760641301118506},
    {-0.29528257618816983, -0.48260314669524834, -0.21636692778162708, 0.369017279546668, 0.34426557989387074, 0.12780542034633974, 0.19737965565611718, 0.07667915620715597, -0.37089673014754954, 0.09413229073459509, -0.30703201161837357, -0.37801072620777393, -0.09495471050721149, 0.15555198124053476, 0.14546072899196077, 0.03796532483634359, -0.3942929815439309, 0.035776355617055694, -0.020046631804814388, 0.02349929845731299, -0.22416036181670887, -0.17497482146706414, -0.03060701432795471, -0.364869777948263, -0.25964648356247605, -0.2334338621833274, -0.022407249775969754, -0.04161570207707884, -0.40215680999473247, 0.017045825335067648, 0.1887227896532933, -0.03442098549018244, -0.31891406676053285, -0.2568240415543283, -0.17920540470834617, -0.28266324654042335, -0.11101063775508509, 0.06733106724007644, -0.3066899752632445, -0.4917005073225035, -0.1391118039772865, -0.329042035127883, -0.15519227990187606, -0.015675896692659088, -0.2597701915817928, -0.0755795800653027, -0.33269512650693883, -0.5220031078482248, -0.41830998155284804, -0.48093092255483005, -0.2743993055614334, -0.18099835228267586, -0.06228197115728192, -0.01021706433967036, -0.4212108115993153, 0.11851317595798706, -0.5630618436071966, 0.0284584695428512, -0.2991995353487216, 0.22004987831702616, 0.2473192409129718, -0.37533159484680506, -0.505460304537652, -0.5742501666562436},
    {-0.3795149924996787, -0.4533939107907797, -0.2474273836854663, -0.08074739988367927, 0.13843594808353543, -0.0790342692152214, 0.09427954439125884, 0.11521313333081074, -0.016338256493367297, 0.21530307304814372, -0.11391204993496741, -0.1602489321467853, 0.26923083567804096, -0.05341485040997672, 0.041650390052232214, 0.00577760815607396, -0.00594453647168207, 0.1439309889385453, 0.1988704430777917, 0.01818632680167315, -0.3423310310585043, -0.584291796327539, 0.17827500492859935, -0.10915194178769572, -0.3598246586364199, -0.3404946255907849, -0.14782265719463525, -0.1054736281104086, -0.3884216951531807, -0.2279342070418566, -0.03660458230214663, -0.3890887203349006, -0.05789890248108808, -0.5202622280524681, -0.14188940993860769, -0.17508624782525006, 0.226588302969111, -0.16967544280103644, -0.13968112484578826, -0.4157559093897661, -0.4025336582359593, -0.4852714810082773, -0.39114187759960206, 0.08647197632474642, -0.4590799917172295, 0.19818267181904117, -0.4778938969994995, -0.481662146070919, -0.36398924645489117, -0.403928576674057, -0.010375270920961917, 0.20612733324603677, -0.29633831650443737, -0.07219131110219625, -0.13161110171894783, 0.17414586094508058, -0.42640342379258095, 0.09744359904849881, -0.549472954348423, 0.3630674554332983, 0.42841649971450935, -0.5422731269332869, -0.16656007079026328, -0.4962729071218207},
    {-0.09898338095387567, -0.1606624913127901, -0.10896479377880529, 0.31018347929582624, 0.28682965426345347, -0.30645597629183763, 0.16809302326548706, 0.12696760340809785, -0.07290496636524067, 0.13856752109549317, 0.1097467286059947, -0.2060726119511288, -0.16352689176024843, -0.07939198894542435, -0.03126709845901771, -0.04153728476690638, -0.04108365682419186, -0.13674127954158585, -0.14376281385998022, 0.08039064195064496, -0.4264152189334603, -0.3010642887659251, 0.22006318886608375, -0.07955643072541183, -0.36652850833126066, -0.25657983612291324, -0.2343320124008938, -0.39211533309764374, -0.23758122728031966, -0.08847808526332836, -0.1800113244395985, 0.03781459745492404, -0.23436805593473756, -0.24663825208688714, -0.23962611081441307, -0.32847890878290376, -0.09446161528591256, -0.4064991962175617, -0.2124104538104255, -0.41391290171825695, -0.35585866262620913, -0.3871973178046226, -0.31850793237336267, 0.1031409407276786, -0.14293415448187935, 0.03352817895981699, -0.21668969908806973, -0.32355960864861893, -0.11738950325970235, -0.300277318125039, 0.09094344297981498, -0.05901678131244096, -0.015033959204404776, 0.028739899397375954, -0.26843898751436795, 0.4364326959138179, -0.32883335550247955, 0.21869465043749292, -0.20796922455104497, 0.39592768194462, 0.08650945276877071, -0.2639347001092575, -0.40908935540985625, -0.3407311958783038},
    {-0.2669415546097006, -0.002175410269425727, -0.3135792107877857, -0.07244193884065171, 0.17923813537850364, -0.0642804399365362, -0.06037855838997997, -0.16990560255886553, -0.41149796165349756, -0.27170953407423365, -0.36676379968517747, -0.03009809849851385, -0.21377001383927463, -0.04772692151469907, -0.010753958549859242, 0.04026245249620075, -0.15292399213103292, -0.03246585930054269, 0.24316029640238168, 0.057826559566296135, -0.45223422636550914, -0.43679485304794236, -0.06852286422840916, -0.5095914199296993, -0.2791570696932747, -0.15181602075714218, -0.2119609274546621, -0.3848620987975599, -0.31324416132712457, -0.26072292025871324, -0.4119657591770447, -0.030865392368027506, -0.29548285447929423, -0.3930154672116873, -0.3284741074685718, -0.42055691124969785, 0.0646540455516139, -0.049107119618203944, -0.29036152425455314, -0.28672257985697713, -0.15580384248075593, -0.34033616530889393, -0.547787720277541, -0.17056983501017206, -0.301884936211894, -0.13161662245959735, -0.2517001110280943, -0.43605848388805357, -0.2984376452006415, -0.4527882516023446, -0.3316956381016189, 0.16094918085490661, -0.24754558339444827, -0.1794834496897716, -0.5497648118875597, 0.2887592722503646, -0.22870637986394438, -0.12551145758484808, -0.10679131963215151, 0.07901515411281368, 0.20748223854191777, -0.2133935296118436, -0.46698781160003816, -0.2764391420054813},
    {-0.03568965117215304, -0.4311317008907498, -0.2775454584738292, 0.4142856453137503, 0.11414918552838446, -0.20056956758710343, -0.1243808457741575, 0.15359097375187525, -0.07889502335937942, -0.016939911119370488, -0.3146411382157347, -0.2252515227351444, 0.16975731904223978, -0.11645394393140249, 0.1151823750240017, -0.03996148287696578, -0.5016604512980417, 0.16502168090750896, 0.017631307609742342, 0.17316371460565308, -0.4210773934964463, -0.3207572511133109, 0.25135002972100684, 0.007064552186351, -0.14607808591774205, -0.0767064132469139, -0.43184687288923873, -0.27867418136836686, -0.2818226354787837, -0.38579891859833115, -0.25470105550769906, -0.20706529465305307, -0.29404322103453007, -0.24971770463258816, -0.25587403689812344, -0.2786876962499486, 0.20497054524026917, -0.012978298319969354, -0.24539489662400413, -0.5615871537648806, -0.275955727061808, -0.4965681069656577, -0.14204076933083246, 0.272185091573163, -0.4140772851925771, -0.23592574867454794, -0.3346704865883206, -0.27251353521944377, 0.014414080196045514, -0.4870136245778618, 0.10007637641123042, 0.2445077251054472, 0.0400210562538434, -0.1636599398786931, -0.4657781301343855, 0.2401653323434113, -0.5015364216756398, 0.1980306341929023, -0.19720898789949737, 0.12539035254991074, 0.08364929373867389, -0.31570389840146446, -0.2591484526223785, -0.1433399636298744},
    {-0.06253258467613054, -0.5899284420801272, -0.4405617049558882, 0.4462231273461391, 0.27600770794529145, -0.18571001399153686, -0.09802293218946415, 0.34526043161725445, -0.032891500033210994, 0.03529256413287378, -0.5240723124109227, -0.5360953469012035, -0.010097243741523673, -0.12777955781338718, 0.25990511226257296, 0.12915721976744093, -0.1999211014039687, 0.02849210881287081, 0.24667572763240522, 0.017722866150774844, -0.3184639007346068, -0.27389562380611704, -0.08461664725784707, -0.08387849540217758, -0.5295616682347605, -0.4388326737402671, -0.39382062664130313, -0.24121047738498333, -0.1505724401833611, -0.24456149806058408, -0.32475836778326955, -0.24813419401655992, -0.3831324559740496, -0.42027281519985465, 0.05168823953232799, -0.4563001154604246, 0.1240957219870271, -0.15214496119218152, -0.40231846874921323, -0.34523460953390883, -0.4143319344216747, -0.38280425603883683, -0.4485529571433806, 0.34329272617598805, -0.1794402613489335, -0.30165779769040424, -0.2900242952583666, -0.24744599654484548, -0.30687479937221995, -0.24356759955870047, -0.4037162093864651, 0.06172516196621288, 0.14533342428619908, 0.0209837137750184, -0.19798829289010123, 0.08498395967673478, -0.5391577475338346, 0.1442962586772762, -0.4274831086215225, 0.1701571234313306, 0.23436659899895304, -0.4050497473665448, -0.24728875761289712, -0.6040355525004482},
    {-0.1976021355047296, -0.4527016859930092, -0.5093229926553036, 0.2622729960194646, 0.24983338991320506, 0.10511947021648312, -0.09991302571430853, 0.17131010427049315, 0.06874402661215898, 0.2562947557883428, -0.4281765699453344, -0.13280092732935922, 0.030038356348554413, 0.06822844018769368, 0.42902306373153265, 0.2785988644333848, -0.4718097439181895, -0.1860687780055183, -0.06927494248969245, -0.1866022972158789, -0.27769782872573723, -0.5833031744567382, 0.07128955178679172, -0.4518627456001022, -0.22549795166266273, -0.3673493829555116, -0.33387002919438574, -0.0841497369870848, -0.21194320588942042, -0.17777540328030672, -0.328773079407347, -0.32052722902443076, -0.27260671009876325, -0.35793039941442034, -0.25760501049778833, -0.07777460783757813, 0.06345087179930567, -0.05871390136762491, -0.3280673594105303, -0.6577293447882571, -0.5731780817367367, -0.42665355324002896, -0.27253103048578575, 0.18063882291694344, -0.46899180826397757, -0.047916977880618064, -0.46066359617847386, -0.09483759157865934, -0.1873936962327501, -0.1361566021211078, -0.17649826890314002, 0.00534069555846057, -0.08518451290137699, -0.19101983558881147, -0.2898541100761976, 0.19665452000095698, -0.20306903029311912, 0.05275274436031886, -0.46211007158524253, 0.07385661527543441, 0.07420867177783816, -0.5139556253242464, -0.4828286229748271, -0.5027047650652777},
    {-0.37704326754640144, -0.29366605912165283, -0.3296351026062964, 0.21095288528295783, 0.29909316864800467, -0.2752195857248478, -0.29601131261476776, -0.3434407149776228, -0.325924185211784, -0.4270641994007853, -0.14573832793071015, -0.08967032128035361, 0.014824128601649573, -0.18179663253089104, 0.10224675644603484, -0.04266302369051027, -0.41569626197436604, -0.320853794022318, -0.2985386878338393, 0.23085589498966713, -0.13639210353160253, -0.3852669921749812, -0.07579882101211949, -0.2511599240241451, -0.27808518554532047, -0.01161594084591559, -0.33317767736882553, -0.23304346980771376, -0.4794649492563372, -0.3464579233703212, 0.07899135976482434, -0.28613512643235134, -0.5256695712676569, -0.10369653852168113, -0.1891887456867518, -0.11365695019617401, -0.09427935832462347, 0.09748619600681341, -0.3252894164384914, -0.5749812584652111, -0.4951569598827543, -0.33933353857433246, -0.13130064594777546, 0.06968690665814978, -0.05640514844785768, -0.3274068657644044, -0.47798405115900283, -0.24770369410043538, 0.19454609808215814, -0.29659991170694716, 0.08021678350051455, -0.04371115591520048, 0.2585291775243481, -0.39675410305966347, -0.531402234195837, -0.10962457413694728, -0.385085510407087, -0.16518615071459009, -0.06058316632657211, 0.1812450393870262, -0.2647634260290512, -0.38539301464628, -0.17572944729176573, -0.4729683648096643},
    {-0.5107909929316446, -0.14517838695669877, -0.18307923177524155, -0.044322518883847924, 0.10110677157426425, -0.018506260970716726, -0.06986573903810471, -0.11331803791724336, -0.11674520635730914, -0.04340805303403015, -0.23055194234838705, -0.017572892322503447, -0.18989246362802836, -0.187815467984739, 0.3808313561012557, 0.22817350511643844, -0.47484519507476264, -0.22080540187987077, 0.09422156261888595, 0.22948280104099544, -0.08051183378739478, -0.535680747260973, -0.09331401193724591, -0.30993812648333946, -0.37426721285793135, -0.18910297124101097, -0.30295358992715155, -0.2900307376432599, -0.36856724635032, -0.35591508175299263, -0.14822244845541946, -0.30389682454834877, -0.4906023737015762, -0.05861181198183827, -0.15908888315602546, -0.17856694184165997, -0.03650541565033018, -0.2835570891888852, -0.3224412816532912, -0.6165912065383613, -0.31132228781821153, -0.4824688110056093, -0.262590566049631, -0.04915106792894883, -0.049506085652942705, -0.05861035631054325, -0.46790957184656873, -0.35984703198983076, -0.09570572874409758, -0.3231853583468785, -0.18258711889831472, -0.1472315760696381, 0.10346533279075952, -0.4366177423903094, -0.5708968622084918, 0.16835334630980564, -0.3759272766114517, 0.01812015854525265, -0.2705741798486696, 0.10528036281695395, 0.39222249732119, -0.0915506616005603, -0.26630033985706664, -0.41013760779018005},
    {-0.3964731292364272, -0.46216684166052147, -0.3851019978658045, 0.12195010136756815, 0.020886721012171025, 0.07795445089775359, 0.1703271416731823, -0.044758426932698804, -0.42020145864595654, -0.1965839876248285, -0.06896193096650971, -0.16518610664901476, -0.10347338816477289, -0.2087462265268789, 0.35361242591806946, 0.3041692440893917, -0.4265766706540845, -0.3219141555281218, 0.1694707441824468, 0.23922539657657865, -0.16607846961537107, -0.566267505150984, 0.06226673715816618, -0.10395020641378017, -0.3523082627283386, -0.3566464929305652, -0.46211843399148694, -0.3236695981416522, -0.376121919955248, -0.08410376037811015, -0.06405357243228564, -0.03173735638484684, -0.4090939669641353, -0.11394968844547983, -0.2808907816485915, -0.48602051927290835, -0.0014007904325422055, -0.2928082108496723, -0.15516205021163884, -0.4269846846136193, -0.3110762043738001, -0.4773020279068776, -0.31758972993290246, 0.173432722485869, -0.4166537993257525, 0.14754041276835067, -0.6582317873228642, -0.4344240356043186, 0.04555420903009928, -0.3690966900802992, -0.327626763491568, 0.13668810664495318, -0.14350630350658866, -0.3196511821563518, -0.5690376428810555, -0.049781197183445765, -0.3925499771533771, 0.059830123807253804, -0.3631351461215524, 0.13547881096450332, 0.2144635549722771, -0.22505767376734345, -0.2519526940850713, -0.40474830110052207},
    {-0.19462495734426097, -0.3253725371407093, -0.5415688643955742, 0.34409507654432253, 0.035974772890928465, -0.18038323131862855, 0.10945964464557932, -0.017626588326991273, -0.27579405043951594, 0.15699780053487264, -0.1656420818756335, -0.46702046230119504, 0.06238358718240559, 0.11833973598831406, 0.36021321082511454, 0.03743577788059163, -0.5714279803367691, -0.27130136554728523, 0.17357624236702257, -0.04668240116854156, -0.3106628437435476, -0.26166990372524335, -0.12506794134458782, -0.3262114039336962, -0.15392496422704352, -0.2983499716150388, -0.5044731331299709, -0.4697640182605787, -0.16008980254022329, -0.1844785381998649, -0.0636875633039643, -0.04409765243919487, -0.4771580275182854, -0.053803563650401086, -0.3735047898525624, -0.24985860576044092, -0.10939023150512868, 0.033296681712392945, -0.06480606647771696, -0.527162928671142, -0.21553922656419586, -0.20756842331857997, -0.3196838990203886, 0.3405475306316203, -0.180101661422493, -0.12731636090857185, -0.5613883167897818, -0.17235525942556873, -0.07747530350601775, -0.09582067953501777, -0.29297211796040495, -0.05829923565870686, -0.055567898656946245, -0.5312253950903637, -0.6180030911750177, 0.1450590064353556, -0.38655738488096625, 0.012464026074531278, -0.27269595904006183, -0.06616748292582642, -0.07437189156735478, -0.4437893075879344, -0.5927950059760275, -0.5855120717376504},
    {-0.5351699391886953, -0.37673466517232257, -0.1873323957353609, 0.3285988063163481, 0.22821202314617722, 0.0908504609673969, -0.17219893023312327, 0.0005397844905287543, -0.41797919144764234, 0.10747728645940874, -0.31996905638419854, -0.42487560481937797, 0.12346134942309198, -0.14488116989788194, 0.2346588550871566, 0.3661447283637891, -0.3453629922419922, -0.1567109996519996, 0.2779014245969916, -0.07746753705085647, 0.025513953596373276, -0.54364496053795, 0.1351892265018915, -0.5499780047770219, -0.23434421279810017, -0.3521659534229421, -0.17435507241368678, -0.43710829412440844, -0.4187740966387825, -0.4017762145132459, 0.13230633288518137, -0.04014344434649061, -0.4383898361978213, -0.2941151756757609, -0.38594969808047885, -0.4355900781983063, 0.24337498377085123, 0.13282062297674607, -0.010674949083522914, -0.6718950554988897, -0.034139521043828676, -0.38781132419628395, -0.481441617738847, 0.44628112340770637, -0.14318860189966012, -0.12918847019397608, -0.29548927258004337, -0.36443439598992056, -0.07583272934247251, 0.06335151081958248, -0.25004365804983486, -0.025800539950645605, 0.07967226213701209, -0.1959972716939999, -0.5672703356459291, 0.16165921417809495, -0.6441145041988778, 0.32456162449919285, -0.438436086893043, 0.12235014514418001, -0.08028292391192426, -0.3994617313748762, -0.3402789498208551, -0.6988964578195468},
    {-0.2329563803831216, -0.2248194897256355, -0.4454146025621903, 0.08957733123219169, -0.031755511602070824, 0.03768186821366568, -0.2129737757695877, -0.034048702314191256, -0.34128547581011776, -0.03054586420212916, -0.5175821786943943, -0.40720772588357307, 0.06907001975234912, 0.006724586875446376, -0.17236177156956836, 0.10617813168047613, -0.13802543169056325, -0.3217295070302268, 0.23669997383573765, 0.29881557719159, -0.1415615198279117, -0.5344025143777169, 0.024631083333897606, -0.4853548987480368, -0.343028199053133, -0.3646101857449874, -0.01842942392158677, -0.11621987999193582, -0.1781757435892709, -0.43949269786590356, -0.23603135151716614, -0.06695080516210708, -0.48252133952467, -0.4647712775689512, -0.2360016217685379, -0.32781325378915827, 0.10948894090667495, -0.18808461558895564, -0.25027295385778886, -0.6389443018892765, -0.32684272921573476, -0.17321424963355747, -0.4534599020287805, -0.08457877671502992, -0.2965899678675302, 0.06972631807520423, -0.29101692758020464, -0.2121791087788948, -0.17620727921128818, -0.42035193187074316, -0.030943763033671835, 0.004740833264648566, 0.06524781099392302, -0.2136027899034805, -0.5415429870785516, 0.05186375146380271, -0.4640279932137359, 0.20726616238874104, -0.46227812045226124, -0.15336194319129548, 0.17313269538652498, -0.46969032454538007, -0.5446129892601838, -0.46762516538114085},
    {-0.3482133601246649, -0.29571779979238594, -0.32814420592034416, 0.4415332511879318, 0.33916827851807246, -0.19482840369679863, -0.2128084783925653, -0.23264762255645843, -0.2926807299918521, 0.051549186790310945, -0.48399457521912737, -0.017525042622023236, -0.1708781508802862, 0.1997546365240641, -0.1982372478271324, 0.27007879023422016, -0.42015256573748117, -0.45379191794278323, 0.18331996843902498, 0.3341270731953493, -0.054357364504617575, -0.23862280435291883, -0.19567984453701864, -0.4296734843912284, -0.07381153010793703, -0.5106845262045633, -0.21752574479717637, -0.4600867009489238, -0.21226607205079154, -0.4357065419245867, -0.0005894693797991611, 0.07479178098301995, -0.609818098131792, -0.13332415726476804, 0.06198926747579585, -0.5558836163633563, -0.022796276445192422, -0.046234965145872, 0.004809310757440092, -0.5185805402181546, -0.43031973571608956, -0.4210497593092112, -0.45799135297625865, 0.2642912215464945, -0.2974780341635562, -0.1442553154215547, -0.5846205098367695, -0.4959169390778926, 0.22204116861596507, -0.20936244169867296, 0.19719576460461768, 0.16273488013021412, 0.2502505495394316, -0.2672772725040193, -0.505471227481083, 0.17501999257630038, -0.6331652529370423, 0.16321939598288535, -0.31717145812352154, -0.14096836122550718, 0.07998617482163249, -0.5333056635048192, -0.25469999862552534, -0.6354742973546826},
    {-0.5875864944971416, -0.3975468427647861, -0.37942003560252785, 0.32824266664793217, 0.4060536255588039, 0.23120753688280024, -0.18097285254594728, -0.017721064660158787, -0.4482779090133002, 0.29629571708161434, -0.4525653285044084, -0.3130728450208005, 0.16835565498465088, -0.014797742827983103, 0.08897258382773882, 0.08675085572530694, -0.11778421715789637, -0.0364924846527466, 0.37619023687565195, 0.09789654038472631, -0.1556987395453879, -0.6027733483920341, 0.031418394781129476, -0.4306433666690545, -0.391340469648112, -0.49076024462858686, -0.04319478257422537, -0.1518438705109019, -0.19180627963285957, -0.07565428072119483, -0.059661850421577484, -0.11272423472772912, -0.2972372524110548, 0.06140894871335055, 0.1050808984518422, -0.5816875463319782, -0.12671591313217195, -0.09406365038790615, 0.10118633102131559, -0.46980195643364153, -0.017595783359586687, -0.3193749985586858, -0.3891967845874958, 0.3591114831450789, -0.07044023275358509, 0.1860616709340009, -0.33559191694524293, -0.4924494191347124, -0.09237745707666468, 0.14494023287098862, 0.35172120682935537, 0.09556433401141044, 0.2737295821539599, 0.006991501419404153, -0.5391179227472674, -0.042298830830233065, -0.6614206085302601, 0.19819230403627075, -0.18192463698431505, -0.023700538237550806, 0.4044102583086738, -0.4928980589695105, -0.6079897589803337, -0.5983832749598559},
    {-0.48515653436050393, -0.41375405509956553, -0.27870779342966495, 0.2683645689572672, 0.47125524504681177, -0.04618947130605758, -0.28539251011439654, -0.21570203375736435, -0.18550054962238643, -0.014050505940696826, -0.544622578106286, -0.3174374461243996, -0.13645821000928357, 0.3538413443986161, 0.2014815414503782, 0.18250140505077894, -0.1359686600445235, -0.1639083261838554, 0.015555062531318024, 0.15948328309255552, 0.32903627798002427, -0.6527165047385747, -0.044351875124216095, -0.2222758773810306, -0.3262956829197131, -0.14387181066471535, -0.058489683147936886, -0.42948530174611954, -0.11557513848380474, -0.1678183807789669, 0.06429798650910731, 0.31221931142378034, -0.24379629805608352, 0.09993527034560166, -0.28138131942583167, -0.5170186484267371, -0.27700831333898884, -0.06552488601908571, -0.19350417849320023, -0.6097543767495891, -0.10128193149737806, -0.45356265654869365, -0.18000623873577007, 0.10416151156199895, -0.007122154628624105, 0.23475724530853456, -0.5517478102349982, -0.38382857781543606, 0.31044011615986483, -0.0764342261246853, 0.061962060886054784, 0.11975549720709307, 0.24205207903785053, -0.4054613104378476, -0.3332490992260791, 0.0025977649109419944, -0.3074298126059125, 0.23312126379198178, -0.19228860997744227, -0.006651069648182957, 0.05757265588507935, -0.4311204138421613, -0.6795991943202306, -0.5821992278543977},
    {-0.23637937139202922, -0.33374711663735257, -0.4623822250974789, 0.2003705696707929, 0.26355141061044857, 0.12025705982462667, -0.14784470161756932, -0.112726029280828, -0.5514908594939288, 0.20186727025911652, -0.6616080998070948, -0.34304258856273073, 0.04195485884512454, 0.14197427875208046, 0.24315649002300105, 0.12423453025073125, -0.4719181970285912, -0.21900154273350017, -0.04306810486800238, 0.09040954682667755, 0.11043418535669254, -0.4622199480005786, -0.19793205419042692, -0.5244035344462769, -0.5232172314824968, -0.3265305626881489, -0.19960844536105393, -0.5169428154528173, -0.17807926309566782, -0.23043141271216988, 0.11884807084949121, -0.31054356137865746, -0.38333771949272855, -0.09291532761460561, -0.27305425677468, -0.40862756462464084, -0.20925118827310224, 0.06496881569774782, -0.22484769564207005, -0.651036334931159, -0.2849608917963841, -0.561112307673352, -0.6016309198206312, -0.07619194317309264, -0.46986532322981334, -0.12196464652773988, -0.5144253926465521, -0.5750077428715293, -0.11039024546131682, -0.11573463460214868, 0.022135690648465548, -0.1040419245446873, 0.12184527464521705, -0.4639825494159104, -0.6725670847943142, 0.07941672678560535, -0.4255110603393059, 0.057403119992222064, -0.37625242026327227, 0.1375744558770923, 0.14247945618215063, -0.4701491284123512, -0.5819346378872973, -0.5585461541946751},
    {-0.4608907314194118, -0.48870306279500725, -0.43267440231829235, 0.2664537456119267, 0.18655517798387591, 0.13431723701662326, -0.09184696378501915, 0.17730319351315588, -0.3970695531396284, -0.024918743771640193, -0.4444293555079829, -0.12495383538285221, 0.12187682471939797, 0.2756803783219104, 0.3605893335573348, 0.15152264077832742, -0.4263062398349955, -0.37730820308074736, 0.10646479218743123, 0.3677473535375643, 0.25143864065445326, -0.6193553842184013, 0.08881670989775602, -0.27782340137869355, -0.36221815235677124, -0.4756015301437277, -0.36311508225363587, -0.0868615369783136, -0.24089201884436257, -0.18864183017734465, -0.004902629567565512, -0.19338344648332137, -0.3318085715455589, -0.1857853105050676, -0.06683002055300451, -0.6689517864605176, 0.08949218894785964, 0.1963138184432397, -0.14818202444591339, -0.6721846979804285, -0.33874988322630456, -0.4688682072281968, -0.4869368870801868, 0.08710805677660918, -0.48354837429586933, -0.1363944786274297, -0.35322543449554855, -0.3030146384885431, 0.1876478881003025, 0.17986091881029723, 0.25002257585916077, 0.14941837222338228, 0.17425717488500275, -0.4481460287866187, -0.5620838846925893, 0.022488101935744746, -0.4213081269282611, 0.29025090940398357, -0.2899204248487508, -0.06282618823507247, 0.4902266408474969, -0.43595898477255624, -0.6884053092969953, -0.5975525617309813},
    {-0.5990866430049809, -0.5289398555505783, -0.4935611320817557, 0.204297486545316, 0.5294827073571425, 0.3359812971940361, -0.3090983352327325, -0.03881535975484268, -0.5257589938401191, 0.3681898887162246, -0.7306075529961952, -0.1892053152329598, 0.20894907774732507, 0.3713175423770042, 0.3811707565474917, 0.5567269044121244, -0.5438058940731069, -0.410086881556066, 0.24923235551477857, 0.5209921681299551, 0.08159558391928837, -0.732666548250403, 0.02281644497608858, -0.4869006718518153, -0.1277678498590673, -0.4782720318499607, -0.024560462153494358, -0.2044619715036454, -0.5136988642349356, 0.14609049633041396, 0.2619270330591084, 0.25340573844208486, -0.47663605248856405, -0.1755366001205192, -0.10871538325919178, -0.6221169900063226, 0.23612269154473337, 0.18289726512300536, -0.06224110446047124, -0.5202478604670142, -0.07046972580262738, -0.4810218306630341, -0.41977971113419144, 0.3661460170093104, -0.4548792913286712, -0.09925769236414522, -0.3787159087249359, -0.22832259528633256, 0.3080633291986235, 0.15882532248272435, 0.3205906570233262, -0.06542409755484467, 0.3808956674165034, -0.29754465744579517, -0.542548217847126, 0.14783989911544335, -0.7638040549617696, 0.011781570453458559, -0.23958978283094198, -0.20432195886393179, 0.09127998174552997, -0.4753492832902731, -0.7138726965050357, -0.6656260116270274},
    {-0.6563329688151471, -0.14815616165636344, -0.2738681935984358, 0.5730278923501325, 0.5552455390118657, 0.3511704770780738, -0.2414817721044396, -0.3746272063606963, -0.29246321071974263, 0.5384476781344528, -0.7039296892789906, 0.21974387593127595, 0.2481882503970241, 0.5625176095278069, 0.10764057802657186, 0.29791838941405896, -0.5672303728880485, -0.5982825899369298, 0.4439826686406228, 0.63846393750426, 0.4388844166189284, -0.6259592300121456, -0.13860787643661834, -0.08141833133266345, 0.12945185847408236, -0.5576164133487583, 0.2954668340097899, -0.34319271289322384, -0.10036082219822444, 0.3719102584158321, 0.5905984243593595, 0.5471531925334318, -0.6761441056015685, 0.04020538325971019, -0.34409160830280755, -0.40151338237126366, 0.17690495070205448, 0.5188786630535791, 0.3883955540291789, -0.6206176344886934, 0.06520003047515578, -0.3513511198589164, -0.3354406625897704, 0.16363848119871136, 0.028342244403954078, 0.11056400566782344, -0.4739243971698371, -0.25601411678361824, 0.5670640946919868, 0.21496002585184948, 0.5887560522807883, -0.3719337676447242, 0.31039858191971414, -0.541448193855851, -0.43730277762888775, -0.08334679921279059, -0.6728965387136036, 0.06237630552422079, -0.07536446955021464, -0.1620058247918481, 0.30747416039294134, -0.30138345275516787, -0.6959439379911454, -0.7136549660436776},
    {-0.6039442993360485, -0.34236835283547956, -0.25772377150889053, 0.27792081745780256, 0.5166206855881561, 0.3449120382826462, -0.38693792694558293, -0.03369119675029352, -0.29151615660630803, 0.4715350946546276, -0.6365823347056034, 0.026984668909461624, 0.18918803960560368, 0.3776351456945646, -0.09521917295658062, 0.3316037396073073, -0.43742954358332664, -0.36379113328197993, 0.06580647418613621, 0.6477735701360522, 0.2669665283833003, -0.7614141503923056, 0.1354832308829387, -0.4427633996162444, 0.05682248431590252, -0.44073330001101957, 0.12606342012354013, -0.40629092165123704, -0.19493425580546236, -0.009299836542113098, 0.4793126922339267, 0.44100623249373094, -0.6323584789531432, 0.025388076701984372, -0.15346834540436788, -0.6725389730368331, 0.2716130652739184, 0.3842694575514332, 0.39515309602045856, -0.6979178630803143, -0.12436107200275967, -0.34422041862926317, -0.25539320800090765, 0.20246652167134746, -0.1501641567867486, -0.17449579780075994, -0.4291175012670564, -0.5640014021491364, 0.37928786343832493, 0.10178340399958459, 0.4645188573216307, -0.2783010301853919, 0.5956448594416186, -0.47975552568359897, -0.47319168240121373, 0.16573276539679352, -0.7570663421646465, -0.055781864602485305, -0.3094675839484799, -0.13706048083529676, 0.31101755782524376, -0.4364309878085204, -0.7679099241223326, -0.6032754788727862},
    {-0.5311825233069721, -0.33590537338572873, -0.27954903251109897, 0.3699732292951847, 0.15639578848920557, 0.16647271310154838, 0.0249924599849738, 0.0494303872331238, -0.33229497948062225, 0.09310428171945263, -0.5383471650683783, -0.2096396468195196, 0.14725090318918302, 0.2916560556675498, 0.1255080653865433, 0.03813849331247113, -0.29646265977406877, -0.46692641837974685, 0.09318003933140273, 0.32964046137932634, 0.1902437398965544, -0.6234268496421774, -0.10734070246613747, -0.23447486353166785, -0.18593615151882664, -0.654112432307853, -0.03160924546501006, -0.44928431975729727, -0.3727496994509186, -0.12618127857191136, 0.03130854971014381, -0.0325602109495677, -0.36400416234276756, -0.3659962801090036, -0.37077423614631794, -0.403463302069177, -0.056183028234147746, 0.21004826770359467, 0.08013524122906963, -0.5063542141289148, -0.22820702997249542, -0.36054272614160177, -0.3863148147867329, 0.25026708654481034, -0.5487033286291649, 0.08295682623216583, -0.5330754656643661, -0.30430759948140773, 0.20662920100622906, -0.18285951990916124, -0.026082184111937523, -0.08061436749939863, 0.3797360493492126, -0.25762873621608445, -0.6369536594151453, 0.11058918175400044, -0.47110160209081015, 0.02621902703157437, -0.12242948076365147, -0.12962739532506284, 0.08800217745466597, -0.2644328930008221, -0.7749130213906933, -0.7124390822501239},
    {-0.5471459834452305, -0.30173483754200653, -0.3265623825280009, 0.5434290477213589, 0.2758666503537782, 0.37900016784409535, -0.07326206690876164, -0.38645715282770365, -0.3181529248973265, 0.43152373084642254, -0.6187078653276176, 0.04338367837886622, -0.10325838790926944, 0.1971726286592196, 0.25395265970733605, 0.3324614538071798, -0.5198647787200351, -0.5739323545982239, 0.16434377795998403, 0.6545908843553472, 0.4695681097930315, -0.7336584915085211, 0.17291907106644583, -0.1101343621621504, 0.19459750802748424, -0.38857033566332483, -0.01514909132082621, -0.3813142825598988, -0.44326879829231797, 0.24651462975758548, 0.5848311218962615, 0.1325949496704855, -0.48458428717098717, 0.04204948121161595, -0.2755250137061212, -0.6273508197502592, 0.23549631006010893, 0.4669794423593619, 0.3356641836810377, -0.41799650467572036, 0.015142592363901431, -0.2639265532347866, -0.39451035222278624, 0.39690721372150545, -0.36709616173659737, 0.033633550237439115, -0.6336417785608178, -0.5193139040365444, 0.2118014434543617, 0.2350070028746175, 0.21365121446730406, -0.013838534078738704, 0.4109040647831141, -0.4835184982073327, -0.5926851273317528, 0.028764718919960033, -0.5695956938976167, 0.06239672544488374, 0.0249005864812378, -0.19530158995480884, 0.34811965910508363, -0.21643365399520137, -0.7697504170970231, -0.7686814462903283},
    {-0.4010561690323207, -0.4667855471316198, -0.45111978447082524, 0.5006197472389208, 0.476644562139661, 0.303432335285473, -0.1245213747273689, -0.06821465230933899, -0.3865213675863786, 0.42232478286906794, -0.4552414596835536, -0.0649672879631379, 0.27755421778356154, 0.3440496375861235, 0.24825742524100536, 0.21230079395827747, -0.5468110173831968, -0.3498543365487809, 0.19529304219485386, 0.5315327950470538, 0.3944105992028985, -0.5312663360091461, -0.056181560818370724, -0.07973990810422935, -0.13062457048248247, -0.3530667072745283, 0.21854794304216468, -0.44867995590451065, -0.35772174146949576, -0.06365526961065571, 0.5342986190317095, 0.3816919460633138, -0.5913220555243593, 0.0821702055178855, -0.23094942879855823, -0.6625574325443842, 0.24643606091174786, 0.24338659142220584, 0.14861769667511, -0.6432033386743532, 0.05130349358756827, -0.4670185023866053, -0.29089759791372505, 0.4120104837323337, -0.33585297185477186, -0.03925204955033033, -0.32938319255002396, -0.3633933949521438, 0.13923727415459497, 0.5155929519063062, 0.17621273762932604, -0.25627680542413844, 0.24245356824254433, -0.4197209976290548, -0.6552102030377172, -0.09270505555819886, -0.5022527951047852, 0.011853693193273887, -0.23368303081026376, -0.17999344018686558, 0.23373159727270607, -0.32386279108111254, -0.6170040827028408, -0.4747958952127496},
    {-0.5611840887384678, -0.529629927179258, -0.35665647858483235, 0.08137962024294955, 0.3499641922850329, 0.39891583079194387, -0.3447044197455593, -0.10632383258654446, -0.4252236853506095, 0.24816371880699853, -0.6670437886497653, -0.26130320262217543, 0.016027487549926705, 0.16573132160399706, 0.14567074195390423, 0.36344675424929307, -0.4191171753284554, -0.5638335051296713, 0.182946540849749, 0.3658976674316717, 0.28446929364821316, -0.7460702142614344, 0.06990343912830638, -0.3302988476931016, -0.10458864441716528, -0.4886066794871204, -0.1527395391852837, -0.432252517256943, -0.382174340872945, -0.21490572266213973, 0.22803721734133683, 0.4930484564719242, -0.4918446997245047, -0.10349839523279958, -0.3672004500940999, -0.49687635695273547, 0.032367945371313524, 0.20120821836324176, 0.0984562203411081, -0.7271502507815627, -0.20561408124288502, -0.23670692750763214, -0.5215462057269292, 0.14386583720318238, -0.22760002938472695, -0.0698007107861728, -0.5411354944621808, -0.6198582547080679, 0.23670411261540447, 0.4023836888333335, 0.09163207355201479, -0.23443916821149835, 0.42431684658458924, -0.4299182993897993, -0.5789952976628737, 0.15161635333797663, -0.783724831826026, 0.1330686019254473, -0.09767665835540766, -0.4052558479596135, 0.23439798838524853, -0.18936342184707372, -0.6679900414527703, -0.7787987591202599},
    {-0.5638084412010911, -0.45957764322668787, -0.30188024382396333, 0.14102075577374745, 0.6514675808779435, 0.30820164685365437, -0.09009134980449603, -0.3813300834582021, -0.5527414068257556, 0.3324533738172503, -0.7725329447054173, -0.21658910905501072, 0.041236367463770664, 0.4025612050501315, -0.08759684238260115, 0.41541696562868413, -0.4654659203763764, -0.3932411814255061, 0.1114502827006411, 0.3270619416210712, 0.1798380262075832, -0.5118637722083311, -0.25300825367748486, -0.32567035624925067, 0.10063536836335535, -0.40972096278944664, 0.04932403523738389, -0.12158930253500912, -0.35434809778870235, -0.06969912001097568, 0.3627157646780516, 0.48018276093397916, -0.6841444125766325, 0.03780092443365391, -0.5203311868909672, -0.7008557456714949, -0.013173123764691404, 0.45005907249131194, 0.1656652265600144, -0.54701608040893, -0.1181824652070736, -0.49260613254356234, -0.6038156543268264, 0.3863193128545996, -0.3636802636378386, -0.12872080309560396, -0.5740407565449624, -0.5351401821109067, 0.40325031434736, 0.5211280859950718, 0.29677788025303337, -0.35251288825364696, 0.5367350728025573, -0.3893873915122585, -0.6609238028695548, 0.01580671070384082, -0.6662076997751722, -0.04330333344545381, 0.0025815952729408456, -0.23115539731612886, 0.19395971051025368, -0.43815555693582464, -0.7178800737549824, -0.7398508538952728},
    {-0.5017795252967389, -0.2061389490113022, -0.06208846261681337, 0.578084030462854, 0.4042351722413198, 0.2502684995840784, -0.23732628514282836, -0.12145866986231324, -0.2868305518934536, 0.18012605294445488, -0.6191375192812543, 0.23888921855142298, 0.24470687920453582, 0.406305245656447, 0.21140047915347895, 0.4039172031883069, -0.37177370718697067, -0.29885784844817487, 0.051988908541425266, 0.5259917575481088, 0.25409668398019025, -0.3812074692964554, -0.11577136902170597, -0.3360752465075017, 0.2458645047507996, -0.6047660470410944, 0.21711078811545212, -0.06638415146059987, -0.17284161394633507, 0.1669939543424184, 0.6103793247568946, 0.37380450040294305, -0.5232505502233499, 0.35776314233349116, -0.212144923964834, -0.6326700506625894, 0.3668658320507686, 0.24769123368482773, 0.4758786711976742, -0.7312883834315305, -0.008141233508769044, -0.42820265378959277, -0.38827669384657454, 0.24383829778788438, -0.11677721545328616, 0.1275524339841965, -0.5452626843949426, -0.3624314867434517, 0.2805835921915194, 0.44622124194878715, 0.3329688783216985, -0.08392032393734355, 0.4068968946294868, -0.3796221557888655, -0.5469756819536781, 0.21610291729623954, -0.7529553909636153, 0.2731182079488573, -0.031978272200203356, -0.19628051402089378, 0.32659278078700693, -0.17091552810866503, -0.7591100184601848, -0.6879026423370942}
};

static const float b1[64] = {0.7304520257814155, 0.7512746223430237, 0.671573773177943, 0.6575687815784769, 0.6674978153865954, 0.7440304032713907, 0.5150843101334484, 0.6423451269748506, 0.7333130388987046, 0.7086709291370004, 0.7382775800773228, 0.7057321202505307, 0.6768996530535031, 0.6632020097557341, 0.7575385182492094, 0.7251217594062999, 0.678866148869914, 0.7146085641958589, 0.7342021986151159, 0.6478147688124011, 0.6349671094376977, 0.6912778130079155, 0.5763257394172917, 0.6609339829485733, 0.6895927882969817, 0.7227796651587434, 0.716486815099972, 0.7236759364840455, 0.6745266808453586, 0.7043303738868584, 0.7290505559023062, 0.6635485909335077, 0.6814790716249468, 0.6739026689004797, 0.7162949579375562, 0.7198212930791413, 0.7331989214942404, 0.6739409787301234, 0.7072938793126864, 0.7352527906098645, 0.7157348043044383, 0.7182342000193062, 0.7050681124726983, 0.7224265247599556, 0.7285306880925507, 0.6777562600377548, 0.6988982575704556, 0.6847488218187193, 0.6434676662780959, 0.7260199709502404, 0.7143700059465502, 0.6183528328176899, 0.6502589914530226, 0.668491620268762, 0.7542035934111518, 0.527195703455083, 0.7062198744621392, 0.6053793768138733, 0.7454255506614386, 0.5504578467856144, 0.7371771381284422, 0.7161409420497978, 0.7108988915543903, 0.7401696986628796};

static const float w2[64][32] = {
    {-0.009824890599329084, 0.06817432541291907, 0.5580315081259033, 0.3845424627981545, 0.41092989445720246, 0.44858057277131796, 0.8109886834098107, 0.17305977066500577, 0.642313375535304, 0.6534630065899203, 0.3755657619199315, 0.8002837392456909, 0.6520519149553388, 0.7120669125852711, 0.2517764819411764, 0.9277048060408478, 0.671304100072133, 0.6777083640510043, 0.3059923191289758, -0.10308793261017324, 0.6451634816029943, 0.8325439548876684, 0.12000333936706434, 0.44723106196258655, 0.4453102626242168, 0.525991332929172, 0.6790870749868958, 0.4686774566221036, 0.6959534516165488, 0.546762902057742, 0.5808550145526671, -0.143740508073679},
    {-0.1426564846553775, -0.1691566124668432, 0.8656753478350521, 0.5330776304594261, 0.6495380393110909, 0.6737210468039587, 0.6962774914467973, -0.20863678414843684, 0.3454914853088124, 0.6800384784750048, 0.700599320146284, 0.7482104870042309, 0.7167555996711154, 0.6061037620468901, 0.6183170741495254, 0.5010318463824355, 0.6652000608176756, 0.9456989473041384, 0.45326040347626356, 0.04282479344772239, 0.5041128096259594, 0.5653793677009897, -0.20157345412866487, 0.45376825924417075, 0.7012966066113313, 0.6955920976987288, 0.8284796197665625, 0.71297990127236, 0.45215286364993673, 0.5032352796411166, 0.5951452376499744, 0.08331242478946774},
    {0.08942226858566862, -0.07800081495304652, 0.7833851729159736, 0.8620155103497663, 0.6433955492540592, 0.3638866173122529, 0.783578479803989, 0.166148664457558, 0.6429418989449017, 0.49552074317730666, 0.38438611266767114, 0.7810377909487959, 0.86911461403523, 0.6326193576881928, 0.3943605354838025, 0.4670456072002941, 0.6965349585265869, 0.4682814505587004, 0.49629637595308324, -0.15843886548276084, 0.4239917897204376, 0.5098749043703493, -0.030722558054989812, 0.4725494236094193, 0.6415285364266968, 0.5469813141504679, 0.6867106785027779, 0.5402723247654713, 0.38582873974004156, 0.8206346446410259, 0.7156052059276329, 0.007562463320996779},
    {0.052951863032635424, 0.12426642035828753, 0.6116405455261605, 0.6537965759379316, 0.3485949835788658, 0.45503678565318045, 0.4336551343220954, 0.08693822275188631, 0.6672461492638231, 0.4698692631872557, 0.6382984418560574, 0.714975695471327, 0.6758177639585199, 0.6063491263403487, 0.2501063260207136, 0.5702546902464734, 0.5517929805658621, 0.7140131259204121, 0.570614156100897, -0.08472241353162906, 0.5925946824990308, 0.6643529884460696, -0.25219876478275016, 0.6608117135957753, 0.580652013591361, 0.8264406049529313, 0.3669462631298466, 0.7370049500101996, 0.43213861373457807, 0.4892067670960032, 0.40806135226188117, 0.08522542186012129},
    {-0.11516387606720016, -0.21836940237639121, 0.808779349105162, 0.6322112385967336, 0.6434598667986207, 0.7923069267230118, 0.6186483211692088, -0.1703877583060593, 0.6425779059640897, 0.790858591999469, 0.5945102355274502, 0.5186623521700964, 0.6877858803986102, 0.5828519896048638, 0.4821750146756226, 0.5047601343614134, 0.8873569097362033, 0.7555500347568361, 0.6768450989115692, -0.08743080379028288, 0.721090628834665, 0.7234732529445895, 0.09766126351516305, 0.6051481104269228, 0.571093834859471, 0.5437458837133264, 0.7275343931335815, 0.7570608468135863, 0.3813808436664263, 0.6551351601431059, 0.42086111556592987, -0.0072498943869578674},
    {-0.20144144145487886, 0.085114370094975, 0.6400695077200657, 0.521728614308788, 0.6436930270082928, 0.45009525860475036, 0.4407396047747839, 0.17186440388592347, 0.4651134786578324, 0.8852638498300307, 0.3486733469855454, 0.8338607526718385, 0.6704219661238968, 0.42552224437798214, 0.5585395809007377, 0.712837429616404, 0.5925023577107762, 0.7172556718073034, 0.68667604746907, -0.07046029767688253, 0.3203828877127498, 0.3757430293477426, -0.0004213495769750996, 0.5527716101980074, 0.3888817873422774, 0.5863287089909516, 0.7734017725769089, 0.7361766150362786, 0.7794325311482623, 0.6357210789414341, 0.6657859794686981, 0.11782855137890635},
    {-0.03257685050057127, -0.05611395237234542, 0.42552579777800753, 0.5546795594005466, 0.46343843628537823, 0.4194422946592406, 0.7792882817485959, 0.21457648489489947, 0.7382763739780469, 0.5201563506831238, 0.34237876840637477, 0.42022377711431824, 0.6946503375818669, 0.7484695201229359, 0.33701199909597135, 0.884861689438699, 0.5262366935124323, 0.41728663854565234, 0.3144208778161764, -0.036797353084738665, 0.6150062379911362, 0.7551492935627543, -0.1282447010893123, 0.42280206218603394, 0.6984008855982791, 0.4301315007806124, 0.5522522517842599, 0.37221235770123245, 0.6591294311521262, 0.565067897502359, 0.5586506836317715, 0.0398865436562342},
    {-0.24353455120487746, -0.220010613335958, 0.5190527574706174, 0.8098064181452547, 0.6817701297816827, 0.6402180645989206, 0.49046791621182617, 0.12113743340371155, 0.6663661270703378, 0.8526724564623163, 0.4568355977693273, 0.48282689524459566, 0.5401016481715878, 0.35950211128617093, 0.3479683899703126, 0.815640174806509, 0.6571135324954727, 0.5771790094674961, 0.7399424437392615, 0.02651021623733349, 0.5313031812951718, 0.4439332521620039, -0.17373101042564126, 0.6149456897137674, 0.8268542325351638, 0.7111932283075095, 0.3801566545344152, 0.3648072512335428, 0.3239613141141988, 0.7413429162799503, 0.4349322700148847, 0.01865454179061938},
    {0.07559913879017856, -0.10642470374701574, 0.5118140734196471, 0.8162547584538248, 0.8514246885627473, 0.4361320452810885, 0.5738799544808364, 0.06463341506422934, 0.38470673995252125, 0.8842273291965155, 0.1829176955852673, 0.8310375533684009, 0.5167173194177559, 0.6895434392718816, 0.32949051821610287, 0.5176548872286487, 0.8264877619217794, 0.8874999814263365, 0.5361744843198203, -0.07736116588211078, 0.5636395261639167, 0.4899476629353399, 0.03299958813032239, 0.627349690155135, 0.6904955767062115, 0.5109723153574685, 0.7417573221221403, 0.6443884330377739, 0.49219143028635304, 0.8240756016582228, 0.6581953848523642, 0.21166713348305866},
    {-0.2113327522542295, -0.14886605781708379, 0.6397416702253799, 0.5039667252533553, 0.7464780439295577, 0.42677872605934636, 0.6135466785144854, -0.22848607585084693, 0.5200621654802063, 0.7205628417843839, 0.22136329102632124, 0.6390570018009644, 0.5779919172794038, 0.4275173468310326, 0.478678054474736, 0.5416577135202886, 0.49033762038095646, 0.9215712230434489, 0.3717951390963266, -0.138831465530525, 0.5752832229052836, 0.6463324640102684, 0.02183219458089409, 0.5024180029515266, 0.5400463065031044, 0.7005091910331395, 0.5333399564328453, 0.5890747235571617, 0.8357303753947919, 0.45898923053558494, 0.43473965683124055, 0.04624752740249285},
    {0.1942532439522628, -0.10801491743055128, 0.7561076971113446, 0.6582414931257563, 0.7465617370350269, 0.7660994465310074, 0.887045455881723, -0.025252105184581604, 0.777523805155741, 0.7056359080209158, 0.4382623617061719, 0.6969351769696993, 0.48418361272302063, 0.7589275941702154, 0.42693717059005337, 0.6036934801432934, 0.4689312577385984, 0.8597285271778302, 0.3017284210684495, 0.051715362114376405, 0.5150598406553666, 0.5851869963232895, -0.2655537541251495, 0.515619132968761, 0.6252312307790148, 0.5205998681772865, 0.7924869966887853, 0.7256417649662259, 0.48107348557968727, 0.39562859829933866, 0.4909828742533329, -0.21660027836645418},
    {-0.2283002042331411, 0.11924689830038573, 0.7016675593987676, 0.4570888537967458, 0.4532915381378137, 0.5032493934587996, 0.8530783038568035, 0.2022405537973775, 0.6619423197031494, 0.7965690816653993, 0.5880224606325053, 0.7822041026888636, 0.5262312429030566, 0.375831412706098, 0.6150329626774867, 0.9005889493289398, 0.6211364737618992, 0.5232095769308022, 0.4775564843481816, 0.007342465287866658, 0.6556005597687825, 0.3836460274839028, 0.1909719655125863, 0.7682811453870408, 0.8389091728388497, 0.5057420661241889, 0.6737421457368598, 0.5083824309533502, 0.5326591144208548, 0.6441432607013566, 0.8050738270073415, -0.055902921257136716},
    {-0.2188298781392687, -0.1283375931071966, 0.6188183198572994, 0.7265538883347381, 0.664176302590385, 0.692145406919403, 0.6449257158762598, -0.15710569108698305, 0.38936130946283953, 0.5162327934385367, 0.5557886575576384, 0.8362602289144364, 0.6021139435657549, 0.3826282757419684, 0.5329572916142734, 0.8602294805412996, 0.38890323205951877, 0.748614373343141, 0.330324770813515, 0.1607967484259853, 0.4698529751711247, 0.3852741224929808, 0.01745667615598162, 0.5713370235244373, 0.3677945587707543, 0.5876191923021228, 0.4010395364276949, 0.548740606809258, 0.5916016870131132, 0.5851938346805012, 0.714416920761042, -0.13090672477193774},
    {-0.249943570916107, -0.05302205054995874, 0.6042214338331227, 0.6587222728228422, 0.4260198676556828, 0.6770171166947441, 0.43140554520666846, -0.2681659052800807, 0.5130860872018835, 0.8831277686592506, 0.5319669641450043, 0.8766177355670021, 0.5088629775490694, 0.38866392378912434, 0.5512990681215283, 0.6895919152283395, 0.45663513778858333, 0.4431291687049287, 0.7145972153360008, -0.25353219590492615, 0.5794770733771507, 0.47730105054041727, 0.03707306760341831, 0.8091055473229172, 0.6567468887473425, 0.46919321557841703, 0.49338275420386535, 0.753502124888741, 0.6156902014289565, 0.7119386826290017, 0.38775683972648584, -0.13988620318888614},
    {-0.2134552220710711, 0.11042365292808856, 0.8237044390316481, 0.39648403094704227, 0.4552253610567788, 0.3997123888866632, 0.4189183109353078, 0.10737278587016473, 0.4015658240525624, 0.6825020783890118, 0.18341327540241414, 0.6590478039868102, 0.3850495786599758, 0.6607619175859945, 0.6415261057025474, 0.8973271951314693, 0.4746386177338097, 0.7918470477516715, 0.3012951014201613, 0.18435960356108266, 0.4537116050544346, 0.7909404953227667, 0.10465284415523225, 0.8084843568253827, 0.7964123628824294, 0.7640203682572949, 0.6432734105681139, 0.3278269382576205, 0.8197330515423285, 0.39021593009729433, 0.5819883375847206, -0.17516620840359504},
    {-0.21513966646242363, -0.10968093912447195, 0.42314256620834606, 0.4631341059204772, 0.7695054572564654, 0.74076714657215, 0.45672708468738077, -0.12251443351318171, 0.7727047223075124, 0.9160833953488463, 0.39256722758884166, 0.8613264431953558, 0.7289841888089393, 0.4662033154827339, 0.7569380658818702, 0.8560561840015267, 0.870063331464908, 0.6084250644388043, 0.6430741177780596, 0.17171654536166223, 0.6796868568477339, 0.553033970882182, -0.2264986897033375, 0.4164984353229593, 0.3715750690158756, 0.6964359150139898, 0.6957961152794672, 0.3746971627156246, 0.8237731693236547, 0.7758751680224216, 0.8803414353289709, -0.031068080413351355},
    {-0.024941734104903555, 0.19045610976876604, 0.48456666297820444, 0.6856765714500127, 0.6453177216788938, 0.715081557837253, 0.7215020076007033, -0.2002362414702279, 0.6439588009416097, 0.48186093854239104, 0.4769771378810393, 0.7602752248792087, 0.7325995660909015, 0.652293323706719, 0.40212939518496066, 0.5748751071794914, 0.6919590484601041, 0.6467836888917882, 0.4980767396601614, 0.18806176372163166, 0.3995151547665445, 0.7101754192375499, -0.15588538964938048, 0.7396592527156742, 0.4727474634934837, 0.8746323964621311, 0.8026381580311858, 0.7706072444376025, 0.4378180304271626, 0.5958766808437126, 0.48029228846166117, 0.21215479472431595},
    {-0.2706950324541677, -0.25369106572382943, 0.5205480592945776, 0.40532042434651455, 0.8799947379988251, 0.7203493878581864, 0.42777214058816915, -0.18833875320714474, 0.3183834992128563, 0.501723076638609, 0.25289396787806223, 0.8055844571999036, 0.7828616465260237, 0.38613940660913404, 0.43593633216385264, 0.6566873920772357, 0.39823159832998983, 0.875672384544139, 0.5031270044413719, 0.03220919021333011, 0.5020239582607969, 0.5881478621582924, 0.20163545622408796, 0.38982833415084645, 0.8317590598761048, 0.38236504025679574, 0.7268843945884589, 0.5464065729241002, 0.6261487789035027, 0.6061406153316304, 0.561577624838083, 0.21484949822490051},
    {0.1943265824486673, -0.2603107213745885, 0.5879025080058173, 0.512195598709747, 0.8122737110870697, 0.6371967941960617, 0.5752829938603761, -0.1594405291146077, 0.688817145682717, 0.9284773309442724, 0.6279622575701533, 0.7536934497442983, 0.5489507103346487, 0.6360632351389567, 0.7607435889718961, 0.9476068485192654, 0.690264490499098, 0.5171836268364054, 0.6304651882320556, -0.20054343045534664, 0.6322017145096526, 0.5454493884876567, 0.0009374540560304917, 0.6737876651295205, 0.5641114665731781, 0.882523818689129, 0.8554370208378789, 0.8068607812709903, 0.5792861690887113, 0.866946394928652, 0.8191370799982892, -0.10555699972237478},
    {-0.11995817120451399, 0.13868857488415132, 0.5982637542456294, 0.5214396978971356, 0.5439945517535406, 0.4354341120086454, 0.44957504318974967, 0.17304290972064795, 0.5996645711022316, 0.843680510112546, 0.19826501123178678, 0.5465481276493485, 0.6070415814561394, 0.5747585644893229, 0.531603351548846, 0.520275768087795, 0.7014665192201859, 0.5373909142177574, 0.7577217727957322, -0.14549925190237561, 0.7093299283732757, 0.5882413311508898, -0.09616626475672416, 0.8773006242128388, 0.4228457021162506, 0.8813921900578432, 0.7880242278897316, 0.5583239021657084, 0.5058262755800835, 0.5149142630314315, 0.4999004739392543, -0.1500906308225301},
    {-0.005414888237033729, 0.07834121450011174, 0.7919511502506783, 0.6375627853778719, 0.8901300372184743, 0.5515700380458048, 0.7404578108093577, -0.26909928371691766, 0.785899308082807, 0.9112453576823836, 0.6677209286428358, 0.5531097776919526, 0.6545430152552721, 0.511320222203121, 0.7640976214224362, 0.6703471797198665, 0.7805173499286469, 0.5710516551857631, 0.5958927893498887, 0.16382840231918394, 0.7814331493587411, 0.46970116373484483, -0.07826509031269735, 0.49682648335215507, 0.4122117935429511, 0.7356481008272064, 0.5242883975210451, 0.6992984528709411, 0.717295126379005, 0.5580232168892826, 0.7875234149672401, -0.003208941205880053},
    {-0.1600980554948618, -0.08681250867567862, 0.5622981812493741, 0.46886661846912414, 0.7331614446017276, 0.6508076930669264, 0.7362462730747483, 0.05489368680486115, 0.5823548795316676, 0.5512827622879682, 0.2548279156163197, 0.7217193160489564, 0.7030726374872326, 0.652436977926012, 0.7357065477448396, 0.7586868304102147, 0.7922219074045576, 0.5451439777832858, 0.332948452077058, 0.034043749576613255, 0.551880106221462, 0.4607840392485899, -0.22242147690169592, 0.8911437128786711, 0.5159464749534766, 0.38423451284716953, 0.8029196377580549, 0.7284792860434748, 0.6177634051302519, 0.6190225018369879, 0.7744722469015102, -0.2654978134309829},
    {-0.21580836107872106, 0.16905782164260758, 0.5102848241394061, 0.7530231596142465, 0.757115693453617, 0.6897508104174855, 0.44136719537037433, -0.03702946939389759, 0.6375741883319884, 0.4514306303653948, 0.48863965968942225, 0.6517399431020583, 0.6816826029403685, 0.5814761301202747, 0.6192421197081073, 0.6291900466732948, 0.37500646504281965, 0.5906582707471022, 0.3785005744829374, -0.17639217266567572, 0.31401855746483165, 0.6596467501583094, -0.04414979198663639, 0.527202933585892, 0.6812161198176157, 0.6355789624089225, 0.4921772348417334, 0.5809681965280067, 0.5619711176356124, 0.6986586480249558, 0.5892272926611201, 0.19834947999176972},
    {0.12231735295173511, -0.11501232068651582, 0.5560625936379271, 0.5313819528735351, 0.5911622456576257, 0.6066587666677956, 0.6731879931938126, 0.032575344062580794, 0.5789473975921893, 0.7619789614733917, 0.7276369310966526, 0.7362556509252075, 0.8643698608737883, 0.7186116999720676, 0.6982599339913615, 0.4641033450625894, 0.4167164694895449, 0.6392053991751264, 0.7644277332841952, 0.15195533809481376, 0.43974984982826437, 0.6557456199649767, 0.061687192420972224, 0.6081731047812615, 0.7255831449743281, 0.4695509094615324, 0.6953651378326622, 0.6304325533671192, 0.7443299124208747, 0.8703641271691288, 0.7623995891563412, -0.08222423384701916},
    {-0.16878071696616775, -0.25307530342606527, 0.7369142314857611, 0.5497545289060355, 0.6675334063065554, 0.4144314164666499, 0.48968231449124544, -0.06764111210761628, 0.44747922137092083, 0.5875520482902064, 0.5530704290938301, 0.8254813636787647, 0.4719791948448832, 0.4075462896798243, 0.5819824113198127, 0.7669474464155097, 0.4086857076204152, 0.7658462011429281, 0.5705726889740336, 0.19345933582161723, 0.5519822741256135, 0.585056067355003, 0.1077892087613021, 0.602657941181878, 0.3762599314419243, 0.44716554666088226, 0.7897762915396593, 0.36506954677683073, 0.7907015364012202, 0.7091832053249073, 0.456793335401814, -0.2569571840317304},
    {0.1680380873569824, 0.14562880306070589, 0.4715502145338023, 0.7161251527655297, 0.683354610190341, 0.45949567466437524, 0.7543618238016646, -0.06489833241747053, 0.3221991947668398, 0.7090593887584018, 0.2609066970683797, 0.6221037566170259, 0.47215059950065585, 0.7415894843380454, 0.4131660910857647, 0.8428505529503652, 0.52082203358254, 0.5191934121532148, 0.4666367588486297, -0.1356914161716209, 0.7764917647475468, 0.8492904219323687, -0.1229779771166604, 0.6166107699983995, 0.7771617054365971, 0.8583053476364174, 0.8495112405186096, 0.5249125032128894, 0.47354794456185834, 0.7426741693421746, 0.8037254324617797, -0.09252767887344696},
    {-0.17707085601603945, 0.05942835983950879, 0.6343569713502062, 0.5223731209335299, 0.5384859148134147, 0.5700949087011957, 0.8324616329928909, 0.15428384071627427, 0.5419808691884235, 0.7901265230247648, 0.4318416282645864, 0.8826871424783073, 0.6331426963744, 0.5118062293038274, 0.6100515179701281, 0.6670112669076936, 0.6993207658678151, 0.8155450140401841, 0.4554535591709697, -0.23170702513100522, 0.6689047000931831, 0.5675557833953221, 0.08178853662724876, 0.8139803925406532, 0.5900382633317841, 0.6036697198576653, 0.744010365349011, 0.7710138972093313, 0.5445846532006009, 0.665122138866281, 0.5941742282112001, -0.09023368812363962},
    {0.13816575813813578, -0.004962575387121024, 0.46244516689612847, 0.5243780717329372, 0.6273986086935878, 0.6555693833437677, 0.7011168797375404, -0.16842666292767666, 0.8129663270608811, 0.9530400876420172, 0.556109398277315, 0.7542954543306385, 0.5266982486857055, 0.7886395783452937, 0.7124026858671706, 0.8828939406777129, 0.8341531797401063, 0.488257349875544, 0.4216042259642122, 0.1514375468268903, 0.7187738903496639, 0.5949860230116145, -0.1622783149845509, 0.8194132485586976, 0.5001787979008716, 0.4677088849065224, 0.7834352860652859, 0.4500190052610765, 0.4247327318212353, 0.6473253176306386, 0.5949000848365683, 0.16230608533213853},
    {-0.07430513927361779, 0.04124956732273581, 0.7657096465944185, 0.6266625900393925, 0.610414471413895, 0.5138948130728929, 0.5394442573154938, -0.02243914594152013, 0.3499198527565592, 0.6494505145923338, 0.2494092346760134, 0.6524576448343969, 0.8581693197919309, 0.4294986679152137, 0.7244866941886751, 0.7102582918189392, 0.7985296494815686, 0.7981962148389802, 0.6981474087363339, -0.1604191230623844, 0.6075259176060375, 0.5990282931071489, 0.048848307213886506, 0.5603626080914149, 0.5407454686986882, 0.6011042009840702, 0.561653987525984, 0.6199807455868677, 0.8655699450081816, 0.8891082175792868, 0.845125107083963, 0.13233278299998816},
    {-0.17449193513511366, -0.22391681123193344, 0.8539976720434906, 0.8391562904378348, 0.5102899631443409, 0.5786235574432445, 0.9231028432963285, 0.13108516252656982, 0.4083608074295038, 0.891604239370133, 0.29047436401436044, 0.907859215033843, 0.8631062092679695, 0.5895614107102859, 0.7556392675861514, 0.6695504006674475, 0.7036571456190314, 0.8731705657755366, 0.7454275347248563, 0.03623267374604609, 0.75702802282405, 0.5204081639375135, 0.0196962209636941, 0.8264651857533196, 0.4562966355936362, 0.4400653557670816, 0.85530158044169, 0.5648745809527382, 0.5563505201651301, 0.454067635551619, 0.8810266462695069, -0.15765979589345622},
    {0.02184074942154844, 0.009616380007688548, 0.6981447092005443, 0.6122861629460015, 0.7905585387196156, 0.6023603672399412, 0.6478087357970047, -0.15034657794065617, 0.7663979807117483, 0.5490322880106958, 0.633367477408832, 0.6476265710579482, 0.6136088047072609, 0.825772897884264, 0.6345027666010443, 0.7076086138389376, 0.3803436157719589, 0.7151725266470872, 0.3268231813271522, -0.06160732204196575, 0.6282997022697937, 0.6297712606830705, -0.2633996316473472, 0.7647134397406832, 0.39268546325084064, 0.7045598022738837, 0.8529061066377247, 0.8019355060757536, 0.6353396297211881, 0.616240352739828, 0.5254699368721986, 0.06470165183011346},
    {-0.2487146928064873, 0.016633000058134517, 0.664865404979239, 0.4840951498780889, 0.6208965755539902, 0.5730146814835383, 0.5994897107812711, -0.010847362713101018, 0.5424664299339638, 0.5805791434635418, 0.34792277353440376, 0.7406803528977303, 0.7638144818354472, 0.7006768422470627, 0.7890754320022629, 0.4701891952710622, 0.8968449267787899, 0.5315102596097877, 0.3722616349218759, 0.11160225705500987, 0.6173219140751244, 0.5436504224360753, 0.20083872070429548, 0.6837942086650723, 0.46109000017788065, 0.7591971443848594, 0.8195590317186718, 0.5469250521886428, 0.6516028607020906, 0.6245995167971359, 0.7545114819836235, 0.20833989003165354},
    {-0.1667620111659146, -0.08679228447364018, 0.8454165220303556, 0.6725328853604505, 0.5894059544415748, 0.6514721280665005, 0.8248305105347344, 0.12118869156936359, 0.6351003223561232, 0.4684124248821792, 0.2917103587765403, 0.775006019305019, 0.46103990688441243, 0.6425177216200596, 0.4070766292226446, 0.7429275548794931, 0.5196059070136205, 0.49219805516601944, 0.7868070477183569, 0.1647622486557847, 0.40260103233121236, 0.5520787263204174, -0.12177210101355572, 0.6854812109054603, 0.8861611242129915, 0.6422137149164544, 0.7872977700528422, 0.8754941184252693, 0.8503105660815387, 0.45677579724831635, 0.6876905217289265, -0.1744637316381625},
    {0.09293854927503553, -0.09742186779445518, 0.6424927878232001, 0.8092066481715746, 0.7144261862015855, 0.6189500075169043, 0.831858885492465, 0.004498864112286646, 0.7462484479080705, 0.5492138128397591, 0.36704972240590855, 0.5893690096574637, 0.5126592122346054, 0.8600975329211534, 0.5131113002988315, 0.7928615826446973, 0.47571832613191267, 0.6339847334366601, 0.807922053361923, 0.1364164857405987, 0.37902755825342827, 0.8463658771775413, -0.10262281730679847, 0.5888281600892766, 0.6525511626102122, 0.6702827922630901, 0.5945833294231332, 0.38097728559788535, 0.5789723214331701, 0.8058634373122369, 0.8270765265573952, -0.2782117793190582},
    {-0.08410578292049756, -0.03804990658908151, 0.5071178124452385, 0.6276044823253564, 0.6558012774938754, 0.599041011751229, 0.5316463967166619, -0.06418558963004817, 0.5649208019012603, 0.8552887242199982, 0.5269576973076542, 0.8322003529854963, 0.6593521487552527, 0.48040993996922343, 0.6193124257016394, 0.8106711509517741, 0.5289809496005031, 0.8630380544315723, 0.7343763866389951, 0.09349493372394925, 0.7541356279909711, 0.8036033556381378, -0.2700687381792249, 0.48129619180919625, 0.43332538959213623, 0.4326347767637728, 0.5081455995566959, 0.7708150241756382, 0.8427305742731083, 0.8792789304652177, 0.6006376842207425, 0.05015871127861386},
    {0.11335571349704149, -0.13633629897139177, 0.8617207126951804, 0.6286272520670675, 0.6252098824124265, 0.41750153912716287, 0.899647089577752, -0.213918121362168, 0.43936223773398425, 0.5805102600637652, 0.5886596483201888, 0.6687837402852733, 0.7183394422224666, 0.8472089823239958, 0.4909867620419797, 0.6648837972310944, 0.5203959818199033, 0.5629265842143565, 0.7514738371569489, -0.22190985496780552, 0.42116390060428, 0.42306490627987986, -0.1294520554972718, 0.41456214926778717, 0.5740282365569217, 0.5293089492377809, 0.5096916156882982, 0.5468027666131652, 0.5662533935520018, 0.6769645384161178, 0.5776728880018681, -0.21941331900052868},
    {-0.18210550976004536, 0.13955711316056252, 0.6158806303031509, 0.391532963218406, 0.5356089977415286, 0.3929788921982234, 0.6884473931115839, -0.1546603822277673, 0.7973811375717642, 0.8609690125755347, 0.6039397411963454, 0.8100650023739643, 0.40585681325194545, 0.6305518227343373, 0.27447157313548004, 0.6699277199699437, 0.5597908245281994, 0.6043382629835176, 0.66179956365486, -0.2765320398571522, 0.5230899258487359, 0.7612316563232299, -0.13966061787102363, 0.6080775800313011, 0.8404076707439855, 0.6144018382404697, 0.5741368963393647, 0.7847676033135235, 0.7307558459806516, 0.4970743439353548, 0.7321702963397806, 0.0011477492816395565},
    {-0.09537635945035396, 0.03142657897023792, 0.8735538838670394, 0.4144421840537238, 0.7826773523521738, 0.7536164542403228, 0.5505748019258933, -0.1967371051300697, 0.3711398742241773, 0.768861792671954, 0.6684636366266473, 0.5227683150027794, 0.8459564718218832, 0.6470092373647794, 0.4985738008659175, 0.4978492770231044, 0.6375206421891844, 0.4397573588011705, 0.5285507466070315, 0.022568988880333662, 0.5850479968054716, 0.7741301509158905, -0.17453987382467906, 0.8764723724481395, 0.38983415283816786, 0.47145846201240615, 0.6483173834251937, 0.7421106974380124, 0.7285827361891315, 0.6968093353072632, 0.8301761347251789, 0.12585321489372855},
    {-0.2163876983930939, -0.22962230188732247, 0.8743870376325794, 0.8145949511211514, 0.8051016976345057, 0.4456774671618602, 0.49809814859376, 0.2103993067204768, 0.7039668301817856, 0.7167474166740381, 0.6593169726179482, 0.44799761831487217, 0.8275974137660292, 0.8362345914101359, 0.44557521069614114, 0.6332421780196054, 0.4951380423733329, 0.8323379127551881, 0.40118834115261554, 0.12531014426518539, 0.38886482315646936, 0.8420791301566626, -0.15298373138198465, 0.7938975855410302, 0.8232819279182866, 0.7964695231718014, 0.8705081261778547, 0.5670320591290018, 0.8001469063525893, 0.4820561814316129, 0.6653310520137437, 2.2208104576998047e-05},
    {-0.26370337864468657, 0.06185786271176907, 0.719158787726827, 0.4260465324759861, 0.7638713555597229, 0.6054930377750883, 0.7321016566090434, -0.21859283639202512, 0.6930204762605848, 0.7701753356007348, 0.6510894045086054, 0.9016204292069755, 0.500395652852449, 0.8109548346472313, 0.5337171451184748, 0.8925129463628678, 0.4357139207788745, 0.9169556384431222, 0.41774052632123937, 0.01392182648200976, 0.6231261632126178, 0.5388641458256329, 0.08429665701372603, 0.5202595270375566, 0.7986454020675803, 0.4034648502445144, 0.7304184667049465, 0.4974564258312048, 0.691804407128032, 0.4443226521335627, 0.5484828996712058, -0.017568094819110102},
    {0.21773416542986454, -0.09627466952483738, 0.8023424967512683, 0.8162611480838848, 0.6294736183647524, 0.42355864122869813, 0.4656017814951101, -0.012919348636984017, 0.6049698047201876, 0.7106049163887328, 0.4335215064251018, 0.6700195976379633, 0.7871091489903062, 0.6070240310501855, 0.5374814102226092, 0.7900498407289283, 0.38163251774030255, 0.6127790638661613, 0.6034896927009499, -0.06018270826377284, 0.7934922536673021, 0.6982235182895568, 0.014195287225192718, 0.7796031476755575, 0.41994110451285377, 0.8211127712229191, 0.614162329673697, 0.822443883959731, 0.8058072738326478, 0.857513729465715, 0.5937306991214432, 0.07322711811907459},
    {-0.015356376793284174, 0.011765582719876353, 0.8671904462981845, 0.7259794201177359, 0.8478133656913581, 0.5871525945151608, 0.5824941145162578, -0.011232804852002624, 0.6000327415150272, 0.703769198892622, 0.205095263357145, 0.8802185218942193, 0.491049517557982, 0.7134386080290533, 0.555659674822516, 0.6714213501497642, 0.387642479519267, 0.8758877100235559, 0.5877442358424461, -0.0443088893089965, 0.6121311655923115, 0.8391986431673315, 0.036167546219649384, 0.8076849271467634, 0.35356917116529707, 0.7091313031567638, 0.5717697719624626, 0.8266636792530914, 0.36922093147698054, 0.9118190774764637, 0.39994557046382345, -0.25415295389096815},
    {0.0668356447088964, -0.1688671094628053, 0.6710495592511052, 0.8354789148291244, 0.7384373563055219, 0.43767460219691423, 0.5372662884572582, -0.04709377114020528, 0.5969683067174995, 0.6349811384090238, 0.653459438540306, 0.8925570319224742, 0.8058230729624166, 0.5480987575361229, 0.4023272184058501, 0.9317710747136225, 0.4055589781026832, 0.9250619563166476, 0.6086864070262761, -0.1022709726751546, 0.47897516758682085, 0.6185730047800985, 0.03635895329184153, 0.4652473345129322, 0.5997491070766958, 0.7241362298806092, 0.8377698819545968, 0.6373378463787157, 0.8415594083438305, 0.8825106585517082, 0.7888281985661265, -0.09440384114536},
    {0.10656353176773654, -0.06317982465143532, 0.871982051476084, 0.6375879129184361, 0.6325659922288693, 0.3497590583269227, 0.6856368464823898, -0.04887465178567181, 0.5440139320964603, 0.5517845080675974, 0.33431697198020505, 0.530584709443865, 0.46119969860984655, 0.7164055462535935, 0.5916424457094638, 0.7078845142796818, 0.7633513809493742, 0.6346969071977384, 0.41017045971000515, -0.14984431511561236, 0.3892871871275195, 0.5645463758783171, 0.11879115436774304, 0.5377699171105106, 0.7897088834311019, 0.8194422808554793, 0.55510368063281, 0.3561185308570836, 0.7695282741671718, 0.5368485577572286, 0.6698640288870102, 0.07957850386551692},
    {0.028312758776311904, -0.1942287945946926, 0.8078669595487654, 0.407855147736242, 0.5594319180593139, 0.5662682219291089, 0.45839452902718625, 0.1481922294756814, 0.5244947451532254, 0.8761380172492113, 0.4047159096930266, 0.7467924847661719, 0.840464184724103, 0.7395895355306672, 0.3746208333388127, 0.7975196562399863, 0.5990390902361095, 0.5581420439663443, 0.5880539449184318, -0.05915749339458856, 0.3461497371102307, 0.6500921872619131, -0.1637423886552261, 0.5004457115813475, 0.5174025484076251, 0.8363727554768993, 0.8097711694541113, 0.596161828753084, 0.6215341755595477, 0.5508793514353085, 0.7862655083628964, -0.23970527783315024},
    {-0.07146948566627613, -0.11800902333429064, 0.6607811634715948, 0.7400746982261937, 0.7809326516274107, 0.4815015797935991, 0.5658684741229691, -0.07048742581364141, 0.5396791431294786, 0.4212172472637318, 0.30264960609744457, 0.6365997000857655, 0.43248268616133356, 0.565881047531666, 0.3041958415007669, 0.7821349584253301, 0.6581864602950466, 0.6502453280220499, 0.3635334617324914, -0.25863743878635725, 0.5488743541564453, 0.6453431180597826, -0.009796519758499541, 0.5791438606034409, 0.464511120069384, 0.7040581257212252, 0.6011903032249096, 0.6761181883580114, 0.48577239283949697, 0.7272794177188466, 0.7796378391507273, 0.016040087450140735},
    {0.20806663634246894, -0.0989776057032074, 0.8267900678438836, 0.5869207665602577, 0.46365153797026176, 0.6261600750208816, 0.6824152583832684, -0.07492847486155893, 0.6658416651373043, 0.7485445237264594, 0.39116997037513307, 0.6326821742715681, 0.8323191231958353, 0.6455129680809801, 0.5021970995072207, 0.7240904824506357, 0.414943753367192, 0.7213986258878096, 0.7240283727277504, 0.016411762375621527, 0.8207429582909265, 0.7755973495821757, -0.11288330084468196, 0.700331673290672, 0.7164555220276114, 0.6166357850150908, 0.7541722619410797, 0.6924559695306357, 0.4613237854520699, 0.4138444280175342, 0.591101957997832, -0.20897622865637303},
    {-0.12174188531852918, 0.10467773022336865, 0.6729144784177906, 0.5799077070211398, 0.5650381072218424, 0.5559651991237774, 0.4594844439274838, -0.003056276656546147, 0.7237162578482736, 0.7457774178590475, 0.5986824167219919, 0.7994416525662831, 0.5247574977970886, 0.7048763577503732, 0.30654413113432855, 0.6852703548565013, 0.71246115182564, 0.6024642694967002, 0.5258660894583804, 0.008632704444877324, 0.33288146605244595, 0.8192693408979566, 0.1528096515803139, 0.489895609923351, 0.6897053568115956, 0.7501449987528349, 0.8692254777707759, 0.5405047344179891, 0.5878497102041452, 0.8853462534245777, 0.7733805521232852, -0.08155154836358283},
    {0.18263353602227958, 0.12478467191673925, 0.4688987160715518, 0.44744477094984386, 0.555617194132498, 0.6818261972587184, 0.8200400385529798, -0.028281719887604875, 0.7347626906431841, 0.5054508913804837, 0.3233512702183675, 0.7829532692287428, 0.8837971300409834, 0.7753735275934646, 0.6110512393248023, 0.4579417061162554, 0.5520449593015109, 0.7085645357323106, 0.5660848954473624, -0.008336389264396216, 0.6001107160875931, 0.7061213482299269, 0.09620474662032351, 0.4775457850528439, 0.4759357007595582, 0.8852501773775922, 0.493340452225989, 0.8170937306606942, 0.5813206317811356, 0.46523438484440766, 0.8611861100963476, 0.09941496824731645},
    {0.012598894077074225, 0.025486198112217605, 0.5840375217502396, 0.776982314352376, 0.5777142129025982, 0.3715363596733284, 0.6388122516445758, -0.14032401566586117, 0.44286773784521716, 0.6997928339570767, 0.3625171353878355, 0.8733876996021307, 0.5830390398920777, 0.8609398640674164, 0.665110105535559, 0.4962046563322652, 0.6381308514388604, 0.8454918409254858, 0.39975782602816806, 0.04954793333095535, 0.6461639804590379, 0.6207180881535485, -0.16153113882041786, 0.8123882842906498, 0.664741724221824, 0.7099798561483655, 0.9154843018703352, 0.4759484687191017, 0.887249446296189, 0.7409115778905208, 0.6621065395372449, 0.047168649895161556},
    {-0.0260635205720027, -0.15091702116255729, 0.43789544604551095, 0.5242282117781533, 0.7203862130585768, 0.39913882831733827, 0.9105109212895558, 0.00033681550326190656, 0.7741937039096443, 0.9125174072202589, 0.6930433911427926, 0.6759273291577402, 0.7640723699056962, 0.538909302513604, 0.5591235920099635, 0.5747394929049844, 0.85019740993153, 0.9377728752027079, 0.31306453998500555, 0.031407276010679115, 0.41036366321109324, 0.7605739150534444, -0.08733344615827826, 0.5389381081506758, 0.49270899307208676, 0.6095037567051145, 0.6035142516673501, 0.5831999270553967, 0.6539571703978111, 0.6810150258776703, 0.7800865223710299, -0.11461003656249653},
    {-0.015704049763157406, -0.17461130665102484, 0.8167781808414131, 0.649764760512396, 0.3371822069196239, 0.4877530452447955, 0.8783885841668956, -0.21485199915704695, 0.45926097568229, 0.3774948051651159, 0.2698276641445448, 0.5415676407349257, 0.7393349765806226, 0.44904067725643654, 0.355588513171039, 0.41014359995100474, 0.5603429221758112, 0.5749578869109199, 0.6652122880440946, -0.1377662775886163, 0.7532328535902795, 0.5210840286013995, -0.19805974480013036, 0.33451990461582853, 0.6699667769820286, 0.7234828410321135, 0.39232118120730297, 0.5396660767836101, 0.6904068589874993, 0.7387358253737895, 0.680480129977454, -0.13236463891034603},
    {-0.20162726594377664, -0.25193503885022844, 0.8380860599941864, 0.7064786241143619, 0.47159232548640045, 0.7724596981369796, 0.6354183787268427, -0.15747487137428173, 0.7390147780602053, 0.6028172124993753, 0.589115091721171, 0.5049487407088405, 0.5526478580480779, 0.3909530310856729, 0.6131259759158745, 0.5899406874222108, 0.7456414699198375, 0.5907282336630003, 0.7044787350230204, -0.25252684655948904, 0.8142791001510247, 0.7241235513435269, -0.0660436513297471, 0.8999214599085372, 0.8494355645463277, 0.8205271406753496, 0.8858185868356769, 0.38944880459562303, 0.4251778992829154, 0.8547558603943232, 0.42036277786773896, -0.14361227192901238},
    {0.09864827615358567, 0.010739194711634398, 0.764977653619741, 0.7467369478187024, 0.7685427700637546, 0.35048488320508153, 0.8211972269069853, -0.27202562838547967, 0.6080921736014532, 0.6770889031548226, 0.5626006182338826, 0.5497843409350558, 0.5627562339286414, 0.7248817473745277, 0.546349619931421, 0.7346415545798303, 0.7742206387949829, 0.5478969073367314, 0.5197994292600654, -0.1404944014888276, 0.7926633445095101, 0.6352439930869125, -0.00115391764330661, 0.5159488288417873, 0.558316437269877, 0.8547203664590525, 0.5621171788530883, 0.4870588615643319, 0.4843721277288602, 0.6177969518774922, 0.7691232337575705, -0.11427558634554918},
    {-0.07140881138683404, -0.20671813453971818, 0.4911272394240313, 0.6627047708699622, 0.47454223523632005, 0.7664928494768893, 0.7083113235254292, 0.09553002944537324, 0.3805252013499025, 0.6389121868802867, 0.19903355525075953, 0.8315305986367026, 0.6030719866785555, 0.8343187492433776, 0.773316718311253, 0.46705667471692514, 0.5207746885186617, 0.6991898515782615, 0.5400967543414217, -0.23761768935877672, 0.4002228666136331, 0.6954757516033386, -0.11763057437409173, 0.6860490940183558, 0.753806911954575, 0.6037547379633322, 0.7492921076158642, 0.5628835330247314, 0.7614222241054021, 0.8469151081918588, 0.413644663714252, -0.19458488189844503},
    {-0.0384714082800663, -0.014238867100552959, 0.670088468232175, 0.5700128086755826, 0.3669269199355626, 0.23780730733694314, 0.5811077851384091, -0.022471937658399416, 0.4585639564279937, 0.43650849324795427, 0.4579860054286864, 0.43621367235307684, 0.4499233322046762, 0.4395546965047395, 0.5177558102918914, 0.5369052373751182, 0.7101561050919295, 0.49751191129554423, 0.7308004197999362, -0.22318197136701998, 0.3952143216695463, 0.5831430850427892, -0.24214744830463591, 0.5079291512326238, 0.5210769235180454, 0.7475975396677463, 0.3233430553166863, 0.4947419360109072, 0.4377427725593501, 0.5836837450188319, 0.5453620620051038, -0.1344565602013817},
    {0.07042754908598593, -0.13896277085612008, 0.7253014873146694, 0.6325487632660162, 0.48884203012509925, 0.7789875035260838, 0.6070306485305799, -0.20895691859479895, 0.362154062954822, 0.7699354422236693, 0.5535133127384247, 0.6013910267928594, 0.6660776679943416, 0.605945975584218, 0.7865411553677264, 0.6641352554253824, 0.43728880874902115, 0.7652238557806263, 0.727346587625294, -0.27283382195265177, 0.5016240523821406, 0.3540426050763049, -0.19695977111516938, 0.5178355347859256, 0.7632417869178963, 0.7422749966617543, 0.8037720767015679, 0.6133453401767038, 0.4086702069518966, 0.7034406399137101, 0.7679153636379665, -0.15937517957353248},
    {-0.03846504271213911, 0.06115746087251821, 0.6447854406916956, 0.46562576304077063, 0.7982358481692694, 0.5168816295240587, 0.8056376045322527, 0.09587667949349653, 0.5823092977332489, 0.6054794394022311, 0.3243094741509045, 0.5359627520901762, 0.46307181395199143, 0.5262323940196816, 0.24431294182929342, 0.7193300734082344, 0.7220125576207279, 0.6206199454496937, 0.6395389181583073, -0.16454185841529553, 0.39164470942830315, 0.5426467970574103, -0.2605337022814811, 0.5553227823137072, 0.42966721393463253, 0.41146673099287956, 0.45800121749282485, 0.42891028080570487, 0.8450154120304044, 0.5283276277272448, 0.5332512811402358, -0.04432312493444923},
    {-0.18254645179776383, -0.25116142234999195, 0.8653982839228836, 0.5044238070012516, 0.8683303823673487, 0.39842883218186465, 0.6716666852945399, 0.053676907814771, 0.4057059552412566, 0.8219577340359461, 0.35425945536521636, 0.7645834887406688, 0.9347987403845777, 0.821454712601743, 0.6787053064110797, 0.8950929798732435, 0.3987700796942821, 0.5181875076195154, 0.4931924628244775, -0.04290626221505075, 0.3428944571772595, 0.8408764730792293, 0.10747749929535694, 0.4240912838134176, 0.5726938402572603, 0.418298473882776, 0.8976391794443361, 0.4409641657899739, 0.44232380110411523, 0.48308449136259046, 0.58713369625981, -0.008843973167376866},
    {-0.15182914593935973, -0.2611508828865205, 0.51877163587771, 0.3608993316661882, 0.7592028795483907, 0.46249631426753435, 0.885730712751113, -0.18005835806344156, 0.7170328602695187, 0.3863891959559138, 0.4552196175031862, 0.4391354735546359, 0.4718704161703369, 0.4333493237155707, 0.5963237417518216, 0.4519043567664255, 0.844212731425495, 0.47780775868483283, 0.37283200922730647, 0.03372700817751867, 0.467734817723388, 0.5527319970836223, 0.19648931070446676, 0.6183352895277597, 0.7312941403796309, 0.8000718086352174, 0.6492552795070837, 0.5287451810089729, 0.4323533591586173, 0.7145688654943732, 0.5603828219197213, -0.010403664694831396},
    {-0.236731355741048, 0.1266784217299073, 0.40901550533976994, 0.6990354770777022, 0.47692947440419486, 0.7676653288055689, 0.8237893868851822, 0.10821172594639725, 0.46209757357378195, 0.8501441197330101, 0.5999812445969419, 0.8022404679106752, 0.8875375764618191, 0.8170797793619496, 0.44299149850878305, 0.6651175036637439, 0.623164040807573, 0.825589100318028, 0.7737521994740368, 0.04271395885283901, 0.3581718062336517, 0.8448437178957561, 0.03433932127908004, 0.8748775389172923, 0.6081657573285162, 0.5614985771195732, 0.4971036348990877, 0.6739860592961405, 0.46757829313559, 0.6959824999072535, 0.6760705117585648, -0.26072594801461496},
    {0.08055835977184256, -0.09083664495630243, 0.8620507335405776, 0.5263460689806246, 0.4369137236594067, 0.5826075667851005, 0.5222103723831982, -0.17644480097548118, 0.619093998551289, 0.6753610571303356, 0.561480989657978, 0.48598239583920066, 0.8171722817925801, 0.5691623524329839, 0.5701184206331412, 0.9018177427709112, 0.5842490436655625, 0.699028025290963, 0.5631998218310782, -0.029972722531204712, 0.35991904244504525, 0.5554440647506625, -0.28653091336823727, 0.6130579305229045, 0.6949595669971184, 0.46312884785390973, 0.871446025172115, 0.5737154703035298, 0.4595899360243458, 0.5940149220396926, 0.8139600087790789, 0.12695336854002132},
    {0.06924621291128975, -0.0047967571628689185, 0.8503691112820293, 0.6500014102177016, 0.5712856216130024, 0.5674998263320084, 0.6993307406869232, -0.09781846030616141, 0.417959360077386, 0.756405462754372, 0.4620759761409083, 0.6189578983575063, 0.6805771497594918, 0.6093215442390347, 0.6179315386897232, 0.7200122734472342, 0.6877646027493541, 0.5020100201297923, 0.39830411563430157, -0.2046003126288817, 0.5149569046980831, 0.4893342315197218, -0.11984932114108768, 0.59955035353188, 0.6210014754054786, 0.7318219528839061, 0.5503769569677005, 0.6621540017028458, 0.6179666166945381, 0.4098555435217206, 0.7395682196611639, -0.11104422634291541},
    {-0.06412012693633712, 0.040574818939843306, 0.56319483283411, 0.5161898366686457, 0.8071900726057663, 0.6274985849230551, 0.5533664918425641, 0.16043124266349176, 0.46575067928828456, 0.7752704617604438, 0.5201411759998117, 0.7133376673378647, 0.7010579938316817, 0.6944136118959809, 0.5118685633933086, 0.7276292543118192, 0.7510736839337265, 0.8654316758664128, 0.745380524506913, -0.11087833663820991, 0.6865954634950031, 0.36942188752071564, 0.009175864148923948, 0.5748050452975401, 0.6063288301329512, 0.8075579460206935, 0.4782731608311427, 0.5706112237941938, 0.38395599876560604, 0.7348398344279495, 0.4435933721285224, 0.17248278379010973}
};

static const float b2[32] = {-0.054469405895533486, -0.03624364811287812, 0.6218062833835628, 0.6057630126600301, 0.6467823784790897, 0.5721184326300879, 0.6585866934189749, -0.046711707793274666, 0.5312859044573242, 0.6479061721578848, 0.4153072250770006, 0.603371404448709, 0.6577662508174585, 0.5892043043342303, 0.5186134259485862, 0.6585497032926242, 0.5859106812021513, 0.6589492391534539, 0.551519276254769, -0.06948801873761327, 0.5395696088934406, 0.5849914026499429, -0.013545849331515656, 0.615016748922762, 0.6357185695182357, 0.6022589360334715, 0.6637085211968858, 0.5870504175182851, 0.6107468525067206, 0.6225298257686661, 0.5965520937420687, -0.02203310880068234};

static const float w3[32][16] = {
    {-0.3439862172733671, -0.2814854244194043, 0.16579530991420147, 0.3120918783438645, -0.0361133749206121, -0.06250376019841793, -0.3257891336571613, 0.2274921126923635, 0.32681065668772113, -0.32310446888177247, -0.2090256805894254, 0.26074095970326416, -0.0815802059593927, 0.3091947438124092, 0.30735437764705165, -0.29275272227953775},
    {0.10228043547007235, 0.3998570763492658, -0.270833707892537, -0.17671387889354132, 0.06411459602080795, -0.2512049382385367, 0.0899300102092362, 0.32438991559105423, -0.3095777562713448, 0.3295043496241622, -0.2882061001950463, -0.22591979870606907, -0.06936817222876411, -0.10104406355084637, 0.27192507589499915, 0.10558241833507488},
    {0.8482485612489884, 0.5288606079677668, 0.7952699788145473, -0.008386653128730267, 0.7115564293777065, 1.0292840215368528, 0.5282783725786914, -0.22104582640742593, 0.6187176239278279, 0.33517227409507366, 0.13209776691206848, 0.7541481097078402, 0.22692044529685113, 1.0556430477154923, -0.18744768594741754, 0.914194612518612},
    {0.9730137047827371, 0.8538007160728808, 0.804591324737105, -0.09363715104520683, 0.6331635821413415, 0.5529163543259192, 0.7741955615701119, -0.25226665502964757, 0.5041295135852217, 0.5213976424357009, 0.08978927205611402, 0.9509888994060081, 0.14656062131196027, 0.5417621174498239, 0.169656166821485, 0.881501876582281},
    {0.6643376132328426, 0.6365361841312566, 0.7848436066920308, -0.288850785845264, 0.7871876710677445, 0.700605924241654, 0.7730990031613809, 0.08654474030782615, 0.735587730861022, 0.6514059448023605, -0.02854778937619093, 0.4789180496177611, 0.1324204354395305, 1.0973799748059214, -0.016856150448457802, 0.6181596526999322},
    {0.676130457779937, 0.5385834926269235, 0.7407103172514665, -0.24643460036677078, 0.5054684592708563, 0.8830792246837883, 0.8824317250203598, -0.22704402785823674, 0.45326918000113336, 0.8215577902694597, -0.09780933288077998, 0.690480453025761, 0.2756676563170064, 0.7737686260830198, -0.24510509113676796, 0.7093695857848789},
    {0.6243804646746374, 0.8189481865226457, 0.8705264277778305, 0.29379621281741114, 0.7600594208122536, 0.834016874553715, 0.4444077739331525, -0.37193498898970717, 0.6313981551405453, 0.7033266830774139, -0.06245417778718588, 0.45065227550733544, -0.28682326388332186, 0.7092223781894902, -0.3114084772632018, 0.7296463562634605},
    {0.22390260895038397, -0.07667925458061227, -0.13576434466711654, -0.1642723556649808, 0.10576952577049706, -0.18920800121325784, -0.3429048547842745, -0.32870027848932115, -0.16866989654454032, -0.13967962480751767, 0.3195589335574399, 0.2446813822856256, 0.09500885288672288, -0.10096738025548664, 0.308733782493005, 0.2490764064381672},
    {0.49690801522118055, 0.74587398532513, 0.29654681088049917, 0.0452276077154548, 0.8143762538623015, 0.4939862151257278, 0.83114337755042, 0.05613959445999686, 0.6958084614749221, 0.8397555552799878, 0.21689755875806904, 0.8910966812904162, 0.23927081758456406, 0.48591383558955503, 0.20169590510793553, 0.6318692920443107},
    {0.5862193790745596, 0.6113659107008348, 0.9123456312915665, 0.04748484672951649, 0.9038859214583298, 0.9605021129262142, 1.037530021017257, -0.26548190988415704, 0.656710282235224, 0.3061225319515928, 0.15607071491224575, 0.9416171337679365, 0.07182234620375702, 0.9642689330728809, 0.25371854060164684, 0.6384176847178278},
    {0.5540528806250976, 0.37350416973131206, 0.5160498142893136, -0.1060873113689142, 0.6416492983507309, 0.838992729266414, 0.5226539598710783, -0.26338965065530345, 0.6708019023515286, 0.6274055326046153, -0.17008858084649014, 0.32444929585583354, 0.026296164462151134, 0.33847392638463447, -0.021076333484659714, 0.6099967096812685},
    {0.6206391201979508, 0.9205218715315966, 0.39274197512420433, -0.15748355104876277, 0.7043819538943242, 1.0063624868179137, 0.8633098347050174, 0.14042359161397874, 0.5624887777297595, 0.4709426807014009, -0.04703809704920261, 0.717871750778368, 0.19176582347230567, 0.9973614828710174, -0.38447366045980425, 0.9160504574082178},
    {0.8168642505532308, 0.5606810965692401, 0.796879336145986, 0.17100449731262957, 0.8054816045648377, 1.0785715061073127, 0.8023204362232814, -0.3176449666034866, 0.8844582564202514, 0.6998273660275333, -0.3358630329730691, 0.5436094205962726, -0.17358554397896694, 0.855017622527374, -0.2674891893619459, 0.3876649468382342},
    {0.334023099897411, 1.038330020620485, 0.7284350304355997, -0.27743167188591455, 0.4213915751786864, 0.6338415464516725, 0.7268310206310572, -0.1961373770202348, 0.8063794658361545, 0.5509426382238157, 0.020230991510644485, 0.7174094818050315, -0.34897840635196103, 0.8150113912218796, 0.18618392670951384, 0.4378744003960669},
    {0.9411681151996406, 0.35971556187882897, 0.34715096660224065, -0.07995845825706857, 0.5129865230714014, 0.7192093933842374, 0.4131369508145663, -0.31770642217494954, 0.7964464267462836, 0.46297759542543887, -0.336723312338444, 0.653644251557144, 0.1867198873520056, 1.0194479205471842, 0.05794096134750623, 0.5826618059358456},
    {0.7075221498754354, 0.9206252550463361, 0.5515171426395281, -0.14656967368438983, 0.871019217923237, 1.0426494508630277, 0.34034802112833173, 0.00047079980592639153, 0.45218517368934186, 0.7965860870722808, 0.18816116080708475, 0.5759679395069647, -0.09628980456340906, 0.8159161439253942, -0.15149976230407344, 0.601154793981059},
    {0.37457895152614795, 0.5567199688804424, 0.9222053889384276, -0.20564097529767988, 0.9561907769006835, 0.6698690939973894, 1.0519468933335534, -0.2523566784988976, 0.891634561812238, 0.9209539757125131, 0.19855524708388067, 0.6716534375078856, 0.19651523486139627, 0.5571727299854613, -0.10539488985626894, 0.9244665795606902},
    {0.7850583884808521, 0.935549903434385, 0.40586767910428256, -0.3178827350375303, 0.8897215308497529, 0.4621932948261286, 0.5512361146163739, -0.2920399757546719, 0.7149570777474625, 0.6677095476029999, -0.31037141307568716, 0.6479490686834767, -0.2792587354119647, 0.666011733984919, -0.20725321812815486, 0.8514125309212109},
    {0.9151442701454647, 0.9562398500921987, 0.8350743151813312, -0.13164266664705693, 1.0049252426192667, 0.36610770187079866, 0.3706148978522591, 0.25481712562062203, 0.6009353096573788, 0.8382761613028492, -0.040641428428477365, 0.34838991082721427, 0.2627510259210245, 0.4866236714037184, 0.03587577529240573, 0.5297956920042005},
    {0.19258253530567224, -0.23103677818506355, 0.21952103564726194, 0.2690129763121534, -0.22454422277271832, -0.14736490094903162, -0.26738599948139435, -0.028393306529178538, -0.24821963184685134, -0.23146833328330155, -0.2321332514494139, 0.27149249439034034, -0.19899307501203634, 0.3402600471892325, 0.2696762025424795, -0.17799203061275262},
    {0.7248038437493375, 1.0252680041342224, 0.39053417484081543, 0.29820977954759553, 0.4700658315839264, 0.7396142266934244, 0.8126912129184373, -0.19598797583186034, 0.4122541056356791, 0.5812155064067721, 0.02677764774617325, 0.3670636567728431, -0.27911234849594513, 0.4096407779220728, -0.3117718509976547, 0.9120625972259833},
    {0.9543788049123553, 0.7526494927035114, 0.5783151649098751, 0.10362780603586315, 0.7186591028305862, 0.5773576342678228, 0.9170387852622364, 0.3253735494510472, 0.8577641248039984, 0.6608948905195473, 0.2746382323103892, 0.8018473229663048, -0.15787335662997262, 0.8139745069591914, -0.36601338151604396, 0.5097105483976814},
    {-0.1666946965534741, 0.15039960953909653, -0.2800431108783128, -0.2739964518393037, 0.11882099483077649, 0.1849406813606558, 0.17404292385094874, 0.17974796981649907, -0.30408157019638693, -0.27806209434823237, -0.11321941927985064, -0.06904366743443158, 0.30783787732508455, -0.045866047181742024, -0.21923941672408245, 0.11615748213567086},
    {0.7967981903534606, 0.6226960316807832, 0.38986147802085536, -0.0949430937515464, 0.8066823950808311, 0.7202779561193442, 0.5125511238884812, -0.24641669708932634, 0.9588395969577697, 0.9383049028130827, -0.23453350158139014, 0.9403994840571612, -0.18156965892323043, 0.7038780523497767, 0.2821384158923414, 0.6537553764872036},
    {0.661393682972059, 0.7604092247858416, 0.9481400140962102, -0.022874052177175433, 0.5972129887239573, 0.9489698882870243, 0.43798027653699223, 0.18462930372367203, 0.6573043262578273, 0.7027088118636602, 0.12560614493983077, 0.45354568801656164, -0.23357174880480622, 0.8581735746023167, -0.2771324899973798, 0.5480961675718771},
    {0.9818361301547099, 1.0353177735481562, 0.954558141876665, -0.04595512480279745, 0.9810528865133715, 0.4346609348688302, 0.958152606589101, 0.0991905413661839, 0.6841601688779311, 0.8875315841077888, -0.003518414678796772, 0.7043398742523463, 0.1022142645104206, 0.7031090552196065, -0.3353348309177999, 0.7105903291958382},
    {0.4890756218276846, 0.6438957453841968, 0.932840755778122, -0.19980128055364357, 1.050095280880112, 0.8263770070534464, 0.9410165720242191, 0.09302519722467047, 0.3098958740686272, 0.29494862417768286, -0.33933090845824665, 0.9629547874080753, 0.18432076278678325, 0.6498121787065158, 0.04939015754761429, 0.6160074020422058},
    {0.8193020563744462, 0.6138150002112065, 0.5406185257048002, -0.3395365524316914, 1.0412596645219026, 0.3522752636235823, 0.38729218185693687, -0.05669716144704418, 0.8003613898738481, 0.49519627733735866, -0.2781562598913613, 0.3637686776447987, 0.13167996576925572, 1.041897946706297, -0.19069508481169217, 0.7965977670857811},
    {0.324162150905921, 0.43781342080676056, 0.5312574343444761, -0.31520914240393655, 1.052119514473038, 0.5064421143894158, 0.7570667139250805, -0.09804990467182945, 0.7691156517040887, 0.5457407133638458, -0.1959322960519255, 0.5289663375145671, -0.3156060583987708, 0.9751247980088741, -0.36871821144662514, 0.9526004541768549},
    {0.6815923433268009, 0.6431663643865515, 0.8068605575678379, 0.0022677956630508833, 0.8051238985674497, 0.8488379747886706, 0.498471732189418, 0.27872515628441447, 0.8315884271791677, 0.8197987796437205, -0.2598744368535006, 0.9355113447225906, 0.07007133051317853, 0.9991211005545739, -0.14817674243247933, 0.6590175956466974},
    {0.7279796801522842, 0.48787170204596214, 0.8579978337741928, -0.3624630458808195, 1.0144952267239222, 0.578234225604479, 0.383713873399329, 0.31489524592076035, 0.4936357645229866, 0.4045257997117468, -0.17898628453385687, 0.6521009081004736, -0.35519945170173794, 0.8669523284653303, -0.16654558989307272, 0.988471505516246},
    {-0.1496244797347833, -0.12844115689959423, -0.029798301113861798, -0.3457274542679074, 0.2128242022101168, -0.17178012092239225, -0.12717834297030117, -0.3084281511620451, -0.09471088152609083, -0.25792185469912066, -0.1595118100838811, -0.16766427541956105, -0.2132094860987203, 0.43566587226723336, 0.23910852508838445, -0.054893922871361335}
};

static const float b3[16] = {0.3654146619213665, 0.4662878743601776, 0.48264598064489805, -0.027812978404692417, 0.49811771372450725, 0.4745509447562846, 0.5122671170933543, -0.02245584149387346, 0.3452150671804195, 0.4790620801230517, -0.045284131536008805, 0.5387438168558975, -0.03592104673138104, 0.5074840389873431, -0.0339623750727267, 0.4361741217272954};

static const float w4[16][12] = {
    {-0.406236297869008, -0.05556000424436168, -0.4810701441278911, -0.44370598050295257, -0.40497437336798203, -0.7868771717664915, -0.40120397237937994, -0.20411611873295327, -0.6350994814540242, -0.15278566655699488, -0.8451668310644128, -0.8285105866035715},
    {-1.124294380240743, -0.6166375556614317, -0.5796309747429851, -1.0415656367986637, -0.9631362849404345, -0.5267363139410821, -0.4483414320481975, -0.6525046722761483, -0.717318502148096, -0.8319257723604543, -0.46136173913925255, -0.32325382012893494},
    {-0.6053168529126767, -0.6675100447707689, -0.6161865019599361, -0.6544688057407915, -0.2903692098810375, -0.9294888068498958, -0.9858589389228699, -0.6947704672175795, -0.6465047012070572, -0.713769673316594, -0.44894809096139354, -0.18762898713189274},
    {-0.3116746089534568, 0.3136708747519723, 0.3722873478469279, -0.07691845161509596, 0.43885887676497426, -0.17972635843545928, 0.26446249672296956, -0.23266183246447167, -0.28557101513412797, 0.030623210144821163, 0.3774650310017414, 0.06268805023793289},
    {-0.9770649064243915, -0.9495539654982257, -0.4444680345374084, -0.22335869992829135, -0.7320440178197326, -0.5626261366827032, -0.5509517356652046, -0.980210452206777, -0.43745803443257486, -0.5719067217258492, -0.4948613669405862, -0.5582789504273397},
    {-0.3749934558882178, -0.6179509309896836, -1.0377847696536955, -0.8137279325521914, -0.37496887110577753, -0.5277493663205554, -0.32285173628027974, -0.2153785804228681, -0.7717817639200113, -0.4259732227604121, -0.714956147852066, -0.616856053967326},
    {-0.4585126903357287, -0.2545069413116363, -0.2284693951258489, -0.7425818108762526, -0.9018586070437767, -0.3714099422626177, -0.9334282510286286, -0.9250315102848543, -0.3657608061771466, -0.8988302907726713, -0.7177179129871475, -0.5261516588355355},
    {0.44190396428238804, 0.16146079613474804, -0.01093295171666682, -0.12306612411463924, 0.2002201651220782, 0.17434097434616125, -0.18463105697140433, -0.4471500171024772, 0.08563481511809293, 0.42500303026309383, 0.024783239463709566, 0.1257820897956529},
    {-0.9053079045029931, -0.38458399577631963, -0.2702953768619555, -0.23253211442065094, -0.4468758547752056, -0.1540174523340369, -0.0686358586637207, -0.6021905027400869, -1.0507730768937849, -0.6526850326389808, -0.11275035313161245, -0.8361084441422563},
    {-0.27272842022714144, -0.8957272462375147, -0.49514457767696574, -0.6437766446035645, -0.28381709347518724, -0.08115315774729108, -0.7788270436144409, -0.20444722139038277, -0.5974586745621198, -0.2920029273349149, -0.6984845224775391, -0.7193578776621097},
    {-0.4976795717885747, 0.24572301842647346, 0.22875016204464163, -0.38487718610722743, -0.4625039206386056, 0.13493892349462214, -0.03726722164171442, -0.2971496547516242, 0.3534021465103321, -0.02109332547495602, 0.08333858796954577, 0.1838077386509576},
    {-0.3695920510803342, -0.8836875673326158, -1.0216622780929898, -0.2297252412974496, -0.805698361281099, -0.5894120741006035, -0.7336252242604148, -0.8538549744850044, -0.3208605659089902, -0.8296966359626124, -0.41447434474692607, -0.6344037764092795},
    {0.2397107953745745, -0.18932317814960356, -0.34307614809726367, 0.3745423419290636, -0.011524308076388672, -0.0863373880701156, 0.08280702204175008, 0.031009913417717853, -0.09510556717586309, 0.387002208761965, -0.16416449424677257, -0.001347347996149139},
    {-0.5289627067801635, -0.513316566814706, -0.3283208264835159, -0.8735231037141734, -0.9389939724155174, -0.8397021973889981, -0.4971914496619499, -0.7011666092578209, -0.5071510189612549, -0.5799509139241221, -0.6407058677047424, -0.4793835915114112},
    {-0.3462176330248347, -0.39283283362358706, 0.15477457581562895, 0.15203436107959428, 0.3693679183593695, 0.1620101721708601, 0.38944192164543057, -0.4632874239871349, -0.32051045805342937, -0.07486115892700648, 0.29003140518714177, 0.13047104709665425},
    {-0.2855894264891402, -0.5252787385674944, -0.9402133585927125, -0.4715990804727486, -0.21528513618025083, -0.8727173135838174, -0.7630677148693558, -0.3184306114493344, -0.36215688170421606, -0.45142531092144633, -0.8733579536581352, -0.7381151306433373}
};

static const float b4[12] = {-0.30753937527758096, -0.15341537398895025, -0.15949265119176426, -0.17179301595028598, -0.25498498393469166, -0.2272639872016408, -0.21724475051887712, -0.2592343717618031, -0.24119119265049574, -0.1608286978874669, -0.16677959753216445, -0.21576347624720513};

    // Input Layer 
    float z1[64];
    for (int i = 0; i < 64; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[32];
    for (int i = 0; i < 32; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 64; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Hidden Layers 
    float z3[16];
    for (int i = 0; i < 16; i++)
    {
        z3[i] = b3[i];
        for (int j = 0; j < 32; j++)
        {
            z3[i] += z2[j] * w3[j][i];
        }
        z3[i] = relu(z3[i]);
    }

    // Output Layer
    float z4[12];
    for (int k = 0; k < 12; k++)
    {
        z4[k] = b4[k];
        for (int j = 0; j < 16; j++)
        {
            z4[k] += z3[j] * w4[j][k];
        }
    }
    softmax(z4, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
