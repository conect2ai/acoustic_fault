#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][64] = {
    {-0.7350644312425383, -0.7553708503583958, -0.29396726420671887, 0.24394535508625642, -0.10086134799614037, 0.15181734694619173, -0.21197161116410693, -0.5374380571834831, -0.4849573137550168, -0.7819011657667274, -0.054978744593528334, -0.7951338395564423, -0.14218126816441803, 0.2835757106649183, -0.6859180314422509, -0.4073357269033238, -0.5911596960359708, -0.5470415637955154, -0.31315760930681924, -0.4297012779901602, -0.4884081125436944, -0.6136800690417877, -0.28809082295478283, -0.4250576640575097, 0.4575104465030378, -0.5239464893027133, 0.17261206689104294, -0.5642667700715482, -0.5380370071305592, -0.33894043902974563, 0.31083810481959445, -0.8668860848333557, -0.5421324144709296, -0.6805747423700971, -0.38118754183257253, 0.23880703485139812, -0.7724354049894657, 0.06385307517054267, -0.5421275107875532, -0.6759656538701109, -0.6228169789352194, -0.3961912074091051, -0.6728149474939243, 0.1783371134049634, -0.07871198108317597, 0.2071198288416026, -0.46947091382861056, -0.7422983544541475, 0.0010364111170497355, -0.42693391198942304, -0.6834686974326329, -0.7107670751008413, -0.10769179033060264, 0.23130645469855626, 0.01650318149718022, -0.6867706200502012, 0.03335905406700602, 0.06006288222791664, -0.7397705063217558, -0.7299237299315908, -0.3543611725903008, -0.7600072182563852, -0.10996832489167506, -0.8106231550507204},
    {0.20545096346735375, 0.11544663137687725, 0.08835978641668019, -0.5469542291578663, -0.41954357544939735, -0.3916102052029987, -0.516172627741342, 0.7071021157798539, 0.03792987039563946, 0.7353625610372261, -0.12229963389955158, -0.12580648572460976, 0.053423891927051076, -0.5712958148313835, 0.15739320011842356, 0.01362191475786464, 0.09003711399055339, 0.18311405148799947, 0.11805078640878439, 0.6165894896568695, 0.5674724008881329, 0.03382158726892301, -0.28453801177423566, 0.2459087979172402, -0.5518987570721027, -0.2691620526672459, -0.4867046999710928, 0.37313195165358215, 0.35646724830657395, 0.5469703494794463, -0.554835253897637, 0.09182538137450491, 0.17698758638705303, 0.04466640590921112, 0.12767203813698663, -0.03700874387643141, -0.0021699754397552823, -0.6541370427230743, 0.4396662834581444, 0.499845005829743, 0.3831556933859568, -0.3661475176378341, -0.052389279804533034, -0.17754144365964217, -0.024084770984267506, 0.049543585520818875, 0.12317122853248574, 0.5239429774743142, -0.34202041349887913, 0.10967206210546873, 0.10145110189948632, -0.01038668399936886, -0.2887493217487554, 0.16636405404107465, 0.24161258724917387, 0.5939416728167058, -0.2309360006538796, -0.10690013549035171, -0.29824795608474886, 0.11329337056032517, 0.5260641315413662, 0.7073934281006461, 0.1801512466429653, 0.5162092223303779},
    {0.20306794741062778, -0.5160345556887153, 0.2858340522585933, -0.4533000997079842, 0.5011301850277551, 0.32794537708989563, 0.22960795443115806, -0.46255737366389504, 0.33262642668554926, 0.05126206805299701, -0.03958775659833395, 0.4655438665180348, -0.34034018443072384, -0.46002253888342415, 0.3373603662685305, -0.46692935854929507, 0.41529506890911866, -0.4092478113965243, 0.13697648749053, 0.04141798827248823, -0.2215156438161515, 0.16988736681943503, 0.1804626022258341, -0.4546678498320959, 0.13551710322535865, 0.7126715485799249, -0.5689463543116045, -0.14823653751985916, 0.0857300284193319, 0.331803597775767, -0.6538282143555547, 0.13132183808069434, 0.42533025659422113, 0.741784767928326, -0.353488880437639, -0.4488251086021707, 0.10921814353905107, -0.4119634405623607, 0.16295318639397155, -0.3972047561189211, 0.1169351062529505, -0.025495992233360746, -0.042668648211783615, -0.5813864701970306, 0.12937989989598442, 0.30067641284411806, -0.22255411830577648, 0.4265482165259154, -0.5264023476431003, -0.1653720880139583, 0.2834320122845573, 0.33020633274154054, -0.45351457106298576, -0.2486322989779178, -0.3944386802993081, -0.41438933462809535, -0.25823040761827154, -0.495117221817929, 0.5567935378066978, 0.5667471850256818, -0.019891956767469587, 0.2867568370049725, -0.08769589762718374, 0.3869650217893462},
    {0.023126057204927778, 0.3979675762682288, 0.021197995056546494, 0.3544821365860705, 0.545932063150542, 0.4229442078831612, 0.08029687498792491, -0.561810838841434, 0.4630628319949907, -0.6123981631254503, -0.20694197221486746, 0.4483204261190395, 0.01631177231048357, 0.13609049644015495, 0.33376311236924266, -0.5932999270288706, 0.3394860550087273, 0.09625640659489591, 0.4542968999175146, -0.4822069680469087, -0.5444517441177978, -0.06338319674023045, 0.46787375860161834, -0.7610442187685732, 0.14576503468155713, 0.6322537103729754, 0.1368900210361491, -0.5602699685156696, 0.4307040918848149, 0.0013499709506039077, -0.17359676551861047, -0.35869883865010926, 0.26968515675190524, 0.7320213608088616, -0.643017112182107, -0.4073522226215892, 0.3040385229847661, 0.18489661891593756, -0.0228875246313504, -0.2999236725706188, 0.39765365831739513, -0.0017715359666389454, 0.5260492430651874, -0.07240684261054751, -0.44656421210743, -0.0157305387398839, -0.5105165144357336, 0.1129376294596206, 0.07158246534636348, 0.656182363988648, 0.3367851104948464, 0.4408147705298418, 0.18394177224017175, -0.5927176954380093, -0.7470489976346025, -0.55573197185207, 0.3488927715204252, 0.02341681114289455, 0.5575455040070305, 0.07698482325547822, -0.024635719991365428, -0.21000949015189793, 0.115661872234254, -0.0717852241621175},
    {0.6192400068179414, -0.1452207214369942, 0.35552893563159405, -0.29265239486617545, -0.07076758790090872, 0.26434698666050166, 0.27119713646143967, -0.16759317169883906, 0.28480874835155034, 0.19232413537708176, 0.05317014937661359, 0.7041656105618577, -0.16548343109489502, -0.6706791669621663, 0.08112746034846192, 0.48061684197865845, 0.5688629891430795, 0.40570455454158577, 0.059546808692126266, 0.27656669506059983, -0.04882750728331417, 0.5800534551798454, -0.08730319162472303, -0.22688033327789492, -0.32283787310334183, 0.6668939705877207, -0.5081489259534664, 0.2135363325106717, 0.2415454758544725, -0.1311174561566697, -0.41234521162280874, 0.676172510644327, 0.42332278690141967, 0.472249325872485, 0.2974823119407953, -0.5986649553814644, 0.3825969801385928, -0.2938750964568809, 0.6092991919546852, -0.3465060636735344, 0.7004390548634978, 0.4336075140556203, -0.32886220099071073, -0.2591435871901052, -0.26456909791333555, -0.19249642350230922, 0.5993144364791242, 0.647238307105066, -0.6474159669811371, 0.2394571149794556, 0.6174598372020544, 0.30077405695640197, 0.1304937952713324, -0.11226881209944177, -0.3429887251895503, -0.5675076592545406, 0.16894247789717098, -0.5355962345589209, 0.2744847854938881, 0.34770959570702353, -0.408846223980536, -0.25714897611400367, -0.23746846439932012, -0.02691981392441072},
    {0.6440123468462501, -0.24626432272122256, 0.5393140639236828, -0.07258172023526004, 0.4305109858246068, -0.08674142663215711, 0.8957074951149612, -0.04544069322702262, -0.17016319962679813, 0.5417044246915934, 0.3991389034197219, 0.8574276284256271, -0.30738574840700256, -0.39415689077188126, 0.714182534620141, 0.6593554088405166, 0.7856058606915745, 0.06270635250957161, 0.09432552478660015, 0.5210234165453573, 0.015486173890469685, 0.8010397677511057, 0.4171953401779919, -0.08744389908966667, 0.10385947068896513, 0.6154777332717565, -0.2970633052605378, 0.21827157849427573, 0.5030345528170844, 0.2713561619094174, -0.2545890608696938, 0.6254329407427124, 0.26678702685786687, 0.43877420354380986, 0.5348946167879303, -0.5950366714097518, 0.3997714801140445, -0.2517415454901477, 0.49495321885117544, 0.026530341838212686, 0.5873134036690861, 0.8396160219739832, 0.20513041906991653, -0.4490036989930292, 0.3225109194236461, 0.30156245437250995, 0.6189620381963066, 0.4320981299610126, -0.34926509004186407, -0.006204194855190452, 0.6297919749387324, 0.5754132888886746, -0.23674813141224255, -0.20180982478285212, 0.0998687653162716, -0.5368207747011684, 0.5260166289599663, -0.2504719420622047, 0.4278543646836169, 0.7754397285427529, -0.49279566344461834, 0.3308845749333638, -0.4897306780914588, 0.4032437554446561},
    {0.37138737594546456, -0.3599031076196128, 0.27577555386030017, 0.06272964335121979, 0.6789011642124934, 0.5533995160532926, 0.8162761473680611, -0.20777883024280783, -0.09304727009089546, 0.35621553494745006, 0.18558588917034868, 0.7101810774623504, -0.11295388233471755, -0.1842766466505988, 0.575555795045122, 0.5971420973495637, 0.8768992460382229, 0.3364812720911443, 0.4735362870466648, 0.1836566918949297, -0.07938500340780395, 0.7598238130052832, 0.3043733733380532, -0.2398556061754676, 0.09699471479733036, 0.840858422825683, -0.401637801446051, 0.3284586163751074, 0.5380114534733802, 0.35606312806431006, -0.35087683260752445, 0.7733842403834424, -0.03939204262189643, 0.42437606668069094, 0.2196152664559825, -0.30189069350204323, 0.35096652014891294, -0.3444559544341798, 0.5284079355362024, 0.2107117856291349, 0.7960119938262398, 0.820510673002833, 0.5093253543235078, -0.08733602927899399, 0.30735081684359467, 0.4323240804041083, 0.6990527242919184, 0.7526965853199062, -0.45561999118675867, 0.14241409422438497, 0.552241286920985, 0.7854694811599082, 0.1787535949997045, -0.4281487438259924, 0.07559823705353982, -0.3213958934257412, 0.7099369834697067, -0.2863663208412931, 0.4127977460575386, 0.6289111331189181, -0.3644170916410586, 0.25292261168496827, -0.35144298773046717, 0.5164384139968379},
    {0.5289531835622912, -0.05413312682559203, 0.33152001394159775, -0.38187715898561, 0.19181028240073855, -0.05026704059967097, 0.03423689395277949, 0.15340885709724236, 0.04568910466282222, 0.43104334236846636, -0.13064125127291623, 0.4556648655153873, -0.3013297899570666, -0.5622586626753363, 0.1721934949624997, 0.14401133722742912, 0.5038078563054627, 0.46689000204652176, -0.08564356288734191, 0.36664539707853633, -0.15927522654393184, 0.18276360212856382, 0.2413453383174416, 0.3870110578425505, -0.5933049147980278, 0.2695210084778656, -0.5433396692640414, -0.04816042511589796, 0.009658577937549205, 0.48061745476264595, -0.47070393032971986, 0.4502493695427285, -0.17073100036532432, 0.28462771982105534, 0.12508458649612, -0.5055689787601032, -0.05349616836503539, -0.13977166653916506, 0.5775777385276546, 0.03668643290767369, 0.039399002584014985, 0.5259790309400288, -0.17030858853117578, -0.37669277559764286, 0.24431116989141044, 0.16417275722531044, 0.5281170013100759, 0.6486043326883496, -0.746082076902887, -0.20040384332412306, 0.1370072134988944, 0.5622339614676771, -0.3623405438542497, -0.14074966998019525, -0.40144683486998023, 0.2450709428432885, 0.2304969328339373, -0.4227768150597552, -0.0667363495693216, 0.48386722184121317, 0.0679068280913138, 0.21910204075006656, -0.2074005737140573, -0.01810154796987521},
    {0.5627823570948431, -0.3716055329355908, 0.08736724427623761, -0.5933991709793374, 0.2550356790017487, -0.4834246839766224, -0.1869996077180997, 0.20212570669540317, -0.051269522351672814, 0.11701608815759412, -0.10602229411026469, 0.16856072812135922, -0.19056189755934613, -0.5238817147200938, -0.0014308878322078424, -0.07639475506912063, 0.50900121756467, 0.07663297098155313, -0.33240768627162354, 0.49215875487436767, 0.5346587901212392, -0.15005597525272418, -0.03272390405248808, 0.3327251330626525, -0.4717006323352905, 0.163906844671981, -0.5894247610310235, 0.14753198460128195, 0.10994007730131634, 0.1295698475406042, -0.7355873042237139, 0.26404867673444404, 0.007644352441484179, -0.18334130455789013, -0.08317875726580454, -0.24094108705648604, -0.09380481391346077, -0.2566756113037542, 0.21905782370579724, -0.12284660282172923, 0.3315252502424762, -0.1285027341342446, -0.07327691927990239, -0.1234089008350518, -0.19205754917856474, -0.2855606853930363, 0.35617764355134085, 0.35153985768182744, -0.6531158578289138, 0.2031679100412989, -0.013079602704678471, 0.29819324448144763, -0.16913880589006786, -0.3608310424608784, 0.06696375685027094, -0.253889733325529, -0.1868053924681135, -0.22826003558094202, 0.02450428407549751, 0.5565620523204302, -0.04591347674649753, 0.5231622832434475, -0.47400118710340283, 0.2987521371433257},
    {0.39766043668085255, 0.5082146624960945, -0.16399741336544965, -0.37371102112250093, -0.6592956931416752, -0.6458245090388903, -0.16748099415480094, 0.523823976622596, -0.3458452124500311, 0.6007853156915823, -0.39725884966286035, -0.12156449744133917, 0.42551870011493587, -0.23496602590660257, -0.007172838045262284, 0.289302038398622, -0.18661730359374065, 0.1464576362175855, -0.3937365287956587, 0.5144876781795636, 0.6834792866504966, -0.20694378229071228, -0.568694087788025, 0.37053747787451224, -0.4308307042831566, -0.6880497701492793, -0.40019009015763257, 0.17964100084761125, 0.4419516187797215, 0.08910664083639466, -0.554865164789017, -0.06875362253985197, -0.210682513701742, -0.39308928298513035, 0.3800748933464754, 0.20601229611030572, -0.27412813683734233, -0.0771173022047821, -0.12990199351176648, 0.06453355842089195, 0.18294629652402747, -0.2251388553039392, -0.08063908182003218, -0.07545322703283584, -0.08987585242659941, -0.3624406505050791, 0.1664219672425058, 0.12366368973890994, -0.2828867748410055, 0.21096974172560953, 0.4319141705257602, 0.0199023193529435, 0.1499151845513314, 0.07918706183318847, 0.3801534291388868, -0.059420561827492016, -0.09273987509437734, 0.009251675148580274, -0.4139984676255023, 0.034102240765449356, 0.5005866107215278, 0.4009254951626149, 0.24292736552081692, 0.08003307672453244},
    {0.5014899015742347, 0.5404857091874278, 0.25210607023742415, 0.028717145959389026, -0.3017346819588202, -0.30449258924389566, -0.021423660789690636, -0.10001790648590388, 0.19970713355315028, 0.6172513961642992, 0.08858779529661161, 0.5075233239194072, 0.26823866483321623, 0.0818164793629364, 0.390673392922439, -0.047442379279983654, -0.10249241745745133, -0.2515234581922966, -0.15604081399164035, 0.36431692040306596, 0.22899248188039506, 0.24628590726221558, -0.2235900137304542, 0.06607001215365879, -0.49946947634600825, -0.061404853854431944, -0.1305437900287547, 0.1215274950168589, 0.6279192077234373, 0.1674573050410136, -0.26554452806535145, 0.4977170188610121, -0.21045694239853105, 0.1742317408009074, 0.444441466853289, 0.009262274065876826, -0.010897508485313756, 0.05870494100216585, 0.3611065193229576, 0.21645164346979742, 0.028077935821458372, 0.32374427072120937, 0.037297949559381975, -0.44700568238868904, 0.011364553509042391, -0.45044849831846795, 0.060662267879027905, 0.13172805623949732, -0.21940650987171492, 0.5463920235526744, 0.5579754551784916, -0.02064177246510309, -0.1473962334311783, -0.34656146701021234, -0.11039082441373782, 0.18479641039300085, 0.5014462686193517, 0.39229611033109274, 0.30736492545095684, 0.28632538797853707, 0.6407867967498292, -0.12498778890903355, 0.2860300612953723, 0.4870728046178426},
    {-0.3204741089250272, 0.07288927553087428, -0.10362404715877319, 0.19804056746646861, 0.39817372527926, -0.14089440863054364, -0.4002712938587497, 0.20432039421951295, 0.3792612944166754, -0.009798040063683408, -0.19178156696179816, -0.13093133658620598, 0.2528506397822849, 0.1540636768758273, -0.3037932113641049, -0.6606768600543901, -0.5213635526451683, -0.30113187080227305, 0.3174145566732522, 0.12445413340116712, 0.22640530809613257, -0.6764950826568096, -0.12356784942783265, -0.5052200827152435, 0.20840546160329362, -0.08267155533948949, 0.349843730590597, -0.4457232303877495, 0.1897256650524382, 0.14635246257728168, -0.10035017166717063, -0.6123627511074768, -0.29861719903286754, 0.28861866754104454, -0.2790150751367515, 0.15014851134534835, -0.1681270744676732, -0.30739801851090565, 0.05093975008904488, 0.17929334430045668, -0.14001134937426632, -0.6141541264710588, 0.43117794677688026, -0.2302782941524887, -0.18267862882352076, -0.21298349939908573, -0.7174727833117344, -0.28661899937910756, 0.4711456349601414, 0.1891780930144276, -0.44283871877989456, -0.01844095199490758, -0.35758562110255776, -0.15831251577650735, 0.1450307612466073, 0.010125571299621262, 0.06651231795474623, 0.4478279869894063, 0.005204110921585594, -0.022784488384085765, 0.42246000169230113, 0.04598672684091499, 0.15788327604656635, -0.31548217150573155},
    {-0.06541046010026207, -0.07371598307144601, 0.5074231705891885, -0.3787222038701671, -0.3614569674366871, -0.5448458481305777, 0.0952380219337178, 0.6754484844356446, 0.013466614254777543, 0.3766037322384156, 0.1595117776586879, -0.2870242897168033, 0.312878577482602, 0.16230360478100506, -0.004021899426667465, 0.4582039373143347, -0.006902706299162871, -0.29074437115143814, -0.4135710214575107, 0.5866575871012331, 0.5823965402179982, -0.16721149103715297, 0.014361899689750903, 0.7051056155503165, -0.3497210776958914, -0.0792170845012886, -0.31421737406365213, 0.7201353511187643, 0.08373815010784183, 0.5318778379488301, -0.43583994063281506, 0.6144471606469667, 0.16325439412215995, -0.26509219574210297, 0.5794061847780031, -0.2005350574809259, 0.15160052997116338, -0.6594805515538537, 0.1837118389488151, 0.6410208210916466, 0.06369486213181744, 0.07400028243878774, 0.12893573069578543, -0.4241407671463109, 0.6659287451718503, 0.18796715330446392, 0.6124961157255165, 0.41775925199484826, -0.2785616957781092, -0.5618202913109495, 0.03656928190537213, 0.051361971750864474, -0.4146349597486565, 0.43734195454201064, 0.7169830810145633, 0.5271338714958492, -0.019202607623560162, -0.4181694760673573, -0.3901354935909655, 0.4371592694425981, 0.059962888547404745, 0.6712368778047587, 0.1669230870294221, 0.6605451186182689},
    {-0.05734652536704773, 0.5097478185031357, -0.10026625984149105, 0.6195523935233409, 0.48437089329845523, 0.6035928026595034, 0.21269220454836, -0.2745658296549562, 0.4091049760355601, -0.328713605023791, 0.42937690060225603, 0.4894215908532115, 0.05776878807208372, 0.3298059110996303, 0.6462648511511516, -0.2769520362430995, 0.5430740598367337, 0.28752844033496766, 0.5810471122944284, 0.11245012572255299, -0.09407035196355361, 0.24803250512726632, 0.6134175443784663, -0.664027144187363, -0.16025613406654615, 0.47202315078841917, 0.452304350144905, -0.3085312138150186, 0.7175232399653305, -0.1730776124189491, -0.014197433533233748, -0.23677254601605022, -0.03552833229529766, 0.06529450200408604, -0.32981855994971015, 0.3425911657824741, 0.488219199513303, 0.19726819839061038, 0.28710017816126354, 0.37503987314892795, 0.19852897937751104, -0.21857108454406093, 0.7504655765739572, 0.05238166407456976, -0.3139854856028766, -0.38762308751961805, -0.44356601836232445, 0.07870099425248944, 0.7222730751711821, 0.5560384320527715, 0.24610338773723128, 0.43014133417612826, 0.4438930824859129, -0.5391177231241799, -0.47250569198101605, -0.19921750517659084, 0.5472160849554387, 0.7110707621586408, 0.48910302682843376, 0.13567793671924108, 0.4322654034121116, -0.0337174970910046, 0.20451699556448466, 0.26506092772078743},
    {-0.4081326146132074, -0.11787797880361513, -0.011788531625795937, 0.7798859721788209, 0.7646262654531406, 0.6927761535403101, 0.46159375586263585, -0.5874559032320901, 0.5596434143537011, -0.6863703283627651, 0.6973276752901356, 0.6001851188160413, 0.12070710566717383, 0.68742629122882, 0.7380570741723977, -0.42973171782144476, 0.5229870285762294, 0.005954095945360504, 0.5507498222041104, -0.5398133986774272, -0.6364451700705203, -0.2302562789983116, 0.8261658733557414, -0.6251314996531656, 0.09913823174050888, 0.8505322868641573, 0.5363288758264905, -0.09298904686287827, 0.3556854696587906, -0.23815178846678392, 0.05803160475191015, -0.06883737789827317, -0.32867498139849344, 0.10969465057136014, -0.4965624349838981, 0.2805002787587624, 0.6200312571730521, 0.2948393638167813, 0.18928767275425373, 0.4334051504160817, 0.1625068597210298, -0.12165166436513616, 0.7091509562903444, 0.18084951772820113, -0.05994925452913243, -0.36554366731676485, -0.261890614733456, -0.0684152485156936, 0.6506302418287081, 0.10415234151427581, -0.12110021521615039, 0.6670514459401913, 0.49962974716154734, -0.3189688820006268, -0.11721712556114736, -0.12136288614034213, 0.40577408060957193, 0.4390195592165513, 0.23217247433049676, 0.10961391676929073, 0.145990572811208, -0.10610830920458279, -0.5183869242094736, -0.20931075326087153},
    {-0.0657520817893862, -0.2863394445998507, 0.22643243728295898, 0.2908737863616978, 0.30755401371442415, -0.0713248553085398, 0.10916334817137784, 0.13265023075980553, 0.14219728113000957, -0.16533383093798265, 0.6994841878125136, 0.04902520137516634, 0.32034741082597334, 0.6542926968711146, 0.4916444953900415, 0.2138110889880979, 0.694444505422674, 0.10647402862866955, 0.31919221185624985, 0.13050837101593726, 0.4665162383572919, -0.228972858479973, 0.3184308241290025, 0.3997083342259958, 0.029238252103620146, 0.4120332748588399, -0.11247313966533887, 0.697446784606416, -0.023591045983055947, 0.07627256302716492, 0.272759949968319, 0.40934582800766806, 0.15788683686743304, -0.6011823352920024, 0.12791715823085287, 0.28142879870679877, 0.1962692590194106, -0.42636829500696277, -0.012346823919637404, 0.7173601236651141, 0.498761351343621, -0.18660332446443667, 0.6954603611009559, 0.09707715364055004, 0.2935589712577995, -0.3091414371850779, 0.38519546871196514, -0.11162778741482422, 0.5679302737885993, -0.028533626867663513, -0.03116261860198244, -0.20132837569271755, -0.0706612658767706, -0.09775892773302829, 0.3873493494417893, 0.44383513909902333, -0.008474243049718938, 0.107304080596549, 0.058951826995376946, 0.5932473626666079, 0.278216679782866, 0.5949157958729558, -0.25509726826062784, 0.45425935361694636},
    {0.2754401727573886, 0.5444301426449278, 0.37738874087633684, 0.7336322171940813, 0.8188322574113076, 0.3639948387350854, 0.4203729090629184, -0.5674171444209812, 0.30026115467628983, 0.11355588959593846, 0.24628418763236157, 0.5256826645913228, 0.47996062721036903, 0.5345415974732006, 0.7969762816073744, -0.03672427353053011, 0.7800386285173792, 0.7054028769509234, 0.5682248997255938, 0.03153960173526336, -0.566670270141089, 0.15394888145099497, 0.6459683651887964, -0.5085191371199197, -0.2772745613289952, 0.7009319889478866, 0.1517472885271481, -0.40517750947146003, 0.5807769718513796, 0.3430815862931957, -0.23459329499393664, -0.08892500161564629, -0.24024017991440352, 0.1287375390268548, -0.3435996798774936, 0.025262127271480507, 0.6214248749856933, 0.3360381557035574, 0.40181978420955294, 0.10767091379506695, 0.5742506835075836, 0.4590211462498609, 0.8121686958794148, 0.404621126803827, -0.19407410994439625, 0.029095084429022113, 0.18287974260938514, -0.03315950511986546, 0.720229131447069, 0.393699568777705, 0.362338212468802, 0.7775229396205607, 0.30340815113121683, -0.4738041669880318, -0.38082468267560315, -0.002810191262106043, 0.6370925382822694, 0.7167549611006017, 0.5205490114054542, 0.3536991548337787, 0.5342622427089218, 0.3818277017349164, 0.1264675358692189, 0.25144267448235447},
    {0.252984596957612, 0.0994291920735778, -0.0697200552251202, 0.43870392047913886, 0.708162516494364, 0.49645786042550727, 0.4974169765710594, -0.2796678561316072, 0.5630821899838919, 0.05404162266821093, 0.3308409363146093, 0.6309541279665557, 0.474275947723499, 0.4075579247111498, 0.30055179395946485, 0.2002838508059204, 0.7322011307250812, 0.35028788290037877, 0.18827262933684738, 0.22995032640879853, -0.0478154046852054, 0.10324842743748583, 0.5298813919515608, -0.5959615945339687, 0.061910648386209355, 0.6168853283972003, 0.09132890222574436, 0.2878667893779944, 0.337331113045073, 0.29444975161448594, -0.23399824998533594, 0.3870799180981861, -0.3476944423450493, 0.19487551014533272, -0.14116048444033225, 0.3554569449293697, 0.18914491673741252, 0.3952737109726239, 0.11939383334447913, 0.5355911690595415, 0.6030016029291407, 0.26774914239266784, 0.7404648416413819, 0.3524975071494118, -0.37565380682217836, 0.0103180126096758, 0.05516438227430574, -0.16147777334236516, 0.668064554829356, 0.3796033988126569, 0.058401692163877035, 0.33130383097695726, 0.006332106546544252, -0.5230168529235754, 0.014395957249822238, -0.06476316061549993, 0.5842096090920964, 0.6168811567649851, 0.49340269331711395, 0.6773554599711852, 0.11175769960551901, -0.04760429864328971, -0.36448430677729876, 0.2574465207517926},
    {-0.5122611816049859, -0.24106361842414759, 0.11564086897563303, 0.502087146664018, 0.7155763953555101, 0.4663949505817515, -0.059664907945898626, 0.0653751294702969, 0.6809153502464529, 0.01729336575960127, 0.3425373524827746, 0.18467671927908172, 0.021880405252506663, 0.6236696999184734, 0.43440217933568165, -0.19882316344928042, 0.12114618392730299, 0.14866092942963915, 0.16865324714205332, -0.21457631814674055, -0.17953986189072538, -0.21136410038448844, 0.5706805583965118, -0.4046199714392236, 0.2963325402323894, 0.4680376485164016, -0.10460736227484037, -0.1648273472056972, -0.24844178154837998, 0.39140072794725395, 0.2078416558330877, -0.036912657140916044, -0.4123823608690899, 0.20492674553130405, -0.4192914836484832, 0.09501495738665973, 0.16915723730687, -0.020061892526941967, 0.0623299670524687, 0.012706475091074473, 0.363499455642887, 0.30286909087656944, 0.7556166403831358, 0.2698668584312934, 0.40903597288459104, 0.16846924517950426, -0.11112267295706289, 0.34379392363162553, 0.6585905903631832, 0.20287015902778535, -0.45920817054815405, 0.5350115928887842, 0.060190236105294816, -0.2694110535138576, 0.013810988297694742, 0.13184020280391695, 0.468929244224098, 0.1511132236476004, 0.6315230194228718, 0.4033070889228674, -0.28630015689764243, 0.352799301959626, -0.2716148042652472, 0.3324249482417941},
    {-0.10452490664428551, 0.45555808317169216, -0.268048381249755, 0.5449837820499023, 0.11791686465779533, 0.43076012890050064, -0.44428596170874396, -0.46357457079091374, 0.16657834031143862, 0.15027178536761968, -0.13973543298914787, -0.16946228981187958, 0.4251208534110161, 0.2977815901105869, 0.6052161502058662, -0.499851600060796, -0.16593577334917328, 0.1653681555324327, 0.3055744597991986, -0.18946758755117127, -0.6218781956954956, -0.1254962716231327, 0.2586215080659355, -0.08201583324129812, -0.08891483719963977, 0.11419968464708856, 0.5934981744291473, -0.46600503378962715, 0.351796512436687, -0.0867345848746621, 0.16799234891750825, -0.42004829291897317, -0.19080567623210226, 0.3436744228104019, -0.0751098082069172, 0.037417366188633644, 0.31734682428944033, 0.25460464719581577, 0.08434519294781698, 0.060079493686369945, -0.3456490839267514, -0.3413906476194405, 0.5239873516395122, 0.2025442113076837, 0.17668616009016777, 0.27341873912331266, -0.11799082854565737, 0.18426424509831485, 0.5880733737069883, 0.1932953948981272, 0.4207304987508982, 0.48077777577921976, 0.45349218571586525, -0.06418620649069384, -0.014752955240389073, 0.3652303287264223, 0.3554183933133517, 0.39839728278399034, 0.3936385510200786, -0.1307187719470047, 0.5247296153196763, 0.2783047776219777, 0.47463169595017185, -0.1319605102185797},
    {-0.3334537262015339, 0.21082344487656826, -0.161477949925832, 0.4890641339267732, 0.42111626628844956, 0.6626558941011442, 0.03193945059830563, -0.49725318546373265, 0.594752007843808, -0.48233946663591604, 0.6045581001868295, 0.06425189808889274, 0.16962110711357328, 0.6387679707604506, 0.5860340595057391, -0.15313023451744512, -0.10691623965994038, 0.25984473673259895, 0.5362883477702571, -0.4402707024600079, -0.6354976584414775, -0.3817871432864687, 0.6710953473159865, -0.19480923541411777, 0.05481826079606917, 0.7056060320651693, 0.6844865176303181, -0.6329791649556035, -0.028948483329667186, -0.2621222028624526, 0.6748355858004916, -0.32734368395407315, 0.020359622747527218, 0.4386164144553567, -0.11223601593917508, 0.4626171799831978, 0.23289734011604768, 0.650255449826348, -0.3111784425442384, -0.07913836404752231, -0.08608044787397266, -0.3138573223172688, 0.5919320576973708, 0.6146718366085405, 0.1648485229783561, 0.1292569221616536, -0.6363737445842897, -0.14438401625968883, 0.7159166685332707, 0.33673775402991485, 0.23624516025237105, 0.5367609466489711, 0.49568826610037947, -0.4662380257084177, -0.6580803204383243, 0.4178547409950944, 0.5032823897564337, 0.5894655473256383, 0.6995519724417888, -0.5258533917232259, -0.22039346347309438, -0.2838115637797033, 0.25522566974582384, -0.0024291699179707603},
    {-0.2888825218331392, 0.41070609547946013, -0.05076030003295329, 0.7591070651346052, 0.13836051514489167, 0.6144605402431847, 0.054289226992987, -0.3620608840507533, 0.6192801838113939, -0.6433655480224276, 0.3052607905733114, 0.4468156606095569, 0.2959982395151011, 0.6147304333649576, 0.6101994628998154, 0.0693817611096883, 0.2964294951553755, 0.44266248629850885, 0.46256572420331427, -0.41089575994341, -0.7138915066255257, -0.056331003049036696, 0.4167978961820973, -0.6661806877061011, -0.17392871739269483, 0.290349129623878, 0.6660072015397973, -0.6650278862503337, 0.6949107966921998, -0.39787446935634857, 0.39495802605750635, -0.027137764266857368, -0.10875550162418865, -0.09145183477197429, -0.2095811972487325, 0.21906617242040094, 0.30790748666747925, 0.4623542242953849, -0.08909763926583922, -0.11164183826727268, -0.40634224339974373, -0.25019752360202485, 0.4218553279685008, 0.6902199334063069, -0.24238174426555353, 0.23980200086777417, -0.3056307995017115, -0.33287943034407896, 0.7504024506863517, 0.680354146635517, 0.5361970558025397, 0.5763729489299054, 0.7228546000459825, -0.513281309230352, -0.7396811191000993, 0.05643726513048507, 0.5134164496469207, 0.6920648463134286, 0.5019073425802374, -0.3436679374845726, 0.5373944566929221, -0.3128692638338691, 0.49533271113229094, -0.25226971748894705},
    {-0.6133885385630528, 0.41358839048280044, -0.35489239294835756, 0.5653987917123734, 0.43884830273009096, 0.7548586353937864, -0.31987983090027106, -0.22506001938337034, 0.37795262070854607, -0.3601169704495393, 0.4219551840025788, 0.07263851993927752, 0.09479145178197959, 0.3624150272188316, 0.339378156474087, -0.08427058506547086, -0.042638249024711944, 0.4645432271916881, 0.6484137282072204, -0.6087529915457615, -0.7861677166247274, 0.02083086021409417, 0.5494532011105728, -0.4105891767272523, 0.23814739664141815, 0.5136420772601769, 0.6247733241110351, -0.3945668353148245, 0.05560204032264793, -0.07571171975485375, 0.5909829656606178, -0.5575874766622393, -0.19929291245333902, 0.08699940119820748, -0.30493616200129864, 0.5362165869716391, 0.4318063400893263, 0.669781784241355, 0.14890711768870873, 0.017278650974566146, 0.00800096800514947, -0.4142427940427405, 0.3025816887960528, 0.33925050896826675, 0.08342811462026486, 0.4378903477181104, -0.23984635347779193, -0.06960826435170536, 0.8320252500841073, 0.2495912882233271, 0.2417137178938831, 0.3465958561319922, 0.4338266636374973, -0.2580695326662352, -0.4556663882012978, 0.5758603733514622, 0.2584870298261779, 0.5876877999728272, 0.5224185005215289, -0.48148069017974837, -0.01240710166298982, -0.28561018929503024, 0.2563096119157354, 0.09573898373611572},
    {-0.44145965009203236, 0.7665815505598998, -0.3852050266444464, 0.0695422669797589, -0.31437904450413734, 0.423861593980656, -0.5629444830297835, -0.31402325399578185, 0.08958580014593068, -0.3632374281435829, -0.24585159134048076, -0.16360327731196211, 0.013919709536254717, -0.02223996260686736, -0.34771617792723464, 0.22029035629332158, -0.6024405905861417, 0.7117997815918266, 0.5441539141177599, -0.5462989155989897, -0.6988935751176415, 0.16817386790489253, -0.2485579341522961, 0.004667646823998953, 0.2060609899288271, -0.3885478680580989, 0.7011328342672604, -0.6351460117081819, 0.3579139808362783, -0.2843917825558944, 0.6556355954799861, -0.2808705118094791, 0.1586534156780198, 0.4221740677735497, -0.3436989248584237, 0.5328598952643853, 0.2115701098617526, 0.7884723656774745, 0.2938644499752191, -0.5282120903460061, -0.42590738867012595, -0.24421062339627608, -0.17782093882434483, 0.6144026543728469, -0.0002721887390539162, 0.4297888011509077, -0.44649141016990135, 0.025833958603812202, 0.3844571130945963, 0.5738821347663909, 0.2961338342890027, 0.3754067160897029, 0.5585459222650788, -0.22421173429675934, -0.6533884422162367, 0.6251775000451416, -0.09802958949236994, 0.29229962139235155, 0.48721892887813373, -0.44265975794755197, 0.2852652341663507, -0.4743598325175715, 0.7711142362989921, 0.04212870779849281},
    {-0.3662434947133559, 0.7270583000969221, -0.27160721130564636, 0.4344420727319422, -0.06669381092379487, 0.5967934157376281, -0.045323671020820896, -0.6794134197231446, 0.3276715878846577, -0.6166685579183246, -0.37176324749781126, 0.18346537642466387, 0.3712582191928991, 0.41885629426078325, -0.1292821530240867, -0.34666432242276624, -0.38439776085519933, 0.6165338891035953, 0.5112723285847905, -0.2171258095396002, -0.6593126492458644, 0.1301089266260242, 0.34892169721051997, -0.423655975639032, 0.37322793106792224, 0.21527720170594694, 0.6924515147475754, -0.7181447986954002, 0.45269374391940836, 0.007356420518006438, 0.5046054511550089, -0.35372986015719016, 0.04462666242494718, 0.5124129308919978, -0.3325037812606174, 0.3933026331123838, -0.013477136364795889, 0.5646107011836496, 0.11826238821851, -0.7938406976128106, -0.14228247769082414, 0.12465037338739365, 0.010555474423629385, 0.09536215622925776, -0.5237283852647597, 0.25011091544464986, -0.7043569444109059, -0.21697634231649232, 0.3220614494305889, 0.6880025418561785, 0.09538557434306018, 0.5599733940856727, 0.5576699640923186, -0.46719261280556207, -0.6079199417003779, -0.24166275913360158, 0.48128933812546554, 0.4744316682454175, 0.5064778600226316, -0.45786027916822847, 0.46356736953905864, -0.35300131774074867, 0.7837543287402089, -0.19106966899569724},
    {-0.15810748011926606, 0.7906026778912849, -0.5540402209928811, 0.2600171752909742, -0.4615474549130655, 0.6971291576078036, -0.3422152605520505, -0.46302379176396385, 0.021499373863669444, -0.4574461258254218, -0.4094859098058447, -0.36532731549647823, 0.4875428969271567, 0.3015194988473087, -0.5794397888824212, -0.2917387163513214, -0.7147521999238625, 0.4340792092669815, -0.001893235245679709, -0.2887932198527869, -0.5005093599760988, -0.34900135650321673, 0.029811451108158943, -0.09243166169884237, 0.19487046317947956, -0.2214233076398749, 0.5918135257311737, -0.7148840706384855, 0.1794803087554469, -0.08704742441512743, 0.5848555192480694, -0.3624204644933082, -0.3197007041713376, 0.6655433453069333, -0.4515052724272906, 0.33672518818171554, 0.11531890700384197, 0.7254185754150453, -0.3997196324962624, -0.649991161379657, -0.3497609869412176, -0.21073078719311467, 0.052386674577884255, 0.0825565769281754, -0.062116255704820676, 0.380212665472153, -0.7527928122355204, -0.055087311104965744, 0.5334720570126743, 0.34296601813827143, -0.2572389755803623, 0.3754410232322781, 0.46090391528115937, -0.21026888086688292, -0.32898896955100787, -0.03913069719721758, -0.009608346471864383, 0.4666903940838186, 0.5279886102995613, -0.6390778788602386, 0.39925267006703563, -0.25909124344393886, 0.39471236139969595, -0.46059895787917327},
    {-0.5432623719788783, 0.7824344556132815, -0.5952031533054104, 0.4818855251262873, 0.15827355841294485, 0.6746098562833065, -0.401883484904241, -0.2561016854860983, 0.39792819308102956, -0.33903214378246116, -0.43395112400576086, -0.24836364287633808, 0.4506062404567509, 0.32626522319424495, -0.23771963533090693, -0.28082497478285146, -0.7042594207199113, 0.29673801221334845, 0.48523773839684287, -0.3651885516405009, -0.4446391759884967, -0.25365102780163523, 0.06560578980425363, -0.47366324067250204, 0.11115158868531591, -0.4386449536640433, 0.706009748090446, -0.854704912417927, 0.2914149024366041, -0.3688849847251017, 0.8098574429490377, -0.6342569403188164, -0.23732005226952477, 0.16025023723243448, -0.4303638849774069, 0.5358711917572637, 0.1510500245970906, 0.5019680331192109, -0.23248773191299613, -0.505975403708585, -0.5356415516115499, -0.3006005748971082, 0.22118057321994442, 0.4409898024832746, -0.28277824080070524, -0.005479616780721336, -0.5940273811939409, -0.28946179505445097, 0.724933400293542, 0.6620696750461732, -0.04845707160008727, 0.301036209897995, 0.6884863083189103, -0.2842519683061089, -0.3698917859759105, 0.3980728826046293, 0.39853103152600705, 0.7638741284661315, 0.34278344391187754, -0.8216272570122569, 0.6060534112081615, -0.6650514266851351, 0.7444633119966996, -0.3317966275473547},
    {-0.3541134879808766, 0.5132210110810299, -0.2841141861385663, 0.3326587889271793, -0.19178117675764797, 0.6749406467378728, 0.0642214115355735, -0.3800555882937504, 0.1811291244725824, -0.1530409263967685, -0.1705447011572156, -0.21497211902083574, 0.16062860090360764, -0.18216409407473774, -0.11764582570365156, 0.17839059114291414, -0.5366092408155166, 0.04436293841901911, 0.41539134174703946, -0.39684782921717393, -0.09658890240195522, -0.0801446588458963, -0.06070868927223959, -0.2778572604560325, 0.26761296546766616, 0.13726096399877893, 0.10156303291650008, -0.5524620010619206, -0.010757337491965096, 0.29202267560800915, 0.7347785502615338, -0.00880720729772282, -0.17743552442194221, 0.7098007808952017, 0.010857102778469943, 0.11199878814791196, 0.016358395435492615, 0.6511463734439026, 0.4063500448452153, -0.5458454492384099, -0.32746649503749786, 0.3053532667766064, -0.17236511761672696, 0.3509208400333428, 0.43224537987577455, 0.3961516760002881, -0.19368374111123834, 0.07335239754365691, 0.018394052920390872, 0.29497147961955017, 0.19332213267327897, 0.25641702389825555, 0.4299722854220611, -0.09519986483077635, 0.04825033041141145, 0.2023511507656962, 0.19365509773838738, 0.04754607947154735, 0.4030276494767465, -0.5793804744588713, 0.3617104284197922, -0.29064811740446367, 0.6985253369996249, -0.24417135054439454},
    {-0.12963269653915813, 0.8339168162516919, -0.574060869584741, 0.6457126236669585, -0.06564310437395601, 0.5653115872945803, 0.1725825635272674, -0.7460616999278796, 0.49098101255162224, -0.25475263054508657, -0.3599798797340557, 0.09850808722076469, 0.11613212271304499, 0.0637117406441574, 0.1542649274923725, -0.32075256226971344, -0.3239007468184983, 0.5891143272959944, 0.547371579580351, -0.2950230028091734, -0.6173927087563063, -0.13378122937462159, 0.18467932679146296, -0.631897775430028, 0.4152347865489859, 0.02991518191166428, 0.5126592408091487, -0.821598102980128, 0.42629860752837506, -0.18379780566273032, 0.37950474305373416, -0.24744960069428903, -0.14688693362422056, 0.5821281946576863, -0.36550313641244153, 0.2465912176582977, 0.38164289303243765, 0.607187780992033, -0.002427650214431075, -0.41011126436430684, -0.3957211873313915, 0.061280331503139315, 0.392220475405387, 0.4535902419979841, -0.4655018135859582, 0.48974281403914544, -0.572940840463635, -0.41617437869868357, 0.382254147778889, 0.7197800458643542, 0.38032197557341374, 0.6111940991821484, 0.478643942171782, -0.5060847829519192, -0.4634457745330709, -0.2055108219463442, 0.5984046752476765, 0.7711553813462793, 0.6600893302027765, -0.24237639237514325, 0.25886752834888727, -0.34291208412872437, 0.2908430293477049, -0.3931060588430091},
    {-0.38439779401580965, 0.6629752308032731, 0.1358471489985486, 0.6483756823253258, 0.31996390798046925, 0.5447719545039623, 0.4037935409613929, -0.5599442533326214, 0.13802172769847387, -0.06574379226459044, -0.03716229377152337, 0.41554783776748555, 0.3446862091109884, 0.19353514929776952, -0.04250311393617339, -0.0548528612409043, -0.11623145291948948, 0.24331887504942093, 0.6456856666204644, -0.18686273454246968, -0.4287523738397519, -0.09194075494146671, 0.41011646484092545, -0.3724094511753645, -0.10926434589687459, 0.16212847437892125, 0.018975821917542893, -0.6542589582992734, 0.4667043233355684, -0.2524970708775841, 0.34684950087159805, 0.06562996179750594, -0.07645057976897328, 0.4961371115727052, -0.5038478052135063, 0.41049484916290147, 0.26710611724210576, 0.31869311821308055, -0.05447631151297855, -0.32097994960812487, 0.16182954585491402, 0.0880886009958191, 0.4681412656101073, 0.14616779789611745, 0.008087089877406296, -0.1831201939540472, -0.4387103724091715, 0.2656668525257297, 0.42633651151889723, 0.6934438177462252, 0.4075663746993866, 0.5582401171267104, 0.31624974837813213, -0.6013029184724312, -0.2727080176723333, 0.2366033610722832, 0.25444539113879666, 0.5766784135727376, 0.46758278728207653, -0.35910243577722645, 0.47541197952894576, -0.1451770821498486, 0.4348274468590221, -0.3765677183197361},
    {-0.34342515162835796, -0.3929962311341762, -0.6859253254548726, 0.3118577140299648, -0.49473851950050646, 0.32060221149964535, 0.30586116551294734, -0.5426186269389446, -0.5565619871157943, -0.41021907922079204, -0.618896238329108, -0.7745569524340459, 0.0346374011695039, 0.1984719967334775, -0.7847569091270011, -0.6061347285204712, -0.5063857312072004, -0.6020892655097596, -0.5519223909032539, -0.26868253790179014, -0.8555599662235347, -0.48269899075986533, -0.02939283018834313, -0.5462690272270887, 0.18887202119796295, -0.6393462824039675, 0.2792891967976106, -0.7998536329228628, -0.6748268424671425, -0.07233094540820299, 0.09891600997079154, -0.7433860106506126, -0.5426490577754655, -0.38859438072572683, -0.3892940238020892, 0.08249248544784739, -0.6818520841104312, 0.4223717497517942, -0.674302408456777, -0.8416104650416208, -0.7525789935881806, -0.1161919429911404, -0.45631300246877765, 0.3253022376900876, -0.4806772455537359, 0.2616787267309264, -0.0015997767360856332, -0.7868955140373409, -0.15285269241339466, 0.14904075721404977, -0.47956346459643334, -0.5894392185276255, 0.04402129561492514, 0.10266980906175684, -0.23673511436893405, -0.5313086002277453, 0.20135776993025656, 0.3250633647156351, -0.7600051194846679, -0.6932863164078572, 0.023635154661510366, -0.4528349196578628, 0.2404987157905025, -0.4983860189038641},
    {-0.0832424815505059, 0.2655081837206277, -0.5956626412356024, 0.4446956793475563, 0.28599830652555763, 0.30073789371048737, -0.021071100172143017, -0.7810205164978046, 0.11584368840564478, -0.7049980641401024, -0.6222827886890443, -0.4945845712222249, 0.30674366404067577, 0.40724324032391956, -0.09893265408403498, -0.7696971136692786, -0.553871690351884, -0.2356219764083202, -0.06618424608861545, -0.46027205935188226, -0.8225562535064453, -0.5043394466299044, 0.17286006184077346, -0.7883169608890059, 0.23366680098842177, -0.32473150108083165, 0.6079931808206237, -0.5014799928852861, -0.03813729225184501, 0.10015445043338754, 0.1554192176030349, -0.7495579813787109, -0.5544999440980691, -0.15835240379702836, -0.7253180080194451, 0.1923422163242326, -0.3334881889985642, 0.30199189705904905, -0.6459321574211121, -0.5140763165099307, -0.7268051545512021, -0.36391022800210165, -0.14334087310999935, 0.3021809063125929, -0.498706843146772, 0.30887285156926664, -0.39147540726653574, -0.36877722919341827, 0.06323587412902984, 0.07218896635620052, -0.37820750907144457, 0.042050369840695385, 0.1580950544823122, 0.2926273873468172, -0.34387115783598576, -0.3716815117744578, 0.38497186183468574, 0.19637184733618793, 0.15723718691827665, -0.36479874120545436, 0.3465067573734893, -0.22204069126066667, 0.5357795615580816, -0.6030786554195597},
    {-0.28178740665165447, -0.14309737994201305, -0.16546371149303235, -0.07444955383950531, -0.34086742701078576, -0.046206647642488795, 0.06280032494535023, -0.6314408261438766, -0.3226445439711809, -0.15219047451921242, -0.6300538020929485, -0.6254823099117712, 0.14681839457809173, 0.20340489964612138, -0.6560714574432661, -0.38693366932063017, -0.5001041093097911, -0.5630219483725291, -0.7470118928822711, 0.0763335402118962, -0.5398462806950266, -0.05497969562493042, -0.006509965819760423, 0.19901523479671204, 0.5016891375820116, -0.11325047323947236, 0.39133404526882754, -0.550024235330529, -0.5601712697412146, -0.05765540525257572, 0.07164597071842257, -0.6910739051140994, -0.48402688144420125, -0.4687772277916509, -0.43154706195233095, 0.3845812824456063, -0.6871522680669181, 0.25105972625994366, -0.6104873618019128, -0.45055669291005573, -0.3093088894477161, -0.11420084896381962, -0.28680289271290177, 0.1301594173782519, 0.041045893376137885, 0.1701859270549375, 0.15143379711244007, -0.6424708492194107, -0.285795878853524, -0.4383470010148156, -0.2088782957139366, -0.22474760306990768, 0.046254533970040757, -0.20427702923369784, -0.23649155402598393, -0.6360061198487301, 0.123966412383608, 0.2654108369776647, -0.5410159592552196, -0.579842261391065, 0.06660864723496003, -0.0009968908229935688, 0.36654613533796626, -0.5060000580163949},
    {0.12300584221425613, -0.32225976579464, -0.5143900519346903, 0.006306410850581236, -0.4568756624271202, -0.05356351259832885, 0.14164930724980598, -0.4011299601774233, -0.45530129551645426, -0.15353885701226772, -0.37760856197970927, -0.42904437017172425, -0.27940003412364917, 0.08694142513907309, -0.37913901478971596, -0.2938209855206983, -0.47656294101813995, -0.631992255847582, -0.704187895560172, -0.03264441946326962, -0.14739007322262515, -0.1450309078884248, 0.1510124029990781, -0.13337634657187616, 0.10114506241419272, -0.5910535234152536, 0.030467713397908304, -0.11770489087885326, -0.5235549961542105, -0.42038952387379225, 0.19719785904063464, -0.4432851883874143, -0.17215716095654365, -0.018224262392925513, -0.5447874993818832, 0.48480621790944667, -0.7066749567377502, 0.30144647216396525, -0.6621516658457565, -0.35659585012244605, -0.647775851849006, -0.34906826336100255, -0.6069894322037847, -0.31265799293535806, -0.07322120194803054, 0.4140592329411016, -0.2790004729321458, -0.5628108957392014, 0.08588953346060213, -0.16816442467927098, -0.43236223601581714, -0.5709330980328777, 0.13914719595990663, -0.033543133148452045, 0.06215241095431133, -0.34236271737324925, 0.23815086362408175, -0.2121974383821085, -0.518260671824862, -0.36964908082564135, 0.34817392702321837, -0.2198544077748722, 0.28298906181201483, -0.6166948105695844},
    {-0.3884177258563584, -0.07598968508988484, -0.5101657542634003, 0.42596754558130895, -0.35459777349758775, 0.41211942720571637, 0.041228246590308056, -0.16920395781356748, 0.1360688685244446, 0.12537449538474277, -0.029609912048366088, -0.3885254685667173, 0.4303319417632026, -0.11075137273868403, -0.5326806657110693, 0.16247120867384524, -0.3324857940365077, -0.3343105784178256, -0.2474989485447553, -0.3596800208491101, -0.4803505294812386, 0.07882555555342419, 0.03572456039389571, -0.1772798370433334, 0.006135256662827586, -0.459062635993245, 0.5976200732144789, -0.32439134133852343, -0.5050590957034427, -0.372514232771805, 0.5884590382008761, -0.38744248645599566, -0.23776035948449403, 0.17507669304836376, -0.37751368304320504, 0.20609792915047645, -0.6345376231562253, 0.12081692627871717, -0.3187707953577042, -0.6060974836378222, -0.40629364263232565, 0.06602988006666802, -0.04575307470261114, 0.09919442130431079, -0.24597565595257354, 0.42428659515421036, 0.17642960838927868, -0.4598919733286871, -0.08877976127764294, -0.294919951421377, 0.20551472960043368, -0.03018033707572997, -0.03372468407195563, -0.10845624266994233, 0.20911452963979946, -0.19438682898010304, 0.3546204039446995, 0.4288687150406317, -0.4489509623612537, -0.4342600742935025, 0.0805360580033109, -0.46816084827570553, 0.14072309074622266, -0.4652546749734378},
    {0.30283777932760325, 0.1257552248361468, -0.06994531316229166, 0.00833377172496735, -0.38778942410198197, -0.030291355470018697, -0.0854098783356601, -0.23643951801006335, -0.3662780479885275, -0.1460608729947109, -0.36124412410327134, 0.05191359404826343, -0.2679853120894735, -0.3235014768597075, -0.38817029171852585, -0.20306187454388258, -0.6154081639081619, -0.25570050518011117, -0.6326309734613391, -0.019269465991197606, -0.11649421791492841, 0.15702219901076328, -0.210284816768178, -0.15891849772292835, 0.48839301994977263, -0.49597360024660375, 0.29459421997068924, -0.29104995354109686, -0.06651920287169902, -0.516584587607281, 0.09984297286973197, -0.6143640803100301, -0.3028985843394252, 0.11145709904451472, -0.28591668999978104, 0.20139631226128227, -0.6729983127989173, 0.14452174713297894, -0.689602463108119, -0.4530070682123984, -0.2670986156708067, 0.06523211701759178, -0.4009056890669534, -0.4564684406344054, -0.07976807528365, 0.34740831474845296, -0.30650094772758535, -0.46034311451298743, -0.06398688368838279, -0.2669966211941233, -0.5045335537035992, -0.6023661934423005, -0.08250847492664957, 0.36254320696029707, 0.3206034841668667, -0.6472268127296086, 0.02652954233069082, -0.044122478507583045, -0.1860909934030361, -0.22985883382823646, 0.21788912502621172, -0.7237605260436956, 0.368646806400099, -0.6080197573212588},
    {0.19967268007005678, 0.10578264996357167, -0.09702411481569279, 0.42317936463056494, 0.28278021341649395, 0.3847974592760134, -0.05220627591991221, -0.24890531089184065, -0.4657581872740343, 0.27956019128001236, 0.35871212509049344, 0.1731212265768848, 0.5392810534511242, 0.42816567593505084, -0.19704740589099787, 0.12998599571020836, -0.16762928208775088, -0.35715478371999154, -0.3699117593291979, 0.12618051063881777, -0.21098766376649122, 0.04417716890039919, -0.1263054673426484, 0.006270608826932508, 0.5211345674710617, -0.26120794618225474, -0.049008476646930296, -0.5127587975244603, -0.20685101745185713, 0.10640536642804094, 0.17351203588345102, -0.49882849160293063, 0.1291221370788763, 0.32558776377525683, -0.33638750425671615, 0.17401735067830662, -0.4283189119624803, -0.039300506294016026, -0.5340501038406319, -0.2645651227658776, -0.057222622167652094, -0.27472043267842083, -0.20844113326856303, -0.14087725318514863, -0.03541661626632025, -0.09792091503382044, 0.2789279365345707, -0.025300305364907752, 0.0465518788737693, -0.1547031629153043, -0.07645855592487485, -0.16999012661374494, -0.022376543897957814, -0.304844317421769, -0.08987353509450313, 0.302359381298907, -0.20577983636255776, -0.0006624344042059916, -0.4381835819334793, -0.03750217574601854, 0.18644904351369798, -0.2709829061810698, 0.06504905842741372, 0.13111739047253707},
    {0.20677985376430982, -0.28400570060503494, -0.13436452273028496, 0.21610237160043788, 0.09140569431961068, 0.21382762933621824, 0.43214967098342777, -0.31932605103522804, 0.11223290137524188, -0.4189913941423837, 0.31010842874295613, -0.20156266601072106, 0.0651248493910936, 0.06656612799199027, -0.0500181504803702, 0.03393805888238785, -0.1422808583521146, 0.0006459778467184776, 0.0037786650139209083, -0.06371477475616315, -0.06117010823108365, -0.39745055141555824, -0.01746606370192799, -0.17216317329220213, 0.5040203711995294, -0.2168876836362241, 0.12897162493278208, -0.45082187537987756, -0.48847993549612106, -0.6778033122241833, 0.3049906057372715, -0.6096387614110551, 0.05358340258318484, 0.32096334210474436, -0.41522885422550015, 0.2485942792074628, -0.10874135345408514, 0.04723920121700501, -0.4554205197621031, -0.04458929323737158, -0.30388419707701886, -0.4523626853503896, 0.04571010158482951, -0.1847771480346506, -0.15939476091940485, 0.11010775494624411, 0.18650172879796517, -0.3602723814808946, 0.17514305709191602, 0.17295246559671812, -0.5120691878944061, 0.3319604684207654, 0.5414774562689499, -0.35559840057048936, -0.052143233205461645, -0.17121828044200763, 0.19578045117235054, -0.017892915265513853, -0.20263918288931848, 0.09881710275780264, -0.3867211826569997, -0.2797397366901932, -0.14095499377157591, -0.03669606402587347},
    {-0.2972062837235961, 0.36817478804607195, -0.4897450459290922, 0.4015087759859371, 0.04303954143658264, 0.3567396072573609, -0.06738011657391796, -0.21120594560031827, -0.1891398413424583, -0.423460638690414, -0.2918356797329539, 0.2340279842694605, -0.4128652971500758, 0.5217050331883928, -0.005561982368199261, -0.4528186619601879, -0.35775387701510125, -0.3317005436799538, 0.3274102953113578, -0.11403143673246985, -0.37855443699584723, -0.25649969435000086, 0.3214687267699448, -0.31880441397200754, 0.051810882591989654, -0.0567911225865537, 0.07675422889281618, -0.16109843674568827, 0.19069757316479513, 0.26472823955462177, 0.38679527414926335, -0.4778296434010703, -0.41500070874125994, -0.028411015045057813, -0.03433972905030064, -0.012796008314482576, 0.04095374786176576, 0.5679057926548434, -0.5308833526492817, -0.41069854854124727, 0.2777477274665356, 0.17208322311959826, 0.19603487741402895, -0.09037188640474418, 0.035348303010110375, 0.6040674075123091, -0.23975646247186286, -0.442191083340588, 0.09001698237483718, 0.16144173368913817, -0.3490626566643532, 0.014693826053730112, 0.13024865077266584, 0.07810806544989146, -0.4228664362588451, 0.04142582666666381, 0.43833525599034723, 0.09027524242912616, -0.41559052430361254, 0.08562227763491904, 0.12365362364497662, -0.5603548728772225, 0.24795869925328548, -0.3283349609701373},
    {0.09033953075544641, 0.10602852026508355, -0.09810418223170453, -0.12778347644211502, 0.3319756758746388, 0.37262374037332213, 0.13826211584399326, -0.002965546920705093, -0.3707728270739421, 0.15938164147115028, -0.31857973726947403, 0.46523440432552343, 0.18407441812267655, -0.40476206553823557, 0.28394558095629646, -0.49581925763778734, 0.2841442382109806, -0.43979223871094225, -0.07261550084529927, -0.3116637613723462, -0.21946379514153644, -0.2993267361505258, -0.25268939464631923, 0.0630582617094496, 0.013245013546955819, -0.1520767191567125, 0.021394378415274782, -0.0880006670578064, -0.362940148850288, 0.38956798541485793, -0.5193911403008054, 0.04899725107911386, -0.38487433571243124, 0.4609009074658993, -0.2737079534683019, 0.1463995618780499, 0.12998192021335517, -0.3176793103711761, 0.21292237839358885, -0.45341485667151427, 0.23556526681792064, 0.13536185151763025, 0.37927815819546407, -0.1959201510479981, 0.3840384630864109, 0.15275280254172377, -0.29632326560416195, -0.12384497825148708, -0.21316850580469301, 0.06283491006846975, 0.02105053330612368, 0.31534441389364953, -0.27540067538876195, -0.0101011564404173, 0.13369442371121126, 0.33740775987792193, 0.20922949424643586, 0.11537125150763042, -0.4375697412004657, 0.06023226866845109, 0.4658445279097124, -0.5413703248815082, 0.13667130102178165, -0.27457711142231456},
    {-0.5094433930167315, 0.36795803109367975, -0.0315886565597638, -0.042267274550762096, -0.05471650411711043, 0.00880020196735335, -0.3261746914430109, 0.33714607976317423, 0.06834833433893417, -0.33358795726848306, 0.17079242694103064, -0.24100752001080863, -0.2285632792751932, -0.12186811426987319, -0.3765618419819664, -0.2332300118869824, -0.1348721001767739, -0.3320216383788073, -0.283530946234667, -0.015252055180749785, 0.28538679586841786, -0.26098305107383685, -0.38295615037308506, 0.2263414523586508, 0.16895432220936019, -0.050015444780833175, 0.4675030336745876, -0.21572958526495903, -0.47914140737599475, 0.1116610860063756, 0.119973349817276, -0.0486019640583002, -0.08850286229218858, -0.38308510835695686, 0.15879629466974135, 0.3676003635695341, -0.24923019959138695, -0.49680554020992723, -0.61190031454809, 0.1453217054371704, -0.2727088938894489, -0.4673726551334831, 0.1225907903004521, 0.26325307451192503, -0.1876313309515308, 0.42879059557127996, -0.5362311939271918, -0.3879414674842649, -0.2770330255887876, 0.054974067596527926, 0.18633810813997764, -0.2834503972780808, -0.11172974007227345, 0.3139911115320845, 0.39502481718501586, -0.1082309933477097, 0.2963789919404028, -0.2848593591229588, -0.22283460159715282, -0.19824861616241413, 0.019463228206420234, -0.44544081494344034, 0.1930831510094819, -0.6094900014435721},
    {0.46346262566140617, 0.47700593486717047, -0.2977983833429576, -0.19486170328197766, -0.3094681855447817, -0.4059678840166167, -0.23740703894144655, -0.2448461559662039, -0.4053908813718204, 0.01002390021797394, -0.13716171746973668, 0.37371519793469216, -0.3713290971899476, 0.22036416826091806, 0.10132607226750938, 0.23402172959791742, 0.262287642389252, -0.12601185761575878, -0.5050682266765252, -0.09713698449369501, 0.08249490744469573, -0.16596568082167695, -0.3916705104635726, -0.20445405555490512, 0.10696059881631763, -0.043897423154538116, 0.195964745056084, 0.2745470901557359, 0.4701610255926598, 0.2064790711701157, 0.4311626280574394, -0.00811416327043162, 0.43901707871632467, -0.2663479839632803, -0.25253893845082537, 0.43560870767681986, 0.270983585008276, 0.15664512932622046, -0.3181996000175936, -0.3856399256896845, -0.5014165377571157, -0.0758827793769376, 0.06741845377925845, -0.5330738573156486, -0.05438809937109711, -0.23012560621431044, 0.15054612759393407, -0.46583878414387087, -0.12966029073444965, -0.43879300968846446, -0.31804358180341313, -0.2793398779025153, 0.1139721238080097, 0.24518548689931716, 0.1169386112505008, 0.4004273854455587, 0.2822365733494674, -0.5412479902421284, -0.20283317657123132, -0.0028696176726673334, 0.1794915052464475, -0.3523563334188065, -0.01488234108285212, -0.09167437637909366},
    {0.4411702374248723, 0.23697410906307984, 0.196425449786368, -0.14059620072748136, 0.09547183929331976, -0.13024762539163076, -0.3742017721073601, -0.6059527087104946, -0.10307543909122534, 0.06006806007664165, -0.0026498627765715005, 0.4379775545787248, 0.2916722804678106, 0.2406838635992449, -0.14234317012781467, -0.4121708089919803, 0.20366683863010634, 0.18164001987349546, -0.05098075509860235, -0.2732376048032638, -0.17468632212563218, -0.044824177174170345, 0.15218693532113037, -0.5002715546198947, 0.3011108777448301, -0.020450694144422788, 0.0521672116342152, -0.3765297446582936, 0.18947621288104288, -0.33030006742886064, -0.13575297865993216, -0.3272049245557344, -0.43446674558293935, 0.34144322283707823, -0.15371856817468038, 0.11399258920010792, -0.2286486796171954, 0.0023187692891107653, -0.29669211222591524, -0.38895187743382553, -0.09677056000863075, -0.4675162986302362, 0.023213361919457404, 0.20950799055525682, 0.03363133349502628, 0.2074170164887822, -0.4106778548286763, 0.19632664537874586, -0.11252171100812923, 0.28086105323229554, -0.11264474115174718, 0.3222561695422519, 0.3920259324459349, -0.33127244492985203, -0.062205482034224914, 0.014156020441211892, 0.03375707190251598, 0.331191494601143, -0.3681222458810582, -0.4490070053216466, 0.12826887333023662, -0.3033919551794486, -0.4028783732832393, -0.24334888635071605},
    {-0.5363603756689396, 0.2758649156811282, -0.4752685473335996, 0.23192975436208815, -0.3548646275546953, -0.17775220208464704, -0.04057133786590707, -0.39820235444421703, -0.10522283748894835, -0.305356584961254, -0.34747538246757875, 0.2732301293776527, 0.10060417262586172, -0.11815789190390717, -0.2833141749262068, 0.30204325556592937, 0.11073521484592128, 0.2184645256427794, 0.2712744470695653, -0.3432498425793209, 0.196611476679291, -0.4140744022402347, -0.18337842874357138, 0.26312679085088775, 0.10470673510331281, -0.382666180258133, 0.09581652790829571, 0.197020888901874, 0.057298787759922844, 0.1291325054212563, -0.12515587165039568, 0.20126130550694277, 0.4179587885013687, -0.004706465075891482, 0.20311833368670085, -0.02571892830582187, 0.07989968591373646, -0.2871648760395903, -0.1663117969823184, -0.24863195533554702, 0.20774889071939825, -0.005845132382441658, -0.41089805019691217, 0.2458418273823799, -0.043902021990243525, -0.4609529871647757, -0.10149519041156779, -0.3255352369413196, -0.43135880427657736, 0.21080148372890395, 0.23501112972045837, 0.04906428534791843, -0.38650893446857504, -0.5397945041585193, -0.11099164215701697, 0.11290820367864605, -0.2872885091014798, -0.331249691902954, 0.1467287527346949, 0.379037062536427, -0.28043202005947776, -0.10358734132190989, -0.461741103513368, 0.14781998915975827},
    {-0.13895525142146142, 0.21570748783195268, -0.2978454720904475, -0.443479058169952, 0.09881152181884156, -0.3054652707013923, -0.30844410042196513, 0.24198299133339662, 0.1941170059364082, 0.08164683143986058, -0.3890419511873951, 0.5669564331737722, 0.5244757703526516, -0.23526159171063837, 0.06914246792787138, -0.3293804952730804, 0.1621773204074484, 0.5921892528986562, -0.2682139538498291, -0.0009058217801436058, -0.0671889621832372, 0.06490568724739783, 0.13114971607631412, 0.19484119872515662, -0.34217706738870884, 0.37827617980212286, -0.10883137006269775, 0.0252786395444731, 0.4787919129612019, 0.22121774291121818, -0.26972470426577577, -0.2375805095830966, -0.1247319396635302, 0.43511717866627403, -0.08175313072848686, -0.1992290055743352, 0.23500868775038883, -0.17122489132791524, 0.37526927742699334, -0.05167388286802065, 0.32969485300471146, 0.11368021500090322, -0.18977814568452572, -0.4953472256768833, -0.15679644702795983, 0.4142748376523088, 0.30480739414771885, 0.38061878470311533, 0.18478055236076776, 0.18946254242299546, -0.14572983262366718, -0.013983970899374776, 0.5316135945939987, -0.022949295663123977, 0.09980969332745832, -0.2803293096120945, -0.23348943686747137, -0.22947954595653042, 0.08998453909013308, -0.1585834160583277, -0.4318176147050551, 0.13004529806282142, -0.4281209702963494, -0.013044395378328135},
    {0.25600076808882355, 0.28425370203684525, 0.20242585594839368, -0.2565785866030539, -0.5430980232582535, -0.2873990666191616, -0.5288166143636231, -0.5591147741795421, -0.19749476552433065, 0.08662334826778269, -0.27865890750525474, -0.09655824896200378, 0.06163177560665979, -0.10505711146105094, 0.018442739562006906, -0.05292623653560975, -0.10626081119826561, 0.5577738499126479, -0.2526795210173873, -0.1710790955436804, -0.11098644289306721, -0.25151621898711074, -0.26179683622810623, -0.10986423338037737, -0.3817229238638116, -0.31180505595243496, 0.031075866130788356, -0.21123676660461854, 0.27342777839361937, -0.5477572159296856, -0.5343079537936174, -0.16430915673633956, -0.45622173445535513, 0.6332304288751661, -0.5555706020379548, -0.22560740613913993, -0.43121597534438816, 0.23260107934587737, -0.10030427760467572, -0.4427157075129588, -0.3920292898084702, -0.44294565806165115, -0.21905170202907584, 0.15127149884133295, 0.14677720840343278, 0.579750070708329, -0.6237579566095384, -0.1938159862629187, -0.09437504209142293, -0.03775343202251733, 0.27080455740011433, -0.31927415347414295, 0.48350126372842245, 0.028411283906284238, -0.3166062772706856, 0.09147451377336673, -0.0864791725306779, -0.15406335500710758, -0.10959030114004548, -0.23624153011562665, 0.08319531415057929, -0.3142879690747847, 0.041398645252685155, 0.1697500548169721},
    {-0.3833880541824053, -0.12118566350086504, 0.14983588511407442, -0.032516166396038784, -0.051500979423215965, 0.339567253215983, 0.06422794199884825, 0.040388498606636965, -0.04007531295857569, -0.47163817991049445, 0.1281469829119102, -0.14543086307348796, -0.2802016162178086, -0.08115934605024437, 0.04720357341981479, -0.5186478750783398, 0.42798067246534766, 0.3390928542533246, -0.014759478528775708, -0.21103140553152197, -0.020558297801598294, -0.16539279451910907, -0.1132708766298389, -0.18979883385648233, 0.0441475855887669, -0.2411299008102524, 0.09332484661219234, 0.3217290925600727, -0.2865596991986913, 0.6201002488130347, -0.311979950717414, -0.34067688079442676, 0.11212706304509652, -0.12910389741238534, -0.32491515069090954, -0.32192654214940936, 0.020812160623487886, 0.2263055809731816, -0.115459365961044, -0.16502179197487316, 0.1362705441924219, -0.381573037767824, -0.14190170290748963, -0.30715267108631256, -0.5780050783526297, -0.1459128852110418, -0.20201574482582244, 0.15614775938753062, -0.02486007579054024, -0.12828065010062303, 0.38985932022892966, 0.29839079033897153, -0.47189493289635465, -0.4307946239677411, -0.5285971035714048, -0.32578067152990087, 0.30331898402350305, 0.3726348568796747, 0.43132468223601694, 0.22080674647713838, 0.08756018175604577, 0.29083362471913404, 0.12914587974652483, 0.013855184036251064},
    {-0.039241800984776046, -0.028427385311931605, -0.0176174960499657, -0.5091035393663179, -0.39611362000769523, -0.2847964341959273, -0.23155013656323492, 0.34197882162387644, -0.04969074160856304, -0.4024485435456302, -0.1665653668594588, 0.02524439177589255, -0.6380072199296358, 0.11898151279732151, -0.28082877615907004, 0.14978460632111062, -0.08410084889419081, -0.5210721440109218, -0.01688034774450162, -0.007986564202332198, -0.16332455757012546, -0.09174719714258975, 0.303390880454159, -0.07559204446182505, 0.332775852940261, -0.035355717362074546, 0.18918580571756424, -0.18954487436004383, 0.01002298532675225, -0.022896555657131876, -0.11965823260397902, -0.3494201388647729, 0.10100846981180833, 0.3487316886775685, -0.3631487429084602, -0.15276048051425076, 0.01916691577418686, 0.03425869495752142, -0.05759108561190819, 0.03478974182671772, 0.36816485957107015, -0.20021845170367347, -0.1266238634177853, -0.5175929927438819, -0.5396990139667014, 0.10863959749698048, -0.43230894524453195, -0.24826301792834737, -0.16714573220182835, -0.36299858169241955, 0.385930772496564, -0.43056208720073275, -0.27182700458243686, -0.00832097440500734, 0.37052384655887177, 0.3000636420240813, -0.1415572161581392, -0.45888609442790707, -0.25517662340286107, -0.27409432947604717, 0.05229671906631566, 0.18023920381548572, -0.45504579764265063, -0.004822280609950691},
    {0.036080705684228324, 0.10035702307653073, -0.054278808429115775, -0.4145904454387582, -0.30001893592729534, -0.5018973138370745, 0.09007634711314999, -0.06957850601505983, -0.45773435123572365, 0.3225576279089007, -0.04678998161302483, -0.24080158595150122, 0.3242372160977659, -0.4967959760769775, -0.31472472506209215, 0.2525949564377269, 0.32374030738455706, -0.24470629595610963, -0.4170033448731081, 0.09920791860756864, 0.4950130293714658, -0.3880784174765228, -0.13051969010157768, 0.4602817658817287, 0.010680558808944982, -0.11575879984815783, -0.5092187847996054, 0.07099642419041037, 0.42918867529697285, -0.02503683714003489, -0.19442732843977842, -0.33878450128893706, 0.17481108540343102, -0.028428585420619993, -0.06778420608224765, -0.3396261874758856, -0.420567637278349, -0.5546663453322251, 0.05489794112897191, -0.043324514706724944, 0.44066260200571916, -0.11911298545593983, -0.1964782573147519, -0.24815223131243894, -0.2956409644120226, 0.4152047865185457, -0.13140210926529924, -0.14600659637678906, -0.11551878912235482, -0.28747600326445794, -0.0022730461193526, -0.27835460563125297, -0.13309884739991865, -0.07098810452693105, 0.38492656826853067, -0.023725486532639655, -0.5027026537618988, -0.41526479084607554, -0.38347048915111753, 0.029623637199418757, -0.05383536935639317, 0.49013850790585134, -0.11332577333836763, -0.3374065935514975},
    {0.15172020837160421, -0.23046071754786798, -0.18184156423810102, -0.3316367681339633, -0.13813089908290108, -0.029695524267847193, -0.5678758357949346, 0.08078830374676046, -0.32925377860447286, 0.37956676970686937, -0.11095665650189555, -0.2283394998544935, -0.3970402617349628, -0.5631209567819146, 0.2265106435134537, -0.13229728385250542, -0.27131381070920363, -0.4709363160625616, 0.17174240656089915, -0.3709117748819544, 0.08085236543479198, -0.41033274530855146, -0.09332215479762855, 0.013657963358401288, -0.32720021535513527, -0.38368826315639865, 0.02399121754101001, -0.09655600616052265, 0.1839654596204643, -0.11826785150803021, -0.5671841761764376, -0.20851857500214446, -0.24714882388504608, 0.056052895389576134, 0.013041494238957198, -0.2985182708609088, 0.27879307251313423, 0.013763704949483091, 0.00010279646383288583, -0.2034685922533249, -0.17313779274611488, -0.06382446381982192, -0.23589610557094765, -0.5339632780943604, 0.09988547444406298, -0.008684228732899977, -0.352197778598748, 0.10380177367962248, -0.37470049133749017, -0.5418713512563786, -0.1808495058674918, -0.14754097347848927, -0.4936081129702211, 0.09213483793848563, 0.4013418667518843, 0.5108323553033045, -0.5252591899679293, 0.1395428734115197, 0.21882052468199514, 0.21982751487385913, 0.19827839382175633, -0.13762489949079745, 0.17445741277836485, -0.09854524216734813},
    {0.07901338985821527, -0.5427250711659575, -0.07490505445566788, -0.15295649794579222, -0.002107696579303816, 0.10776585834920106, -0.65658700939198, 0.013702556256592533, 0.33827563408779354, -0.33136803493039224, 0.1619139285723085, -0.28697875952911456, -0.4573331137073902, -0.47285299313398593, -0.2632957892540408, -0.24341380054046263, -0.06801733205517956, -0.22468987640622246, 0.361616605065052, 0.01567895328061706, -0.3382000197683715, 0.37126749294185873, 0.08797824580105149, 0.3720274638025456, 0.3837309274638083, -0.2723917025772021, -0.27876486525272415, 0.03518283660066649, -0.08782324952809878, -0.02586963614636211, 0.027082267259151156, -0.13355451010329938, 0.02344287647032329, 0.5078798280858214, -0.4418178000432105, 0.1621292108241846, 0.13123123344054047, -0.3249274737874259, -0.1634516004744522, -0.30339478522528746, 0.20862707309873868, -0.2795863086199975, -0.13009111328271317, -0.5650581953962043, -0.46667428926657195, 0.34178711900695996, -0.05576029476059205, -0.22514557809543284, -0.43431498606033736, -0.6241182580455971, -0.33278237542951417, -0.34651380082746525, -0.3324619798879629, -0.013890837461785726, -0.002355563070390705, 0.2631176210442533, -0.08487142951867087, 0.16072700994118075, -0.20082827887358454, -0.17422382221784002, -0.17567215228692704, -0.05509115158569783, -0.17599334392888946, -0.06091189171138751},
    {0.009563870890855976, -0.3284105530829266, 0.09358285344654738, -0.5124251096346749, 0.4045888772521789, -0.33618423440502154, -0.13523452917522735, 0.013963790212160224, 0.5804425032758685, 0.06076903307157642, -0.5290044977026901, 0.01457236654499162, -0.25992034914278017, 0.13011533633494674, 0.2340720625071203, 0.14337567718417044, -0.1478017786395523, 0.04885844515519418, 0.1594653032875197, 0.5390039535221742, -0.17797741008997187, -0.028153297381737295, -0.07574101095430652, -0.07159441828771486, 0.12348396196783731, 0.24898725732416468, 0.14025587011539523, -0.006992933878969855, 0.3279802139930565, 0.2932099683349449, -0.5641617812343215, -0.2963493848492469, -0.18722162865624684, 0.32901845139779706, 0.33446949666956916, -0.0853257606849321, 0.5385389887742952, -0.3862443746191357, 0.288429812117528, 0.38798660324606493, 0.21785751941988973, 0.3533492590132362, 0.12156113259842936, -0.33830451421283336, 0.42252666679062434, 0.20785857642022937, -0.23059170391755943, 0.35117888498452804, -0.20606282122951422, -0.3404498420106447, -0.42321813244178996, 0.14091338841998374, -0.24297042754151787, -0.14020644197960613, -0.1812721588984779, 0.39629773998712414, -0.13707399225235367, -0.3228138161922588, -0.12137351210402796, 0.03449057125078859, -0.2003381888182316, 0.04233414991527515, 0.4171277656281194, 0.18814148014964716},
    {-0.35684866355653194, 0.10622412109122005, -0.2659477520978437, -0.285774281653781, 0.26041054047212264, -0.24372683315374422, -0.4825437736026743, 0.18936836848748817, -0.3258831456761785, -0.2576377866689662, -0.09249337966636945, 0.4135485558956216, 0.39380960806678583, -0.11298429945448167, -0.05905786105955027, -0.12118684673296257, -0.1963289771141826, 0.14658829362935127, -0.040960099834374125, 0.10516954908591727, -0.20116271682557396, 0.02527393769875803, -0.3467656966920074, 0.14478842648264975, 0.42420897164290183, 0.053275846996775775, -0.2682419714965489, 0.25608036807645346, 0.09268371293962246, -0.2962622793734603, -0.12093079289723269, -0.05788360584367271, -0.0014396823275199297, 0.058532964034088794, -0.3113844775823178, -0.0911845814117967, 0.20824263256779119, -0.2691071904973498, -0.002028455912324099, -0.07673388690988205, 0.27087859029104683, 0.3937613142491262, 0.16837798966423873, -0.15532433413398167, -0.18367048866496305, -0.20695985012160764, 0.08052471665106484, 0.10245397005132105, 0.08024170455683624, -0.13984829319425818, 0.40726381313597315, -0.2232733185153333, -0.10724284273854541, -0.3844483797369553, -0.3297885458150563, -0.0875871043132102, 0.25973145192696134, -0.18203282011847097, -0.07814236839254801, -0.09520148263619803, 0.020823023230840787, 0.052603385094865784, -0.5502953518170586, -0.28274892000042773},
    {-0.35624626828806116, 0.04489627882348173, 0.039231754994510155, 0.10622057346461988, -0.12102188601842498, -0.22344987868253086, 0.03380384538516611, 0.07434744492544745, -0.14507139643838207, -0.445887529107047, -0.2180165900970532, 0.2017956247164237, -0.10877804928386696, -0.006731646737177051, -0.3465575698879673, -0.5122869152080962, -0.11399379675254401, 0.32994402756614666, -0.07761101826342907, -0.06469035315301097, 0.08156443625006497, -0.5259305040076553, -0.2732056207196119, -0.01327461791556216, 0.11181143690107335, -0.32368730213808966, -0.22176581262754627, 0.12930497149744932, -0.05727261195520242, -0.22182547051231738, 0.1899241872893805, -0.45181370120229175, -0.23395022554838663, -0.264118598312192, -0.2797787462791313, 0.2916407579565651, -0.12140044288797683, 0.29362618404477797, 0.10865555824631895, -0.34606868433197535, -0.04604443235427029, 0.383724711710524, 0.40895353746777585, 0.25542500546988833, -0.4309746935714338, -0.060074711940910894, -0.35064602454395644, 0.04879729666625375, -0.23919814037062082, 0.16349635829926842, -0.1503606579440311, 0.09919612152328529, 0.1541821852935814, -0.3388193815313061, 0.3153130661033041, 0.46753020478090546, 0.08189333847721549, -0.23888534324778732, 0.2121401857900389, -0.09676582558347349, 0.3766891688069614, -0.17436917675731678, 0.16229749791385653, 0.02192874974348986},
    {0.04716415615707966, 0.14784821951866156, 0.016078672777620713, 0.4318253636578803, 0.46950017295368934, 0.34113948309150555, -0.10204258732034227, -0.16201195653541617, 0.5272548095058888, 0.19106175749590087, -0.43184672744334396, 0.06311668686483814, 0.2922818086865312, -0.28715208766571426, 0.3047989124272608, -0.27529553695043346, 0.06681673298535819, -0.05828139748147192, 0.4098343824999578, 0.2384685796121577, -0.2839043099648072, -0.2146330837270109, 0.07084092358421974, -0.1320851717242417, -0.020802631248644007, 0.18023280404837055, -0.03659370245435354, 0.06096324429203963, 0.08809141009615622, 0.27274779943016914, -0.31400977561499893, -0.24036762441998852, -0.5431835302785526, -0.09914115040802275, 0.20343871989534534, -0.4443839274637394, 0.27609937034752025, 0.12173599253150748, 0.3722230100172879, -0.3815301816185161, -0.06415232783241112, 0.15727922614029605, 0.034425637777976574, 0.406070084177221, -0.12435283780507866, -0.18914741905063048, -0.44929751742328444, -0.2658980237419019, 0.4024067455754321, -0.09599464812113405, -0.11156735643531661, -0.07764297993561031, -0.4780028750895824, -0.3498129293987768, -0.08005629325978728, 0.05732064609034744, -0.4007227598527539, 0.31955712839072326, 0.46536793646896873, -0.3455495373865874, 0.16917994416170362, -0.1158449462260562, -0.06436974538142463, -0.3734539290044525},
    {0.16733841093061527, 0.24957038041574556, -0.21555533402540658, 0.1152255976224772, -0.026769372740768016, -0.0937388766505091, 0.323346471001782, -0.11052637004869995, -0.3663929174578527, 0.4197133623997776, -0.130725914222273, 0.04910782578643769, -0.29558157542940416, 0.23952828577592505, 0.38706143841018953, -0.24459973070610772, 0.3484426179994719, 0.033265999363037764, -0.013571958324163295, -0.29760567102298974, -0.1092314520193628, 0.4712760994776517, 0.25540803231890363, -0.11875090772904376, 0.4825946341872957, 0.05543087858459489, -0.25016721728198704, -0.11492876297856168, 0.4127597116087531, 0.22765600947725897, 0.0357399552187043, -0.05209615367377566, -0.47825965763320855, 0.0857408989091756, 0.17545082550781307, -0.016400543931116875, 0.3531597665711553, 0.47053409926428447, 0.39773577961220974, -0.2688504816294838, 0.25409426487953335, 0.20799528234178707, -0.0439891476508387, -0.002797550015229392, -0.3632217334095597, -0.08518796731657031, -0.017323890764018763, -0.21905381909223257, -0.21053191495616816, 0.18143079755233124, 0.33584749333242697, 0.38370562459373275, 0.16235717735986896, 0.41592545126768166, -0.5092155232330483, 0.4198446109610235, -0.13584138481263835, -0.12706756788215592, 0.19155466550503666, 0.1964494985252157, 0.284305901074676, -0.04855132277535401, 0.1876909331176966, 0.0616321628913019},
    {0.41267847927398965, 0.21392914260152743, -0.45658205500320603, -0.16081937058182205, -0.07812186116645654, 0.3444626984292637, -0.43377108902727385, -0.11634224673040963, 0.28409395267425563, 0.07673729959702404, -0.4097726491666588, 0.1176198157274242, 0.2867737257540829, 0.2936225863505299, -0.3166405093547987, -0.05823004534066446, 0.10152186906747762, -0.12398334593324051, 0.20030641947876957, -0.09973138142434144, 0.3635709990479763, 0.08277434974041836, 0.13756887398969728, -0.36065400862152064, -0.14637221051349386, 0.2859376430757407, 0.3141311782461117, -0.40494047184807924, 0.01374846271407121, 0.5144461922322948, -0.18580942726839808, -0.09982312913701166, 0.5317094113950386, 0.12877135609864346, -0.2882060184487497, 0.5733961689439632, 0.031967685257675224, -0.055965623912652224, -0.4412173924661569, -0.19804437893219304, 0.0275801373742523, -0.2548051535632184, 0.034399891879116996, -0.2971639301167106, 0.10575371260497174, 0.0804516545196756, -0.6016572216615252, -0.4880801343000153, 0.1717860588581418, 0.40181158623966334, -0.23355605831325188, -0.22464095934299644, 0.011327814865849793, 0.3153535124716658, 0.023355942260710517, 0.22367066864041132, 0.4293950108241151, 0.28827804125226475, -0.029632058928723067, 0.26301114319710334, 0.2743818872577178, 0.018015212804948992, -0.27989829166990443, -0.35899634888285453},
    {0.10491434652245947, 0.3462173348956289, -0.08402394612363649, -0.006292494298389626, 0.5805976194757508, 0.17095699075088766, -0.3614619979615239, -0.3542330575954297, -0.03808162435261654, -0.41492103615079295, -0.18459041239904805, 0.17992490497341146, 0.044158133848710285, 0.22881510743060682, -0.060875499872593546, -0.2813738305973213, 0.016043317683927076, 0.4271418067617785, 0.008538315734936838, 0.034114613787552435, 0.034786733086083016, -0.43685703029045675, 0.2336270033118523, -0.467784744579583, 0.1053099365550669, 0.28754377950449644, 0.40282161346193035, -0.18031619276751218, 0.28611870078828117, 0.4588758865606324, 0.5578538677393221, -0.012711375625257938, 0.37034940121013876, 0.4003438118468154, 0.19928363738789126, 0.398921529988533, 0.20249089636653966, 0.47772431800177523, 0.46463565088368874, -0.3350773039271103, 0.25511760889951185, -0.22888179137230183, 0.21338775465710877, -0.22517213158585772, -0.3855182168127979, -0.2743293232243237, -0.16487120396915902, 0.200849565459778, 0.2454783457862623, -0.21011333429411663, -0.043755491103642595, -0.022862844550539947, -0.19474357984966598, -0.3264755363083599, 0.2223814590714787, 0.0665547189814961, -0.011479423078182886, 0.21712414846430098, 0.22661120665882376, -0.15711811985656543, 0.35699090732057803, -0.24199616995917952, -0.19809466386304317, -0.24310163548842714},
    {0.5078448114408509, 0.49641950836566023, -0.23912696893374735, 0.3614656046917209, -0.12342868414090166, 0.13646177889790592, 0.3271806236923435, -0.4238905662129576, 0.41346967326057804, -0.43665837086036663, -0.5238272115752697, 0.5760013564014831, 0.2590220706827347, 0.35559554036307434, 0.1903884962386125, -0.5992327275370943, -0.1012961404464377, 0.09330807455478309, 0.2664636184983856, -0.06957375814692797, -0.5031757392480327, -0.1332920440840418, 0.02993720932490382, -0.6614910679047703, 0.2892371311543967, 0.3552133753659774, -0.023139732222384583, -0.45665301165464967, 0.28518553956479664, 0.11371874467612951, -0.16951100387006318, -0.35713950319349375, 0.09099779803696799, 0.31591814722287487, -0.17916946522238045, 0.3239666590023972, 0.05575129590988461, 0.36953077127154843, -0.2776220884220146, -0.5427542813694501, 0.5258593661477314, 0.4672512172026519, 0.07892671927152628, -0.03922266815334534, -0.5090667051746812, 0.4401173416003086, -0.06770569710760539, -0.2388936186188513, 0.27587741784429215, 0.39812687433554356, 0.3327156588420149, 0.202768445116358, -0.1252480164978636, -0.40006375314385806, 0.20977233754541136, -0.4634554487620584, -0.3659644966109167, 0.06784510870664083, 0.113080356020064, -0.29501248402961466, -0.29159633916253236, -0.22607283848516146, 0.35233726758905226, 0.16728656460104072},
    {0.1857432739152783, 0.4309709246471898, 0.14641130804866673, -0.1762206215383872, 0.2540797983705138, 0.550387444046727, 0.07153306467043771, 0.13385739081042872, -0.10268409123692473, -0.16686092783429546, 0.05243292881295799, -0.12893589496687413, 0.4358554600747778, -0.15705813028497934, 0.5084811174018123, 0.09709309494835817, 0.31702535139273985, 0.11194770783630092, 0.1487354614407489, -0.14903891781676626, -0.34538827137498906, 0.5808399001536358, 0.14046365019090382, 0.1902573587605757, -0.20975543269311325, 0.325167354483686, 0.1830008368134558, -0.2649315601896441, 0.28928705364514734, 0.42158429740575964, -0.15869907668126784, -0.28022359088955034, 0.1775118490154681, -0.13923098493861122, -0.03341716405801882, -0.15270448992255414, -0.27266746288174076, -0.10889210012708656, 0.4146310499211245, 0.011774294496396148, 0.13486086355581994, -0.4068372827941334, -0.20188258499473175, -0.23347965347037528, 0.006429158034903794, 0.2455318819572784, -0.14123624523078623, -0.21423084165974657, 0.525262465926643, 0.29096584685080257, 0.0015400280288122537, 0.36495774367061373, 0.45838866075170237, 0.453631162316962, -0.3762706282198574, -0.45691836637186584, 0.17399123551896545, 0.14975710991680227, 0.2542948741747538, 0.04295884256537802, 0.24162292182402154, 0.24885365480302685, -0.4114171028164873, 0.05487948235238133},
    {-0.1872113609960663, 0.08631716012452795, -0.1226772565782158, -0.3331049454628544, -0.0652378453589953, -0.06265197191423547, -0.23015515895394614, 0.027960245533522513, 0.28577972173181804, -0.08723157405194268, -0.1412377464107295, 0.3010507795236189, -0.09570032292909561, -0.19474937277228851, -0.1103777932543982, -0.17093219335589485, -0.05735638643085599, 0.17847268910732159, 0.36223460122239876, -0.07249380024651063, 0.2217388278238768, -0.14840244346082673, 0.1995298757594189, 0.4741973140305959, -0.34252923385500655, 0.05612436235676955, 0.19140345672248196, -0.12227266275565465, -0.1761509874153473, 0.049685376183845414, -0.29141357579214683, 0.36137539223577014, 0.07530384307716702, 0.1615676346610153, 0.1233096283992295, -0.2279451174805706, 0.2663446479265948, 0.10645756426318026, 0.24774699215875962, 0.5140299328936908, 0.308672931995985, -0.16585056565528475, -0.15523072929560938, -0.4109409560176405, 0.08663059048561554, -0.014637427587244147, 0.06484638480143318, 0.01656850315494153, 0.4548381999337393, -0.12238393441026928, -0.07087194902016382, 0.2703399692229166, -0.17374425489492729, -0.31263517848068073, -0.09240218386574783, 0.019567970828746912, 0.2660166952803764, -0.0030123433166544355, 0.3692740683314636, -0.0815981530979986, -0.42998409509155483, 0.06494623294613543, -0.021128447572059863, -0.013707963462415816},
    {0.20047965136385018, -0.09935560835307065, 0.1305739647281984, 0.2298266584818644, -0.2775200102323089, 0.08407568813070794, 0.12986311738572523, 0.19280645064597865, -0.28153431912466775, -0.25370626984421135, -0.183015272149145, -0.30562768738287105, 0.19870930485876342, 0.17639611601111368, 0.08991269983688649, 0.38930878901689037, -0.15463088598120767, 0.06334147160138597, -0.13043244845752394, -0.3602829789346754, 0.33865260994687313, -0.26861134222581456, 0.2407628099956486, 0.04429732471390794, 0.2699148225305167, 0.2049300768424907, 0.10533148954919912, 0.2628944408726952, 0.359650698989489, -0.16032021551065354, 0.2754218244945692, -0.17622942143366943, 0.4552420075955936, -0.20763764166594192, -0.1684851293295458, 0.33577646158389723, 0.05006090416163362, 0.14099871450694115, -0.11333562582736799, 0.023256352553909405, 0.15672501576592268, 0.2289160000145861, 0.0685456827689608, 0.14041878302073763, -0.12471876065354538, -0.09883773104119158, 0.03497278468590308, 0.45257688334570945, -0.28948379977541133, 0.0296609200403416, 0.24286157962497198, 0.3310857397115897, -0.446058209526264, -0.32849802616290313, -0.09831944222953194, -0.3058899475183887, 0.03281984853846507, -0.20960295907325646, -0.2690536824214515, -0.07447515064222908, -0.27812223301052685, -0.36228585222911175, 0.24983528826020246, 0.05959103189851568},
    {0.27362207538091265, 0.19966175061190888, 0.08288293019984938, 0.2475749936991502, -0.34203004750136423, 0.3712496873244748, 0.25592024766396654, 0.16857403447638122, -0.21009438493835067, 0.2879324818541348, -0.38871426721616464, 0.23439821293996016, -0.1085390696204587, 0.24337127082255758, 0.09125560298861383, 0.29941104057109474, -0.09350687481568092, 0.10864411146927125, -0.3114745888768257, -0.2877559289426598, -0.0012701102942189377, 0.4582384952110954, 0.21928079313692458, -0.2813481457510957, 0.22110118609782986, -0.27215346521654765, -0.1553097722068983, -0.0882964552237486, 0.3247988230780129, -0.051101880528106124, 0.014722763484375815, -0.055299757299381795, 0.0469050667256797, -0.19833255641472214, 0.09462118850013711, 0.46623322585979926, -0.03683294927496922, 0.4193326235735425, -0.011594066261045997, -0.09169456552238836, -0.07006654097065551, 0.2046117857979791, 0.4442080009340373, 0.04755312056543782, -0.058690807405625545, -0.10045140721450034, 0.29865391973565747, 0.18505157049518592, -0.11767714185578525, -0.12342570531332908, -0.29748615579779497, 0.034972573367264, 0.05807826333836175, 0.3675915104199954, 0.02955392359017473, -0.12595348686471508, -0.07092957498016704, -0.25882897124118925, 0.14764465681865283, 0.10592970414491534, -0.329166941564104, -0.3982106012397608, 0.2913213393276549, -0.24589922269503828},
    {0.13849569737542128, 0.2115182557602702, -0.3513554085711927, -0.03128468267465641, -0.15505853114678309, 0.37243989211748163, 0.3389324963963697, 0.05540987511577498, 0.004851651511360384, -0.02272537361756791, 0.21988485594723195, 0.2595039276678222, 0.3447643970576416, -0.05583273959598042, 0.37699988218309305, -0.23918572977968205, -0.10553715044905018, -0.017188985331520367, -0.07670918167680152, -0.06420391458332964, -0.19720448879607871, 0.3617833078638851, -0.2732914135437034, -0.09599136713180569, -0.28354057209264955, 0.34057196506812437, -0.27720521762374667, 0.03778993995338685, 0.33110993485169454, -0.2686493356773186, 0.024029019782370896, -0.03778052981661942, -0.1576593220991619, -0.021018805464674738, 0.41752592478424666, 0.26034951501211223, 0.2513042678420778, 0.25505171640847474, 0.29072150120304024, 0.0916964232239528, 0.02290473778915758, -0.28905040762557666, 0.37444781071532834, 0.09985860526461177, 0.17743858218096734, 0.4871804945518616, 0.2002738849075265, 0.1486897739284288, -0.22140078727548923, 0.3791197006609118, -0.3646096968213608, 0.05041844535794779, 0.3995299924352658, 0.19603847724646845, 0.32062835591347544, 0.20656880982079867, -0.3800007427641993, -0.11642448153032435, -0.12878908991941818, 0.22608558324877717, -0.19088081190031675, 0.2763361151237567, -0.3389202073533729, 0.2927862837798467},
    {-0.27746922835664006, -0.15522843287568533, 0.010870157324630378, 0.18026073804290813, 0.42038137538468295, 0.10349277440287254, -0.4403209976034061, -0.2779507130499427, 0.13000354056505653, 0.32691740779256045, 0.1914600552664197, 0.07495088171387532, 0.21902474604895816, -0.044747298925819495, 0.12855422229959435, -0.08176262326380558, -0.018690541952847962, 0.07129073336614587, -0.39431173284927884, 0.32387569589341375, 0.07053375481830942, 0.16658784203168148, 0.08110878540083831, 0.014892519881104679, -0.2525923375324082, -0.0063997020316818925, 0.08907139926633742, -0.35410484628433386, 0.27802740491957445, -0.38253479376253163, -0.18090767632164206, -0.2955911981792552, 0.23298506569395355, -0.12153043951668963, 0.13050883432656235, -0.03222705090081779, 0.3310157773495345, -0.3435737515672681, 0.08998843477538275, -0.2843367095764425, 0.23225115128690385, -0.19781805702433794, 0.050437070453724246, -0.06363301069848032, -0.21603957260343548, 0.41422726170537805, 0.05337120434548164, 0.07626596361028108, -0.2656768594836399, 0.07532777301734127, -0.048905553027186396, -0.2300781542384592, 0.36785811866552237, 0.3598958485773332, -0.012248884806669228, 0.27220079897548066, -0.3644674863278528, 0.10215423003566314, 0.1800146208705168, -0.16859190797179116, 0.3984840476533509, 0.09560476690368921, -0.33278314104463746, 0.2218967436232121},
    {-0.3369109441710596, 0.09220004614930284, 0.14745314008920493, 0.11701011754686283, 0.26044105871641127, -0.029758786393955457, 0.27019577149552687, -0.4210422965367948, -0.10503995368401843, 0.12579835538053655, 0.36425715179886003, 0.18090902289778402, -0.09594870917500897, -0.3993665781428268, -0.34583293647468666, -0.16403805048881215, -0.33719376828179953, -0.08876492115669878, -0.01722387208308447, 0.07241062048232526, -0.3823177518583257, -0.3100441418321649, -0.31170996783195787, -0.318091037529982, 0.05062186242701516, -0.20261317766259346, 0.2968818565787643, -0.25145420590608825, -0.32379888236880033, -0.307127295045917, 0.1449847302453701, 0.21444389249344212, 0.1819303643473833, 0.2388862564455268, -0.3009377549327961, -0.04376120775056231, 0.3692422820384491, -0.2622628159845425, 0.30150606732003093, 0.2144416760298128, 0.18237914248001602, 0.0824094856130839, -0.4399381830793825, -0.425343077670241, -0.380431145410087, -0.030893735304411914, -0.2079127148076624, -0.0024477882309809178, -0.2622683039601368, 0.22159090400631937, -0.04905909942350321, 0.031946822348123655, 0.21434840291694465, 0.20652452566298699, 0.21965793906018896, 0.36507909751861134, 0.13004796551903808, -0.2539519688158981, -0.04270586021127394, -0.20407317713536147, -0.14637395573535072, 0.016093937958626972, 0.2784296161762013, 0.286496716760257},
    {0.3656318254645029, 0.15227520857274152, -0.10687186932051733, -0.3310068716127471, -0.31464511101503406, 0.1914915805087726, 0.15130231580552939, -0.11066743153036207, -0.3285332408288586, 0.1645219324877401, 0.358999494207839, 0.23662202912756436, 0.3545517271021958, -0.4450089028159277, -0.057394396601063026, -0.011524447627849713, -0.3973318175508608, -0.02109180967011439, 0.051069578057961015, 0.2124305784448138, -0.15520912252201297, -0.2777197951528571, 0.20195000157503765, 0.3678832131421699, 0.28906324848918075, 0.10226901826599023, -0.11138358283243266, -0.17672247169581976, -0.6009769028695005, 0.08247968643865873, -0.12571470777730198, 0.14608485027494597, -0.4857522514633996, -0.18636276634012744, -0.36189634103303164, -0.0175520156518712, -0.1433581379640367, -0.10281916764147787, -0.24328339432387916, 0.30157879260782067, -0.11343809704651708, 0.35156284075848776, -0.4265747116835386, 0.1790868291492609, -0.15769728810993455, -0.24405500690121062, -0.08154689135886649, 0.09375093827676076, 0.04284301750023214, 0.4155307945453482, -0.13227255509531805, -0.023102447743480616, 0.10841256856476703, 0.23415566287480682, -0.16360638308698291, -0.12818466745852486, 0.09375298174246947, 0.31217380887912605, -0.2200209222562935, -0.429062366999965, 0.07993706898766587, 0.45213970946657417, 0.43021505795812814, 0.2581718722874332},
    {0.2758608646673858, -0.23948369691824145, -0.43628519900908175, -0.31782428821432224, -0.28819428608690223, 0.0762266710826494, -0.004560275472697023, 0.20450221833590257, 0.24388764355668377, 0.22347795392342806, -0.11730545889145223, -0.3772073806580921, 0.3464129986520134, -0.08397771507083976, -0.09497600817385579, 0.07805482852860698, -0.3310849120369469, 0.0213965925815856, -0.19152851562664105, 0.051940339252608055, 0.10730460487255114, -0.1802757455600713, 0.1865977340582475, 0.22385850143965783, 0.3340078295321099, -0.1909871411566843, -0.0811209147615323, -0.41757911629525923, -0.5298068208100288, -0.08526188976212003, -0.22332355476041368, -0.29878908672360227, -0.12878598061956045, -0.207528067606385, 0.029744055752676586, 0.3395192763686761, 0.1681073648134557, 0.25898675692079376, -0.26245520582070386, 0.11881973254827013, -0.42139089675655, 0.0588248514638773, -0.06629386242141157, 0.1655344045065224, 0.03082016693874304, 0.2498097054737318, -0.2468800463097528, -0.015859458257948687, 0.35595880023744486, -0.1603950769080315, 0.24770496627754285, -0.08138230459809767, -0.1662345228257537, -0.18411003765467263, -0.0418930267692381, 0.3098806904440875, -0.24728752985891758, 0.20708603116337726, 0.21356986682965237, 0.007107898754214969, 0.14712843415049648, 0.10156733092495188, -0.35321288469164297, 0.03400567403755939},
    {-0.24045624942613436, 0.024525329079346958, -0.32212927107266237, -0.34665476911081466, -0.2472180183180959, 0.21274760628300463, -0.23136782803799022, -0.189307270217076, 0.42468303701515747, -0.3248331818454633, -0.15399100112426345, -0.27448917003700063, 0.2778739425085823, -0.25062778030974303, -0.1598378548160591, -0.16425108751477016, 0.12561122084105272, 0.008684779300937449, -0.09618393486935295, -0.20137573659361266, 0.023774603487588534, -0.2076236897161674, 0.18125431039415113, -0.09673226819315725, 0.4047276977019, 0.19716925357980605, -0.14736904738415488, -0.26497143978757065, -0.23460848903532708, 0.04158294942049504, 0.1699664901309485, 0.35810705477120985, -0.20300955807520824, -0.10893891339620423, -0.07264955078059823, 0.29639318619380933, 0.07953718817204701, 0.15247832329159774, -0.0790916319843612, -0.24947887451041947, 0.03144469855137361, -0.054207407183588456, 0.3206650561870378, -0.105665910925555, -0.20096861720415313, -0.03880457414740933, -0.09431726076673581, -0.3799894251788537, 0.12976543991675676, -0.04759397351265035, 0.4027178161185162, -0.01324096696404444, -0.10069592937515374, -0.16195777280805163, 0.1885587923153672, -0.02231225060531174, 0.18729582624597918, 0.3682257428120553, 0.40425722459753827, 0.2707927805229883, 0.003079314140534599, -0.19943375546624734, -0.3560821939798113, 0.16036309372183627},
    {-0.1411175926150575, -0.3569003053766244, -0.2666202661517976, -0.26094347609225627, 0.15203290178938908, -0.18847343613433568, 0.2264335410913594, -0.1961417912391558, -0.006573786538321976, -0.5137584104158857, 0.004988302902039675, 0.20324050186570233, 0.23065129482113603, -0.4851494966589972, 0.030837973454600962, -0.31281727957522937, -0.23006670215574127, -0.1746374283287664, -0.3151074074687141, -0.21733012598697202, 0.3174532396349967, -0.46435585195683604, -0.13942094406345126, -0.015054897260558931, -0.2976944000617218, -0.16034604052299256, 0.1101187399691451, 0.26115502991765016, 0.335844933067282, -0.3791956438506035, -0.3220847888314128, 0.18811897485601772, 0.3460469187838581, -0.27974866067805343, -0.30542177489175415, -0.19193785835379992, -0.1362636068890092, -0.39023386129773113, -0.33929653220459466, -0.15305202190502454, -0.4515675359699547, 0.06637636242027392, 0.1623746411684893, -0.18224302643404588, 0.2262486083005666, -0.2799046576698195, 0.3921228581512444, -0.05236295715730595, -0.037108723198448254, -0.126033724904285, 0.3009150925281392, -0.20630888521130034, 0.183749721637179, -0.1999746106154964, 0.043536139265675435, -0.23366095612948598, 0.17096741282344144, -0.2698645550277585, -0.21629560064946396, 0.001327789124013463, 0.14871653982562125, -0.3670238114313934, 0.20313650105499892, 0.13631729583333851},
    {0.42574994485875156, -0.2943006542338998, 0.2699513227465655, -0.17243020535135392, -0.21247675774616462, -0.20510463779024793, 0.22192179959070032, 0.10970719127747335, -0.338945287937467, -0.25150526306201826, -0.21300624788385505, -0.30238943451781325, -0.52032071166588, -0.4748075688126921, -0.2885788461481272, -0.31557624994348865, 0.17777830259631688, 0.08764609364149988, -0.40368924333138584, 0.15820635361891833, 0.17637108432360202, -0.3811730299450437, 0.10504615108600576, -0.3101866772637096, -0.06510970052802809, -0.08618758743547238, -0.1745517369551927, -0.13123273733955557, -0.013838888588880625, -0.17728424048734512, -0.27536340419535515, -0.10428207391389589, -0.12166249429635598, 0.3160449378641966, -0.22293304781099435, -0.060014873787778096, 0.12417534882524192, 0.0092594775645085, -0.227245954135172, 0.2440475036953126, -0.4721105949780265, 0.04959844538759542, 0.11867546372714055, 0.26918617555879654, 0.18416329955020994, 0.022805102219693882, 0.2519681785373538, 0.3945505021854475, -0.37314969448658275, 0.11505157312758811, 0.04012609622096477, 0.14461796896106546, -0.16609133101543255, -0.3912233057059521, 0.5035807643464998, -0.338112824667356, 0.038489408273519966, -0.23143267567132095, -0.053465143384552556, 0.026104138711036638, 0.38446974683532165, -0.4620521136588071, 0.0064577675264464235, -0.27892054591873794},
    {0.07109236629945795, -0.3632111933731331, 0.05716277194040548, -0.1818616527790591, 0.06823581127668746, 0.18750334290026197, -0.21261469255235868, -0.003367836193926539, -0.41771107077885716, 0.03699110183500002, -0.03522140646014577, -0.1588907280167973, -0.589441297133248, -0.015582391076938094, 0.25793440520764016, 0.12915680763926535, 0.002603543628486506, -0.07656484210672657, -0.175355251833967, -0.03804288553670445, -0.33201594818965213, 0.4391239198166472, -0.43159581058796204, -0.1262147699673985, -0.32586287125292196, -0.09018771845927417, 0.09757367137462145, 0.10865427976404973, -0.27807300455743106, 0.3108989341524861, 0.21539131744478562, 0.027097442153575207, 0.2104489167874471, 0.15763205787233792, 0.2778085077695021, -0.06343475937685494, -0.08424105484020836, 0.048227609881499364, 0.17128586214315836, 0.113297631027295, -0.06178116682297573, 0.2037333586606292, 0.22052970162757715, 0.24495865989352414, -0.363000308731093, 0.3420997539296601, -0.23162557409578127, -0.3826425655929597, -0.011604908852217856, -0.14256692808105267, 0.3241181951512024, 0.3292312768066509, -0.06922086343933441, 0.043999294537195026, 0.1946224975665401, -0.1791755046250589, -0.24153885547516307, 0.3004612705636955, -0.3795232754789382, 0.010954876789688121, 0.2614220383101661, 0.3180423438992823, 0.3710471285545976, -0.018704062370368542},
    {-0.30365629542481093, -0.3026546937149593, -0.201712919535499, 0.39017464877632874, 0.25533975604938597, 0.0746770124488362, 0.3777506701284495, 0.23627711840964458, -0.2678369044707297, -0.3793561254225956, 0.25097675663667096, 0.20491491091141914, -0.3453561869504955, 0.33007605646774274, 0.1865872792612503, 0.20342331653553178, 0.15628461970411436, -0.21371838034560733, 0.10218417469560233, -0.32277698446658815, -0.2269109357033262, -0.0563846271387135, -0.09660560719226888, -0.1332831872285364, 0.004983451944248971, -0.0005625143021626822, 0.12162644345935807, 0.04439044697330005, 0.061601299968703706, -0.03970864285015052, 0.5216102253357013, 0.16022344702285277, -0.43873117256127825, 0.02197838337530487, -0.15834400554544995, -0.19783893517671414, -0.0695119261052644, 0.14416850905741943, -0.27229519033398636, -0.02664844651110839, 0.1741924647644715, 0.29966745081201457, 0.2966159361686585, 0.06946449331045287, 0.11548222922784206, 0.1409017138533862, -0.27515785535235604, -0.346033502184405, -0.01925560225959728, 0.2977392168677561, -0.07729898853218278, 0.20531127835658936, -0.07198629318702973, -0.013284044369486214, -0.16213603317226943, -0.2749310439028785, 0.2835673662681139, -0.12720796052468464, -0.042259536737798864, 0.07618589258101371, 0.29142994131389377, 0.1486008827580321, -0.2892112384788516, 0.31224333014444045},
    {0.11984655962955715, 0.27975632798570194, -0.08221327934149644, 0.15264540242678282, 0.22376199818330525, 0.16118702517762992, 0.051964036017054384, -0.15223424377936728, 0.27314269029845967, 0.05036093827637863, 0.195271594716438, 0.12356528400516155, 0.4245395630851548, 0.36173099857421254, -0.24605100157636606, 0.41000524033864827, 0.2509293895492056, 0.3572426854104997, -0.4159208822456861, 0.15898334795741556, -0.1964925049626117, 0.30079689398376247, 0.1893412406396511, 0.13627681531297214, 0.3414077291532888, -0.0797907219879615, 0.22025620673779073, 0.32075116858985436, 0.20072926421309223, -0.11914078566086865, -0.02585214282939679, 0.10695139249296771, -0.41020545455904345, -0.13441118931100898, 0.2885430232473387, 0.17697310215820733, 0.286277230622043, 0.11555177420581514, 0.2382003834043499, -0.05157978419623609, 0.07891465659861517, 0.22575378322723913, 0.4356506481396955, -0.24746252211628067, -0.11777447756586218, -0.06257172800646814, -0.04272978823738985, 0.1586875722045778, -0.1285205000673136, -0.17259248471711547, -0.24274688026792593, 0.19186842291729625, -0.16236513144451173, -0.05265470439714738, -0.35675039971619804, 0.3130641652889056, 0.20816044679782927, -0.1906919697840481, -0.18715485812147004, -0.09141816076022918, -0.37534064818221363, -0.03489460514056311, -0.06978944244357238, 0.4340352028112275},
    {0.16118126768968297, 0.19050682520889395, 0.4569456722463023, 0.17372047588203976, 0.3117259300612338, 0.02643420398396171, -0.30159638806231986, 0.22654676865530157, 0.49611823771911967, 0.16788178955500763, -0.28138034259423145, 0.2534135950647889, 0.31928958955645054, -0.031603265881783624, -0.11230317996546395, -0.24161127068009502, 0.12310868544920865, 0.06421473380089175, -0.016816836225179828, 0.22145960795462574, 0.30827110509622824, -0.21332253297333229, 0.41880828245107127, 0.2447997891885212, -0.12891998975139077, -0.07114770637047231, -0.1681132025652524, 0.0011760956039678716, 0.2665545205722661, 0.4366287943095244, -0.1287049554264538, -0.3687985323309514, 0.45285029577750663, 0.11698718021953307, 0.4412909727705163, -0.0963109398795546, 0.2920792982027176, 0.36491806204516736, 0.3557949474494805, -0.007944818038198962, -0.15205081152185002, 0.06163321795391485, -0.0437174145200122, -0.11259174890736677, 0.4113572949746175, 0.11120793810047779, 0.303793870357449, -0.01164946334415774, 0.13053636262425541, -0.2068640875885209, -0.299379739930624, 0.2676882648446039, -0.31433093881332824, 0.2918950144067922, -0.3611671315234903, 0.052839596382466915, 0.14046548366146508, 0.08024704166204236, 0.18849301522818543, -0.17509186440421892, -0.5203251414284902, -0.23233952358523585, -0.1862371051363607, 0.3495180240008064},
    {-0.31999873706400905, 0.23374524190024495, 0.309919972291368, 0.17743096527609883, -0.1993043530454534, -0.08485875350727949, -0.294136308232432, 0.1077539452360069, 0.27424102169966086, -0.08700909965697995, -0.11429450151250752, 0.16743273259860406, -0.04348698715062606, 0.2522359767116671, 0.20957592223865046, -0.05632227726826106, -0.19188519595719594, -0.1245114671306612, 0.33686579968568986, -0.23843280059137095, 0.1573431637331825, -0.417343162549179, 0.004458582219820192, 0.1770415556791805, -0.22587266589901014, -0.030390526851076804, -0.2895883469591152, 0.2949317238557323, 0.42647777763344535, -0.10890272886834522, -0.31213644961384523, -0.16973653352272478, 0.28406186035282427, -0.12539267783263042, 0.2815937922661949, -0.02421416544023873, -0.012939746556421652, -0.39882368693463166, 0.1923161956350453, -0.2108018360470303, -0.09580137461511062, -0.03599028417684351, -0.3140990144018438, -0.22841854450248003, 0.3985240452987972, 0.2993884073514846, -0.2056077817206078, 0.1336996625185472, -0.2959206295267417, 0.06331576168665616, 0.23385110724919111, -0.15480056667472095, 0.06554827813220054, -0.044248680753102114, 0.3439921670666147, -0.36109575628717583, -0.13254243963188497, -0.43979510859584997, -0.15526245462632737, -0.3140256065323519, 0.06077980178377157, -0.048213061887206796, -0.026880166272153564, -0.2731741548761785},
    {-0.4306733140526926, 0.12577731037019746, 0.2847118190755505, 0.21341742544155345, -0.3450629592718234, -0.38009019839759534, -0.17910472649718528, -0.02976480094105317, -0.30123739278867195, 0.436341029624662, 0.40448097905179836, -0.0701547917649236, -0.07155978469161138, -0.02656129747216949, -0.15343692015841845, 0.07764712887054241, 0.19452317590758328, -0.14870724506076222, -0.05036076279301195, 0.1340969515164513, -0.3901389910893593, 0.07879254311643716, -0.30931464808216336, 0.13086772269298685, 0.19891472153615408, -0.23443193135389284, -0.3799087425640176, -0.13810790851433896, 0.37917853773607435, 0.096397681849041, -0.38374236399276734, 0.11464891275772927, -0.34857743521947154, -0.02734306579554291, -0.0769752660899629, -0.19893236180317997, 0.1793027439367016, -0.4596124701297692, 0.3710058775522508, -0.3060435249171458, -0.06695529130907624, -0.2000245134269643, 0.17124907997606637, -0.24996571854387165, 0.4765590227337913, 0.15185223029617442, 0.2044728538743222, -0.297156948145644, 0.31350629533026186, 0.06285419421828517, 0.21380611452599516, -0.06681566017522618, 0.3420150107170174, -0.22031345955535972, -0.3045476618035051, 0.3565667555479451, 0.27019307164611617, -0.005833641090946078, 0.34338747158442245, 0.3195432882036669, 0.2170345727917337, 0.25017019055781653, -0.17866538495141918, -0.2806104019868712},
    {-0.21406360613854758, -0.26049391089827373, 0.13577016402103362, -0.003151028857571603, -0.2813634182723476, -0.29202059630065325, 0.29788072720672926, 0.040716281702430135, 0.05013354159620014, 0.08960419750719474, -0.0753811772145998, 0.07356977944086938, 0.31061189176466675, 0.28017322011816603, -0.06216416353090317, 0.03819517887301332, -0.08923903981425585, 0.15866210264329964, 0.0544936266836386, 0.08208863665006998, -0.4049777190267449, 0.17763273581691208, 0.07233326020320892, -0.31264104233529605, 0.3569957737285911, 0.10465125216725706, -0.202653972066268, -0.3807540696680657, -0.19864378686257933, 0.046868858539598005, -0.4221384855112998, 0.20306319984603435, -0.2628779457452538, -0.3588131812309, 0.07235484975702962, -0.4439219718941987, -0.053481020702904176, -0.00922136322877644, 0.19188798419470948, -0.4323018118916132, 0.008604413868181933, 0.04066424340749155, -0.19521287106679375, -0.11933987354006576, -0.49814522500189307, 0.04388321283136326, 0.11888125628650872, -0.24070389749223883, -0.13989420543887826, -0.2332546385169909, 0.1918914440971818, 0.12013595000288264, -0.010552459118903606, -0.17954835987057668, -0.19406168278190247, 0.21634139188233367, 0.18090798184361292, 0.310323842936794, -0.279991388422448, -0.03973882235276461, 0.1712117947093087, 0.1210886908518829, 0.044383023905838995, -0.43577266869050474},
    {0.1768971782058585, 0.31700470157755833, 0.3234074675084352, -0.16298868291915888, -0.16613604398263662, -0.24484831309542288, 0.36524030802751833, -0.1889182220749065, 0.3549071959164841, -0.017677641641627943, 0.2787108617054682, -0.22251195874297128, 0.18659862912432063, -0.2346698753473917, -0.10013825169576235, -0.2616812087480571, -0.15677446982751186, -0.3696279228227979, -0.16286472742988406, 0.18807776805139015, -0.13208553029026207, -0.2800381352344037, -0.4024111072750447, -0.22453188290024872, -0.13294851437982488, -0.054710146929313176, -0.2240375042752995, -0.231007752656329, -0.0896714524709186, 0.37346809450999247, 0.20941328756771915, 0.0028876746357246207, 0.26274598163313556, -0.06920076711266143, 0.10550868550863433, 0.14352575422809247, 0.3095017906720786, -0.3071913654294401, -0.07958813834362095, -0.22994214419883682, 0.28405782204612934, 0.032596732015556885, 0.056766596374312965, 0.28901085469805965, -0.13431201562245337, -0.16047934125783545, -0.16306442468703117, 0.11550784473273198, -0.21667676800952043, 0.0875942818047499, -0.011395793592725923, -0.26667773972631525, 0.23187534936247228, -0.038809272709953005, 0.12859232463206763, 0.16136839671582892, 0.39668411353974914, 0.2965022786358164, -0.029959484594835842, 0.011390861723453997, 0.04176578045979492, -0.18666485442526184, 0.44974655466661734, -0.2938145938255081},
    {-0.011128994974005189, 0.07897650757103714, 0.22925176635216837, -0.20580677878643344, -0.1924095067976734, -0.14256365752433983, -0.32475711372648197, 0.0626996651763831, 0.3862056424070104, -0.20878027566362858, -0.3999702239611214, -0.20251965407065958, -0.09286289262684498, -0.13733386972098383, -0.2979148000650335, -0.3718892562813357, -0.32835608743612, 0.2689874296009485, 0.36748064732884245, 0.30824461992751817, -0.2918472836232705, 0.039816574580944154, -0.27632863297416577, 0.05265142660735397, 0.1765210199653482, -0.1349652232755615, 0.08504296068777646, 0.038967435360932626, 0.15831890586202177, -0.29400945269586826, -0.047327102461802745, -0.34524313225330155, 0.1264162580519032, 0.07073208774645473, -0.09077553171813688, 0.40893783848566756, 0.05875046012440879, -0.22363914924022651, -0.15004136534784074, -0.3692530280338919, 0.18341938250596349, -0.14860153451267474, -0.04318463610186453, 0.1851779699233572, -0.009288273947530418, 0.26218910347804997, -0.0019172373954565176, 0.09943743378361287, -0.19698833493314086, -0.3618660120880002, -0.26002877908714445, -0.10955302810269538, 0.42153731249809706, 0.3116171326144577, 0.1396545817091518, 0.35504150557198383, 0.38663121370586506, 0.12849494756016264, 0.23356091016901118, -0.39616334024057065, -0.2674529546763573, 0.1345157582614707, -0.003245249858994848, 0.05609263970049694},
    {-0.037849747977209545, -0.32273531414257606, -0.39593883811334524, 0.19726883301852552, 0.07990600778341164, -0.1967804925040945, -0.012300769260249304, -0.20501990371315829, -0.24151711035117443, -0.3320264123712928, 0.03272014276321071, -0.08531824808232927, 0.15675750148848175, -0.23829297653349796, 0.03615046524962682, -0.1422110046269605, -0.1798726566955722, 0.3385473536647438, 0.07141368281709068, 0.018725303231724482, 0.11554639320093017, 0.02029800217445893, 0.19706895106060437, -0.25135153632099294, 0.29470434905451137, 0.17528548459762736, 0.08512484058741399, 0.15392778334150117, -0.025108821776392974, -0.07257949401858999, 0.35457145241666793, 0.23431081652934282, 0.031281360342352446, -0.11483087798329748, 0.3505078255733986, 0.029324868320804668, -0.276519571346295, 0.3644658642004103, 0.05747374376497296, -0.06328169216144024, -0.4240541535771083, -0.26659529250786246, -0.37450267356289313, 0.047868037435111296, -0.13012814298854025, -0.23771205081103977, -0.15773181272220183, -0.47506999891104235, 0.29827568696352735, -0.16632037639378974, 0.30787914945378236, 0.20075633071303817, 0.17409148208897499, 0.06256360576880537, 0.00576241579278983, -0.10492343728771239, -0.36586212389455985, -0.24131775471259864, -0.30595867540387556, -0.038383910065892486, 0.17618120133183285, 0.192636618521774, 0.2282596879769646, 0.22827312490309187},
    {0.09918834842760486, -0.10187062709112973, 0.2705474255204539, 0.05309046399631329, 0.2614908922420701, 0.3669845449023043, -0.14168272009716762, -0.00723850737352528, 0.3453298557305797, -0.252665962891644, -0.27296399418395245, -0.22968698866812676, -0.31500271236870864, -0.3576798365050332, 0.3842096434599898, -0.34881241005605595, 0.3754955553247197, 0.41560060568511786, -0.19437857086153437, -0.171965440451445, 0.44262555736801656, 0.2840272213178559, 0.1395849786016468, 0.08929919892181545, 0.2221427480231293, -0.07042629404644248, 0.43080742847650644, 0.47495797571364917, 0.1248139972463279, -0.03646747742592126, 0.02523539463557274, 0.28608080013078235, 0.05998846425647169, -0.19898139798379572, 0.11998802770707834, -0.18387138843555684, -0.18711955926319143, -0.2104869184042314, -0.03093683995599531, 0.18564893809657285, 0.1788228698498933, 0.17113884164038737, 0.11022331892758, -0.02780343816453969, 0.3516556575675214, -0.1956275046796314, -0.23452559286743344, -0.3887236158934887, 0.3226555443097271, -0.2638362518821393, 0.3742140842378015, -0.030227697459285163, -0.07941801498731306, 0.3559817176004863, 0.00039509570435833857, -0.09004575301920124, 0.3156111130328115, -0.06627524818137692, 0.10974627550903004, -0.050050325126244806, 0.36510423506345924, -0.26611197438388146, -0.008594761135576617, 0.40302162793739427},
    {-0.017871779830264105, -0.1870324121597172, -0.32265142469360236, 0.16200480483337967, 0.26028224993035, 0.14052123934397212, 0.1531954398173138, -0.35872009784395187, -0.4420242997520497, 0.019076372512366758, -0.07678651780614788, 0.29979725648850386, -0.04691646024038468, -0.1607180136947875, 0.0018920014055643357, 0.016313063086435948, 0.17684897281439713, -0.11038689420142415, 0.12753624716419473, -0.013168465437676566, -0.013871278936639623, -0.3840185184379265, 0.0849924481654562, -0.3224652145294545, 0.2874995815491583, -0.09945391741278288, 0.27573159543103337, 0.16264521547556232, 0.0691532165222234, -0.3371431977398059, 0.30599809090846863, 0.22761156231690655, 0.17112844129451474, 0.29850570812318145, 0.020420883031750284, 0.3290540024513857, -0.18767901781152121, -0.08266717538664348, 0.023670684567266145, 0.26373941350688024, 0.3612952109619504, 0.12973128911099685, 0.16114997510327692, 0.15692241747561136, -0.058594758087523825, -0.05938017405257474, -0.23743966547898268, -0.04473394082791795, 0.2977276296225377, -0.3136578592914608, -0.23135297020126158, -0.20117115627544696, -0.0858533708148531, -0.01561909348977306, -0.3809195815793732, 0.34416149308668903, 0.23482312749140294, 0.30501290415076715, -0.19020811351330583, -0.26132035836363243, 0.3485125310271578, 0.03266977191250533, 0.1152004722297877, -0.35498621121337476},
    {0.3354874404086584, -0.05557654968851468, -0.37696386881222, 0.12479883590145986, -0.21776239975551936, -0.3024696962276449, -0.33012702617858625, 0.20866742122085305, -0.461351613635029, -0.09313252828695902, -0.17413392112865933, 0.13251598514901827, -0.1686518641229574, -0.0937975743433805, -0.12105048749661809, 0.2162037756236461, -0.06348860536169186, -0.34243114154353094, -0.14463384065665794, 0.23087404208506812, -0.18957218925212915, -0.1801438333691902, -0.07295254535907969, -0.23036884337267316, -0.16317311337672635, -0.2623678271014149, 0.07942500237290667, -0.2389240577804237, -0.4145441557239381, -0.22689412607494577, 0.20404206980077827, -0.01694725278614931, 0.02525408580467137, 0.32212296267854784, -0.16274060076433203, 0.28958761856813636, 0.3413651040530849, 0.3553495685157259, -0.11717702935211577, 0.47059413951059587, -0.023531819799863508, 0.083266889078563, -0.22124751807265264, -0.46064400243753256, -0.27984330955610764, -0.015338701942488738, -0.3031047871733107, 0.13031978523781518, 0.3973387606229726, 0.24631879500606194, -0.42013864226110026, 0.2295767592300578, 0.39167133981849345, -0.0015017032692775472, -0.08043197945412071, 0.19160522729816015, 0.11057406938731859, 0.1661234318847548, 0.028617896863835902, 0.009779856440467907, 0.31526209985358716, 0.4433080244950339, -0.4038231734351345, -0.2306508263544027},
    {0.1760628675158255, 0.1442527764613457, 0.04438016501383592, 0.22661424928475715, 0.1453204820204582, 0.0048136152033262936, -0.1946753094131934, -0.007269927780885108, -0.3167760979232646, 0.24012130128978304, -0.10344607915925645, 0.2099480283480382, 0.12713856310676175, 0.20575507034297458, -0.25384569404939594, 0.25839828393655156, 0.2502106380457157, -0.08080348908963, 0.11364156954058724, 0.2907647295216109, -0.23600316865605406, -0.17618362061002396, -0.006902449474330531, -0.0012072403079677965, -0.33884892055646004, -0.05534724822670199, 0.15537828710838042, -0.06398964038674158, 0.2801536478385477, -0.35477584606616036, -0.08892100926890935, 0.1445361899377858, -0.006275909181621524, -0.1698946550731552, -0.266930014383253, -0.37309341298531273, -0.00464283962180039, 0.17271318194509677, -0.35657822014162294, 0.21370757915381128, -0.23027981125809915, -0.3905051425507959, -0.1347883746180578, -0.1909006930843387, -0.0639418403722385, 0.19247412552649423, -0.29728239948018553, -0.11669242657958198, 0.09300889675705688, 0.37224877577655563, -0.021296255261024327, -0.0790108676865575, 0.48021048005486555, 0.1440982346970737, -0.06484900114914025, 0.020514148527432295, 0.19777096345377332, -0.37448431137403426, 0.3469808871711041, 0.24927389755650828, 0.30484690932974196, -0.25408908959103566, -0.4068727095955297, 0.14419472814688317},
    {-0.13691267572499397, 0.3772652875403068, 0.20594958829075327, 0.07595156225268966, 0.3188760404824579, -0.050544884392330174, 0.23828497210615662, 0.08343031003516133, -0.05260744350876263, 0.25192622236134676, 0.21385960149368075, 0.279712213285698, -0.3098292144092224, -0.09273866931170657, -0.06254036543051088, -0.4120744740820248, -0.20681200433556243, -0.20253231246191933, 0.14908517795275805, -0.01656896805426362, -0.3797607910272141, 0.3073392234959193, 0.2023660426460024, -0.24780027337766566, 0.05846860548454028, 0.1432939282636498, 0.21709195180040858, 0.026501604966864836, 0.287893848932112, 0.08445744790967016, -0.09422215381718953, 0.09658828683758802, -0.30820838884362556, 0.12352642399516586, -0.01823141856721876, -0.06619243143806343, 0.15307001336607845, -0.041730194638108835, -0.4952388320724079, -0.20622313791536934, 0.1455865503559798, 0.2080344998309689, 0.21214990913967985, -0.11608569698217032, 0.050688903067461856, -0.20750559272931132, 0.2779802824040057, 0.05064417584574722, -0.35215548248976025, -0.0504738556801139, -0.2616749379744597, -0.08579915189865968, -0.025476816920450642, 0.18518721580710876, -0.09796746419443532, -0.15235856744613277, -0.06476843463324043, -0.04036152679788057, -0.1974306463795789, -0.3710785381561113, -0.23309140134791526, -0.03802989711015965, 0.18542327165414904, 0.1283111016470365},
    {0.20691745533002825, 0.03772212221567683, 0.13319125056282277, 0.21590012644509154, 0.18247759094850974, 0.07690331814406634, -0.4722493480777272, -0.0823934421184638, -0.08237567063479145, 0.1417342774256664, 0.23412768639629292, -0.08429856995931038, -0.29977579107266766, 0.20796410773520194, -0.21041671722083805, 0.13574405889567148, -0.32826759502695135, -0.33112642570709994, -0.09175638328050578, 0.19940979488725585, -0.12026622492367267, 0.325860981234573, 0.08770547106068875, -0.12033018144760264, 0.38650916686833153, 0.024081850156985135, 0.3339795819706397, -0.05995365640621485, 0.2577964081571063, -0.2554715828863151, 0.3229717202795981, -0.475552013232918, -0.35508993455496246, 0.05493625671702906, -0.3397013006348514, -0.2563308367243605, -0.35511614790497587, 0.22644352232376075, -0.14648244163111285, 0.12045101687578764, -0.04721261096189321, -0.41486255424471385, -0.35201521700773264, -0.24877229622945227, 0.08921519701018864, -0.025791001090731222, 0.19098408422356014, 0.37747281378466235, 0.024184518928076326, -0.3709109344945814, 0.0351877253371755, 0.04846259568450601, -0.2093028761760382, 0.37608256585526056, -0.20773752338674495, -0.19335298445046703, -0.056100085933555206, 0.2764080003471552, 0.25409576127324246, -0.4142601391292276, -0.0708361891814573, -0.27694361264215395, -0.09964708467746634, -0.16473129706724726},
    {0.21783280055921175, 0.19356247333030285, 0.17592492552164313, 0.06055049066755915, -0.0967434383754913, 0.33295846006597546, -0.3139420917283973, -0.13126515835800248, 0.3208197502340248, 0.18905484695241118, 0.33725109155501387, 0.24371496894693057, 0.21479730492910287, 0.03345619790250226, 0.06570643653794908, 0.40339501841473874, 0.3937501470153397, 0.37652950518621425, -0.20094881876540793, 0.19830991738989415, -0.17972372783058663, 0.19244908748606113, -0.19265990854407497, -0.13705140055375928, 0.09514585269086763, -0.19579582229943082, -0.30542923800879346, -0.0848836241295784, 0.19645197744598525, -0.1844921574202682, 0.3991323443873087, 0.2549641138569006, 0.06540938056580849, 0.12829229440042347, -0.19705144173223124, -0.017488446858968477, -0.287242245710072, 0.31092635974696187, -0.02311777666580339, 0.11024111305919196, -0.11521116892724871, 0.10015459697709282, -0.15380604816839713, -0.19086729045900888, 0.032248425424083176, -0.2601480386262304, -0.3043577827472268, 0.2568659357652441, 0.16235866538394794, 0.027197677868335778, -0.08559421487459584, -0.10452679455138911, -0.08405197214174691, 0.06685371299107756, 0.17239076737484516, 0.33592415458688457, -0.0829127216112277, -0.170289481984798, 0.11366680984979588, 0.3566508783411573, 0.31746209520248664, -0.23926040233258236, -0.2663243792995141, -0.04687227779542211},
    {0.3866587931745541, 0.10966049745202017, -0.043800182477376624, 0.19576320385357257, -0.056365071890034465, -0.3669254434807423, -0.19142196568294706, 0.2073102042436484, 0.26397473742557875, -0.12792247217914213, 0.26815788278265307, 0.12139941719943673, 0.19253405791506695, -0.30321262080033407, -0.2584121770822113, -0.3664163424730084, -0.14409614616562944, -0.3963179279188929, -0.0035964520193148266, -0.025760227300194963, -0.05086755136567625, -0.39584453997415, -0.08345345917291193, -0.3214543180227022, -0.1428943922620834, -0.12590362564437338, -0.05360793528427695, -0.15556414120862153, -0.5044037000325239, 0.31758398090821843, -0.2493487223029555, -0.24978056809584262, 0.07484920600096776, 0.01577952766608041, 0.10882148746904037, -0.230966679881796, 0.14935685880442306, -0.295016180601748, -0.16881747808123448, -0.3341257052455504, -0.1011279842656496, 0.005732160874025735, -0.08931951141218289, 0.11590593085494097, -0.43299665779799346, -0.13709726018122545, -0.3559925919697799, -0.49907572467356126, 0.26241018384435955, 0.10344106186580398, 0.3493964262523018, -0.28413337712361586, -0.2720258106328079, 0.3094417797358429, -0.15711615759312816, 0.2061466794239773, -0.2441227201750811, 0.1930932390442534, 0.26928103929109376, -0.24707808896538966, -0.20576670891838283, -0.2802216611781259, 0.2977604669880009, -0.24715392467441},
    {-0.32235865914759415, -0.0987854669332269, -0.30385022751861634, 0.20667737818281734, 0.1370808753080561, -0.38829010746521414, -0.07188539715683297, -0.2309649723034761, -0.07990769846988509, 0.22622425934769352, -0.2547560468745761, 0.23915947306229973, -0.2885486302613607, -0.19290225563869728, 0.018101308177046412, -0.22226176319374832, 0.04102593525248892, -0.39251829285310114, -0.35466360711200556, 0.02307343322243926, 0.008254487927273213, 0.09573723536825711, -0.16346659493694318, -0.2865466853262166, 0.38158422642475376, -0.12134603464254455, -0.1669903827384186, -0.05577133944412434, -0.5210726327053029, -0.23148777889064903, -0.07665334723637574, 0.13366724882985698, -0.3001782497305592, 0.3482119519087564, -0.07687487219736037, -0.293211481678471, 0.0026278761308272973, -0.36190495905337766, 0.3078759383087135, 0.23205739385750782, -0.2601582973407016, 0.13681814705285333, -0.2967023165289694, 0.2884790098499377, 0.35576477737939033, 0.27379056292567744, 0.10683091451512036, -0.21004138754397617, -0.057573442324810556, -0.3538441046602847, 0.0051635352065751315, -0.31831403210694437, 0.19916358141172286, -0.20885043252381014, -0.4726882618377222, -0.15700147252317292, 0.30645285144794, 0.14474894326278057, -0.43638630513377913, 0.2815276545008057, -0.3750965037315341, -0.256657816598283, 0.3267314136021593, 0.03510819954392394},
    {-0.006333459909587417, 0.1289551861321837, -0.4260603667037802, 0.2301037680761998, -0.055183885025414624, 0.22842556130246713, 0.30253223217778413, -0.35454530629195297, -0.29851599746688295, -0.32937115550881, -0.6656353876280073, -0.2524817444305872, 0.3337503951038596, 0.146394999519738, -0.5553198376015471, -0.6389014657743943, -0.5464607864725421, -0.15195922868081493, -0.5108539005129493, -0.03621250360443422, -0.6713767573046933, -0.549578019661244, 0.04537080079976315, -0.501717643501455, 0.2974701901399914, -0.5962648612285174, 0.5325408762270321, -0.5386303935093685, -0.1458308108652575, 0.12472570045480871, 0.23694530738989777, -0.6173156767101619, -0.7462482933352138, -0.28026911761639567, -0.36703144012449845, 0.29270232256590106, -0.5219361921684808, 0.5753888529493882, -0.660761489499269, -0.8228599471620044, -0.72015665849305, 0.13014374980890175, -0.04177013459415322, 0.4353540601025149, -0.3072860420363554, 0.045846598531757585, -0.07740776314650258, -0.6310200389492574, -0.013376552888306917, 0.5042661217151949, -0.1427374380083636, 0.020141568602631985, 0.3003212430035442, 0.26839557209664355, -0.3155345119705394, -0.21808405642162967, 0.45832929235928666, 0.1636429565937576, -0.29396625357854, -0.4828128250667075, 0.19656755221790434, -0.3905461845889845, 0.526113926231776, -0.6740920105487862},
    {0.0688567998999689, 0.6683692533594378, -0.31715552234970573, 0.4213346357636089, 0.3750148398952782, 0.4116998937982868, -0.08035200834803531, -0.5010513607359474, 0.45463090379880255, -0.2993934815912543, -0.6937068810566477, -0.23199236152025932, 0.41409596327715026, 0.5389156351065604, 0.18298425182625316, -0.7865706081342637, -0.5202155382093427, -0.08381814619198232, 0.06397567574091963, -0.3330632724069082, -0.6824089256003686, -0.5997273443062321, 0.43262918942697015, -0.652071218250349, 0.34122486979558575, -0.21377636422683102, 0.5426590382941285, -0.538873011385444, 0.047812286654297716, 0.2882857041718092, 0.006783825616132153, -0.7019047760757536, -0.7382354799614752, 0.34666725722156255, -0.5912128630527147, 0.11292229881118, -0.0662565207790974, 0.5103528343815735, -0.48377374034984577, -0.5853052427752107, -0.4374351743392011, -0.19964931322724916, 0.5032539730401656, 0.33485973299852206, -0.2876577367523172, 0.4627339335063293, -0.3745350852315632, -0.4978967712386364, 0.35974873725484197, 0.6341188416751612, -0.014830839504829635, 0.16595674603512683, 0.37838911996982905, 0.3990584861612424, -0.28838321326976957, -0.15423110493869552, 0.47612845703650997, 0.653104196036741, 0.33637696874833445, -0.3780041308754383, 0.4305661201629965, 0.039210827082947625, 0.454752256248614, -0.20657249808921252},
    {0.10941099609510595, 0.04551598885888463, -0.5009813063106024, 0.04241563901142134, -0.08946588492142114, -0.08211904121483575, -0.036727885271005546, -0.5012912356613362, -0.03199302887475749, -0.2594331904644605, -0.6052490160164637, -0.4790295899383209, 0.3543292680660793, 0.07682570261324835, -0.4789429305957341, -0.4104984129154798, -0.25386796570843734, -0.05901675439515817, -0.5263495123995932, -0.03503600225215578, -0.2157210762497019, -0.4674666774448688, 0.09130253640388832, 0.3423449416425822, 0.48757357003594004, -0.020536088802544587, 0.3550289520745202, -0.3395855510085178, -0.6070211684724218, 0.08472482244485763, -0.08178409627886055, -0.7347905856020395, -0.3712712111784819, -0.2295824471396349, -0.4496127495291356, 0.18748189538227866, -0.6244166681345051, 0.5154055659781615, -0.6590801855752564, -0.6432367803721255, -0.6225358683203266, -0.01754758471822807, 0.0064041309251552875, 0.2775798140165564, 0.05834317063549971, 0.31274349049244815, -0.061647058272526686, -0.6080727902326992, -0.17775628711666352, 0.09726909710165722, -0.32907557333859855, -0.08710332298806851, -0.12847522899226824, -0.05899535781833938, -0.1403313986645336, -0.4190276492421759, 0.3011191564143441, 0.21154123945174805, -0.5801664288900428, -0.6572111748094062, -0.08671132430861085, -0.03854910034669019, 0.5507817963856292, -0.15536093556480376},
    {0.3074665237407633, -0.09486392143466992, -0.12698362011950476, -0.15109210103371093, -0.5153284515670963, 0.018237211514266518, 0.11769763757281664, -0.08727622738781127, -0.1439318721590955, -0.2113020318185405, -0.17220576394191062, -0.3118718134210494, -0.15920819725439042, -0.07068453574611328, -0.43469602223608705, -0.16885007846938802, -0.2893544984352211, -0.39585809380853254, -0.6391575116511502, -0.11124427340558239, -0.18958713292051207, -0.20916401473920024, -0.1974033032519809, -0.399175462635064, 0.040114606569931856, -0.31970286507455553, -0.15960031328709554, 0.022876508249045864, -0.33255692702643874, -0.5438585191233141, 0.45413990785324326, -0.4276472387387964, 0.06908934315285441, -0.18754083264015745, 0.0012303549911480442, 0.48573467984008223, -0.48403215998142196, 0.22798486362953466, -0.5990324489834209, -0.6754826030521011, -0.5023166883451206, 0.13310189272519238, -0.5051270226903862, -0.02999229549434556, -0.2021522366840847, 0.4928819594531298, -0.34197245518651087, -0.32991108430717964, 0.03888186035189557, 0.187463973683745, 0.0280912857666899, -0.33962047352498625, 0.13863214262269832, 0.401459711024255, 0.17135852154134076, -0.06012079359400026, 0.060018485267975374, -0.1018141210589415, -0.5431879319856544, -0.2919340821528595, 0.41130062131908546, -0.040708391181225496, 0.1993085823777809, -0.611510306432667},
    {-0.07050073368695249, 0.2229302617707596, -0.2955503331262926, 0.25829129683463303, -0.41975325049758855, 0.056234658736833254, -0.2246110661138577, -0.2716129210765078, -0.2504316560247519, -0.03738332880559402, 0.07535990000308031, -0.29397039611701586, 0.1787084717027503, 0.11830347448653401, -0.26533854815257907, 0.23697786110044705, -0.14244224778500922, -0.2012935007475326, -0.2739229409820866, -0.28876102408832044, -0.16558053325015754, 0.22038558934379662, 0.2708838666808695, 0.18202344555429847, 0.057752553866021544, -0.2580426884006723, 0.3426375280861649, -0.15932043865066278, -0.18584248282059046, -0.13169857008167682, 0.5841755498880424, -0.05433130403143168, 0.12899568327915487, 0.17617999497099288, -0.14240447674801832, 0.36467007596829026, -0.4700298086684193, 0.2842596365035397, -0.47960904858355446, -0.5733818747262293, -0.3102183558714279, -0.32504737394585603, 0.19044948502165554, 0.33806243594502844, -0.45342824044376145, 0.16502091873583621, 0.30410257059710427, -0.46828555140333383, 0.19908883014402698, -0.26674239718832105, 0.26322985956152195, 0.08242601358626504, -0.014987859328582468, -0.1364565934312033, 0.4685342330395389, -0.40477245240702503, 0.07477236488884903, 0.3884674999145372, -0.4941651361647266, -0.30460527494023565, -0.003849710893202519, -0.24891832939581438, 0.3666825371022748, -0.1281953578445799},
    {0.3912953339749074, 0.3138474953573066, -0.2279116216330471, 0.13875392307001877, -0.15633516829393254, -0.04726600203983501, -0.14220966812755217, -0.57191669864134, -0.4769042679287547, -0.07346490172708987, -0.455077577491011, 0.11333788349667369, -0.0890808044302748, -0.418226389664725, -0.33859680305261725, -0.13737327418801687, -0.49050645715634617, -0.5257814960674891, -0.6368673413465105, -0.0037958771528421877, -0.17840980067628512, -0.0940085518096799, -0.39566802338877943, -0.5564146125336534, 0.38468486024982257, -0.23851176042833777, 0.28793066349464935, -0.20449774306270652, -0.17638983005605294, -0.4623312127539764, -0.08799071171521099, -0.24757320503791583, -0.21308099788573287, 0.11634209107479883, 0.019269863416564847, 0.23156738077123537, -0.678660033748498, 0.08979504755579734, -0.7277926247231181, -0.6124265908368202, -0.16863697823123533, -0.08046228803282876, -0.07813048938560038, -0.5070159643390886, 0.10398496258317806, -0.14885780421796468, -0.35426068399395355, -0.4711188903120639, 0.037069197195544364, -0.23949851092346366, -0.4822963975243181, -0.35801688238581036, -0.07388906018481178, 0.28096046540552183, 0.25823140705252945, -0.6313717368610534, -0.18063690585984288, 0.09148922589986373, -0.23856575461440027, -0.43256411677645873, 0.1311316312636119, -0.5912772619411024, 0.4510609479897439, -0.6792157335646972},
    {-0.059399399173557944, -0.22256087180217443, 0.13440798135461, 0.33541420832095203, 0.11105911773662513, 0.15407567160788843, -0.16160813905720192, -0.39436587790810895, -0.17078729315245553, 0.05164505046229645, 0.34487570592802747, -0.07210352554330934, 0.6197097210103113, 0.4334673452856144, 0.17388720665964555, -0.242074593859651, 0.10911872264790543, -0.4089430583249194, -0.3541855603391292, 0.000575073870902287, -0.17078907177534072, -0.013654944646252394, -0.11186828012856648, -0.011830963033290905, 0.14752062449593203, 0.022180927988013466, -0.031827593037295314, -0.4764375183148283, -0.002304327446795811, 0.3960382849762786, 0.18559186988165605, -0.4553426922593218, 0.14597211739338012, 0.17156216995913393, -0.418140601553367, 0.17427303699417224, -0.3299420699669918, 0.2745350056432757, -0.1762366219400166, -0.3707601873015403, 0.10277540619434618, -0.29395497998778536, 0.09649444324655926, -0.28763291081340137, 0.0017889227096655254, -0.11814860296703933, 0.14655109369229052, -0.04503121801862746, 0.14674544024585068, -0.20339740019447344, 0.07679977148704413, 0.09689608011237917, 0.4045919777162177, -0.2224027735792955, -0.1857929652501536, 0.25116755284281833, -0.24878181026234236, 0.21560285262996964, 0.03074434450310975, 0.16579401852338446, -0.09558981844234658, -0.030899570222035627, -0.12273107867189574, 0.1552048966880349},
    {0.0323588906872597, -0.21204827213991898, 0.10838735565871563, 0.04302215584315798, -0.22196931845575926, 0.1537855977166933, 0.36386364344582267, -0.47202507599520455, 0.1204577647899996, 0.00022657607499408568, 0.21886865551505955, -0.08410351564653717, 0.14049283870671078, -0.07814106313624604, 0.2211466288001851, -0.011527046231628741, -0.3446406061466554, -0.034213913161738094, -0.07148528602258283, -0.4730204319707556, -0.10711941234886838, -0.3532534552149626, 0.006627083925198697, -0.3737187306201439, 0.4757586680390912, -0.20175452667821958, 0.19125351824429065, -0.1296877892437006, -0.4708084261367254, -0.5929694822111717, 0.11083278664675335, -0.6101220455691448, -0.10779862438760071, 0.13583258044244226, -0.370834042778797, 0.2917941425462592, 0.06633426769001037, -0.11909621287906495, -0.5045554867074918, -0.19812524234323461, -0.05115199044980469, -0.3768243130046159, -0.15275703417321662, -0.2698012871504323, 0.025848241554517537, 0.2822070730103185, 0.2253752021598575, 0.03160877141459565, 0.06029138051806154, 0.42453987056977893, -0.20098672828372338, 0.48201853772539366, 0.40733117488514925, -0.2599311074180168, 0.1826354289172335, -0.4994175682265123, 0.12083289402965659, 0.07996918469459886, -0.4438599644460839, 0.15736477826084277, -0.09279117188914514, -0.2632074660037056, -0.15083066552479618, -0.0806262573826637},
    {-0.3849911774941395, 0.15878565698616665, -0.16752510869472587, 0.13886129411859177, 0.22123044851192877, 0.07721326083782405, -0.19377887304791766, -0.600127659383402, -0.1613741166399601, -0.07524149026679527, -0.45951073736788645, 0.2815894279219208, -0.13546285742201183, 0.5410498121275067, 0.3765105743836819, -0.34819818698631827, -0.2815421347617116, 0.04818377449512892, 0.2671454954490745, -0.3590453168042003, -0.2701299703933907, -0.4955797439647728, 0.16404196213341968, -0.11718700645810139, 0.1869979750893788, 0.3500762804838692, 0.11252730434576505, -0.39605908734243817, 0.12465305386740047, 0.41508651121365925, 0.0696038729699926, -0.4102632638088444, -0.5861951047912543, -0.04560454844925185, -0.11877348865488913, 0.439013038280538, 0.18334166297034712, 0.4385002386728046, -0.12336789341365054, -0.2315040965030145, 0.10637262179696547, -0.07955329511211377, 0.11674162425016293, 0.3042525128777048, 0.32377612871911976, 0.6037307266439844, -0.05735694249882499, -0.2931567974317869, 0.16920515185687435, 0.3843509578859799, -0.43026847680279706, -0.03377395098147576, 0.4739580126824151, 0.2446096161468225, -0.2815487864493972, -0.12093775247820629, 0.23387975970471242, 0.40912730290951077, -0.3287920859263922, 0.04272065944302881, 0.5392921226099099, -0.20516951803435035, 0.42587975627557384, -0.4069131681164721},
    {0.12163460606561087, 0.2736003766053962, -0.32502752572467913, -0.2324139098330123, 0.3758706603687243, 0.3337243254975879, 0.08904896134838917, 0.0757602514327266, -0.16010565023043413, -0.11264768694223021, -0.18976029259699384, 0.38240598779210144, -0.04835565951766151, -0.33223316443987383, 0.1463808155169026, -0.49460649468919393, 0.058412405478916914, -0.35266447097789416, -0.3493539060620371, -0.05862542288357964, -0.3426370197816998, 0.17929245113722916, -0.35986718147881425, -0.22392715604456337, -0.2973740750314143, -0.2753838448915597, 0.018859101515455688, 0.020851674394564125, -0.2927712439644228, 0.015814332296758857, -0.4849997443540089, -0.21098521484627716, -0.629221645454755, 0.38955754337140197, 0.11108347379817823, -0.02549658430413785, 0.20871949492198325, -0.15887301799713932, -0.05379206337390146, -0.3718987542172558, -0.15243335520127524, 0.3342643609735935, 0.28278318308308564, 0.0027990380642752455, 0.4449994462210085, 0.036801617233116916, -0.15318088170012534, 0.15688105013285522, -0.3005386878566778, -0.1708022311801272, -0.3230390578893895, 0.2837050516387319, 0.1519012333826888, 0.05861822526681672, 0.3081214874612348, 0.40003697303044966, -0.23658310493301044, 0.36230088503164865, -0.5912440548971725, -0.25899262517998, 0.4148573136709785, -0.23697902191804712, 0.32881320554037147, -0.42437432143676757},
    {-0.4168911731583674, 0.28424426297444516, 0.048502607885213926, 0.257562624166047, -0.20429886800409308, 0.26460906917302207, -0.42253319778405074, 0.2517415600087854, 0.3337740526466186, -0.20660987729392977, 0.3481402708945217, -0.3113996462413195, -0.011466191239435817, -0.23382952449324157, -0.3463725158684225, -0.40714608093991267, -0.3674607860561012, -0.24936954103799816, -0.43932907466079274, -0.16564967779803572, -0.08156533438685246, -0.13777633221010602, -0.49963882584566405, 0.21834578879724642, -0.11050791340918811, -0.1316326142459525, 0.39882893304926825, -0.4262348626831561, -0.1740927047235232, -0.2974887229468557, 0.32652456372487815, -0.40803296638119213, -0.3564347138683945, -0.2143683130510899, 0.16839654162447187, 0.11566991308267595, -0.2526074343569979, -0.31760042169199904, -0.36270308073679947, 0.012904297360771857, -0.010977244323094713, -0.3627731431948718, 0.11953435559742054, 0.48729191241339964, -0.19808717296219, 0.3548933117515887, -0.3313253891366289, 0.054709536614713394, -0.32790986142112843, 0.14063156858377876, 0.4265282984802215, 0.04503837123921235, -0.17801840910871422, 0.18311761456261424, 0.3660760759718911, -0.17777815363529986, 0.11400682576861096, -0.2742635962896652, -0.25172300807076725, -0.07723968146773513, 0.4180977584402844, -0.29174927837579534, 0.04430539989186222, -0.4377111742720856},
    {0.5533796992887148, 0.5345304894785619, -0.2951214349455085, 0.017306688400024518, -0.3365877700020122, -0.1752928310260544, -0.06817881515432776, -0.08408361837044197, -0.36411921337383063, -0.13773731604912168, 0.21886527878855616, 0.4229153252364748, -0.3434920465200704, 0.0821548241351177, 0.09125169652308789, 0.5096800419215387, 0.23923630055775408, 0.006537622391395647, -0.4895850046021583, 0.04974634189846912, 0.03422161958904954, 0.045649095414787, -0.24501671418621085, -0.15428396994677065, -0.17822116080788492, -0.2493709370462737, 0.48233582992331403, 0.3890545049640724, 0.4696628413991419, 0.4033709627185917, 0.5527260143094815, -0.10366093795623335, 0.47410472967295286, -0.060765589022642, -0.078511389701448, 0.5164530498545278, 0.3160394037306723, -0.003496840728337508, 0.05238789871496322, -0.3849703790188278, -0.3818060783051999, 0.28501269324264156, -0.15506163602943634, -0.36546349245090715, -0.08760917280214882, -0.3439422587641346, -0.02249985031765722, -0.19684376302378528, 0.3204173769761184, -0.40218913575061, -0.25808395556354585, 0.04186232072982039, 0.30849522174578453, -0.051913355681443285, -0.13594653802595993, 0.22312870932644255, 0.26961548385512407, -0.4203717107556398, 0.1471681499680392, 0.1459297750651335, 0.04748540348070239, -0.3623195939015408, 0.38677089752936883, -0.32750815311398385},
    {0.33376051980390475, 0.3306630998286819, 0.22957084380301365, -0.22715837720028356, 0.2555384288987785, -0.1316142945086693, -0.41647784575611, -0.36104486439273964, 0.07413235186104378, 0.21556914929625892, -0.32812275332330687, 0.046012013263257365, 0.3332511931626468, 0.21138479101137733, -0.3755413072319089, -0.12587355103240663, 0.1593830004061875, 0.4145227748008286, -0.35770546039834833, 0.18563412207936333, 0.11613269874797298, 0.3593021592472899, -0.18100477283648828, -0.18038624465283967, 0.0903115680028312, -0.29765207162406976, 0.2938780075064947, -0.032757578077009436, 0.031245155226678645, -0.07378123801480917, -0.0790573133047609, -0.02083155946611571, -0.32177516303312337, 0.3797019292422255, -0.16256075640023454, 0.05131164802964361, -8.77035470769238e-05, 0.04781871235549469, -0.3407629038685052, -0.4610327494619603, 0.10593727884471067, -0.21483766993305403, 0.26648756273816726, 0.42035027618036286, -0.24494483635014988, 0.1495679440085446, -0.5138181295660427, 0.2154265070139736, -0.02312275321230523, 0.14389841747975202, -0.24227776928495495, 0.31257296071572654, 0.1202437354372632, -0.10938374429284851, 0.24964646240484006, -0.19235752389939564, -0.2932075520677771, 0.15489423702190044, -0.36134091814662656, -0.2872671755958995, -0.04678733731679424, -0.4347870316487334, -0.040415131702299746, -0.017751807320720115},
    {-0.6207478046400948, 0.21387339997788307, -0.5390139508730755, 0.25352578777218787, -0.12848177799584445, 0.195953528094318, 0.1640252115420829, -0.330500080838282, 0.20712809235693752, -0.541166206033529, -0.3934911094130212, 0.09089651606321533, -0.11660175229236809, -0.06995816977039872, -0.16946754801419203, 0.19702483410101157, -0.23488733343961235, -0.11660154491857418, 0.09069200366174597, -0.49535200051053235, 0.10866710448656221, -0.11202434919542223, 0.188129423728191, -0.15971274728039925, 0.10667166983455953, -0.3139000845752897, -0.1603537088753868, 0.05006380367866775, -0.03713230616261202, -0.35459733397271365, -0.2389279852872876, 0.2646456955575589, 0.4211652317286166, -0.38584541834884134, -0.14038617494513903, -0.09100655613347773, -0.14371018671149965, -0.04888206662454106, -0.2042625916462227, -0.5232200425189176, 0.19833886104539852, -0.11754830222184408, -0.3996390654023973, 0.06140916775307088, -0.5737221527944707, -0.573679958636432, 0.12004860459540401, -0.19661169767391493, -0.48246528938397015, 0.2783544664973278, 0.12468130724207471, 0.16894204775939492, -0.4423337912461665, -0.5103902889908563, -0.09467850542947163, -0.016916374562721864, -0.09286864467635644, -0.395034084981623, -0.2776486439690631, 0.2272915610529828, 0.2399153831999565, 0.14910781247729568, -0.4448439437617483, 0.17451313539577928},
    {0.1286897897261322, 0.24145812976683173, -0.2284486376315098, -0.3888156861613527, 0.018576338590434994, 0.01544586942963058, -0.0671621668010942, -0.1862802837543281, 0.14068071664617754, 0.019681256724150855, -0.3851575051641029, 0.42138204039656146, 0.5511717237580989, 0.12277750862398401, 0.30215336882488336, -0.3953239301628097, -0.04993345838069216, 0.47608061169024396, -0.019110443286202716, -0.27759373754986627, 0.3617178950063708, -0.3019486133439495, 0.3950462770685992, 0.2302786532988543, 0.1152739588149548, 0.08529966126956226, 0.35739908924155717, -0.24066090265093137, 0.004879335325427789, 0.09232601551890775, -0.00819806162332272, -0.4205157425444916, -0.13397535535637403, 0.07523620859364381, 0.14892340857583544, 0.24951676766711606, 0.43513268269855776, -0.21211103815908963, 0.18235058982786856, 0.3262026746074951, 0.47926557429146655, 0.39199556571910377, 0.05563643197849429, -0.429173473511469, 0.03219417778161226, 0.4835313550894052, -0.17712041998624542, 0.16494436374658097, -0.03178697782413153, -0.07412790164962652, 0.016428731552252968, 0.0978315201615442, 0.5049903921652826, -0.07614500813170426, -0.26440897949338105, -0.2385202911863339, 0.18083357487502122, -0.18217529689142245, -0.22351926334294414, -0.3283456327225251, -0.3845501690113969, 0.29148347586898254, -0.14471508411307052, 0.0029974429226704517},
    {0.2559543857161451, 0.258947705591246, 0.1431048778248828, 0.16037350601565223, -0.3785977651058254, -0.2305656249823526, -0.4843760054659812, -0.4411161693341102, 0.071518349788504, -0.2190294483516487, 0.06642172987837712, -0.21041303353579455, 0.3638041481263237, 0.08305298126174762, -0.05403783352941022, -0.17069383669430607, -0.15331688443610514, 0.44429040072305215, -0.253070157913708, -0.23875224670605769, -0.11643764225598009, -0.37067923805188685, -0.3275284765435179, -0.166611518140089, -0.15658483813247576, 0.1332990065818276, -0.08098968761325558, 0.07314024993385873, 0.3281312250904937, -0.5277178930823895, -0.43855885576913584, -0.42327711879781543, -0.48034686571341745, 0.5307666926930308, -0.5187264174450742, -0.25548084327531095, -0.3758867810295267, 0.14903357251110994, -0.15244830988335334, -0.05851850926990235, -0.15147916558184313, -0.46104579412962615, 0.14743795707580523, -0.2093825306894211, 0.25487658838658406, 0.23940580012953053, -0.5503044230661611, -0.2749528104042624, 0.15043600637865864, 0.41200421963743294, 0.19711253431566667, -0.08626573952475282, 0.551441582264221, 0.3135538909741633, -0.2982601209540122, -0.011565541248015992, -0.11478920347506365, 0.2399387309731792, 0.02834078007162653, -0.059822820960983875, 0.15841060124254733, 0.17390898212508735, 0.11401052670746703, 0.2618063957188908},
    {-0.28826362883073936, 0.41733688824575144, 0.20535986788828461, 0.08545659443380414, -0.049670315366769274, 0.014514202594621155, -0.3299343002790744, -0.16381688270352748, -0.09356934721754637, -0.2958659619715478, -0.23091685492915195, -0.1917155184849893, -0.2243254951258574, -0.04052921112341031, -0.20200178709966035, -0.5090686687422084, 0.13057710368718553, 0.26782807310041645, 0.17673119099982468, 0.1180695954663796, 0.1899420005291837, -0.42248246998017913, -0.035615000998622165, 0.22472506417055702, -0.24692725589997608, -0.4339089311536069, 0.4709806033476728, 0.04448438014568146, -0.08074473461184636, 0.524695577183312, -0.06344200999646228, -0.1364293866657221, -0.0004677598204604659, -0.10595087850087868, 0.0971040144553837, 0.08944693872198684, -0.20463545221867016, 0.3900578605656857, 0.17099876863814212, 0.0016685538411677892, 0.23113679297292028, -0.02730960700085345, 0.02948304075229288, 0.09083645559135795, -0.531886002157624, -0.2763976907371848, -0.2945733316797061, -0.2806748263504955, 0.21869687609776595, 0.32166485010050155, 0.4012003065400431, 0.167421835592089, -0.2971998905519735, -0.45455428024752764, -0.5602903759789205, -0.3576968257573458, 0.15422982970187057, 0.548409396371852, -0.09402221967099117, -0.004116640089819859, 0.47613939129397653, 0.22120718358570127, 0.4743958241149935, -0.19133761586384407},
    {-0.23376590492404534, 0.004920127987504346, -0.36531894545568117, -0.13735903616162848, -0.44483552813733335, -0.311224879790582, 0.08890450974800906, 0.2225478944642938, 0.07821655835690311, -0.3919647352153482, -0.11782203195253038, -0.2916714322489458, -0.485953712615693, 0.17205642947112895, -0.14216030683968264, -0.18405653103964192, -0.21696301420257993, -0.17722243891955478, -0.28547501407291875, -0.005934184734148795, 0.31459437575532856, -0.5257388691011958, 0.1767738246731914, -0.25158094780017465, 0.3570420004428495, -0.09055612884386989, 0.05102760989058064, -0.3157713770836999, 0.14802874477036915, 0.3043790938132725, -0.3030312698763993, -0.004438124892805109, -0.0782951541632576, 0.11195936135258537, 0.09200825689348782, 0.23792919842903257, 0.3001082916694486, -0.015373797512824814, -0.40360658929263094, -0.10915509637154475, 0.38003911159721027, -0.2506119911791652, -0.01767765974619329, -0.16311859152222807, -0.5117727595207351, -0.28785382829714395, -0.5549123887362908, -0.28492631403070884, 0.11518210249376791, -0.14562072403759196, 0.2504709421006987, -0.5830777037843332, 0.06884086793713572, 0.12344161518892674, 0.407205234398125, 0.4359970119708705, -0.21719999921752967, -0.05672607350410238, -0.08270821816845783, -0.4854853045451918, -0.046208684860264, 0.20036647220958448, -0.3113803437006122, -0.13619709748341005},
    {0.38156776497689987, 0.3925794514793445, 0.19998115778582215, -0.1030800531516432, -0.1752141646062126, -0.5254631451461869, 0.11112849187214591, -0.17481553699688906, -0.45437495739937594, 0.060317837581749995, -0.3628827686514527, 0.03440305307918282, 0.3410594834237462, -0.3815823582966223, -0.17745522978830094, 0.3516756826223291, 0.27505450331030057, -0.2486241637202767, -0.5335954696844106, 0.38990130045559973, 0.5333622540383107, -0.31409630327935495, -0.26354097915960056, 0.3147351989596774, -0.3454690987103558, -0.016782296645838506, -0.5277712738726589, -0.17116099972137494, 0.4052586987373835, -0.25547958098836, -0.038677174906812245, -0.31841747619001015, 0.266043351843777, -0.37730147895795046, 0.03145563659345798, -0.43477718164957646, -0.45721294074726027, -0.5316117013093514, -0.40537716161421233, -0.15442230420201478, 0.1664200842177831, 0.10759978482382539, -0.37312388856051293, -0.027624487188198557, -0.44252275722000356, 0.18419701842173652, -0.009595204385673396, -0.15498069272847947, -0.37754764359641196, -0.28623319348600046, 0.14289055427624378, -0.40998582714901366, -0.15733397694764015, -0.10646527571118283, 0.011826695224930397, 0.2745590018662437, -0.25129595257018594, -0.026796631495491056, -0.309306492275885, 0.14315380034798023, 0.36030247364984935, 0.39720391656904025, 0.087285575775572, -0.27301485833878447},
    {-0.08820662827922986, 0.26397610987811687, 0.11795437345052066, 0.04168600490383628, -0.06577306209439329, -0.027856367264479244, -0.6819939892576143, -0.16502635522703313, -0.1345496945430688, 0.38959575476716146, -0.19165333577080723, -0.4025563357682679, -0.4168323460503674, -0.18343584809827654, 0.030894470986173612, -0.33581854104023373, -0.33889021728658497, -0.2549131495453468, 0.07961873421273927, -0.4162151752039461, 0.26217794491421104, -0.173405057934577, 0.1974425505925486, -0.12742647330456636, -0.13015714920199972, -0.43010565518086186, 0.37478797062264074, 0.1062722290945597, 0.2825625059536288, 0.025581184173323467, -0.47153612154556385, -0.39247484829569573, -0.46487771042756015, 0.014588011116107078, -0.15949728126277102, 0.18843621328481372, 0.21894385475792127, 0.26393210877220635, 0.17636211577102567, -0.488506180352883, -0.31131004307588994, 0.0702190193444772, -0.13156961650514218, 0.027772165599224644, 0.16112542081406794, 0.34719622602479605, -0.5795246780872774, -0.3768403790031201, -0.2500592731415264, -0.2516755286286912, 0.13608433258737776, -0.30372424609697085, -0.1022172047746547, 0.31397244954649856, 0.23575727580942457, 0.44573005327025944, -0.4051278462686367, 0.2588564840458591, 0.23828705198496838, 0.0829532311186425, 0.3272498591268686, -0.4585885142386573, 0.436084240830523, 0.0039782722009613835},
    {0.03354392209354752, -0.3871953696839589, 0.03831876154312833, -0.38044689413626487, -0.28795941556790816, 0.0011188899479138083, -0.6494964575822937, 0.18211256224460612, 0.3232899256377639, -0.3827701021054961, 0.14653543489708212, -0.13392432488706174, 0.015922198951691984, -0.21900981204014341, -0.5799256370797976, 0.0054439945458774975, -0.06914101186486771, 0.07846662884733467, 0.20170696036630686, 0.19511752705000035, -0.23409167998692199, 0.2270810827323283, -0.10838996171810343, 0.38389438997372577, 0.18716025242423337, -0.10374823734172288, -0.19893731706158568, 0.015228406665647478, -0.03237148018860543, 0.06720789511364966, 0.013257247449702842, -0.424772805487583, 0.1448413418006511, 0.15463268982765696, -0.07627178903786248, 0.1576598589683896, -0.09390936145467971, -0.23008600165292376, 0.11344020216661602, -0.32398593623995264, 0.19799690400294617, -0.338315802605046, -0.39781829998916657, -0.5551247767958658, -0.4252130128249197, 0.45082115737895095, -0.4930636898175363, -0.20330768797962845, -0.04657817250723012, -0.5573951563267097, 0.06170696214562937, -0.5713477442878869, -0.40917679478849783, 0.06788735561979146, 0.13731162927314544, 0.20077719658472165, -0.07402156623633387, 0.15157533097171322, 0.18044116458771167, -0.15991078216033372, -0.19357357062998265, 0.16431690395058968, 0.03422866384867444, -0.46651668249554135},
    {0.47574655128545384, -0.20255626539328644, 0.10300314096000533, -0.41202225429559985, 0.4559732158467411, -0.24402868079458964, 0.016390234715599507, 0.37958770492843597, 0.5670065164250166, 0.15608132759239723, -0.4390554205385255, 0.26216391632084934, 0.2929206131341571, 0.08094120808885473, 0.16583989452465578, 0.3582654833473276, 0.21455470869011056, -0.10648734409645237, -0.010546465337303105, 0.2878253018902156, 0.22376349395785805, 0.10613824844411893, -0.34846766849276195, -0.2355968757564312, -0.03938102724569599, 0.356108075890235, -0.061596306198891136, 0.2676289308336167, 0.09774111978434291, 0.08209673147783651, -0.35570298862126326, -0.28408726958196173, -0.07974560462888232, 0.13012320512830344, 0.39330071406607275, -0.13115673392921737, 0.5174221229329142, 0.03771351584700693, 0.037828751573611326, 0.07229654694520565, 0.03505962036094902, 0.302341116658958, 0.15080677995867925, 0.2677426038332203, 0.26136948947414457, 0.048106589145607476, -0.10789557814417147, 0.2298720604797955, -0.21182177555027265, -0.2905092959640612, -0.2909128700799516, 0.30591398583472673, -0.32066549514454507, 0.10811154527763271, 0.017586790892625926, 0.41553860471885234, -0.03266128073794046, -0.2489267775208445, 0.19737282525672448, -0.03983764238414519, -0.054610975393279165, 0.2429805933098314, 0.27132795397224646, -0.18964186250148332},
    {-0.21591412008605065, 0.14186471833837141, 0.11087840374583466, -0.38525357178560227, -0.17201597269553104, -0.2428372271521631, -0.4784322333209153, 0.17743413109098655, -0.32956968517573976, -0.21855870709718916, -0.4158769008295602, 0.33622758457196134, 0.33668698367031435, 0.3055849246562544, -0.45736434466237913, -0.3443511183023909, -0.28577740716732497, 0.24091994584432888, -0.03984619790970615, 0.28039246951256475, -0.21962359857533043, 0.12880405598401318, -0.3084635693879766, -0.03478116283246305, 0.4180607178313588, 0.14470967391273612, 0.13065424681472526, 0.01837971028601332, 0.05261750824100749, -0.14686906524650659, 0.13533323991305427, -0.37539763234611395, 0.06904400229793745, 0.006338720211730887, -0.45303222659795367, 0.12707890359694418, 0.22607387403036588, 0.19557464074866093, 0.08606936168180664, 0.2427489392356218, 0.2741361405152387, 0.2930937203387369, 0.04660485144499145, 0.07554334009917711, -0.17054329851249236, -0.2745710063151455, 0.2036997961214059, -0.17306804472732915, -0.05392574181150195, -0.13840530966645181, 0.40074245726915675, 0.16845306970682034, -0.2404368330214817, -0.04109165753363442, -0.2360292288407344, -0.15781574960025105, 0.31098398925058907, -0.06966745863536537, 0.09380662815122981, 0.0635566390542728, -0.16138597508533806, 0.06138241245927149, -0.4049082825435652, -0.03476427755891432},
    {-0.12910611294281574, 0.11295018328213528, -0.24248638297583003, -0.35305785548676943, 0.00539059914824222, -0.18895317120284352, -0.3428454248665129, -0.18746327937307547, -0.09921720477960316, -0.14931121694130198, 0.07709574723783502, 0.32224099453447064, -0.2116300202658951, -0.07501358145650004, -0.43458164607395555, -0.24123883956467332, -0.14667054319439243, 0.43297776761430923, 0.07283142312668031, 0.15180208612323134, 0.1211711401223284, -0.3284934360535505, -0.30966549267145793, 0.1669927203900598, 0.11632492081635411, -0.46133925523179153, -0.49029891015531313, -0.2749450673143819, -0.3872756472180822, 0.020263708990759036, 0.26966346280175474, -0.1808449684963112, -0.07235939521704375, 0.0005780976818350245, -0.3281673753882697, 0.12383165084628125, -0.2550043892294836, -0.017247718189509095, 0.19586893849635167, -0.4445963914119217, 0.11455437402416707, 0.23134143271561897, 0.35105052825688343, 0.154119744109354, -0.1685866859830549, 0.16571480443368616, -0.48192638601491844, -0.2374202561890578, -0.14905751022663508, 0.048586715871712594, -0.32659734999237977, -0.08256739399781995, -0.035373526707260815, -0.1864412127567569, 0.13641059635680086, 0.44427861632673005, -0.043050582663750156, -0.5184233361719853, 0.18068464975630627, 0.1924736551421363, 0.4199830230635678, -0.12155445817108107, 0.27347951256465075, -0.1097547444398483},
    {0.19664938032195153, -0.04561718185131556, -0.29005628803707534, 0.09509695388368944, -0.08010812254550355, 0.22471541990179586, -0.030923515812645033, -0.07115908352354189, 0.5317892359606956, 0.3682866785180683, -0.582015900668857, -0.2863581942819652, 0.1579682998737072, -0.09616799871341229, -0.2607065118684854, 0.13522969249423403, -0.24349439151887337, -0.4152983753241282, 0.05204197710427473, -0.05668838493953861, 0.0762264105786715, -0.5876321609389769, 0.13239328850685592, 0.018479526936300835, 0.21020511204933204, -0.09538238336291024, 0.3282025739763543, 0.2923107450725478, -0.2083762428086525, -0.26976015773574774, 0.1366328671293058, -0.4395300758874897, -0.4076260319887401, -0.40088189466856466, 0.2939533032381721, -0.3799128664546642, 0.1080183772238378, 0.12112478613594156, 0.2541092268900367, -0.31660210660637683, -0.1017751673822612, 0.07404922151415388, 0.2728464624520989, 0.42167834797391285, 0.11596222759300188, 0.11050789573347915, -0.5218374513532248, -0.40511435458251155, 0.03172775700800793, -0.21905903156189022, -0.3068711819236415, -0.19265613846326873, -0.24385811921572087, -0.15630162637042222, 0.24089062034627823, 0.1615344613194472, -0.3225249935534809, 0.04140209508750388, 0.29643323658058573, -0.49545234597162036, -0.11699721269144725, -0.5558022100694255, -0.046677165043399825, -0.3978686119161633},
    {-0.13979485233564204, 0.0928474253083853, -0.07763069579599353, 0.10218880303686038, -0.10442239012001675, 0.13148027672073218, 0.0048154981477215916, 0.0058494755187280525, -0.0892552417164094, 0.1942504875689962, -0.2539833909153882, 0.020413442780953563, -0.30029016421050914, 0.32922534158913447, 0.2419256474292242, -0.03720474427916253, -0.05934817926461745, -0.1285389218999268, 0.22080247539362405, -0.23819904867279496, 0.2930528505228472, 0.2949702099020582, -0.22930301555215465, -0.18799764751899387, 0.08078051761537784, -0.3527385411747782, -0.32237329127931663, 0.22104434928322897, 0.21609246486216419, -0.18106194680372512, 0.25282690017996473, 0.14205017647314278, -0.3479723757784845, 0.35875281530600994, 0.09259229955041151, -0.05939895946983816, 0.18323638159474384, 0.5385299846295127, 0.19565974143286138, -0.3776085034426275, -0.21506066964145396, 0.3999000019538442, 0.24294112148225194, -0.042931872784481656, -0.5182445663452424, -0.2357181371644211, -0.04690572156039671, -0.51237035086106, -0.3112344671352809, 0.3890160535396724, 0.48709229465683834, 0.16562968461220973, 0.13772985271783153, 0.3266533428320516, -0.3620355023835171, 0.17050126268766305, -0.2073996820408581, -0.17465321087795244, 0.23551305912701964, -0.2539555193168018, 0.3332122535414752, -0.11854843321186825, -0.17021347515985646, -0.202214233346181},
    {0.4626133948098454, 0.4569103560056641, -0.34787045345756124, -0.1472904412934863, 0.16232342409732858, 0.30292309418864266, -0.4474565053025569, -0.2977895498721471, 0.09199939709054754, -0.3442623362318857, -0.4546150154966941, -0.15904038553550248, -0.10974983919884151, -0.007273745322480969, -0.41879445597922926, -0.48897990892203963, -0.13824750251846413, -0.4394698644712468, -0.23079630582967334, 0.026367772406574824, 0.19902274586292587, -0.42990354370527506, -0.06944210835936768, -0.04553061647633288, 0.18400748495701524, -0.06113372018041419, 0.024811801998085414, -0.38536237455476297, 0.04678541460707623, 0.38446036435605274, 0.17492665947065233, 0.052153241608395635, 0.3473228789878792, -0.19903508085062946, -0.44325291991805826, 0.5496047715447628, -0.08285224240830519, -0.214198917050413, -0.4535160543090151, -0.168294767288125, -0.39994698115510124, -0.19248398064750913, -0.24061877514672575, -0.37655385561161153, -0.2850078132428238, -0.29606833109752323, -0.5949665283702941, -0.4294297014172494, 0.13798269105533312, 0.13703034859039864, -0.16608716564409653, -0.13958323560222433, -0.2912846752452678, 0.3171512539160082, 0.31307803801270684, 0.2934189827750308, 0.11750862367777179, 0.3110199215891124, -0.026966491898395274, -0.20083979647722622, 0.3837204794608182, -0.1697414299010361, -0.1889925571057471, -0.39726426514540875},
    {0.1806411490237054, 0.5153393118717983, -0.44538009788681937, 0.11823323796469362, 0.186312445546951, 0.371353869382081, -0.27734776236240666, -0.15557538878863, 0.09704121231974099, -0.4787356003239128, -0.38966355266314284, -0.14439613472454782, -0.27371706333198, -0.10025316176723138, -0.2879455330122132, -0.14152502453107796, -0.24023168829184444, 0.4097961173231883, -0.09732678405761916, -0.043937138199876276, -0.1854900507863023, -0.35538884119585334, -0.2938441463335445, -0.5583804612405031, 0.06370810179184754, -0.2275383274935018, -0.007260371821311401, -0.45115216789359674, 0.29827160076162595, 0.37507775545407124, 0.07896941039532022, -0.2043253330311127, 0.14023699046775698, 0.5573740487715765, 0.22438012514691633, 0.032102733085403276, 0.04601369687256376, -0.06709593803107225, 0.28811938513588164, -0.17891006910830637, -0.2775960701755728, 0.0008137955697087338, 0.07283020814158898, -0.2525047343613768, -0.3045920718165514, 0.14214272755972884, -0.24323559369416617, 0.12400054511250415, 0.24812247286261951, -0.38674291920760884, -0.29274407584989653, -0.1820981449733402, -0.1844620840888289, -0.1932168497414545, 0.2862416154386035, 0.23790909987612271, 0.20497270621092975, 0.02563122032863909, 0.0677432351305233, 0.0859540826432031, 0.5000976276138731, 0.06434644901271334, -0.13085969815745271, -0.30270046844736576},
    {0.33512022609087333, 0.07935237311510239, -0.09240985015789943, 0.381159981086831, -0.1815967940923533, 0.27523206823437696, -0.0019941144740128107, -0.1461422512939616, 0.08490620798413714, -0.42743994954577225, -0.25173233028278935, 0.5395109791358843, 0.13491726769120296, 0.24665790500310233, -0.21027571057227176, -0.6175719577571722, 0.1532935460643687, -0.10850037536101134, -0.10049293943933918, -0.3830752505277923, -0.1985728214876658, 0.07398008888956259, -0.04552309587260078, -0.5412201386054147, 0.271174819468963, 0.3098428986470236, 0.46099824807788137, -0.26546264508786727, 0.34173927636828394, 0.17345793161960424, -0.27699134439004713, -0.044853417877894354, -0.11987609158105542, 0.2116500356847964, -0.31767726092251225, 0.08679724497454765, 0.018885356525284447, 0.36174258813935367, -0.16564951772567932, -0.3166047378891337, 0.2991350547627526, 0.48011672749231304, -0.08224461500482562, 0.21609022298003228, -0.47115630060462, 0.29225725633934097, -0.16730487993397167, 0.10343389211204587, 0.3949630301574903, -0.17490374616845708, 0.44109864763623635, 0.3494352204897122, -0.20988742464148602, 0.1638759378725406, 0.2700769814088746, 0.048628271959568384, -0.3007676968722656, 0.2844702005341807, 0.325560294614828, 0.11452822407642449, -0.24667671262409063, 0.11232405013606615, 0.23827002595392502, 0.17789852410601806},
    {-0.20409948236669553, 0.0975183005072395, -0.22384592356411445, -0.11031774040326676, -0.06950270168139962, 0.09850130271890187, 0.27803945623947285, 0.24688944727029122, -0.453137510499318, 0.2347072226051524, -0.2455413489955396, -0.05655084859037038, 0.2974374307104514, 0.3224186293005348, 0.3080424901755419, -0.18302337946805106, 0.18576060936849376, 0.14385881977747791, -0.1558611115530245, 0.04772204386616492, -0.040463691988556476, 0.4226523595961161, -0.02013034829527761, 0.15146612289738035, -0.07638784436406884, -0.20962732165279008, 0.22616901428049185, -0.3487242581295913, 0.17933424015678762, 0.3684303940543455, 0.0672851133153981, -0.5688351858566153, 0.1788850469847877, -0.3270673883684635, -0.3185535535044468, -0.2287129158713402, -0.15312735422777246, 0.2447455656020824, 0.16844307308354858, 0.07720164065301724, 0.30880174360950385, -0.3856162793781294, -0.029434496964385434, -0.37883883489366965, 0.21294472363490713, 0.32093039826041875, 0.12691541360460204, -0.41193903778866087, 0.3697061422647589, -0.09423698023322769, -0.2789087938987761, -0.01315903473220782, 0.08867010663866805, 0.5029415207211125, -0.4726221674420064, -0.5028654336133909, 0.1584925864510134, -0.1424650535117879, 0.2736829847851358, -0.17208334011600565, 0.3900829987756037, 0.40839878976009897, -0.3451487414182416, -0.13683700597644838}
};

static const float b1[64] = {0.8279563817933336, 0.7987802205898203, 0.6373373661157119, 0.7480067833710952, 0.7967414045594382, 0.7385495576041182, 0.8220284161042751, 0.7607922993684342, 0.823707587044481, 0.7958529107680964, 0.7761767949238724, 0.8082224552156763, 0.7909024852605011, 0.7820611482729509, 0.7409488842289407, 0.8055462318317469, 0.8239996877226415, 0.8228357903769594, 0.8138253345966444, 0.5782332901087334, 0.8290784719407243, 0.8572901054683232, 0.6980938872717228, 0.8032747370793788, 0.7952236292960787, 0.8068397197269802, 0.8218639865477049, 0.8267571814551711, 0.8208969472865674, 0.7681343258746677, 0.8127194116999148, 0.8378163631877525, 0.8169854323885135, 0.8284489363587322, 0.6689406148165233, 0.6845050511011654, 0.722533170993164, 0.800319885187482, 0.7972895984573838, 0.7862445628618896, 0.7936637870912286, 0.7504574039761785, 0.8037785614659523, 0.7549313415690067, 0.7715598096821361, 0.8072663946328332, 0.8192962736280944, 0.8197104909019993, 0.8115688831995765, 0.7659861771436404, 0.7083531181805305, 0.7421559615553189, 0.7794247589024758, 0.6992932261991889, 0.8068475411158953, 0.821481792132331, 0.7472613851396143, 0.7938988646221523, 0.7947675327754163, 0.7724904455596634, 0.8148900706903759, 0.8424746286678041, 0.8299207054577548, 0.7728427303894179};

static const float w2[64][32] = {
    {0.6324440943174652, 0.6839038421038093, 0.8725227872895471, 0.6915905530723674, 0.7730737784758848, 0.047189728086246975, 0.20058924880155815, 0.6254655089189357, 0.5319735583954398, 0.4341706837672741, 0.6500614995839232, -0.046305447252087184, 0.7908226602603652, 0.7283323227502244, 0.5815484750326032, 0.5602179704812007, 0.7115769800555966, 1.0005779281250826, 0.7111615298521419, 0.8076646699239851, 0.5503212523317101, 0.6687070565497292, 0.8242760552693752, 0.5990212622301916, 0.5982030610761312, 0.531062173952504, 0.8337967161744274, 0.8450244713347824, 0.45453768998188687, -0.29443320457665845, 0.9761602248899959, 0.7150664732457953},
    {0.5165670725241949, 0.7408394088406476, 0.6387840074236671, 0.8821564000443943, 0.8956911211969721, -0.01305745674476772, 0.6160872529553559, 0.7938281686009742, 0.30686993986848116, 0.45505167565826066, 0.7581415892928985, -0.3041912064427906, 0.9071484207439056, 0.5990619510260342, 0.3455848206792924, 0.6193912996494211, 0.5204041472270093, 0.821248028552218, 0.547470814060428, 0.6746253428146338, 0.4864284880290845, 0.9271828954098864, 0.8551678670109446, 0.9082470204150161, 0.95040170371803, 0.8068168870525132, 0.6856985979709826, 0.74898051762883, 0.7317755984360208, -0.08062320968907072, 0.9637227371070715, 0.7801167559019827},
    {0.6663074835231321, 0.9093977181017197, 0.6232599719046149, 0.6541155766973309, 0.5830672132544432, 0.17275664980467212, 0.5401369909283155, 0.7255311253303074, 0.43691835627699876, 0.6773222771774485, 0.7028978444313683, 0.04010531461648792, 0.7057799716224922, 0.9388363185288118, 0.5338238164413138, 0.736254765308841, 0.5366279386273752, 0.5309884979189005, 0.49993615158753096, 0.6476958645009114, 0.3510517127520729, 0.6320412604588235, 0.6591365299889554, 0.8970626138187309, 0.6563041585703706, 0.4723962084349986, 0.7712840686896747, 0.6432662853651878, 0.3708579834917929, -0.11839376782107618, 0.9002292638602375, 0.6290515284818878},
    {0.5318702948322434, 0.5185730651354082, 0.5807511830686318, 0.6354946660742149, 0.7583543847834163, 0.09614455790618351, 0.2700790921787515, 0.6541566612319906, 0.43177324904972797, 0.46461046482153856, 0.6621412524288303, 0.06590333358175995, 0.5237686613790277, 0.6619066236900905, 0.43838906458233695, 0.9255149432019094, 0.964261355859252, 0.7875547452649658, 0.866057752343664, 0.8138824627798983, 0.669199538552334, 0.5031238347663906, 0.9949729007702965, 0.5727934565887394, 0.5957366072054573, 0.5587855913951695, 0.7668522324832584, 0.7971230738080813, 0.46480023026730394, -0.06709184181880071, 0.7404533089796232, 0.6499595068936704},
    {0.6259639479132736, 0.6034842811050928, 0.8180567852384473, 0.8565604320560339, 0.8955342484996388, 0.09215925073970203, 0.27244939588991346, 1.0016397470589997, 0.7542516459880629, 0.7719600081631984, 0.3089731793079337, -0.1101889745536394, 0.8464650172933267, 0.9704721934790342, 0.4895782250572087, 0.6410068665163107, 0.9415134673072278, 0.7600755902719215, 0.7808137712363856, 0.5013060121630359, 0.6962889302470913, 0.5222669654285572, 0.807416289985249, 0.4888676722804661, 0.626407181384103, 0.6102031093136839, 0.8578409797021944, 0.9502898627789013, 0.6539893486862226, -0.036220792808223344, 0.4641646562858293, 0.7767723918792128},
    {0.7876186608271835, 0.7236679043919239, 0.8519036689411135, 0.6592753812398926, 0.9111017459475826, -0.18940752988142256, 0.4858875399284916, 0.625563791862774, 0.6777099724188963, 0.8140769028800545, 0.46031704636438936, -0.16864741551382437, 0.5788845249768334, 0.9658495052810397, 0.3521895385080708, 1.005834519253484, 0.8329694087190441, 0.5780675773526958, 0.9297907160853782, 0.4439843272144414, 0.6963577025172498, 0.9544625244832367, 0.8551684093612208, 0.5456518233846975, 0.6507048940666175, 0.7585293228306937, 0.9255317289689987, 0.7035660928989084, 0.7654460551446431, -0.20360915168903176, 0.8436514592437485, 0.6031600313984633},
    {0.6898788486507679, 0.9017232060015585, 0.9000493640255431, 0.6493547645365283, 0.91336701100568, -0.15501494678517516, 0.1833320388673573, 0.6036226961525517, 0.7544263438292655, 0.7506398190890622, 0.359810350144384, -0.16036222547346654, 0.6658726506861674, 0.5651645165077713, 0.600984661856964, 0.9651518766471757, 0.6967661391271169, 0.6545794403809779, 0.6325937026618726, 0.5151227218630652, 0.5308945426214281, 0.9267115106383342, 0.9309891190786281, 0.6843009502010691, 0.5372285629963507, 0.8055509076027496, 0.9347659864738345, 0.7758365865492993, 0.4301508872304125, -0.12830471648909825, 0.8389016087881676, 0.7291118978746777},
    {0.7680313513304161, 0.8561482781886697, 0.4881353927163491, 0.874476382291898, 0.7006852803720173, 0.16417445428206268, 0.34993907807590985, 0.7844315587732583, 0.7537829450435062, 0.654110581464092, 0.6858498487262567, -0.008611483501096681, 0.6023678950932102, 0.5191338928850772, 0.7590443205094398, 0.543151993108158, 0.5563184888020338, 0.8579671712187006, 0.5027829743752937, 0.635222726424385, 0.6642789379363017, 0.6858937310024332, 0.8458517575728496, 0.8719860909654005, 0.8244240869211237, 0.8678406352669655, 0.49142929745634883, 0.6206855982826298, 0.37881817451706973, -0.010035189844062759, 0.6168511727644365, 0.5456366652098472},
    {0.541934507028753, 0.9814210386999814, 0.7690394039756603, 0.6576767712708973, 0.8958020403721718, -0.05385788619556253, 0.6105540679494029, 0.8895990240310674, 0.7912310480332928, 0.7196469082138734, 0.5442711915053745, -0.0031177002975884363, 0.6282591718406068, 0.9630262913791722, 0.3556174881285479, 0.8477744534357826, 0.7946634392110189, 0.5445594971266586, 0.4824836221712686, 0.7029201606454324, 0.5867023997422233, 0.8900998580844883, 0.6450503582582086, 0.8457890832517062, 0.9075011969792077, 0.8085461675420336, 0.6075845589925551, 0.6723688955215807, 0.7780609036848767, -0.12280397516142373, 0.7036622665581581, 0.6566384529763357},
    {0.6371045851007754, 0.5306529855528365, 0.7774947248784434, 0.5508447791234348, 0.6709355094469244, -0.1639634452545675, 0.239266121325693, 0.6861415756718013, 0.38612948684237974, 0.6378842830167843, 0.6506909008851308, 0.00843257981143291, 0.8216561965343235, 0.520816258983877, 0.4342143973612857, 0.7704506146448186, 0.8248665545501312, 0.6099320416829032, 0.7460159947938402, 0.8970727945493017, 0.3725810200283258, 0.5569501599927665, 0.6239759033040428, 0.740510457482165, 0.6736620629669143, 0.963830102941448, 0.7087454939438075, 0.8497150914407529, 0.49078498599181325, -0.2713779384528233, 0.5783784370594022, 0.901238464441397},
    {0.9337296300695743, 0.9533726347429429, 0.6896252809172223, 0.7274767133360438, 0.7809432596547747, -0.23466759826578473, 0.5640130469910033, 0.8030003954896016, 0.3532773721004482, 0.7822868018522163, 0.46940581080407573, 0.017840483211676635, 0.9187898078029033, 0.5230023349339732, 0.36802064133859125, 0.7247548757988244, 0.5261037987357888, 0.7954547129747426, 0.9110047188305774, 0.5150882395873648, 0.3363866417434106, 0.9854141631107274, 0.720796510813679, 0.5607250943503553, 0.792762136426858, 0.5632993776120241, 0.700707565011623, 0.9479985715631178, 0.7670059750499125, -0.10434217192521655, 0.5531577097831312, 0.5941613561616016},
    {0.660126164394728, 0.5254834299014748, 0.663418172893345, 0.9609091523400372, 0.628268455197789, -0.037730525802628895, 0.2557143985101943, 0.8595165312202422, 0.6814327365148611, 0.5493007927121031, 0.35289852588763737, 0.0569237932676965, 0.9488557874446681, 0.9014200401130985, 0.3701922336375896, 0.8622180029586937, 0.5294989756520093, 0.8341040855700339, 0.6802059555210603, 0.7289830521743828, 0.5333728765597979, 0.9710584986688023, 0.8923377112641427, 0.8923786381331212, 0.7679400717525917, 0.9064091736206202, 0.7895158312587506, 0.606840817462536, 0.3663788955021815, 0.027626565816216954, 0.8550939902977606, 0.5628358324302999},
    {0.7977792025355173, 0.6816664156478806, 0.48016305291190065, 0.8787125099474459, 0.6313153625707011, -0.08261921277468438, 0.5212982693225645, 0.8051268346385225, 0.46812801670285015, 0.7143476886890732, 0.7273505647869359, 0.08544866964075758, 0.892002999333864, 0.7600295322784305, 0.6533302735142142, 0.5679740187512435, 0.5202440660823402, 0.7898337546298673, 0.7811438116539304, 0.7090129471381917, 0.5698363239402933, 0.8946936633954927, 0.5139625963526991, 0.9237926721149259, 0.916651230148541, 0.5349580336774202, 0.5269933509598832, 0.664253596103058, 0.5650949346896803, 0.006464424043452977, 0.6603333007475694, 0.7992173841274013},
    {0.650205916148996, 0.6706222376353778, 0.7828467052377928, 0.6796175447815396, 0.7790065647594658, -0.09389407504985774, 0.6257734757462199, 0.5750897109018344, 0.5773740828139584, 0.8266667089983332, 0.3073022180443757, 0.11765976012849673, 0.9352353298357532, 0.8830589263885295, 0.7008318724161577, 0.5411017374547873, 0.7881279726533482, 0.7550294649625203, 0.6748434479328946, 0.8322773555487468, 0.4326908004647313, 0.935527855724525, 0.7853081101557056, 0.6736560875304509, 0.6306329104786066, 0.6958349736947377, 0.5167387417212731, 0.6304901010771187, 0.3243427569387756, 0.13572175492300972, 0.9456855954938171, 0.959848492930479},
    {0.9604267918184629, 0.7078541208840945, 0.8998067147912439, 0.5770566145058065, 0.6460385337624566, -0.007404743480057401, 0.4250946899025942, 0.9481074355718544, 0.6704923098986117, 0.5983055044283018, 0.6715009855369884, 0.137413411555641, 0.5902318263388746, 0.8212893351014146, 0.6653165620704998, 0.7608385137649659, 0.949927674256205, 0.6112731133173396, 0.8703215003855584, 0.47428839932484085, 0.40569152248829127, 0.8560479967588885, 0.9451367064551468, 0.9192073009658143, 0.5314687982785796, 0.6288768172721376, 0.5429202458374538, 0.6348931396668321, 0.8090716885720043, 0.10519654066829118, 0.6409449354575665, 0.773528990216672},
    {0.9278831743736002, 0.754843946278478, 0.8287430500467732, 0.9029043300202698, 0.9514712220982173, -0.06790659124890279, 0.581424832956796, 0.9510471115359649, 0.43758158388068014, 0.7372380899598031, 0.27199368144502006, 0.09463428288123651, 0.6278352010014602, 0.7427151513469048, 0.6934792563830163, 0.590653738181366, 0.9265019643583464, 0.9524388088714789, 0.7099781207513051, 0.7395387285508624, 0.6986377436621447, 0.8126768904409787, 0.8253019028371873, 0.6264997423330897, 0.6493636942716645, 0.7797150630898416, 0.4902780668987176, 0.8340430534834705, 0.7445792782072435, -0.060284174736926946, 0.872382329642913, 0.9434354567214985},
    {0.5172407445662228, 0.9322507884228682, 0.6906648579163246, 0.5461559526379247, 0.8599605697608044, -0.19755871579621714, 0.29960316134863474, 0.8794495265186493, 0.6558078094912841, 0.830265409612585, 0.2532290369905299, -0.029650636948984024, 0.9135506008294568, 0.7804139109144247, 0.63025242706781, 0.5811191505894693, 0.9365353424671742, 0.9834772693327032, 0.49854725488890905, 0.5751481058674313, 0.43656859785692964, 0.6613083219354455, 0.6518679310860753, 0.9593494459906275, 0.6345800064483106, 0.4888872942939359, 0.8192724347517035, 0.7418811729689723, 0.5240729118774147, 0.10838442564564021, 0.8719583316797466, 0.9353559745963255},
    {0.6065572105807081, 0.8671373469810788, 0.8281491730416063, 0.8862594641678239, 0.5724746690891538, 0.050400671732754386, 0.5165538202761492, 0.7488084400778631, 0.4639532287765813, 0.45196138998367763, 0.754064819984421, -0.11729121214391401, 0.7874769379245177, 0.5754492542978243, 0.37872289974378986, 1.007710282210622, 0.6365144028732492, 0.6041197452884238, 0.6052401166643518, 0.7379857697164741, 0.34388000181040773, 0.926482129560359, 0.8435386872828446, 0.8969865278997786, 0.9654286685217413, 0.6675697875705262, 0.49542450858392306, 0.7212911002040112, 0.5566645404144062, -0.3210436991296383, 0.6928648146281491, 0.7749462461674416},
    {0.9143485480553201, 0.9467734338296803, 0.8827873564712048, 0.9162937298907938, 0.637500848368207, -0.1415493669865105, 0.17798931443514016, 0.607447101497305, 0.590835470543996, 0.6437891617122793, 0.6344050259114502, -0.21145263665454153, 0.8396921452121211, 0.5827297739762195, 0.406817552437811, 0.8553724781740143, 0.6385810029969345, 0.5719932092966066, 0.5820708615108814, 0.8763757696936659, 0.3663551277378716, 0.807854903497102, 0.697924501523894, 0.5834886636237734, 0.8105562318877609, 0.7079745844649059, 0.6680806825758128, 0.5712738554409045, 0.4250802681948409, -0.0892046878346535, 0.7028369612931553, 0.49156486386804},
    {0.7368206303536202, 0.6551079934584519, 0.5222031039449364, 0.6244097114624324, 0.5288251185215969, -0.11517234386992689, 0.30583847834202044, 0.5955817251034704, 0.7813305296099214, 0.5589846801561963, 0.46952357542097894, -0.17699935097884073, 0.6789422808985558, 0.6697364350453352, 0.6619748462051542, 0.6767428218571385, 0.7349939226966078, 0.5975292133220629, 0.7803682602280533, 0.7282471343596013, 0.6454424283174873, 0.5201588546066231, 0.6281839076313693, 0.9189772643102564, 0.5241224275331351, 0.8200083084742944, 0.8863301106281307, 0.6993827003933947, 0.6713514770992512, -0.01208225544571529, 0.6868909724226662, 0.6829351274430233},
    {0.8540915655139053, 0.7822756739988025, 0.5641889763370038, 0.6179951479524891, 0.8900411344410009, -0.0995875150055875, 0.4429541918472138, 0.729489266593282, 0.7611693646225044, 0.535053615640642, 0.610038076283493, 0.02688748825287949, 0.6771259969334278, 0.8862520321944275, 0.7062951899699415, 0.8182998737575276, 0.8416444189153699, 0.8777362015474295, 0.7473945678543082, 0.6564338872205864, 0.6114602232044455, 0.9330515467198583, 0.5523528928240307, 0.5975742226301665, 0.651841770087021, 0.8460732801202744, 0.570560603952013, 0.9628686854629159, 0.7351265720762369, -0.1871477155263981, 0.48257504059495193, 0.8795955481385934},
    {0.9563224842269717, 0.6007756167202621, 0.5155692561779367, 0.8230699644858442, 0.5836118281267778, -0.015417344418465541, 0.18441517689136486, 0.8290405513910829, 0.49521686566753464, 0.7079678938409234, 0.7017950557966396, -0.024444528824468337, 0.820392040291416, 0.9751603303053333, 0.5257160202250605, 0.8427092478599159, 0.6744772119336965, 0.680521585383709, 0.7145358027754385, 0.5052922544718811, 0.391216499535534, 0.9716892743785509, 0.764562029147989, 0.7170846984870954, 0.8938987059701102, 0.6241521528593884, 0.6078861428263805, 0.8078536492867587, 0.4015776921189273, 0.04378921592559507, 0.7866060039655752, 0.7656734636985933},
    {0.5604816302624339, 0.5821859899732826, 0.48052505078132696, 0.7268612204410556, 0.5310534779585602, -0.2861774916788388, 0.5102479674538443, 0.6564610657521252, 0.4306504668365086, 0.5330722312752458, 0.46303627389748486, -0.24042080843503827, 0.7345211890994606, 0.6805284990594548, 0.3901346509997628, 0.7448757834717022, 0.5852430135189782, 0.6028610566327186, 0.873902446019547, 0.5453593011664807, 0.5451737111761904, 0.869470334585805, 0.722290686811022, 0.5786464975666514, 0.7261970846272047, 0.8049157524500242, 0.9479490807992741, 0.6628213217647483, 0.5608037418013312, 0.10444201272552275, 0.5208394038914411, 0.9838481687474415},
    {0.7008236392250922, 0.9696938671326899, 0.5620957054008195, 0.5412809156896259, 0.6219043380343788, -0.2941602123597063, 0.6023313464184868, 0.6390477456470056, 0.8143761827759989, 0.4172544872138454, 0.3428777964024333, -0.04152730369035178, 0.9456766643251386, 0.8398648015188187, 0.6640781405791479, 0.5706685875474505, 0.8542516997684039, 0.6293967241625377, 0.8330144357482774, 0.7253171473330473, 0.4226054375379182, 0.7581252873532465, 0.5181490394683854, 0.7768783376011278, 0.8047104453615211, 0.5575458830229957, 0.8714106154657577, 0.943422684348864, 0.4209396023912845, -0.013530915987550358, 0.6904595019513182, 0.7783800971904624},
    {0.9031384819962159, 0.5964379695345702, 0.48468412088199125, 0.9965600400659178, 0.5945920942894796, 0.04311315326196921, 0.32112640493742517, 0.8923026067719779, 0.7280825895494539, 0.5501440349049543, 0.4970109918383171, -0.2852791552366993, 0.6195009531678484, 0.5508724998705787, 0.56093004112853, 0.6960523961544517, 0.5372620457139883, 0.6319842327742152, 0.9573403934872855, 0.777358797422995, 0.6111111210739657, 0.7725483109282132, 0.9418030414147499, 0.5268699501853751, 0.7792105476050232, 0.9334478163074774, 0.874535831297097, 0.7092938268707384, 0.7083682242780036, -0.04504566441183464, 0.7201588328195678, 0.5974884457493863},
    {0.7041580807712645, 0.7312420892816536, 0.9350411910258034, 0.9489265866693349, 0.5288240154191848, 0.01631056905755356, 0.4869825202810729, 0.567087464102501, 0.5297056524871948, 0.49752613629040254, 0.6174707210842469, 0.11202877386303307, 0.8942109029501106, 0.510420990630613, 0.39587540397809734, 0.7453456868010989, 0.6399310614087933, 0.6513626722068311, 0.8629266366493381, 0.5710078448864268, 0.5523496142590784, 0.9460421963769479, 0.5564041647912003, 0.9128120511695053, 0.6753760243738602, 0.4688107700278475, 0.536827046631218, 0.8105900976649212, 0.6505015610525108, -0.31888617288169996, 0.6175651614714742, 0.8445565401712078},
    {0.5137630097381056, 0.8272201130362274, 0.6869230678650976, 0.544946725976666, 0.6845532991802288, 0.06013007944422488, 0.22806570348170968, 0.9416942974026329, 0.5456701371453657, 0.6329497101329341, 0.7039826158356576, 0.09669902004820403, 0.7470160529670659, 0.8996127701044351, 0.583699590568374, 0.8534432300958935, 0.6788357770276381, 0.8908133392173068, 0.503501371981928, 0.4597718693323436, 0.31188980650414194, 0.6384080682986618, 0.6675142617734274, 0.9205327561425474, 0.8820704564617229, 0.947185511821386, 0.5260725362133504, 0.7491320275805994, 0.7017563689938814, -0.23032198168576218, 0.920391382100874, 0.542643402387281},
    {0.6756222108982327, 0.603068535635277, 0.892399382172731, 0.7302510464126301, 0.8627881878271536, -0.009324965773318953, 0.2242647772891487, 0.7573776358305746, 0.6397620947425716, 0.7431729675877722, 0.3969805888189074, -0.1758315205482087, 0.5911356503701473, 0.9301999850003757, 0.811819972674395, 0.6293320646215812, 0.734761300242416, 0.9495600865416203, 0.4724230531761598, 0.8539039618337587, 0.27221580625875136, 0.8276698442551806, 0.9148048836541921, 0.580403979190318, 0.8160968667524504, 0.9202225336496939, 0.7469007652909401, 0.6458331508112739, 0.8058763890422245, -0.10236520705858031, 0.6144265894308151, 0.7072309882016629},
    {0.8371983768436505, 0.5250720372885398, 0.6423371292654335, 0.5462086825621463, 0.6642261008658777, 0.027966224987319228, 0.26767111511764885, 0.8404803143930627, 0.4229103628845745, 0.589199957051521, 0.3278816543362976, -0.17260093806916804, 0.8193937394798204, 0.5180674242506129, 0.3680916984093455, 0.7242438083621875, 0.6100461903009899, 0.8166724722091508, 0.5921992465961126, 0.6596078134093295, 0.44409845196113534, 0.8991274874867673, 0.8618562609534444, 0.7843498760247763, 0.918550897052698, 0.7852652710427778, 0.626975013495694, 0.7095231102549447, 0.7366485497564538, -0.20305519812499587, 0.9527108212934321, 0.7208903599200625},
    {0.8036257947366092, 0.7424253297723461, 0.9088393812681355, 0.5637860668997673, 0.6448301526951795, 0.1720971628410216, 0.5593908254433335, 0.8165141675409959, 0.5432055164944065, 0.7601274609358378, 0.29809920226678427, -0.02399339714028409, 0.6818052999363823, 0.7895840757932493, 0.7647043976114423, 0.9918986811194066, 0.7580952526920498, 0.5194280883315324, 0.9407573949895727, 0.605795940406316, 0.6803796072253575, 0.8077963862697201, 0.7628064009951953, 0.6544514720498124, 0.9088769249598605, 0.9531411437622836, 0.45948832381102145, 0.7024131857897625, 0.6552822795715246, -0.15288474715829498, 0.6840107972693587, 0.6382104823287915},
    {0.5387813400980853, 0.8553609246437444, 0.8970095657003864, 0.8257631444522107, 0.6326996108692956, 0.06304077956794697, 0.3095252373323917, 0.8043821120033575, 0.6297279698755144, 0.7356772823495441, 0.2702947121893695, -0.26687225548955346, 0.7247058064614155, 0.8447583460434814, 0.5979241075057653, 0.6729586381120903, 0.8199710186855966, 0.6462166809509327, 0.5754179808226009, 0.7445728758459912, 0.6269047824456098, 0.7776685188347097, 0.9899961749701424, 0.5983950071066197, 0.8894564603011347, 0.4677347183223376, 0.7334417378359764, 0.8332375497306058, 0.6105836530733545, -0.18184024409427324, 0.975699867793975, 0.7994551878516867},
    {0.7528841129618249, 0.613873873415758, 0.6947494457398389, 0.8770640967503286, 0.8538374925008757, 0.0038784824142646074, 0.22831018700432332, 0.871336939832722, 0.5734692259324451, 0.8339965385452712, 0.35692038315386376, 0.12015129726058678, 0.5536619198529131, 0.8426773115660134, 0.7407291888485257, 0.8375761127796959, 0.5374407962165086, 0.8237559666406736, 0.7904341193789829, 0.8955543661353891, 0.7510857707945403, 0.8420233948184435, 0.8318297859946306, 0.9034170515539045, 0.6578912981988934, 0.48480916222733555, 0.8655848654330894, 0.8658765762974213, 0.7259817659356449, -0.09684411915707353, 0.7636964460638461, 0.9257593368015109},
    {0.7813359810624314, 0.9052572776406056, 0.5583050115261149, 0.7724830824207828, 0.8777988578607776, -0.10877191467547, 0.26587017468617646, 0.6727875676216661, 0.5956094320469774, 0.6723621840187187, 0.6091399470537845, -0.12514439622593476, 0.8671948871881329, 0.8105517885279696, 0.5150674862321216, 0.5336789829726313, 0.580801948953821, 0.8204287371387211, 0.7514382845661928, 0.88417524132332, 0.6383504599444472, 0.943733151384465, 0.6383320752107885, 0.591182932864091, 0.83589606924829, 0.7903891870784859, 0.8853912280650966, 0.8731827596964392, 0.3947276816872929, 0.03790123666338608, 0.6841324221021181, 0.823534024935106},
    {0.6406615930887499, 0.7472148025849871, 0.5617898499938734, 0.8186206717041933, 0.7085894572551172, -0.2601851544555031, 0.3448426786228196, 1.0135146773750838, 0.49547397173381924, 0.8133032574909209, 0.5898583705532944, -0.12364726643366257, 0.8445564123649651, 0.818413116322148, 0.36730808420409006, 0.8698301953611443, 0.7735344410199603, 0.6868280262063047, 0.6210026001592247, 0.9182580360522313, 0.6175693013432424, 0.6442658049509234, 0.6508125287626999, 0.7930505574325325, 0.5888949182738008, 0.7993992213549169, 0.674471625884964, 0.7949071790240984, 0.48412300208804593, 0.10008704668923789, 0.7080760635644889, 0.7117443008670377},
    {0.9156758731971817, 0.5642970468103313, 0.7786492065366813, 0.9431696365171304, 0.9062672980317866, 0.050228116857557736, 0.6196080616506215, 0.6314627819347409, 0.7940248523056833, 0.8410591433127212, 0.6016425682310167, 0.15856656014792178, 0.7871535024918674, 0.52247567283256, 0.5898023267615041, 0.6272129032104674, 0.8207821003160808, 0.7602961817366216, 0.927070532021768, 0.6889652005922112, 0.5639401917492033, 0.6618623399962363, 0.5773401308366529, 0.6325606198552608, 0.5431771317366503, 0.6691340308273135, 0.7788681262755961, 0.5511415009421474, 0.5557313159329734, 0.17335407580666679, 0.770587362345466, 0.5187747951236146},
    {0.6949787309678223, 0.5768333640705853, 0.7386791204941886, 0.8862083478402384, 0.5768030143399294, 0.03479476987367476, 0.18898887123040053, 0.6157821359128187, 0.8206323724750566, 0.45544255538432615, 0.3268104604927152, 0.07050390114365712, 0.569426828139443, 0.9144419766837271, 0.5781635523203261, 0.5418140388304568, 0.6575044717050358, 0.7047230252625373, 0.5139563720972056, 0.8478022872895501, 0.5593237385249612, 0.7012400163955086, 0.6716883455419501, 0.7863017834737152, 0.657882561334334, 0.6365524048404887, 0.7871408678621004, 0.7618066897577767, 0.6412131022387801, 0.10118823067419601, 0.8385059381079784, 0.8068216134816156},
    {0.718528078245495, 0.830784130015929, 0.9393101614175908, 0.5743970444222981, 0.7833244137920323, 0.10572768544142896, 0.3470881492123049, 0.9730302483047578, 0.476574860921441, 0.45329674108263424, 0.388207820214778, 0.011227698105994081, 0.5191583358962525, 0.791883954791482, 0.43643782060948116, 0.8189530400050062, 0.7797813179383953, 0.6437364435832187, 0.7401621249603599, 0.4941231504510613, 0.43071836929339224, 0.9621482551258602, 0.6341942698407426, 0.9436448223990871, 0.5542361793000229, 0.7825961784188519, 0.6235795785560762, 0.49964869419909186, 0.7219694157371961, 0.026810001457564254, 0.8766260355266011, 0.7256372707216473},
    {0.5758174267352049, 0.843099305723409, 0.6093242142510616, 0.7225073237433773, 0.681005106832669, -0.06589497104098874, 0.4669323574928499, 0.9119092173345923, 0.3374859772461187, 0.6393657696583991, 0.5944791757436096, 0.1257895422612416, 0.7839380644461262, 0.5858321021303537, 0.3742353611675467, 0.565634000724922, 0.7886776140556067, 0.6873807799694398, 0.8651149667639845, 0.4611925715948574, 0.6236070681594184, 0.7558721261146295, 0.9331359012368555, 0.9601678120277274, 0.9599802915662946, 0.790539876773577, 0.7865994915131865, 0.7019053670115707, 0.5975097037820509, -0.0899297807222642, 0.8741052101853407, 0.7004726420841797},
    {0.5577846142449414, 0.763045716025823, 0.6666494380729863, 0.8929685382416077, 0.6999464195902887, 0.026351544215988787, 0.3587251578892469, 0.5791865999526485, 0.7289906796049135, 0.5523959866761722, 0.34313970525955223, -0.2255735445704868, 0.9546255807187174, 0.7597547964054687, 0.5673636622127959, 0.5751134634212043, 0.6507790544416497, 0.5689888552042945, 0.8732375191039233, 0.8762005114781258, 0.5265059219625453, 0.8738874960503349, 0.8982577267684179, 0.7665773533605442, 0.5162386656915182, 0.7051523875991272, 0.5505527512008878, 0.7143515025627338, 0.6264333581643774, -0.02370026036558731, 0.9098568756132889, 0.9647797326349955},
    {0.9142091688234015, 0.5199817574370991, 0.6608262712478162, 0.7782556738027038, 0.8247085412686386, 0.01894047516464469, 0.21898004934618767, 1.0063884089414816, 0.6628627884387457, 0.671043583758249, 0.29600353994111794, -0.06381207724069718, 0.5536924696170613, 0.9385368362401213, 0.6425475856610939, 0.6863007305543273, 0.9318567110706221, 0.7451610690508232, 0.5127181494799847, 0.909232382511669, 0.3476154628830227, 0.9746113357702034, 0.740550958123501, 0.7154038132692077, 0.5146370071301876, 0.6031126473951841, 0.8748910134548834, 0.6978664092262024, 0.7048041771702227, -0.0035545087756541373, 0.724865130017661, 0.9295241044570036},
    {0.5596843094383614, 0.6803824170075206, 0.6728063466522132, 0.9234744228017614, 0.6333329067205538, -0.24620662421974568, 0.6002139908279115, 0.8946572819595539, 0.6869769895687291, 0.8271263115166658, 0.27181003710073276, -0.046110364791589406, 0.9694861773696123, 0.8699133527857914, 0.3603297820335702, 0.9906969817320743, 0.7464996854520934, 0.5641954441690902, 0.8492289165560716, 0.6620442993295382, 0.3970723854192907, 0.6045939665491857, 0.6645079460476826, 0.6332194950688876, 0.800160083435037, 0.6518429813440685, 0.6536308130245774, 0.9088134098285167, 0.6954759217536627, 0.07071001566082262, 0.68542598840544, 0.6304839794013178},
    {0.6657927137371468, 0.7998380446295762, 0.6722504889467436, 0.6952637697822618, 0.5963155803303062, -0.12964390595116607, 0.2737962791269138, 0.7678924272274443, 0.5804024864109419, 0.5946226197399269, 0.4516253764361594, -0.22886840648731102, 0.5541103135812634, 0.6015675880680906, 0.5403102583805783, 0.5542746786317899, 0.7218856421595559, 0.549953384006696, 0.8504368281202893, 0.5032128532617123, 0.5125799485145395, 0.8929015555923993, 0.9602682262847675, 0.9149039224043224, 0.6552571650117, 0.634896051917131, 0.7631469555943002, 0.513492436065145, 0.7781136184271089, -0.27752951939698073, 0.8814510449978553, 0.7480090227936508},
    {0.857455345728723, 0.902758022975781, 0.7644470102547656, 0.7404010033544438, 0.8199462676946877, -0.17328300052741027, 0.3798181046559164, 0.6523335196806966, 0.7684659595633899, 0.8970714747330402, 0.6239837317354356, -0.20147244720951457, 0.5256619327029639, 0.646378977761481, 0.5919090688229953, 0.7485221681631408, 0.8518608926265421, 0.949641730351748, 0.49415916877866767, 0.7077426557633698, 0.6298443286197964, 0.7583490462020749, 0.6506937223196985, 0.7199380231663132, 0.7948719349545367, 0.6151307861035742, 0.7199739824365233, 0.7104047161669649, 0.738880048034781, 0.02147555047519721, 0.5461927890795021, 0.9509610948481578},
    {0.7031387070127294, 0.8835372267019823, 0.6020222753130625, 0.7624796040404492, 0.8478824242404845, -0.09734010525330256, 0.5285245955478686, 0.9322393271316127, 0.47956370495748324, 0.8031072994451833, 0.6848552015354445, -0.2976421098721093, 0.7305107401519682, 0.8334320662512184, 0.7592030900631375, 0.7185332492533918, 0.6985521485526097, 0.8285386905333846, 0.7031393061960217, 0.5585464628435963, 0.4678235961643568, 0.849411593341576, 0.9096031963149175, 0.9251974877581266, 0.6278808582779198, 0.5698273425944799, 0.8826822310792163, 0.6075996835484652, 0.7518749165479339, 0.1460353180066451, 0.8708086357078821, 0.75371268941807},
    {0.757613939682844, 0.8775529756816701, 0.6294838992283897, 0.6995553367608444, 0.8212505531638767, -0.10772630846428517, 0.5883821789185018, 0.9380459911530666, 0.36889225894485683, 0.5764171776417889, 0.5208638759439972, -0.021718969948842468, 0.9187781804793764, 0.5027933215147716, 0.7509875941401262, 0.7158978323548235, 0.8494803464248785, 0.5354300240090462, 0.8891703833307746, 0.7540937286817541, 0.3675439454643947, 0.6098036652032861, 0.896192098401959, 0.7586335138179853, 0.9159918686110748, 0.5412586499200783, 0.47891097349789385, 0.7099458010642165, 0.7211519663790547, 0.01759412128814377, 0.5367697127236467, 0.4952769372255283},
    {0.8326418188761819, 0.8594826814652617, 0.6071056336948398, 0.6397427818582052, 0.5470980975349654, -0.026502394635826345, 0.19097522450836343, 0.6897342657959562, 0.6130035011776405, 0.7101631029204458, 0.5375944875845303, 0.07998144701360227, 0.7914978273341758, 0.5593354249341629, 0.6735047904696039, 0.8946297513847451, 0.5566370486770905, 0.6250395180674373, 0.6547710102311105, 0.69076109224899, 0.5378074387024895, 0.6651942691064006, 0.7642909965957893, 0.8043865878036234, 0.6466231698016223, 0.6771886871428215, 0.5234953862951647, 0.8564696375711606, 0.4751841733433398, 0.09201700316299685, 0.6396331474693819, 0.5215156203325422},
    {0.9372421881741, 0.9630873472144371, 0.8235436164178593, 0.8154792938313012, 0.5052284029577054, -0.24822032688339415, 0.2316523141226752, 0.5168247522377293, 0.6476298754775418, 0.6617905861444561, 0.5751021478863879, -0.22787721069953, 0.8368531705322081, 0.9727780623263138, 0.5481844788823153, 0.5401747174174818, 0.8168958198400478, 0.8519029931519971, 0.8272230208446588, 0.5940652775421058, 0.5108307581223174, 0.6439578116239827, 0.6692753032646965, 0.8409676048317647, 0.8491873240247185, 0.5537401064791795, 0.5778127715001964, 0.6786976769986273, 0.3691732939432529, -0.11384692364933213, 0.5445930560734272, 0.5259984755151567},
    {0.7967297600656046, 0.9201495896889387, 0.820060567730681, 0.5305720839641627, 0.7611303412885385, -0.027895300525497442, 0.3762327273562577, 1.0122567600035883, 0.5399304467041665, 0.39708329127511827, 0.7038886371014185, -0.055083285003955984, 0.8835494544799904, 0.8155359400214927, 0.518536735916406, 0.8047562112549025, 0.6368621734155818, 0.8016630914445964, 0.8621447984978554, 0.7674838126527713, 0.6297050221453853, 0.801688297720959, 0.9261411693104619, 0.8658707588859673, 0.8599063011641163, 0.6775715727339562, 0.8386355354638527, 0.9720924448620405, 0.4133147050791068, 0.10117153231784905, 0.524886026934119, 0.5704334940399406},
    {0.7786544602109527, 0.7023743560351943, 0.5668099082480157, 0.7346342723305274, 0.6557058760655111, -0.11964367487189405, 0.6131467797510438, 0.8494804566264366, 0.6380192125830286, 0.49023542706532014, 0.6739331262805294, -0.007697595884708503, 0.6223625778796334, 0.4958968888953973, 0.6276814486345331, 0.7831556777276967, 0.8114274528267247, 0.68616752115321, 0.9476066913911873, 0.6359399181666495, 0.721639774300404, 0.7295115115069474, 0.6119397925948432, 0.5738764355050513, 0.8966989004206632, 0.511285243397991, 0.8678239662339818, 0.8621139071011916, 0.3503917506161015, 0.005745597656144918, 0.5113059040286764, 0.6160832722027961},
    {0.660310045668566, 0.7284391059230318, 0.5205601077880395, 0.748096113478013, 0.5211078166346289, 0.03702869610101361, 0.5258114838401537, 0.6839750898885036, 0.4405805798226378, 0.7232442516417299, 0.7559293414280628, 0.1630976907343492, 0.688437559907432, 0.9575537593687217, 0.6881528477173575, 0.6746847272158177, 0.9713892823129636, 0.6241534449977435, 0.7320014762925077, 0.7792389838864489, 0.46066234375017123, 0.8946996080717229, 0.8010964994209486, 0.8872658260093936, 0.9902494880259946, 0.6285494156001002, 0.7790938260603717, 0.5956306068448277, 0.720022824354156, -0.03458544399651175, 0.5659525349515514, 0.8307476635034725},
    {0.5704393244996453, 0.884920633120243, 0.7663956642728394, 0.8197292305112132, 0.6155472518071159, 0.015566602404741014, 0.40526577653669427, 0.604124025936396, 0.6865045391889795, 0.9099866675767783, 0.619700143569099, -0.09633885172103744, 0.5233777650365441, 0.6782337250338083, 0.3750832354373564, 0.6593813868780725, 0.7675060033741435, 0.6941580159641222, 0.7998106091896798, 0.8364470236153856, 0.3212666792978255, 0.7484551834710231, 0.8513079152164197, 0.7267000043314614, 0.5298191650325322, 0.849822094814025, 0.7727675641209149, 0.6732886036360213, 0.7320785623979551, 0.08498279973722186, 0.9146169694233115, 0.88943078444511},
    {0.8398683878631619, 0.6377240558549949, 0.6074969219384435, 0.6102898663899854, 0.9010871645726968, -0.12035091529840745, 0.4666581922566062, 0.6639612877188533, 0.34851425504226935, 0.5965505285914267, 0.608898151084269, -0.029626990118475464, 0.7800541413490064, 0.6885155805781752, 0.5788710448335308, 0.7380817041836721, 0.5559066783860479, 0.8027566728410981, 0.4920324375289441, 0.5007937155103583, 0.4159882190459821, 0.7782606839649716, 0.9413342127750493, 0.8432563579038685, 0.759023038938685, 0.50980762018851, 0.7543728956094362, 0.5490053723337479, 0.6363639883888467, 0.0322094951025335, 0.9600980228146172, 0.5683343200512948},
    {0.7895561216396016, 0.5424990981976353, 0.92481216491662, 0.9545368497879955, 0.7249963621784127, 0.07715280223182927, 0.42403630254749086, 0.7182952733497114, 0.3178541247685072, 0.49645876662998284, 0.40612305273716476, -0.10667021316958096, 0.8781793566844025, 0.7128558359133537, 0.7912465443399833, 0.5299950031329893, 0.8557306944205485, 0.8223069728149612, 0.523585669494966, 0.493784041488564, 0.4506903733094786, 0.7981270310290731, 0.6955710638325366, 0.7414095228103917, 0.9083961359132005, 0.581761673752241, 0.5293904538996216, 0.6186745139044941, 0.7555477109753634, -0.06898698733368601, 0.7364592996955277, 0.7393441542797416},
    {0.9001647683052224, 0.7740149431831189, 0.6747822504205314, 0.7028152962009574, 0.566170258774732, 0.017230787534181224, 0.497936142273581, 0.547961711212571, 0.5633106643641927, 0.5708632181434266, 0.30657493130988805, -0.12567703732144417, 0.9375410069859208, 0.7526007687684214, 0.4892036791489795, 0.5403799760642787, 0.7258093465120268, 0.5281766134752468, 0.8578631913953804, 0.7470177481627083, 0.5985728941174857, 0.5875003717369278, 0.6519889145192084, 0.6705412480678937, 0.6994033756273998, 0.574460248235437, 0.6601385705029461, 0.6774325299944024, 0.778161148443105, -0.2721385235603414, 0.9068706099495212, 0.6182193674359268},
    {0.5504771470294246, 0.7834285353167123, 0.8588849961535263, 0.9253220143202907, 0.6735363715492493, 0.04802108909778984, 0.5023215935862516, 0.7157592565469187, 0.5453008991078363, 0.7323457618993267, 0.2610377574501731, -0.15481051344656613, 0.6078564802720774, 0.7758190606713087, 0.6548729993534036, 1.0185024644976592, 0.7233153496589917, 0.8253073998776719, 0.6249114708454778, 0.900657666257714, 0.368104874964878, 0.5149651780731997, 1.0118461405008887, 0.6082050606010709, 0.5881329933924715, 0.6144532189862523, 0.8001050438989843, 0.7030809396263002, 0.3704023933065563, 0.02003282474881513, 0.5245108683210613, 0.8779669927918082},
    {0.7528271484350845, 0.9290054162907432, 0.5297335015215506, 0.5956321123017033, 0.48960011681354404, -0.03828828993597467, 0.6449049288462644, 0.7311234908869801, 0.4489452675434415, 0.697439448755944, 0.25925472818081335, -0.017656436934938475, 0.6311501900428961, 0.5905078645841688, 0.8318727295225906, 0.8763826788676432, 0.8432762638426838, 0.8844075138334273, 0.6186660443473906, 0.6061191822872275, 0.7888617241981081, 0.8370107798086874, 0.9645909570648556, 0.6376134742239095, 0.7650277911993079, 0.6463439739814623, 0.8793203647634363, 0.8485654297295794, 0.3984285446658531, -0.15084231726926145, 0.5522762008071423, 0.5669526147279221},
    {0.7896441642000487, 0.8664011148747333, 0.883056271852783, 0.9517346517895948, 0.6959245421684614, -0.10689597329461031, 0.5175408758173056, 0.6111098755890784, 0.6476614468428583, 0.8044605964268527, 0.6283583419634524, -0.29259375898859286, 0.5354073616089563, 0.4633906208253516, 0.5332685295329419, 0.6661965559498197, 0.6547905364266476, 0.6535930949282934, 0.5117301844805656, 0.8390059585219218, 0.46249888502869974, 0.535288343401956, 0.5101220813401047, 0.9078352985274242, 0.7285598785489056, 0.7675504533756576, 0.9334141406197564, 0.788940803689016, 0.4483574493864445, -0.06300151284096335, 0.6362085073555511, 0.8647221911101514},
    {0.8922362399719937, 0.7730851411935673, 0.6264618440271218, 0.5423267205594261, 0.7144823026560402, 0.09669734299907176, 0.3966175400701306, 0.7950198147923538, 0.35727247050420596, 0.645818305536032, 0.3271564287326789, -0.01570407318115804, 0.9476460717867561, 0.6029303228677018, 0.7947139643045065, 0.8911423430439049, 0.640897624568635, 0.6011691145570135, 0.8337009680746955, 0.8736653575574459, 0.3554983339319749, 0.49158456183825355, 0.5789560503253879, 0.8628574984850597, 0.9508118101105392, 0.5051586833959923, 0.57992840362436, 0.7444379896217389, 0.5027414958986873, 0.06922202766946366, 0.6078427207630228, 0.6608112581767183},
    {0.6183152153288944, 0.8391074831970725, 0.9384640674826272, 0.8327945246637681, 0.8528370659677894, -0.2374917997442583, 0.4783879612565869, 0.9761169767283181, 0.5872322967005976, 0.5635678850677749, 0.3542881068089932, 0.09575550673405261, 0.956554707239358, 0.8030678054681509, 0.7619730890837675, 0.8458615467057501, 0.8167947168371448, 0.7567424860396609, 0.925106569728633, 0.5308005265845044, 0.3795742677406618, 0.707285478028745, 0.7089926276036208, 0.7186819419179993, 0.8621246028407671, 0.8754244414186468, 0.7972497526153248, 0.9134011053365797, 0.5065016076238641, 0.06863180539816008, 0.774792305036343, 0.7681819297922462},
    {0.8996395297654584, 0.6713138564191449, 0.5872989851501382, 0.6493038654516394, 0.8410918771529392, 0.19885044653039208, 0.5426571832831854, 0.7070796573330309, 0.4572744644785645, 0.41227202032533233, 0.6002694320061642, 0.16711412927181024, 0.531626095194301, 0.7491758783087656, 0.362430012954374, 0.959805878827151, 0.8799770822601345, 0.9719997781157859, 0.4926853097990431, 0.5304488846603059, 0.5830167180937834, 0.646286668032499, 0.6685479084060177, 0.7543338083752735, 0.8725624320063844, 0.7666644657550014, 0.8484010913463511, 0.7792980079609766, 0.8150122701052461, -0.11038538952610419, 0.9579291215008566, 0.5194670980852524},
    {0.5006011685525483, 0.8930092482189645, 0.8798368500693167, 0.4997986408995474, 0.5694952377951968, -0.08804122742215267, 0.6237683971478949, 0.549237744566237, 0.6545173753349949, 0.6750935689983458, 0.6282475392196915, -0.25726824327022657, 0.636538515340667, 0.5012624318981325, 0.3783002356950945, 0.8229288982006422, 0.9352030714309016, 0.9539170566251765, 0.7282157012572522, 0.9047398829553491, 0.5378970544799385, 0.5536164995266035, 0.9900422874637383, 0.5689184719254627, 0.5072264622484864, 0.8967394970878086, 0.45326900421284316, 0.8504115108250552, 0.447283831803565, -0.10622569660065113, 0.5268507196152423, 0.9373138578420376},
    {0.8084345360722779, 0.6461234862782962, 0.5660375026957402, 0.9713061154018346, 0.9140429810212366, -0.21914908779219217, 0.4221042629450255, 0.9542394913703536, 0.5976180812001533, 0.7536885188530746, 0.42324687517485143, 0.0006986922236631986, 0.6517100217981954, 0.8226438154190557, 0.5408292416058325, 0.8640614007215399, 0.873038498852852, 0.8078300261438097, 0.7467608865209749, 0.7223852368607196, 0.5971795498206827, 0.5124244495887849, 0.6208566291653352, 0.57003950609309, 0.7209379659758905, 0.796942440802361, 0.5502375777764215, 0.9231921165011681, 0.7234965812374695, -0.09604414442002944, 0.5913698441651221, 0.6500759078292171},
    {0.5841843569233646, 0.7579855165099482, 0.5701673994402762, 0.8743621439258057, 0.7012801081636679, -0.2611628167881584, 0.26338837305867363, 0.6587896553258737, 0.38173868193387256, 0.8840382743234629, 0.32152538048421153, 0.1141095985382403, 0.8348119071812221, 0.492923722093883, 0.4294824381397921, 0.825758807468933, 0.6037279391754843, 0.7463961791498153, 0.6891886795491827, 0.9402871855471092, 0.7381490420634068, 0.6353217546778516, 0.8742341946266982, 0.8857900956538316, 0.7743482919677738, 0.95391887305628, 0.664284237787152, 0.5821480369599651, 0.49247055380073385, 0.021487189194727682, 0.6152199322905525, 0.7241119736393814},
    {0.8621118371097084, 0.5937988725592437, 0.9403760992784803, 0.6450696544435646, 0.8572943920335193, -0.2563134699504936, 0.4645210995356118, 0.6176600269202563, 0.5742773986798156, 0.7174651492975648, 0.6381099297159105, -0.2668382423528478, 0.6967983672815377, 0.6698545550262303, 0.7101340172166711, 0.700996262348693, 0.8050639221268375, 0.9136019740545108, 0.6567989776504589, 0.4636320405798618, 0.581507702608765, 0.7102557857679761, 0.5574261632370231, 0.8413634653173176, 0.8684832428191128, 0.913864237415059, 0.5632972767152429, 0.5853881535795004, 0.5929390878059023, 0.027798091222604387, 0.6274632962015251, 0.931036026997761}
};

static const float b2[32] = {0.7138568685907205, 0.7043716701804903, 0.6838807084305786, 0.7227718443330818, 0.7218664469474358, -0.06913441905577251, 0.40155415493655044, 0.7272561822000906, 0.5488798080868655, 0.6467132506963365, 0.47598172410187134, -0.08381871137002349, 0.6804944655953565, 0.7021047973563898, 0.5753709789552813, 0.7630029693366915, 0.6976375032905244, 0.7152667340200757, 0.6797909238499849, 0.6729724979821226, 0.518905732853395, 0.7137471140130176, 0.7112297596225132, 0.682939670078358, 0.7015446563150657, 0.6782725336260529, 0.6877053623394875, 0.6569402637377899, 0.5148711144642265, -0.0905398328291272, 0.7068849900787116, 0.6820851445743004};

static const float w3[32][16] = {
    {1.0673202722634592, 0.9458805326181189, 0.9745240396523163, 0.7677977883665155, -0.30059776868807425, 0.2947427674211562, 0.1750320271101389, -0.12051286511922861, 0.5275891886647293, 1.06256610705352, 0.9728614105396246, 0.5962840315914942, -0.3128411148547377, 0.9961456080640901, 0.8232140253634725, 0.7036889706032678},
    {0.9419476988138324, 0.5316302942088482, 0.7841352964093495, 0.8866485876130129, -0.22839129544093262, -0.14108113027537098, -0.007297437454483953, 0.0946657131717131, 0.9453789699605537, 1.0325202917905623, 0.5286674928616247, 1.0371010247708154, -0.25203814029024874, 0.875969387540113, 0.8385284719902235, 0.9641195006449462},
    {1.0449780263498167, 1.050185475012137, 0.7824759675164185, 0.9649261331638902, 0.005275955726033356, 0.10267656215456349, 0.3102794777747729, 0.11222800013648862, 0.8006994943480709, 0.643453301912317, 0.8129953792020779, 0.6679607851663117, -0.33696695382745195, 1.000601978391892, 0.5345018648197902, 0.7949236729278281},
    {0.9066220570908587, 0.7323403557113751, 1.0916658519493352, 0.8631309806436893, -0.20685631276370572, -0.20784807846488842, 0.029563156675550845, -0.020285044335546093, 0.9133637041207754, 0.6087744557436526, 1.1048129517867138, 0.7064527895966198, 0.20016685309567545, 0.6371458791219985, 0.4984716598862159, 0.6130448942421811},
    {0.8199873743325327, 0.905952327994404, 0.8405505772407651, 1.0836801002042604, 0.1569653836405244, 0.2749104420751869, -0.26329533632528335, -0.14872762876900011, 0.6177232581966428, 0.569831276219051, 0.9142022199145325, 1.123550675291412, -0.08469340557995367, 0.565128055311306, 0.5354679093056188, 0.8079884685846973},
    {0.21798800076106314, -0.1079310917633623, 0.0696213247095592, -0.22947443189106762, 0.35884519244914487, 0.24230011530323534, 0.28471994945371304, -0.06461472192544576, -0.23513512743396023, -0.18908593070584506, 0.3884294456526283, -0.1682118298339774, 0.11828001131152094, -0.009681129664759208, -0.23481705953141105, 0.40481431480274044},
    {0.49291963277655665, 0.3886236197902699, 0.46874838490416265, 0.4060756267886906, -0.18908387476758726, 0.2998739247142296, -0.12576512797087194, -0.15186266710297103, 0.7908407240925467, 0.6792536776547584, 0.2359952083580548, 0.35158894816071334, -0.15715680518485503, 0.6221873625919683, 0.7862287942983464, 0.679533022807083},
    {0.8459434812559267, 0.7033389282008541, 0.7946013722916091, 1.0004621684242678, 0.1696222220080496, -0.29326729747111346, -0.14021536662744127, -0.10324137431629947, 0.9920444012753987, 0.5457075089517799, 1.120324307985221, 0.7195196557815896, -0.052061779888139335, 0.8475507818295314, 0.37693352366002925, 0.7856547979555774},
    {0.4956700914551744, 0.6112685351253232, 0.9445310095279859, 0.7958217859402611, -0.02662594030440208, -0.05978468811597862, -0.14989345533491616, -0.1557716230324108, 0.5509382396104455, 0.8197220233829909, 0.407541138366712, 0.4478931460150753, -0.18130355032543213, 0.7370541895367987, 0.9615404276943872, 0.9371949516484751},
    {1.0317547618317924, 0.419637036745383, 0.7539662642583376, 0.8466079344345371, -0.10435961989577518, 0.3348970414039778, -0.1267611931703567, 0.3125369523193963, 0.6807586458956615, 0.8445082402122781, 0.8754516613343098, 0.5446770893914347, -0.18290678495174129, 0.7951822627416628, 0.46228220275869564, 0.8936757177064897},
    {0.37041585338605576, 0.7090610107362154, 0.5893667855169643, 0.5204167598873196, 0.20477068364910056, 0.10183317967138165, -0.08908916997181245, -0.0212711061322183, 0.828757714174003, 0.36923801299397274, 0.642978205563606, 0.7366839795392747, 0.09956187418072557, 0.7581131539964232, 0.3882020179465139, 0.671497684591349},
    {-0.02628934218119757, -0.12836753852908075, -0.14605202975073772, -0.08771403934472198, -0.187785052684759, 0.22640728520288175, -0.3308440772638025, -0.2548085274542377, -0.24824512601043702, -0.18909999884639037, 0.27046311564263315, -0.257917016789971, 0.0260664184280438, 0.25320408159019075, -0.09165071125672007, -0.22026708110814752},
    {1.0607851483838748, 0.859216518473213, 0.7458091450423449, 0.6518911774812908, 0.003395459313163129, 0.31344767466920237, 0.30531160885994596, -0.06989964885801185, 1.0552328016434502, 0.9368092156785284, 0.9583440142017696, 0.9787489832575023, -0.29056935628213615, 0.8569355003406243, 0.993677013600047, 0.9075297335255851},
    {0.5726289856192138, 0.983140931376283, 0.7183128562216352, 0.7749282722844689, 0.2203645690762346, -0.061589375159962254, -0.2922883371569461, 0.27163468140247393, 0.7013087498309456, 0.8423969157109952, 0.6564240657000131, 0.8518693138720883, 0.041880515412764156, 0.90138338389185, 0.7136909389333376, 0.8095323166876194},
    {0.9877936897137654, 0.9587180739545643, 0.7429232611087989, 0.4504154450242798, 0.033432149154981376, 0.18542420316799837, -0.27360390999347184, -0.14392795868108668, 0.3889844365509916, 0.41081191246075777, 0.9380969817016629, 0.8853682828946644, 0.25355021398202954, 0.42648631577099705, 0.45960261835597804, 1.0123800971747665},
    {1.1116457246609408, 0.6471301480716573, 0.7169262390629679, 0.9533399463670286, 0.1196271535117424, -0.2080416070218017, -0.23048934430262794, 0.22660613251453587, 0.6810207196675275, 0.7443187844448894, 1.0716619776757323, 0.6483507981746053, -0.3044459131664064, 0.8236047230124434, 0.4102433085075108, 1.1419889042126545},
    {0.7491928203201419, 1.0341892555655525, 0.48297018838128636, 0.7105854048664416, -0.08245601400684877, 0.20676355093826757, 0.09127138820737446, -0.12682186245388904, 0.9484093725773065, 0.9907687124270487, 1.1282844131242247, 0.8631934459384782, -0.11544994043050866, 1.0790937458824645, 0.8469331422173256, 0.7649859116242032},
    {0.5473375801668237, 0.5825181167902684, 0.7253310201594244, 0.9038743980461598, -0.37147817820708356, 0.007133264971456141, -0.19955935132954725, -0.26091503257151494, 0.7617463888277559, 0.9950264121309249, 1.0381932434111059, 0.991013713968102, 0.01351855488304473, 0.9459717855732379, 0.8521791254002508, 0.7130744598511987},
    {1.0708750191827427, 0.5739112765142872, 0.5643208512348186, 0.6121792486150979, -0.26362084069619773, 0.25416929521246384, 0.12079697310149148, -0.1730028685066553, 0.41868841690630276, 0.9538149232937494, 0.9906696837434049, 0.9222388032399323, -0.03385737031555029, 0.9777494816189718, 0.8856875046005885, 0.48434059479822117},
    {0.6622849505079823, 0.845703650327945, 1.0512939652043556, 0.8807668214479263, 0.02200261507949412, -0.23042628680923294, -0.28621520457261596, 0.1893138922210914, 0.5453085100616522, 0.9953508543165404, 0.678876738337261, 0.4887332579286038, -0.2927548716486611, 0.6299749057169202, 0.632677975259012, 1.115149446415695},
    {0.4592912938206471, 0.9988244636277352, 0.7331468793750024, 0.8494859208718091, -0.25118195975637386, -0.0837378114164864, 0.24833143539689956, 0.2805880902869533, 0.3283922424662781, 0.4089505888616108, 0.4577723382571483, 0.7863245157278477, 0.10700130064012064, 0.8137475463367242, 0.31959250204362954, 0.5109432911235684},
    {1.0047692752432054, 0.5276927871083005, 0.5883605971688047, 1.160444909206486, 0.2515159485215082, -0.03960308321851383, -0.18077396258661352, -0.3327371045814003, 0.8626643018207003, 0.7937726403575077, 0.9125373451000766, 1.0935288838561683, 0.09245537220876998, 0.8568776148035091, 0.4907558498452528, 0.9010420896143363},
    {0.7767945190982961, 0.4999546187090517, 0.9297517396577659, 1.0498280855741002, -0.1513080160575139, -0.3109122000193352, -0.12512738360347025, -0.0772333792092209, 0.8741049733026148, 0.7775812426291202, 0.8064576438083042, 0.907208051847268, -0.11262542763189687, 0.9496737294392147, 0.535353372133894, 0.47228927351300026},
    {0.6719429585680867, 0.5063787210044076, 0.5566622320944662, 0.8412741542139507, -0.2668710652895786, -0.26778695065648395, -0.23530318968829989, -0.032982452466465355, 0.5532055984373404, 0.901899295171777, 0.6236967667724034, 0.877328668429313, 0.024326510922037463, 0.6613942035877827, 1.0373641744457172, 0.9345841116096307},
    {0.9930864090468958, 0.4607075899115852, 0.8872370507220904, 0.9961548900401349, 0.2669960721301003, -0.3574696731184831, 0.29074832335634304, 0.15309413990530443, 0.7819792419500117, 0.8023645900313003, 1.1415867527043828, 0.5566094325282261, -0.07879472837347888, 0.5637414060933439, 0.9307900812242796, 0.4622527895786731},
    {0.7200118306618362, 0.44237690456880807, 0.5838095475255828, 1.032915894249573, 0.22145767553001722, -0.0542094214863233, 0.2220930713375492, -0.14168928566762024, 0.5566913370980904, 1.065644276593978, 0.7523030796276401, 0.4870571739901293, -0.10642566962952615, 0.8898431809998278, 0.7060573121608923, 1.0409854010433741},
    {1.0143215371117922, 0.5777891463187239, 0.7201645120020046, 0.7607323653350514, -0.24268962820013826, 0.14797133842958607, -0.2637935890469083, -0.2564422682811127, 1.0107643472829975, 0.48260423946834746, 1.103663107220075, 0.945131888647995, -0.21543102317849686, 0.4945038604707284, 1.0154044821517014, 0.4627797673195543},
    {0.9413679665889219, 0.8832392265252355, 1.0401919568445914, 1.1503314104684652, -0.06284925635128381, -0.36760939736429504, -0.3669844534666039, -0.29509258586023696, 0.6448695544906541, 1.081512346866126, 0.795358894969033, 0.9150929406121271, -0.18754745222110603, 0.5066963881953861, 1.0372322876568096, 0.5974177487918801},
    {0.7583999732246894, 0.66469982036638, 0.45713420639713936, 0.5533899149711909, 0.0736579015768446, -0.002875412683018504, 0.12554678892847895, 0.008157762327796936, 1.0404462218452408, 0.49539374814157683, 0.505263644492865, 0.9710159517369269, 0.08163097114234734, 0.4469464283380069, 0.8109053126171435, 0.4070987828472507},
    {0.20015509140463494, 0.37067489873707504, -0.19018623349674205, -0.19000710147300448, 0.3024450794844551, 0.23887303992462788, -0.12239118141986484, -0.09447964266436941, -0.16610778776869314, -0.08377219031719182, 0.025711208795016004, -0.29275265568970715, -0.07375156459198198, -0.19640370547942487, 0.04722314104071625, -0.19683346263461887},
    {0.8153306197815087, 0.5554123663553454, 0.5678152457027205, 0.835476898022033, -0.0038272418988697632, 0.08226785728973499, -0.09984404111231641, 0.23568916367216003, 1.0941163507241494, 0.7157772301979397, 0.9416003755663656, 0.49095800339103357, 0.22350161975392605, 0.716209092541392, 0.6168013846649801, 0.7000554425521646},
    {0.7213201846873719, 0.5855835145808672, 0.5201395705948743, 0.8130730370708712, 0.053236987962297096, 0.24688526510850806, 0.3222897531351, 0.07132187474643258, 0.8502908202375793, 0.6713799454270364, 1.020097213472909, 1.1082479389003057, -0.19847867888882234, 0.9806438550356599, 0.4669568603721559, 1.013808314402526}
};

static const float b3[16] = {0.47825067038704355, 0.5918566310044, 0.5925444811995968, 0.560282746746455, -0.022782009296549954, -0.02318605907622253, -0.024402720883274852, 0.016849268626200307, 0.5222765687039491, 0.5180978976274759, 0.5019041792721, 0.5196540826606794, 0.024840966102627978, 0.5801076385217329, 0.5375670186646307, 0.6020669772698126};

static const float w4[16][12] = {
    {-0.8666258915263643, -1.1019039791347451, -0.21766944318075535, -0.7466065674264051, -0.5392552285704149, -0.9448586384348351, -0.39239629854986463, -0.8663652053118839, -0.1619168631297133, -0.1617228760726438, -0.5975012104609582, -0.856759705912776},
    {-0.39106293785565327, -0.9910316854949309, -0.890389532070836, -0.8672518225866279, -0.375858657640423, -0.5775473039488821, -0.5992750545790125, -0.5457667365570763, -0.6618772185836929, -0.758409943897768, -0.6884738514012763, -1.0201450402898458},
    {-1.0960914715502892, -0.9580386466083369, -0.48426901207355855, -0.8844138876454964, -0.5336480744162563, -0.7756024080091197, -1.008210047205734, -0.5785053456408843, -1.0014491016641218, -0.26292926772235575, -0.920357852262072, -0.410715882088108},
    {-0.9090204253585666, -0.6687776122210554, -0.5443247848093155, -0.9575226017705193, -0.8711598377243689, -0.5701427029811472, -0.5817643005756451, -0.847148418922427, -1.0231407009837248, -0.70572628752748, -0.2827370824298552, -0.7301089996932992},
    {-0.4025913416402228, -0.23493850602872604, 0.002961973391241454, -0.19752138411551182, -0.38364011235758777, 0.1429561596654258, 0.1854647540247321, -0.06322970228332717, -0.08755199692164234, -0.22368396863067458, -0.27829992259068365, 0.1874596118639761},
    {-0.3726125201214095, 0.35691240319461504, -0.28204197561382155, 0.017605327680279993, 0.08364233758144042, 0.06572460979431885, 0.366386621463504, 0.08423039171819517, 0.3264074323512004, 0.14899326075776023, -0.4434881412479578, 0.3087431952873613},
    {-0.07583795188741015, 0.13503709296266456, 0.04055278129686133, 0.302361414904705, 0.1886150711974398, 0.1825835243426606, 0.399760370196188, -0.4413375244284334, -0.06434247439974117, 0.09084515460847369, 0.3585312395753274, 0.21346173478758532},
    {-0.24280200294646384, 0.17278630418939644, -0.32372728967111847, -0.22222912011107362, 0.3186225910290777, 0.22360842287644453, -0.4145689642114799, -0.12100450369842465, -0.05460151590352854, -0.09506726305592962, -0.33589534939580595, 0.24413247028422658},
    {-0.8008577837598021, -0.37660451632290165, -0.5594567748566531, -0.9325964087497991, -0.13621426109501564, -0.8524257768873326, -0.7625883919247942, -0.7987950779677668, -0.3964969424682226, -0.7333708327113309, -0.2508308499545987, -0.8768721053808108},
    {-0.5950154671357404, -0.7040875889806683, -0.7644712610516797, -0.2381573128838817, -0.7997642064545263, -0.6717771221796145, -1.1024837400898648, -0.9825365027570573, -0.9051150484594214, -1.0493348304194123, -0.5593851556804971, -0.41809772898889364},
    {-0.2473462428571838, -0.5559205848128839, -0.614444625925329, -0.5584182878072316, -1.0121050666567972, -0.4969862824296447, -1.000100889965287, -0.8263336971510794, -0.9919956156767364, -0.7395282305542031, -1.0961314813728078, -0.595221248001833},
    {-1.093252970494002, -0.7070896015681761, -0.7717662776490417, -0.1620887286058779, -1.0313315995374055, -0.3329791383250386, -0.4212083633100667, -0.8058229124870874, -0.1950558392649809, -0.678998652761966, -1.0388174852881642, -0.894567104267218},
    {-0.06308014289556495, 0.04397008193008602, 0.012315582420027546, 0.2803176577354024, 0.0908421534073409, -0.07447994331634948, -0.4728409188156485, 0.29003034743358985, -0.11827810558089474, -0.41020000177158183, 0.14614631366291228, -0.12983591345242923},
    {-0.25196243610575164, -0.9271182178601912, -0.9720434606774373, -0.7216840248462933, -0.9322794531445077, -0.8740812337308848, -0.7319092362181068, -0.4848821914828584, -0.7359015789222906, -0.9753978204464467, -0.8710660431993675, -0.6812485120640261},
    {-0.8100233471756764, -0.3002397871594415, -0.9720862947350689, -0.7654363908324312, -0.5416660541476592, -0.8854902850986641, -0.2793544782818573, -0.6206312358433776, -0.609666419187128, -0.8579505664117442, -0.9670742766301973, -0.6691130041560794},
    {-0.6552639095381132, -0.34059987700278177, -1.0121128363564966, -0.9334458895632607, -0.8578805206827484, -0.74540071316023, -0.8233577934971985, -0.2788150056152255, -0.9740621766208214, -0.8201039157894126, -0.46564116828719904, -0.5509886031965852}
};

static const float b4[12] = {-0.2902801250196611, -0.25119927469844744, -0.28193363836693586, -0.18869779244529697, -0.24423882496512792, -0.1128288790806741, -0.28293863923699686, -0.3390776280515407, -0.17420205130778188, -0.26408331811557356, -0.19681242063724938, -0.28186228729420226};

    // Input Layer 
    float z1[64];
    for (int i = 0; i < 64; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[32];
    for (int i = 0; i < 32; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 64; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Hidden Layers 
    float z3[16];
    for (int i = 0; i < 16; i++)
    {
        z3[i] = b3[i];
        for (int j = 0; j < 32; j++)
        {
            z3[i] += z2[j] * w3[j][i];
        }
        z3[i] = relu(z3[i]);
    }

    // Output Layer
    float z4[12];
    for (int k = 0; k < 12; k++)
    {
        z4[k] = b4[k];
        for (int j = 0; j < 16; j++)
        {
            z4[k] += z3[j] * w4[j][k];
        }
    }
    softmax(z4, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
