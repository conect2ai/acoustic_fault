#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][16] = {
    {-1.491323338988271, 1.5036926208810129, -0.2516037565656868, -0.22919132811193726, -0.47269676036174835, -2.23941194645666, 1.3307488424633418, 0.2881565960079471, 0.799535541755473, -2.1476811756315914, -0.38596900245698174, -1.4564615447210987, -0.5338315815956128, 0.25766213882646194, -0.5585354503510361, 0.4974033087982343},
    {0.16092970862971928, -1.6988781929050112, 1.0713923269966927, -0.01647565608840524, 0.7959277343469038, 1.7414251698552388, 0.39430696292281414, -0.6175223888162944, -0.11299205644004337, 1.5137938680234753, -1.1294653082589603, 1.1697480932254418, 1.2131220527046658, -0.13674506192917077, -0.9445888480865463, 1.2294555052178207},
    {0.30131115967061367, -0.11844304149735814, 1.052225982173006, 0.9522641470942881, 0.960962168370026, 0.5748747228455596, -1.136765877377497, 0.33930975492689647, -1.0296966068808342, -0.23946550553574694, -0.4109361088600172, 0.5439056968979356, -1.240788718693672, -2.0215885772587256, -1.1109436391803404, 1.3973861275402102},
    {-0.0540585024973648, 1.3156810564701713, 0.058033560362530906, -1.0460419818566287, 0.9317811785591589, -0.05624694338059726, 0.019080074118936533, -0.7021635492577717, -1.2627199954114594, -0.8038899527652517, 0.4458658873985005, -0.5368863713513029, -1.9631259306537783, -0.41773332539715974, -0.9531801215549647, 1.0893166066557336},
    {0.187234883885261, 0.8773611539511316, -0.08798225697824437, 0.8661004345672397, 1.0249109605524434, -0.04257667586485575, -0.5431739725254177, -0.2620863258657803, -1.0893727906066093, 1.1621601646193103, 0.6912485710164477, 1.0570567526343102, -0.593269848226506, -1.1762749742394285, -0.305605138377339, -1.2481656275405857},
    {1.1185711763612982, 1.496549106686159, 0.9927990632050653, -0.07843965859418224, 1.5679164910558723, 2.0005441930264998, 0.6908979489894977, 0.47021623429813403, -0.12191158403290077, 0.16223201095962098, 0.14528622817659156, 1.609667384407459, -0.6667779474021068, -0.24097528354014822, 0.5422331830189397, -1.1229699560274906},
    {1.498668921887472, 2.3671593348273743, 0.9534711899117437, -0.5728912260045934, 1.3300151844504737, 1.8665254475322255, 0.8812439216858127, 0.7732163918206092, -0.0707873587278923, 1.0135138896587468, 0.05635940931392498, 1.0312963495154837, -0.735948742646482, -0.13540076496603462, 0.1590796418411405, -0.3707823578630143},
    {-0.628375986022008, 0.1590486381002048, -0.5639922005181366, 0.40876015193751575, 0.8476850544026981, 0.5662506065686399, -0.07881697420662648, -0.3803860219032427, -0.1358957149603164, 0.7998530357953052, 0.14727361462827657, 1.0310782434663934, 0.6077689674316069, -0.9678147200069143, 0.07171147050120406, 0.35923554221224513},
    {-0.5311036073362055, 1.1538872142116452, -0.4488675611514522, 0.9053367724167112, 1.1668393850841055, 0.6028545350121184, -0.01981078985154659, -0.3729382214574324, 0.1630230623882151, 1.159717169013991, -0.7064073509463352, 0.8009788931671479, 0.8357531230577526, 0.40686183080256627, -0.5789437065766447, 1.229498936189377},
    {0.3207296074227261, -1.0980267121106446, 0.31829316448234457, -1.002768915349738, -0.4165013045810767, 0.5124095117914341, 1.0026136318938557, 0.1845653429358768, 1.549078967389854, 0.9280139660396188, -0.9110944761822858, 0.6250637659885877, 1.6303029781833802, 0.5447635268070453, 1.6146856152977969, 0.6463241553190135},
    {0.40613659441441996, -0.6845380920320278, -1.465876999678274, -0.9831264217857336, -0.8894140373719771, -0.3943989443893798, 0.4862450063150532, -0.10093106418690496, 0.15076778735326257, 0.6330246237923393, 0.2305812846416602, -0.09048156475066685, -0.7637972219692541, -0.9594877970863698, 0.2167958425570785, -0.793759303158578},
    {-0.1917403206013185, -0.005298440953752684, 1.0066322737009643, -0.8056784136190597, 0.2887702900052382, -0.4553908026581349, 0.5920173456265594, 0.2671059346292916, -0.09415598641014818, -0.7898590715073932, -1.4840493851514431, -0.5197418050356377, -0.1584722041214737, -0.1779282596199241, -0.5670479761434141, 0.8561422072776332},
    {0.9868516440996088, -0.5478384204604468, 1.136839485889125, 0.3284796559777305, -1.0941564483433464, 0.8966747264488143, -0.9715088554896975, 0.30009449166697333, -0.17381119946073728, 0.8836002346385798, -1.1981267903745751, 0.5746119848379186, 1.2713229802056771, -0.8168827432753214, -0.9160444013251895, -0.17061199823369919},
    {0.8256703870939744, 0.8350821933321807, -0.7005835962279097, -1.3251694529707436, 0.9379151120296311, 0.9470584093315231, 1.4934412975701616, 0.8950146040934772, -0.08901056251971488, 0.29497088266264193, 0.6051402681202298, -0.4950678189676375, -0.7152455076513616, 1.8959314243061276, 0.1510514047225449, 0.6464241552540686},
    {1.268421768126978, 2.2043897606381697, -0.668961111692312, 0.07350164717918566, 0.3486445690060074, 0.5681340931971824, 1.602459671118526, 1.6025294508402173, 0.039845762843124424, -1.6895660687834684, 1.6958787471580945, -0.16704211190428153, -0.6322249356558302, 1.7117998649072768, -0.14942436033542822, 0.27221810449801664},
    {1.3801198095474072, 0.30557097846583176, -0.08348141373996855, 0.9048008661015483, 0.4701651533027243, 1.890876226602872, -0.16591274986916638, 1.3127779427757336, 0.43629267852462095, 0.0041849346035390715, 0.003850723909665324, 0.26958988565257136, 0.7149891929588043, 1.7964735532940437, -0.20148045024279482, 0.6598557438306372},
    {0.9335540505319218, 1.2196542217386215, -0.38509852151926205, -0.6665173971960984, 1.58142650297724, 1.645174717927783, 0.9475836767966204, 0.7689873436125604, 0.005602069827634239, 0.5153409946760079, 0.7339000448227809, 1.3422642829071503, -0.9202281659941356, 1.1408793419400876, 0.4056910527292206, 0.3522944133739315},
    {0.5809645119399194, 0.6851752959378367, -0.5720629388283822, -0.7409034753929772, 0.46164447350305765, 0.26320998410848784, 0.902453241498554, 0.7168316205583828, -0.40468673959511897, -0.3285173198828294, 0.13358174123480468, 0.2174196009844345, -1.3910268782691022, 0.45623696569395944, 0.034937498000191386, -0.3202896483727864},
    {-0.65095849729091, 0.003723073548201313, -0.1397883488608952, 1.2089830391942544, 0.1249475627455728, 0.28834168102296814, -0.4742209127249528, -0.5557729737052193, -1.0006366775435487, 0.8570344729549165, 0.2650195217404536, 0.45287749599344257, -1.0751121193509545, 0.06553906191838013, -1.570740096680165, -0.18884275565230096},
    {-0.5089554905290082, 0.03004015314115911, -0.12698580226291414, -0.9304108497196468, -0.056871512281932116, -0.4965511690686205, 0.6776208517563534, -0.12538720143843252, -0.11005667503470518, 0.11079114705948566, -0.1031047217247384, -0.6281049793682091, -0.7879012636090638, -0.8480356486687398, -0.5923994880422352, 0.0007690207871843071},
    {-0.7146268655934644, 0.2562188142051426, -1.0138994372882457, -0.020555468061790354, -0.2077726088394268, -0.3346492124911378, 0.007001720846447759, -0.3050604656456052, -1.0562893288473179, -0.5398510794671193, 1.1380692864807036, -0.9569510654440708, -1.6572113147200238, 0.09807868709515942, -1.2095020362750482, -0.48071151791477146},
    {-0.256293508585993, 0.7723900068748291, -1.5115293596887898, -1.7083330017364038, -0.5731516544071593, 0.2527617915775065, 1.359318304168835, 0.5952353551480782, -0.15250677704355348, -0.20074549509052353, 0.8725893587435488, -1.423962194704514, -1.08764406030482, 0.8455801129209888, 0.6051042607133832, -0.6512000324810349},
    {0.023036259876555512, -0.16375897980353743, -0.11234027943034418, -0.2511475725631497, -0.5284094907094723, 0.17551676424687032, 1.018374823337672, 1.950505481198347, -0.29658447359315787, -0.933485890007002, 1.7709096846887802, -1.528472016612761, -0.2858400143180958, 0.9709691143743621, 0.29497684447861167, 0.9079423170572652},
    {-0.6937530287802092, -1.252569760718451, -0.8644470780922051, -0.37654663628054663, -0.2587527175017602, -0.5183040145212963, 1.2865497505419126, 0.5513746771879691, 0.12014675566894222, 0.5671763902475291, 1.1766473977238674, -0.7101527716642293, 1.0518121680379713, 0.3062651350360038, 1.1230564214675163, -0.05416045128110803},
    {-0.5578276656164343, -0.08099797677433486, 0.1592856628298181, -0.4317096690938653, -0.0507167670213954, -0.6360612094549354, 1.7515285767395135, 1.3345903871164266, 1.1947804536021132, 0.4896795127103759, 1.6573074693361516, -0.7588376256667111, -0.22235167423068036, 0.8446253187956342, 1.5116041698185076, 0.636962675252249},
    {-1.7505271655617762, -0.984809935873587, -0.9297442595014735, -0.6487817569184303, -1.124712087383783, -1.6748331410786719, 0.37043645111072077, 0.04479796085778031, 0.3869918209085937, -0.6785155605441869, 1.035146246983562, -1.3592176085057508, -0.5309164719354765, -0.8995003560286186, 0.38082219405427625, 1.1505549385772584},
    {0.10562915348970138, -0.523693599458338, -1.1035778773869156, -1.075937683154738, -0.871488816321976, -1.2094745882614035, 0.8892768019260511, 0.9041573920748165, 1.539445453091606, 0.08816693943917175, 1.7136701820487976, -0.8203319916748812, 0.36184574047294027, 1.1383685319319996, 1.5995555667740724, 0.24810545133201536},
    {0.02975125377142179, -0.6264556136896828, 0.5263693356966966, 0.5689904126506377, -0.08265979502025426, -0.027392011907242365, -0.4126506627708608, 0.46993464528747764, 0.03346808424976707, 0.8298181186828165, 1.197885346680499, 0.2740376849855471, 0.14998725464584792, -1.0814453720729564, 0.22005842792390512, 0.3002119255211884},
    {0.0853141985191303, -0.6822211522645881, -0.5483760346685985, -1.1620849494752021, 0.007094249478813698, -0.6985217865250134, 1.258289081245482, 0.2752361958161006, -0.39826485907685893, -0.49892594955228714, 1.129758632208956, -0.46468273998277937, -1.2592652877016008, 0.1495925179360638, 0.4073612473852817, 0.08282341903592111},
    {0.6205289388319367, 0.30247702409218563, -0.3247124218581324, 0.7286746980790338, 0.027874240578092693, 0.011406187801885834, 0.15432340204928396, 0.08754175420002916, -0.04158777290592768, 0.606349408094525, 1.355032294215222, 0.42801192999530546, -0.8530974061996695, 0.4061965724207637, 0.006870963936833323, -0.08685067374026689},
    {-1.6060244118087048, -0.014759241028306995, -1.519193403975713, -1.3199874552734376, -1.1526509180222435, -1.1279283440094447, 1.4783612007079565, 1.2029211104952326, 1.5297107277137936, -1.0768517675675855, 0.7102930991814392, -0.9093179812328054, 0.38280974710429566, 0.8774414944493438, 0.9510152823018149, 0.3956816075482025},
    {-1.4736857716388851, 0.053443130681392614, -1.7569355262363207, -0.8855844313615971, -1.0385189576207663, -0.9340528466548749, 1.640975244387145, 1.6097658373256367, 2.3107035177820436, -0.9506443735123876, 1.5968831673038049, -0.7825536044649329, 0.515608246704837, 0.7088887747157027, 1.245297246503646, 1.724835537270648},
    {-0.6921632581340307, 0.4046937424035057, 0.18004709706152025, -0.3696993322106855, -0.42124407227114524, -0.415369220935842, 0.982473137462363, 1.536284465918872, 1.5681645757300795, -0.6750329016673845, 1.110001102084045, -0.6127567126342569, 0.8620347750508761, 0.9002343366002743, 0.8112711138969186, 1.2656951189643333},
    {-0.5017146444216622, -0.3134526042072261, -0.49867068120990904, 0.016962205862753637, -0.7580505664070174, -0.24112927439146356, 0.7641258273853285, 1.2168621770115144, 1.574337483542375, -0.7327892909425859, 0.8560889434070128, -0.40940661602235473, 0.8571467669643037, 1.0783132846534145, 0.9838722414458541, 0.9339282404373921},
    {-0.5081639008287184, -0.017705436731647227, -0.25501585646810754, -0.6725403128843604, -0.3482426478029604, -0.1509945512758598, 0.3790932499459315, 0.8734223240086104, 1.0737694567700484, -0.6390958708757957, 0.7122013425463197, -0.24352761345280305, 0.24559970803737685, 0.2709804971160589, 0.9434271518265662, 0.6402038575653234},
    {0.24763239174139168, 0.15206759898468303, 0.3925248243177255, 0.1504396593929315, 0.42776324776182845, 0.009862487361055057, 0.8794553099412932, 1.4131276913089132, 2.082300120720979, -0.025313993343573572, 0.6804722441800173, 0.2727849358532533, 0.6921489048740637, 0.7751565107364979, 1.5863139305678613, 0.7248316920902428},
    {0.13331066624453414, -0.18633356788184202, 0.3311941919027972, -0.05564371470869807, -0.3432424434216403, 0.25487102744777407, -0.02024569112106791, 0.723963057338085, 1.3805973029149408, -0.5753310584078615, 0.5985823685922037, 0.09734946341660378, 0.18312954368491222, 0.3956113851484125, 0.8651589901758152, 0.8117520702975977},
    {0.2866134473875419, 0.2970253033886297, 0.35444391582356716, -0.12433739578237095, -0.23174634376778383, -0.07771699361959544, -0.7253207313301856, -0.3348220667472556, -0.33313781932384645, -0.5976313244815611, 0.48231604835681474, -0.7402731296798295, -0.5632750469319211, -0.036059779819599166, -0.6466396739950037, -0.7275972664663923},
    {-0.7310814673248093, 0.2439891485527235, -0.6549512379921085, -0.3282993116179315, -0.7723761442021644, -0.4388975218663734, -0.04712976299875947, 0.6379300430550251, 0.52049830556474, -0.8419549248403071, 0.43538135387792143, -0.8100005226831057, -0.16653049881334356, -0.31469021292661936, 0.09565495467439714, 0.29417349331671505},
    {-0.1591909615344781, -0.06466726084375422, -0.47256784996383283, 0.1945669625550599, -0.3696376347334975, -0.23521500509317678, -0.2431708931873334, -0.689029422937538, -0.5603071574653048, -0.10583130387107102, -0.5754722896633208, 0.02124242031753194, -0.9824021714665969, -0.7438445585347627, -0.48979387575696276, 0.005330164406467119},
    {-0.09742810565135167, -0.30929051951616476, 0.4941293725414444, -0.005692572634725426, -0.5603030493823339, 0.0764637512674452, -0.19611833387406136, -0.16770802764393455, 0.37822957707468585, 0.03478901587504524, -0.32372314401449687, 0.16059668013189538, -0.5412670461523474, 0.049599125495035964, -0.23309470206832675, -0.12967133814455692},
    {-0.2162728337418147, 0.21456072628961304, -0.1491552689576516, -0.5042678786421215, -0.24677286633306034, -0.230383567845225, 0.6059119378332277, 0.7794025192562559, 0.5272547790996689, -0.31496775270643007, 0.4785712672470932, -0.44674940260253043, 0.2561540054636258, 0.140129245488743, 0.09220683491879283, 0.3710626863150605},
    {-0.31540767940479114, 0.012071486789948476, -0.29540082072935314, 0.030284198267398556, 0.040161340701961895, -0.20033713097926753, -0.1362425368554428, -0.6596260509048514, -0.5138825714799757, -0.04365715975840974, -0.4805031778629489, -0.16676793722118827, -0.26321437511615736, -0.05180240596993177, -0.24051121070779805, -0.13473872061751946},
    {0.10689544413509074, -0.0767504668509438, -0.12532996237368768, 0.03899228053191154, 0.030880823499843526, -0.1045511091282083, -0.017161644770890296, -0.17218291780297673, 0.6019411926636897, -0.11006205990706684, 0.5086223737648686, -0.5582158501200082, 0.45319312944722023, 0.19736432652432984, -0.252885221298069, -0.01406689795938978},
    {-0.061868850110022126, 0.5132971240281273, 0.2770053121810777, 0.18194648862506188, 0.4441831078864301, 0.05368856457259574, 0.5038971979209719, 0.42540299755951994, 1.3396831303479821, 0.09004853153694577, 0.5046716264190971, 0.10209685199532548, 0.8997972640183478, 0.597567592479655, 1.2553391120754924, 1.2589021612921687},
    {0.04120872456593933, -0.16655206108976717, -0.2684720867053417, -0.30827052280465916, 0.16924991946450618, -0.25576266351773075, 0.2114547982739085, 0.07492514541046402, 0.2858197350441958, -0.3444676436508353, -0.1869607041786364, -0.3101204975338257, 0.5369529922786334, -0.17671322493578387, 0.3996575873706786, 0.608855214638569},
    {-0.3392880635514304, -0.03721082420223597, 0.2024170687307518, 0.14039353612868227, 0.03732646183180387, 0.13423869960609028, 0.1589147109075915, -0.014174797268942678, 0.027252933232395984, -0.25638477783864855, 0.07172921969492452, -0.34813755055110523, -0.2560296853337524, 0.08352898684308781, -0.17888436171886818, 0.011234062807461654},
    {-0.21456919540737635, -0.7705804742078487, 0.4855922914669413, 0.2781966720705713, 0.369399028437884, -0.16771100085812501, -1.1094964552301552, -1.4368769171020264, -0.2518756751887848, 0.49564150408628643, -1.0459854956692138, 0.4348842775168296, -1.073075612726245, -0.5503300390742493, -0.04588295396946756, -0.4802207106467736},
    {-0.48525990176773864, -0.4541366244067621, 0.6705117490314267, -0.060987673941619976, 0.09730641436160692, 0.33206975550979717, 0.3830871984717278, 0.15659411916490495, 0.5501891844712913, -0.30243791379329493, 0.022911421321471916, -0.38600585633649614, 0.7635379287971835, 0.261643744451221, 0.7352772491984152, 0.8600898031618501},
    {-0.41752212505834735, 0.0034537510619121, 0.560043317430126, 0.17601133851733808, 0.3417756928642181, 0.2365515146313705, 0.06512999915031753, 0.06957565569717848, 0.04286241087369538, -0.43109710301736376, 0.2131342677100836, -0.004712047941568415, 0.16040189382957792, 0.06368980331233279, 0.22401015336501978, 0.13827369309432075},
    {0.04454998478666586, 0.14120389055818308, 0.599984494916911, 0.06721342551153595, 0.15961363634715697, 0.09822467222019488, 0.0434892828432688, 0.12832147513902423, -0.2259157925000199, -0.07340891248008928, -0.45646197071405253, -0.189549352661294, -0.31579934024953965, -0.2827884994221956, -0.19768259344321598, 0.15844942265461415},
    {-0.06329206542729478, 0.025273750306214603, 0.3394678664687418, 0.4146449792451406, 0.443165045035021, 0.031197629604943763, -0.11125336054543329, 0.34656817034686066, 0.39878194968321146, 0.432867367859602, 0.039170218826233935, 0.3165123998111043, -0.41198768487146825, 0.36588592705905365, 0.05132230849604643, 0.35119695214396257},
    {0.6146675785617034, 0.41655571718923323, 0.0782166158523135, 0.2662389320865318, 1.3904895871910294, 0.4873011201656956, 0.6053076312512029, 1.1657418268284763, 1.3860112855963194, 0.0681426965385866, 0.6899684038180057, 0.6636553013976862, 1.2396806169174743, 0.7966976360978659, 1.457558023021099, 0.9775392978645842},
    {-0.4046474175263526, -0.26921272214687647, -0.6484340215408347, -0.5622103416373334, -0.36364349984204, 0.22080266758479833, 0.19575059758668986, 0.580643247662308, 0.5155301036095192, -0.6996517582909513, 0.3290744897676034, -0.5211030308576646, 0.3444372641352077, 0.29969907311342736, 0.8985964939500233, 0.4635384484878343},
    {-0.38803455371739953, -0.2860581235574332, -0.8111889677153696, 0.24433227328035517, -0.7743104727870492, -0.46400379586612583, -0.669161652470698, 0.06027550032564078, 0.38590941270786794, -0.2992622347849829, 0.394119724137444, 0.03292206600054399, -0.8531628190592407, 0.2347516365409303, -0.24175387579397625, 0.15649929919739475},
    {0.35705612226851496, -0.1184288082567148, -0.1547002915094634, -0.05657305324939456, 0.6012045016051455, -0.31828660181768115, 0.2741328985195683, -0.6229149535732966, -0.01078107128827671, 0.11449952167437856, -0.28962436949185477, -0.39703855991065606, -0.10100071574863274, -0.4179645779721176, 0.3267998260086819, 0.3487404877166067},
    {-0.2117298578926392, 0.04110666717902936, 0.34991657228072864, -0.24309317603279113, -0.0553419506754752, 0.420248635157813, -0.14311837725376486, -0.33380452883807027, 0.4218603318314689, -0.8072232428113437, 0.10707519308909363, -0.38942013078836385, -0.27264827269539293, 0.05565847820906029, -0.054328824926069684, 0.01174201860500773},
    {0.13951730491592282, -0.1283027166609534, -0.21380581636957074, -0.5838952840696472, -0.2266222940794889, -0.3828174749767223, -0.2048678971107602, 0.12029975273972193, -0.5519367581891629, -0.8173211045921992, -0.3466983430961165, -0.9237896703920643, -0.8444008881130143, -0.8023616961401613, 0.05702178317519365, 0.13032753411426182},
    {0.5602659280560816, 0.10141739017911688, 0.4827665909188439, 0.5864401501189228, 1.1169851679086267, 0.42162188668432715, 0.8997155563543296, 0.3787711537734116, 0.8213573797141359, 0.34486764544707116, 0.25099151339838655, 0.8115502833151218, 0.44569792799832325, 0.829376123777108, 1.5845256784162545, 0.9350201717647216},
    {-0.1358836310510352, 0.39634622216662935, -0.7235235323222338, 0.017988400893050926, 0.05435088008448453, 0.07803458812525804, 0.4771992716549827, 0.10266003460131211, -0.27318212189950686, -0.42528643336674454, -0.5098295433746504, -0.48501394803014736, -0.6725156157253444, -0.4525871782128111, -0.11879811604714954, 0.16076496712403932},
    {0.0356565410172638, 0.16098100514850575, 0.4307765284794733, 0.07500341138010475, 0.11129412919794689, 0.040496975085930836, -0.06954432513739588, 0.34864958445788313, -0.008330686542122925, 0.33963785519326906, 0.324722820690241, 0.456240088663383, 0.4180436710388234, -0.44101493478683523, -0.32109474593973175, -0.46392035315303065},
    {-0.10610238239581683, 0.35834284167603897, 0.020946503964359597, -0.03012906362571659, 0.021949601208525914, 0.4971912289681988, -0.38530838261662137, -0.04882471861118415, 0.014014733255545572, -0.17075556069920877, 0.39090285410480563, 0.035756183513044194, 0.22278686181961713, 0.08249295157105345, -0.6434117157143485, -0.32405160879821754},
    {0.1836846891998428, 0.10912365651931338, 0.5568576037642363, -0.38753422524970915, 0.13820287888758184, 0.035808976930514304, 0.42354794937936296, 1.104363603088119, 1.0231748078512082, -0.09622832653844442, 0.899718489544831, -0.25549614609389715, 1.383120686127558, 0.6634074379711346, 0.749643998860388, 0.5123212653706362},
    {0.8026483061030182, 0.23785687743529424, 0.379990806707677, 0.07558388916184454, 0.5924404940357516, 0.28659295033503385, 0.6371985083169527, 0.5395251718079915, 0.4168636438187869, 0.29397910781857706, -0.08982171204875933, -0.05253592253278905, 0.785862125767484, 0.9482818468659782, 0.5524959376276884, 0.777971806604776},
    {-0.5777418620856362, -0.34334000556575617, -0.5155705127773581, -0.2750599268132109, -0.900385071764373, -0.30655344052946026, -0.31499413109514723, -0.07791449168539995, -0.7530707272354953, -0.20966938897714205, -0.46601080142738643, -0.5229561957180399, -0.8884173554102098, -0.7728429275331856, -0.18689919474231131, -0.27404496439566195},
    {-0.002643317411541823, -0.3429974747387287, 0.019485050776680418, 0.3391645881854215, -0.13888004246015428, -0.4787257756876439, 0.027361421549057113, -0.11600760018201593, -0.4947896767874763, 0.5115034130225183, -0.05603242806175392, 0.24643050794252463, -0.13611604670664898, -0.16665271123745287, 0.380989829896337, 0.12280993320509619},
    {0.828391356164861, 0.21977759268748615, 0.8533318248745619, 0.42506363000120734, 0.9258118448417894, 0.5480262662210367, 0.48170375682795996, 0.3106262412655596, 0.9290087020505643, 0.6221736451415703, 0.055440016475839016, 0.47870445951181856, 0.5270930004683051, 0.8301449125532983, 0.5234239543493909, 0.6677571302987811},
    {0.08458438006050134, -0.07495892982376026, -0.2175267230971994, 0.15236095074798778, -0.24066611951049344, -0.12835247618340312, -0.6913339669500904, -0.7515354012455915, -0.040661121617304445, -0.28769677547829653, -0.8599152336207154, -0.2580479787819081, -0.6214455015147564, -0.5821998385531811, -0.535820345443885, -0.3360520825884955},
    {-0.2656718297437129, -0.16313130255990319, 0.3062055007329014, 0.23801523881420836, -0.1462880516377568, 0.11544220977539245, -0.4535604873412256, -1.1545713831558664, -0.7064113493953831, 0.12538261121267008, -0.19922735767266367, -0.3661289075930474, -0.8344748736322037, -0.6315917623042934, -0.19878054706031495, -0.24304088204856536},
    {0.2954267434676659, 0.2519787618215214, -0.040960789078190854, 0.07748247134293136, 0.10165798669296672, 0.402816559870396, 0.5608530333102385, 0.3696511408978325, 0.46860367454765367, 0.2778635469659008, -0.21196700406322258, -0.1444353235363891, 0.3234301587896177, 0.3836142708410726, 0.6747848529413734, 0.3320598128477761},
    {-0.38872411839198134, 0.15244771191292794, -0.17381890347751772, -0.4437366890832324, 0.1503647196509103, -0.11448756179265326, 0.05239733753632961, 0.6073588702132998, -0.2016958101187598, -0.41679479886044957, -0.073486649211917, -0.31568779114580825, 0.44061186193923046, -0.15399369378211608, 0.25998818588654654, 0.2512741432771101},
    {0.10229018617009247, 0.112504241557764, 0.3692393812355726, -0.4446350350512846, 0.541859683001903, -0.2566742236598145, 0.24326297479439937, 0.6853221277730714, 0.8157513783785156, 0.18887033684429955, 0.5090145431730139, 0.22047377143395536, 1.1702199097263373, 0.1536140912613205, 0.29747636608561195, 0.5380995265781572},
    {0.4564897376836335, 0.3562406934324386, 0.7204048753315722, 0.46147744782859174, 0.7254969843799072, 0.3627092672882104, 0.4140717174588926, -0.15342223719518075, 0.50184674931528, 0.24186733849848976, 0.6992943471551403, 0.3393861614453221, 1.0126346599313614, 0.4237487969693412, 0.46756584835459175, 0.33744117826517983},
    {-0.1559382464544168, 0.26178005278679606, -0.3244145830724506, -0.16615300163470378, -0.20289811824463863, 0.2151083343104387, -0.09796944150887942, 0.2504949307967816, 0.43849215215747855, -0.4729088499798801, -0.3059154267443705, -0.5167597867763392, 0.32529591096391525, 0.32808037382914335, 0.49831330020076914, -0.02048712668910968},
    {-0.8772403661281494, -0.27697327775843744, -0.7530438332312808, -0.33292171819650773, -1.0280195562619365, -0.15922106483539206, -0.1375143943317849, 0.04920547565872591, -0.43557710580707687, -0.0527527254070142, 0.14985047842045376, -0.03639861989988344, -0.6887390267441397, 0.01651785041014366, -0.453457716869237, -0.535599030182091},
    {0.3648707577894685, 0.31126929471481374, 0.2198613526146622, -0.024064504201098288, 0.46776439219872773, 0.361856636898344, 0.2820187057800011, 0.38118552083593227, 0.7927295822996469, -0.016777095837540525, 0.09805753473240703, 0.11047218766278825, 1.0369809116128872, 0.9805931948359404, 0.8022367719458944, 0.5521828604890104},
    {0.051896673792627815, -0.13064740769830233, -0.1731355001329263, -0.2124791811643837, -0.22282545730952685, 0.022526282437825736, -0.03419372472501288, 0.26947126360955437, 0.19270090392847897, 0.07355578398357386, 0.3050070690894078, 0.008752902323429991, -0.545515504155212, -0.13464518723512603, -0.11211114516339205, 0.05638222331894875},
    {-0.45007101339914873, -0.13706336018594834, -0.4321261894018673, -0.2875591968862174, -0.5126853827014896, -0.4227808792155864, -0.18304290750989988, 0.026657358850362394, -0.14693873249263356, -0.30146005318525243, 0.2860357954371705, -0.610739954997256, -0.22537448286181758, -0.12055350094369874, 0.11837442652608555, -0.0888879655336438},
    {-0.14366567814927078, -0.3558476791944178, -0.7282212049164487, -0.3287755026045504, -0.26516006277281257, -0.34385833989559317, -0.3459505926210413, 0.21988248031024413, -0.046400845564753886, -0.2785453108355973, 0.33833050846578205, -0.10120449441080374, -0.09347476726574094, -0.7233792406715224, -0.4154416588426039, -0.13886535455962803},
    {0.24805898815798125, 0.0893090038208448, 0.21542475888581575, 0.3148453794002985, 0.6427070971375117, -0.062056412827978684, -0.10779081812157318, 0.8526552825492432, 0.7071769597578772, 0.42426006243675135, -0.18761021574986134, 0.12458497637972704, 0.3940054747123565, 0.7597122509312098, 0.33709203867934906, 0.21091467838609307},
    {-0.17771966295261735, -0.29581235317646276, 0.029820059665242885, 0.06949835470071751, -0.4546010841034735, 0.20097244293604505, -0.45735117360003946, -0.25710732318501844, -0.12093829540619552, 0.1964185460477268, 0.04925658054185159, 0.3701188586466889, 0.0018309409335885388, 0.06420243103258337, 0.013717404995292328, -0.15761505205853854},
    {-0.35459490196670995, -0.4226153110437044, -0.10878397474725145, -0.010352837304241799, -0.5843159198371659, -0.25885803899543636, -0.24450314122334557, -0.35772116685647265, -0.6778796970618985, 0.11872667357813149, -0.4020730921075489, 0.1994660007769024, -0.8831322165090741, -0.7368153385776094, -0.2858921444932399, -0.37372209485848024},
    {-0.08667866005376518, -0.012121364935498419, -0.8118666120437288, -0.35274089350619203, -0.37916868400561815, -0.06105327801859852, 0.18880287527222586, 0.7492248678113939, -0.22752346415489427, -0.568778522767936, 0.09232837295652349, -0.5994546822136466, 0.40209871934247926, 0.002084597366748244, 0.26693581060361, 0.19347252228082576},
    {0.6328877769267924, -0.16467221634369192, 0.19624256817813013, 0.05183805066393056, 0.7487923984149064, 0.1252369790168981, 0.070257284931627, -0.13255846292477583, -0.06886513301301021, 0.45377399231470567, 0.012192169235298195, 0.35585905487260916, 0.45731650957266057, 0.028402678531996708, 0.4458961983291967, 0.26019947178317543},
    {0.1426804175542869, -0.15684984921797407, 0.5000886710719665, 0.044227989439858756, 0.5738149704623746, 0.2552763667769896, 0.3153807828562594, 0.13930234840963907, -0.22613369861024124, -0.09964225950541648, 0.19646990835448772, 0.3683023225968589, 0.5155233981023882, -0.09687638816625536, 0.7063138002212267, 0.6566284965748185},
    {-0.5298817552997327, -0.025821641669721784, -0.5354434763477005, -0.18155186775046922, -0.7734925686108183, -0.581732135430429, -0.31555431328060557, 0.43567778098369553, -0.6423049630954171, -0.42706636014196486, 0.21957455085136057, -0.5877583182892285, -0.5114850623535557, -0.6287928778836585, -0.442835113355161, -0.5610689471152179},
    {-0.07758633595641741, -0.4870798478066657, -0.06782479681093828, -0.20712949760237032, -0.27516447358360646, -0.2383587244305902, -0.26469005325060935, -0.20311149477196166, 0.02825049033417058, 0.28428032349970517, -0.32604310664161296, -0.30835904938252384, -0.08366598068253871, -0.12306880696374152, 0.2809437603078625, -0.19033375899822452},
    {0.047090191728041506, -0.23971767161340923, -0.28937468104463343, 0.18983340459946849, -0.03880888078721803, 0.14967657474642543, -0.02899515566561854, -0.13871086100090635, -0.29479923275900594, -0.1641067855226137, -0.16440015777283754, -0.4315928893795051, -0.38916624511373693, -0.6889048965458375, -0.8037540100741413, -0.30318567591719847},
    {-0.3231458787851081, -0.16899723333130962, -0.30457770725756256, -0.08071576133195743, -0.34795414872498276, 0.13777120024199388, -0.28533637012025004, -0.008316405849225585, -0.03555489454279658, -0.39928325998755276, 0.2316948433587584, -0.6788697137612265, -0.34840240253994087, -0.33804863341502434, -0.1064424118553699, -0.008934453656199583},
    {0.3791264051056166, -0.1954880615795709, 0.0646956342234168, 0.001820732272671722, 0.2999568674107416, -0.06288755114005709, -0.1351911584716036, -0.530614039071283, -0.28585883200455375, -0.17075012592578523, 0.1696998035085646, 0.0893230898637492, -0.15451665987390478, -0.0844533676582399, 0.13103668170665939, -0.2257215261533514},
    {-0.7892342562512772, -0.11040136642755767, -1.5111357077018475, -1.8012776586577657, -1.104321468411648, 0.15839210930599634, 1.7033007164169256, 1.2253236246179255, 2.338952340212883, -0.4691528235043732, 1.2039666360838996, 1.0868110376560352, 0.26354791600790173, 1.186513279198514, 1.395998908346226, 0.7733869213131059},
    {-1.0853537175054637, -0.46005167343100145, -1.2839659734664923, -1.1978770994395302, -1.06718858111595, 0.3172070118454952, 1.7987333790194096, 1.1446851716466626, 2.149606726961323, -0.009738361638369684, 1.7160464771389055, 0.6137942657453175, 0.04482444017232339, 1.1707063596249794, 1.4344769691460988, 1.8274938285153517},
    {-0.4129217614983982, 0.17409523236436908, -0.4539335478485655, -0.6437507185138736, -0.766493820982927, -0.04400860371099158, 1.1655157664773845, 1.2637122149091415, 1.6406446769464675, -0.6891049849147478, 1.2023560541045182, -1.0515472077488446, 0.8197354201956715, 0.7498758003806524, 0.7924408569516528, 0.7209540872752328},
    {-1.0414631178399052, 0.10317773315533478, -0.7219210996985587, -0.34480779822826874, -0.6440375526519433, -0.03182953429389725, 0.5499371382178593, 0.7841587975651053, 1.7081692338998955, -0.6920077056815502, 0.8401607261503125, -0.7205654194048037, 0.6395880256999621, 0.8623230678576705, 1.0879216939142622, 0.9147312356217779},
    {-0.2619408821216803, -0.04653112014963853, 0.33657898583134427, -0.412546698516708, 0.09157754105465865, 0.5246877288259033, 0.46089696924847146, 0.553829081992039, 1.5412676685414302, -0.06148883106557004, 0.43526763326045564, -0.13665947588464913, 0.8828448685285223, 0.8178157508981634, 0.9874513415805106, 0.6781839558818488},
    {-0.025809762145988745, -0.0341627822127804, -0.3562775030470967, -0.019637001819394234, 0.3256282658439162, 0.08020936041376069, 0.8959200059859723, 1.4389460365154372, 1.7868883935392763, 0.1991688941970903, 0.5832034933735276, 0.11962378079153875, 0.5171626188454433, 0.8474750412335124, 1.7661832792881003, 1.0095969737338049},
    {0.323543426887264, 0.10941147396092217, 0.2825080005718542, 0.4644555045337598, 0.29892506917191014, 0.6568442798815967, 0.36765309204271707, 0.22715951072036242, 1.0715580979249186, -0.4467665385709155, 0.6286173078238562, 0.03494902303435892, 1.024543027317245, 0.8444887567281816, 1.0372737573176618, 1.0145272605701712},
    {-0.3206740026522317, -0.2742157052699937, -0.03792830776981686, 0.2307468302600805, 0.23695843638120598, -0.06619216408935856, -0.1045077358141227, -0.9496845952340143, -0.2985054302079783, -0.1575936642288046, -0.28885771694752566, 0.24793270788542027, -0.5403492508757682, -0.26647590402164073, -0.41065128926149175, -0.14186479019871903},
    {-0.31179178636620825, -0.04809403627670811, -0.7304986260664004, -0.6864362031363482, -0.3832697782985698, -0.02208526920736154, -0.014954823778055612, -0.31744564330948455, 0.47531894367611444, -0.6429112651479597, 0.20343379954998853, 0.08902418579837162, -0.502535840811568, -0.6919705871478384, -0.18915652427330384, 0.2011013058262612},
    {0.4354669115899967, 0.10689139707703352, -0.040029175818243286, 0.3247238818415704, 0.052907407062486554, 0.1676665365140787, 0.44343424475369736, -0.2020626251162729, 0.5861875582509137, 0.8469229149509172, 0.16013297561662104, 0.5841449174093033, -0.432444319616467, 0.036498896010095205, -0.007593948220699468, 0.4097104054836784},
    {-1.0466942095937464, -0.6792603642854044, -0.9794307347803392, -0.30437028770118235, -1.078379123663149, -0.753613463067958, -0.625756626931275, -1.080195102095687, -0.19148867130279845, -0.43445395065194387, -0.6775165560289402, -0.2728608682180261, -1.7989562431661112, -0.8143535123604525, -0.723079838566106, -0.6858761613149044},
    {0.031528783791359705, -0.04447372495733414, -0.6910815495887114, -0.019325024229293702, -0.42622037046869915, -0.1681858196669714, 0.11097206591374673, 0.6523299491301248, 0.4316897529148942, 0.260912865791149, 0.562216627124392, 0.12173092887677739, -0.4949708462529691, 0.22378063808516344, 0.183337271108472, 0.1698457458306607},
    {0.47770856038153137, -0.08136555181596916, 0.2242653834857564, 0.2998555956940353, 0.41386691822504285, 0.25003743539696943, 0.2743339250852537, 0.11245229307186529, 0.6921281167473431, 0.508243919373448, -0.525896725362074, 0.3761259367668218, 0.37978801726986455, 0.5313088293167966, 1.01371865154006, 0.37902992904314853},
    {-0.5101689503711951, 0.06770336095221308, -0.5740666553227263, -0.43920049085451474, -0.30528589362000713, 0.014518991222734144, 0.045414166808942315, -0.025937105233073948, 0.40875062031521414, -0.7839261313130582, 0.3668614172753238, -0.7725179581978325, 0.07928622624141268, 0.3489338066581162, 0.01888694684860438, 0.07186741453691065},
    {0.12325837098094633, -0.09823731287668612, -0.0188492963614467, -0.15207072782105097, 0.0742994677101835, 0.22062119222194737, 0.092077069000432, 0.009233159360452586, 0.5156011940063061, -0.20095987723450404, 0.08551469967532598, 0.01972291886532445, 0.4175526567955563, 0.4573586744047899, 0.6366532529315609, 0.5317986095991152},
    {-0.21039385916026038, -0.30477055571514383, -0.4721137406650475, -0.3667281081441768, 0.3176359147679757, 0.1359453267890348, 0.5176870506190718, 0.15968897755684566, 0.36087808561746265, -0.5642912859889916, -0.14896043253554928, -0.6276460231936444, 0.028176303641086906, -0.40761047339696577, 0.570275699822274, 0.06539010008261396},
    {-0.11951494227172954, 0.046517117040266655, -0.02115636699319732, -0.3312389570892382, -0.25607369591609935, 0.20348614625023412, 0.06437568551602976, -0.2831020756849202, 0.5466191030242147, -0.409755762615861, 0.13022303158326465, -0.24524847862301904, 0.3637570942099626, 0.20587124640038584, 0.4952976383418718, 0.589190217431539},
    {-0.46035796676592244, -0.5007756048743933, 0.027528147948233033, -0.46466755476586663, -0.4183428463099115, -0.48816135057466054, -0.6882901078928059, -1.6157621592067735, -0.4087613750117581, -0.13159925418000606, -0.43698632670426685, 0.15936383915355457, -1.045321615874546, -0.7193342332012643, 0.16106053789202365, -0.18410345725658994},
    {-0.035874984819814784, 0.49440577543361625, 0.05159882056905746, -0.2071324958462254, 0.18246397584721066, 0.3908375458038082, 0.567400131960784, 0.40496670589871214, 0.897317737718496, -0.10302876075928187, 0.5244064998590922, 0.13901881217627673, 0.8868252638562252, 0.6825471750236864, 1.357935395859772, 0.9342299724742867},
    {-0.44316415545817195, -0.21853225911351648, -0.4032213845306377, -0.016444704172804664, -0.38125990501020307, -0.12266950609029091, -0.07552683118110265, 0.10402094996935467, -0.17039904757623142, -0.3800500667442708, 0.20117955759751838, -0.0030736624157054627, -0.08602936578316758, -0.2345879013791742, 0.1082306015873705, 0.11217322248724149},
    {-0.10422819476743278, -0.12462941177396389, 0.5397672180738613, -0.1319867602288675, 0.05040353334781754, -0.26154109531195996, 0.12211470924281354, -0.3391795570349993, -0.13494296889949955, 0.1386298631179494, -0.9127221016312197, -0.3394272177376922, -0.19170504554128887, -0.34321193213947765, 0.46757162858087326, -0.08527327002952308},
    {-0.5621853178584001, -0.030124767676298066, -0.04366877496660123, -0.1875935350428394, -0.6770280516798323, -0.09109864657604422, 0.10384459716249715, 0.011947183640458893, 0.3029175091070721, -0.0520939302161195, 0.20116649203305625, -0.18427888324193234, -0.3702848298435025, -0.30399783419141113, 0.12263766144929458, -0.21969209365999687},
    {0.4684867423799021, 0.10069842800850048, -0.17269913166407716, -0.09596469376715672, 0.6049735258603769, 0.029942815737041262, 0.5815977083128469, 0.921712486996356, 1.4522556022824775, -0.4616405651224511, 0.24028974036442455, 0.03439539326334734, 1.3852962528183268, 0.9404569285167939, 1.3271791872828325, 1.2435426966171825},
    {-0.042604708423117886, -0.0731441477642555, -0.3939892415999845, -0.08503016250974223, 0.37875810532513626, -0.37816423478112593, 0.31675657043668665, 0.9107661390832048, 0.7488653675584357, -0.19986977569929504, 0.24793232576023932, 0.030718451868871576, 0.7872613094054659, 0.3450678719914393, 0.8703347488535212, 0.4938867411076141},
    {-0.7386923667314815, -0.6899385394036235, -0.7554636927661184, -0.35498035107681564, -0.7855390513118975, -0.4746611166349008, -0.2554125236964707, -0.22529557433378652, 0.8862027556790392, 0.016841658031823265, 0.31255723053014517, 0.07382482882558912, -0.4581378015734605, 0.3063764179289628, 0.21574342937272467, 0.29165150318808797},
    {0.4839209819264381, -0.006019130666383087, 0.1407223355829902, -0.14355232158158357, 0.5864828334877561, -0.2101733489005454, 0.0903586626014648, -0.28226922003617916, 0.9052044041509216, -0.060522410097751785, -0.08373135756683148, 0.18304880991343306, 0.563036504574769, 0.051278029362245556, 0.9355760622488807, 0.630702652983376},
    {-0.5221231185301289, 0.38215306000654387, -0.05540916004162088, 0.03070561721068801, -0.33780230752321344, -0.04543346327585854, 0.4599720891716866, 0.10163917258730919, 0.8607218051409246, 0.054304476998158824, 0.669418074391118, -0.41621076071138446, 0.20044681565324896, 0.5618313026505617, 0.5476576662984127, 0.259043152105158},
    {-0.46508493435054005, -0.46408682577752086, -0.5244766092178902, -0.8112420791030673, -0.396332672497661, -0.7564115676652184, -0.538863884950962, -0.42723407173628863, -0.7747489722654497, -0.9943575469357706, -0.34129866669144715, -0.6938334603283668, -0.43029168590401007, -1.0283102581609829, -0.20837282018468198, -0.13303665837071585},
    {0.6481002601785361, -0.38016448582794665, 0.11518612484060026, 0.07941235426762844, 0.6768993468186973, 0.12801182587300639, 0.17124778422811376, 0.006547880387911284, 0.4527562696502663, 0.1950958083391433, -0.0753376743931614, 0.2679607026128193, -0.02442293230443641, -0.03267534614490541, 1.0998532038821425, 0.561302630536742},
    {0.20420019746459292, -0.11974697107159275, -0.4955447393455826, -0.10327376674091222, 0.017668558636695447, 0.3001959611316068, -0.09900111839007297, 0.24361013746833707, 0.29861764350301934, -0.22483422721298954, -0.45400539514786603, -0.33702435857438584, 0.1089718713367556, -0.10528344385850921, 0.13354792939093765, 0.5485139035115381}
};

static const float b1[16] = {2.122840338830988, 2.0259380232604487, 2.1197395309370224, 2.1231876357316013, 1.8867737075244506, 2.1324175024692544, 2.5072978842238407, 2.263647855520915, 2.76766275557422, 2.0056259783875845, 2.409282754298613, 1.7298333398141175, 2.6891124105712456, 2.6023015123170157, 2.304832538394409, 2.9830765045727663};

static const float w2[16][12] = {
    {-0.4491690134794449, -1.1451616145075674, -1.0323312579467714, -1.4394434924297215, -1.1215369934504051, -1.583998252949819, -2.073656225432703, -0.9185382333495619, -1.0892569325879469, -0.7068411406008565, -0.7285093020679575, -2.0214566547142656},
    {-1.773227588914531, -1.0480067432876221, -0.7970377924869197, -2.146518886157034, -2.036143030389824, -0.7566005071042168, -0.12748674463404358, -1.7879633981491216, -2.0371564954055423, -0.4684912902401599, -1.4163795338883123, -1.635606154458595},
    {-1.6172202578071295, -1.794960617592847, -1.4756318612000423, -1.0997709121459163, -1.124944139079478, -1.521066216274532, -1.6756152777927438, -1.279303403695469, -1.6437115875593613, -0.6817502874979401, -1.2430185851321525, -0.45579533492033436},
    {-2.168941652896951, -1.925923323500884, -1.539959078470199, -0.8585197856401989, -0.44072455287181794, -1.4728922146335055, -0.4403513023975813, 0.1205112164353076, -1.2362914499432704, -0.8752345567732212, -1.9950728410776861, -0.8380528101809244},
    {-1.563322202758209, -1.089352824159723, -0.9053086124022741, -1.7971928191873863, -1.27128241583903, -1.1683035841948943, -0.5275550208900605, -1.8638691145631399, -1.5133096655307325, -1.7061586321369109, -1.8112276737721442, -0.7683984417201976},
    {-0.14249145062940607, -0.7225000976681033, -1.9014551291911872, -1.4246959814671707, -0.5724087345557058, -0.36909802496642524, -1.462836815279398, -1.8237810500338372, -1.1518544292317008, -1.3630714625178413, -1.6847829147366211, -1.8682167980720752},
    {-1.7965243849344965, -0.4892608926698564, -1.3218953868193846, -2.0639190589829344, -1.706286183311079, -1.1580810319669752, -1.5723251293688034, -1.5483801216649902, -1.0978161955610202, -2.2893790723234777, -1.4095319574986787, -1.2394744933195605},
    {-1.2800551776716966, -1.781533249304028, -1.6105256672297594, -1.5953508180502014, -0.7349978242682291, -1.5954673505917307, -1.3657649033484949, -1.7184479083891337, -1.503801879047419, -0.7612507327764045, -1.829022884041948, -1.4309240124571918},
    {-1.480786462096095, -1.2214599683574041, -2.1398800301637024, -1.4445126878307317, -1.618449624391893, -1.3371121110577138, -1.3138993742553737, -1.338368351806103, -2.0300120666517394, -1.2801679452830437, -0.9748388070508731, -1.2345010838368622},
    {-0.9758156682209516, -1.1304594487131732, -1.3602943235308425, -0.35758431768931304, -1.1939182466269667, -1.2266359707583592, -1.084906696205221, -2.0820043723789188, -0.8713744365646175, -1.813406034893858, -0.6225997371150045, -1.305263668161611},
    {-1.891052859297408, -1.66188344030446, -0.7219313891783439, -1.4785830840294083, -1.1136705389309927, -1.687065062219145, -1.4853976562787925, -1.6376881437741382, -0.9128536127987438, -1.289836198127302, -1.2235286585757674, -2.090936040973634},
    {-1.3075162297135268, -0.8068810510985581, -1.5123561457316117, -1.634778198677817, -1.382540829034549, -0.8281165698132738, -1.6578156408270586, -1.1136510260560355, -1.6903495684413226, -1.278769308341744, -0.9927053730305995, -1.3280144889566152},
    {-1.5334545422150063, -1.7789596734059996, -2.0425604293617057, -0.4905939480769709, -1.4048962693920628, -1.5522300437259662, -1.397582471052215, -0.7731224481566462, -1.957460099768485, -1.982536658907117, -1.2004278881199992, -1.51324946268795},
    {-0.8995872728213915, -1.1706792709188778, -1.0974817718131273, -1.9529858302357679, -1.693058516308214, -1.4747618748702132, -1.8123948336237248, -0.7148192213076255, -1.1869338032535235, -1.7163129781843816, -2.280454014853649, -1.6411540649481549},
    {-1.2290640372613686, -1.3901884541270182, -1.143733929266907, -1.8147431184204181, -1.7904155267031876, -2.1119062119244085, -1.7678156590536254, -1.8339823122752614, -1.9878839104202632, -1.5216746110682913, -0.776255563571499, -2.1750514407755523},
    {-1.9892614648968712, -2.309180953140276, -1.7491096210657748, -1.3476054879048354, -1.374850349199811, -0.7162514293140235, -0.9812130880875296, -2.1018062953164875, -0.4886991210877747, -1.313585614583719, -2.3663837155172223, -0.3370219141908998}
};

static const float b2[12] = {-1.1794179939700922, -1.3074717607813353, -0.848009112731336, -1.1114603773396694, -0.8839660062286214, -0.9048524035349295, -0.977426427160701, -0.9302587034347618, -0.8190763793295956, -1.0009087137137214, -0.13237141834632957, -0.4125298048478584};

    // Input Layer 
    float z1[16];
    for (int i = 0; i < 16; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Output Layer
    float z2[12];
    for (int k = 0; k < 12; k++)
    {
        z2[k] = b2[k];
        for (int j = 0; j < 16; j++)
        {
            z2[k] += z1[j] * w2[j][k];
        }
    }
    softmax(z2, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
