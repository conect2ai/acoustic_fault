#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][64] = {
    {0.43924825577372867, -0.7715834015199226, 0.5042577536039022, -0.5611384270905156, -0.5512387886060903, 0.514111069312089, -0.14008957262277671, -0.6585871210260897, -0.4994304403140203, 0.340155572585527, -0.7299131671091592, 0.26500058485328754, 0.2904408431483074, -0.57511175066921, -0.09288540795150396, 0.34678804422238296, 0.06351320306121297, -0.8937179100349112, -0.43740268526181264, -0.29056372478925024, -0.5096375447050412, 0.36535440599042796, -0.779705661117191, -0.04730630997707663, -0.6963168001614838, -0.7841125582421873, -0.5404725002706242, 0.12858639702277044, -0.2621573687828515, -0.7509252241893279, -0.6970667176835642, -0.4494848811943601, 0.4290752731190035, 0.3045889414351335, -0.6575879602783127, 0.19658209485994807, -0.5547729029493603, -0.6971613586169857, -0.7188488888665863, -0.14193746603359977, -0.5862144107929017, -0.5963505016851037, -0.7152250983281689, -0.7955476541446933, 0.22644672642527613, -0.8066259193239909, -0.03368134377509767, 0.19294473042722038, -0.5957665602199191, 0.47512628090519377, -0.19181086766195873, -0.20969632184237721, 0.2574718540539045, 0.524326231711065, -0.7172797372420957, 0.45259368459953675, 0.5320567309547064, 0.2575201540142728, -0.31850295028816067, -0.35963203951061046, 0.39995561094455334, -0.6052097409346285, 0.03766917487080354, 0.5834523140880186},
    {-0.27951073213705663, 0.24855397466050302, -0.6004359421883839, 0.08420622754457267, 0.5920180708071856, -0.3233181680274696, -0.6231985630916304, 0.5933409949200273, 0.4296898895894663, 0.12042426844348059, 0.2558702031747707, -0.011858464280941927, 0.5362060355032692, 0.6143286634536247, 0.08758639268709512, -0.6555928339825997, -0.6961418584839856, 0.37520363808019136, 0.6473231409448695, 0.2477472341845924, 0.2579548673029111, -0.48915944063269423, 0.6938539086716694, 0.2116927562688755, -0.20019644861936212, -0.23298654489128315, 0.7195931814917732, -0.39917313990338427, 0.45729572087429426, 0.3001945181437098, 0.6418451175455957, -0.06717264960324582, 0.11807211281602178, -0.45413573688287767, -0.32221497335808275, -0.2508214297099822, 0.02497601623502482, 0.29039152418828973, -0.02068321075462177, 0.3424154337028145, 0.5532550842857444, 0.6109482107477362, 0.14592421016070778, 0.4983876492283526, 0.10855302669021696, 0.16910057725953367, -0.06796388324827292, 0.3984081927803335, 0.8454946513886994, -0.737438954441064, -0.3451342946234362, 0.7172952501516277, 0.7147771058885432, 0.5304417324345743, 0.16901370237020713, -0.38432792578830777, -0.7736566943575383, -0.592758729487027, 0.5099688193275524, -0.1460434961981514, -0.5407614110957656, 0.827226819668256, 0.788227261677884, -0.32459284533412935},
    {0.26778569179448414, -0.31016182388764935, -0.11586867278891763, 0.6096187124626871, 0.40352354127688383, -0.031982934401060883, 0.34144419652802926, 0.3224910294824503, 0.7421178587874601, -0.3022595045464259, 0.6838717418878498, -0.5187977759484744, -0.34163301971305904, 0.43986552654905864, 0.5335748751383336, -0.6493506176389123, -0.24411104322893448, 0.2068900218897667, 0.13390975004816202, 0.5171025464090323, 0.6466276082706514, -0.42524476077732276, 0.4792749224640498, -0.5454689367765483, 0.4030438041498973, 0.2938375609142352, -0.2841388483879029, -0.2256813577865764, 0.6791266506962625, 0.39257118429749593, 0.5925615844066647, 0.13452629296079546, 0.3871001156965352, -0.5551030371523649, 0.3479542124690594, 0.43550619040588867, 0.646660190949101, 0.562987401964926, 0.2957160219782839, 0.26697799719548615, -0.4254959884449047, -0.04168538015468065, 0.5471430790808627, 0.0781489594765575, -0.005773288746772157, 0.46889601335385117, -0.4368845781323492, 0.4875708518255322, 0.21317407178986758, 0.42085305972440473, 0.2051399177618462, -0.029105317079813942, -0.260903551003525, -0.1316209915226825, 0.5644014349740011, -0.5460456641266576, -0.5014943987848282, -0.4468787843191644, 0.08715120267030792, 0.479987702882419, 0.4725470458685596, -0.22152253543287823, -0.7084060955009346, -0.1506620689467026},
    {0.4094975501008686, -0.08241971875152881, 0.5337476160108249, 0.5973996629823186, -0.3997636462507152, 0.29412969935549904, 0.4225930330305374, 0.24876846013630044, 0.6200080281832748, -0.33699217679356575, 0.20432917686607333, -0.3186399736799525, -0.8142042425451109, -0.09830071635361397, 0.45795933041461806, 0.42998167630196127, 0.8136614602793386, 0.43672109960978156, -0.4020657809332358, 0.05605847854578011, 0.366659665508811, 0.4498628057639486, -0.09991743086993418, 0.08194873469226997, 0.7242455742505522, 0.799682052554809, -0.7208942616703234, 0.647355550622753, 0.011076860271974754, -0.22824673457528022, -0.11122251279817232, 0.34912756463169736, 0.526511251942503, 0.4813941380834432, 0.8494122022378483, 0.6714892497644469, 0.5810727717134474, 0.8549217627984911, 0.7651187010610208, -0.36516679438602917, -0.5246766364610939, -0.5518152346498719, 0.5842121865964143, 0.3065187944705254, -0.10096579348894952, 0.5664838322877581, 0.20043077086025599, -0.33547780929731813, -0.2788283693135628, 0.6968678382953474, 0.6160180659040045, -0.4861867156202483, -0.6651322039577753, -0.4313778056097409, 0.5430279786005736, -0.1980608899453539, 0.22458291753735427, 0.5388462916493368, 0.04103714646524733, 0.7547955375674221, 0.8729575457874823, -0.869978516496075, -0.6660480398795725, 0.28135760595162296},
    {0.08975905094890904, 0.5638464386879825, -0.10054992269257468, 0.5630284978495342, 0.5334008923897934, -0.08858727727305915, 0.8316268076498442, 0.5158399388893098, 0.32831088756075333, -0.35054512185180825, 0.44860241348421925, -0.004620281904453984, -0.4741633479192217, 0.17026063183262077, 0.3324310935573126, -0.1148875790175208, 0.559145819992714, 0.17945635091713746, -0.23148393467861308, 0.36752924025659367, 0.07895869884157113, -0.2147025104634367, 0.4546885850246705, 0.004435536013174761, 0.7176199203288682, 0.8839704557300382, 0.13106670291022843, -0.177589702607085, 0.6749462904516788, 0.4452601973538017, 0.4135387519756049, 0.1910181140897756, 0.0016936430821532817, -0.35430829521151097, 0.23175631928870558, 0.45901444588460993, 0.4376736125888114, 0.4151214690981997, 0.7368370295075632, -0.06579334042566566, -0.44977321752218496, 0.22875648416909267, 0.0735260456133867, 0.7354692731180117, 0.3358489390279476, 0.6087127722429652, 0.08666581523245033, -0.16361477909485367, -0.09634944081138919, 0.46825871689052945, 0.631061430637652, -0.5717173463800782, -0.3066365017691083, -0.585747178717093, 0.9059066365889775, -0.38026395987098655, -0.34390911187437867, -0.3702083816470637, 0.14940923878464268, 0.4049243036507029, 0.5601988750020416, -0.27249303625736854, -0.6437809078091304, -0.6807566455079158},
    {0.04432337005902147, 0.40335378870222166, -0.06394825756080065, -0.04790527261500277, 0.5542365452493846, -0.24896660621120595, 0.6938245933035424, 0.4361180445362233, 0.830636077757885, -0.6611384302583959, 0.9348713576803129, -0.3635062304552478, -0.6419471251212495, 0.7617861628172624, 0.40401106570104445, -0.0925343430191212, 0.8046811871925823, 0.514312793799984, 0.3276238264672721, 0.5171323179355237, -0.17987963979269705, -0.2095122593874049, 0.3749540714001423, 0.010433922299820037, 0.6119540554392261, 0.9463475809744788, -0.048274509798030336, 0.20787450935903012, 0.43510977027634357, 0.7477569294467423, 0.5884448876244461, 0.6494691419141917, -0.2604070299684596, -0.17730216327574763, 0.546206822563913, 0.29181818203402793, 0.8265229165261206, 0.44728969970186094, 0.6956638043253225, -0.2530078194969299, 0.06607669285657963, 0.4575568608780268, 0.5409474909118491, 0.5468918042083691, 0.7870859757924009, 0.7257230041997675, 0.6567531557310118, -0.1605363738012198, 0.5051466085203734, 0.35087638494610385, 0.08588496546253825, -0.20064348945873917, -0.20194160172788603, -0.5048045709557776, 0.8427040101766059, -0.3479906143543053, -0.31923184814404443, -0.36558663322591356, -0.22767630460267915, 0.5439550095447512, 0.594653117871579, 0.04566791980538729, -0.5710231193760794, -0.6573683825394917},
    {-0.3606891654054638, 0.30864317824124887, 0.13840173804263473, -0.14016247486587277, 0.030620886016419636, -0.6317181005707357, 0.7534594146412389, 0.4035374549347518, 0.7545825366008495, -0.731491461049878, 0.67954556684626, -0.6580459076808179, -0.6198279833216753, 0.6737942843276293, -0.042722246565722745, -0.25394054234297875, 0.5878161289462236, 0.4609218092375285, -0.11968933749589453, 0.24524690016789968, -0.022894492075356133, -0.44785374628769276, 0.18460648659045648, -0.13586322723547817, 0.7125447962182779, 0.7912156956638474, -0.3536760626925125, 0.3674862022748924, 0.21521189378674702, 0.7219708487389574, 0.1603824238850079, 0.529030443337866, -0.06496197726377466, 0.08778502175606659, 0.6122611468038099, 0.32894396164818007, 0.7640283373881847, 0.5564823757008628, 0.8165004798588196, -0.35596119400647036, -0.3298440921714022, 0.17175427540681137, 0.319300557516534, 0.5340320296215677, 0.4195041406435506, 0.8182058512194968, 0.4082470577148405, -0.2382486006768413, 0.36431107273844743, 0.5658963620808282, -0.09880726514806114, -0.21244919693883163, -0.6985896961925331, -0.5100998148562842, 0.6104369612752392, -0.6643886050710639, -0.10386950984753408, -0.24108510211363818, -0.17364216133089155, 0.6968009104056221, 0.38178819803937497, -0.1363734451378564, -0.6046547604858369, -0.6397966690445929},
    {-0.09241564559671056, -0.07491201229008355, -0.13858315240266456, -0.05369283953094755, 0.25949838956635973, -0.2958808322490436, 0.022672907591699293, 0.512734858542269, 0.22065704436897307, 0.17747689173699158, 0.5348576201542211, -0.5348893911992965, -0.27390376983307435, 0.18461857048159028, -0.16790176603609486, -0.6697337537413499, 0.0020477494071120157, 0.07569324952075275, 0.3058236530036234, 0.6618092819067206, -0.2635429447506134, -0.5316271778784393, 0.5425587068193505, 0.21757064621197095, -0.010169670106324455, 0.5645014920244886, 0.4095518580911625, -0.29959125610476944, 0.7718397480909198, 0.4196916661911736, 0.25026924486724217, -0.15903659463944153, 0.3734010067477913, -0.670224919483819, -0.07553920654663403, 0.40619519895964074, -0.09175984800006089, 0.0035271154059680347, 0.35772338896197775, -0.07075573742702636, -0.2576767033848806, 0.5295603151523078, 0.08148338466819943, 0.3326483200252129, 0.5612267373478019, 0.5127027867617162, -0.0438197162832008, 0.22101495295768933, 0.7253597461201017, 0.12904733507358265, 0.17399419804211158, -0.1929166695142752, 0.11296786797097146, 0.04995394490722507, 0.1325575146076239, -0.3031687745940681, -0.4846955614736862, -0.6528245697207377, -0.1290653906228006, 0.43424262945608694, -0.3163312061133877, -0.10368486846040949, -0.2707271422683742, -0.7729211897368098},
    {0.07045787092501031, 0.5641768984507288, -0.049792100476905896, -0.3243931565728796, 0.7378315869158195, -0.009357707473863918, -0.4945274743834896, 0.0714307484808203, 0.5701407478273494, 0.4107461568512874, 0.23072910064796393, -0.5320911539756101, -0.23083465802705494, 0.38645579032121946, -0.05356262785402868, -0.6136637819109537, -0.020997213238311992, 0.1917470355798754, 0.5596252605020362, 0.7754943897835036, -0.1377304016126246, -0.035671479293714864, 0.6318127265471114, 0.23893271279597406, -0.14263627815211372, 0.33043107636998564, 0.3447378679733077, 0.12463245012352031, 0.7302946789160026, 0.5246295772280457, 0.39948559031934, -0.07805202507486472, 0.30696367227077376, -0.4566075763070266, 0.0955765665816931, 0.23116651037473515, 0.2232029366553497, -0.00614560995703773, 0.2794272781379854, 0.41608332806857956, 0.4433665723735221, 0.37543414977926565, 0.43652748823421295, 0.45729193701992726, 0.6912593998330476, 0.47484772873633585, -0.32634288291596575, 0.0841029493229696, 0.6672626122350547, 0.41356405944601543, 0.26399072998532075, -0.034447788948224894, 0.2064450085797228, 0.5066707990865238, 0.27792046727528213, -0.5623427809147921, -0.5700210847169964, -0.5854513186528288, 0.24160830365305874, 0.44726337002890354, -0.0888586425177573, 0.12729684603879085, -0.2419584229409089, -0.5926907021120028},
    {-0.6329107418079732, 0.24222325446293655, -0.6419313684433158, -0.15589890309815982, 0.2664054987686158, 0.23335225217029623, -0.8384611466700086, 0.32334518098884707, -0.04515408490946486, 0.2803126197572611, -0.4265844179006391, 0.2775230028493368, 0.1758871987366126, -0.3245147688617862, -0.3710119807307204, -0.5542407387648736, -0.6440812067344771, 0.3394280390858117, 0.434857576892493, -0.18116274727016035, -0.1545469479244349, -0.08381762703532264, 0.4022593057819765, 0.46021199412323416, -0.7340896955515621, -0.5142533277822078, 0.4610237956189712, -0.11921709023220728, -0.09963575302347631, -0.2314580167923049, -0.06470085977000538, -0.3890163024744757, -0.20599760865058192, -0.6184757080688579, -0.18341819929309072, -0.3160208098800366, -0.10340526909890398, 0.05522931398139706, -0.32706600912807887, 0.13314966076918536, 0.19396802694028265, 0.1614254970489795, -0.2535921559289967, 0.08773292163360139, 0.23286005438006122, -0.1820493932586043, -0.3846830964189013, -0.1844159051371583, 0.7773811877958092, -0.3190152326816022, -0.5728624563146019, 0.06903616311827125, 0.456432792140425, 0.20571092149168294, -0.6309629733087124, -0.2938960255253384, -0.5677632263438283, -0.7223035209111631, -0.2546936867390935, -0.2678767597754866, -0.6637196618254255, 0.6461712911099015, 0.6918555822967523, -0.629009825576251},
    {-0.708539093409203, -0.41647394508985025, -0.41795716459439014, -0.40242348775360187, -0.0033381836264087007, -0.2854322738649421, -0.4046949387521696, 0.1599317757234692, -0.08152183855194405, -0.5600511603932044, -0.12257049663736216, -0.3855411429194263, -0.22213893865649711, 0.3346563827562333, -0.6200111504262618, -0.47292817261489795, 0.11157599656108752, 0.3315136785551343, 0.51041080999688, -0.1849900471395372, -0.09651349209141882, 0.15529596824964093, -0.19643310262413344, -0.04259947233703931, -0.4158629406096591, 0.08136016864381056, -0.39582614752421974, 0.24913706805222213, -0.006150385651402333, -0.4114647726516359, -0.36217895181359494, -0.46139969180861484, -0.6143826558400659, -0.133279005977384, 0.26275200348981553, 0.028917469288203802, 0.1854466768543088, 0.2085766522430467, 0.22013742268721587, -0.5438067525070813, -0.3205974137168966, 0.3450996228655978, 0.08324671048430599, 0.0325340047120086, 0.22906374919881903, -0.18721380033810675, 0.14062389893873076, -0.39547662046907833, 0.4847371241494931, -0.30627021644158164, 0.09512173915082207, -0.005079306148019241, -0.2320574334023867, -0.5490033812687926, -0.40776771100161574, -0.46521021119652495, -0.4022656862840719, -0.4628073485736407, -0.48794943820784725, 0.009448047158219178, -0.3054289671280676, -0.003648766115509383, -0.10706626645143628, -0.49305924951902746},
    {0.41711526568170154, 0.3186790964533617, 0.3545571562293846, 0.508045668210529, 0.384859248594943, 0.3354878606050459, -0.29670353725672943, 0.361110673731182, 0.6628328161016875, 0.2274154558035834, 0.320002191403563, -0.04357604471593365, 0.29412471472585605, 0.12668569596276266, -0.06457077263765791, -0.19799416863490293, -0.04859138781033472, 0.1944123699675279, 0.553083005389843, -0.037545055852469575, 0.4726535646104833, 0.4930924592753737, 0.07406182729224041, 0.09852174478560376, -0.017056374967065087, 0.33239545583473584, -0.11742942914780613, 0.46541590163443985, 0.014405810223383567, -0.43232667284126264, -0.15179881271201712, 0.476935507282761, 0.6781400618649919, 0.35138727733095104, 0.5441641650913388, 0.5036411204515017, 0.4758998288628606, 0.6774729675403894, -0.08574647890111996, 0.19574504289254838, 0.5651933369050534, -0.3135361177380616, 0.338107328682413, -0.005880488391596289, -0.07700312678578697, 0.12560489537892364, -0.2998355290933972, 0.5381847461387486, 0.6257022652037746, 0.27544936447318935, 0.3416975615717405, -0.009183141694430928, 0.2839160937134957, 0.23307831556568084, -0.4378287870546476, 0.23056821304920044, 0.11714580877864426, 0.056314790391893264, 0.41181053907242166, 0.38458693242891356, 0.3864392613404833, 0.40329265797084085, 0.4345844409215371, 0.7162047334509306},
    {-0.1478756461638524, -0.1759350703761493, -0.7171285363097796, -0.639223415390743, 0.4664306968125195, -0.7112998066022443, -0.5227210243132827, -0.6286826256319364, -0.11790589304099174, 0.2202289505808498, 0.09270695875005337, -0.4352110553244777, 0.4577933444514849, 0.7424274873521741, -0.3251719682667813, -0.7693766870123331, -0.6980709322972402, -0.2135226262059697, 0.5169418443972525, -0.15618718759007066, -0.4555342122130024, -0.6226202016590213, 0.577656267180936, -0.21403490954713958, -0.5561565148432865, -0.5673291111144354, 0.626387135857853, -0.5689508081222637, 0.6047223719879098, 0.3299016421474343, 0.4757308375896313, -0.5170852313663223, -0.3500182359113693, -0.6853060037677877, -0.48617828520853107, -0.4744212239304533, -0.2908721570499847, -0.703849983728425, -0.5929539678718886, 0.4289168430228585, 0.39172797521434455, 0.22198070031779477, -0.21795206930047759, -0.24775495260568836, 0.6126294182375862, -0.18645601813571724, -0.40898302821987037, 0.7046683816409848, 0.5791670920123164, -0.4727540278630547, -0.8624491561130251, 0.8055622146968494, 0.7069266905400693, 0.33010113824105447, 0.04865730623059805, -0.407307291009326, -0.511422063939164, -0.5847305603336389, -0.12121657165066002, -0.5404756010844256, -0.4818440975991013, 0.7044805329584651, 0.5328502604918233, -0.33250870207108935},
    {0.10766248558035023, 0.7804560147970738, 0.8419562664104078, -0.2472804275173372, -0.5287771552404075, 0.5955000614897697, 0.309655879312794, 0.34235175547958574, 0.6859022749422059, -0.2814057454325249, 0.07635229691509636, 0.2597914326454971, -0.6131982708173077, 0.27049450926718527, -0.3895194948993103, 0.47614237357326555, 0.6869026480589508, 0.5004418931905485, 0.14190386588042833, -0.5726148946258388, 0.2594620032135501, 0.4473813368979729, -0.0529163601467349, 0.4884200074496218, 0.3824801993506643, 0.7235920955576786, -0.3415565182198108, 0.6845763615357502, -0.686090463935528, 0.03807522324529987, -0.6891091880400327, 0.48674412389314176, 0.1306808507778008, 0.7442667353294674, 0.4185797341676791, 0.3395411898949698, 0.2509227833711477, 0.7060645563472685, 0.6407810352005513, -0.6067637558977834, 0.36669068352203404, -0.10430816997895273, 0.8496858887233715, 0.6536347350489835, 0.011678806186614106, 0.7803439268814334, 0.6934172255133692, -0.6273017320647305, 0.3675578025918554, 0.7105265993360075, 0.6907589610651559, -0.5809889420809049, -0.22727235860973868, -0.35522219141523437, -0.13241679448333374, -0.49527002458728764, 0.44030042110879314, 0.7341711220383581, -0.5352060465730236, 0.8116826355962362, 0.5776239773915665, -0.4063828264720967, -0.10915769604584621, 0.5348709868926542},
    {-0.0824010288222874, 0.23858978848732293, 0.6475354957852373, -0.4602851041610807, -0.6337588659307333, -0.06901196241057286, 0.6245617290733403, -0.2906706879592765, 0.26177637693986633, -0.5976034373253537, 0.19779788669849024, -0.09640205322672694, -0.4928911424262726, 0.25413205739735567, -0.378138548396101, 0.6170979047165066, 0.6621602400725266, 0.25895182790482263, -0.45963855735468395, -0.7054452698356762, -0.3337114383351806, 0.2495611372620861, -0.5088208322044864, -0.20673187322537726, 0.46515313370887684, 0.3867917896057077, -0.5918201443973129, 0.8843342355936966, -0.7414282240851385, -0.14708376351967276, -0.6858357169360961, 0.7528719823707015, -0.38024302346195443, 0.7376619313910547, 0.20623516573216555, -0.3924523764570587, -0.08229107240987801, -0.05685611692384963, 0.2223628990149746, -0.5264993493477549, 0.35876128637881294, 0.13044154169273936, 0.22076195869506704, 0.15394471347578187, 0.1716354332080983, 0.34322378588803276, 0.6311285322319349, -0.27961646989817823, -0.6888675777237795, 0.6665492193024463, 0.02948976093350756, -0.2440135900888255, -0.507505387267451, -0.782716941574915, -0.08506648919280196, -0.3214817383412487, 0.876754170326265, 0.7449436730929763, -0.5870687563099349, 0.16199961546410838, 0.29072103369766666, -0.649112557628918, -0.6515823644512929, 0.6645384058596556},
    {-0.5008740745397888, 0.48053200793398565, -0.37353445025585635, -0.7444256542865174, -0.0026989685175559854, -0.5645387193948403, 0.10115121703690685, -0.5741075806159309, -0.3729994094665556, -0.44956951066475004, 0.013360247049480448, -0.1683153318190137, 0.4987362522151109, 0.611498829264705, -0.6575393371880441, -0.12394603511944027, -0.011448672778279082, -0.3525867300370319, 0.5065357588828805, -0.4900170792126927, -0.458819099120177, -0.18617116172025255, 0.2703168451648877, -0.44586220473936283, -0.5703954051163674, -0.39693484912032695, 0.5140531190097741, 0.5686726558503351, -0.23226923464372443, 0.20681487105210422, -0.5723098832329317, 0.28251260648939147, -0.6834692337128184, 0.34532700645034214, -0.46315939218830027, -0.4905123855322863, -0.26848341491267447, -0.5560520694802067, -0.14848694780885022, 0.6009034253401396, 0.6679833038194621, 0.4775087306366838, -0.10492927992667442, 0.12737976106476484, 0.4694832165518374, -0.007577225179873409, -0.17857886645269802, 0.2900595836586019, -0.28460117910209437, -0.1871692330371307, -0.4809056407198775, 0.773183465324636, 0.7096094619697543, 0.023717518268326732, -0.1362299955697213, -0.37088129733455427, 0.16763831619203773, -0.09368525850138412, -0.338393440596413, -0.18633397843760685, -0.6852280438020923, 0.4203280333902484, 0.5460931920768376, 0.4098124044858117},
    {-0.47112479860165496, 0.6360100939172647, 0.773804134888539, -0.5675270071113425, -0.15822255303893987, 0.38600215802409577, 0.2505989492177841, 0.25594134689530856, 0.55593509201053, -0.7292125370955428, 0.042703963359613004, 0.04212552600693659, -0.5201487299307588, 0.16025962436501315, -0.6068338634423681, 0.43077997983117317, 0.9484953225602885, 0.5270242493808369, 0.07158687164382851, -0.3730553845600875, -0.42319491377901647, 0.48345323785154226, -0.037049872404967515, 0.47960220013073296, 0.5637938661816827, 0.582096224496409, -0.7109640498502667, 0.9547232890196529, -0.6536505651030102, -0.11326180026431053, -0.7534459870469246, 0.7744156986735155, -0.19760030549832744, 0.7227996746528775, 0.5625989574496577, 0.24090778237385393, 0.33570484468277056, 0.7308411042769384, 0.6770364610150258, -0.5710096432551249, 0.24966267085713523, 0.24908305554452886, 0.5940513302862296, 0.26309812967197566, 0.3183872549178374, 0.8196441539610414, 0.8238403011610965, -0.7698456582899327, -0.13079867205659973, 0.7389642112424988, 0.42782295587613184, -0.6579494633996823, -0.10838628940240165, -0.7483532257260284, -0.20521091926561216, -0.5513788030771017, 0.8295493380109016, 0.7125223878738872, -0.358890385717238, 0.6975970679272177, 0.7010244404363418, -0.5991325953300229, -0.07641052669075578, 0.4621186060282565},
    {-0.2310568068160262, 0.3813885259550976, 0.6782657643301973, -0.5166435965908956, -0.3376332891006414, -0.14301095727079913, 0.0532994674698176, 0.39699044888309915, 0.6619076270370343, -0.47482754066568367, 0.023378486510428228, -0.3292184836029389, -0.20626248033601052, 0.2970380751550004, -0.5713119491039034, 0.08427854450527293, 0.6863436052602668, 0.30550295511483466, 0.39772607010043887, 0.004945501283927328, -0.25134447084521283, 0.575268007079734, -0.24313007289490474, -0.14247681825381134, 0.20154343385013415, 0.5480826512432679, -0.5153316260035499, 0.5804037264283316, -0.19102156945474644, -0.27570034192746384, -0.49876721520837025, 0.7936185369489165, -0.427869982579513, 0.7521009648644144, 0.5139503126470948, -0.1762775216964228, 0.3367789712706254, 0.5408885280235541, 0.17499871177787674, -0.025582542044768765, 0.11035091476348102, 0.0011568124432847833, 0.7292455422461783, -0.03505936767275399, 0.14294575038408214, 0.7575036869745945, 0.49275451925411456, -0.5856629859425273, 0.15485668308526168, 0.29056786730912926, -0.17133733976004586, 0.03574070270611178, -0.08505929033031058, -0.4954472352924335, -0.1267816115933815, -0.4922765808918678, 0.3307731854556091, 0.4498544509660369, -0.16814469598285, 0.7236280301536858, 0.5011521143927441, -0.24652269551332032, -0.13797818706616627, 0.40996436109530476},
    {-0.25269419286681766, 0.19504740740310747, 0.2845841988925512, -0.1500892868246277, 0.2075369725664127, -0.06566123607438135, 0.048572870441677435, -0.15312127605365838, 0.30903789154311095, -0.15370943938923273, 0.07761059041041793, 0.1314367208246089, -0.21519630834320586, 0.356267268228081, -0.41182693027679473, 0.21706556886998157, 0.2608619009572886, 0.11510299142191868, -0.020127269328089125, 0.1795461997388368, 0.3925830709164558, 0.2842660474842756, -0.13603327422463743, -0.18237815061750176, 0.6377959497923192, 0.692543862860371, -0.2256848649665291, 0.44973414527616234, 0.07166123116147528, -0.10819081194307184, -0.26424627556021246, 0.41366062565854345, 0.2950604566476907, 0.5411910640028305, 0.7513162103216648, 0.286028588922773, 0.3503729399469508, 0.5234224005941014, 0.43942151497783083, 0.13398984737517233, 0.2747583232172987, 0.015133019168135278, 0.5209384318580772, -0.09702468857969838, -0.020976280481173077, 0.645048151323838, 0.5467920277253219, 0.4009688375112304, -0.15105899288881047, 0.7585720417855493, 0.2506116683571804, 0.3573180812019266, -0.3253626648663432, -0.15000520440467124, 0.0019084348154270773, -0.15682616415212816, 0.6481850008679, 0.47280547245774623, 0.42806354774249344, 0.4681877779071305, 0.19853035416120987, -0.29933329284351223, 0.4619836997141734, 0.23929346699818718},
    {-0.7121840486325627, -0.2823184282268428, 0.5361118538858637, 0.17813976795749797, -0.47955490074092105, -0.14518218157563587, 0.1578789704938784, 0.2789717349169559, -0.5260087724793969, -0.41951561500429285, -0.50141960745901, 0.08438734378694296, -0.4232561864193105, 0.09927894706257087, -0.4479808473995384, 0.11671941659605274, 0.3999570487429718, 0.33953602213483425, -0.09842905509882449, -0.6381020613160219, -0.16632374442433115, -0.14802652087152135, -0.39620983399107046, 0.03931655564369104, 0.4360819970818158, -0.3535452536898063, -0.2785224368369789, 0.10948295534897881, -0.30512615202976373, -0.2068661950094821, -0.5855443816033482, -0.3194229697980533, 0.10835313733592164, 0.4924237465638867, 0.7164052404701352, 0.5880862591811368, -0.34140963739814284, 0.5000239451624513, 0.10688776781686736, -0.6113375677913216, -0.2088990967481216, 0.027946083153169345, 0.5562890152953559, 0.1087410893263133, -0.5056779499785985, 0.078688853693874, 0.6701931968789824, -0.5365025677463672, 0.31695251918282047, 0.126268316318306, 0.6300599069604349, -0.03852771904498417, -0.06636278428631676, -0.4799742227808965, -0.3437895601767221, -0.4926054878932734, -0.02678263527342973, 0.02021514689642763, -0.08963898147479257, 0.4111315897072662, 0.19157059169129992, -0.5357346529509522, -0.10207830462999305, -0.24443718629495706},
    {-0.3204350966578652, -0.20699926288922343, 0.7337843961454573, 0.03541825430395753, -0.6952072074713797, 0.12617736453521644, 0.26039440629390054, -0.14770007875149632, -0.41170847028696456, -0.3066166597144697, -0.469675625236096, -0.01123058795033294, -0.42843241595259846, -0.5853427856432356, -0.4484407484625075, 0.7694681586403359, 0.6219549497868058, 0.21513755744309337, -0.7647793697706089, -0.6050858413043584, 0.17122774336762212, 0.34543834606571727, -0.5214011538196931, 0.16513780622499183, 0.4937928818415704, 0.04343373608815188, -0.6817099734324751, 0.49246932638980917, -0.6828304854892525, -0.3598530866827617, -0.5323884944325864, 0.27844749925846657, -0.09631845480371681, 0.8158302063407987, 0.24778599278116809, 0.06977936728360341, -0.35229762484517707, 0.3437144254623162, 0.44259774377107347, -0.4555633591331253, 0.2149693577804573, -0.1504078927621844, 0.18565659864732703, 0.08007892367787355, -0.24447655992150288, 0.2847393869720172, 0.24263416848569025, -0.08049448796874481, -0.43740617705121343, 0.1864978336669025, 0.29303815844954306, -0.18006265863920032, -0.08422261775598094, -0.4977935822083528, -0.2552668641368289, 0.19518376430860207, 0.5237501076213058, 0.5939167375406453, 0.008951877271799986, 0.5272225679390056, 0.6283708950884351, -0.7104697361227189, -0.33111135765560484, 0.15048193251703929},
    {-0.24045152984934984, 0.3574270581479175, 0.49801681099197515, -0.18857760698230905, -0.7237093898111188, 0.3438731618073083, 0.4886506515790437, 0.4933311665228574, -0.6383219174090395, -0.25692124957617096, -0.6843641822812708, 0.4759134515397177, -0.5175450166503008, -0.7118783774184978, -0.18546859054364737, 0.666385858825489, 0.8889021349620251, 0.554399934365277, -0.3862405040602097, -0.5245286083408336, -0.10995363155132654, 0.27971102136037673, -0.627279015213723, 0.3056989259895996, 0.5331440575371036, 0.33626233486748364, -0.3696200480960234, 0.4627903547510995, -0.7378429773789058, -0.47509321212788763, -0.8150896445945693, 0.5640032264836313, -0.23948925378183042, 0.5066458867901018, 0.5494560014877593, -0.09631361432736214, -0.4259171547846999, 0.6558990177848847, 0.49988002704109386, -0.7389529624065672, 0.004538798942657719, -0.014034156110409379, 0.5371305937497081, 0.45563634353850224, -0.7701814455470483, 0.4358155285905924, 0.8364461112196274, -0.7681875744206927, -0.2807880196205983, 0.36959436792668404, 0.49380097723774424, -0.46293006036620105, -0.19093198475703002, -0.8022036406667756, -0.45593893742410846, 0.16092043610703707, 0.6634204136129889, 0.6600085450532164, -0.6149480679964645, 0.3758608611801798, 0.469554776761882, -0.6184185667404801, -0.4068803105669221, 0.08171869584600498},
    {-0.02443583693545305, -0.176311438929852, 0.2915104496120257, 0.576741127226941, -0.7716236191249325, 0.10868382164195978, 0.2573831727261854, 0.12871798617771998, -0.6605128209066795, -0.6204257286132231, -0.3469153251318263, 0.25897432580363733, -0.19917010301617513, -0.4334410370383292, -0.10752624648658818, 0.5334983748766452, 0.6902949184443303, 0.4807474615212124, -0.7078576371969395, -0.7656162530972148, 0.4979133222818319, 0.1767114935693271, -0.7286490543334562, 0.014758746368268849, 0.5190856169720102, 0.19230290884177656, -0.4997954699944864, 0.2819824429312992, -0.7131921735560234, -0.5897304985906308, -0.5555544507079571, 0.4325701222231804, -0.003630774938515795, 0.7801849360199342, 0.3173553175829482, -0.10309018135350469, -0.5276793908539112, 0.48734358737667716, 0.485883509372399, -0.4138273390994746, 0.19607814779328783, -0.29953866133708557, 0.44206220563416876, -0.18811036434833037, -0.8017980290147544, 0.4804663991652921, 0.6247388888043679, -0.1783530183492341, -0.24939014742017163, 0.09286507174623027, 0.46380390064544047, -0.5059533024986892, -0.01845825300803689, -0.7885224452039041, -0.5614524084117289, 0.4712663740634506, 0.7943667623169737, 0.7346092638323273, -0.5043662686624998, 0.4072951788673712, 0.3889956669943823, -0.32393715115111077, -0.1880303267309281, 0.5219044361084281},
    {-0.01569478697825469, -0.021977105157687117, 0.05163771796287498, 0.6564152631355372, -0.7310482814706356, 0.7074109920498266, -0.03594603104360895, 0.605545768421793, -0.7311968211243824, -0.47820560622081737, -0.3124711162801707, 0.7393352881594064, -0.16274692570320853, -0.8741783978845796, 0.24651436441208627, 0.38616237812177195, 0.4729483327029222, 0.7329567027606647, -0.2936032842003891, -0.6153903361046854, 0.25846072675428616, 0.25574463643563666, -0.6305196416859118, 0.50940009285111, 0.3002856903833521, 0.026476132886955155, -0.17712717330192984, 0.2736878781691895, -0.7381838999540745, -0.555010442440946, -0.10477354864961405, 0.03791210486600866, 0.20252156810129235, 0.6088601323686974, 0.36567159594983906, 0.23364436559484264, -0.3752063582065849, 0.6333744457875308, 0.5720186468684171, -0.6815485102265266, 0.018005723570876063, -0.29160852492631123, 0.33528751328642115, 0.08104300082923416, -0.9369415787821702, 0.1468655694249248, 0.5241391754845526, -0.6471479686273177, -0.382214213194535, -0.14081929234963275, 0.6980543635871456, -0.7137126477461808, -0.20359793328445946, -0.6056711327574185, -0.004910574764652389, 0.6481883606165728, 0.5203649606642508, 0.6603022891492684, -0.4126955863158076, 0.016520345126295473, 0.08589771981349455, -0.2561764441418687, 0.23390715796548617, -0.0048272752035682966},
    {0.26213156160020007, 0.3043431185765051, 0.6695876579286528, 0.521757713554846, -0.4811569931585978, 0.777679967788923, 0.41576555068297255, 0.7293758269922833, -0.03568998849390979, -0.22209025249526113, -0.24796079855558917, 0.5033006417434548, -0.7407625829681032, -0.39071042049889165, 0.18251354220759405, 0.6984009876579057, 0.7416315386709658, 0.5464156683700788, -0.5568128851449582, -0.21264914520305575, 0.32461217150790256, 0.5693217657783303, -0.7664093240267571, 0.13412018522863478, 0.7398621338052488, 0.48313457092163903, -0.802092990397623, 0.3098766551862037, -0.3194900434079051, -0.5511862739468333, -0.24213310675445185, 0.295197171607097, 0.33601554993424765, 0.44651045754518986, 0.5280205454594489, 0.8281225936599904, 0.30641938392707263, 0.6666871061883486, 0.3899203412193717, -0.7588399150970778, -0.2630364630631905, -0.4609871730512992, 0.4715394355325197, 0.45031903148725416, -0.7537263995697794, 0.5606715009181881, 0.5333005502496737, -0.7100647738335898, 0.051372323644145026, 0.6679346082602893, 0.6851111193768854, -0.6555276688844535, -0.4035040712256671, -0.3500829339500452, -0.10772360782123414, 0.1093063303155735, 0.4589500099394189, 0.5012011992714627, -0.39327461386418405, 0.7519491235854314, 0.8013515507468663, -0.49256554210859954, -0.16790002835187504, 0.2437380413193656},
    {0.17526612512025777, -0.32341034431432436, 0.669068487558155, 0.7673961944307073, -0.5578487368684459, 0.8524832691662366, -0.15342957623501283, 0.4531929691476989, -0.10395328737372762, -0.0518413289596738, -0.556947556040582, 0.5651038666826779, -0.466793288205585, -0.7416453888184212, -0.026545011284324512, 0.6440246499974901, 0.29574550881874445, 0.6295556519213189, -0.6555182295968578, -0.25574516459671826, 0.48781334692056905, 0.6524310421418288, -0.6700926060940116, 0.4299126363397248, 0.40815490598739246, -0.3738236408015318, -0.7376985371717263, 0.012261737867452636, -0.31756440937519226, -0.3644548633124076, -0.015479585059080744, -0.4997324684645512, 0.5936980571028192, 0.47490069009795777, 0.39746459076581364, 0.7836107163867103, -0.45313548020005157, 0.6768513106097608, 0.3171233284534856, -0.7434565597645029, -0.3557830510523425, -0.8120610765976022, 0.4032626560820485, -0.3734562043699129, -0.8423876697673773, -0.40417695866734776, -0.042670637917035854, -0.22830618122067722, 0.17632207794749755, 0.644447810784991, 0.597435104781173, -0.6357582386862125, -0.5756328530246358, -0.2979520136320536, -0.22230142596911887, 0.6723642515372888, 0.37597203629220244, 0.6490249293396108, -0.25603057767513243, 0.15766797303818952, 0.5737222943731637, -0.6539132907008648, -0.22134422405904855, 0.6612127140015807},
    {-0.3791917579296213, -0.17800181792378159, 0.6894741387164561, 0.2284471917504219, -0.5581276204574607, 0.7499543161836137, 0.24633643466860217, 0.09687455599079915, -0.8540617478928362, 0.06179293793427879, -0.8966203470693193, 0.6659052280065726, -0.6600335790102072, -0.7811809083042623, -0.5114004019548533, 0.8066481760744814, 0.3957980549075938, 0.526335012235573, -0.5859653337780492, -0.4559536601535435, 0.19232467693585406, 0.5324617265301511, -0.89397919171889, 0.31489766087117615, 0.5453522685022356, -0.59811717736428, -0.6528763886133246, 0.22474930374591845, -0.9190680092192143, -0.7832081427004345, -0.7212900225132697, -0.2336633668953013, -0.02101892064078958, 0.6628984080148719, 0.3780006691995976, 0.052135251189427176, -0.37272755666867624, 0.4902759915419622, 0.21344917818432557, -0.728094380690916, -0.27961264157614174, -0.7465992230914533, 0.25291747186702707, -0.48392903941202386, -0.7594462770897519, -0.2795577512861956, 0.33663375146305086, -0.6704927230283485, -0.4361900197913819, 0.16971642912302873, 0.44397696026039557, -0.7394548834009185, -0.3756586358180095, -0.6693375422939599, -0.7779159578061247, 0.37448232610230126, 0.44786025427657017, 0.732059036958876, -0.1468832871560301, 0.3060538168246903, 0.6498035770887322, -0.7503563356683667, -0.19307874955970314, 0.5820766871716263},
    {0.1288886375483349, -0.5288165188439817, 0.25875225767435744, 0.5123634775273519, -0.11655749875815982, -0.0333949389840486, 0.30726014682912867, 0.2740159860381763, 0.03223901978670584, 0.19619698619660736, -0.485481055424484, 0.6229226639289246, 0.13546754414955892, -0.44630475432072864, 0.5329022903573806, 0.160903959847363, 0.5656668294509576, 0.5894492348183258, -0.38110638718503953, -0.3794307939993339, 0.724021719470159, 0.2470867833084638, -0.519380961204502, 0.07603223953836703, 0.6600700589946114, -0.01554003031649228, -0.11742940513606316, -0.050720609764354954, -0.28834425375433975, 0.1431205034949191, 0.2627520679916293, -0.5049839018512716, 0.1648629332942823, -0.029895603844355304, 0.3466461570204226, 0.49274452845811345, -0.09258959410442959, 0.3149524027595216, 0.0782386916021428, -0.14664645814816651, -0.6431605814588778, -0.5995164682817326, -0.1495349944338063, 0.34862247146306125, -0.6305330008653375, 0.20808475403011029, -0.20443415592766234, -0.021371640869959647, -0.05526296536072547, 0.42605984707123745, 0.17541091659853406, -0.0035184260177859414, -0.633807400496099, -0.41899013683483566, 0.4195448949818937, 0.11675118017449775, 0.3500262403114391, -0.006249284932628139, -0.16667348845068744, 0.2767060095729479, 0.6681058685518579, -0.1578659799003461, -0.05042536984991234, 0.1869259347011067},
    {-0.08992073499606355, -0.1637381581941901, 0.6660770366975045, 0.2279630326227228, -0.4466933905697093, 0.6580476725208932, 0.6491532861988987, 0.7452791098170947, 0.30642688179013194, -0.5460568907597169, -0.21195879933229733, 0.6649114750231806, -0.8435801799944282, -0.6329297319696015, -0.0024163204563717056, 0.7566342883376085, 0.708445731179876, 0.8742258290159447, -0.17460873478184255, -0.5793408821447724, 0.47694283897478684, 0.7659417779355171, -0.6180632999552836, 0.44388821695253333, 0.7397026104662899, 0.3165463726102066, -0.8708150952175748, 0.7508425568837811, -0.5287869528331269, -0.5784306123832929, -0.42730327490916364, 0.10475247522798675, 0.022430109858222684, 0.6490926178210438, 0.877246863280365, 0.5495668570060257, 0.08061024200070793, 0.8387107166990967, 0.60184508389725, -0.5886900114248885, -0.4671991608069455, -0.4532017987355646, 0.37110940048031615, 0.019511354651798218, -0.5944502959957709, 0.30858119808141693, 0.5813604925705772, -0.8052537647323289, -0.09936147214989255, 0.7779858495694773, 0.6689195740745709, -0.8552556302385919, -0.6864901400516347, -0.7572252148341451, -0.3064515117128909, 0.2352286524941252, 0.6402545315478552, 0.5191450291351466, -0.20092986583002595, 0.4937842051285625, 0.7954929839211502, -0.7832084841937694, -0.27373101057196036, 0.36850359382201126},
    {-0.07696576483559847, 0.5222020968002287, 0.4698437520233692, 0.37467674925311534, -0.2343952363642102, 0.4824482550269101, 0.6044663621173274, 0.4443961993357302, 0.204986467143406, -0.3400336498616874, -0.11746376589407995, 0.4333657900457529, -0.5108995210682071, -0.2480638135950853, 0.3677711455715984, 0.6165776489523598, 0.47859068086427786, 0.8272168033354003, -0.46268875532988074, -0.3767489703391437, 0.477844676238076, 0.660456858731661, -0.3098752533708254, 0.2903378203621617, 0.5771365106357168, 0.4403606629027542, -0.31241116557109583, 0.5791842408673142, -0.49448563660493566, 0.17035560183975176, -0.25945558568626886, 0.3792199186872838, -0.0533261381316906, 0.7092184611339762, 0.7562847332544486, 0.17320863287531255, 0.2735448740063467, 0.6093014064332994, 0.5199015953663894, -0.2777283133441273, -0.3752618864368379, -0.3180658923831333, 0.5440872416760406, 0.4839383349765491, -0.09351921959348436, 0.3080210858458503, 0.42436746324948127, -0.45316638302274603, 0.16708896937763107, 0.742243056584619, 0.40457887589089664, -0.5047649320795593, -0.5713522274528688, -0.8224668255046622, -0.06761163250755124, -0.1264669918366892, 0.742481836122233, 0.5134700133885418, -0.2858979998853235, 0.4098638635425964, 0.5651791119714307, -0.6259866702573414, -0.27421523000819237, 0.5243070489273373},
    {-0.5911191085838964, -0.849955237452233, 0.5084517908533799, -0.8756608973156137, -0.6913329462564844, 0.4395538032903627, -0.1792673591832131, -0.7503906785305994, -0.6374263900208318, -0.15668715251420454, -0.6049377193737224, 0.40382555273146203, -0.015457950692602347, -0.41087603782975357, -0.6515264407777532, 0.2904726045759274, 0.2720307591075219, -0.6330542583980098, -0.7506256168946999, -0.7459506099503275, -0.8832826915629794, 0.4617027473991649, -0.7531707967646162, 0.22830044122346593, -0.4284141461951684, -0.822230897546279, -0.893164170751591, 0.19451915207667342, -0.8766818183511006, -0.6739651388023467, -0.8666415714422219, -0.40773347322869896, 0.11726467903049499, -0.13030648585998403, -0.6258775836027272, 0.32311203677853506, -0.6523426296794108, -0.20525993416724098, -0.600130869798802, -0.9320765969855489, -0.7775439490151245, -0.7589299262404616, -0.5531275188494391, -0.9489765535115102, 0.185635614239224, -0.7718151080594863, 0.3710609605485966, -0.459980296342636, -0.5829355006329402, 0.30386151443469683, 0.3090425640369986, -0.45170084522295545, 0.1365652310385976, -0.013441562109768426, -0.5278551441896329, -0.36440795684607113, 0.17425679256323504, 0.10807095862411181, -0.6133405808449356, -0.6294739228521525, 0.4613543735729372, -0.5539590990678769, -0.13676317550104977, 0.4119046368071541},
    {-0.33908317436202984, -0.5376531357648914, 0.6402535759157219, -0.37004805653560274, -0.49162944261407054, 0.6057933487140719, -0.12692132919090807, -0.4940254866867544, -0.2468744930457542, 0.32952722688101566, -0.7267537312103248, 0.21704734156166755, -0.48659549079637826, -0.27239604806519613, -0.3941261495549678, -0.008980752963809497, 0.5911497892154934, -0.17922978398768716, -0.6188550871164474, -0.63860688224928, -0.06478388131605382, 0.6899231126619667, -0.8324545428060457, 0.4845166088314679, -0.2103895515697, -0.5621318644287235, -0.5228003648933554, 0.3852109860067734, -0.4842707600815221, -0.6489285014816192, -0.5689339633168334, -0.5597142421834026, 0.4074462879447011, 0.00162714922404086, 0.07818099077497902, 0.5020671874174191, -0.09876094976286047, 0.3383129588643493, -0.5195946180102579, -0.8631386106810246, -0.8098123645931655, -0.44306823316269894, -0.09951136086168451, -0.6657047327966246, 0.002994345566691076, -0.38662749589111994, 0.3330007943293202, -0.5638498549938074, -0.17717505575860829, 0.5960085140652149, 0.4257478974181984, -0.5075632093456989, 0.0377998519988065, 0.24547695627793537, -0.6630640856344168, -0.5432856914833954, 0.35002924401765884, 0.5112299400988234, -0.577092474282545, 0.20980267990000584, 0.6455442301359242, -0.70093288103887, -0.14153045582615711, 0.5703884141260696},
    {0.02299827551284402, -0.733068688343155, 0.5367930531474635, -0.5055259547869122, -0.6376604883557625, 0.24746616112296063, -0.40553966097233207, -0.7063828481045688, 0.027267232966752805, 0.3844889899730569, -0.7629054515411731, 0.5307094400294385, -0.07081726314694287, 0.0518915512138954, 0.25802396774916936, -0.14173275264281748, -0.05544792938969118, -0.8235334709372889, -0.16628658216769798, -0.6658367724305181, -0.12352818826394235, 0.49479067549067013, -0.38402632307024964, 0.27332897009870083, -0.4030227447141597, -0.28762675171772223, -0.5786900875146452, 0.08780252970701274, 0.045437990233563395, -0.3763379251372172, -0.19713385534953562, -0.7193779526903602, 0.025067976188491208, -0.1289334259052753, -0.1268053186560073, 0.5075896519463899, -0.10453490687089496, -0.3098558263870661, -0.3514489029909531, -0.548620984671142, -0.7511077211794784, -0.03472474905141716, -0.4314860900790869, -0.7790585347981829, 0.5728807720600814, -0.42541328259000644, -0.5275679436836804, -0.14379388343571686, -0.416142338847388, 0.3753361234042168, -0.13195053967451464, -0.22884874016032986, 0.3845491354746022, 0.4327464602423863, -0.4725587053253345, -0.4887987787805406, 0.14901365758133006, -0.05042324575409881, -0.5677268648278938, 0.1117553229502893, 0.13185271833784962, -0.05382473338278315, 0.4597960846270821, 0.4862128905914182},
    {0.35237130562878777, -0.30143248679852974, 0.24941026489726326, -0.34725675422732244, -0.16087275179710617, 0.6028173744693971, -0.5916376236601252, -0.49953632220988503, 0.2096259385740458, 0.17597621564065913, -0.4714594064122938, 0.5058088210096348, -0.01196179268579842, -0.438093209099466, 0.25398264602077697, -0.39204550884414846, -0.24573833183525157, -0.6308596299153099, -0.44244399597208706, -0.6341097979092001, -0.5071506030322023, 0.4364090226394187, -0.3762806789782471, -0.13715479107647965, -0.5333654397573975, -0.28341032380211156, -0.48519756716278156, 0.09449453815015092, 0.023702600726033505, -0.6236973299355746, -0.3080973712126127, -0.7828336018421227, 0.2778665608748269, -0.00977231112768412, -0.5222795949321307, 0.4894582824514446, -0.23172136522658923, -0.0380926150883541, -0.43212830304745253, -0.4849861220507685, -0.5506716068946376, -0.48884410375260196, -0.2524580637401706, -0.565337751219431, 0.12830369204546174, -0.43513171833036807, -0.21370043269230685, 0.02568789505170187, -0.40194855227489057, 0.24919725114395164, -0.09238657261065525, -0.05790424950351654, 0.0589767368566793, 0.49253716729126623, -0.3674671936684227, 0.015416372472816983, 0.28961629956436297, -0.00020439171935300222, -0.3590200533570605, -0.4947032927803507, 0.37831741963654, 0.0025070408538794818, 0.24209207914192693, 0.5255761026127429},
    {-0.5240248256216571, -0.49521849381964816, 0.1072927782975706, -0.022315178420458874, -0.05390769584357873, 0.4492386826703137, -0.215188926661614, -0.3832036197317081, -0.04304428585210104, 0.5687462447171081, -0.27889225088186004, 0.31436173872008033, 0.10093234874170187, -0.23296236966166617, -0.010546263171968658, 0.14641822484722164, 0.4732644623956921, -0.4402387251390359, -0.007530861181176582, -0.5580131322990305, -0.28800765874753625, 0.21049372261474122, -0.44262949385903194, 0.3213692607680458, -0.4477189220747924, -0.3140434699117884, -0.4323713579933748, -0.02015782887112654, -0.2675460230847226, -0.22831657857671972, -0.3498595939080365, -0.7164800931095237, 0.4783030500402966, -0.10015433091525754, 0.1520990309154031, 0.3646763461088617, -0.5815538869878688, 0.12890147237467312, -0.4781522355194306, -0.0212339462141599, -0.6596695306846566, 0.28493131338924055, -0.3262234410531008, -0.6256807192183252, 0.44865041629628494, -0.4233752497220912, -0.32343202510963714, -0.42918857795682985, 0.17605675400212364, 0.3546903366862822, -0.08166444296168998, -0.39221132965280503, 0.01898162589429822, 0.11566672925631581, 0.11328065903965297, 0.1277473548687375, -0.000880324713835523, 0.3865695697678428, -0.25515088253499696, -0.2560812877585439, 0.04303033342877054, -0.2457958083860788, 0.16511588535533747, 0.42747740758778124},
    {-0.3624446839871695, -0.6195435298483761, 0.39961861045863994, 0.03710294829055382, -0.2445327658137516, 0.6320925268928103, -0.15103829109144334, 0.3242435861664585, 0.11223567302010286, 0.34797676379396014, -0.4033648181562265, -0.1702798073915244, 0.13283683494231385, -0.33145207491522943, -0.16924524063047836, -0.1600847287269776, 0.01771711452466032, -0.5480551074466045, -0.04268966466773213, -0.24998068970417253, -0.1965847732724298, 0.054208694064985574, -0.6057494459754833, 0.42013662988022105, -0.1810265128951011, -0.502581343186903, -0.5796275210973645, 0.2162916876838706, -0.19134147902678816, -0.6992635446328238, -0.3687823359798703, -0.6865051418936939, 0.5458436136852756, -0.33882822083857483, -0.13493382070630766, 0.2699543495878431, -0.2349532101087457, 0.186992119367739, -0.030054362340670458, -0.5227965192782573, 0.019087110681068838, 0.339510550245851, -0.269700233452134, -0.654947247133108, -0.1505610752116823, -0.20819401074373695, -0.2532605890939956, -0.12350174460134031, -0.13474345665825269, 0.33743985573735735, -0.1156619281164128, -0.3633498318224388, 0.12857368583988135, 0.31004703208731166, -0.3300223657222812, -0.14647544542329874, 0.08363511016555536, 0.057714755217304084, -0.5364582412223793, -0.3071498276524899, 0.22952160440705782, -0.41334098220933513, 0.3236142885952269, 0.4446311015326009},
    {-0.3855755000974729, -0.12836463116454713, 0.12275845361461078, -0.15139577973900126, -0.19631297037787346, 0.23508345144948417, -0.13138774802117054, -0.37561662334113066, 0.3087341498962038, -0.03204241591737157, 0.06788762460853373, 0.44287533698902826, 0.32894591224785696, -0.3488733375842888, -0.08249659374586406, -0.30748145156622453, 0.2829916858809766, -0.4264648219742059, 0.25724984282728913, 0.05475913869536131, -0.1863665268436163, 0.6638269446521086, -0.594951545913502, 0.36104009196721737, -0.425071445525567, 0.09648074488029312, -0.5906131870882979, -0.16987028283150657, -0.1734849315049403, -0.5455601808867403, -0.37832795099444544, -0.5728139456972822, 0.04045270605366212, 0.3475910894547322, 0.3708474799684039, 0.04366133116895026, -0.283012772239128, 0.3385054358745365, 0.05302344961087585, -0.16011619606794653, -0.337696590158054, 0.10076572711961883, -0.016730563529156563, -0.5784481922005524, 0.02114443080860129, -0.6211475989401027, -0.2795789243362341, 0.0038813930087075047, -0.10967835270981496, 0.044560952507738165, -0.4839454478100832, -0.1576833495466427, 0.22570181730722097, -0.20745846089293987, -0.018077601500156307, -0.22984992399763585, 0.4591497414337964, 0.4681751032207332, -0.6942129250539147, 0.2194530627802172, 0.1300055613559367, -0.06838699442150076, 0.0016332016316273018, 0.333064418060386},
    {0.3232341450690903, 0.13594283696844975, 0.36306717309333225, -0.14956656040060334, -0.7141331733488817, 0.1790317552246381, -0.262009895210933, -0.37375687575055205, 0.44229157075062886, -0.17032681811207093, 0.049307336809733246, 0.4481170564337121, 0.23260998222705923, -0.4965455069927515, 0.5831719984077085, 0.06717411441610295, -0.025386890072886387, 0.05820393667232489, 0.0691166763290285, -0.5959269957054706, 0.05305665755548841, 0.22191767247939087, -0.15785123460251765, 0.0725386151289261, -0.19942461660297556, 0.26634657726596067, -0.5213512531811371, 0.156960643449691, 0.014865254304329297, -0.5091892000976831, -0.04223956452912253, -0.3365216623004797, 0.4554621619567271, 0.03462819160730176, 0.006897041913767676, -0.034508317692393625, 0.004438062297869454, 0.32241382658297385, 0.024536480803408183, -0.04413023184177423, -0.6406920815467261, 0.0748257782469288, 0.46893961889166064, 0.18154671440873715, -0.2945425502625109, -0.08086311195055129, 0.18157329744809367, -0.28666822282867116, -0.5291950074330268, 0.4921254162708978, 0.5182658573876476, -0.5123571497407193, -0.6312874029982964, -0.38804117273920447, 0.05123698467056746, 0.3951522269942031, 0.7308441316858957, 0.3938641537201963, -0.14977376193948713, -0.11557826883001153, 0.08622944048352098, -0.04955020061248767, 0.2031131324889894, 0.44201234790854416},
    {-0.4051160554123189, 0.02229569589048468, 0.5381968912270054, 0.16386986807815118, -0.2789593451066996, 0.11172730667170265, -0.36692108343688506, -0.21780873243258045, 0.3466507341549757, -0.41104131651541653, -0.3717182812370443, -0.08763950247280068, -0.168409229162335, -0.2418040537823188, 0.19983188921594672, 0.4011276235489035, 0.6066624403458121, -0.12333991463925378, 0.12877946777302424, -0.6639447183613745, 0.14525688951259388, 0.12143022993830406, -0.4369571314877575, 0.18729063991781045, 0.3829733013327455, 0.11641655047144786, -0.43498350046188045, 0.33573358655803587, 0.017692372806084482, -0.44500990477416774, -0.5072093340675431, -0.04904818900645886, -0.048058817716089594, -0.02509351430019473, -0.1301527416000759, 0.40104894414077447, 0.24063909148980453, 0.16059991254624884, 0.03824155348933117, -0.5724162393470986, -0.4179764510440413, -0.5301482654011772, 0.4661353997471788, -0.16151144277705248, 0.3293175195343867, -0.2794087612625241, -0.47289886293492117, -0.25921163403244074, 0.17968277400515248, 0.4892666283365699, 0.1529524998079731, 0.0001885159652034652, -0.11775892414230214, -0.03842858564807925, 0.028543772540745565, -0.5475689886719339, 0.6043869460366703, 0.5056130366811111, -0.47149757724436847, 0.25851694318395685, 0.1583512951550799, -0.21861723057974194, 0.20707909961153959, 0.40330502307177163},
    {0.15871429214644922, -0.18238184984198919, -0.20311112040054444, 0.0712926319882043, -0.4461477999380702, 0.39944595275429523, -0.29409540516340466, -0.18673076657203752, 0.02790439847815053, 0.4120764173328737, -0.16939914203576883, -0.2991645137288098, -0.08806653818753665, -0.2717607300957697, -0.30896203292761815, -0.42668227832103417, -0.32103001745759036, -0.09743262123222855, -0.2992414522618992, -0.2440509296432875, -0.2882812261457892, -0.2235392877077745, -0.4554960695267255, -0.31913061815600896, 0.03314636252771032, -0.15643768449636053, -0.07818064386683105, -0.44555830461974033, 0.482503757870897, -0.5151754463334963, -0.09588530279708796, -0.12430684170964616, 0.5563280059002196, 0.06298945837530126, 0.08367055251531214, 0.45002645472008707, -0.017206620675526245, 0.11379305422701827, -0.18844144491567097, -0.026609438424887017, -0.09828449598337181, 0.41092492154842775, 0.39474920883156367, -0.2664308228437572, 0.17625649857280432, -0.20861309946542045, -0.0949846909142775, -0.12882221433904756, 0.013408462544003949, 0.20758415311641046, 0.12399895906688523, -0.3574671365613971, -0.36619127682156544, 0.37552733564330676, -0.05064142333379677, -0.15813000474445799, -0.16516004567822717, -0.08812469936140518, -0.14467781087985584, 0.5433419793205946, -0.568514719012489, 0.3017204586308824, 0.2979746890163106, -0.15275490839325276},
    {0.2507898570920582, 0.16413611665650588, 0.224226414636322, 0.06316240286668597, -0.26425475935461773, 0.510692249656095, -0.4579337119378626, -0.11049740544775231, -0.27888434724853434, 0.4496436523326686, -0.28736667616936623, 0.3124593071120324, 0.46955189293109173, -0.12545321466135176, -0.23023056948169118, 0.18239551701398476, -0.23626558983710097, -0.6349016954682556, 0.2264174039834747, 0.08250380501633585, 0.14212997778081768, 0.09828881453598455, -0.15710854111806435, -0.08535523821891004, -0.2683219598118132, -0.35133520267455015, -0.11260001242327834, -0.028003550821533957, 0.24084412118565662, -0.05635972043797165, 0.01987156840574372, 0.25038612162997537, 0.04104932854410059, -0.20423016647711612, -0.16944437258890077, 0.4604347097905852, -0.0024082913022290147, -0.42370725756522953, -0.3509410727674627, 0.5561091567209732, 0.0268168979635667, -0.2990420755139454, 0.27710842112973016, -0.3095384945960813, 0.37612309955724404, 0.07131260946915259, -0.496391182247386, 0.29767646252083513, 0.1251767419500564, 0.26962016952636936, -0.30333006380070554, -0.05506055469876529, 0.47281393687075607, 0.42280580534881157, 0.10366867089140759, 0.014243274931128189, -0.13865421564524427, -0.2184401994265478, -0.17411559405624702, 0.3780431524972889, 0.06100371964695666, -0.22011869375124074, 0.1593180874591517, 0.48889504477314705},
    {0.3450292060491841, -0.27333650918109487, -0.39233481228877004, 0.3700045659968491, 0.03817768546019902, -0.09291657335559557, -0.5614589735736805, -0.15726100247276567, 0.041446919945081984, -0.1143018187125756, -0.4968400360610801, 0.4147763080722564, 0.5284968869739836, -0.36751772856658826, 0.5121208846180544, 0.31714702462797967, 0.015772458555115797, -0.023899461658795355, 0.4022131217195671, -0.2199014522567381, 0.3775977137701694, 0.3444617323051102, -0.34953908815573825, -0.44912480236878893, -0.5361868120997381, -0.08908184985186306, 0.08753911411296439, -0.39949464024242315, -0.0950830198628712, -0.30763796593628356, 0.21249019716631898, -0.01688967401233542, -0.08710683647426709, -0.1949279861124748, 0.4504952507357423, -0.045140119554764435, 0.23816189631497317, 0.17585553238550247, 0.002597017067098376, 0.1766650660459782, 0.4860525196288713, 0.605083421591705, 0.1915908895748382, 0.3121954672257706, -0.12937424854348206, -0.3370188595485599, 0.3602364185160511, 0.15799369359138998, 0.5585553275071574, 0.1626928383953811, 0.24166125322303733, 0.32375137964165457, 0.563647493314182, 0.22466768970929668, 0.12230013871936438, 0.29474941352218437, 0.3278779877575904, -0.0772124112235405, -0.17116740123223817, -0.46150604770085646, 0.3220977559796303, 0.07965508224142812, -0.3681063134224759, 0.37005863164504754},
    {0.17889622727521287, 0.4881554156113324, 0.6171632663278055, -0.10441086068931654, -0.5111356078232653, 0.5836825769705519, -0.09757351541336427, 0.30823654883437857, 0.25328150366773544, 0.29473899712522755, -0.16699172623809183, 0.23415249396127225, -0.25081347056736353, -0.00968994586573355, 0.3045717231136265, 0.2781948130835774, 0.2538526600827951, 0.23163490691478128, -0.37076646240132966, -0.24242102372526117, 0.2772733771899334, 0.44936863018002193, 0.1172285527703275, -0.2307348915037823, 0.4906038892947076, 0.5162482797865091, -0.2895615762266511, 0.3780065613295316, -0.20711640895595948, -0.4071314358962473, -0.18095487182035985, 0.5721343146716263, 0.012382741364887505, 0.4631681886158814, 0.5957643129444987, 0.05797050476483979, 0.05928804518483334, 0.40730192395630493, 0.3409729144550717, -0.3742216610672639, -0.07208552482428199, -0.31849152532746033, 0.5851488268798212, 0.09781029951435809, 0.3984429178094099, 0.3255793220370894, 0.2018135662672022, -0.5279966077547711, 0.3486283075628059, 0.11816219868449947, 0.6816571829422311, -0.2077515876245989, -0.34746955547167896, -0.2509472507418337, -0.06808137162511661, -0.057479081621204006, 0.5671970255192829, 0.08484069441315414, 0.013541534250964998, 0.5422523414940202, 0.4176602639201257, -0.3063800098169903, -0.4323669149384138, 0.4253255771101639},
    {-0.3474542862943497, 0.3929043066515755, 0.0841467232601149, -0.40378365459483606, -0.04855835014276044, 0.03776650444863414, 0.1355055668829141, -0.330343030066543, -0.39360660264614095, -0.4130875533465148, -0.21928357171148652, -0.35548855772100296, 0.34878737680211785, -0.3829964976588281, 0.012553228021026668, -0.2399897987434721, 0.025895673378756145, -0.12318266411252478, 0.19621318667033025, 0.1496142087805699, 0.34119762374220497, 0.403385728346726, -0.15430789241826842, 0.04022345479532116, -0.025682638178129904, -0.10270160788056105, 0.05900984829550302, 0.025816428753893894, 0.3570328167858568, 0.1562582372453664, -0.49779440717115037, 0.23273983565775444, 0.3137773184729056, -0.3621082485648352, -0.09440220115099646, 0.1173048084196682, -0.056341530796227994, -0.3411598458401212, -0.4156568074721099, 0.27395743439857884, -0.17412353708254216, -0.07500470148745031, 0.5148907281116555, 0.19879907315058565, -0.13703773933627622, 0.1953466083498519, 0.23869858915372147, -0.41963304801898704, 0.17522875584473058, -0.11846376992857907, -0.12158148179480435, 0.09321169654831499, 0.39155227592836866, 0.28354171911002063, -0.27987684053035755, 0.3074605156384643, 0.32560612683897866, 0.3727392625014209, -0.04405533949354406, -0.2205651177834033, -0.4039956885309806, 0.21708786425771145, 0.06318629363361379, 0.41671642347920856},
    {0.556724247157797, 0.16414936234199343, 0.27203364845645006, 0.060543307860787626, 0.42652790132294177, 0.35493095774340244, -0.11798719218187928, 0.26398739811897715, 0.03127019782187513, -0.46704561880067763, 0.23029337862374769, 0.25873847061852084, 0.11483572630648235, 5.79862638553081e-07, 0.034619518558790224, -0.031219903049453455, -0.1654487016688642, 0.3926188768656662, -0.06268530588409028, 0.41123234259891245, 0.3637135045225333, 0.30242120265178535, -0.028366317918239674, -0.0921670043807148, -0.0034035264568353586, 0.2370626615279695, -0.05286565008673632, -0.390174500276373, 0.1409513383319375, -0.4375544828317449, -0.26132450540462776, -0.10569796140129997, 0.3492015680776701, -0.39010932995325776, 0.3201632172832999, 0.49804903820371343, 0.21667714343412373, 0.5967054251885187, 0.36199526148718525, 0.05910042736677987, -0.0767163761855972, 0.4923714381624588, 0.6297781112111336, 0.3760343714092052, -0.3333250176045503, 0.20847953602970049, 0.12440650121551412, 0.4212130613461882, 0.3658543925662428, 0.24400864851204485, -0.010358870583400175, 0.0641401364299636, -0.02300905232018973, 0.4294617440853576, -0.1825800047924413, -0.02069082113436161, 0.17365572740282767, -0.05649928796439342, -0.12383265936121057, 0.47173240189574184, 0.21931762275337816, 0.253922889576259, -0.1303780795332559, 0.2255844717756847},
    {-0.3412199281617975, -0.15707265867201065, 0.5420833799483695, 0.2931806951990751, -0.14808030732784938, -0.028509962479470352, 0.5151084572821658, 0.23241321575492957, -0.15859336198065532, -0.04181908699888911, -0.2328428967589918, 0.3431927504157003, -0.2144514773576462, -0.43542001792567264, 0.640322221282629, 0.13905369694540487, -0.05677746828992056, 0.40200524161350965, -0.1323549575770198, 0.1898600380477995, 0.1658008037202713, 0.5337349695978475, -0.3637250052142863, -0.15420533533144534, 0.32319367482515027, -0.16954782074028435, -0.6277525141498348, 0.4431140228849165, 0.16809304647033985, -0.54718206890731, 0.05105600776343258, -0.33299647356665124, 0.30082683387644105, -0.46070955554078236, 0.4841231796335041, 0.3622833615389072, 0.29297111667544756, 0.42329123842307637, -0.40894890621541813, -0.0021469221548920682, -0.16120927318053355, 0.47782646719658345, 0.4022937654385533, 0.47386522888004157, -0.21709988567128732, -0.40882344997003595, 0.5377883134129878, -0.5226271388443238, -0.1376642664388938, 0.35404636418807645, 0.23396110527383876, -0.27473270816978235, -0.4091338266429856, 0.041350476078882814, -0.06807339670512086, -0.2777081112978079, 0.0543192527064932, 0.027291766852910362, -0.327608766065766, 0.3773409372984004, -0.04395992553669506, -0.5077279115917004, -0.03223686781622955, -0.16459002964453126},
    {0.03914689927538388, 0.21641113219677036, -0.08840855872759762, -0.16465411982339354, 0.062055282158731066, -0.32027622248012444, 0.3815872241199182, 0.40270562310601565, 0.3657835058664566, 0.11966834563063994, -0.22135190719887535, -0.43689156352527925, 0.20678086613832405, 0.20817127520069356, -0.013479227657227767, 0.22639875879405935, -0.1656206592977643, -0.42833450496854725, 0.4214163245703527, 0.5500220757421349, 0.09000168096506427, -0.19176559233272783, -0.0859769888070225, 0.21430723203453342, 0.13645801418399, -0.17153362771396558, -0.14704921013041933, 0.15755599711204876, 0.4414108967928555, 0.5166917337811886, -0.343448761412237, 0.29732604683110925, 0.22094010591142418, 0.06599115922339363, 0.42523846010008765, 0.6000528311758334, -0.043914990332107065, 0.0040370678299562245, 0.06081051449353656, 0.2178590709228962, -0.04708274149117338, -0.4188633368963036, -0.16211421591484138, 0.2231204725453389, 0.11546238841598741, 0.4849085973142263, -0.07685354984693847, 0.27455904974022494, 0.1240697659665612, 0.24845412966697117, 0.0018527537533941495, -0.05684807558351382, 0.18349146878138473, 0.31372060313293815, 0.07764675297070599, -0.03956298759203645, -0.10722220383304437, -0.14096544411974937, 0.034233417143729294, 0.6584721400753512, -0.21011869301237376, -0.2103079277404698, 0.005550817190062562, -0.14385172045165776},
    {0.004201592437933942, -0.03207268920338525, -0.3730199501354772, -0.11072760108963575, 0.08895982040539559, -0.5045999683753598, 0.08255679755881656, 0.2660042790929626, 0.48904800551712996, 0.02627192136611282, -0.42118971489902135, -0.0786753504359304, 0.23996853963874806, 0.0340897123391255, 0.09084623052930216, -0.5203823327016788, -0.611883469885297, -0.5713312125601896, -0.0582738287249715, -0.0033326108563297577, 0.2671523995376662, -0.2548424047938242, -0.265243103456183, -0.23056275785744876, 0.046804851045552036, -0.41068226249623624, 0.022350366473113305, -0.3543727036928071, 0.3673020269736376, -0.4287877245963817, -0.09255134083115545, -0.340880409621656, 0.6531348618694386, -0.1599831141918612, 0.031760421655636174, 0.1208398802839895, 0.43924087135405665, 0.29736441724489787, -0.3131927020789517, 0.170556184672084, -0.29149816025517145, -0.14671548426884357, 0.2071153731416844, 0.1825478063059475, 0.2615245312420741, 0.1810024405175132, -0.4089861277085475, 0.5200322823512036, 0.43583862889172603, -0.39153862712168924, -0.150897911440756, 0.15231279024727667, -0.26964245598362, 0.3532174754464636, -0.01583583424243111, -0.517530158110709, -0.12257447920454992, 0.005495736873190063, 0.5171851573774071, 0.30332670597711375, -0.5194327130905696, 0.11911207276021743, -0.1455090967642172, -0.3260136991977387},
    {0.6242861895522248, 0.05140980119340381, -0.16861598934515565, -0.027079449350225535, -0.2190198706074268, 0.131601879509377, -0.044568656634616205, -0.3702757249067645, 0.4446241829728922, 0.10659701382153464, 0.22570484566506152, -0.2995818895201149, -0.34881004206930544, -0.09175916062667529, 0.11568243544485392, -0.6477207151384488, -0.4943265509289381, -0.421958287946474, 0.576261677180462, 0.2177984450579394, 0.06405906529517479, 0.4504028223433941, 0.4253970982864441, -0.4488497959394896, -0.5745154447894121, -0.2511723746869157, 0.25209109395340257, -0.12338344972651286, 0.20090625084078786, -0.14168531288594796, 0.2025708079885094, -0.39455819682241355, 0.570039812429034, -0.6759819492604001, 0.0358136489232274, 0.47619134440433564, -0.04933785081836301, 0.3843599516492432, -0.6304772829816295, 0.09220063101472645, 0.17398551253432662, 0.36035006384776486, 0.04955584164863461, 0.4301628982348455, 0.3380381215057188, -0.37758064867253815, -0.25461245641515773, -0.030280984528538682, 0.22896380181377657, -0.5926054873540835, -0.0982490770601738, 0.15004463912006963, 0.5092326921722087, 0.5434733251872997, -0.21367799818181338, 0.010474190393780641, -0.09457238500387732, -0.2052408181308271, 0.08130188562957681, -0.24613518221340608, -0.23496803431184318, 0.33480156316974474, -0.015527361414912986, -0.18766370951953018},
    {-0.14472358952804204, 0.3704729127929715, 0.19915243062795684, 0.5404671301496616, -0.10720336484721289, -0.23939031361567037, -0.045043163966426214, 0.1970188967123098, 0.26772699328214716, 0.4953913763619661, 0.6363024790889243, -0.1655143734441596, 0.1058505596490205, -0.27469229659817307, 0.4693401249991648, 0.10328780046830881, -0.5412528318265113, -0.5466296613528866, 0.11688656883789973, 0.012135883513637535, 0.3348673158904853, -0.010946859375469692, 0.5007733684130367, -0.5738590128635356, -0.35388828966144864, 0.17981614779232322, 0.04950853166657234, -0.2698274830665331, 0.6310306702973568, 0.13391517831156163, 0.5020053144748785, -0.11899254355127407, 0.5287678372512418, -0.38725866380459034, -0.3721145380399418, 0.3574799402513631, 0.26692515663423627, 0.059016420716874546, -0.5026511362028382, -0.050126062700586824, 0.29011407701838343, 0.37038175466374107, 0.005523979904012453, 0.21772453084127436, 0.3607224262984906, -0.24341573291954388, -0.191397368028275, 0.3000488086898008, 0.27436426845384676, -0.4202328537460453, -0.36887307273653486, 0.09055109084380289, -0.045077485933709055, 0.08806197903696991, -0.2401730650422041, -0.07319876181557086, 0.07431963571838957, -0.14018522079165904, -0.09135443144916036, -0.2487871302314681, -0.28934888815980236, 0.26107991103088585, 0.245902710419319, -0.3404900298353967},
    {0.41268425568142825, 0.12908470107097636, 0.2478398812433439, 0.3937699483982547, -0.1698582335343679, -0.0030750430485385863, 0.09477919961455397, 0.22480348837531253, 0.42865032244406914, 0.6371399896375716, 0.07032884677711207, -0.11646619776137433, 0.30295251492714087, 0.35109881103777746, 0.43251117386929583, -0.16517881819678326, -0.297490590186032, -0.27107720223412474, 0.29528430639431613, 0.2063468930774415, 0.19267467104795075, -0.2948278568369489, 0.3719611202202853, -0.3714787262341059, 0.20273676301398577, -0.09173136353865502, -0.3061184027026502, -0.017802889049124606, 0.32562176356775413, 0.196419444647507, 0.27775029238977605, 0.12259035026335076, 0.12115799001143716, -0.13745708768342707, 0.5192689047175543, 0.5800339845471922, 0.26355328984922016, 0.48518610224429337, -0.38041118467912893, 0.2845541979403559, 0.35466242263405096, 0.043616388463845315, -0.24314864178894496, 0.07838241180652025, 0.2955636610677154, 0.003721045457921661, -0.679896118390829, 0.3182788390228584, 0.2566683471280969, -0.13846293028485743, 0.005984677982102809, -0.22695643516587047, -0.25639740788073556, 0.3763880771238691, 0.15648889211186975, -0.17964584334810452, -0.1438508173134215, -0.2858886698989344, 0.5355078034863288, 0.05703144616074905, 0.10015234698680141, -0.1108427808590812, 0.14417124384694066, 0.38773381589770833},
    {-0.35940227894517973, 0.23440975606209796, 0.02565351806964722, 0.47374245620232514, 0.45764875903984026, 0.17644719208900006, -0.5853390787485371, 0.3069848445427634, 0.6044471656867209, -0.45240879856908606, 0.262706205255833, 0.07469986679700735, -0.13833400190851483, 0.09615125027454385, 0.3402069246404237, -0.47027348223580284, -0.08077732689560904, -0.023127092931191858, 0.5899064866810675, -0.26230345058314974, 0.48848513742201294, -0.394484219122054, 0.26620436833921185, -0.2997001616422047, 0.3008536897381151, -0.01478570055421335, -0.19101624870693185, 0.25774488195449813, 0.37033039089661, -0.17222657757069554, -0.017007376023141802, 0.36471214524646217, -0.293715355810906, -0.3989457548090459, -0.26948520011143073, 0.6856114205532988, 0.2574353633582466, 0.5022001549827704, -0.019976562305934992, 0.5203801626560289, 0.41739608320709404, 0.040121961978197174, 0.5092191056989082, -0.13172501388278687, -0.037751031765326036, -0.21725923065850405, -0.41141161487447997, 0.07458561924441717, -0.07412314229232961, 0.34669671076157255, -0.12535639048156375, 0.48883439308515064, 0.2788305772332274, 0.49217279697316574, -0.232153412850322, -0.3370067793267045, -0.22621915101751114, -0.36939729826821605, -0.02223876112114982, -0.17045191571416393, -0.14205300768673526, 0.13985580436104061, 0.5668618630001351, 0.1809178125249255},
    {0.03737395560655623, 0.4074374199140914, 0.34136700375305773, -0.2781321285149667, 0.2430500582947744, 0.3084355042329186, 0.1300095143934512, 0.10501177821195161, -0.0652606298119731, -0.2514993822392403, -0.18548380572373982, -0.4924507220205415, 0.12575671210621664, -0.14524904965530583, -0.20618193995585762, -0.5759783455978056, 0.36927917557794904, 0.10004566905334566, 0.4933312453650947, 0.28480974077815996, -0.13576291542882657, 0.11166132656622826, -0.04966583783339016, 0.24916178065043237, 0.0275730400202962, -0.05811233291934596, -0.2368517432748502, 0.3215948439358369, 0.38302376901393576, -0.054633057453749155, -0.3630048503644039, 0.01288303736953481, -0.04045793665603454, 0.3139663634409487, -0.15951693466965183, 0.5588479941809109, 0.13936241673609648, -0.16878602896791634, -0.353513424755994, 0.03090481871855723, 0.41597631571577054, -0.3617612667394414, -0.03178174727844581, 0.22150951785810677, -0.019807971049453383, -0.03322464989974294, 0.016570025322846176, -0.40474082041046927, 0.033037634727126244, 0.3444090642623555, -0.11080429597808053, -0.07043654413142968, -0.07067746075792126, 0.0059395396180111654, -0.4411800643985778, -0.16857663330994357, 0.09835917888403255, -0.38072969444635774, -0.1299051762807015, 0.14778109463799116, -0.1710748496799736, -0.39027545655825113, -0.1313528984351007, 0.37002045560293906},
    {-0.3446132263474109, 0.37616339354579204, 0.5158922301632781, 0.4326603770419814, 0.21744304094580513, 0.28756199579355024, 0.10073938131774089, 0.4841700955448868, 0.4786943055877302, 0.12061089763842758, -0.31693201100954904, 0.49554680879147206, -0.32344049188683016, -0.004917754305993437, -0.3021051902393828, 0.0724840462515613, -0.19556516943592891, 0.39370305091741387, 0.06349428330970419, -0.16002438054980087, 0.4045825983111903, -0.23496979330927245, -0.3022176661125173, 0.32642219134865574, 0.2200481968605978, -0.08372224464063834, -0.1419511631523032, 0.0822546677885803, -0.5431190022714576, -0.34288940285836467, -0.1850576639035559, -0.08267760618212842, -0.3271841286913387, 0.23264743176531194, 0.33401089139602064, 0.556019721270246, 0.3727622773307155, 0.44146522371343516, 0.07787934548750886, -0.38061201113614374, -0.05293438998674954, 0.0023472439303756044, 0.6208528712904783, 0.36837271404192845, -0.41438675087760224, 0.45838348733880235, -0.04914919623845365, 0.20679828384283694, 0.44529853761197513, 0.2646129270607557, 0.1824314139148188, -0.4216231523133639, -0.3184396855439558, -0.5206188919657161, 0.004878149372749076, 0.2959158432571426, 0.42265080776655406, 0.1085843756232761, -0.2581432976442116, 0.08673447850196866, 0.34175193565336054, -0.06612841076455508, 0.14733343109944969, 0.47878405327594636},
    {-0.06718368196898834, 0.20573095662975355, -0.052200240465656654, 0.27671093989364204, -0.198219065331209, 0.38648114973515574, 0.3787116691170683, -0.2206374218006346, 0.17419148177178517, -0.36978403804008764, -0.2080843423981856, -0.13254437779558875, -0.44557821029906225, -0.11001447026923492, -0.5642430726375108, 0.1711445701119298, -0.04124004651064591, 0.352595324146114, 0.35613496007585715, -0.33105333132971493, -0.09741306352235501, -0.39324455357680377, -0.03944246736487359, -0.35837260497423545, 0.17267226584642134, -0.1665349150985151, -0.36722069996246576, 0.36355073060962406, 0.038605365254598636, 0.23411127463409404, 0.08090616627984981, 0.3564163988429104, 0.2136739766892139, 0.10245820615961898, -0.30610821130203275, -0.2724592550499766, -0.27491641176697995, -0.1532279070481799, -0.41212382915326234, -0.0907957660856826, 0.0235378036069023, -0.27432566821274645, 0.4843741467358403, -0.43827963398253855, 0.32116455817202444, -0.14094550806232567, 0.0007748550353722497, 0.05748433350509739, -0.260659951399469, 0.35431380086857533, 0.17499858001960072, -0.28852434090207796, -0.24546858651034997, -0.28594497498752125, 0.349566594709305, -0.017440319341943854, -0.10777964259633116, -0.030754669518422272, -0.03203319195891379, -0.08033935148008241, 0.42007059113065875, -0.12144964594810838, -0.2796162703828637, 0.5306798041582431},
    {0.05526114925660672, -0.05598870053804705, 0.014776713763110674, 0.04471785862048461, 0.20373819792765818, -0.15747262082829633, 0.06339474704749319, 0.515955108139483, 0.43928580606986517, -0.013060823331661964, 0.09402256942974466, 0.07449305172833055, 0.2228016293653296, -0.5070815053748879, 0.5244769922268439, -0.46843221184706707, 0.3332642600895726, -0.2696386400434497, 0.5102789883559903, -0.026701986350345795, -0.036769018653044556, 0.09640603594876333, 0.01985517910240384, 0.5316793665636795, 0.3341954575257333, 0.5074111491058972, -0.11221049345288678, -0.1761217094827333, -0.2640506347087519, -0.0603270238759799, -0.520825463144889, 0.06282084737341265, 0.6014839594337982, -0.02755763977279992, 0.48402660252848523, 0.5508988711227379, 0.24138301480994886, 0.07175322136060319, 0.33567379260002844, -0.3945775801556497, 0.10562540381620297, -0.03319468750513237, 0.030966310122826284, 0.5124617216821762, -0.3112925585161796, -0.014005284133210196, -0.5143692132111949, 0.12381319541924585, 0.08098800447734514, 0.15361988289918233, 0.5066492182918148, -0.033027377694074114, -0.6676378085365788, 0.012759276296156722, 0.28576738349817743, 0.27588928362022036, 0.055333539383288464, 0.2014796128383459, 0.12570452861114043, 0.4746216881278115, -0.16391086821533893, -0.08713373066932797, 0.15639131381338292, -0.4641611480883231},
    {0.008045630834505041, 0.43431767261127774, 0.4688711581113111, -0.4238166045861934, 0.26910946002033376, 0.09538784097078692, -0.1369671194108349, 0.623092144269709, 0.36176369141445536, 0.13865112362102675, 0.10001488048898674, 0.3952952063385583, -0.3308437063509753, 0.08540132087268434, -0.5383479889488244, -0.2484670924233674, 0.058699863874467365, 0.5498942219569463, 0.23053623878127938, 0.03472982893832467, 0.04553949326868843, 0.136707719377075, -0.02729828788102065, 0.30676343793988947, 0.5218574404219776, 0.4424005250782922, -0.27968271045597004, 0.3469733584568788, -0.38647261017433965, -0.61640147121614, -0.02339774602123743, 0.1614552301001079, -0.06445126975497732, 0.35265565556237227, 0.5802634785080801, -0.11958788057824692, 0.23658236736328428, 0.3635756522859184, 0.1666887587614964, -0.4878965139005203, 0.3350569647367486, -0.33015012567442803, 0.2271522922959529, -0.4794772565260047, -0.15541499367105902, -0.18020563562248904, 0.15020503210816358, -0.08555926296182595, -0.27199026468814547, 0.2221944357039839, 0.3822785127578344, -0.3834458363513538, -0.16569359928707786, -0.3175589153909221, -0.1145248157735707, 0.2812123145758438, 0.3780998459542887, 0.30716646494032696, -0.32011241508998883, -0.13412167812183962, 0.03506002851573818, 0.19175602237193917, 0.1900303092990026, 0.40629810781419556},
    {0.20353958185202223, -0.23399866046342876, 0.2782346660131986, 0.4095611755612944, -0.26269260852023124, 0.002139389285087753, 0.10413066884304245, 0.45546980732461895, -0.3403229734980636, -0.47764978670271657, -0.534383528029964, -0.4184223549219658, -0.28272154520875464, 0.4994018202093955, 0.1647094140355398, 0.1011933927289498, 0.36389576235380244, 0.538606143313045, 0.07792526809518813, -0.32395530682576484, 0.4462568199802705, 0.32933434312500914, 0.11873860047767813, 0.010996310078105597, -0.023226858564794832, -0.16038908792892642, -0.3089202430612897, -0.09256275735835703, -0.3638108525422353, -0.09939421732780856, -0.4798879752372274, 0.07527696836384748, 0.28723975024133963, 0.21147367153974575, 0.23216277409948669, -0.004263988231386999, 0.028727966429744723, 0.2381789644939282, 0.22141185014835496, 0.11315428990329825, 0.3416840248432761, -0.35898726773678347, 0.186244559150254, 0.10149196073123849, -0.603364003455367, 0.3449011819326347, -0.13057362634289776, -0.3973465356535484, -0.530578964669448, 0.3262272970216929, 0.40655611782520923, 0.001267590387581174, -0.00223476192915608, -0.5949060640586445, -0.2340488705950552, -0.3484511647863724, 0.5334506463289879, -0.09850677070184852, -0.24281040088727204, 0.2335170012560819, 0.17169256336685484, -0.16062373240407465, -0.4135932976246105, 0.4508546833914269},
    {0.34186318245354663, 0.29321497706546934, 0.35370224625826396, -0.049188733413535975, 0.110168141086752, 0.7038476224206096, -0.1311834501895529, 0.6446334769978578, 0.6132942089128067, -0.42125129883879897, 0.27053134360556336, 0.14398939597463864, -0.5200741925488459, 0.2711924119053964, -0.29842444670854007, -0.024680079737396717, 0.49999423071599175, 0.06720911602812381, -0.14615976728300084, 0.22000746624725614, 0.019323583194803935, 0.38111767294289467, -0.31234294406831153, 0.6822649658014333, 0.5001256348143758, 0.4099956224324789, -0.6345789443931096, 0.32011718619611945, -0.6038880802756943, -0.3855053408603327, -0.030942745407016237, 0.3493646526397312, 0.4055437672926023, 0.24931167344924474, 0.5900020535494537, 0.28922267026340687, 0.4702781914695302, 0.17748117309297948, 0.0402789318810782, -0.47143366259873914, 0.43416792892711953, 0.2289960421838348, -0.012846727752192116, 0.0940714584164768, -0.12193811324659216, 0.3449896009332231, 0.24300596500553812, -0.030295504630762717, -0.020453547557639538, 0.13686829798325725, 0.6636515209496322, -0.5987456933261734, -0.41096388141351325, -0.07868369778760109, 0.22568477646903815, -0.2276739686805552, -0.08045927872174871, 0.4707484085485438, -0.3443651375251298, 0.2773866821574125, 0.5833347689751007, 0.05154197044508661, -0.04698677743717799, 0.1028731412571286},
    {0.3237167157622022, 0.1768403248373326, 0.4920057824691596, -0.15216444258373024, 0.32735888565693483, 0.5541489065510932, 0.0541749918828285, 0.16533230072309313, 0.32111835988511317, -0.3086985474505887, 0.34627518813423935, 0.16009049330722125, -0.35759154350199696, 0.0021436043196349825, 0.13811567978291198, -0.08366312754996402, 0.42031142016280915, 0.21909354068967754, 0.3631766102624748, -0.1426714326180572, 0.5695593365650662, 0.20925250368880102, 0.11463748455301159, -0.022456452314350596, 0.565938383441113, 0.6425247824464987, -0.38758374777298804, 0.6099913386445412, -0.17393806116826635, -0.3062033162152242, -0.2586357894141815, 0.35249666765531634, -0.16452174451926382, 0.2714881200050912, -0.3104830208698429, 0.3723410877620033, 0.4462270098167688, 0.4289738432889796, 0.5087706302825269, -0.13545898739535764, 0.09401209438683313, 0.27847800270069994, 0.13639445493274985, 0.172297677413155, -0.04318360862906136, 0.32705922281888367, -0.13984497163129755, -0.6148311668480175, -0.012022504787064158, -0.11139401088606654, 0.3691614535706687, -0.5426490834936974, -0.3707955756923181, 0.27531373760334726, -0.21694572528586253, -0.13268081574603477, 0.4625523249391385, 0.52231243351849, -0.0720298249914057, -0.0989768487633445, 0.5386261232705661, -0.5649578468598656, -0.37654208619000723, 0.23054531554112925},
    {-0.3856759962568391, 0.09376011467491781, -0.3387036574546818, 0.3567757026028759, 0.2897766408382758, -0.12770584164700213, -0.003713049093989842, 0.358328606731175, 0.3836409232988681, -0.19782944882216053, 0.266804796029451, -0.1725244528729318, 0.21839078908270754, 0.33728260952438016, 0.1270402536863951, -0.2549019559903813, -0.2905251795646686, -0.06400697760550952, 0.3165010412085864, 0.09336963472060925, 0.03887103265747027, -0.31129998966661604, -0.16198144857686578, 0.24651876554293808, 0.2519717522338267, -0.18281713619106332, 0.2082610694880361, -0.32261050020787174, 0.2418738636905655, 0.1180618519552309, -0.043705161397322695, -0.09135405783279735, 0.16563692487504192, 0.3392126260093442, -0.12496098962191772, 0.03890567175427165, 0.4024699755087715, 0.2310648054054674, 0.4435228243356239, 0.09076815289569634, -0.04742064214400414, 0.2874844733837466, 0.002224023080916878, -0.0882456630045857, -0.10119354653194633, 0.04624347299682695, -0.13431819843397685, 0.39976396293328875, -0.16160345466392068, 0.141058408018902, -0.12027282061556988, 0.13852311706773957, 0.1476557105956668, 0.08473095572144587, 0.11019358584778598, -0.44096167448774465, -0.03493847828651658, -0.1429801091412906, 0.3196373679743543, -0.15611802297338412, -0.21323881136770725, 0.14101566545484678, 0.24372865737935945, -0.21894136775732978},
    {0.18725860884097426, 0.1046026378334774, -0.3015689313881932, -0.5292348419926391, -0.25901431902315947, 0.3098118407408039, 0.24834733425552089, -0.3048657312877082, -0.0810285935210521, 0.14072039642461423, 0.392062971516241, -0.25831997620142083, -0.05669220514855686, -0.11021826714361954, -0.4271469361125646, 0.1196585748672248, -0.2539563018473446, -0.2872229409229296, 0.17949221063270593, -0.11059391878144086, 0.1839134598177091, -0.31768909249562977, 0.49812257308575897, 0.3028128535579322, 0.3809054958779683, 0.23525490635294016, 0.27435000797461745, -0.23631334906199292, 0.2471867441333087, 0.21961276434996407, -0.1308912180522761, -0.11153288470605982, -0.13284663463885651, 0.16190215503106362, -0.4302139641894599, 0.13030586903780805, -0.3646538487606259, -0.12908962496118556, -0.22517742168247876, -0.002208345355089571, 0.47671503985483044, -0.30620936360067486, -0.1927620893792198, 0.044088016300131184, 0.12309393817001647, -0.07376645356897149, -0.41340870869580804, -0.428457584104862, 0.32476956294558407, -0.0548267146265821, -0.5716700014519779, 0.42178449005381113, -0.15267777077473024, 0.22434829979813203, 0.22218667552092156, 0.40363512806049384, -0.3732606941872053, -0.18519397951030284, 0.48643881004653555, -0.4283967151931519, 0.22165690938713148, -0.19608059361463112, 0.4187664577789232, 0.2026686550279837},
    {0.36958818287934314, -0.12044894349360133, -0.2006056264851129, -0.3498289109838993, 0.12815187459037736, 0.006800617452688399, -0.4418422503768255, -0.301444559052756, 0.15992735584556922, 0.11670268171215752, 0.031009113280332994, -0.05871836241821798, 0.41367380772953216, 0.04351560583568775, 0.061948678187406674, -0.14489426225751104, 0.24281079014114573, -0.2058320515372367, 0.33961872949839966, 0.22514367701758164, -0.05254198545636177, 0.06981058138963575, 0.46545551312822836, -0.05410667350606925, -0.24983464044140527, 0.009332773798888446, 0.08568475321488934, 0.19485734723339357, -0.05304587864538381, -0.19505453874772768, -0.23033519033445135, 0.32310488863570597, 0.4158955913655061, 0.16317950930516104, -0.38469083683923294, -0.13231124402300715, -0.0421657990955755, -0.1648596153161462, -0.140429199152417, -0.04037481410812554, 0.5349245283216395, -0.4165138158565082, -0.23642630117126037, -0.26368881306110875, -0.017246931591262477, 0.20121895869212866, -0.29268136400324013, 0.06260453158388438, 0.06193427761416422, -0.3156210425216714, 0.045133215093376026, -0.2439493647708414, 0.10394646012328077, 0.32941455790315227, 0.1905708148594955, 0.45582406022549943, -0.2923238898445689, -0.20340570336284663, -0.15251690723112638, -0.0967390032049108, 0.4419921296681287, 0.1646336958253479, -0.03008779389188692, 0.09354473689729254},
    {0.018587810113894192, -0.35647097284951623, 0.18728640017264786, 0.36021053268206893, 0.061925313719765784, -0.06512799118080086, -0.01022988410849664, -0.014689223367644567, -0.04422528970882024, -0.35318199573766546, -0.07068378476594898, 0.29705044600278735, -0.08422886652000372, -0.2701007941024754, -0.017622015327079382, -0.06649867740193681, 0.008572439501728635, 0.11328837004503765, -0.18567933736914888, -0.1497733963508766, -0.10150029368086991, -0.03007529112910624, -0.014604813307245088, -0.27660008532907365, -0.3534222183378354, -0.26999284152752884, -0.42395345073188434, 0.057357937400418106, -0.4926094943530112, -0.0712965750341545, -0.15753562611967767, 0.4016383178543416, -0.18320237333544076, 0.31664420944546684, 0.035761978339068023, 0.2853809858245278, -0.010099066219682262, -0.06255118816331418, 0.18390823308103216, -0.28356441693917905, 0.2819270723211187, -0.10701575759325996, 0.12368643934908984, -0.09206492173889397, 0.2046909122305923, -0.09670000882216026, 0.1578555274153855, 0.0776615548234986, -0.47435383574680634, 0.11678472217102813, 0.2589221583561806, -0.01590357711979592, -0.023832660881631766, -0.09987852629935424, -0.36836577579142477, -0.009062240698888249, 0.36385721444258295, 0.030904313691585673, -0.5290949325439113, 0.20378308254640207, 0.45970025840877765, 0.1446872202347506, -0.552766745871556, -0.2846839527979271},
    {0.1337498492716999, 0.020100803339494606, 0.227038838272386, 0.2273527147327555, -0.04083581765018183, 0.030084667991405717, -0.2157922777863044, -0.36907800688640063, -0.10236136696819664, -0.397864941971547, -0.3398974208104163, 0.36549670014927177, -0.049267165762575206, 0.31385251084758614, -0.24326899830161938, 0.33159467011028054, -0.30547378931180275, 0.19364979155577236, -0.05756563034723837, 0.2919390042295932, -0.12924287519187325, -0.2461122523239603, -0.4029157214487858, -0.5796404158196146, -0.3007796004137017, 0.01725751491893132, 0.13640309546687263, -0.11021415739567499, 0.07526734139456644, -0.03376554443446887, 0.28513142715958867, -0.3348286992463276, 0.2593526041149732, 0.09570818243518944, 0.27749950065337503, -0.2978926540663334, 0.21154225413825234, 0.19102747988088192, -0.08393725686671437, -0.15859326886840241, -0.19682823518718673, 0.2816008926505793, -0.11140329478707635, -0.04507162584556954, -0.16478862235539213, -0.153997206935284, 0.4648795748084263, -0.16865127496972596, 0.3734791755110113, 0.23093736788737645, 0.41158685871933415, -0.1801262219371383, -0.2663618347224835, 0.2855014094810361, 0.07472972083702874, -0.5715918887266077, 0.16279096676742008, 0.3034127768384996, -0.035332153373379395, 0.3120710373544322, -0.08669774331796272, 0.17532209837493648, -0.3889002965140704, 0.007104118318407548},
    {0.08967182639793848, 0.13408482291437315, 0.10882780705923055, -0.10189145435509603, 0.1769540460139902, -0.028005789156231944, 0.4178952703022235, 0.30547872237291557, -0.15719457792398642, 0.13789326289685352, -0.49818697636564674, 0.0653314437582308, -0.20789587418047778, -0.11539037407281438, 0.31272752966800005, 0.5017882179394986, 0.22656608711758894, -0.004045824211337881, 0.3566009070558194, 0.009838118426712185, -0.1322836503845011, 0.08860529282015049, -0.4443979994485869, -0.46241108982204987, -0.32991538496404443, -0.24938459150007417, -0.2363646604126134, -0.11936745871878757, 0.1288653642104938, 0.3157905448474428, 0.10841336319056853, -0.28837482293744676, -0.0363395270298052, -0.33226222001685274, 0.38794118606313494, 0.2672155104138904, -0.19045233427973612, 0.26445931857028776, -0.02811871728732844, 0.27345560585370543, -0.4566492315763782, 0.0004735928802282371, 0.42311795848380906, 0.24693863537827332, -0.29026909255119526, -0.25824895850696045, -0.10432230774590047, -0.003884339385817111, 0.4852104123061105, 0.3473093192021306, 0.3608823860667377, -0.2544445836397366, -0.5211735341290359, 0.17074002965770116, -0.10272086185770775, -0.20196613612050693, 0.32627974460404424, 0.2926423513122336, -0.13910489693687964, 0.18501283530931545, -0.2911896545488376, 0.22939414052431176, -0.4645024350833763, 0.367297519387173},
    {-0.25461371500903685, 0.26204911041576273, 0.34647155708016236, 0.18674853802200098, 0.0010075721581620787, 0.34720338176980287, 0.3135688243097353, 0.3165249694422996, -0.1254088111352049, 0.06643555303472944, -0.10693721207780933, 0.1687800901890245, -0.15146357579137648, 0.10437884087834622, 0.2933396976556733, 0.07458486887868616, 0.4156995782970213, 0.20613696393630926, -0.04540425898195136, -0.40273277576328786, -0.36202926505091937, 0.26062596169777025, -0.1908612044315121, -0.12872023372059754, 0.10295340326224593, 0.1511692690125137, -0.045676793274001815, 0.1738508914105188, 0.20106823064342133, -0.05877561358868423, 0.08671650685993418, -0.19863521221310093, -0.3853375134289124, 0.08985403297024877, 0.2874399756638799, 0.47978202303700196, -0.08309803213723924, 0.16679661342134616, -0.3950197445852364, -0.009173058670494148, -0.45240618250208364, -0.23714493166862569, -0.10202612420213976, -0.13889056966227176, 0.12430741678328282, -0.3564685180664011, -0.046181167570961634, 0.23538967645614833, 0.21259140340228458, -0.2913734655466461, -0.0617918570997716, 0.2929500558039852, -0.39980532297841304, 0.23182315168046874, 0.17705340342984993, 0.46916304967271877, -0.009413553830563453, -0.23725648795581739, -0.14761577525509428, 0.168290141514425, -0.5618124952495259, -0.17144782227934588, -0.13649542443696602, -0.10310212658952661},
    {-0.12602670626621837, -0.4666246829263446, -0.09292341493609378, 0.2790981908415529, 0.1320285671160069, -0.1684306959864613, 0.10091485871418406, -0.1996726477706005, -0.011098097751836377, -0.04461884921212723, 0.29042910900422275, 0.16009727533135137, 0.22478235493946563, 0.13460600472981987, -0.4908503984783571, -0.44748631839438063, 0.1782081585546064, -0.01135541690249908, -0.21333845653309955, 0.055467074942889744, -0.4091248703487982, -0.3403267654524498, -0.2325095443028544, 0.34445695099730705, -0.06402489080080824, -0.24053865096902996, -0.3137341414711956, 0.25094085539586336, 0.32374298403513596, -0.4166794804389184, 0.018523237134212053, -0.34773828759668113, -0.1883117467406134, 0.3204645614845102, 0.28869668338696, 0.4382518103101819, 0.10979776012881058, 0.12805400089219585, -0.13060733759009752, -0.19170081692663835, 0.07520378565024835, -0.20872903923611105, -0.35013361812592025, -0.3910161309322821, 0.14876368662264036, -0.40678258119269245, -0.015432523797900898, -0.21289294863544367, -0.35908171717945314, -0.30843270011267354, 0.005717024255263618, 0.17690988645606617, -0.42839185795065493, 0.17613088762748147, -0.03943279322695762, 0.018073928165392023, -0.25456940241810455, 0.019335692423997873, -0.4576351015886212, -0.0011062327975813904, -0.46613316523102283, -0.44615254416097805, -0.2901470953117198, -0.390718642877105},
    {-0.0066923698439398825, -0.06411227035533079, -0.15415824537122513, 0.0997765330630298, -0.05977486181571255, -0.3086397384782655, -0.009549124993871446, -0.010038273083137416, -0.0002770138573191644, -0.10073271193790422, -0.2610160937728227, -0.10542000321941562, -0.14358881087401135, 0.21087544639695996, -0.34509158113376837, -0.5149531909248044, 0.01838689901835316, 0.38974734916175213, 0.015097244727754205, 0.3516098215991928, -0.2407228330691343, 0.08012051614537385, -0.3834182279870062, 0.5463731888950775, 0.15298783219042772, 0.014422667764146664, -0.364608769682586, -0.0826910997856041, -0.10248533805794195, 0.1416061371553141, -0.11414962018033424, -0.32865159835163715, -0.1893831277089682, 0.06892976286124565, 0.18511454276568856, -0.019897104684769837, 0.24142053132374547, 0.17298091992433515, 0.31342940548944037, -0.298167051661573, 0.09613972637500975, -0.18269375304667823, 0.2636344434210708, -0.4402687898324859, -0.37878750818586665, -0.2311143079816262, -0.01203093466281094, 0.05114299676023031, -0.22985372757451725, 0.2373202463021324, 0.19829873904636958, -0.30695801330484007, -0.2888482860963791, 0.020466823587298837, -0.5037846575671392, 0.15715154836364348, 0.011610476090911169, -0.12841228189451329, -0.5495706667288434, 0.020959266485259285, 0.07106930867339625, -0.3404822582828297, -0.028833646769272775, -0.40112936431659624},
    {0.12248169808410692, 0.16658528100113795, -0.34152209292026536, -0.390377867798687, -0.25306975451194785, -0.04483531060444268, -0.16120665705969503, 0.39730197515456495, 0.17292154645423147, -0.3449147878130117, -0.3102631942526703, 0.06588690718111974, -0.1287017771660571, -0.038797281269141205, -0.05694644853800637, -0.2017250828163296, -0.19412580923392606, 0.34998168188915046, 0.2558137509500681, 0.36736730683647006, 0.2940300435787597, 0.003201426871546136, 0.1421177257393258, 0.23154152550053317, -0.3400860760846785, 0.038295133915563495, 0.3590831297350147, -0.19440253108376335, -0.026499181173080075, -0.30068591868978517, 0.16878652929625612, -0.28692351067497146, 0.2555625831781213, -0.3222406351799441, -0.1519664688611778, -0.32012721190944654, 0.22205898782220534, -0.025583221893240346, 0.05696518540592622, 0.22342263016334396, -0.21493421385533665, -0.2699708259323021, 0.03813413097536631, -0.11902230760512851, -0.5464167905517766, -0.31814589713399705, -0.41069122750415427, -0.06062585994933597, -0.33891129508820483, 0.20880560565516348, 0.010620056333208524, 0.04952159414939662, 0.41797573656596393, -0.11113133563442293, -0.30720080717543546, -0.16226108749109358, 0.27403183147437915, -0.2676121743906241, 0.35109859199138, -0.39922520382367943, 0.086780252938557, 0.1325892218327373, 0.4263885273662193, 0.011991441163454835},
    {0.11504577854362612, 0.3196774122695563, -0.36372563226834626, -0.4132371409784127, -0.30184546280691243, 0.08797374780934034, -0.15531924681450454, 0.2650638592754296, -0.021034342079159864, 0.19710499216996338, 0.14104273214452892, 0.41291883827676484, -0.05882510868644915, -0.39237788862939654, 0.0032952128700092734, -0.12147251980071204, -0.38529422909775246, 0.23287315737094863, 0.14003192279112242, -0.08793572275724315, 0.2825134141041175, -0.286867697390311, 0.13887293928084865, 0.2362506576721337, -0.10820317203263634, -0.05524739281724727, 0.281750361231358, 0.07484411301673674, 0.07502941298194431, -0.24898972236369013, 0.2537049588668938, -0.35030908649550135, -0.18575396274986872, -0.013439684933398283, 0.0016028282189332452, -0.27060210050542893, -0.029259525711102248, -0.4924281345456121, -0.3507695311163218, -0.21853964958893496, -0.49271858587810724, 0.23266999897804905, 0.18183417458781748, -0.035680507610853965, -0.21084812016326424, -0.3699685721300799, -0.07983423685351397, -0.016753687624747233, -0.31479098127989247, -0.1162676342893879, 0.020288863205520227, -0.31422505292906955, 0.4284393780922561, -0.29069345324999746, -0.48205861180930926, 0.2804644404440989, -0.04224626901991295, -0.11424845809904673, 0.5418895172715037, 0.04428723356717807, 0.026727458718774418, 0.3161027243844728, 0.4161006147695192, -0.2794763302075917},
    {0.24192327673532663, -0.12638563323441912, 0.1445046205269341, 0.15049636440846198, 0.10617371096441297, -0.22347368329324893, 0.4369135636201469, -0.35549946433836993, 0.13094630593319742, 0.5094739821404766, 0.0029154256966721854, 0.2799443388069875, 0.3284278286775813, -0.05297915278238198, 0.33005836282220996, 0.2216471794492767, 0.20579447760840244, -0.16114662006122699, -0.3567937226037474, -0.22655562119112413, -0.25057149639096826, 0.007973601866373674, 0.2773737141236415, -0.049399411557380604, 0.3419464919908993, 0.17707680212837001, -0.05417745494158961, 0.1899459139080724, -0.12285187698652782, 0.04989881760512387, 0.3438056112293114, -0.1958891398695542, -0.397073149423484, -0.3044988927967988, -0.12692957805068292, 0.3411853079080427, 0.13041909572182447, -0.11354177922473718, 0.1884418740862818, -0.12678532497418812, 0.09520252024064146, -0.01524088363170118, -0.06237021895420033, -0.4500322566332246, 0.3141506286721607, -0.007441076289113489, 0.17408094287136064, -0.09163420490613194, 0.07883973359493071, -0.21908542937957232, 0.26711967356394234, -0.20664632167698707, -0.21570744150152227, 0.2826532220823806, -0.32820757108147725, 0.3978979752908354, -0.2575251578035676, -0.2215401727168625, -0.1109634853813142, 0.43512895569416155, 0.22283893139910685, 0.3158396853035198, -0.33233872142688997, 0.05440392557621198},
    {0.24521142378141886, 0.40145867803274166, 0.4399491834162337, -0.03245744763690929, -0.04990103961393333, -0.3671907933459889, -0.22097014289983447, -0.2297497648708771, -0.09859479168123854, 0.34250975370239656, 0.3461333954580235, 0.19824890343295978, -0.0774686235216499, 0.17197565321507763, 0.14485688897384147, 0.22915995940353215, 0.48461685300154145, -0.3556100263682672, 0.13322859338489523, -0.27426668548932925, -0.4038581944586996, -0.018767003987756974, 0.24410502940451723, -0.4541497245194989, 0.16323304408894543, 0.1345937023341423, -0.07222464154490488, -0.09994726557186008, 0.11421842635112849, 0.2810477478618205, 0.15820755583688217, -0.33339157177742373, 0.2705998692484594, -0.2859567070893669, -0.1921186788952297, 0.22880551276603092, -0.1651650110369113, 0.13698669767002306, -0.09923652359281494, -0.258100272229146, 0.3627680107790759, -0.3200417753833278, -0.0836999046528652, -0.37212038021552446, 0.4814328973403774, 0.3263716134660429, 0.31065085738667414, -0.05243306207130928, 0.07992025003032646, -0.026947902488765895, -0.16483916755508052, 0.17446644984279408, -0.06291971792358618, -0.04824313948265147, 0.36517186363427534, 0.020121176390905483, -0.255301899219607, -0.22433729600608632, -0.3744070172668789, 0.38884019101661654, -0.24247754469275096, 0.18750969662232195, -0.17878135517014046, -0.22898962998188047},
    {-0.21921191741234045, 0.19626563009685294, 0.3059038544443199, 0.28557194289332233, 0.19346591217013032, -0.1865057115463953, -0.42190706401369105, -0.3362076093815379, -0.08626404935236474, -0.4152280628675663, 0.36377403944357833, -0.25082308222872296, 0.2403186538586639, 0.10582911951643172, -0.18523785657243483, 0.1448772725872471, 0.2684539516684368, -0.0757555185578839, 0.04518263916852176, 0.11802738567955788, -0.10933071025234237, 0.33515148944816664, 0.13833867509907713, -0.24585323959444888, 0.04569950962341671, 0.19921901299213257, -0.27849729197894213, -0.048448019012441036, 0.15289513469354254, -0.3650105267907823, -0.38781034161862, -0.3069204559881666, 0.3727413663354053, 0.017520785425325928, -0.07476492987160178, -0.11218989788234626, -0.14929156759372503, -0.01284265420018414, -0.37238155790691374, 0.11524553575319038, 0.4324100338590347, -0.4400367270632678, -0.38507902861168114, 0.002914324136800926, 0.4272078002616143, -0.1366255918541652, -0.13692559858327785, 0.01644793514541392, -0.41368071970363285, -0.0007478550536201235, -0.2720255121819335, -0.011717694997414324, 0.11967636204213601, 0.30323789808363355, 0.26127020344339635, 0.3753643118901343, -0.0534924511510781, -0.10714441899782838, -0.48508081821896143, -0.06689140070324076, 0.17666759129838305, -0.3135252627040363, 0.36738026984172584, 0.13539000998476536},
    {0.22548499842217307, -0.3464875206337148, 0.059386353680028474, 0.24242041944983686, 0.2869625109432945, 0.3370383438451774, -0.16593890988945062, -0.0637517265460295, 0.3819958585761622, -0.1697577391124722, 0.28604201758703224, -0.020398275836057075, 0.33079047118812605, 0.10384856883620507, -0.1312383163830048, 0.19701719434299322, -0.07584592818091973, -0.013127340846014525, 0.4007263380982949, 0.3307605516592073, 0.3458780007160202, 0.07069888434310231, 0.022687911790841817, 0.10204626037264161, -0.3035033354533708, 0.37894552199061965, -0.1759044228409736, 0.4242653552841704, -0.25001603079664225, -0.27645896232373723, 0.20428340635671327, 0.5834436104764752, 0.32629471030560053, 0.12720288789818762, -0.09250608442752296, -0.1640248638561092, -0.22666486787799522, -0.03680746947214866, 0.23853608240295338, 0.2689723881861129, -0.21658560418298045, 0.04023945158510825, -0.26000584475614313, 0.4090077047119848, -0.007431763433769435, -0.06912279003853715, -0.06695848295827284, -0.1162830211360999, -0.24001114192188297, 0.07039471730806508, 0.11772796311634912, -0.003998104113594565, 0.46545071810895433, 0.14040363442903953, 0.24407831105225844, -0.2977035484774327, 0.3575563943644387, -0.18999935537265206, 0.13103693413735415, -0.16892433419331251, 0.13391163904070266, 0.09658159107280086, 0.038879940898964, 0.09546597801488894},
    {-0.09724275512798827, 0.09924708469823397, -0.22817161616565484, 0.017539630622453325, -0.07939296592489299, -0.05091335851963443, -0.05658740328999812, -0.1181129878880574, 0.44432082624331853, 0.2866730283703445, -0.2717247341242583, 0.1164459287262064, -0.22175939177279563, 0.12506446644111002, 0.015677680589719568, -0.2768408979832476, -0.35996899467073923, 0.019452121674466173, -0.11211291230394785, 0.250726391244156, 0.45881047951567566, -0.33868166089521695, 0.13566877655226106, -0.267811354698531, -0.38495007000127957, -0.07187208289131986, 0.25223352901998725, 0.08957510965430415, 0.2521400587242137, 0.3717306047546658, 0.3740115899504031, 0.42013211061617506, 0.23332590803377254, -0.27748489846361546, -0.1789399767297309, 0.3029903113718717, -0.26711709588240334, -0.36639589900570146, -0.0015509625350547875, 0.39565295168472125, -0.16503250897066193, -0.15552652180492732, 0.196512955274827, 0.3786242389008793, 0.26119472316000086, -0.11031381329793398, -0.21425392995057455, -0.2610166846523088, 0.4072259917581782, 0.11315322485420772, 0.2314548810862658, 0.16408189578220378, 0.37499176694822706, -0.23954167224532213, -0.24730934106755434, 0.046560216475512305, 0.2464634083976914, -0.15785347391860177, 0.42758882510303925, -0.2545666097650615, 0.3807908893045533, 0.21417679740115417, 0.1336363247580832, 0.044245591086350344},
    {-0.38968628595367943, 0.18464663988146693, 0.17090736251946778, -0.25305267810953014, 0.07879254419953866, -0.29793972314003764, 0.4442934526686499, 0.27134447036771947, -0.049364691241007765, -0.19661845371269643, -0.20933936865177993, 0.22308543929884533, -0.007914930649181773, 0.4063016984304129, -0.14215488332426146, 0.12341182840020008, -0.2956197707416166, 0.44732777207553776, -0.10859046564364334, 0.15272387813182176, -0.04227113450392364, -0.20297118953820464, -0.14241803781705384, -0.5253845271566661, 0.23846860305934803, -0.20703043790775796, -0.11369752136142068, -0.36512353603713615, -0.2172728591471075, 0.12424609965862027, -0.010587910656799588, -0.0798798642442981, 0.3302550826547714, 0.37411591378361136, 0.13473653758601847, -0.18948070513004225, -0.08133790494286901, 0.3396300188466572, -0.20539559551869296, -0.12785533184847703, -0.285216589581135, 0.3949545990110158, 0.19576206545721794, 0.45488483213113867, -0.06046222453872114, 0.18194536732730782, 0.08832416604665236, -0.14754320547607727, 0.30817326500381875, -0.24589828909203254, -0.26878203276401985, 0.1413261674487301, -0.35003057580245084, -0.508135406266242, -0.27410454444506294, 0.2903791718267582, -0.13091593334893414, -0.21361685592012242, 0.061185868160601946, -0.26220710440439354, -0.11376256114121741, -0.17508067577155942, 0.2781472840226723, 0.2641685034378528},
    {0.018929104860746598, 0.28883138213307635, 0.3461188254699659, -0.23220389827103366, -0.30463265746699875, -0.11955803455198141, -0.09908366989221537, -0.2530882069023774, 0.16205262012338592, 0.24429830001837094, -0.26912985521045496, 0.34803651547555864, -0.04697663248240385, 0.09319041559044436, -0.3606037562652784, -0.2401388106393537, 0.21383308390811245, 0.04980790801842106, -0.09359405638759037, 0.2358608387036401, -0.3960742911971113, 0.6107116866230728, 0.017099600546174924, -0.19896563161637446, 0.051969923282833924, -0.07354632824801459, -0.16537363190823143, 0.13986275049641303, 0.22865850400653248, -0.14978922542295411, -0.24454764163376533, -0.2594332030288005, -0.19395897284863622, -0.24641266760827493, 0.11473935023736115, -0.142506068971922, 0.359207502259457, 0.2673264393431989, -0.15280776529311432, -0.2752066630521571, -0.44243895238432523, 0.43040206196431624, -0.12490825492471275, 0.21428642070936543, -0.33255726203995495, 0.21618560646930396, 0.3608449871304162, -0.03799830360060697, 0.2809787466539062, 0.29593762228747494, -0.09000569645607796, -0.2544548034873291, -0.13803587374212736, -0.13418934903553362, 0.39330669874063406, -0.2611905177683837, -0.2306416847181296, -0.17591798685782034, 0.07437224889640356, -0.2048710943749606, 0.18475547031186854, 0.11225397320540935, 0.13837468778503256, -0.10594046372559654},
    {0.3606301228398546, 0.23699533237468057, 0.26449552588481, -0.1209056533092667, -0.38129872028060446, -0.11950009072060822, 0.15720711035429633, -0.09767542490776167, 0.3217447685942554, 0.30170446461102285, 0.19012590747698516, 0.4240777484726104, 0.041528330919806414, 0.3001790758819454, -0.19826184440409256, 0.06782890038071944, 0.09168268852556735, -0.24355852261209995, 0.14316927352571782, -0.25340361260567146, -0.23923951071042526, 0.2681631429050829, -0.18203079134502534, 0.11339013535283086, -0.05709535301480291, 0.5021820454319206, 0.3105992781207588, -0.16469205018416988, -0.3023262129231649, 0.04442341557615191, 0.24780628185435052, 0.37075966045645525, -0.2868154533871188, -0.44926699091386985, -0.22093921405832834, -0.04832595445379923, 0.056044894363154824, -0.24235287431956096, 0.27102908797702874, 0.32191868030035437, -0.2554427799507943, 0.15440871609310663, 0.058981572893008934, -0.12588494126737246, -0.13632680378810205, 0.11971188118439906, -0.2101377656849967, -0.3627004936627448, 0.22999853370130746, 0.05408137496033218, 0.3420545692476642, -0.30645926127489387, -0.23106599012537285, -0.3129998683777082, 0.4750330857492279, 0.15062991912766918, 0.2955283867855663, 0.02386357420376515, 0.17829580477160895, -0.17945400266836586, 0.07116552582026198, 0.4021494515865676, -0.31958073217324573, 0.0861794403853075},
    {0.10585763166803573, -0.3313718976260841, 0.016880449605943152, 0.37518789163725336, -0.38984581781585337, -0.2325263946872848, -0.48528188316775117, 0.10784523638026958, -0.19638170018690015, 0.32756033738011187, -0.38879942593146377, 0.1290137771583345, 0.4622328958005423, 0.10524293222431881, 0.06188556996000165, 0.1402344915484357, -0.10984078625030345, -0.08990695877744849, 0.13028632848359778, 0.11819719279938276, 0.31012408242211237, -0.19295990401663676, 0.18184550087194576, -0.3901260659740024, 0.3231621567571158, 0.08861365171907579, 0.21966479184486043, -0.3933836108085953, -0.431038363318253, -0.3073214805174208, -0.3263876678975757, 0.4742612281670213, -0.15975467559713138, -0.27185755952486473, 0.2316008858266434, -0.012570817088578013, 0.27222009331114017, -0.12723158583985247, -0.2705507649839573, 0.04190549057409524, 0.3475249894757042, 0.09608454936700342, 0.1089546730904427, 0.09540418548046105, 0.3270115764689618, 0.029490863868962415, -0.024126041761952672, 0.37964669237002546, -0.29935207559958643, 0.04827486122388617, 0.49435027220144395, 0.26030766515651355, 0.5567408267282912, 0.037654847246822776, 0.12686145589235648, 0.14076760259205118, -0.1910874681419635, 0.41084387818639734, -0.32175075652948754, 0.1084642772521362, -0.04396221777482887, 0.19208470865650562, 0.09321293646210732, 0.24169900889268478},
    {-0.3332114934738196, -0.49104868409550123, 0.05274797424774552, -0.44270274196009957, 0.06986425287942966, -0.13051870565412604, 0.07214402619443455, 0.16874127717978074, -0.22576051634857003, -0.3223591241761713, -0.41746362942996296, 0.24972540232701765, 0.5004319903279222, -0.5269941976897727, -0.08432882088878009, 0.1924153813603004, -0.19862051054288693, -0.0657062284589695, 0.06636355947371884, 0.02381494077868828, 0.27926004975273355, 0.1947553198985157, 0.12097045765116678, -0.4334790711492403, 0.21604983033015657, -0.29074935526345536, -0.26525563001394314, 0.06136930079030014, 0.01367753263193925, 0.25052481858856357, -0.23983261504652953, 0.24308318802252507, -0.2930687620352823, 0.22303806969838108, 0.10271615829556453, -0.4810101796130395, -0.44331454562548134, -0.3250086486078598, 0.21070895262438882, -0.007395842278141037, -0.07126873871590611, 0.07967426789596742, -0.5227123417593624, 0.18959071948390008, -0.4553360505137009, -0.2887949438494249, 0.013371952589813862, 0.2190637164354221, 0.29949196480347823, -0.13999757969822435, -0.18016945021177888, 0.17063421634133052, 0.46745461121018533, 0.21843001787198796, 0.0373509943354579, 0.41299378361373573, 0.059068009588317136, -0.08618605522719316, 0.15566264296377774, -0.33492247520887186, -0.1216344969519408, -0.2449839195198637, 0.03992480446999791, -0.224492200997159},
    {-0.007882268355105377, -0.4468943704895803, -0.22271845322958464, 0.2087092411082044, -0.1495805576296363, 0.2309155117084648, 0.25275804576310557, 0.16090799924839044, -0.4545356251809521, -0.5181953270857318, 0.4178266047731983, -0.5935728515935136, -0.14395645324359244, -0.1586993443151835, 0.24590418456109608, 0.11060171413185314, 0.16278507433980172, 0.21061090432598747, -0.35675659685483685, 0.04927493297268011, -0.3060873862821012, -0.11909417587103747, 0.2957889755267928, -0.3996097097435328, -0.4370244514256263, -0.4239515351556006, -0.34122459540260486, 0.16574922331147246, 0.22268074809728633, 0.3697394640571416, -0.03764006291302452, 0.11024105692008322, -0.4261222312950926, -0.36404943556649566, 0.2227992970769459, -0.20163782497915514, -0.2130748090784207, -0.050550770673727825, 0.3694973582182117, -0.054846427893265715, 0.2626347413146246, -0.04223328215719295, 0.033512313907679975, -0.31394904026115455, -0.3261857797525936, 0.14900119186662025, 0.254488477408118, 0.08037049822020642, 0.3574077476430738, -0.07634994551694241, 0.28246426723045986, -0.2495710196612026, -0.2790111971317537, 0.02955285740820815, -0.12107358741668622, 0.05501359781681382, -0.14119500390350534, -0.16100560846497555, 0.1804189692111181, -0.4305826444007992, 0.10201195957800165, 0.1502592230388269, 0.10849857224225477, 0.14511558230998367},
    {0.4170436465775983, 0.10768976446510815, 0.16193766775681961, 0.2827795158343106, 0.19260167198916556, 0.14124526692408923, -0.30157615405976557, -0.21629816337762972, -0.051605921054644906, -0.30650034308205726, 0.2704424632290334, 0.2409901998393224, 0.11859170935696481, -0.03938649246027263, 0.4214265631605948, -0.38721409841827376, -0.22888528557433188, -0.2785829360672505, -0.15112014769313778, 0.2633376956394902, 0.38057109667794, 0.14916649960480355, 0.10499565184947877, 0.1472097150400249, 0.07561237415380655, -0.28507353215361386, -0.18109106330907698, -0.3058219879833588, -0.3534658614206552, -0.02631234653269697, -0.08310349515244748, 0.07522356337744013, 0.4175757409928711, -0.29676949304887457, 0.0647122271693069, 0.011793021597944698, 0.22922985290505463, 0.3312118655186086, -0.06016682054691515, -0.045946430117711094, -0.03731897267496107, 0.029595888509694687, 0.285531232853794, -0.07161931214493861, -0.07056296565033178, -0.14879510396540463, 0.3470831264083505, 0.33682099695618006, -0.015494166557679264, 0.19847095861597636, 0.18008465453885508, 0.4170878228435041, -0.2404474971529989, 0.1956534065827487, 0.09161226173089052, -0.171857065596161, 0.14613299272326807, 0.40600583244323996, -0.27657926357313445, 0.2838628846708615, -0.14984226589352442, 0.32785285115831364, 0.24697334772337765, 0.06525179984519565},
    {0.42213478176355573, 0.15855900788482097, 0.32822574662489473, 0.3308533205733099, 0.30575541368112436, -0.019798273025802532, -0.2536780593682688, -0.3005281575603287, -0.11137195253776608, 0.40133443939545743, -0.0741129447737687, 0.3555657943264634, -0.031168314422841625, 0.2369924267980043, -0.17578146675251852, 0.21533354589354575, -0.3242145202981497, -0.08685532547472934, 0.21857433142041097, -0.15159648367182288, 0.1926325964578824, -0.059387844033069244, -0.32557213003554214, 0.033611722599371265, 0.30867551525603565, 0.1502044638700074, -0.17559002764927414, 0.10190649358576567, 0.19886507115948704, -0.385521119376091, -0.2459070963688221, -0.45133150612190487, 0.25111727477865364, -0.16445475328471798, -0.22994347655710617, 0.04963121011638051, 0.37314584851135724, 0.3325432193427714, -0.2733555343355866, -0.37575928844333945, -0.05474594129380306, 0.4998701657569791, 0.1263624763802738, 0.18941241209699836, 0.0636216405438966, 0.010711868121207183, -0.2998081902246033, 0.3606815194445119, 0.20806397167922425, -0.10753746122806912, 0.04847449355928099, 0.11704762376350861, -0.1959782799659439, 0.13427004750667895, 0.021149162478769756, 0.17725666284987845, 0.1705887976329835, -0.04479179627639334, -0.4194094403015095, 0.32193421923033627, -0.3332965551539821, -0.2663061949547786, 0.36824589142630143, 0.19292525057518384},
    {-0.1903229949416159, 0.23828248086853698, 0.06150630120865058, -0.1731857496263826, -0.26911554239725916, -0.2614083343223868, 0.24298239751933456, 0.3118393488776203, -0.1356569587651737, -0.09669794046533099, -0.3059174008562602, 0.1845262598431672, -0.347254081948192, -0.04391295802557864, 0.19701791428585044, -0.12175874707055329, -0.23378651590998867, -0.28997360993493226, 0.30732105005946864, -0.02360815183983929, 0.033775444510885724, 0.09588299714820417, 0.23010450218608627, -0.03974924630178165, 0.27660201694875836, 0.32568752987061844, -0.16292026014361266, -0.00594639564354316, 0.33993045740878686, -0.1844490646047956, -0.0032878656196260038, 0.1909731794626865, 0.29297577960203813, -0.012791249974828913, -0.04684321325467658, -0.11841746919141946, 0.33642211575649134, -0.3236590524149738, 0.08020826472479997, -0.16480394323140699, -0.2617694812905868, 0.4594681028381478, 0.3753136108899819, -0.48144132269709694, -0.12301293328802008, -0.07802417327178231, 0.17362298570998988, -0.11293874854008859, -0.04695123718678108, -0.2239516284851944, -0.014654524474486712, -0.03981338993707732, -0.3177962775581936, 0.017233771493942333, -0.48318969488516655, -0.3051811904202085, -0.07680986787278964, -0.2629781761065663, 0.27778467530631673, 0.09628087159038828, 0.18412760267748055, -0.35545616248091866, -0.012235037386323288, -0.0329236885515272},
    {-0.37262058718220753, -0.13664556147283277, -0.2539365613268202, -0.14585082236299307, -0.21114280135053362, 0.21582741912186107, -0.3526125452287874, 0.3030627672100948, -0.0378804148351563, 0.016636150183280463, -0.12168203690427792, -0.2566800583619826, -0.19870154005096438, -0.32706066480754714, 0.14513660043533752, -0.019306476692238776, 0.28039340227491555, -0.30306031561739827, -0.1268457325170524, 0.3597387558262491, -0.35520602740889523, -0.2158972431735226, 0.21227475739609747, 0.4870332199484038, 0.2323662870355246, -0.3408417057322802, 0.3728070618296678, -0.0037846098931454413, -0.12658742907770687, -0.1453004210843893, -0.24934144225735377, -0.02111751661184625, 0.15140313833259966, -0.37978520646670366, -0.10729301451465394, 0.23721158793140584, 0.34137999323563084, 0.29170458145442535, 0.16957228668070753, -0.2011350003062276, 0.3436587462495406, 0.035876343125723624, -0.20871066560519666, -0.3354338673656621, 0.03585160212279558, -0.43330771085008996, -0.41206187138828854, 0.0902640388891724, -0.23816959254811465, 0.1520397083814782, -0.3412871192850866, 0.07259630362476961, 0.05201159901717313, 0.17327062132561244, 0.3223409008229271, -0.341095832577389, 0.20265607466452137, -0.20620176423019, 0.2830770640311142, 0.2812092688824475, 0.01407577023813575, 0.1280972071295354, -0.11089791346515618, 0.16489668566538926},
    {-0.3754442169438322, 0.06849366211151157, 0.3237921270154753, 0.17440414166197502, -0.3788852507100076, 0.29443336443833795, -0.32684367847578294, -0.3706087496297302, -0.4274762003120075, 0.4084133993347285, -0.30370312646353254, -0.14634576744103697, -0.4849625028866665, -0.11427304855374903, 0.2875103846842381, 0.33930056720264773, 0.20551824738949098, 0.09768908340458303, -0.09610022485499475, 0.0011166098539939562, -0.24244375513521454, -0.12287406773865286, -0.1508216601582166, -0.14596927627528355, -1.4398849254599958e-05, -0.4092781077374602, 0.09263938122968535, -0.2049193835644537, 0.08731007816346346, -0.38042512481410995, -0.2654924720701029, 0.19232141600444178, 0.36200312918458344, -0.3783948665527723, -0.023794346985760495, 0.07447663720227224, -0.19751649443794292, 0.05975130858526295, -0.08383463120652113, -0.04469757761891133, -0.3112778033392255, 0.11810471459128088, -0.17689138255167627, 0.0013987350496307387, -0.14328010366421967, -0.3624526940015532, -0.21643599827177526, 0.04786379490220942, -0.08503245063292217, -0.05820449225015219, 0.3482466284586863, -0.21406129550086844, 0.46797605462284925, -0.018756330946962184, 0.17053376054204475, -0.4617631458095031, 0.2206336340629922, 0.33772551019301145, 0.08473624294980443, -0.10053239229650494, -0.24241294591760976, -0.39234933941448824, -0.19442073543702562, -0.24787634634722389},
    {0.18954866007360308, -0.14452969799245335, -0.2435121585051497, 0.1498330494552619, -0.04181072082577491, 0.12722946735811566, -0.22748254028153703, 0.053280851170597665, 0.002612966560380673, 0.19754510656957544, -0.21025537251724394, 0.021939061662119428, -0.25172327054229826, 0.08521432797632272, 0.32839783341190626, 0.39793943114961605, 0.13563719289275802, 0.35516883422439727, -0.2986489060267954, -0.1592410333791413, 0.04479163515925728, -0.029359386579429034, 0.25214389775266327, -0.39263665192606334, -0.0315924454483589, -0.15521046576213182, -0.2268886288750458, -0.09462152929682967, 0.08938316528915162, 0.006210050509417315, 0.07977786416338156, 0.13234469028559745, 0.23223255451255967, 0.114126644843721, 0.12376879163309651, -0.28580075564006174, -0.3292398898738309, -0.4372635205528335, -0.2307133479775054, -0.22503178745190117, -0.20230065141338174, 0.33005227779105295, -0.34431402166423336, 0.42790074500917696, -0.23110959445894239, 0.4060795920348218, 0.4678044049215804, 0.22346846697353182, 0.1277698637687376, -0.16798390387896864, 0.026287501908952716, 0.37241505791203505, 0.43820908003552445, -0.18083120028620936, 0.35725878640091185, 0.44360128643047203, 0.04576379483946109, -0.027001469071573213, -0.03693039759623515, 0.041231438017493245, 0.17707065654980142, 0.15261368149846966, 0.28746663071195244, -0.18559922655872355},
    {-0.35169258587340163, 0.2409459179403905, 0.04151879485112663, 0.07285606912975523, 0.07620997832607354, 0.06881992756993832, -0.13430397729423402, 0.2361478020848751, -0.04166545905386833, 0.3150464434324137, -0.05607900102397485, 0.09315662082737179, 0.15309272923353062, -0.31615941141409704, 0.041200638784298596, -0.02399455493335935, 0.23152279070534085, -0.31883372330876264, -0.017059845153528656, 0.038466831747164094, -0.2513265802169283, -0.1974864652676759, 0.1916201110853806, 0.15164239930323783, -0.31871904914787763, -0.20893142859751745, 0.11182784330263923, -0.004268984539039006, -0.07315993322889909, -0.12738386641968014, 0.059212768914625645, 0.0797153140683095, -0.4567150541279929, 0.11155552281478119, -0.07698656235727176, -0.33360927659558737, -0.32778321168759894, -0.2185605214808163, -0.2333231617954378, -0.07759795897031346, -0.38055255725279286, 0.09763949347042497, -0.45806241659240965, 0.21095224649597571, 0.06990099211811147, -0.17401718034767497, 0.012562076771259654, -0.13420329298980369, 0.287548190189884, -0.15574663327804292, 0.22055528716850312, 0.3032731455409252, -0.3776935375061931, 0.3631138519329261, -0.03580195286441865, -0.429212965741326, -0.4013170756607945, -0.21726100849065602, -0.2135866145071142, -0.21718037666677592, 0.16812805621135565, -0.05163613251627205, -0.2798796205580397, -0.012403702804701402},
    {0.09214755163218814, -0.14022176605014733, 0.42759728249688084, 0.0398895045292988, -0.2608755426172618, 0.0466732552030765, 0.2622076084363574, -0.09486806695731138, -0.13346662401491521, -0.12849309812991222, -0.07942078456706197, 0.34929982731704434, 0.17353872925872696, 0.3109760656363004, 0.27824483289824253, -0.10233781149856794, 0.05339987494435137, 0.15219349169860336, -0.1723010016988661, -0.16727517831210847, -0.1855461551786424, 0.1315535940149649, -0.17732545294551, 0.2060911805794452, 0.1280040941960398, 0.43223331759181616, 0.24608592903104384, 0.3227990424498406, -0.022990592260380627, -0.4642127039851809, 0.14916182571000838, 0.08481781418964252, 0.07237848491173755, -0.08471471270858907, -0.014385418746770467, 0.19073864488231113, -0.03148140964530136, -0.018499643173648772, 0.18179078442660307, 0.06497174559546087, -0.11836710913384012, -0.4197122388559849, -0.1730242688463361, -0.29193776643939245, -0.061326696720660365, 0.33879525211660944, -0.26498785960808674, 0.17371460810984596, -0.34562237530236023, 0.33026707103465613, 0.18481654418643392, -0.0892293811467148, 0.0007201386880586435, -0.16683326534041668, -0.3695812718408553, -0.2915768191139606, 0.15560097626487052, 0.14976163514377747, -0.07515569119880813, 0.07886472005294648, 0.17214233333091722, -0.050904186775664086, 0.4373413430961298, 0.2525136364947968},
    {-0.7442775653026311, -0.8347472976088529, 0.3806446483970063, -0.765629451110146, -0.4874877621643246, 0.367694799765227, -0.15771494586589874, -0.5364094686359347, -0.7096404298894733, -0.13833950230258743, -0.6946019653250712, 0.4088707565982651, -0.4859232629310566, -0.2530512113991846, -0.7295945621209243, 0.023168747477010344, 0.637582596889605, -0.18451587158659602, -0.723364733592612, -0.7003469983127804, -0.718443393660595, 0.390354974149346, -0.6428226573147998, 0.39980035188512325, -0.5591231105060461, -0.46540032847169177, -0.9408986765252584, 0.32032939951403827, -0.846252547186629, -0.7783638598089812, -0.6275135387187101, -0.25593898134538484, 0.14318072935752246, -0.24212661225878754, -0.35600059988885446, 0.06797336554295717, -0.39458031932247933, -0.1737040459623978, -0.41772304370267843, -0.8287732056173268, -0.8408494326084948, -0.6733074723010843, -0.36617894441361704, -0.7171393871707008, 0.1807330363547269, -0.4498081913164567, 0.3293661104235611, -0.6033704426642891, -0.2193578154689318, 0.34222499289502684, 0.12562825782247056, -0.34087324718646855, 0.17696308773511274, 0.02254921269299837, -0.6822941073610116, -0.6834354654823441, 0.3323249728681978, 0.11392500740793028, -0.510264725538152, -0.5019751822103007, 0.47814630052364904, -0.5033892829333209, 0.003780306031122703, 0.38818184116392634},
    {-0.48116005334984174, -0.4188125239848853, 0.335955246637387, -0.49038492044897036, -0.47047508751525546, 0.6527036484593435, -0.5274754279676808, -0.0972849372736828, -0.454658786244292, 0.20290289117832983, -0.47666496895531035, -0.052460458112484336, -0.3947174440833285, -0.5575518720617934, -0.49979187966379357, -0.16410059554482812, 0.7144289103468817, 0.20415564701461197, -0.6502895562591057, -0.6598883951333662, -0.3733865068498445, 0.5683896050087144, -0.7562493094010404, 0.4005148146881497, 0.09015450425558337, -0.5339143433015623, -0.7319218626020436, 0.6703874746225662, -0.5864384048998967, -0.5937490869971751, -0.7437415124221473, -0.08972624868235611, 0.5081365768790117, 0.050325598254103925, 0.33600847287955016, 0.3998519139288308, -0.18930151705201653, 0.50086257874096, -0.23792522285001413, -0.8166396952000421, -0.6938785712583633, -0.5009521849602082, 0.24838401037771818, -0.7443973379769763, -0.4091199489915752, -0.3018175446698218, 0.35429174040611733, -0.5954059752081053, -0.15724703002911558, 0.3725128670263159, 0.4534366209308331, -0.7771807557441713, 0.10882231401251657, -0.07156662070277678, -0.7291777817831071, -0.7638137948372575, 0.13269227066128964, 0.3371573907140478, -0.5020691937944629, 0.1024914355476494, 0.20366811481693486, -0.8397650283381888, -0.11342669714421255, 0.3830431458908011},
    {0.08991143092335181, -0.7201080079470142, 0.2456676796892351, -0.4503703301611086, -0.6612104491100242, 0.2385822416644985, -0.34020389485712443, -0.28568127368773094, -0.40251373267063695, 0.5099670883866929, -0.7201599841815737, 0.5657565085439278, 0.35480053809796, 0.07577012856097405, 0.31209283352232214, -0.3436444069787986, -0.14635558490207082, -0.6350072888739405, -0.01458785480066869, -0.43073782153681417, -0.2516483997901854, 0.15654496695426248, -0.6103880310679586, 0.11936262487354617, -0.36640762934947524, -0.3417061477028769, -0.38257603730839823, 0.27435634801289777, -0.18401989254894738, -0.39157215461041234, -0.3560253654221675, -0.4066340113882494, -0.18188661641216192, 0.20157995812327295, -0.03761424308403292, 0.3409734952484608, -0.48020422595492146, -0.27217025821445784, -0.2611817222572715, -0.5946073039073166, -0.6939867010430382, -0.1656576921364553, -0.3990262659522458, -0.7069869492835513, 0.5037515060111902, -0.73804314694744, -0.5166815003505797, -0.12330203201401296, -0.3162077576402271, 0.3200785516427843, -0.016910628899662092, -0.30870670349630086, 0.46474928132507, 0.14677338742496138, -0.6028084146740863, -0.2337078852140245, -0.005841090204802644, -0.026061221490768633, -0.25273664770283943, 0.038878791607947286, 0.07413553429456818, -0.3168110836887161, 0.5315891659789016, 0.10364179592099347},
    {0.31805379027391095, -0.34787111198220383, 0.2635977432009436, -0.320595444376492, -0.002776436353415295, 0.6182140959031631, -0.1140187297830091, -0.6074606624637746, 0.0950501163014384, 0.10983088634185882, -0.3277160026447572, 0.5103485194383809, -0.013455459311228116, -0.22201314394652605, 0.2009712216713764, -0.06048270951181074, 0.157448241141108, -0.5208000018070587, -0.3548404723061362, -0.7037778194370692, -0.5085292841227954, 0.10149170089211433, -0.6214462273112407, 0.01841193928231319, -0.16841002359436735, -0.3832058646293947, -0.2569346231848848, 0.1806047039037034, -0.11452915638428975, -0.30635846189977184, -0.23560197796108767, -0.4038480059234445, 0.49781860747188184, -0.14467148975210326, -0.5066209283166726, 0.4003511143758352, -0.10107861982891571, -0.0758207432161946, -0.5718093289023145, -0.1459735705463385, -0.2044612463140066, -0.16353150752420434, -0.5931725369310209, -0.18194754186762144, 0.18869110636626135, -0.2533467431052343, 0.016637124193763217, -0.19546269017340995, 0.01754014536554627, 0.09315066387144273, 0.27085789791310033, -0.22460659309275888, 0.28628085077633986, 0.16506836836913177, -0.581144992110812, -0.07725027605295902, -0.12653316272696755, -0.18210744565856696, -0.3967769200417067, -0.3646570151392185, 0.2164503668804314, -0.07025968001985704, -0.17548297517991418, 0.17451962082415956},
    {-0.47610678277115215, -0.026025255184517232, 0.1814005944510907, 0.06774688130152078, -0.3117076090104813, 0.20058814116811885, 0.08512813963060917, -0.37959959952840255, -0.38244439409087877, 0.3481032928717418, -0.3138962113317244, 0.5856656821280036, 0.19880429155920154, -0.5238325337870953, 0.006074065846566168, -0.04178439077466286, 0.4816301789394044, -0.47477758029272443, 0.1630399038564674, -0.5340275494681465, 0.09647501405962046, 0.007411789210142802, -0.17691739028615192, 0.5699061499820438, -0.3845008963425482, 0.014890305092860196, -0.10566124329112553, 0.10240200613106548, 0.04125895955534859, -0.5247424021711903, -0.174258649823239, -0.5780158278840078, 0.2884227516667135, 0.28855605632658826, -0.029959075469169674, 0.31921094883561985, -0.5150973648642194, 0.1868316325792141, -0.4122945309352816, -0.10979568584629476, -0.220390060468231, 0.37859956335373074, -0.1571254454483746, -0.5879369801086365, 0.4132927640353091, -0.44999795740274967, -0.07297357090181786, -0.32109620469939176, 0.3095978484751769, 0.44627179297853, 0.2121140883384399, -0.30890172700261176, -0.03384332600545885, -0.016554842206581693, 0.055472671387360444, 0.06499399665272158, -0.05566822793911292, 0.2593861042219476, -0.4885193766208216, -0.1136152254875212, -0.098093265587833, -0.4204879442778878, -0.12802765682974176, 0.2739802434304278},
    {-0.6609595778539328, -0.6966205413913515, 0.16831387148336063, 0.024395635319947335, -0.37041062798302576, 0.39964056909834333, -0.5007085218623445, 0.14799705004370356, -0.009438755391088755, 0.06622290381481782, -0.5474243749196483, -0.30799063991347153, -0.20936858844045542, -0.2761708967385666, -0.23596452796153236, -0.2333871153951428, 0.037349782672698506, -0.43722970098988845, 0.09599131817323756, -0.5454397446478648, -0.40413177267794037, 0.3865357793311614, -0.7002835598829211, 0.5046987706075534, -0.33592263641836945, -0.6446712049893819, -0.2257702022649663, 0.06401015543097952, -0.17582953488901817, -0.5855932513336856, -0.3873557048790056, -0.6253756903766694, 0.29040174963248716, -0.38753384128466795, -0.11536385612170731, 0.4644127044891173, -0.27889892710096026, -0.12801720752384613, -0.20493460695119414, -0.28433923958987617, -0.2821351006877993, 0.22092909182830378, -0.09358559986010635, -0.5415536431033908, 0.023127897274515075, -0.6350149974045272, -0.31682086046446545, -0.3974956360727486, -0.1632221650038808, 0.09461158170875297, 0.2620931160772786, -0.511910805049789, 0.3839121787589066, 0.0841622708489021, -0.1670390862904314, -0.27399987225714695, 0.08181111704752259, 0.29520674389766827, -0.6908087696110079, -0.35397598337900676, -0.2761037715809316, -0.05252592818578821, -0.023917860060408205, 0.260164138288927},
    {-0.4553325285878135, -0.3391647353397392, 0.4113625189960989, -0.09044632371850742, -0.3773750422089984, 0.3173567229483486, 0.14980729340196855, -0.05783025394077618, 0.41957930215712536, 0.028938034593781383, 0.06577895466097063, 0.11622045750457341, 0.2063151418984592, -0.06542655616897255, 0.23002322426082544, -0.1615039763887296, 0.1991527358425746, -0.4254087209293836, 0.2135819610238742, 0.10339352539091866, 0.11698556323103938, 0.6824763215387353, -0.10358656483038865, 0.2927548632002583, -0.2140742557998231, -0.11277251360356978, -0.45577766897622246, 0.017973539592500944, -0.03176635775220561, -0.13661416797589762, -0.11801332186538367, -0.020119523279965947, -0.2747394601237153, 0.5349777881541038, 0.24086625332133133, 0.42558353918469827, -0.2635152606491869, 0.48310913463964755, 0.02410242497930631, -0.3411529604369989, -0.37683754023474625, 0.06486575693578044, -0.21193166165733726, -0.6465460992572472, 0.3112643919954738, -0.3633105255779409, 0.186952582483143, -0.0382783716239007, 0.09955045408778629, 0.4572803999039563, -0.3598048978634906, -0.05234952694111324, 0.2930797770329179, -0.1834628801754694, 0.15243452465217291, 0.0038355802880908644, 0.4862516905580471, 0.5363278683783025, -0.5450374378189247, 0.2620629472033981, 0.346785648922746, 0.1330831644897207, 0.1301955806269892, -0.05418851928784326},
    {0.19413495939018918, 0.21161388763081454, 0.6065642722729753, -0.4974531957347858, -0.5080568222651074, 0.4133718441598216, -0.41749458032769055, -0.36212411197512434, 0.47419662894821485, 0.13352000925413587, 0.27762793282508047, 0.5461182352678464, 0.18672076975751792, -0.3595523642824327, 0.4509481200794739, 0.08587251203471984, -0.008296664857190392, -0.2447437404193449, -0.09676721534657186, -0.6119856774363926, 0.03918464192941508, 0.014047215165491686, -0.5388403933568907, 0.2678913061348662, 0.09722407144871448, -0.11440699107222779, -0.5451129638869602, 0.5725309960957166, 0.00833605694433958, -0.2268524071282301, -0.46335408959588087, -0.2622522706605239, 0.6915378630538553, -0.12902636066834894, -0.1806219964355862, -0.05501664128970956, -0.10737915585602516, 0.1474877129091198, -0.041068810981767394, -0.46098437194485453, -0.4267969259244724, 0.3538890785284818, 0.42952449130120846, 0.0539924778984756, 0.2569978962554428, -0.10896472616011486, 0.471616548432425, -0.3280371309513366, -0.49320336723992453, 0.43431601769511413, 0.19038757074479015, -0.43366265270402343, -0.46444363812051076, -0.4124592992548099, -0.32732774338738985, 0.3038671007817593, 0.46823718333614855, 0.20391580515367866, -0.2394055969681997, 0.19979987481306688, -0.0950601037697894, -0.009110483100322914, 0.30241469746026556, 0.5118899490731156},
    {-0.5046476585486926, 0.20257016073683184, 0.5042891546412979, 0.1533664784980959, -0.4621822482582739, 0.05817804654092793, -0.4676008665981066, -0.40081987876092595, 0.3294938093140952, -0.3488747743537137, -0.31617821804726354, -0.034376963320432115, -0.07360185925344834, -0.12484210997903197, -0.058890198830364435, 0.281392493170537, 0.5692284319113572, -0.06846319914282913, 0.02321442242543522, -0.629903509616267, 0.25384470590266706, 0.23260108140773997, -0.31465175780076043, 0.11995770350329088, 0.371164365997167, 0.08354800374757648, -0.5689289816985024, 0.3402264090353276, -0.3225432775114676, -0.6266502587350921, -0.5502273392026106, 0.06012839428523471, 0.15562914304497538, 0.2906416237704916, 0.16652142075956292, 0.37722413808030697, 0.38083076006165756, 0.03817456020510111, -0.08101355983112375, -0.3214314804649993, -0.4368869937621214, -0.5477450016350096, 0.43242688383309874, 0.16980341173942926, 0.21268724768061778, -0.37170459031870484, -0.4413121938716908, 0.02268550162747341, 0.2949794721575227, 0.39028847371418923, 0.5115949111130228, 0.026425087024300645, 0.07999719043021652, 0.21637313056922133, -0.5476129099109234, -0.5259191322593947, 0.5817469014947289, 0.19086712892727375, -0.6801902300845195, 0.3337472326422162, 0.3402673094280922, -0.36453189359093957, 0.20518396117615387, 0.23341416060553527},
    {0.29248187298261713, -0.3458481355019688, 0.08117757983406443, -0.32307244587954953, -0.42843424720356743, 0.28708521680141347, -0.6350222545969088, 0.018354058740252616, -0.042925028708645084, 0.1605357119131136, -0.13038124825418454, -0.3315034286540144, -0.0819962778919184, 0.27784445933447705, -0.07915232143121241, -0.35062380335116317, -0.024509505089861414, -0.05703578263088903, -0.17762571781689326, -0.2968069545283423, -0.5214088349346226, -0.36440302732043584, -0.5148428470500368, 0.07298626553204265, 0.10295999283204485, -0.17936170645578417, -0.31824228456573633, -0.3360650651456717, 0.24443616967432485, -0.5771587977296255, 0.007569993264068462, -0.06358497616684587, 0.5908964838196767, -0.1370078597551832, -0.3401470467179373, -0.08983846816216011, -0.23061031355407308, 0.14743825812283484, -0.38693143779439604, -0.23425574519863213, 0.29639760535871446, 0.3593214783380615, 0.23743411140318002, -0.0029617756721161143, 0.47220658861480685, 0.026365970057256133, -0.431979807986656, -0.15864600125428865, -0.15772984867080628, 0.011276263318060037, -0.388209851725212, -0.414242821268188, -0.11110045169928968, 0.4059695985294767, -0.23168817678517636, -0.17224012116504744, -0.0005338361778603371, -0.05116069494997144, -0.22455413857670772, 0.5311044223119584, -0.5061675630786598, 0.26020054322478436, -0.09679801896564874, -0.29033766428055385},
    {0.16660626346687446, -0.19944802388428715, -0.21903514009774314, 0.1462570356412137, -0.4352062939134186, 0.4379243312208471, -0.3144208526850872, -0.3846080536228431, -0.379728415652492, -0.044342297983361166, 0.016319868798196715, 0.23746795934528392, 0.33702435565911454, -0.3835597345826571, -0.18235236182240827, -0.16505115916519145, -0.07552506519582117, -0.4828156022790158, 0.09327320949682714, -0.053472449723874896, -0.10977687345295457, 0.0233371531714996, -0.21257096855358348, 0.04308965770492611, -0.14177065030665517, -0.33263585727614436, -0.24350503487383396, -0.005005800909637571, -0.08775757856683983, -0.3369182207959, -0.3461967106646412, 0.09085473742170966, 0.4118728372916575, -0.10356452860343962, -0.33683773393739436, 0.19936917016016034, -0.39260509844111124, -0.4163858928635765, -0.18474616755564063, 0.23305672158799842, -0.061797074541268995, -0.4272412592637463, 0.28356507166957934, -0.5343357615905434, -0.00683400688737361, 0.027077149173143036, -0.5331925539163848, 0.04153641426738305, -0.0031384442200725303, 0.3188537592731151, -0.10961048356533198, -0.17020182058717395, -0.04739284827101594, 0.15926135008718514, -0.2688457243688984, -0.20167217245002853, 0.16481685839798624, -0.33606915258900844, -0.4568196704317893, 0.19526087899377872, -0.228789056182143, -0.11475768255668083, 0.16884917311038777, 0.3903735702566671},
    {0.04657164274783398, -0.35831039280228444, -0.3153854418121668, 0.3708178925941177, 0.2616104892159605, -0.19326429992394195, -0.4613341823526917, -0.2577700781047704, -0.2387279684207362, 0.22769526859805803, -0.4170134087064788, 0.30976547685469125, 0.3806016102517116, -0.22451892115858874, 0.1426402294649955, 0.4624518302704881, 0.12336470322684386, 0.181979100917001, 0.4277514022499136, -0.2797164449266939, 0.0006188236849196817, 0.11553667574495848, -0.4099556675064031, -0.5104675411857179, -0.4091208891198156, -0.010225821733859058, -0.01709145233649335, -0.039708240990720206, -0.33246472451373654, -0.2894974821929042, -0.09904318697915336, -0.29008676868718203, -0.3018126350239998, -0.19714081354801904, 0.1858155135040839, 0.08960415227653021, -0.00020205928474745994, -0.1972725236894771, 0.26432316916436704, 0.28439241045744085, 0.5212337651860308, 0.5948708229042808, 0.04618804533069356, -0.14578075348363942, -0.04356679329703182, -0.1783695030444122, 0.09124310268204619, 0.21852647799240887, 0.40878809053460435, 0.44447191328691277, 0.3432821757271203, 0.05915199875204028, 0.2670094094203309, -0.010271009029577931, 0.32888137988822236, -0.014800821313697964, 0.0013117144781934673, 0.05837575272918353, -0.23191101374862919, -0.5380531830552474, 0.34156152518115374, -0.017636740500150756, -0.24693600978137373, 0.5901591299851454},
    {-0.1304256058321284, 0.3545114526209813, 0.580709880496494, 0.14590169200043035, -0.6308401092057864, 0.5878920683492896, -0.29313034189961357, 0.333394641657349, 0.4024315356374263, -0.13066586299712615, -0.2631874551822128, -0.13510660378605474, -0.13386528030673397, -0.34819758682709995, 0.031149228397619518, 0.08812237297076819, 0.14046598887841685, -0.017462574206254817, -0.35735277197994375, -0.379438928930255, 0.2961257357675227, -0.0050574339179320065, 0.17458878607335368, -0.5305215693830412, -0.10564612992385243, 0.1699065334221149, -0.2631267341864278, 0.2342687908076748, -0.18054856448690781, -0.44321274115998843, -0.23385645063709135, 0.48578029439481535, 0.15078549040202727, 0.020612672012765027, 0.16600513676345116, 0.05095221957650093, 0.23491802108851068, 0.05687847215842608, 0.010996820906645888, -0.47506440901711966, 0.2644633272515354, 0.15934519674377323, 0.23235784035705997, -0.22737148535392213, 0.2469622964332582, 0.30415384286158814, 0.2704175362396056, -0.5267000164041189, 0.40542186864573065, -0.10958632019845438, 0.5126445333126565, -0.49841480623440104, -0.5619051966036961, -0.08590976958247619, 0.06758005744062226, -0.44663800623890954, 0.34396353678079855, -0.03192196482796876, -0.21317841510950822, 0.3749620243778822, 0.22192972545914808, -0.5723117003614577, -0.5353870526290907, 0.12867004525477316},
    {-0.40559950690493246, 0.24971849416895203, 0.21449661184485003, -0.2723739591044019, 0.1721721843629823, 0.05877942053241746, -0.18518160351793728, -0.4306661793201614, -0.2615550838354004, -0.4728416990401783, 0.18269420003631553, -0.42377972018769616, 0.22278160441390113, -0.5477542334543299, 0.03473115286886309, -0.35599998652658643, 0.25161913408235176, -0.13283793659941737, 0.1989864624960332, -0.2103313816800649, -0.13298256858730442, 0.5345594608662393, -0.3196038878532959, 0.32415952126434383, -0.25094231510490644, -0.3500419554605306, 0.23561614160594668, -0.10873628097643447, 0.07056099343044832, 0.038240604651107464, -0.5677420912613955, -0.18767932424030298, 0.5540978488663337, -0.35523934481831937, 0.24795125743684535, 0.25683728819415425, -0.04175625491678342, -0.11667029358917631, -0.1847761989572307, 0.27259983771322166, -0.3657980295026079, -0.46734738787163915, 0.5505728694641154, -0.16135701405848357, -0.35970699305967196, 0.0709555521645258, 0.26625895118970555, -0.47039227796557925, -0.20219958845299363, -0.2442161160066056, -0.13932369381437293, -0.18221180251992045, 0.25284408679059045, 0.37744599350812963, -0.3470127841819449, 0.11594711781427328, 0.4333537754527117, 0.32736352981944605, -0.3361799531082059, 0.024970316961543337, -0.14586835650004473, 0.15883056655294195, -0.16649541771347898, 0.4359574301870968},
    {0.4530841774041688, 0.17676260351410586, 0.21910393479394843, -0.27610282777393985, -0.04461101737629758, 0.2975759796513168, -0.5351290975507133, 0.08192883061016987, -0.01835284106054673, -0.6547815676593266, -0.042131737092516046, 0.27614034499579443, -0.02594172602582709, -0.3560662010342251, -0.25289548914410126, 0.049371012070788395, 0.10399412565878804, 0.38457340033964976, 0.11228123751233222, -0.2159390299356705, -0.09605820884426644, 0.18019932087206839, -0.4644320684652611, -0.048841797047406155, -0.24065403100524313, 0.26176109843519557, -0.03739033760345965, -0.1221198247264313, 0.037825496653415044, -0.5775995658322669, -0.4557248421913102, 0.12862165396605096, 0.5358503368653588, -0.2470918208490907, -0.1107848099578163, 0.4736797235921048, 0.12506288589265904, 0.4954543324723482, 0.194121399187036, -0.3650806997868291, 0.09665370256970313, 0.3476633544236245, 0.6134955851309899, -0.15551783874487832, -0.31054544526101363, -0.22782319692916203, 0.34591747140821555, 0.078652307595051, 0.1954307373421389, -0.20071675531395772, 0.11618120021761348, 0.030814158161830835, 0.24191426886792752, 0.1896363996960061, -0.38555630935468194, -0.0770337172708019, 0.033446305005540085, -0.0747780976797933, -0.48381919556125463, 0.11647893295890403, 0.20544792163092362, 0.028427177223198166, 0.31373796393920833, -0.1315825350918352},
    {-0.407724292233025, 0.14772199589049242, 0.0813230329429999, -0.3262597154068548, -0.04124287937813564, 0.13947817333816964, 0.3787322247467232, 0.2518518557293965, -0.26879498031012367, -0.1525910847882495, -0.09204598896521987, 0.07158532691646546, -0.1942089687031565, -0.521405584193156, 0.3769638316993326, -0.1738531415248133, 0.2913151948917204, 0.27336109780702084, -0.2748114182959753, 0.11530466082475622, 0.31343381073689214, 0.35709928233651195, -0.14092157724092857, -0.03131803049603129, -0.13346261913618182, -0.002883930686547986, -0.5385915536542473, 0.4412621593960005, -0.1731366214249682, -0.6455660455636262, -0.16105439030311333, -0.2024615072034371, 0.2655828580467827, -0.5050854655456906, 0.5000467837754687, 0.35921433127655084, -0.21941784772845377, 0.2937959751051867, -0.5670142071809331, -0.2568795002394904, -0.031197167893158993, 0.26603203352384835, 0.27352643246153374, 0.14475047233054958, -0.15316484508034947, -0.5190028063189428, 0.5454082604997442, -0.3764688058941166, -0.2744229476682466, 0.07431793150574845, 0.39997839998320817, -0.19875113095944003, -0.19432059306639218, 0.12858755461427135, -0.10963871617118079, -0.3588384381756505, 0.14199492675351083, -0.22778777454946073, -0.26747505081695355, 0.4077342212725696, -0.41165477747923546, -0.6103632863385733, 0.16155780071929943, -0.2388502668709541},
    {-0.5147964544839182, 0.23648402685791192, 0.018636900793365937, 0.02636600403156424, -0.24825825202558433, -0.2656258368109002, 0.3081066126003863, 0.1618614152608109, -0.3322819415300148, 0.3605166465556371, -0.4764162681351844, -0.2677406112068622, 0.34147638180745554, 0.1399835759474215, -0.15208997675081723, 0.3099831494258007, 0.13889780403173105, -0.4059098936242933, 0.10493328776766925, 0.22097163904126962, 0.06648690785129581, -0.22057507192610942, -0.5376107212267527, -0.05738384212022469, 0.029283381132602766, -0.4521444395942516, -0.38699862066443663, 0.2199370425164641, 0.28289332286341523, 0.40806331687950215, -0.17665492576240555, -0.3662585913953432, 0.011802733783969037, -0.038057986324487106, 0.23674385648146234, 0.3630978206087356, 0.016100476857984783, -0.12648328231801662, -0.16652399729607237, -0.10877291711529241, -0.16241644286011617, -0.3895738369303206, -0.1816136573845794, -0.18644984209558704, -0.41325837725147535, 0.11904757029361686, 0.15697576612014452, 0.19572704006652866, 0.37715879844443917, 0.41586008321256945, 0.45830478212613857, -0.527037606226222, 0.25769939725565966, 0.2471137193391239, -0.46688780765412186, 0.24732594535890795, 0.04293889181519502, -0.13010893551196137, -0.18099231801823268, 0.4308733477936732, -0.21296601554479935, -0.004919372912000192, 0.26100321021666234, 0.05308051544402237},
    {0.2604573231245203, 0.07724675980130022, -0.028219420780918592, -0.38161782179333564, -0.3138253312230356, -0.37461669788450747, -0.28794037844813986, 0.3579833056028766, 0.3060587934446558, -0.018889434019692286, -0.5666225784412879, -0.18179168743241475, 0.25648347411436195, -0.2443509029975295, -0.3901812515873135, -0.4523370816164834, -0.2821256159777581, -0.17213198628787477, -0.08015773845851214, -0.07131560212906712, 0.3529837987589427, -0.3992450920710113, -0.2880949410709692, 0.09277157713402596, 0.2057265252663834, -0.33674483611772593, 0.3042788384762197, 0.16237342834735957, 0.2967415512601489, -0.28643683000988895, 0.04803649738750001, -0.2032879169855558, 0.4825312019332244, -0.09025891904199715, -0.15759315889366546, 0.3934083274368743, 0.34122846379762767, 0.11093230363725856, -0.17538324187304727, -0.20832001837685998, -0.41725575946555804, -0.30021937197530013, 0.39751049302665165, 0.18055227803586013, 0.05353637658509392, 0.02917601476925968, -0.19883118031894365, 0.341302354121589, 0.13770547435327748, -0.2348514591541301, 0.15077493413536672, -0.11949919863573218, -0.12417849849745187, 0.13283320443267935, -0.47026241602925206, -0.38100175756662874, 0.024478860256323776, 0.026207371625004118, 0.4406035089329374, 0.34365118333263933, -0.32961948587889583, -0.15479160754321694, -0.3296980969823904, -0.3590115696719369},
    {0.5389295592302467, -0.025453352121998583, -0.1599884861321632, -0.30847838352955964, -0.1971480436107341, 0.33681850981249795, 0.13307392871874466, -0.2734348898047575, 0.47156091493645025, 0.09173130852000684, 0.24231806653495924, 0.04205906022054829, -0.47200592002875824, -0.0417288271748792, -0.17167322448140832, -0.5926130519170465, -0.2646983428791426, -0.535380695639049, 0.490538904972759, -0.20790475302614173, 0.10884807334956993, 0.5410456486223463, -0.2562416132506131, -0.44296296819043873, -0.2819968444229688, -0.0926665113676535, -0.10168397718623766, 0.3040636538111559, 0.1898079760136921, -0.2802738693406761, 0.2569563479625882, -0.19732748046791448, 0.07831833351026968, -0.6659385136840088, -0.21377871854531735, 0.38046688933700784, 0.1795327530865889, 0.12378336030771722, -0.5450963712981495, 0.04793337267377205, 0.0927051017793236, 0.2734550753682691, 0.10445187144794814, 0.22336806383309357, 0.17869753692083842, -0.46668643651363545, -0.09430643767401134, -0.3174683364508876, -0.11973336568786665, -0.4813523802849413, -0.12929760168263157, 0.15715497817047092, 0.3485929729004794, 0.417626755951651, -0.22190438816844632, 0.07487190190496934, 0.1291634451812201, -0.01672239888659077, -0.45226951537391213, -0.35734483945000894, -0.45844009766947125, 0.06802302570868582, -0.039007427865379814, 0.06327411268197773},
    {-0.2905487589621956, 0.007357630546527942, 0.15143835632673205, -0.09550827571341015, -0.20668179885071022, -0.1450544233353704, -0.0016498512412028436, 0.33519448504577337, -0.1837651272177725, 0.4566780928266672, 0.4677160065134225, -0.058547352342194166, 0.0386818710604088, -0.43539641060467454, 0.4579177481506356, 0.18715635295036528, -0.23605994531955896, -0.5490548217593759, 0.2618774418433404, 0.13961304512011555, 0.3280743984298237, 0.13804992447096445, 0.17716493327769012, -0.360976464848818, -0.1430631419731778, 0.061020994798989064, 0.22042606369367135, -0.0489411997195801, 0.3510443491823103, -0.14344227022119363, 0.4102013919753133, -0.36747999190520136, 0.6095658372637915, -0.18870710420415884, -0.2915762762287121, 0.3038210264392487, -0.09678403834310914, -0.14931043849763917, -0.29655200779656515, -0.3274565009489383, 0.3769528063955569, -0.11270550387322095, -0.2900492969010717, 0.15400299163033535, -0.1326848702176691, -0.20925257603887684, -0.5428890898871076, 0.29998721720690097, 0.21639191776159322, -0.4543980450756722, -0.28612542585531886, -0.029351996333613357, -0.0007580907379832936, -0.07501920489770605, -0.538699632031438, -0.39529028459156845, 0.22134412634657785, -0.40808389665851774, -0.09405581594844635, -0.3883910738149889, -0.23690607195066615, -0.04127376513845979, 0.040632785172409785, -0.37067768789458005},
    {0.1184892511785973, 0.0708134381684935, 0.18083059021011777, 0.3503616985536287, -0.33365228422036003, 0.237499940813297, -0.21403351473260018, 0.37357088331528554, 0.13511199368589882, 0.6221635088242958, -0.22707188221833036, -0.13367454974754606, -0.10159898685240056, 0.30528328297214485, 0.2875921455896825, 0.14616592972489775, -0.26661785585463965, 0.08359549114284734, 0.13785331579878676, 0.014276236737233189, 0.4964545439399076, 0.0037362563416589757, 0.15658359338528946, 0.12941238944197353, 0.20482393575948452, -0.16784357721392848, -0.3968258507178669, 0.1876022192640912, -0.038653904850960465, 0.0566192357904769, 0.17939014694941666, -0.32297287757479237, -0.20540144124058668, -0.24588501076056904, 0.3634677332340531, 0.25193356531067473, 0.2338320507616513, 0.16234067868920346, 0.0020257063663500674, 0.07830282187406024, 0.41952821589321354, -0.2629511100590903, -0.1947918065352611, -0.17482511279658428, -0.09358075732782696, 0.01162820930115286, -0.5647750658653085, 0.5013311581959745, -0.047990439879139674, 0.01447652908559819, 0.2853890986036718, -0.4483781658833796, -0.2307379937954161, 0.18554201050982225, 0.08805680597302305, -0.13705442703712217, -0.029208737366091888, -0.5166604387086224, 0.49439444189926113, -0.2495207744781201, 0.2784329955629154, -0.07525044948133992, -0.11711733113131113, 0.27497156774467657},
    {-0.32701942161680014, 0.16308908176338516, -0.2696231632091125, 0.18760599526373897, 0.4105942835331375, 0.025465016920917755, -0.48891352299370816, 0.5005412387428014, 0.2610154106142817, -0.45499946299602756, 0.002824523500360049, 0.28222721523748306, -0.2769678301762441, 0.20453102373068502, 0.2666742534593063, -0.5302483353463572, -0.11174969528330536, -0.006200482948486983, 0.5413765105505149, -0.38586995328038454, 0.2635960271792993, -0.42322608160679104, 0.11367704126912925, -0.37468490954641653, -0.039501728303084856, 0.1651969358700829, 0.18127184840768043, 0.3689567226135009, 0.07612741864191626, 0.0054879758394445945, 0.23301408752314343, 0.030465564021821684, -0.12338328236400727, -0.38525671571793085, -0.33511179296430466, 0.47318471348742697, -0.16799330255299028, 0.38384121438758995, -0.2133215725621504, 0.40585568412841305, 0.15996138258195597, -0.13680021976547113, 0.5662807595247465, 0.25218837238052866, -0.10706475843047232, -0.09411608591641628, -0.5338444935136107, -0.23653255354413205, 0.011549896632175708, 0.475808399784953, -0.25474077742122725, 0.46932518871640483, 0.42746555447097456, 0.4157478570018355, -0.17865898867432878, -0.4092202026078295, 0.17351476758505555, -0.19842858983296052, -0.0683274841234529, -0.25533010651505866, -0.28150751091396503, 0.05070078176175535, 0.46197104301262965, 0.21686692304729835},
    {0.08054785508539712, 0.1541753399283539, 0.15600782691357723, -0.37037580601560866, 0.02720669543158381, 0.40319254113531305, 0.07850965537860612, -0.2961129544322711, 0.02278966577511833, -0.35968519757989187, -0.21593232144807445, -0.3383238712247802, -0.1946735487995974, 0.06747297164280655, -0.33546021507829193, -0.3451006929965444, 0.2868711619581239, -0.20725500788806267, 0.442879337954933, 0.2622344859456044, -0.0906774302024985, 0.051085753301463796, 0.025050733585256127, 0.2653544894723094, -0.12361280806034383, -0.335324087431748, -0.3297931088423399, 0.3828038616497143, -0.10452988654591581, -0.4519089641383097, -0.37804389212778533, 0.014954565762193384, -0.031099377789313983, 0.2529051690336179, 0.000253399889036774, 0.09439503866685668, 0.17408451329040606, -0.33293657132401233, -0.4680804008771747, -0.26756466407667107, 0.4474258396616729, -0.2663395936011201, 0.340297642987639, 0.3050751853535886, 0.20414475368765508, -0.15188447211248052, 0.049595950582244835, -0.2916283737047883, 0.38694175454742913, 0.15364000504181044, 0.07926358840415963, -0.09325495518118608, 0.36794145197552114, -0.039912204852938844, -0.5388925638184189, 0.26834338135762564, 0.027225478287086304, -0.3579705495487383, -0.24270638867819788, 0.1136567714489176, -0.41644373095760406, -0.2719240548551847, 0.2818122039913435, 0.34327864362739413},
    {-0.15709744214306012, 0.4800365517338318, 0.2425074026522389, 0.4204356164419333, -0.05405999037366476, 0.2303906088687017, 0.11234019641434767, 0.37572409897051995, 0.07106971230889275, 0.0099161850586818, -0.3453393393354129, 0.5477396268128109, -0.1312004594874074, -0.2570645747646757, -0.2864999899588964, 0.2168245237411965, -0.3450964769952525, 0.24638154568570275, 0.12994976542527858, 0.01876544540971878, 0.47070783941996436, -0.23581308146218888, -0.5251183387185292, -0.22461758853426436, 0.1728556073963348, -0.14816567190268842, -0.04448290594858457, -0.35805598629938645, -0.3024665974746341, -0.010470366605130038, -0.03268575918594561, -0.24687014970361323, -0.4817331227931563, -0.05887567242675524, 0.36295909029744466, 0.38385254390188994, 0.07856320969616302, 0.1298185839347112, 0.09145994492214249, -0.4484635227309911, 0.07991126929851042, -0.3662726907251164, 0.43022856057147757, 0.2801169767058542, -0.25912492907908385, 0.02442167246549026, 0.1881718156287663, 0.3039306920907316, 0.37885490973938873, 0.018250800568614767, 0.34196935889565994, 0.014278035903610929, -0.1941105615655384, -0.34513782861989856, -0.27979729771682965, 0.06716158514534316, 0.04863988587649709, 0.12421142587783951, -0.4976893433084111, -0.09789635898273451, 0.33358723273566115, 0.2546422601178736, -0.3117208689039429, -0.2105816091614725},
    {-0.18829746451853094, 0.19291565993309065, -0.05463606809327457, 0.37408637455988486, 0.13969590559444658, 0.3742444434475506, 0.007894841408384033, -0.3173611946951926, -0.30549828508277715, -0.2645137002812249, -0.39350471516134483, -0.022243634509658123, -0.25625602580071605, -0.47856495654187403, -0.6006488331634084, -0.011722948134437573, 0.07437622897937271, 0.3322174724556651, 0.452380834964974, -0.5380958143689755, -0.21279599990742282, -0.12126497757677542, -0.45625706739782784, -0.10327884810117904, 0.23371989840746143, 0.2502391700409471, -0.4314905751455821, 0.5115137146451418, 0.26580300354143516, -0.2585757417608263, -0.20117254822479536, 0.393964514640744, 0.04366737558102652, 0.2710237067583024, -0.18916935791662157, -0.03442804513655935, -0.05697221631780089, -0.3561592765233047, -0.34913443734105193, -0.25358367166743206, -0.10247950962047053, -0.5446211851346386, 0.4648745712048014, -0.5476751504171324, 0.33042958695724545, -0.17122368139438074, 0.21336540082908506, 0.13646177833925785, -0.5032114873977096, 0.17838119997247273, 0.0875296495634089, -0.06224183378300742, 0.13531182901165342, 0.2763682779294519, 0.028273750239285123, 0.3843668784211176, -0.2380842119153017, 0.2503359118552815, -0.3791845283462216, -0.2360209723262961, 0.20103247817062805, -0.002860587028225407, -0.04823668371573509, 0.3421022699242577},
    {-0.336500044364218, -0.32195517972154997, 0.22377606490645444, -0.23059193550998117, 0.027133852649857168, 0.2708915862958134, 0.24992819328176816, 0.3805658122678245, 0.5016522335740913, 0.38879998604634686, -0.1427404660276715, 0.1027586629584867, 0.35494530734348917, -0.4498062554258061, 0.4327716611535493, -0.44624902862259536, 0.34188639055270126, -0.06232812609830933, 0.4710075739388643, -0.0857438827645034, -0.4089492236045543, 0.17840972864202062, -0.38897803530130415, 0.6133837282126048, 0.2642805524564946, 0.23983578681080472, 0.10402954602237968, 0.09199707781693788, -0.13010722421001375, 0.15284984488446712, -0.43448654371092793, -0.29779648490087285, 0.5032231596475497, -0.02521396344733925, 0.3397745661902487, 0.4716990729479997, 0.34972266496136606, -0.20959747326077874, 0.33038504854284456, -0.2851826830135543, 0.0685085906188535, -0.06029349167419821, 0.13694350656271156, 0.4553012158477878, -0.07337175088031786, -0.04031991608997153, -0.2222285130448581, 0.04619477265235526, -0.3751480058050557, 0.365488249035791, 0.2793249154482201, -0.06752946020876875, -0.4663839146246969, 0.05106001139462234, 0.05609044414974755, 0.1286450208196186, -0.17098468687532728, 0.005938243059615639, -0.23970665109251615, 0.4393118451624468, 0.1621843777012601, -0.389715681233654, 0.024143706366301206, -0.2736724772337682},
    {0.25217313427268967, 0.03967418965508217, 0.07827620323247451, -0.6202732442148746, 0.06277968109369002, 0.2995109194795665, -0.4088522716049114, 0.4979283724437094, 0.02469236102510379, 0.15022050357770939, 0.07924778726221551, 0.011467906804322973, -0.4603851034096217, -0.054291287057923875, -0.651260817911851, -0.0982211729383233, 0.03799486193374365, 0.3654754502951539, 0.2560081154948656, -0.05510430446719424, 0.023595124739462275, 0.33160670012514976, -0.3817327343381294, 0.4455581458689219, 0.47071040222330535, 0.1757618461652894, -0.1468730584561262, 0.5501136878711945, -0.409194616295814, -0.6261896451105778, -0.029980914522471456, 0.06425106511096626, -0.32330763097804693, -0.006420710285276013, 0.4190799700443176, -0.15540565072561452, 0.20992759790095245, 0.25298726340971694, -0.06504011330123545, -0.5101938086121148, -0.06057781287649771, -0.23921253317968347, -0.054500058085835634, -0.40259386641611633, -0.30869897787722456, -0.4234007227494869, 0.0725982605854848, -0.02069878541808681, -0.25005490430698035, 0.19701024754972246, 0.10058931359920018, -0.020270403844807862, -0.16098520633744784, 0.007315329392406613, -0.47477460475225897, 0.38478086374724935, 0.014838008637433042, 0.13569884970415988, -0.5276401483566984, -0.20816994511442405, -0.09266368571469047, 0.1456336583921215, 0.09200779768286703, 0.006028130358595139},
    {0.13203434161413788, -0.004888390471811295, -0.1558039001651497, 0.5998108193115534, -0.34963653355496127, 0.16700752353307216, -0.2502771781828803, 0.5024494404634008, -0.30492539445697137, -0.37026247097077775, -0.5250285322701098, -0.23850590446027, 0.01567054982986508, 0.3861483295679775, 0.46757036081713893, -0.298522790206884, 0.12131658685285858, 0.24178236065524325, -0.3204539758002226, -0.20665937042591934, 0.34182114394889573, 0.3509553091931621, 0.008054381422077726, -0.3420820412709091, -0.2300384130599804, 0.11013639539383649, -0.40601061440220154, -0.1570337316645487, -0.28592114651566714, -0.37144784678642623, -0.3384926407628262, 0.17828351473124093, 0.1768759771606337, 0.24661479555202007, 0.4563896301221265, 0.0018079069491869868, -0.005555337131803378, -0.041094453869456954, 0.013413805043393106, -0.20950716612593712, -0.04559552112891832, -0.34566455178015204, 0.04667740878553363, 0.0037441345814997946, -0.46763426372834094, 0.36875164856937065, -0.5066308687649758, -0.053752907316670755, -0.5840037884073311, -0.2329415160084477, -0.06070405143470911, 0.059730991739513635, 0.05363073828312487, -0.40456310422921826, -0.39787679860898295, -0.1827599740484748, 0.34259130812487437, 0.01021985843163424, 0.21174487398899183, 0.15467915212739725, 0.31187170972774564, -0.06915312259599267, -0.06376804354123329, 0.5407515765092074},
    {-0.20348661609332241, 0.1907307230576754, -0.08832165463196358, -0.2846510478804603, -0.27954243593669814, 0.5295190673269533, -0.5133009186544426, 0.45190715581891466, 0.15785118349761731, -0.24893745278643578, 0.022653144246901406, -0.33066849839789786, -0.1515327544643683, -0.23776399319372443, -0.06479058325631001, 0.23891570644834212, 0.24753683581882996, -0.15059696398281486, 0.0952211514249625, 0.1902619070604318, -0.19067607000738362, 0.44462501048302744, -0.47438334087324363, 0.6015923871209136, 0.11169595879325091, 0.45838064504146236, -0.5595438541963433, -0.2187062715161894, -0.620464044445617, -0.3832408235341347, -0.35894588230760344, 0.5103671123644865, 0.16762060867177686, 0.15699925716526825, 0.4934892666541161, -0.007720435204137755, 0.34879144219967734, -0.003576477541892205, 0.022346659144170635, -0.4234414231186649, 0.23900529005545387, -0.027429270423371552, -0.053594496367337034, 0.005729204694050365, 0.08718482912603175, -0.10106543767018077, 0.308471138846792, -0.2668620888880878, 0.09196011733863935, 0.22991491170408976, 0.5040903025177035, -0.49002690175431496, -0.161729654283507, -0.20843763049324623, 0.20778959353956677, -0.0187305105278061, -0.030693869713282147, 0.03396612570441185, -0.5105088382137729, 0.43308776510150376, 0.30962767369833116, 0.21403263334752803, -0.37029419518128975, 0.10367506536488695},
    {0.3513283977664961, 0.14210370380537773, 0.4282103856996025, -0.3220590757815905, 0.22662934324466674, 0.2198605342572804, -0.04475967439228292, 0.09069416558436232, 0.4391850527530037, 0.10202014414569076, -0.18633813159310328, 0.2752462058316496, -0.018376337817742557, 0.0531612160051614, -0.1222528150670861, -0.3241516440474337, 0.3096798235958262, -0.1712778075696788, 0.22036788919600267, -0.3005808974720127, 0.5437706117293098, 0.40219106918181097, -0.21543125387515963, -0.05400210885610849, 0.22334973854898452, 0.47279074325210546, -0.07549344943148562, 0.4333313172292974, -0.2528592387743847, -0.4008968943430856, -0.3784375312912485, 0.3737603477390111, -0.015388515849442128, 0.2898342943138948, -0.43120455592054024, -0.07031835655370595, 0.4941423495193041, 0.4949304798304517, 0.32844097142622125, -0.21245945622517498, 0.25078306586712235, -0.1552216290946376, 0.03540472302555351, -0.08825850697005078, -0.06535851060044359, 0.28235854057236065, -0.22807717679706918, -0.5044338514943966, 0.013242684168562642, -0.039364976657083474, 0.3750586542876815, -0.3427827627029866, 0.11215473551145076, 0.3889200309297906, -0.4068832507145869, -0.5168384653240499, 0.2983389971577669, 0.468141591302803, 0.13345557480832543, -0.25793695168271863, 0.3051423474736947, -0.5072710642361966, -0.4344354450193006, -0.13640066039757062}
};

static const float b1[64] = {0.8830834127307844, 0.8694654128824257, 0.9028442077809196, 0.9301053890808049, 0.8854288773824707, 0.838723248886193, 0.9168402626047968, 0.9011442750979922, 0.9305336345729468, 0.8978198930521317, 0.9116272567644459, 0.853224530544213, 0.8342831258055441, 0.9042706122608642, 0.9054250410156666, 0.8878590639279591, 0.9289080033358215, 0.9301618880311625, 0.8332005207394219, 0.9091564275460766, 0.84147283124755, 0.8394083597119532, 0.9002696458611409, 0.9109127361377574, 0.8848374126447243, 0.9164326829145006, 0.9076696722900036, 0.9257036985780693, 0.8890498455643857, 0.9241350515297238, 0.8757575437152177, 0.8952593921912099, 0.8718621595017854, 0.9168814415468209, 0.8999297845941878, 0.923218222818723, 0.6720471248379417, 0.8767385739322215, 0.8251300059340377, 0.8986662301733467, 0.9166402409968687, 0.9158862798788436, 0.8921452427441289, 0.8811415158144364, 0.9370957098197061, 0.9111932596461232, 0.9013600361331057, 0.8955502254244524, 0.9052189250078377, 0.9063948736660266, 0.8922152306547222, 0.9312174677708863, 0.9038823124330859, 0.8625180096404154, 0.8740944666338455, 0.9080955890282463, 0.8196688406929314, 0.7543280840048442, 0.8595315821089389, 0.9038119400857155, 0.9344924689139222, 0.8430669965887824, 0.9218586802636941, 0.8843141059827395};

static const float w2[64][32] = {
    {0.794776641468785, 0.7016566976874632, 0.9628093752582594, 0.04579148335329957, 1.0399493037741687, 1.0729825963390434, 1.0186566427092119, 0.9396684995240567, 0.700045828137725, 0.6294472599516586, 0.627322562522622, 0.7643561949912846, 0.903413324848973, 0.841349390497964, 0.942949300684777, 0.9039849183223344, 0.1449625952089076, 0.6863765607440944, 0.9604660970047292, -0.08125041340177502, 0.6560802638094619, 0.04028917019405458, 0.97378256329644, 0.98546218332345, 0.5603238336949456, 0.7258859398702643, 0.8809560209487257, 1.0117079438532381, 0.7899961291354125, 1.0603716518921114, 0.10442843329224315, 0.8845496616915938},
    {0.7805238358538209, 0.9053644957267648, 0.8598701097655577, -0.19219980060869998, 1.0475255570681612, 0.6799762043975629, 0.7817871102374996, 0.7770833115193386, 0.7639038571114711, 0.644614678482162, 0.7594540060654144, 0.8652541170528159, 0.8098198710842984, 0.4430290050482753, 0.5886241608656768, 0.6609761518136374, -0.24476729039212333, 0.6630647632375408, 0.9348081209883143, -0.1065414270773107, 0.8733815012501411, 0.025645399305726804, 0.7981857683196992, 0.9077595264120912, 0.758384841407042, 0.7091265632706182, 0.6624657844044195, 0.9860250749833951, 0.4519621309262923, 0.9119076408982154, -0.2096745502643408, 0.7492427361300168},
    {0.841155966295594, 0.9784883875847395, 0.5874165025376993, -0.07306124483783252, 0.683403829697194, 0.9021679379186244, 0.9287326893219296, 0.9174464112432209, 0.6932380280464748, 0.5255706264604865, 0.6599564551378255, 0.8183625590036264, 0.9377704007212556, 0.5590242884486369, 0.7585079442108352, 0.8778208779789962, -0.005016857188210477, 0.5788434766298601, 0.9851294519874042, 0.10076792068969491, 0.5052611334794966, 0.07053867161097861, 0.9126675810403816, 0.7823724632866369, 0.8785161583359612, 0.5941047411083921, 1.0495844030483041, 0.6114540705319593, 0.4676966958472637, 0.6475233890117975, 0.10140761818198205, 0.8510267583656255},
    {0.6635319155503654, 0.9986562392725854, 0.5843683089568091, -0.29346867593265563, 1.017769469651704, 1.002231773408742, 0.8361097827916755, 0.9874197017703187, 1.0204897548744252, 0.6318086150630414, 0.5538549167122435, 0.8262183335175373, 0.6321436958492999, 0.8736326812460904, 1.028954815272393, 0.5978298858375027, -0.08915829311119038, 0.7977557757371555, 0.7642776109908767, 0.06292723369352816, 0.5914909777042996, 0.08718718618543218, 0.6944981532316359, 0.5203187314663138, 0.6024832809952922, 1.0487134423017341, 0.7010049782496776, 0.8937146210819983, 0.6816026480246912, 0.8408625080093554, 0.14879051416810496, 0.5348271814504022},
    {0.7153369440209953, 0.8467811359510493, 0.5266205247124358, -0.005786753226309264, 0.9747135196850212, 0.875503681793879, 1.0565539678895677, 0.8611576439970355, 0.5896172628056651, 0.5610442569718092, 0.6160936138528912, 0.5783503769571442, 0.9647667386805988, 0.5685610601006581, 0.5627847233685797, 0.7468866663627509, 0.1311929393824132, 0.6089513539637187, 0.7840058750435795, -0.2853347224129956, 0.6502823936269592, -0.21281444763302135, 0.9478471641324321, 0.9076510586000337, 0.6256602934015381, 0.6491535731401428, 0.7704446661035624, 0.6273927360474221, 0.7524575690525159, 0.9890698485701755, -0.0751081691922221, 0.6088060886664903},
    {0.8471894338671235, 0.6136094518867512, 0.7584167216697355, -0.2658341528618143, 0.9497008480497047, 0.8127900882869034, 0.8870413386959973, 0.6796507764126198, 0.9586812117786189, 0.7584604303853484, 0.575110235045567, 0.8188003841084337, 0.8931769411936302, 0.8100301028062028, 1.075740904421453, 0.7023746730613498, 0.16215620293532776, 0.8497509809976203, 0.7708492548225482, -0.26670203028273937, 0.8785673188206279, -0.041005493673453304, 0.8181234939916711, 0.7408507869505611, 0.6157802888805046, 0.8828300550517206, 0.7706048319851595, 0.7315136637292595, 0.7742776208309741, 0.6695587359073775, 0.09115767599400584, 0.643040584020237},
    {0.5514681952528635, 1.0200741814783405, 0.6548254402037778, -0.23196353872298103, 0.7276152748461276, 0.9381982729273461, 0.9700399545209069, 0.638084667854539, 0.7202058937500447, 0.7578295143650866, 0.6130363528017354, 0.8450176002547903, 0.8944062948718574, 0.8180839950036136, 0.8097943301711599, 0.5959488324820308, -0.25694224925073517, 0.787910278471452, 1.0084941234508278, -0.2549141551374187, 0.5584283379418649, 0.10542545109765288, 0.8815361032704304, 0.9277332219211328, 0.8247479759848321, 0.9279490564708707, 0.8050985032546755, 0.6440526854852017, 0.6020429701916621, 0.67135559802788, -0.10385557629917332, 0.9436636053376054},
    {0.7020776419736935, 0.6603609952468023, 0.8752875057322517, -0.04976999390339745, 1.0782654215170324, 0.9726878387851959, 0.8881737252723358, 0.8182778649124238, 0.8583582316429532, 1.00306039755213, 0.3110040119717948, 1.0402162129284107, 1.0638919799065631, 0.8052311824275509, 0.5940741456680075, 0.5716258635724722, -0.20188332414603397, 0.9993294923127434, 0.9898995450537043, 0.028393113974595634, 0.5410185702108024, -0.27319136905459385, 0.692615965596929, 0.8502575948439787, 0.7438240743860357, 0.6249639827210313, 0.697523783542226, 0.9008258785133417, 0.8748441024432572, 0.6449866573319757, -0.11219533472059995, 0.661500927256748},
    {0.7073728369892067, 0.9692448651129254, 0.7032552959211538, -0.1682989050824287, 1.0175329014505239, 0.7451181951042946, 0.6182881607558027, 0.9557941985965875, 0.6758016863818577, 0.5119903203707904, 0.553088282109294, 0.8934869371643623, 0.6912348455512138, 0.5041273506729045, 0.8669681028259116, 0.5729489303214762, -0.2017299468428851, 0.9306452192207985, 0.6083208007410195, 0.15861252432670114, 0.7557851151740284, -0.2541402707109853, 1.0672980681473596, 0.9808193034586414, 0.5618911203285466, 0.859904833777072, 0.9356420045430096, 0.9253609621129328, 0.6078581405525267, 0.7705902979320252, -0.14978432247818907, 0.7033457625057559},
    {0.5086657541889998, 0.6723042954943012, 0.7066045412559706, -0.09383210675838265, 0.8780817352766083, 0.9050753950856976, 0.9903658620186193, 0.8275205861730284, 0.6215711454079244, 0.6909789197283509, 0.37674604907310355, 1.0655367306626626, 0.8875093788035375, 0.8121418138026526, 0.8641728476774251, 0.9922294377640607, 0.047282966215497, 0.6184271689104829, 0.8183845339034872, -0.0032571097603141786, 0.7167688615266046, 0.0502300265346103, 0.9099585767909995, 0.7609394731121165, 0.5715849399941021, 0.6166746206594335, 0.6957518670807452, 1.005869226023168, 0.6190186662961423, 0.8777373945841049, -0.19116570018862364, 0.8493201887741488},
    {0.9498051322153784, 0.6896503589346336, 0.6894928923943134, -0.0025032057572188723, 0.9802571992449138, 0.9719348638908983, 0.8537646596081525, 0.8083607983237554, 0.7792535391469917, 0.5057918657958045, 0.4019306535936109, 1.0532715416617076, 0.6717315614217277, 0.4607290908980877, 0.6325078823611318, 0.8843093042253162, 0.17528817718668624, 0.8390384965039548, 0.6733750917164, 0.09207969345274658, 0.475773878072247, -0.21085879952672776, 0.9905386441745679, 0.8438627473621242, 0.8471523986360168, 0.936515074028881, 1.0592894344302266, 0.7886746346729459, 0.4882990867235923, 1.058784184085932, 0.09355414547206188, 0.9537853140647117},
    {0.6528343140609763, 0.7381340856523997, 0.6385735811043982, -0.16364941821021778, 0.849478001089398, 0.8351957500247568, 0.7862708410408502, 0.9715634143391433, 0.8720197670884227, 0.9115925580357375, 0.3476118337128615, 0.7304030097344645, 0.6519284268549096, 0.8800315170085369, 0.6920169208177778, 0.5904673287200864, 0.12805341052141717, 0.754213605526852, 0.9224689429347042, 0.013543889485605014, 0.5088209775043667, -0.1961227105548403, 0.6093213664992136, 0.7420200916160379, 0.5335603584726116, 0.779695830639422, 0.6353104321637688, 1.0561306781286137, 0.7215338670941985, 0.7886269524364135, -0.29114874649240013, 0.5898072878929012},
    {0.7910700761114885, 0.8593616048274786, 0.7065270258628511, 0.012543344989471213, 0.7836439083748501, 0.6943441069194238, 0.9298801542166774, 0.8846183769396325, 0.9505167229391, 0.7907778798988946, 0.5927695300383703, 0.6804368296827804, 0.6312558304717286, 0.688191622590301, 0.678001929530571, 0.9892170552570686, -0.1809774714879921, 0.7598869136296482, 0.6818281952962384, -0.028324419949928143, 0.44088243301549096, -0.16386782088683524, 0.6949416835676004, 0.6010788291391388, 0.5498320748094326, 0.8707513245899132, 0.9506241452013251, 0.7932847562364602, 0.46138797359273553, 0.778464236205675, 0.1364583284270143, 0.806014111479683},
    {0.9544802013005433, 0.6787326753679712, 0.5782163487145904, -0.02449507981140665, 1.0096066936647505, 0.9143242356560409, 0.9659542898367811, 1.0955617738982202, 0.7481215656038556, 0.6667301775905036, 0.6841973119571766, 0.985245236202376, 0.7133123532742122, 0.611205414782733, 0.7670533362919577, 0.7868036202802448, -0.14781895641157225, 0.8737152404576134, 1.009375871449434, 0.006143351420037644, 0.4852169564570545, -0.016661765316596286, 0.9484285842797424, 0.942957556142717, 0.6060359554200916, 0.6937465357192668, 0.897742902596392, 0.6589612677830061, 0.5977505783043235, 0.630206206945324, 0.0667606724062009, 0.6281099080985463},
    {0.7842381935103364, 0.7286893945104639, 0.9365450234950293, -0.15333909263625095, 0.8743554276279948, 1.0276032074926509, 0.7087346937027582, 0.6716060247688123, 0.8337557917442668, 1.0071186543871604, 0.7593260772700549, 1.02023803984781, 0.7711062434601831, 0.3997129203486189, 0.629826545748665, 0.8634496089420737, 0.10387758422780018, 0.6309517410059999, 0.6601129078861647, 0.07128390978693926, 0.732998178940383, -0.2395547571714578, 0.9904712658816907, 1.0013469367786192, 0.8388818859760477, 0.9776795783885072, 0.7158221966634485, 0.7139112804392381, 0.7061684836460741, 1.044231484152174, -0.03966905251659446, 0.7033543254706599},
    {0.8642513137362687, 0.5852360093657913, 0.861379074894923, -0.015004088731331553, 0.8618355823505317, 0.6918796677427699, 1.0719149390978742, 0.9615285871510594, 1.0153929868217204, 0.9283359148243879, 0.6271957234041311, 1.041072768426843, 0.8186640622823242, 0.5737043065679507, 0.748936665264854, 0.9812749181873325, -0.1315357447246761, 0.6383918712037324, 0.8980225322805246, 0.03939676226590859, 0.7919268633221449, -0.06708696348845548, 0.8145001188997926, 0.9220910975770863, 0.4296005856702243, 0.8264241520475111, 0.7345747681365484, 0.9455263822295293, 0.8718121602833613, 0.9280887140234981, 0.05072795919788885, 0.8359624436148727},
    {0.9713909936481494, 0.8582216057769303, 0.48604611206793885, -0.1763717651829926, 0.8381454044221809, 1.082576578594035, 1.0067941590635276, 1.0648521290225732, 1.0419923813050818, 0.5802079641498976, 0.31069423645275923, 1.0238218928714655, 0.7611084814281752, 0.4073069258555634, 0.8845309632573942, 0.6365651811026493, -0.12279914269073551, 0.8363960211737275, 0.7073666394173341, -0.016792242729592125, 0.6710852375861571, -0.028501006704123977, 0.7179728462121027, 0.5944601556463213, 0.5378837232202762, 0.9617221317262873, 0.741827701708042, 0.9036698207449665, 0.6331981125950581, 1.0549475522871545, 0.0052244176411044944, 0.8569585169300341},
    {0.7350834743956618, 1.039932940866833, 0.5963092752078101, 0.13314660022466002, 1.0948946355399394, 0.8766331412396159, 0.7455056270592144, 0.7429492680201754, 0.9434279672537644, 0.8917075582814692, 0.39904523939089753, 0.7107487829998608, 0.9483293436498561, 0.8600127364630753, 0.6779194757376787, 0.6283347273691515, -0.014372645678371774, 0.8982395100144401, 0.6105141504211282, 0.12504928688831551, 0.4736823196146828, 0.07425749123317625, 0.9008258880171427, 0.8059600780663432, 0.4418911665379025, 0.9599612280877378, 0.7080224064702035, 1.105981972051263, 0.6751482248863988, 0.6420129516793505, -0.14255003817649384, 0.8937490696316756},
    {0.7189973195652112, 0.9156627385842792, 0.7570710318306907, 0.07432195927601346, 0.7904975035356018, 0.6562879388471005, 0.6660060415400176, 0.885838254751674, 0.9666473486053683, 0.6764131460688511, 0.42802485760953846, 0.9384536698286529, 1.0692460027541306, 0.4537587678904951, 0.9439411347646638, 0.7599885968466641, 0.05788127519482593, 0.6133012024364972, 0.6346491984957106, 0.0798133024962759, 0.8294084547400484, 0.14484309394531417, 0.669636312346083, 0.8551074443728631, 0.4981989694866824, 0.9296901189744878, 0.831390834454375, 0.9267104960011201, 0.5909112849621531, 0.7179572751608373, -0.15312880527167527, 0.8979946540386987},
    {0.886969593419117, 0.7812619332150118, 0.7397302783422928, -0.15315239558920637, 1.055733715453814, 0.7767047390626409, 1.0460512773372124, 0.8548915337671684, 0.6291277136695674, 0.7942722655037314, 0.5270083003361943, 0.6219493338136924, 0.5721462518304833, 0.8026557076399388, 0.8890939595347986, 0.930875603593735, 0.054727563633321444, 0.5741835616064561, 0.8781763399760074, -0.03345417039809337, 0.41377026167153286, -0.1039239841970751, 0.9026290791284788, 0.6364756246032957, 0.4711391872257875, 0.9882060846738934, 0.6709647519045637, 0.6409108802043311, 0.7038855842814237, 0.8854680959203332, -0.036744355096204266, 0.9385814608688826},
    {0.72711594738487, 0.8545375944259122, 0.9285516146398206, -0.1277514538353732, 0.854969351957455, 0.6805396987299174, 0.714159928971222, 0.6453026333131681, 1.0477705786181686, 0.9744361313730858, 0.7614269167530533, 1.0115958160845244, 0.6193276046967298, 0.5096263284624782, 0.8587607237006418, 0.9686682049177779, -0.04551481058784973, 0.6190981326175437, 0.7895428821985282, 0.13494117752619408, 0.42024603903447044, -0.07397505437744625, 1.0075827973802634, 0.8848378151332716, 0.8924317560889933, 0.7587605515019025, 0.7755150672252521, 0.891388486520071, 0.8476710664091026, 0.6921475928169912, -0.08001500045983866, 0.6450279449335391},
    {0.9341410762563406, 0.6417820661721756, 0.9663811734259782, 0.06620966070209439, 0.744135560656676, 0.9024534194175079, 0.6591962621422697, 0.8358902079929055, 0.8154917938323765, 0.8652013572516648, 0.44170686178789964, 0.9908400840393345, 1.0426512396494456, 0.4409552095578032, 0.9099687899279647, 0.8912393528663586, -0.2686411726785216, 0.7359864503609144, 0.7603105585656496, 0.12479674022781057, 0.5538746852334632, 0.0076289484956394505, 0.6521182102203745, 0.9626382447928409, 0.7178056628716694, 0.6925489822668305, 0.8724188695617483, 0.971808681623197, 0.726651860541298, 1.0748560705364165, -0.23363190355515506, 0.9851238460904221},
    {0.7284334500033127, 0.9707170288559576, 0.46496985057136575, -0.009347334548743294, 0.9947273993311905, 1.0487769484333138, 0.7232289238507981, 0.6860361650736818, 0.6917735396573191, 0.5134168011300775, 0.28886746479406394, 0.8493882578499717, 1.0363597445333848, 0.5108023970569254, 0.5930530704101362, 0.9505397439657922, 0.06700699158391449, 0.9848518495945716, 0.9265324943092373, -0.15472197603056842, 0.6745949039691389, -0.03171550571427394, 1.0368180110109917, 0.5720420990783833, 0.9044547523236253, 0.9888466531735575, 0.8585993116836004, 0.9951621312372533, 0.8693450967173085, 1.0217738347000849, 0.009928421102465518, 0.9552131929712236},
    {0.6304638467663625, 0.7831630447042884, 0.686962189725605, 0.11464535417018014, 1.0621748169370222, 0.7586860804934142, 0.671119529591497, 1.018976254004093, 1.1080918004802556, 0.7612424422940094, 0.3150996458383599, 0.7279400648677579, 0.625903385361773, 0.5128665318587786, 0.9011901491693868, 0.6700912539559938, -0.23017996060447657, 0.5757316001521277, 0.7844042705025807, -0.12240324147401312, 0.7941646741113417, -0.3156844394591533, 1.018977367474263, 0.6703642944635267, 0.7861592437199689, 0.6445240685958284, 1.0465258310047225, 0.6735282517674879, 0.5744501600077888, 1.042351370673788, -0.12882666248125207, 0.9300127904794264},
    {0.9942497117201314, 0.7522655465356103, 0.6959027785145189, 0.052640524291858025, 0.7399039582079046, 0.9155598359533246, 1.009630759691663, 0.9339656344038632, 0.7731541628114078, 0.571377725449311, 0.6025559510533346, 0.9673906819328952, 0.929339825194612, 0.8624520708676902, 0.5761156056818688, 0.8001125361919581, 0.11991886100185745, 1.023211776864531, 0.8969685551128002, -0.02301354840524375, 0.7648933782808212, -0.09203733593792895, 0.9596059295276371, 0.5492605360931961, 0.6354796084546629, 0.8318510767484832, 0.7219841535473142, 0.874735992198868, 0.8722053535046211, 0.6373168013750603, 0.15058175510490107, 0.6132562526475767},
    {0.6202248113961856, 0.8613015001749255, 0.5690621688537826, -0.058461789511040814, 0.7426480716132607, 0.7846655014206073, 0.7833072644506316, 0.8969439801863688, 0.7026428001285863, 1.0284829915431721, 0.5652288054413221, 1.0392313206484907, 0.8901236905177554, 0.6157987366356761, 0.9085467506216861, 0.8130820139929851, -0.1461763234842277, 0.9331224593792143, 0.9678235003504478, -0.17021399605852122, 0.8600426813927866, -0.1956899574377133, 0.8130691265292189, 0.7395712835496238, 0.75619361571615, 0.7745501567237009, 0.9208189641228821, 0.7854733849672497, 0.6537784047181239, 1.0234782268701723, -0.01651853109496909, 0.6263633173209066},
    {0.8329705271902339, 1.046136774815975, 0.6960147953984992, 0.06873823307633489, 0.640636184093689, 0.7487356256252857, 0.8036457073583017, 0.9939646197328963, 0.911236920603111, 0.6292610131547121, 0.6933770690741962, 0.9867312206598812, 0.5821909914797776, 0.5791959676908414, 0.6433456769436336, 0.7158184795376925, 0.05220368141115906, 0.6353751242201227, 0.7042433405886385, 0.07068674066796699, 0.7969380341231459, -0.08186755546941388, 0.9465830352809139, 0.8941292738919447, 0.8657512508299062, 0.8395606938467017, 0.8346525857892072, 0.8755644032630797, 0.7543266125136981, 0.8743713937524223, 0.04440175100125687, 0.5056839000579791},
    {0.9482790312349938, 0.9030253239336197, 0.8388372879653859, 0.10113997373788734, 0.6604282732625425, 0.9854307327573976, 0.6329080140305966, 0.7144163696513031, 0.7326938490294613, 0.6666336310584645, 0.64538467563172, 1.0714456556246377, 0.9359151815908742, 0.8609454948863478, 0.7851075324543859, 0.8206441931288486, -0.12868015511354688, 0.798492081834363, 0.6932038715207559, 0.04206347900218306, 0.8439966229155045, -0.28801415440427297, 0.6848878046142463, 0.6276247872262435, 0.7471170198911705, 0.862519242797661, 0.9838786026144186, 0.752700185827597, 0.44452443593759, 1.072028034124808, 0.03544032699589967, 0.8472571378828777},
    {0.9603896362266, 1.0573787044563325, 0.5550172595771476, -0.19005034888170638, 1.065844223115619, 0.7045068351110123, 0.8062134396341241, 1.0126764898477127, 0.6364243637829348, 0.7433430285201759, 0.3225080002747576, 0.8667387714080884, 0.8104761629569255, 0.6590182092321641, 0.9237877385173011, 0.6481607475789221, -0.12953852995376833, 0.8333129881319843, 1.0439161874099514, 0.12850481580894937, 0.42490924345875675, 0.04387893605320011, 0.9028208576329236, 0.8314575269344623, 0.44306153838054824, 0.9995905866497611, 1.0157438032593846, 0.8895932832115595, 0.8275058746922556, 0.8290125016492922, -0.12066284947733166, 0.6589251068223021},
    {0.9281103429838414, 0.9647733569450742, 0.7091567426625678, 0.045255245104970254, 0.7088993506970609, 1.0182209381679537, 1.0739752525447435, 0.6674791057713343, 0.7742600105846376, 0.8310578716392982, 0.7424308073515028, 0.7369440762423026, 0.8214511070426819, 0.5222845921222686, 0.6990793450570908, 0.896342865005687, -0.19510968554564112, 0.7590958649959992, 0.9406602800522758, -0.07710210023427769, 0.7774843728526688, -0.15832025004838995, 0.6334739868325194, 0.5454137058740565, 0.6261095803112272, 0.7302716226398767, 0.6721724836463583, 0.710524299363733, 0.7983847421359324, 0.6605586333225537, -0.05044601732044307, 0.9077244659008514},
    {0.5451387967825501, 0.6386285712639457, 0.8774978488816491, 0.09389908367293563, 0.7224665610457676, 0.9450746839704368, 0.864528361788553, 0.9300713047267966, 0.7473630110243141, 0.6283569175455618, 0.47498426612431927, 0.699820540032339, 0.6036929244648984, 0.4344315099322948, 0.8856225443575176, 0.6799893975171426, -0.21529466707056497, 0.6539027207775533, 0.6735205385488109, -0.06280563709301801, 0.6472862502969221, -0.14932547556292147, 0.822160206280161, 0.9644723672531138, 0.8274387017478154, 0.8847838516934533, 0.741171068764643, 0.7984100420853377, 0.8110122381655229, 0.6645744777608218, -0.2527201443104652, 0.5051644258779565},
    {0.9356652948841371, 1.0498439661042789, 0.7150871878059751, -0.15004503105263622, 0.6323820926811887, 0.5993659403810674, 1.0612801741110374, 0.8075818230218585, 1.0296704056784045, 0.7278699036236179, 0.6174777534196084, 1.0616915154900493, 1.0557480453668693, 0.8685072183325898, 0.9370120834617853, 0.7629557003582499, -0.24615778729659799, 0.8494869853313987, 1.0638334762907382, -0.26990609440770136, 0.7434969299373901, 0.08835043808625985, 0.6903685923991756, 1.0098501745160888, 0.5537449202197178, 1.0298422196063737, 0.6722451426798233, 0.7332971928230574, 0.6559772717315742, 0.9549963436080902, -0.1023204274772323, 0.7113142160186359},
    {0.7754816151038945, 0.7237042425150751, 0.772354449162756, 0.024378553912775353, 0.624821880641637, 0.8638665341855013, 0.9439015922843402, 0.6416999625000565, 0.7912294463561339, 0.7378020793706905, 0.4747196642053815, 0.8922154354925842, 0.8522799897720015, 0.4380111404430985, 0.9631145114320503, 0.6510623630161441, -0.12266981603632711, 0.7918858466441325, 0.7737377072715305, -0.012098650660900543, 0.5478829407527385, 0.14300979947657957, 0.8883973479489317, 0.9406676143867557, 0.8485517601903366, 0.6784257876042953, 0.9864547637131983, 1.0452160686860048, 0.8879773236305107, 0.8814965141768258, -0.22618472688167948, 0.6896007451300679},
    {0.9280385683746266, 0.8566948269746851, 0.6429590089492893, -0.13727016339403636, 0.859752488932926, 1.0829717114733024, 0.8672830764266747, 0.9918938932629646, 0.7681467311178746, 0.9596025931796953, 0.46030756130493244, 0.7403662093732238, 0.7049186588035805, 0.7814494957229348, 0.8884347307167407, 1.0074392269600578, 0.09954151739238598, 1.0299473823220227, 0.9470863708745246, -0.1387731718230892, 0.47210235731674527, -0.06772952035814649, 0.8725556853945897, 0.8543395928747568, 0.5761587080877744, 0.7531303482694264, 0.724203076313906, 0.8812363585582542, 0.7103765115230837, 0.8734472411511294, -0.2124777925303966, 0.6535281325618512},
    {0.6961395462127017, 1.0187195533479796, 0.9899655274342852, -0.21689892085598508, 0.9567098536108006, 0.7237387393169639, 0.9723009190162892, 0.9082082648276933, 0.8027550813629182, 0.7178250812796453, 0.36546752475420125, 0.695493967997512, 0.7754748793400627, 0.45208971776044415, 0.911168592597291, 0.60530544927401, 0.07361030221583315, 0.7631382451180584, 0.7696260559025202, -0.2778143242136559, 0.6436552758884947, 0.06850616642015368, 0.6589747753794428, 0.9446188689939019, 0.5611450701015812, 0.6477596167255664, 1.053422456784819, 0.6889082283295863, 0.5260325153796466, 0.70731483940458, 0.013143461769539769, 0.7891229749567602},
    {0.6240250638780885, 1.0017318597969627, 0.6669669487292779, 0.045458168953120597, 0.9209872819055975, 0.99376015209911, 1.0841285654818278, 0.8060580898070366, 0.7039262797946682, 0.8568852212350766, 0.3064436305850269, 0.5860518387886315, 0.9843486980424322, 0.9104757561358209, 0.9617250118070941, 0.6503376817022529, 0.034685897103438224, 0.8111642803664434, 0.6229431117739871, -0.22215493991279353, 0.8019198960988103, 0.14435967658073778, 0.9717484758872127, 0.9279761413223175, 0.7680368441727867, 0.923662705527456, 0.7828683332419619, 0.8825767964650791, 0.7885591839724113, 0.865528589361494, -0.21480313033080153, 0.5804865768278771},
    {0.6872839541481865, 1.0506170934478778, 0.8207061641102258, -0.13560639225808693, 0.7948309645926955, 0.8292092504397996, 0.7384884045693355, 0.6740984284509157, 0.7001258561266466, 0.8696360264143889, 0.7077184328403294, 0.8975526972236769, 0.8276640990966428, 0.8459587942814086, 0.6533640408584519, 0.8624470149229392, -0.25917034064951533, 0.5737102537200133, 0.825418138759415, -0.21455837573888117, 0.8702459002510203, -0.2891558692654016, 0.641698694698859, 0.774867598212616, 0.6659449716143973, 0.6855971835598312, 0.6375962859734695, 0.7758426064764935, 0.7003181111124122, 0.6433136905779251, 0.1564422618086919, 0.5696132348123719},
    {0.7440542519571273, 0.5762060360245216, 0.6377362884923079, -0.04306426698953303, 0.9904401180267091, 0.7390663363616977, 0.7487493912783767, 0.6773932902940676, 0.6586414637019609, 0.8459765111925318, 0.3223216798520418, 0.8627662740330329, 0.6621912127044965, 0.5959117829549582, 0.9303171261239088, 0.6185604333109455, -0.2804194862859227, 0.9132928571793748, 0.6175313014190031, -0.15819806499907255, 0.6886258387185232, -0.2975887902142929, 0.6870813512153805, 1.0065603074307363, 0.8249634192104092, 0.9240791953335848, 0.8668660469092732, 1.0706458471355424, 0.533622884980629, 0.5921737011832751, -0.26069818438168657, 0.9320953317378841},
    {0.9516598271497286, 0.5890465741621863, 0.7779621103039447, 0.11446165056600187, 0.830932872475896, 1.0439118711422193, 0.804476207248257, 0.7746251003451937, 0.9838492645250442, 0.6126404207598098, 0.48336915977124933, 0.7880573112450034, 0.9871322836917527, 0.6178130841472516, 0.6357756618225682, 0.6862462803496884, -0.27726711818607375, 1.0032205879597653, 0.8694074663686986, -0.1281826612836157, 0.5108123125256834, 0.14538342489764886, 0.7069455885830459, 0.7236157540636058, 0.6611328295182018, 0.6853090607414476, 0.735334838285509, 0.9526522808068448, 0.8480654594166915, 0.7020555081634438, 0.047265222316107657, 0.9675517356289521},
    {0.659236862659725, 0.9616669186940737, 0.7535599303545588, -0.1066453518918802, 0.6937767175896173, 0.8322473046327441, 0.6598815429958765, 0.6998052602028693, 0.8124099172478724, 0.611739096517848, 0.3013607228514192, 0.9000358172064105, 0.9567029614436068, 0.8429934392250945, 0.5918593433917647, 0.5497996213345886, 0.17269473990576073, 0.8231980185975907, 0.9366326550780887, 0.06518212891289323, 0.6212833964654813, -0.2774645032928278, 0.6307840347166078, 0.9835188527984001, 0.6337561787806696, 0.6581021657667642, 0.8551692082917683, 0.6487606888166133, 0.5748620613697191, 0.9487176728918321, -0.27171335500376015, 0.5324928985082946},
    {0.7844396180312374, 0.9126597966560114, 0.5124594898760207, -0.0019707877264114673, 0.9562771692849714, 0.9463450930984029, 0.7397579402712402, 0.7107337263246131, 0.8475764357173509, 0.764718970724701, 0.4788651747427468, 0.8618560472082154, 0.8757985210602547, 0.5211600431412279, 0.6477461989313384, 0.971666451501031, -0.22949088467686016, 1.0167439619172967, 0.9329355586329435, 0.09740190478349453, 0.40576773153079976, -0.15176871169328632, 0.8290761928199346, 0.6117902322252426, 0.7296399228667824, 0.8388688521883126, 1.045424998717505, 0.6238438909628509, 0.7496032814295692, 0.638300491953762, -0.15449058296891205, 0.8254551197402009},
    {0.6006775438059339, 1.053985821159122, 0.6132197890062069, -0.19746827893706168, 1.0036829653400914, 0.6393676240619212, 0.7633845408633297, 0.6188037708255872, 1.0223449666100437, 0.8117763024572976, 0.6723079293446517, 1.0844557484883153, 0.6941494870631241, 0.5793206400034074, 1.0726631070296717, 1.00817252885397, -0.05885415666224035, 0.7729538491720552, 0.8766983394880592, -0.2548740433833793, 0.5669548483661802, -0.1386801871493276, 0.9347712612698365, 1.0052011683648185, 0.7259408888819178, 1.0689740528117664, 0.7511399440548353, 0.8943253408123437, 0.5855679869616804, 0.7603586946855866, 0.07173662554820676, 0.6714169186019611},
    {0.7717424723656355, 1.0671627128867078, 0.6195968237528534, -0.28670757214189113, 0.7456945245580251, 0.5954037182325167, 0.9349602746656016, 0.91933288490328, 0.7927945533223466, 0.7236668229958694, 0.7749365172272903, 0.8414332423466143, 1.0251398611342415, 0.602993655277775, 0.8221398425820075, 0.8324786939478115, 0.13592861878299395, 0.6882531207618516, 1.062128105248012, 0.011400708713808416, 0.49562544598065184, 0.10420268348393291, 0.6295102484590769, 0.9824336126916854, 0.5177586397355004, 0.630217073035078, 0.6689079946949663, 1.0307107838248672, 0.6575538819345488, 0.7794328255774823, -0.14171027571713732, 0.999590797899125},
    {0.990610574410806, 0.8453330209313481, 0.6261725468533917, 0.11002608743966646, 1.090054766105464, 0.9479694759665234, 0.696966486138831, 0.8441273759356464, 0.9096853552680937, 0.7010009174894554, 0.40893337068335334, 0.7487014613321301, 1.0316528095029132, 0.5892779600108512, 0.9069365532814763, 0.6371588316792686, 0.07084049661905839, 0.9879140306273481, 0.8868936680193682, -0.2662407969745966, 0.8372000533095036, 0.02967053035277366, 0.837040630771127, 0.6336301805065758, 0.5775029160927607, 0.8009459037267452, 0.6062100775366307, 0.7318737439829339, 0.7680984433390871, 1.00658593147862, 0.08471971582955821, 0.8466117979423682},
    {0.49885003228230806, 0.7531570084204374, 0.7935566451283855, -0.09696081960220389, 0.6457482799916919, 1.0411272212400287, 0.9351818413285676, 0.7564561448545566, 0.97917727000361, 0.7734583906237374, 0.2978971642333025, 0.8994522900899371, 1.0182767159749897, 0.5400761107480356, 0.571433931931386, 0.6366101928008148, 0.031104518966490514, 0.5444878371735774, 0.9200458363179936, -0.26223813632827336, 0.5918002837103427, 0.05584844365861133, 0.9809768910890976, 0.7939972142976938, 0.5396671823349708, 0.6331879591183646, 0.9495296172672095, 0.9145874118165433, 0.8947248752219703, 0.6644771819587739, -8.36488240432779e-05, 0.8841504666384666},
    {0.9226007681855278, 0.97240461724801, 0.7012673589960297, 0.11160750938607049, 0.8174153119056142, 1.016053970741926, 0.7869169892275876, 0.6304480459058442, 0.7756044993688995, 0.9313453656825444, 0.5468664132907552, 1.051327604838944, 1.0252792704752105, 0.8656734004900698, 0.6566879606414233, 1.0261721857689983, -0.15069566912769897, 0.7987391558078827, 0.8958022757279324, 0.06988960784176909, 0.43383103026719283, -0.0846605325837232, 0.8844587192512604, 0.8541808339719996, 0.809366264270845, 0.627728455402938, 0.6322047189822193, 1.057155414886669, 0.7167053446101163, 0.6773589687340155, -0.28354442780434064, 0.9249235433276084},
    {0.751223889885857, 0.8619851818909241, 0.7311087427062648, -0.1546932550927296, 1.0706431693576743, 0.7712158682068079, 0.7883829409398261, 0.8287628681772908, 0.647500533547054, 0.8279947512379134, 0.6829961035170325, 0.7061515685840764, 0.8849051665397787, 0.6780846324375506, 0.7998025478767019, 0.5660787699046423, 0.06007066610195492, 0.9619656689067225, 0.8392723725878645, -0.06248648648492033, 0.5090514417439994, -0.08767161345350477, 0.9091059956762417, 0.7465663052610215, 0.6713148754494691, 1.047443250052411, 0.8003040691092416, 0.8235742710836264, 0.8238851422116246, 0.6812370544778786, -0.10190489174427814, 0.8470226863661895},
    {0.6107145414981843, 0.9357567858974284, 0.7666194699582312, -0.0014901636691150742, 0.7975551509828922, 0.947199727337053, 0.7541766856361451, 0.6507168395498579, 1.0680236036424184, 0.5362807486423329, 0.5033335555202011, 0.7647211393672617, 0.6691106127321621, 0.6146951367915204, 0.9129833416638297, 0.9715345084627546, 0.09255487713838989, 0.6620722990199788, 0.690584995702657, 0.1472935047131056, 0.7349540064814136, 0.15332446088410948, 0.7525854556041194, 0.7704840998880303, 0.5054340565592554, 0.6813440102674225, 1.0284153429450493, 0.9289912126797405, 0.7103714409195164, 0.5944775204521514, -0.1493321273168293, 0.8797505875652907},
    {0.7671835839239894, 0.8443093355723791, 0.798091688594138, 0.06838255425172407, 0.7370791527460854, 0.9119091923998702, 0.694844040292454, 0.9245934025148479, 0.8876997796310175, 0.5947045742251439, 0.42046799426712583, 1.021300281502433, 0.8353702109105036, 0.859033245095587, 0.9345189684428243, 0.9395296579473308, 0.030893848710841897, 0.975461940421817, 0.6226668707946638, -0.10302150507667689, 0.5819262975600584, -0.15165196442118728, 0.8044108404975602, 0.7251755291182935, 0.640199550488995, 1.063256940481286, 0.8825973094062479, 0.9726665276096745, 0.41110712612096784, 0.8114110354548429, 0.1501016690358804, 0.7393172116631724},
    {0.8916496662986193, 0.9805605503331195, 0.8080052402518733, -0.2176941582885966, 0.7389301190249877, 0.9964618682682316, 1.0411968270907905, 0.8784727644591377, 0.7480610380751306, 0.9220006414687881, 0.6916938052071525, 0.6671545153136229, 0.8754337462961268, 0.48834613126289916, 0.6694967314524498, 0.6625408195362567, 0.009430366416895179, 0.9549948201288637, 0.8767187535350845, -0.2273473466256166, 0.5112488296951612, 0.05059169416215903, 0.8551437844733979, 0.9089584749642236, 0.8510585704903699, 0.6490243749848067, 0.611662692863764, 0.8987840232429671, 0.6334227252863386, 0.704006420127968, 0.021213545679887577, 0.7385168631878276},
    {0.6443826138537475, 0.7069256404312422, 0.8398021943748321, -0.11001683888675987, 1.053914063579742, 0.8217087704671425, 0.9654589696144769, 0.6869165813266821, 0.681907056447248, 0.9801546014717245, 0.3414198056674694, 0.6691722659980166, 0.7660364465380468, 0.7813188292965693, 0.987765258694066, 1.059186314359326, -0.08616838538184515, 0.9913071990256771, 0.690138664159532, -0.006264484652088105, 0.4439090016528505, -0.1244901150038977, 0.8298551616389674, 0.761224229528269, 0.8577745200308514, 0.803347332629099, 0.6498508679939875, 0.5919090371618032, 0.7226930205146922, 1.0694700951616545, -0.26187113574635723, 0.633374231071839},
    {0.7160072337521094, 0.9946445387062218, 0.7444539012335396, -0.13590578873080483, 0.6803656202183561, 0.6655424019010369, 0.9710099833309573, 0.6754114633706022, 0.9475637097182439, 0.4883821225132852, 0.3590858393723677, 1.00650648990606, 0.7696592282304926, 0.7677687923061555, 0.5792385958941723, 0.9711045513332068, -0.20942550820719216, 0.9126199952040567, 0.6506669698269157, -0.05763653528088627, 0.804938201668196, 0.07560753161721473, 0.7717991080183414, 0.7938324282157934, 0.8482378285467066, 1.0781785981057792, 0.70338658773446, 0.8117538019518653, 0.7378480165363861, 0.8602213589281629, -0.3079282964402297, 0.740715325586193},
    {0.8171824849520196, 0.6932032792645573, 0.5009759529317377, -0.03555506803961309, 0.6891193328722262, 1.021553254074087, 0.9444641436416001, 0.9787424158567894, 0.8504964392687258, 0.59738934320196, 0.31892392094636, 0.7398267975634534, 0.9712994381334542, 0.45235358892517735, 1.065024436201594, 0.9134333917272937, -0.14276791626428836, 0.9075472965349862, 0.7537879292697794, 0.15087033834343908, 0.5189841007359842, -0.02941559028860872, 1.0732984920541326, 0.9865483248274969, 0.6630998305602197, 1.0753452016464689, 0.9030187721812044, 1.0426643418806383, 0.683552431258471, 1.0721931484462175, 0.021718713286998387, 0.7127743346772872},
    {0.4960696988751701, 0.6694917864847002, 0.5830190697986765, 0.07696457013262105, 0.877191608733854, 0.8258014381097959, 0.794027477160574, 0.9939454583327619, 0.7308022317543369, 0.9253078988068715, 0.48754679839636966, 0.9277579775809613, 1.0000037836046607, 0.7757115352838133, 0.747832604169008, 1.0178932786159507, -0.19172536566165993, 1.0015138544942828, 0.8381969037681894, -0.27988169896967174, 0.6884146049196868, -0.19829871711196115, 0.6773282519562958, 0.7939222337588991, 0.5116449212244019, 0.6801758677917942, 0.810513810008329, 0.910886255392238, 0.6256697049410065, 0.8464768942899916, -0.050644262687365986, 0.6332195471486008},
    {0.9458630339245923, 0.845815184803532, 0.5548927883038047, -0.10824305088884872, 0.8099355034225034, 0.8891668110324288, 1.016884657984414, 1.080154425266905, 0.6576761452240579, 0.8766326335020824, 0.7747236962702355, 0.6321970267643121, 0.8379159766002879, 0.6165405479190628, 0.8826353364325508, 0.7186954050206106, -0.2413847904776254, 0.6103788478077267, 1.0622819076739904, -0.08064305531831545, 0.73298173628275, 0.1678926945438742, 0.7497968627640607, 0.8635972596322622, 0.5734661149871366, 0.7266285143093028, 0.8621619429019703, 0.6253362000303568, 0.566681968466883, 0.7365343771394027, -0.13565857867715878, 1.0017969536400648},
    {0.9773586906608565, 0.7072430072293295, 0.6848814141258384, -0.1428264428051019, 0.6674728585437849, 0.8987753697510789, 0.7668515681092358, 0.9144591094296545, 0.8332954891224303, 0.6551563053596754, 0.6941801033504943, 0.7540285386657594, 0.6069300495427116, 0.4777223304281373, 0.796059292601595, 0.9968651180209914, -0.12864259330866407, 0.6698531535628821, 0.8298604869548698, -0.07772517475320224, 0.9087914370549407, -0.044788026876792675, 0.7851839517329037, 0.8206190569047684, 0.6649073742004977, 1.0753301066256944, 0.8952588270477161, 0.7987763029961698, 0.48421495279157245, 0.8593522224469523, 0.11822884681993885, 0.8473885557091341},
    {0.9705037665499551, 0.9872213595755028, 0.6774234747182087, 0.1297833026183415, 0.7452681474423041, 0.834720907584713, 0.6546519559796904, 0.6895363137552272, 0.8896351023998782, 0.7061532914880714, 0.64189117511392, 0.7219616192852535, 0.9954778907329941, 0.6160462212765828, 0.7193528978484347, 0.6295126125510222, -0.013827413073970929, 0.9183543488691313, 0.7585914771813211, -0.14682777318600887, 0.7719942619575515, 0.10396152922744374, 0.8347542357643837, 0.7571206365259173, 0.45816223027791325, 0.6741454810301163, 0.8519158708793706, 0.916420530596894, 0.6695735784321163, 0.8540065398946168, 0.09760543086198013, 0.5654077758273202},
    {0.9244860646671881, 0.7352350241179524, 0.5465539546658019, -0.03747911561237407, 0.6546880396365118, 0.6681318923443539, 0.625667800240719, 0.7420352215661384, 0.8980991090620064, 0.5968337928542864, 0.3930539244886054, 0.7716685714617809, 0.8239411640895891, 0.5739777950455173, 0.8071833330668058, 0.9102133062086143, -0.14488366971461786, 1.0360239140372987, 1.0564707636858224, 0.015913092888361065, 0.9079083090363983, 0.1712481257846673, 0.6839356793612867, 0.9186709664657403, 0.8385523168581926, 0.6435365081561051, 0.6959153427640263, 0.9845631999065262, 0.5281242978198825, 0.6955146895547734, -0.15491318358124218, 0.6322152779964436},
    {0.8970605496089156, 0.7807981426106968, 0.7708095441087988, -0.24066432551607714, 0.9902127823603022, 0.8095287829484413, 0.9735735239583904, 0.673833384749133, 0.7006169023741179, 0.7072701516874292, 0.7289865090762997, 0.6981292654286905, 1.0539900097886101, 0.5869481606981881, 0.7326884975959591, 0.5957185290578215, 0.12951124229396993, 0.9659847561725813, 0.661394941620712, -0.04936991871371478, 0.8330828353262829, -0.08238543222444634, 0.8842392687588206, 0.6703941337037069, 0.805915741745595, 0.914555810537661, 0.619149474381809, 0.6389543076628644, 0.4512091459863085, 0.6578383313156213, 0.08316673214910339, 0.7626555425841876},
    {0.8098036696185049, 0.7949533865120493, 0.9575224018606212, -0.019010909613390952, 1.0310290360396794, 0.8306791716092263, 0.814016366857557, 0.5946239113107746, 0.9219904588664626, 0.8935808112388713, 0.3288142209444325, 0.9946325832537597, 0.9901742956652907, 0.44217559934470113, 0.9200273524760442, 0.5795809374922342, 0.047994972133795846, 0.8802214999118045, 0.955711410072219, 0.03660935347965236, 0.4332825653324918, -0.3193766350961032, 0.9014776525880959, 0.7569780849739794, 0.7564667908380472, 0.7231487236830252, 0.9372197415090869, 0.9239192526823266, 0.46407225822191017, 0.7820761972517938, 0.17606021693827148, 0.9756905067078644},
    {0.9230889500709664, 0.8793439178092165, 0.7695362430796874, -0.0666509255036046, 0.5989224559428341, 0.8539846896951527, 0.8422558554320949, 0.7422834672058137, 0.8552161862989166, 0.8933986107599704, 0.6611268264881618, 0.8222241326719698, 0.6374648048574665, 0.728815755195142, 0.8986430121009809, 1.0505921290003353, -0.19100147450991756, 0.568333512817409, 0.854731671134221, -0.18556314674485996, 0.7313349753466366, 0.0026330103749109147, 0.9381452735729784, 0.7083891420249127, 0.5022499812719796, 1.0869086998800792, 0.9109022817366346, 0.717649962872521, 0.46864358735191736, 0.6623449537609569, 0.0018552265714294825, 0.6954877657228165},
    {0.7992743399239585, 0.7869710742499083, 0.9416337420577661, -0.07857824332431541, 1.0750016166498342, 0.5868638417382478, 0.7990247943983734, 0.7767022364213706, 0.9660028672019386, 0.9070484678081197, 0.6673556164787234, 0.8151822154669516, 0.5931397798215639, 0.51217644126999, 0.753606524898814, 0.5555699846989466, -0.021183441006391985, 0.6042622755438448, 0.8313233645665854, -0.1174858906005387, 0.7247219986049257, 0.12445275742198407, 1.0860824682285624, 0.8399201388861175, 0.8656581176526444, 1.0733312676445563, 0.5864391758828364, 0.9965962117910879, 0.6548682286760543, 0.6156406338791209, 0.09834781019208429, 0.6043727514182557},
    {1.0098472039278186, 0.6475668327044286, 0.6349808617127624, 0.09280146183576929, 1.0690464013257672, 0.9657595043888794, 0.9399531294123626, 0.9450019424630098, 0.9399842783556249, 0.6654733602217638, 0.6331425036285285, 0.7811015844652152, 1.0444344160494965, 0.6722165840297603, 0.5877901582240124, 0.6106153519446159, -0.27381317728203003, 0.7708734778127856, 0.7398637661233375, -0.1838548346705524, 0.3699255635280346, 0.08776310714507378, 0.6816606713243999, 0.6281333310408888, 0.4894336812599142, 1.093080851934015, 0.6165948970925264, 1.0903123698350032, 0.6261347758608004, 0.9346699626617333, 0.125182378064715, 0.82094376067975},
    {0.7579736523896772, 0.6735721213052144, 0.8087362258811701, -0.15527502914560234, 0.8062926138449653, 0.9253861298323606, 0.6465395812178472, 0.8261877293137955, 1.068594142762522, 0.7546725825408456, 0.5441150794401693, 0.8280327113302827, 0.9067331842929236, 0.6190112062140979, 0.6212279037312701, 0.9224926450920704, -0.027285901843796326, 0.8796607844065573, 0.6366816522788853, -0.17733710815301895, 0.42126480570018876, -0.27130442874929567, 0.7145763489807392, 0.9387666758779457, 0.6557736016959596, 0.9570718504698621, 0.8826869252816025, 0.6781914340583223, 0.42279288204747834, 0.8752092208694082, 0.12697321312161028, 0.9349707199266055}
};

static const float b2[32] = {0.6923115903436226, 0.771160196713393, 0.7035125535949391, -0.11020179510155019, 0.7784414388223099, 0.7755321429180916, 0.779978286057179, 0.8017033406828388, 0.8019874226204616, 0.7323269048148195, 0.5181405038507638, 0.7762998932115549, 0.7776593514369643, 0.6277148300504269, 0.7812980447231586, 0.7576275641753367, -0.0495956802447953, 0.7371055784591152, 0.79480067172103, -0.08031115419918175, 0.6076580193378396, -0.0910094073294525, 0.8026959973560915, 0.7516996722910247, 0.6316323702500753, 0.7813098755814026, 0.7700267864637443, 0.8338463919435423, 0.6563726142239663, 0.8370873430883173, -0.06936732162964232, 0.71957910777227};

static const float w3[32][16] = {
    {0.13158149399484242, 0.8656742620113803, 0.636089068446729, 0.7739619393750619, -0.31121291823263025, 1.0405364034791265, 1.19354270406768, 0.7457608768173595, 0.7491680185651374, 0.35512232596345633, 0.8093427109309645, 0.227828418436944, 0.8840166862100117, 0.564314756995086, 0.7869980088248233, 0.7361633205538102},
    {-0.21164091694007067, 0.6551528858149313, 0.6926013123019776, 1.062071509218547, -0.3222343026728511, 0.5434993497336186, 1.1464905012042022, 0.8974039969335689, 1.0978550482353353, -0.10969467356190682, 0.718751335362785, -0.13109612676402402, 0.5694385388337915, 0.4874563422596343, 0.7016150143271942, 1.146887870350599},
    {-0.07217622270220703, 1.002921517095625, 1.1734628438213184, 0.9843217466132187, -0.1375250634202028, 0.9159163054250384, 0.637456980936055, 1.0813507012392782, 0.6502257305590966, 0.1850672664686034, 0.9850693128760329, 0.11019451481916906, 0.9110854143934612, 1.0429575853409334, 0.9046968516750649, 0.7069962313405701},
    {0.0411105474265777, -0.02434460902286822, -0.07695139152535932, -0.2413795660571568, 0.032569778542581605, -0.17272806831183282, 0.12147200177494064, 0.14271399703846507, -0.047525962498781195, -0.08871744616178408, 0.33242183658704244, -0.16670641215063575, -0.15985909595380554, -0.26986574021131277, -0.19136842899998152, -0.1884941438627322},
    {-0.07141669931248111, 1.183154851989981, 0.5299014008579739, 0.765269415280838, -0.048501812879524264, 0.8736313167961755, 0.9018163305512583, 0.473135346787744, 1.0705788875460007, -0.2520614315295965, 0.8874742887709853, 0.10023426937939756, 0.6730092375876905, 0.9983612613948762, 0.5862935040766311, 1.0878818871878373},
    {-0.128661909654127, 0.994493320173309, 1.0074715231210312, 1.1989500186684894, -0.18538693696573078, 0.5975124086525152, 1.041148692227425, 0.43162092107731465, 0.9042166996077414, -0.25214626082768976, 0.6893492163232051, 0.23552350766789207, 0.5015059664702833, 0.7252815633753176, 1.1750629383760172, 1.119473234416053},
    {-0.2682496175319804, 0.9115101028600083, 0.56887243679022, 1.1705536098531302, -0.2538302183057656, 0.8196195719918496, 0.9398778957993704, 0.5246251066390581, 1.162272907758132, 0.0018277334132567585, 1.1603404034948472, 0.1764705275304869, 0.35656143280267594, 0.9141877949032193, 1.1929743213430606, 0.7347463279649589},
    {0.04134958611436798, 1.1231059806433519, 0.5731530857633651, 0.7782153693596152, 0.029359359345433433, 0.8510669153183682, 0.9286518254102968, 1.0867236745276834, 1.221422727865854, 0.009820487509630995, 0.8382288835106525, -0.3971429243233703, 0.5818669603145079, 0.9300982190581426, 1.0386468840177725, 1.0544350452065272},
    {0.16283551329357457, 1.0768186402140314, 1.1587512767050647, 0.8873164348451897, 0.18153563518922194, 0.8089385648096743, 0.9947908713433047, 0.5774126660430449, 0.8125561485050592, -0.0025259115427869808, 0.7650440225008658, 0.13812088736350314, 0.7358412451515328, 0.7619344341970404, 0.8384446751504512, 1.154592364492058},
    {-0.16126624670364248, 0.8591158070767027, 0.8092252956906374, 1.1183142908265429, 0.28114564522205765, 1.000144066684197, 0.7787486655810972, 0.9584148218312526, 0.6025721445166744, -0.26910905129755697, 1.1910229875712601, -0.02287720254094777, 0.8043765025477828, 0.5590085483094539, 0.7222027905889279, 0.708115628336325},
    {-0.21984890428184584, 1.0055616528077964, 0.4975394022603219, 0.4678055283540102, -0.3116797369006402, 0.6487527378244241, 0.9552919526579656, 0.7989643470542389, 0.5641356110490082, -0.2081627217891911, 0.3754766632216802, 0.3222317797393038, 0.29346031271825945, 0.4366101524622116, 1.0312472105288868, 0.4383444576194432},
    {-0.012831458057635352, 0.6577057282833524, 1.1394919299178399, 0.9028174686986574, -0.169369258999491, 0.7898049222445395, 1.129159733075484, 1.069927595720978, 0.5427138151316726, 0.13124934223052334, 0.792018529101695, 0.0060978250567843475, 0.5939292981583004, 0.7046576809295358, 1.2027799513295498, 1.2255589193926937},
    {-0.3395035168203977, 0.9335473644880797, 0.8429878059276776, 0.7796038487704342, -0.2741449376221829, 0.9632603100281295, 0.7214500104470587, 0.7766575557022508, 0.6442233263421914, 0.16985866459553733, 1.2347609597412497, -0.07222169823774838, 0.6640722037231779, 1.1066393675536628, 0.6102338954559335, 0.9957322456828303},
    {0.2432297040466084, 0.9561714919193073, 0.938406639572773, 0.6552250119369797, 0.2187350766930174, 1.1717072797776689, 0.4459613879050875, 0.7815025118405404, 0.5323893308504026, 0.13139800998597534, 0.5306531828749893, -0.00016962840051239068, 0.6084843187292283, 0.9574403118512422, 1.0751531490264807, 0.47413196287092},
    {-0.3504459263490624, 0.9596496997746427, 0.6585883893915562, 1.2436476354440429, -0.3395893789041492, 1.1259487466384177, 0.5882472655647264, 0.8349656166443624, 0.867039327340762, -0.26681723901261556, 0.5868900448020267, 0.1007489576221711, 0.538509665821762, 1.0548599002859291, 0.9571266284906766, 1.1742672785591117},
    {-0.2128873497258112, 0.9365346581566719, 0.56296994447637, 1.1249094441848158, 0.17608527596932863, 0.9096909632108433, 0.756663093244644, 0.8819340841609319, 1.0374170317874694, -0.14434494269315634, 0.6349554277721344, -0.2759834535242032, 0.6292200919653188, 0.7948179110083264, 0.9367128124536455, 0.7201122038601946},
    {-0.05682989890787466, -0.09288063612953361, -0.13499465385104079, -0.18468541113410522, -0.24239442750069115, 0.2242260936136222, -0.3051797935130474, 0.019020880481917617, -0.05087847117095197, 0.00231463674306608, -0.20527224843980865, 0.053265574583303124, 0.08936898146058192, -0.016566715437202204, 0.17112385694441545, -0.005844904260454593},
    {0.23227632738370507, 0.5997466321499527, 1.108454932064209, 1.077588489209903, 0.0917544018559561, 1.152440488227504, 0.6346537392023173, 0.8737776000299052, 1.0115448210571658, -0.12553416645138923, 0.867413134038892, -0.021098345693053654, 0.356096943929072, 0.8333648205847395, 0.7129420722659374, 1.0036600144388341},
    {-0.13124446187579397, 1.1153740661963072, 0.8564671673151182, 0.6665899751623768, 0.09117430315534582, 0.919359124819368, 1.1529180004262796, 0.9312419096514766, 0.9566047595150096, -0.21543866702912645, 1.0934981092487341, -0.2575044776785906, 1.0161648388002287, 0.8510980796839451, 0.8801961903065776, 0.794201499150767},
    {-0.33683474266165764, -0.013998413455753332, -0.14498589633944234, -0.20969318121104658, -0.05393043610063001, 0.0930372371515441, 0.273828163924341, 0.13089366052132737, 0.02243753576129062, -0.11465641417303157, -0.058637924470550475, 0.2885161095797897, -0.1919283741518847, -0.09008757281319955, -0.01367654496266425, -0.12248757872031765},
    {-0.34346708687890015, 0.6502085716738067, 1.1796717192675434, 0.9170665367679044, -0.029455195654858435, 0.5307774761043917, 0.9234037709021187, 0.3585233342038431, 0.5168897273212365, -0.2722804522489731, 0.7554957926981292, -0.09780574982776387, 0.7453403405151733, 0.5769425057942181, 0.7459698569494211, 0.5514941207250176},
    {0.17528565302561752, 0.25392455672897923, -0.09335721581775697, -0.12611535072515279, -0.20748024219158498, -0.023967690449383995, -0.1805308566097888, -0.21840833587450667, 0.3147938806367044, -0.20245330530044847, -0.1233218269857075, 0.15973799590479484, 0.12790261706860725, -0.17133618338092088, -0.09293323652711402, 0.06612938252067399},
    {0.18063188227741575, 0.6993060480281388, 0.728615593816571, 0.920315513835323, -0.32373456049106425, 0.7793712650375981, 1.0525371468080222, 0.6859166054790262, 1.0268127782743717, 0.14984718953311577, 1.0626283336709277, -0.3145928879762247, 1.0252579494185823, 0.588371367346557, 1.2040353060405702, 0.5794526694755876},
    {0.23540986166146524, 0.6934836225051545, 0.9982299505815316, 0.8523563303052427, -0.1758465547848973, 0.7217926419626579, 1.0063595566435204, 0.6565382216805027, 1.037285122083589, 0.12643371165870426, 0.8167812678583216, 0.24610508253995736, 0.9585879579448605, 0.6874824508104034, 0.8538780399408068, 0.8291441802736224},
    {-0.29061848392269607, 0.5508768382275503, 0.5760198278899171, 1.1087313474766156, 0.2120515795840827, 0.6241226748178152, 0.7499732926164423, 0.9360872391367232, 0.5311685977193562, 0.09754093696765379, 1.158474113899138, -0.09055219150879913, 1.0238919007358098, 0.7566578497278441, 1.1034195197951628, 0.6362915481627125},
    {-0.23952078384112707, 0.8312888803199533, 0.8836736312947213, 0.6264617728999575, 0.1584668343549605, 0.9448199416050763, 1.0917145501026597, 0.5665687081998847, 0.6422067486867085, -0.326337197234239, 1.2038216505026804, -0.1937612172266934, 0.7565445421540112, 0.8488755066268087, 1.0780754745511, 1.2295579774564716},
    {0.12635674568943964, 1.1872086958042634, 1.2098605262905306, 1.108556566711255, 0.12054387114555054, 0.9020982471856023, 1.1059508120548631, 1.0412995375099652, 1.213557382464243, -0.05007513261740684, 0.7802257134917941, -0.019232292852015172, 0.8265494404165065, 0.707963073066877, 1.1876541921259853, 1.0874418252193956},
    {-0.2225356100193981, 0.7974424022551532, 0.5743208553467519, 0.9554345441194053, 0.043269218206072324, 0.7570711974701677, 0.7063122761748646, 0.9926898353105861, 0.6869415576518526, -0.22317045669986757, 0.991880209787316, -0.3383354473829341, 0.5251605075149738, 1.0929459352439794, 0.7155168026972414, 1.0431327888683095},
    {0.17672387432944467, 1.002725516259603, 0.7411228367216143, 1.095329670228762, 0.18717342968559472, 0.6366635343346448, 0.4638299519122896, 0.7485121230325334, 0.7476641133503735, 0.17992018489023548, 1.157616775030259, -0.08837462306519128, 0.5384347536261919, 0.9466225295666402, 0.8785839503643837, 0.5113828977704233},
    {0.11739157044223693, 0.920291068702769, 0.8850372089340209, 0.9842651801266978, -0.040567953202512226, 0.5284147289573194, 0.5428385758322394, 0.5468205641137268, 1.2135781602230602, -0.27771287435749464, 1.1740074525249702, -0.3056811063923014, 0.44040330996757754, 1.0008577517769213, 0.7814889724849715, 0.8636257987105035},
    {-0.1007310708747968, -0.038084406799943356, 0.15465967636819927, -0.2158125367674081, -0.015873636804068156, -0.05985968605365241, 0.0358671744837888, 0.2878992965033275, 0.0675901348963847, -0.21062113521948636, -0.2684943998947084, -0.3653684673679438, 0.13080062250071414, 0.2066458358542119, 0.125809441813043, -0.2622825322043554},
    {-0.23387148800224472, 0.8059814514641556, 1.2190651254463898, 0.9104832713605373, 0.31760458437311045, 0.7341168918475159, 0.722026390027113, 1.0411034666172017, 0.6996863892374169, -0.1770537412774621, 1.0760496373351631, 0.09764459393848746, 0.995821812409267, 1.0757016163003927, 0.6979349254212615, 0.9083017302804995}
};

static const float b3[16] = {-0.02765335003935572, 0.6281275345549511, 0.6484049719315959, 0.5748319302094381, -0.018234938188543166, 0.548136310242782, 0.5787981498349835, 0.4982741020349973, 0.5992385286558864, 0.030711634451124497, 0.612972237502885, -0.04899811096718092, 0.5602110426916469, 0.5552322280090517, 0.6592109848687873, 0.5775233393589566};

static const float w4[16][12] = {
    {0.18244473843119866, 0.13733309973539254, -0.04788267419526073, -0.018682172549233676, -0.18174489600915372, 0.34651786532504425, -0.34001858837203386, 0.3666617767474037, 0.4216211870999031, -0.21852644635795382, 0.3277751678484587, 0.3485005910239573},
    {-0.43535548260847956, -0.9047610009235189, -0.46109385013469156, -0.9045136611409326, -1.026553267974166, -1.0769732678838007, -0.4079419968581258, -0.7702329535185092, -1.036857787421389, -0.928044283685661, -0.5684972682707025, -0.7232973574564984},
    {-0.9404138296421357, -0.4014203533433802, -0.5788704496990543, -1.2239237882511569, -0.8135744774257242, -0.9003545310655913, -1.0799836796598024, -0.3284872737620996, -0.6225373412713175, -0.5767790461773679, -0.6732848226809351, -1.2050697197371367},
    {-1.024546047014434, -1.1369018059354692, -0.32376429998940276, -1.0845889967862772, -0.6970123282117964, -1.0302742552934068, -0.45399720406621485, -0.5043687642445558, -0.24776971133097372, -1.0550890199690546, -0.7097417677912375, -0.7775332999794449},
    {0.24793082480907105, -0.005475744885351819, 0.024631975083185466, -0.43822117108293485, 0.045733921051180834, 0.32815796482975096, 0.24476565137046397, 0.41269497565712476, 0.34836146146948194, 0.11549146638199673, 0.24256157565701, 0.12274761926883028},
    {-1.1716659067508775, -0.9497240017384156, -1.1029480363945132, -0.9449693697868728, -0.5208860481677638, -0.3900411680872356, -0.866992982102528, -0.966681558112344, -0.47364801619982977, -1.0080051133000043, -0.876477437664961, -0.842034841101345},
    {-0.6461728654117284, -1.1206939622320333, -0.42128073422992585, -0.7947499349088551, -0.820718510353617, -0.4480936767977541, -0.984745706553567, -1.0192151982782012, -0.8102226939484067, -0.46949013642425375, -1.225193134828296, -0.8437555424829084},
    {-0.26195658714233183, -0.27833725745191235, -1.0062595803525456, -0.23150454350441121, -0.5013088679764176, -0.7688273767414369, -0.678337322989541, -0.20151755737908328, -0.31215494273343614, -0.6405692214988881, -1.0641386711364988, -0.7009579336470568},
    {-1.0952082579552214, -1.038097989620013, -0.8708106282556579, -0.2945647161861901, -0.7142477824502477, -0.7966327131975032, -0.5725747425389947, -0.4150483510121389, -1.129927658321938, -0.44417790789779726, -1.1136116931849485, -0.8121218889952814},
    {-0.19730005228823919, -0.1897490430779291, 0.2817290664431067, 0.12444826837809107, -0.46714451263612805, -0.4490139946358873, 0.42237441586344376, -0.248461075753385, -0.40566159230396975, 0.237316346846272, -0.014446336563305956, -0.010109670183825987},
    {-0.5935474812955237, -0.8165870014124272, -0.7985274766735462, -0.46475323053403905, -0.7675877448436906, -1.0570400095689305, -0.3751161484217876, -1.1360974119130371, -0.7502472441055701, -1.121442237939602, -0.608832012772212, -0.7429447567461311},
    {-0.19489832194109677, 0.3111182833729512, 0.10424204130842031, -0.18663499692969424, -0.2794382751360406, -0.03793618234762988, -0.17542657904763495, -0.010369076493012963, 0.4122353184876522, 0.3524386516559756, 0.17363353239738305, -0.23560594339272636},
    {-0.8654832394823196, -0.45110729264543964, -0.8444391425247553, -0.651214826087664, -0.6691019450646328, -0.20189401899825313, -0.3933970546454872, -0.9344605350314101, -0.797808945638324, -0.6076853120109491, -0.3459510245648307, -0.18922350253520098},
    {-0.644854400260215, -0.6748282058291867, -0.6336298582551317, -0.7228452655536078, -0.6607928029330359, -0.32738214675278476, -1.161075029810503, -0.6230826765828772, -0.7781298231181456, -0.9515198102224937, -0.590544670736593, -0.7865309876377169},
    {-0.9180311560306179, -0.505593159668301, -1.0420901887002778, -0.46666934250352865, -0.6718873212492474, -0.8089668206384067, -0.8800785719269617, -0.9636101144213748, -0.8107740245755647, -0.5289473264874838, -0.5214091539742344, -0.7812441726251055},
    {-0.6464030542623139, -0.5768745004177769, -0.9689839654501009, -1.1264298412162599, -1.0883729266104423, -0.9655895696439414, -1.1054142779156333, -1.0903878543687924, -0.8634204009150791, -0.5919977139070596, -0.6449158645788762, -0.538995495192443}
};

static const float b4[12] = {-0.34239105400025943, -0.33661306892764187, -0.18436562367143886, -0.3037204045340271, -0.2538961862214911, -0.19497505807672294, -0.31451283233033167, -0.3145854430542702, -0.2625123968339501, -0.23712503788578682, -0.32433325181163436, -0.2116100822150149};

    // Input Layer 
    float z1[64];
    for (int i = 0; i < 64; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[32];
    for (int i = 0; i < 32; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 64; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Hidden Layers 
    float z3[16];
    for (int i = 0; i < 16; i++)
    {
        z3[i] = b3[i];
        for (int j = 0; j < 32; j++)
        {
            z3[i] += z2[j] * w3[j][i];
        }
        z3[i] = relu(z3[i]);
    }

    // Output Layer
    float z4[12];
    for (int k = 0; k < 12; k++)
    {
        z4[k] = b4[k];
        for (int j = 0; j < 16; j++)
        {
            z4[k] += z3[j] * w4[j][k];
        }
    }
    softmax(z4, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
