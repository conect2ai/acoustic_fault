#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][32] = {
    {4.344182139881554, 3.823621128319242, -0.20234422641062844, 4.355555233731995, 2.9824411588718776, 4.336908757920298, 1.024677117862136, 3.5103863498250485, 4.705468846880768, 0.014951334736060177, 0.34364533906711614, 1.3128418631678125, 0.9681700070601391, 0.5086727855787411, 1.1399357329086766, 0.11808330151719514, 0.7886562126154723, 1.6190412503933054, 3.7214464472397055, -1.13640286625533, 1.584244855909476, -0.2905807160326019, 1.4289943440657158, 3.676502039378448, 4.24106796538613, 1.9123575277089588, 1.1822295546341521, -1.8469271118885682, -0.9448961062020321, 1.007676700129673, 2.1347012253488598, 4.206135834524025},
    {3.5130865353113165, 3.1845436579860227, -1.043935838486896, 4.105185958957473, 3.6945817016370452, 2.844937056570898, -0.05965622526804812, 3.3515597346264325, 2.657266965065872, -0.27094508163379644, -1.4706991076662124, 0.24899461098702622, 0.6918997509256605, -0.4726493664670005, -0.41618234414900174, -0.90850698094842, -0.9251940228019297, 0.5850761461529468, 3.1501417359850916, -3.0663300129005173, 2.070298752158345, -0.8313086265812692, -0.20839503641309323, 3.156674365517856, 3.7517569269232767, 1.0112217237542296, -0.5942689878919908, -3.7678091449380067, -3.0835294272179548, -0.06343266944005205, 2.7442821970465614, 4.262669808103366},
    {4.173748085535987, 2.854995945242938, -2.3711595102663248, 4.865583861942702, 3.787437760161875, 3.0874728786347383, -1.4109977359316022, 3.9067212552683235, 2.143685098908631, -1.602589917686801, -2.352697672698503, -1.1510403608408986, -0.935789498234603, -1.3037741976785397, -1.6267565668699975, -2.0268789673857373, -1.4837543006247682, -0.7146975181783981, 3.8942004127945156, -3.8204633923554896, 1.7206407839623297, -1.2420126650176664, -1.310705401655249, 3.83282914999414, 4.646761393718832, -0.25016795689231414, -1.7787739481393094, -3.608803064659699, -3.5042170518329065, -1.5589963570106384, 2.850719118281904, 5.082491070063627},
    {3.5440442339212264, 2.17237357675397, -3.8126475481328415, 4.324951766601426, 2.5274334869541604, 2.4384329849161723, -2.8156485047927813, 3.0791758204070394, 2.1072234626390496, -3.662561711463216, -3.857646651969486, -3.1054111655099974, -2.9331311830809397, -3.221439448059675, -3.7307687502936324, -3.9099211220516272, -3.698236269890355, -2.399025179756446, 3.1099196691722293, -4.659058169223584, -0.45320828776341754, -3.1475330289060297, -3.296335937134217, 3.374987604954896, 4.038408798671503, -1.787409502937945, -3.433198357288217, -4.912939623014698, -4.808995301154264, -2.9198083205545964, 1.399071837180409, 3.768681406409749},
    {2.6504487662080827, 0.843516473475534, -4.663873682144854, 2.935957855485331, 1.5576148204315021, 0.967261709031575, -4.138125134807847, 2.724259994200524, 1.2948151611271466, -4.715361114672174, -4.380975850150873, -4.40259604465376, -4.052898898872494, -4.424468866550144, -4.673633427920008, -4.533156899569539, -4.3335484123458015, -3.6385817318852895, 2.4419470787930715, -5.04475748616612, -1.8640846698740288, -4.308922428580784, -4.363519187809527, 2.757019660557777, 3.2274901680405916, -3.3954281786221, -4.269892086418817, -5.178915209928136, -4.88173099434, -3.997305390412223, -0.13297864316982755, 3.0164936953857855},
    {2.2694026049081337, 0.3101356661971617, -4.282014827422476, 2.162200176436221, 1.0416783642165797, 0.39029241564782785, -4.260738882215914, 2.2168608745926948, 1.100170498941664, -4.486974530493693, -4.553344955930775, -4.327215263547224, -4.153037969068424, -4.439755127028942, -4.377253915076972, -4.60657725700977, -4.587405780332188, -3.788229119246381, 2.5149875080248405, -4.923856162859078, -1.965504194693337, -3.8839322665126943, -4.662260208906574, 1.7881808818754634, 2.601470287158484, -3.8241083701090064, -4.383017136514499, -4.868812343120511, -4.9494612256750115, -4.1194034746766315, -0.6514977427490055, 1.7273371766117358},
    {2.0750339676301124, 0.30593734930236205, -4.555043153623174, 1.1816105888631547, 0.2603718179926701, 0.06808136469695562, -4.134523404365284, 1.931316659694251, 1.2880517863406717, -4.588862631625878, -4.301801411851369, -4.065688966528193, -3.469248740581287, -4.404048186094192, -4.329804268957032, -4.513362468520023, -4.439990842541352, -3.7167018571774797, 2.437242884734158, -4.822606026808406, -2.210263090932567, -4.309175094821239, -4.2802474956102845, 2.0587453280576917, 2.238400945857353, -3.572930482065335, -4.010061229325233, -4.878565319009499, -4.788322968311351, -4.142998728406585, -1.0366687903711467, 1.1503099168374131},
    {1.8248859179334458, 0.21629048950564636, -4.386185709671234, 1.388142694336496, 0.04488190147619597, 0.24235470945854826, -3.9967605593870514, 1.717917113329522, 1.5360404190968484, -4.447455455529929, -4.339308007059834, -4.243938313754652, -3.9372087095862516, -4.205046243428788, -4.627673854029511, -4.646388347924261, -4.738956742845449, -3.8287272552000102, 1.8123222812643436, -4.964297519208165, -2.9281996260662138, -4.386720805502969, -4.4964789037653485, 1.4164439458362592, 2.1089068134923994, -3.72816282838779, -4.3058773463572, -5.31592768865515, -5.175201355103855, -3.913042533839326, -1.0249742786878615, 1.1841015561116206},
    {1.4762017856134333, 0.5187334987728132, -4.50994842492652, 1.7480330870868814, 0.19869295101702805, 0.34335921786114554, -3.90931823048138, 1.1831956483694939, 0.7402134635562713, -4.383759354107754, -4.136721660042305, -4.33106098689751, -4.0501030825365945, -4.227392399079647, -4.677413752238981, -4.755731455932922, -4.587792249911208, -3.6936692474056976, 1.5428978300249596, -4.924375467501784, -2.8535862362831215, -4.446988355259629, -4.561808560528725, 1.545146995601949, 2.1049901270492306, -3.7360542198508693, -4.299609056502178, -5.678758277417638, -5.000993617986124, -4.056641308033808, -1.0686710497478045, 1.6132028318705611},
    {2.3643623429424045, 1.0878241188656217, -4.232891149138372, 2.7096451981461973, 1.492105719104585, 1.2433262663707132, -3.77535465074421, 2.1040058816752385, 0.8919699637554931, -4.202192162561265, -4.271489240186143, -3.822046449211067, -3.624076358486675, -3.9580232217290328, -4.15786651723856, -3.988651978752014, -4.238968951952299, -3.2569829867798137, 2.297136803668503, -5.0814728496089385, -1.6668777797227587, -4.040721352171053, -4.039280620032168, 2.237321443168419, 2.596679291087669, -3.178681771568815, -4.053641656064357, -5.4291911033406, -5.266002797635653, -3.58037908827072, 0.137314171022094, 2.8022647215951184},
    {1.623360948413806, 1.0908098224481915, -4.198719751757967, 2.630061135385651, 1.6755078246167092, 0.7249825376832991, -3.491526926658911, 1.3538243219858996, 0.270964160375235, -3.605030113036386, -3.994618224405655, -3.642900829992067, -3.356780582925798, -3.7886891165939915, -3.727321117585119, -3.939683718316498, -3.702196366703276, -3.1098002828957676, 1.702985385245453, -5.008642245252113, -1.3350771730397364, -3.5517985665712257, -3.678685148173509, 1.6754671952481, 2.1923419212522233, -2.832547770483596, -3.7926972431084165, -5.087116299696718, -5.044837526868986, -3.429866525629596, 0.6609339150560283, 2.8905846853599813},
    {0.43104421227269063, 0.0833445466683964, -4.184928863026934, 1.7088991545179242, 0.13563953989739314, 0.2865638719019139, -4.02048064347425, 0.9785590772908366, -0.48211512449517635, -3.8013376488358745, -4.080092484658599, -3.983802857694909, -3.778705676367193, -3.9447892611322826, -4.1777855168913645, -4.305865438482169, -4.277561027065724, -3.54716336055119, 0.9391754775564978, -4.392554465902503, -2.48166502039327, -3.9835486959866664, -4.052086071493427, 0.950226991844012, 1.3114333702106338, -3.5002069215196774, -4.029979714361136, -5.115048039923456, -4.822511539922277, -3.648299115352042, -1.2477500440189817, 1.5794233300091747},
    {0.9935987609496555, 0.4967473461244482, -4.213097737741168, 2.2280481047980225, 0.7899003672162457, 0.9380063801781894, -3.939121753573032, 1.4954612370025178, -0.18068537272092433, -3.8015406881062153, -4.227601755790461, -4.079675144945123, -3.8854762204205167, -3.954792263813917, -4.081672249868449, -4.089252345827612, -4.287511485023681, -3.3473913792925143, 1.5803211933270334, -4.403881249212745, -2.687273298792339, -3.6340828220514583, -4.047796193706365, 1.3804291203505865, 1.8640283911641375, -3.0386176956475905, -4.058058420301126, -5.038430355376387, -4.982601878627372, -3.7074311612109443, -0.8693018241984133, 2.320325532284639},
    {1.191079959047548, 0.004715718837967387, -4.246670461401971, 2.109686424813444, 0.6774515648546787, 0.6423484373584096, -3.93670672361627, 1.2259513976652816, -0.643970032039973, -3.9628493418859616, -4.154718899266554, -3.7814940342899126, -3.6277746601799254, -3.88431360668095, -4.007326709369837, -4.110669824880262, -4.204412523290638, -3.4039117295945833, 1.2053483195463142, -4.491296367189865, -2.5030362749995576, -3.5457913548720232, -4.155512717100255, 1.3570518217858965, 1.7163482274197646, -3.374644768724361, -4.238136525315783, -4.884072003548915, -4.7411786206854405, -3.548187011363454, -1.1778363539924548, 2.2283501891505146},
    {1.9815832875622084, 1.29600457500133, -3.672392127679281, 2.707463399698563, 1.174212406899757, 1.6691548117474535, -3.4237939131269703, 2.401249791605602, 0.38262068864663085, -3.715738838430508, -3.6763781430395497, -3.3411214245850016, -3.2992752036050907, -3.7650706911879714, -3.640696863316096, -3.91394058062207, -3.586838229903849, -3.045683198398336, 2.079406251126143, -4.811610804752731, -1.9945923046656056, -3.4560279234323583, -3.6539303012099227, 2.5842492888009954, 2.7226541731693925, -2.809766328320407, -3.495795376824893, -4.770768991531767, -4.495759508032054, -3.4606578358660536, -0.4340335019349933, 2.9507379503492674},
    {2.493753270309862, 1.185854875024283, -3.996557359736931, 3.2040937782646934, 1.4501396581493418, 1.2126308994200643, -3.594752795773815, 2.4187095868450057, 0.47761904728272575, -4.049782480382137, -4.131210334651749, -3.7202526653969885, -3.6517684231373333, -3.8534700364226926, -3.8650616171007646, -4.017276274964097, -3.9453432049186787, -3.5135628602596105, 2.469539843686245, -5.2207738002755795, -1.8590565382953583, -4.2300710923106735, -3.944934949758307, 2.5435784221500564, 2.834001581404536, -3.0857118585350953, -3.878643752100983, -5.252433474062423, -5.1404437708073525, -3.6686490773552496, -0.030437770322811357, 3.160671282724764},
    {3.0545449954982797, 1.885940748536821, -3.7237926767263057, 3.745970235535721, 1.949790761908665, 2.302668396018105, -2.854219210113573, 2.81742374660343, 1.2237174585142772, -3.6152240992484943, -3.718225287095342, -3.191760555071462, -3.2022439844873687, -3.9886144327803885, -3.556449869809307, -3.9221640930184654, -3.9855476679165753, -2.7758078411122504, 2.648553228113212, -4.81864180547849, -0.912336338339015, -3.3779418751706873, -3.5878087309805355, 3.2079832698849393, 3.6748229076127803, -2.71260562951847, -3.4128759792175396, -5.19843951835211, -4.949415149815836, -3.3353165381294274, 0.6671831031437495, 3.7730463089293673},
    {3.8337640812447, 2.524183143818244, -3.0277559817049, 4.713310240311283, 2.4837110399402866, 3.2659559223949843, -2.380698197377421, 3.4651085762059313, 1.8937017048678986, -3.0921926441786716, -2.6283565170231458, -2.763633337774382, -2.56533461279606, -2.972190302385629, -2.6617636379519336, -3.1144134063094353, -3.250283289022272, -2.005097786040318, 3.3061906944447084, -4.059379866049847, -0.5545732529878528, -2.6188211927389604, -2.789081601791722, 3.949292509249589, 4.362381527008124, -1.7195745146331383, -2.670762419491438, -4.1181435522347405, -3.9638873909454566, -2.63789276536307, 0.9214255036620553, 4.491178337962981},
    {3.5500427411852895, 1.849335490524014, -3.304349690233038, 3.8701268116384635, 1.9256087738016565, 2.5557204745406468, -2.91261873573556, 3.593312532410151, 1.5386725502345466, -3.5125030611861945, -3.1638973360933798, -3.234029273856761, -3.145371410535716, -3.2177404675699854, -3.352211856135078, -3.465340982965021, -3.407930415897088, -2.5675781383197234, 3.151266572310441, -4.122440260202858, -0.9288018270388684, -2.494242233183137, -3.114602706471297, 3.6819682666083002, 3.902599359478168, -2.359229903035561, -3.115345803968612, -4.198450229597091, -3.9589741590951815, -2.648682423188619, 0.15240520903730728, 3.8897800385589107},
    {2.9590355561557, 0.9186747720651868, -3.8533879119412293, 3.812088047577466, 1.6581404424416608, 1.8052141136630173, -3.4791229995182307, 3.190285213126823, 0.5732178985824297, -3.817346772582176, -4.060952026461515, -3.6080688320387617, -3.533690757180247, -3.9410706249731438, -3.9492344004904805, -4.396310099939091, -3.9046830264424592, -3.1107921743987026, 2.7621747098456377, -4.521135556619613, -1.386494493123476, -3.2993405341666366, -3.8103429811760305, 3.1170481632925826, 3.524033202436311, -2.680474797408945, -3.882310319706554, -4.828326287581352, -4.823106481271109, -3.6333880711462867, 0.20181845287689978, 3.619393442311757},
    {3.0435627698688186, 1.125339626262722, -3.765662390734352, 3.994857072229887, 2.076766159563426, 1.671893214184792, -3.5281437186710085, 3.194555920976054, 0.5309538012214304, -3.40850686253447, -3.777024205026718, -3.4088790693060926, -3.4027711607895417, -3.642775915353047, -4.007729045090334, -4.0870714143654645, -4.061872990859384, -2.9140374202408172, 2.6273732855780803, -4.829212465041143, -1.249582041944469, -3.1660270949000693, -3.7816276757490632, 3.1660536019632466, 3.6780852824742243, -2.45388061306343, -3.370253379722544, -4.934252006854182, -4.8039931615584734, -3.396859025445718, 0.481867440443008, 3.8797698425398575},
    {4.3615458291407965, 2.537837491086497, -3.2418667191846686, 5.180831575235955, 3.08549823918528, 3.4014902942128926, -2.223231969578236, 3.745646989872597, 2.2591819403001048, -2.4657386165758943, -2.887862084871004, -2.118715962494974, -2.3267408602719652, -2.4060562920657036, -2.6093208818389857, -3.139725716134018, -2.8389451329058515, -1.541475497775199, 3.7989553256588624, -4.159918112525907, -0.18206274354054153, -2.205346312210856, -2.0522540061499863, 3.9406826290946, 4.747037762482491, -1.2725489194713466, -2.5316783152984774, -4.498103852390603, -3.8101509717543864, -2.271477586762118, 1.6541080695414543, 4.993246654213874},
    {4.446910635398274, 3.526230932277268, -1.9922882521051475, 5.188432325875881, 3.368710576041799, 4.255605172770383, -1.1999248270753886, 4.254660559242876, 2.849652201105949, -1.2905109942370407, -1.644484262893819, -0.9109983480503197, -1.0544192356974802, -1.4762724711166963, -1.0673289148836402, -1.84124562309591, -1.8403079079303004, -0.633467142972567, 4.123882312128783, -3.0671228095556318, 0.741123840030725, -1.469818171879458, -0.8312241663500981, 4.246528566075353, 4.862584874214129, -0.10485507009252623, -1.3949040683168064, -3.7156468703909207, -3.056148880375006, -0.7853748185686367, 2.124654110970592, 5.144099950307969},
    {3.947684145993575, 2.6742080910021273, -2.9929249599055705, 4.86004590863152, 2.9352240906485676, 3.341023744560306, -2.2473808349924855, 3.6077439944062313, 2.0092075857343503, -2.223425543830232, -2.7164717599585217, -2.1764315737499684, -1.980627632067465, -2.3575403245931112, -2.4831538292914033, -2.875133755048962, -3.0201363895870412, -1.7652611373727904, 3.0383917305649955, -4.068944677899697, -0.17374878992949316, -2.385322778659009, -1.973917811476934, 3.819741397113799, 4.377575372529813, -1.2711221494257292, -2.616367757434396, -4.549929007076603, -4.012149747614873, -1.9516007790585788, 1.3917150387120087, 4.450190680721709},
    {3.2353107639186742, 2.0186510903771704, -3.0648083446648364, 4.237694944960761, 2.6556407951329004, 1.9608987985552737, -2.8754314062383615, 2.9755210620720116, 0.7485011152739153, -2.833880433882999, -3.137044893785509, -2.9771249589054722, -2.5203390551645612, -2.8827449058064256, -2.977020824686797, -3.450830233638299, -3.448953669581373, -2.673226401867003, 2.8484822192294095, -4.5119268661237495, -0.5010207575499034, -2.6280337396771003, -2.7651090189365353, 3.1803116110479412, 3.883263315319173, -1.8451341704467643, -3.1492741442007803, -4.872629000806226, -4.840587600267763, -2.71558938813006, 1.3018767089438832, 4.510148250151332},
    {3.3180651998724944, 1.6679425830345156, -2.868009849218184, 4.131832293196569, 2.253562695945427, 2.409696045135117, -2.8717433247179187, 3.1949059904036736, 1.1184475516915071, -2.833599291777818, -2.8661382809842038, -2.6443713309265924, -2.5232815029101983, -2.510399943825002, -2.9373855342592723, -3.288056425147002, -3.262272376254217, -2.089427410496674, 2.8751217686539716, -4.077333989499655, -0.5387988806081111, -2.5313836522228996, -2.807954794750908, 3.539089962661765, 3.918792987286578, -2.003686518068143, -3.0942082083513305, -4.812657324388679, -4.2309679837933825, -2.717484111452491, 0.842235477204676, 4.0038122271481775},
    {4.033224059287596, 2.9520828283860174, -2.9059546456833183, 4.712316101917379, 3.2255680850546122, 3.0947428579830856, -2.5705295449172136, 3.6187623979748564, 1.7335152265243972, -2.4156818756044216, -2.658181753489207, -2.2198995137559057, -1.8217933242186208, -2.626237164039077, -2.8041016658334708, -3.1120586811870172, -2.8740651803626234, -1.5911499757022696, 3.8618221298969693, -4.113763677730045, 0.228113188497568, -2.05287202240843, -2.33827498097295, 3.6748608837598566, 4.511780809467644, -1.2732555036536004, -2.5071667491146004, -4.343984831887789, -4.152541032446238, -2.195754128856879, 1.894936763483952, 4.667302166820272},
    {4.173429980154915, 2.7504595177266062, -3.2439683875749497, 4.670277767931018, 2.968805779897075, 3.2552869199599628, -2.5869333155556213, 3.8264894828268567, 2.0462121559500845, -2.969437368960236, -2.9587937945902616, -2.422737043987756, -2.140256184737013, -2.793124648200688, -2.760491423237575, -3.027417378196319, -2.8621186762805175, -2.151270203422912, 3.5857858924080626, -4.4163332461136635, 0.11885183780029544, -2.702292773249977, -2.4767985694145502, 3.7954385581335286, 4.130348448905552, -1.5746461275702677, -2.7563026542630604, -4.801710178503764, -4.391126914953512, -2.3157507576087624, 1.5119618520818645, 4.842206573506907},
    {3.914552914770806, 2.1777106303185376, -2.9771793080494295, 4.639221453944339, 3.1157742539056423, 2.9731272697145306, -2.4640004388546135, 3.399127413622795, 1.1961058687415247, -2.552699013049413, -2.8122281701689253, -2.4668218552053878, -2.027544490814943, -2.8878460214874133, -2.303080170300709, -2.936864866719488, -3.24986390982025, -1.8760475210672445, 3.5183714871213465, -4.630968603996115, -0.024028889993881607, -2.5053849867010003, -2.6151035474176942, 3.4649744828589566, 4.273172717181302, -1.4643754616281197, -2.870261638781731, -4.8503298727353386, -4.327905785092968, -2.264506939511945, 1.6515062977588835, 4.776443776293066},
    {3.3481872539099364, 2.1881476697462756, -2.8442450149959613, 4.2633766891934615, 2.3071232787419973, 2.556428499692414, -2.4373897553481862, 3.3806682784354893, 0.7377734964991499, -2.2974907251634757, -2.7296136685893027, -2.461137763869538, -2.0045984841138043, -2.518335800239516, -2.7718489603790997, -2.8171029644129932, -2.884239023303567, -1.923995095044316, 2.8516715605111385, -4.391118222522658, -0.17620348518231488, -2.175660054636787, -2.3614769247937937, 3.2679228237314843, 4.0598617276248765, -1.045805968423443, -2.7403175508796465, -4.763223546276723, -4.492190829713331, -2.3372394992069387, 1.386835721041714, 4.267956550399399},
    {-1.4085657125855089, -2.3675712864796825, -1.0220314497861582, -2.526821272103645, -1.4446977261632068, -1.8565716987725431, -2.1141295006121275, -0.2571034932683436, -1.7395774571500442, -0.5476590363065776, -1.1785486068631377, -1.7746516986418812, -1.7440893464508196, -1.1282307800732736, -1.487840829527011, -1.2151367676326676, -1.2852696946350461, -1.3158288806596796, 0.17693941192623575, -1.1616769312272959, -0.909649529661261, -0.20744322370546697, -1.4908480073588883, -0.680082467599523, -0.5463991328868122, -1.8270174075319308, -2.1594532046568062, -0.1100283901621466, -1.1556208076011105, -1.7646652770382638, -1.7229122117231999, -2.075375038332843},
    {2.0984807928121105, 1.7738380745793019, -1.4732684481422587, 2.388594379547016, 2.071513971948504, 2.1582560148607466, -0.6728910343248252, 1.7277394184200068, 2.209792527953074, -0.8927068770696113, -0.45545801261538055, 0.018975439669126116, -0.14227742372821167, -0.7332461144509502, -0.07092358847876783, -0.7189352827992502, -0.42529539830977114, 0.153131902525734, 1.7490500024124362, -2.128840437040571, 0.4976557475698445, -1.4274648548620819, -0.2184170450544712, 1.7344596444229672, 2.2061994453422917, 0.20570262000687567, -0.24299418787753774, -2.8740731820733836, -2.4777578739335624, -0.3361758767351188, 0.7777611005927125, 2.2125130679726532},
    {-1.44500989065777, -2.586662354192679, -2.6598926048588263, -2.1342400363094427, -2.941052221537975, -1.4813109812081884, -2.9867796677420126, -0.6420460915261642, -0.31204498833223726, -3.400486826346634, -1.7537908858874778, -3.171556643913667, -2.815527288056003, -3.1281611118595833, -2.972691328223714, -2.6811319020801467, -3.058464076571737, -2.8433288518997646, -0.8534253834453684, -1.578448807091185, -3.1669555439812926, -2.7513272957389656, -2.8581741176839857, -0.9237837498792447, -1.425354709065781, -3.197782536356188, -2.5220970802794396, -1.1803184479467663, -1.6035628005352707, -3.135041228255786, -3.415975373627975, -2.8247889037801426},
    {-1.5174380630289603, -1.743877927178918, -1.7940256034495925, -2.0456581618486673, -2.719975767423756, -1.094402599129291, -2.1518026986088885, -1.2246468292587986, -0.18223728141252196, -2.67623553438291, -1.5645693628191155, -1.8166688157008035, -2.316418617805315, -2.39524653294288, -2.0734429854290104, -1.96416447595792, -2.107125031276236, -2.2422845058721137, -1.384903201678501, -1.0338322703847773, -2.8693152790192893, -2.5974136843768316, -2.064135551404445, -1.3181792661677707, -2.052852835741646, -2.556973136357629, -1.7620560110168242, -1.0679847955263244, -1.2947830430498364, -1.8347800456363195, -2.7684398170201527, -2.6187996931714634},
    {0.25335126437774047, -0.588393345655672, -2.6251450761099844, 0.1915688744603023, -0.5793014221645693, -0.8225060722428644, -2.7878302108370008, -0.0403489462055176, 0.3760825655898579, -3.119615566473145, -2.4027555778309413, -2.813994703283772, -2.46691020080874, -2.510080497298151, -2.9318569994079855, -3.1338629148351225, -2.7430137983947307, -2.309263689810196, 0.17161907326429482, -2.6838379489357163, -1.946570676022157, -2.3109738990125197, -3.1105579764995364, 0.15172864082377618, -0.21825023933872176, -2.7800966286721245, -2.449595608631187, -2.289478154359054, -2.316252977313443, -2.5121593518799177, -0.9457017215893949, -0.41523414084633625},
    {-0.15396974173577951, -1.2390633911831241, -2.885240201761347, -0.9088683879302125, -1.4752884330664224, -1.2143213963585358, -2.614573121334246, -0.3942094233859143, 0.9801988795015745, -2.9893753405204357, -2.7313395700502583, -3.065320517339803, -2.503176139729411, -2.665699372449077, -2.690214660934606, -2.8873537520679693, -3.0570776106759934, -2.328048523981071, 0.3544490482992613, -2.665138626992138, -2.68850531695142, -2.948645723157001, -3.1159335160229946, -0.6882432252465012, -0.8960126436403828, -2.8334309156180577, -2.453505325596281, -2.17156830890586, -2.4414871672379554, -2.3902296188637457, -2.0791738051842246, -1.0990000572059102},
    {-0.09909301511309579, -1.3654508551749256, -3.0719767000143956, -0.5420067332384292, -1.2909150529105848, -1.4383725048612603, -2.834649353539113, -0.07243651583012638, 0.8027944472619575, -2.9269297301089368, -2.5188068644027, -2.7058902660296025, -2.706506731454739, -2.892576592748904, -3.0604716651074924, -3.122498037411132, -2.902696440331845, -2.5893205982848495, 0.22781398737444097, -2.5854875918507285, -2.7155475840264645, -2.8027192378487857, -3.165197307406162, -0.35862675841604796, -0.37878711749787, -2.5332676452041833, -2.7070950294738583, -2.368476804632675, -2.0527317875586224, -3.025737052243509, -2.0969155811226274, -1.3240037477262276},
    {-0.06356592076257545, -1.0925276176025833, -2.4999141133926304, -0.37459281739743766, -0.6841699984796447, -0.9929412296654204, -2.473859483266693, -0.15744601220155968, 0.48251991291992685, -2.114957011266124, -2.1530030790036094, -2.479215347508898, -2.621513379201689, -2.186564184161156, -2.0994351381202816, -2.6891377107630157, -2.7080159066179674, -2.463386804368155, 0.3304495015528099, -1.6753593350073002, -2.4126484020096277, -2.138080970407482, -2.599379446722066, -0.15809549680863913, -0.3840037566821421, -2.4454088871198465, -2.4752440821041786, -2.085618837977369, -1.7723846239591827, -2.5596422634809897, -2.0169190565346047, -0.5713356972638662},
    {0.020892663998342418, -0.8759653895917803, -3.149215997038622, -0.47749484248477153, -0.6363569432653325, -0.6576824640698453, -2.680065985098739, -0.1458036110228602, 0.939338659410081, -2.9305865005350036, -2.439075732844206, -2.7810949595401264, -2.7556144754168925, -2.674616529068921, -2.777471166933521, -2.892324085776611, -3.0117454672408366, -2.6097382748746676, 0.8144314872871893, -2.8681649572024877, -2.7227999527142197, -2.686165669562504, -3.071146404242916, -0.18160381811818893, -0.06261721657285589, -2.972064388751566, -2.4383879134383144, -2.6478685043164454, -2.363123331345126, -3.258466329734873, -2.5526651304242316, -0.9338076554932676},
    {0.7520937267290734, -1.5236251329236434, -3.2823556782240915, -0.9465776868083923, -1.6317791579705017, -1.3833048915121, -3.546109234576839, 0.20294398793668647, 1.0149982722094215, -3.7183618023799836, -2.9902269695574533, -3.5422454493873237, -3.29651309943232, -3.394755195767686, -3.346128083956271, -3.4832624749972667, -3.4123460318324494, -3.3006663999777333, 0.9317833179843282, -3.5736302807015763, -2.917694593047321, -3.0442134591429726, -3.3490407545023744, 0.40408782330767323, 0.3647134002921997, -3.4080168195175498, -3.3647389259141947, -2.6118226775283424, -3.4648712500904635, -3.2727673410766114, -2.6579518570401977, -1.1558278542955664},
    {-0.3192608912992555, -2.086578367659261, -2.6476762806204874, -1.3676422208344836, -2.2236811011881072, -1.816611115420433, -3.1469798664509683, -0.5211058027982244, 0.2854376418732928, -3.0206546528336715, -2.596364136926472, -2.7289839029453993, -2.7111552068075873, -2.4705800988191235, -3.15350914488554, -3.178212047721845, -2.7045897216635613, -2.729159445177444, -0.06764912525898835, -2.5563190926424775, -2.8026612774225366, -2.565997605148326, -2.5528081279749135, -0.8913844259043933, -0.6614084664636622, -2.984586481840393, -2.7213082404531663, -2.292127997030804, -2.5811479529887014, -2.6907061908063556, -2.470530864672122, -1.9423374091882388},
    {-0.41829867262709486, -1.7837039190426263, -3.0865071418563343, -1.546972672990225, -2.375239198401915, -1.5491252787829979, -3.391685978257334, -0.41015925953762444, 0.2944353173785831, -3.4986221590899076, -2.7362870360852654, -3.2824392935500533, -3.0193239727049135, -2.997062945982642, -3.344867859062499, -3.244587416205075, -3.071264163987925, -3.084990062493163, 0.4078502983161978, -2.6566876482948385, -3.4675850891534785, -2.890400151462787, -3.0824141182050155, -0.9456241378163129, -0.9128225856692542, -3.332342486517426, -2.977154714077024, -2.3690941808893755, -2.5663535330083316, -3.4178796080735263, -2.837439008689822, -1.9912489129646915},
    {-0.2819139059551689, -2.499132355011588, -3.059183070450874, -1.716910781656984, -2.328244883319305, -2.3350711555309047, -3.5420378393640903, -0.6259675458168508, 0.6874447830403317, -3.7084047989495175, -3.2796977900594992, -3.6053589044199073, -3.376968003055272, -3.3739542891373873, -3.5193537995864017, -3.622909827425061, -2.9739644677642576, -3.2154251073183646, 0.2989380173123489, -3.2314634248434766, -3.2877795261608416, -3.3529988675360163, -3.5971261693431984, -0.9330087560577663, -0.7497578214281652, -3.55649790496946, -3.216669876672457, -2.6797018196480957, -2.8740064951415545, -3.275157170890167, -3.1344161154385213, -2.054543010781048},
    {-0.5732908908797468, -2.811845180282153, -3.397024387454905, -1.762551304739269, -2.5542945382288758, -2.604388623837995, -3.679592665992323, -0.9002919050619939, -0.0048642618992959024, -3.8060401932066834, -3.5766128227678213, -3.799255276628884, -3.6858494988151547, -3.548176618458391, -3.6464398006669763, -3.537276557831215, -3.5909622646969312, -3.4838275203827065, -0.012356031031162514, -3.4452539471139945, -3.565156800028763, -3.5347724679278656, -3.5910274219974, -1.1428614549540752, -0.8461276013541947, -3.5592124117201083, -3.4169338473848816, -2.772993703721879, -3.029628899281454, -3.4867777127033595, -3.6145117821812125, -2.4280527859477457},
    {0.2999183058400396, -2.0688313885497713, -3.5903429480432325, -1.510314594361578, -2.2481197670777213, -1.3949704315783245, -3.8538088485678976, -0.28673510124727314, 0.6196760482631055, -3.481304105910305, -3.6700436286920106, -3.8556215908457117, -3.711335382078682, -3.1672897110692606, -3.7977674101926646, -3.3743346126187204, -3.41215616880756, -3.4518288849528336, 0.4900817556729504, -3.014238555298226, -3.14593241141911, -3.0088295995463987, -3.586760002628242, -0.5328653692565887, -0.35699669910183046, -3.7425088182890285, -3.3866162928152552, -2.473818402287627, -2.833432879047877, -3.7937263462862694, -3.001961594257264, -1.6794274090716745},
    {-0.986538788082088, -2.204751710028366, -3.1902172039840306, -2.04923255412061, -3.308569202279609, -1.5297445562198784, -3.213449186284731, -1.113649252694688, 0.3245053008489201, -3.6654038041678194, -3.193683737737554, -3.632695070779824, -3.6021128943539527, -3.808189052609487, -3.2993058172131544, -3.302521949931017, -3.1913395226634114, -3.2330624232499243, -0.4655875536286392, -3.175088190815824, -3.513568229948399, -3.4499596517781144, -3.5517726054877983, -1.2840945593530937, -1.45198918338355, -3.4446701699269298, -3.149602541625664, -2.635824626939176, -2.7418105457415827, -3.388475057260246, -3.6934980752135473, -2.3975817100541534},
    {-0.01135356924019283, -1.1657565159364658, -2.5801824789869268, -1.3026028199387045, -2.685223389382856, -0.5395141554718024, -2.7790526290952724, -0.4261938721750063, 1.1455142655429673, -3.032682020569254, -2.6822148040048774, -2.830656851641685, -2.812133145859383, -2.8413976542649606, -2.5986228001720724, -2.6560575740844103, -2.7259175237217774, -2.885707154477479, -0.0814561485574736, -2.2770278252289176, -3.205608392754772, -3.0409536786108724, -2.7744148348906332, -0.398480866268411, -0.6559604606801707, -3.1888094600732373, -2.4442729798063314, -1.5944312300365517, -1.9819831368384258, -3.005418757096968, -3.1805947602351963, -1.5992724698966492},
    {0.7594463831885355, -0.8400771070822813, -2.442255832603407, -0.08992437189484319, -2.1199694924928463, 0.32547092135371747, -2.1904962818477656, -0.03201344930654137, 1.2700177122063128, -2.888291805824967, -2.05720699356108, -2.4344246587389913, -2.6654015524978276, -2.6474067313454297, -1.974356755755519, -1.7292011262070137, -2.2305773064390584, -2.5435140651179613, 0.32245719584323573, -2.2796476178513316, -2.5334117866426644, -2.3802832339195623, -2.6120501237880793, 0.2906223042788849, 0.1647969081814366, -2.3405793389792175, -2.059116137182819, -1.6312985147864183, -1.7058890748361915, -2.145320803779706, -2.7652059109058826, -0.9476083669693223},
    {-0.6858627675993684, -2.04629137071275, -2.690113368263435, -1.8502840453165192, -2.743961289736524, -1.1687987543565705, -2.848331952984069, -1.1028140368017167, 0.40179117651016644, -3.328374213947138, -2.307707392569682, -3.100501050630429, -3.0657378012096173, -3.0731271633875514, -2.7615784581269853, -2.5784311187334605, -2.746186141298312, -3.197720245244022, -0.525786071853351, -2.088448275782127, -3.315899514387848, -3.2766463522646436, -3.2349630703500942, -0.9176379721614888, -1.3606098278268848, -3.57560214117259, -2.720751323430836, -1.1025778207346055, -1.604748277492308, -2.979523250563988, -3.6016556376483417, -2.505207646436535},
    {-0.5364706435253099, -3.045765772507506, -3.7927985523827332, -2.099929115905912, -2.809169414302215, -1.5158347740246434, -4.436803865717472, -0.48874854477830615, 0.9797366797290695, -4.219488618863431, -3.57511657889574, -4.131501327140015, -3.8902180564737514, -3.4707014932750484, -3.77822606526296, -3.8691655128110947, -4.0126704206132455, -3.8160116968381113, -0.049802974920881767, -3.4668878897391155, -3.5914588237719287, -3.4750214342243857, -4.16892798648892, -0.8584604724105723, -0.9661545693367735, -4.1755044826505445, -3.678038835131836, -2.106674444340749, -2.5631647891746674, -3.9672053654674797, -3.775273493848495, -2.5118779695167213},
    {-0.7701107928067782, -2.6113479030450053, -3.844683315714912, -2.2006317503695207, -2.876146080369159, -1.7653977504333802, -3.9653622420275068, -0.9596125896940083, 0.4264192518378688, -3.9048020061791275, -3.988167043584367, -4.322114240680002, -3.853969608305476, -4.132587000582868, -4.118435521295241, -3.8402948083176085, -4.098560558313123, -3.960707992188064, -0.3164575215178088, -3.7056820659967475, -4.291006881670787, -3.9111812736953673, -4.098505022015984, -0.9464012931461384, -1.244736254433027, -4.0557319136023855, -3.8568218302731916, -2.464780777693229, -3.1198003352955244, -4.06598137296793, -3.4734419133878967, -2.509971754596858},
    {1.9796777259636809, -0.22564222657265015, -3.258386614354321, 0.5931674426135974, -1.5008316780021247, 1.037616837213969, -3.4535768275756724, 0.897790017705037, 2.7949518420602226, -3.6168464553054656, -3.0238781114811877, -3.2302705698962204, -3.1425248218523114, -3.6405657263722087, -2.9286924217019203, -3.2137798282567567, -2.7783520182759665, -3.0456858984292925, 1.5078290980395264, -3.426948657392397, -2.8155132558408074, -3.247370958351377, -2.797941748430504, 0.9729913447870909, 1.2006894124863674, -3.2253275077830326, -2.5497418421442983, -2.0776490451636604, -3.149700304865951, -3.133777576915473, -2.5261983537374646, 0.2275335438125665},
    {1.8675152379529676, -0.27163912255392597, -2.0673948113613796, -0.24929861592550906, -2.532899812831519, 1.517190564628417, -2.2660805087278253, 1.0867990021297191, 3.616033381276702, -3.1870323929507243, -1.7919832239415625, -2.768503485559108, -2.6526038256861866, -2.591022704283439, -2.2309071713264284, -1.7840831047220107, -1.5360567471229556, -2.3786314358583485, 1.9900808811696684, -1.198120582526425, -2.727400507744832, -2.6749636861150314, -2.3349519786388018, 1.2489242783609211, 1.3339342234700233, -2.8262582505448677, -1.5679141795107354, 0.5097863444660022, -0.8464157672898538, -2.4543234876175277, -3.577536098478296, -0.9645038003718792},
    {0.7005863001014626, -2.1380669530961804, -3.247351167225037, -2.229411069252338, -3.5515677480971575, -0.5576269031877346, -3.7766915766750806, 0.05699268709110393, 2.166177911939252, -4.135678537504322, -2.8745561724483233, -4.084155484255403, -3.8713995275327364, -3.753468253478427, -3.471131019000622, -2.8462167214875134, -3.206982821938934, -3.441308989473557, 0.40825883104403043, -2.3957247809621065, -3.949229528622378, -3.513011732655032, -3.727340988992323, -0.12624342639286806, -0.3351284240474868, -3.9678754070728792, -3.194499921654835, -0.5134970820660884, -1.8330444830579091, -3.721863963772915, -4.560768749981217, -2.801355313582565},
    {-0.3121366476854733, -2.235426235639334, -3.748863798106288, -2.033014044984223, -3.191358650688249, -1.2032021099146382, -4.2578779863436145, -0.9516863304162667, 0.9621089702409082, -4.2379017460417385, -3.5414631775746557, -4.474340819458334, -4.012191307242644, -3.867922447103026, -3.7347337397200753, -3.9051219235933434, -3.8372285445736716, -3.854720277822659, -0.07007749762029983, -3.8358533228737715, -3.920659831368252, -3.541505982574472, -3.9029696984833446, -0.8434822113233837, -1.049191821950073, -4.284485716454515, -3.7075062471410507, -1.7072720605472236, -3.028339181077995, -4.357084262867831, -4.174020331975313, -2.5264311099161483},
    {-0.2750883760577002, -1.9451646958937812, -2.473093846039238, -2.160805440736765, -3.777227515948858, -0.20610058571044942, -3.1196763745616525, -0.3894257713609603, 1.9025798006868733, -3.451890087918445, -2.237079598652478, -3.0369670965706774, -3.3719652838292213, -3.454566109809334, -3.0086329620253243, -2.439519918083943, -2.793716626491795, -3.1799957104386856, -0.14333555040586904, -1.3662708249824445, -4.099091508794965, -3.0104719630836025, -3.399297616895178, -0.49203450717225666, -0.7914215320851564, -3.41026467484567, -2.64640922034956, 0.4389778285173535, -1.3624639649400503, -3.341794336129812, -4.527295718160846, -3.142191902393722},
    {1.1508725120546144, -1.468893407986034, -2.802526039326599, -1.0829180458285472, -2.842254554738166, 0.1670189676587621, -3.4281438253370378, 0.526985415276363, 2.381807047835415, -4.096151182258203, -2.7229440796754165, -3.491922887926098, -3.4320456855045025, -3.6562085541830465, -3.397150698153045, -3.089604567002226, -2.970535129356046, -3.1737968194774138, 1.3596732008347954, -2.9134441168387712, -3.632955527434652, -3.2795737488277545, -3.519486034045292, 0.5511801002787617, 0.49723624140514855, -3.4653937571785893, -3.016878779630153, -0.7537022862664231, -2.7212044775595845, -3.488634714715205, -3.906352095566449, -1.7918532518873507},
    {0.5378095246845072, -1.9830799961404748, -3.0073865582123203, -1.5037726341633926, -3.5067327052259176, -0.14157478892353204, -3.7784089532814282, -0.16386745891125784, 1.6522565688554942, -4.050957894956565, -2.803902812127866, -3.9961209098487465, -3.7180466327628054, -3.916701023334224, -3.425505362637515, -3.2644316236957023, -3.082629734507976, -3.8036219652487215, 0.6217986136575936, -3.241241165337228, -3.6098079045623086, -3.419875019296466, -3.8195609626772025, -0.10967910792724223, -0.036860718360161235, -3.7586819246246637, -3.4473406416830783, -1.47044121988611, -2.95898356626173, -3.5994293236954946, -4.290306343344229, -2.572392539863913},
    {0.7013069210142667, -2.0342397171561895, -2.8024985737684824, -1.8371490022849917, -3.628996178568829, -0.19249330581204266, -3.8442279548936207, -0.2818952521666258, 1.742475154291125, -4.038297081078246, -2.7360591943280865, -3.924975359317002, -3.9179263414924694, -3.7823036577131615, -3.735788405610077, -3.1083639096513047, -3.049140538325403, -3.4536644727692054, 0.7318274548417352, -2.925007860607847, -3.982030954382003, -3.7393224915134056, -3.8845262477885107, -0.1452340285177206, -0.3504774757728676, -3.9577656651935835, -3.3705520898637245, -0.5518626249470172, -2.4242658172335743, -3.9663206310361927, -4.659688141675092, -2.5294231960475253},
    {0.5100793787700546, -1.9519989587194209, -2.879632561887878, -2.097212579043042, -3.9141058278857828, 0.003380260139451247, -3.402203308362768, -0.1226869558722866, 2.34919265758134, -3.792223350015852, -2.826464342543669, -3.4215756504039727, -3.5817097500627906, -3.2835863153283937, -3.092246132296986, -3.1234900423125014, -2.855715545774751, -3.38038718375939, 0.6363304382443785, -2.8770135733935667, -3.8405479820878634, -3.335900049089787, -3.2896881028169225, -0.1641892071844558, -0.04134707590803577, -3.4018694168550967, -2.9425087632562126, -0.9245624573511456, -2.447882512668199, -3.3978752778442454, -4.536698623236659, -2.88926854600138},
    {-2.5899321326255524, 2.1758794926706777, 1.1198533564802988, -0.4787359548813854, -1.3827465740689795, 2.226605968796967, 1.0152493155379194, -2.3276933651381495, 1.46727032092256, -0.8715801570360308, 1.1514295750717753, 0.780603675899563, 0.9193656614886673, -1.6145165827935826, 0.37473729960972907, 0.8999143496518918, 0.527994005457687, 1.5372031546949616, -2.4214603754271375, -0.5346016576461122, -1.9251903957917738, -2.1086405421798258, 1.1664811522260778, -2.743044087467671, -1.9142509639032157, 0.7852006135174712, 1.064538659112082, -0.3317263570753863, -1.8151652413126869, 0.8205160652118675, -0.5126990664787993, -0.66466381275291},
    {-1.7724904848118157, 2.998524061839526, 1.3930405009363023, 0.5065470194273877, -0.1331423775326748, 2.664032103886464, 1.435782315263202, -2.1176912213423384, 2.157734131093743, -1.0197471779815084, 1.3637302031573935, 1.0984524778032236, 1.2593861666835826, -1.5651247834522677, 0.8326513592491822, 0.8621572483202935, 1.3870496116355813, 2.1143351465919724, -2.201619319360014, -0.2791508482628734, -1.2460387543463969, -1.7726443671142387, 1.083744815253261, -2.1667786735634817, -1.2884432485322657, 1.1041554136533236, 1.8322548499414317, 0.5413015231557424, -0.7798807616521046, 1.3708843805881796, -0.07849162760381256, 0.5324852699627691},
    {-2.224338637454297, 3.082978823670803, 1.8567219538149404, 0.011454922168800345, -1.0861859675649654, 2.8266707258219608, 1.7747895754194678, -2.477865185218263, 2.231060401823742, -1.1214823843679438, 1.9064150830017328, 1.617878243061331, 1.5794175927014065, -1.70489848380474, 0.4293938027447821, 1.5265779224908615, 1.701621792425659, 2.416804313643078, -2.722492623455824, -0.12763995060214242, -2.0681688434781704, -2.186016696505625, 0.9034777608724328, -3.0458469053357087, -2.108995457112171, 1.597635869310067, 2.566821844495564, 0.8285058270985389, -1.1177099528310384, 1.8925811364500906, -0.26876698991073855, -0.16598201223191117},
    {-1.6709453221282968, 2.627707714819088, 1.7449828970051602, 0.38762459265757765, -0.5519867945440962, 2.572540168919507, 1.6979046093597252, -2.565335080186987, 1.8656284887700836, -0.8190012538891852, 1.8753576470643105, 1.3847083436250074, 1.55771930493006, -1.7084460717625929, 0.42636594409219053, 1.0978849800796153, 1.514745161273326, 2.2809168948722385, -2.2488808138300023, -0.06906899749765673, -2.1876722694404696, -2.3842127244164595, 0.7150030852069275, -2.6769750819998857, -2.0353013282059615, 1.7347700561009018, 2.167109454580912, 0.4544380699721342, -1.1141340297664173, 1.596069385813192, -0.05496795141874474, 0.05585107586645526},
    {-1.544909323419823, 2.879854915815618, 1.5784082311666239, 0.4238035981915411, -0.4891802279014168, 2.0386833982398924, 1.6553668817979954, -2.299774767103882, 1.9940025119630551, -0.22768753630921623, 1.4987190086400157, 0.9678732022539491, 1.6843261072914157, -1.6458685314231454, 0.6991409072761925, 0.9355237885763614, 1.4604566566431811, 2.234053912211705, -1.5856175189560364, -0.2386724881011925, -1.4918977576142436, -2.112902360070797, 0.36435409552305187, -1.8648883815423787, -1.444846830078929, 1.813336591090835, 2.2384223220653885, 0.38759676947365995, -0.8615350423118443, 1.4931468245878543, 0.27382918667588396, 0.21937002593927862},
    {-1.8719580820756865, 2.7175610432219095, 1.9123119965900361, 0.2852278710770532, -0.6493209891007075, 1.9409355820824634, 1.545527133143847, -2.341381605977597, 2.4649762276725844, -0.7809600648010536, 1.578872233610938, 1.104910689125467, 1.3550371316670444, -2.085190275485382, 0.9168523146115197, 1.1104825233232527, 1.4026722870710961, 2.144128403803879, -2.038958346709496, -0.36539442236432434, -1.818336576611694, -2.710522991469822, 0.8633072766632469, -2.31436461591205, -1.7330188086961211, 1.4992639429492303, 2.4425313535239632, 0.6851212950380225, -1.4806767475267608, 1.3129095676215612, -0.3208687421579141, 0.22821073444918227},
    {-2.2699945082663637, 2.998096753624922, 2.1400823494688157, 0.3173053004057598, -0.7858966830069385, 2.551367281803118, 1.400675652391065, -2.7718607150638555, 2.3735000412936356, -1.3780415501856167, 1.782446281868822, 1.5185074576087498, 1.4023821512254138, -2.188381774683536, 0.3357629030980801, 1.1939145051888647, 1.348946516191689, 2.167967545432587, -2.5143158822816973, -0.6597446898106727, -2.0950716860822407, -2.680973797166665, 0.8103013856387844, -2.6943049902136154, -2.032701395208026, 1.5693187859706457, 2.310049338193907, 0.30634311664448366, -1.8509443418950358, 1.2678252228885663, -0.13617672127061323, -0.05925706268384483},
    {-2.7211395327807035, 3.1872975891857185, 2.3218039692927523, 0.6457729729277849, -0.25247505099543077, 2.848326074000485, 1.7242437614006907, -2.754671888228917, 1.880929153423493, -0.5313045730040518, 2.378635594953747, 1.8118453230580187, 1.8212332667388271, -1.8922550197271375, 0.7185241597883423, 1.2944149513306102, 1.5987426485102925, 2.5005119843102808, -2.6635346555397073, -0.2568787786241246, -1.3863323325557855, -2.1990396487424393, 0.947166811228326, -2.6677506612153277, -2.1121896851305717, 1.9863712590781941, 2.3272824559669174, 0.2746029737313848, -1.3719302458866904, 2.065929497219976, 0.5246648755316949, 0.10155837512578948},
    {-2.6658398129790397, 2.8175623947489274, 2.262218363593533, 0.7965319816843712, -0.6840625441286409, 2.898706740168859, 1.747244828439846, -3.180618366053402, 2.709091870003645, -0.5230727350239556, 2.271537060509911, 1.9449363448531345, 1.7502652957765148, -1.7874639054769794, 0.6825489214025573, 1.6787768680964033, 1.7645893914753137, 2.657667925136591, -2.897099979395347, -0.49383961571268165, -1.4297634443884384, -2.3853493400582604, 0.9307494233411361, -2.7115127768103053, -1.6618301021058, 1.7865714536224329, 2.683320292658991, 0.4017927100076588, -1.5668054254827979, 2.000893595433331, 0.47025891221931404, 0.4298144331934569},
    {-2.4095842615148513, 2.7875011265787677, 1.9694138996981683, 0.8252061873848379, -0.6535430864838013, 2.9728885290753078, 1.7057973930102488, -3.265447280515895, 2.4872850651740412, -0.8695117772609215, 2.185329976742771, 1.3391922775976173, 1.40647013282111, -1.8879403422145014, 0.45886959117851533, 1.595993344278683, 1.4302718804476553, 2.448251242484073, -2.827612551132594, -0.9844409866971328, -1.9714639018431763, -2.74635374321706, 0.8684191072853696, -3.23523843180073, -2.178223251881474, 1.6074740517275654, 2.3990978814012682, 0.3358848568177221, -2.000054175559608, 1.4704016438026417, 0.041802755550377574, 0.15755329583208152},
    {-2.169663160515963, 2.5754327827859105, 1.7197491494159591, 1.0403750087433885, -0.20125948450540682, 2.6266586019506333, 1.8207909826501758, -2.9024312116910096, 2.266100283609834, -0.49058193629359526, 2.1731985999015477, 1.2140073157139295, 1.3942628657098168, -1.4917283686385483, 0.6050622639284123, 1.7633616859378152, 1.0993112546689836, 2.455575363711402, -2.9418042928033206, -0.855125979711319, -1.7744164491182424, -2.611747735885687, 1.3565474272239817, -2.6762322210981644, -1.99422236451566, 1.4365766617813627, 2.2605822615917734, 0.014308157218025227, -1.7399013201539042, 1.6355706061190232, 0.3789657430019984, 0.6417762443865218},
    {-2.2217173159711527, 3.225944409040537, 2.0688604888847744, 0.985984912008138, -0.4533906682140816, 2.9678601018673, 1.877954904323375, -3.2092157357478923, 2.3661511701894544, -0.6200857074690219, 2.05102025789014, 1.6658566921045346, 1.9306968156857038, -1.6018601982886511, 0.6233692695048824, 1.6032471218900255, 1.7695678758732836, 2.8630422691257795, -2.91850216045783, -0.19789777444027656, -1.4637478682791976, -2.4776543926453813, 1.4344805792552597, -2.793430703512444, -2.453594215676993, 1.8249653120599467, 2.713021616158123, 0.9099422155099813, -1.5962995212133908, 1.8458487732277655, 0.48773669697546485, 1.265665121999945},
    {-2.729215051417247, 3.3629759695213433, 2.5353658725146535, 0.5709264109439026, -0.9351147955967749, 2.946703151904246, 2.0567907506972287, -3.205457155905137, 2.294821925420092, -0.4843899852651303, 2.3667452587761733, 1.6296347508182507, 1.5977791024304533, -1.8389716160171625, 0.6254059308345935, 1.5011713275360863, 1.7885021600367395, 2.683848762343628, -3.2899166705671594, -0.5306685636647711, -2.1084041990772824, -2.8676321886058633, 1.0637925267620219, -3.1133220818856833, -2.6974691603852743, 1.9397262014117373, 2.447731187561098, 0.7665086465836582, -1.9640049034122677, 1.7194770147732403, 0.19203076127918886, 0.17156043011570957},
    {-2.6017832518186257, 3.2894494804353176, 2.824869907888611, 0.6128348881397503, -0.7751218169777584, 3.26992546148781, 2.039672680707382, -2.953642215432647, 2.5535447129905835, -0.29907712385528484, 2.624645021390691, 1.7795938698571168, 1.9580793411568294, -1.5604886364171144, 0.826247112585783, 1.7914781223064444, 2.020457667897058, 2.5832901375315647, -2.898776842198394, -0.12149200620659202, -1.9236494392043457, -2.526887792722677, 0.944217230412777, -3.018309243071495, -2.4976280927988714, 2.090988344173649, 2.494589302710512, 0.5091024572967487, -1.5642193880008781, 2.0198346610235927, -0.1252823624702407, -0.12933185442097506},
    {-2.7736984608908846, 2.7374597244606056, 2.28287621698883, 0.22497890415980532, -1.1250384248228424, 2.224778183579019, 2.035462301990042, -3.155220941794131, 2.15102650575475, -0.5990314378860707, 2.2620219203710357, 1.2602349334808074, 1.8304626488631364, -1.9012725895032387, 0.8673169238688234, 1.3213026714122935, 1.4478669395201031, 2.634935114737651, -3.117064200077972, -0.38588513593858287, -1.8637435572965209, -2.6180135026254887, 1.2709037912337566, -3.358360944013586, -2.7693358308496516, 1.8632627688689993, 2.5083188586380336, 0.45257600246227647, -1.8272030436983344, 1.663305780716263, -0.19647712446587118, -0.710771704629513},
    {-2.321086638629286, 3.1093540730112736, 2.4325653199276034, 0.5025326776991595, -0.7177383147310511, 3.088635813872118, 2.1023363286804777, -3.261755670425262, 2.639216178522424, -0.3837700876055606, 2.4083424520579073, 1.6121934765252206, 1.590565108570251, -2.177345863761316, 0.7202327722888411, 1.759873488064474, 1.860307845621061, 2.6142512226051373, -2.855363346996985, -0.935115593105123, -2.0944732734036773, -2.8668449380600687, 0.8928870625446222, -3.295102093270554, -2.7688912652212503, 1.9769666958006031, 2.3828056627998717, 0.2529321308781915, -1.858294903732336, 1.9883610338106208, -0.001464618167865083, -0.17583133398532355},
    {-1.7399414423866573, 3.325070674388893, 2.288375281901286, 0.7213368867121441, -0.7256445671434589, 3.5564197113192075, 2.143927692713206, -3.2162534469476336, 2.5265463196221662, -0.6912946173817552, 2.454314392937247, 2.2533003848132935, 1.6493072010987049, -2.333934984497912, 0.9014993470320285, 1.8003822362031772, 2.249738835299339, 2.7163887156759103, -2.974465762872143, -0.5357150436990075, -1.996900496746311, -2.8335704620849307, 1.2314956886032482, -3.006536812930987, -2.0656386665184, 2.4119162131800436, 2.7736368055222718, -0.359501919442681, -1.7394355634959904, 1.8145051578130815, 0.15620066446634154, 0.6384647179435107},
    {-2.3877155398907073, 3.024118512927839, 2.509767921395918, 1.0590862102052045, -0.7776476421086106, 3.406696285474512, 2.278989534082869, -3.4393515848204363, 2.567938626560965, -0.8464795477715392, 2.7329001913110087, 2.324297284212794, 2.1151079126151306, -1.8904661938853078, 0.8503707959035857, 1.868982101221439, 1.9751769084510877, 3.230315122332265, -3.0672828170656534, -0.7389923283541636, -2.0212276436848557, -2.630078139166588, 1.5295503686419827, -2.7132795739985225, -1.9385339164980495, 2.304380120286464, 2.620854247081904, 0.0444579972216386, -1.5268131535538203, 2.2737385758158317, -0.22102522828653098, 0.34582700081575846},
    {-2.931652423876048, 2.995013062464345, 2.4280464660825203, 1.1651614707337468, -0.4002353322317703, 2.966729195863086, 1.8581884677036562, -3.2491603352308362, 2.528858597597044, -1.0233058913951865, 2.663354051611897, 2.2269139599589334, 1.9094116270819106, -1.890289415105566, 1.3333460870021248, 1.842643742026961, 1.9503418046194245, 3.0093645944031664, -2.825282519887145, -0.34823208534717137, -2.2551963312013728, -2.7838047536931874, 0.7928343919379061, -2.877288722083127, -2.2620264836522765, 2.534621319487825, 2.6694969760121854, 0.11344912135893903, -1.8264516767237706, 2.1469446378743178, -0.05990433269984374, 0.15304832361033557},
    {-3.174964271732594, 3.509106665849697, 2.6606564310185226, 0.8319727107444405, -0.28491737969681213, 3.20192799531508, 1.9662852777481399, -2.890881080077361, 2.5301648722897907, -0.8503559735283711, 2.6695317832174035, 1.803269894543603, 2.244089277397094, -2.0312784635984027, 1.1575605996194862, 2.055737517680984, 2.3511275810144663, 3.0651708970792746, -3.184910094425624, -0.22434882910756163, -1.942175666717426, -2.402431837608646, 1.7683058159495688, -3.1860151591869412, -2.595139021739716, 2.4880772152879094, 2.6459275387034484, 0.28802518694246537, -1.5218424538652076, 1.9053553806401013, -0.28907070957603875, 0.25040238590711},
    {-3.0391848055810566, 3.203281652734952, 2.7196914807842747, 1.0458783167788543, -0.3228196117006533, 3.4194278355989653, 2.20653703236329, -3.2957541065185625, 2.3178360005986396, -0.5947442651891, 2.8717175293289934, 2.07951629037488, 2.0675168548442344, -1.8742495091284275, 1.231309882106693, 1.9060559129207806, 2.2659125407475833, 3.142204316187973, -3.2351184396598778, -0.8861613681365943, -1.645976337608484, -2.982465112224367, 1.6153141741628347, -3.087178735299459, -2.703984997399409, 2.306108239930014, 2.919968414596114, 0.19822673745733096, -1.4229786840592396, 2.2996000360343216, -0.025138807000172004, 0.6066139515389845},
    {-2.7360867327640213, 3.5751850397061, 2.7527615096542144, 1.422517340008774, -0.17184747951418627, 3.520852423767347, 2.527073937727208, -3.309073198066865, 2.523745525216668, -0.6671184500085858, 3.071362122401829, 2.547049477032166, 2.424683215358499, -2.31017980364545, 1.245550490481762, 2.010478554893652, 2.321261344726281, 3.5360522221979105, -3.526978768884778, -0.6754322014146921, -2.2341511730357317, -3.281303096896557, 1.9732106742861186, -3.2048524343232905, -2.4984165528951277, 2.69568793251715, 2.798142171415948, -0.004060933946855542, -1.519276887923324, 2.422858684236655, 0.5813967005648346, 0.9792054167999816},
    {-3.0082857878250056, 3.1385269495982255, 2.6593004620874874, 0.5086225478604487, -1.1689905768515645, 3.1674349476014054, 2.3411748113238815, -3.699301133364937, 2.1592394838403486, -0.7038778504681074, 2.8173954770442267, 2.4137848888020814, 2.160815510843721, -2.163011712159548, 1.147843671879624, 2.1583325621161165, 2.4986929480389204, 3.3119366471719567, -3.7999939759394414, -0.07618835292173042, -2.63630307678694, -3.526518615455474, 1.8114703838784125, -3.5954079995995802, -3.552955767516856, 2.503441906477664, 2.6734483908257163, 0.343303965623538, -1.1611572416425526, 2.4859732399029824, -0.17838477277774115, 0.2402166799580738},
    {-3.4140086278437187, 3.577005632274335, 2.6332162334753666, 0.8619941286366701, -0.8360694237586241, 3.5596775782340755, 2.4829873274650764, -3.617541776276402, 2.4488192375494737, -1.1439739180755908, 2.636469342339842, 2.3117233791957945, 2.693506473713991, -2.150766609012755, 1.2363502857850401, 2.0355946970886776, 2.5011819967635445, 3.2656623903095543, -3.617892485224729, -0.7759700373527941, -2.9047086311178933, -3.5143501245206794, 1.8585186463477623, -3.838295943734756, -3.303236669252095, 2.3297828376616962, 2.80658294691357, -0.050756172366835016, -1.8371266568278155, 2.4576968537340385, -0.0809839319078777, 0.0352351073243139},
    {-2.877805457114093, 3.7493678222455475, 2.7056432341954224, 1.4190496580481737, -0.9099658401461425, 3.8082767762219225, 2.433356224737377, -3.2978055340426713, 2.86218624305532, -0.7572944110098457, 2.73944668474059, 2.5294143132819285, 2.361112566053536, -1.8669552447332194, 1.1532286655965038, 2.1449253597131794, 2.4956827422718146, 3.282434824194215, -3.387711324283532, -0.4565105026784926, -2.219081695789348, -3.001453271738977, 1.7081883821517203, -3.251507769789887, -2.707140148939466, 2.6117449909122956, 3.0631399373974952, 0.2192666498460558, -1.5704507430630745, 2.6936837490039265, 0.6748388438625184, 0.6436483193635892},
    {-3.1409632909053626, 3.326560504746042, 2.9786184079086997, 0.7585372245354798, -0.8249164190879797, 3.4519228043482686, 2.4974959531883725, -3.8041580051476593, 2.9390353572103405, -0.8196347915559269, 2.9011166795056655, 2.6862328800954685, 2.2660941270400468, -2.3732772844910994, 1.0720218315546572, 2.371055906226904, 2.6161956019926156, 3.412066541486123, -3.690467048312677, -0.7212942548543793, -2.612676502331127, -3.635379807807119, 1.759156607641642, -3.8956895079424125, -3.07042087122316, 2.7526538468273247, 2.9460915054007772, 0.4477229967154172, -1.7556176275000506, 2.7375584235291255, -0.20498395707727568, 0.1883289972038441},
    {-3.320317845565888, 3.625133691740369, 2.7133412977792233, 0.754173546998174, -1.2784064252006273, 3.1991254328243506, 2.3150314335299287, -3.6137527240636196, 2.60713175413925, -0.7929462699737551, 2.8269068152029204, 2.869470279223772, 2.3064355263782352, -2.3930642478285766, 1.3427356372336985, 2.030282818267461, 2.640378619442149, 3.097079924763176, -3.921498322285661, -0.5276956730421518, -2.6272182021516426, -3.2770636014902683, 1.8529789583091776, -3.845677076999001, -3.6394256334177015, 2.8062887352140846, 2.96692479830378, 0.17597085918048033, -1.6299181855957339, 2.444897250872311, -0.2081009296856921, -0.07987217269722029},
    {-2.8473301698638753, 3.848568497127049, 2.5465175193342424, 0.34372688738159307, -1.2354863345487697, 3.2226319317905965, 2.0659302928767365, -3.5330772299372977, 2.8905207968265576, -1.6368355213492798, 2.5998456196809174, 2.4296769299210337, 2.12270752557017, -2.5784328146720794, 0.6486187360640312, 1.6620403999516582, 2.1064214456863515, 3.1067651700675403, -3.277001200143498, -0.7904514253120947, -3.2316115764894047, -3.2852564552738275, 1.3920081447519408, -3.4098993396890407, -3.1656190117225314, 2.150544116482129, 2.5950594016135917, 0.11171819975143726, -1.5272164095114935, 2.0861077126327072, -0.42468196454529844, 0.1192221383864164},
    {-3.0159749138798166, 3.805475676593226, 2.786737763534968, 0.725679490242678, -1.1983452560818852, 3.519090775448663, 2.3720120686046173, -3.4803506694216186, 2.7987716226057415, -1.3093758926072139, 2.8997641077799257, 2.2061644368171853, 2.5128295744944396, -2.8113455037099313, 0.7985213350717647, 1.7252087928123072, 2.5166881477322898, 3.325155807552879, -3.306064147129205, -0.7717456484731041, -3.148115334451447, -3.738282370684459, 1.583228310489823, -3.301384767192379, -2.9516231936365105, 2.549824371630954, 2.8455410187235404, 0.24409161781741595, -2.023584118959453, 2.2703184574355624, -0.5675013106477765, 0.15069767300902775},
    {-2.658719448254258, 3.4998844927197967, 2.7009949989720012, 0.7254406520460069, -0.7963064499752694, 3.343996151958037, 2.4444135352356313, -3.6745343173533485, 2.7729909274380153, -0.8721754748262054, 2.9950071016651716, 2.5658165578749426, 2.874205818463678, -2.3098484322319885, 1.4830210799264765, 2.2939366610691065, 2.7810188779906366, 3.176570756140253, -3.208248260997559, -0.5562651337125007, -3.292553928980976, -3.3520496100045887, 1.8874016025722453, -3.5752578605196024, -3.2855412327521396, 2.8380486203358197, 2.9361792861454306, 0.3010476388261419, -1.6369876294745314, 2.7255777997214756, -0.08894878682373529, 0.27096594799953866},
    {-2.2658047099356544, -2.683106108650572, -0.4041160029622892, -3.259519469739258, -2.1722349979354285, -2.0612462407226184, -1.7835406807332124, -0.6232666116186588, -1.2990164950760532, -0.8800705672592858, -0.7167990545824164, -1.5942490077257436, -1.969765110366764, -1.3281893974607013, -1.7436852451510914, -0.6483166847058276, -1.1495972054653811, -1.5292932842796394, -0.4688921363149047, 0.2104868374312786, -1.8910403646434015, -0.6268736122750064, -1.2132720384930695, -0.9260966893803048, -1.830870036479009, -1.8020714037785834, -1.1862276925542365, 1.5788023533005786, 0.17588276648242537, -1.4100974195919815, -2.345970998563043, -3.21395003756384},
    {0.8944621658926164, 0.8233871818063522, 0.549022366398294, 1.2307937309783485, 0.8622436361672401, 1.3004645840126983, 0.4683626394840666, 1.3252915336116857, 1.5380385627370818, 0.2953326563048407, 0.9082121106800057, 0.35047737493479497, 0.6041682636113413, -0.2369307798583805, 0.6923503031329042, 0.6312811113554941, 0.4156892601811976, 0.25240535988854024, 1.0881202229662152, 1.2003559157265336, 0.3799191829737409, 0.16310791868533903, 0.7688786216214021, 1.1669416433626347, 0.8701627572866673, -0.19015358272363359, 0.6565501345293098, 1.097498511279391, 1.1510243822168527, 0.09736378870414539, 0.11228796222811932, 0.978736270390207},
    {-1.078870975000087, -2.992769230702796, -2.3339919139535676, -2.6823690739224806, -3.4200904383303437, -1.5895231803540482, -3.1437159499775533, -0.36920852490544276, 0.1291284048474669, -2.921539984715064, -2.117234943782732, -3.275682864501987, -2.8891363804507475, -2.5833289803356894, -2.89004703169169, -2.7347304669614507, -3.0200798852079895, -2.826787889731592, -0.5179781562710803, -1.4764263372462139, -2.815678815450584, -1.9125465493790106, -2.9394550019405252, -0.8727528316755356, -1.372041433914174, -3.137728048353006, -2.762770379191299, -0.9412891118018903, -1.1235065419313526, -3.0527514882035733, -3.2576696060440944, -3.15023547974714},
    {-1.299222248738401, -1.7467801292002991, -1.8750328566678076, -2.637769272388614, -3.1339709334561046, -1.041246695865666, -2.536998207711543, -0.9723466281734663, 0.18942676768601605, -2.6022915754084712, -1.7331806760277557, -2.225791937442288, -2.537993551866426, -2.2512385194913502, -2.1450327188480833, -2.0902590556283087, -1.9456375540596929, -2.068725720227588, -1.1497702015910498, -0.6034276814513239, -2.702195523915759, -2.131533826384407, -2.4150292078343343, -1.4728274860390853, -1.9597443258160878, -2.51651580100308, -2.0234388317418803, -0.6987793758090675, -1.1611295561907735, -2.0399546920782337, -3.109426807229526, -2.9487011534079244},
    {-0.04575860438127518, -0.4181997784961012, -2.1121016468282874, -0.2650109819276468, -1.6357816928177038, -0.4892221224544118, -2.3869989293200087, 0.1104765612844651, 0.8175597343808568, -2.7450655527355248, -2.002695038115037, -2.29766203897176, -1.8260576776067052, -2.1495488055251175, -2.391585824181446, -2.622296316715916, -1.8676890694778887, -1.8714766141317798, 0.10168849285782426, -1.8268714620297866, -2.0038399175390342, -2.340728939313908, -2.618383033316627, -0.31245155330474766, -0.7084778091784537, -1.9012276336870062, -2.2171777280701357, -1.4699323304300804, -1.5657851795470978, -1.9014454893908697, -1.991677659305773, -1.528712830446332},
    {-0.39021781438496983, -0.938033090045427, -2.309485993774115, -1.026541810536456, -1.014183755483697, -1.0164245259313616, -1.8850885730240357, -0.1123375271427015, 0.5977522357272099, -2.108138135650554, -1.7573560093886018, -2.3372043436079126, -1.756453906767469, -1.8901383825177192, -1.9729570088558792, -2.0585858198667975, -2.4571556334289855, -1.691948661046653, 0.0048283198796582475, -1.5449707261923493, -1.9519871491303895, -2.322687412002555, -2.262435658984749, -0.26300174595570375, -0.4296666101662325, -2.2765322933673993, -1.9279705281009158, -1.537532029903927, -1.399199288387457, -1.923102858126238, -1.4289669407263625, -0.9637572136082518},
    {-0.3478527057006588, -1.2846227827417116, -2.125232735188341, -0.74593966685057, -1.4847679867258443, -1.3126262655393455, -2.5354282800515713, -0.41018415181504886, 0.3762344474576811, -1.966737511971262, -1.870038835197048, -2.097778699383065, -2.197568406152735, -2.1912615956741357, -2.419151537138223, -2.199408974943279, -2.0256005375926964, -1.7370700458136696, 0.3132899792088183, -1.8757251239226573, -2.647682172255032, -1.8806671291737087, -2.645146841824924, -0.2458123190696317, -0.6863864799862885, -1.9157424544791875, -2.0116023770142943, -1.604011777627576, -1.4714095772498588, -2.3117085630526772, -1.902587329718312, -1.403814041601962},
    {0.06619331525523921, -0.8513764209055418, -1.4458390454628933, -0.6643954823754856, -1.1716196474132041, -0.6965985714548893, -2.049397964392748, -0.046749034622727566, 0.6139298549478953, -1.6832645434508564, -1.32937317915721, -1.8099603919152312, -1.7749249434918266, -1.4078576506947673, -1.3204908339787265, -1.1465221916010933, -1.4270935231086295, -1.4251856772525164, 0.47656812530560083, -0.755027509357877, -2.0792929610034108, -1.6765296371584146, -1.9263917509919772, -0.12859362398180646, -0.256603053649347, -2.1130454848372078, -1.5852562440462115, -1.1638888915768524, -0.8701530369238764, -1.5758451579697763, -1.4914443837115903, -0.8235407718394144},
    {-0.021729686638317206, -0.7180209510692835, -1.816813205003824, -0.7241212084689801, -0.9200579821216652, -0.15551898931934555, -2.0376726029076413, -0.19696338816264986, 1.0832210745222604, -1.9503657912650447, -1.425768281600669, -1.8573365517377476, -2.1141556594709208, -2.0365265552910374, -1.985206785919073, -1.582570502887841, -1.9094288659189473, -1.806535781241213, 0.5118449682307749, -2.023954482806605, -1.9316465814687562, -1.6580188436140895, -2.135069729202146, 0.22103619910242842, -0.16399207254314016, -2.076927646359642, -1.4202550313391107, -1.4874429625923289, -1.3835174830976182, -2.077192076718277, -1.9593545606364196, -1.200887869930229},
    {0.7459905756037959, -1.3273222104147693, -2.6758857996093024, -0.9475088138127684, -1.808317691385217, -0.5498509312516424, -2.88144503396134, 0.6455109736139948, 0.8860068425390917, -2.68175554043219, -2.4342955631848184, -2.537389165715685, -2.767507698553207, -2.478418763847017, -2.7773472375616812, -2.346534354021098, -2.4321138350963922, -2.493975034430353, 1.3789670691894418, -2.413689192813239, -2.2279378517520194, -2.2371178657661033, -2.6372327962656446, -0.022473400233212096, 0.6213147560326843, -2.399381989076681, -2.6826005210270165, -1.7303562945750472, -2.1258053805606023, -2.580388798236032, -2.568864660359676, -1.4884451857522225},
    {-0.7012382001810628, -2.1037007449480996, -1.960614789062407, -1.5244885844029537, -2.1325616495037796, -1.5348356629666362, -2.0285943586411848, -0.5492650416826771, 0.4512713245652691, -2.292789122227988, -1.61747624283097, -2.1169426594259986, -1.9539516823244567, -1.6835751615029402, -2.2172623023314384, -2.0321826507347853, -1.7080626392585148, -1.9516562727924047, -0.1859976601304307, -1.311949408557267, -2.342668746256381, -1.731869230671486, -1.6954553890364192, -1.0128339162566027, -0.3885187654651054, -2.1259069002884114, -1.9185031200739557, -0.6187329407850335, -1.5158930923653562, -1.9394435778373722, -2.3311179021730384, -1.822957093348063},
    {-0.41373932373833394, -1.6547762093164933, -2.227145887042739, -1.7857728551165901, -2.0381734707673775, -1.5600286442306577, -2.817543126573033, -0.2336042738690562, 0.5486209907990041, -2.524238529033625, -2.3758440256263866, -2.718469074929325, -2.216533758484956, -2.2577650898075934, -2.2124144535135466, -2.427465975173821, -2.2136614735560407, -2.212019457852798, 0.7394424461705144, -2.1847010351254204, -2.5702500978051144, -2.0606418182465536, -2.3188463356725983, -0.22039169584381108, -0.483765545450746, -2.5567502723947695, -2.333203508996485, -1.414348233046828, -1.7595876940264465, -2.400766270494873, -2.4300212243230837, -1.9986672379415553},
    {0.45322113843546613, -2.28784588703166, -2.158765526057848, -2.0498674914587047, -1.9961768557722703, -1.671895300455239, -2.5950975949996473, -0.013099178957463436, 1.2330129147063833, -2.5148055323269216, -2.394725007794459, -2.502219307609921, -2.487530605655835, -2.3899487386501654, -2.6959274541615024, -2.24542536609891, -2.327252229920798, -2.256725133205213, 0.8289480366136561, -1.9748912270591654, -2.679557479295977, -2.2363128754210364, -2.5278377175454323, -0.4388878955515809, -0.17659615339968054, -2.306172550341415, -2.410137456250705, -0.9012342052188327, -1.5638178897425852, -2.320303457981426, -2.598084630537058, -1.867362335211788},
    {0.8102206200229588, -1.9558959060455625, -2.4439153506135005, -1.7533705302091647, -2.34410835163039, -1.6495577539917985, -2.3784737089833086, 0.06106826325805759, 1.2290088161328316, -2.5598839281295254, -2.455390128413896, -2.564314930020963, -2.6939121308960168, -2.6837094560078527, -2.625391166099976, -2.1850123877523044, -2.598203169654117, -2.3929821853244553, 0.570016115615322, -2.0522880311263885, -2.6543114611161367, -1.8112226228748585, -2.590459240711586, -0.48210821474138293, -0.3896834397474194, -2.8359203508033386, -2.28349187405851, -0.731405915486925, -1.1187476713265174, -2.650925136897716, -2.781046288369147, -1.959013805536173},
    {0.5744593998013525, -1.9771052839033547, -2.831608938838051, -1.85781129020156, -2.273145613242489, -1.0352322539539514, -2.962342648091904, 0.4183222431391729, 1.066964578629604, -2.732532341245952, -2.9709365739417533, -3.2813031254153686, -3.2906116199386464, -2.5381436451560537, -3.1469659835926334, -2.8610970429031806, -2.7408329944100482, -2.848243878088231, 1.0848061474335333, -2.140493967283286, -2.435509987079472, -1.9202909121597724, -3.03349033184677, 0.23154372029116238, 0.054705044644735766, -3.3108473572365367, -2.859096879952225, -1.0080135205296339, -1.0611860878297212, -2.8764986339189957, -2.68841687028658, -1.9283375458949403},
    {-0.833741466536652, -1.8509981353797547, -2.0545367803790566, -2.2239951373440214, -2.8026496366809046, -0.9048721909293199, -2.5139880692580454, -0.47689025809137936, 0.7662020970195272, -2.9423455864872006, -2.267178098890226, -2.3937277374016, -2.717715780649292, -2.8909194713718254, -2.564354342470374, -2.3559934454992932, -2.0786216233658936, -2.19859300551309, -0.12001473888443721, -1.6161423051639607, -2.512220059559775, -2.288766983030506, -2.305072069211854, -0.9634721190273121, -1.0649218794110697, -2.6738586578996553, -2.3751338522107543, -1.080745319274351, -1.4247336632795138, -2.4918866038493896, -3.4480487431637488, -2.2934181986386823},
    {0.006179092383847257, -1.3375888528459579, -1.7786198365156713, -2.098194115064806, -2.9312350812684063, -0.6424323071425166, -1.9822832380498507, -0.6332978932158843, 1.671130494825604, -2.533246001780866, -1.8966807436722877, -2.2787921418713806, -2.587430808060848, -2.5025314155714393, -1.9796292335511738, -1.5354862386845298, -1.9212185569831508, -2.5774027875340213, -0.27390278168035126, -1.3192039675280178, -2.6969064332688104, -2.1605873047301665, -2.0018906029884875, -0.29252214533312715, -0.713066904780457, -2.326997719214394, -1.7569870740397449, -0.14980592718351418, -0.6577878029895039, -2.29444353909138, -3.3109185678469197, -2.6056631028852295},
    {0.300129898215375, -1.8306886884047955, -2.094926223369192, -1.8692367657516729, -3.4077826540343983, -0.2950589457442239, -2.1971561157380823, -0.2265445035030571, 1.677238875081363, -2.899667530822475, -1.6426465850457235, -2.647338662664144, -2.646775290437014, -2.923346240276351, -2.2424840163958346, -1.7640246567445048, -1.970787263219909, -2.233404309391475, 0.215871449899412, -1.3238364306404677, -3.061241981803896, -2.628182934895188, -2.7595546964298125, -0.16754601758382684, -0.3615094298403104, -2.756993718944478, -1.816625748186496, -0.13987722957626306, -0.8318143230172867, -2.437616637482363, -3.600728742746773, -2.588891978611558},
    {-0.4726630595623442, -1.7027503694403645, -1.3707116731718556, -2.3934120792938955, -3.240793110707988, -0.49267851895024134, -2.267871666925701, -0.1888941415521695, 1.4894540102508467, -2.6618843091940065, -1.5540036543871396, -2.44439858826503, -2.3648536744703343, -2.3912538455906263, -2.105080138605511, -1.693930357226327, -1.6779531222864617, -2.2647628315051387, 0.062492238344342, -0.9520580105211159, -3.104564333956327, -2.4940969537908986, -2.5044657283111693, -0.8717733579498019, -0.8720865516378248, -2.6617206928336623, -1.8290990207675277, 0.6348239723655766, -0.26069983205142194, -2.3883348481950977, -3.3156702834209772, -2.8510052684888914},
    {-0.30762863046609396, -2.4512038649078898, -2.6769886035547032, -2.2473757906718137, -3.474187242116721, -1.1485193213257443, -2.7449325310768744, -0.4274022884813134, 1.5711076324031186, -2.865224650847952, -2.320797884478755, -2.9872600946596592, -2.651362931868276, -2.8927860518914352, -2.594586482576334, -2.3219915953118546, -2.2995081120224885, -2.534139640162595, -0.11628952619802119, -1.7664260342016647, -3.2586097924093553, -2.6430396687177904, -3.144813401561061, -0.6566234178837833, -0.9052573297778, -3.187408478531, -2.2718729400509825, -0.27239951352289044, -0.8874795416494289, -2.8168834003715286, -3.3332570859169923, -2.92538701812009},
    {-0.5508584150923785, -1.9916864729758574, -2.4562775947280016, -2.8781861015850514, -3.558592279199328, -0.8463748550111244, -2.981661425082043, -0.20029095491971338, 2.022075813089898, -3.3627820153316486, -2.7485998302755674, -2.94139389350819, -3.24700484013901, -3.117317310624668, -2.99114207103477, -2.405450823701038, -2.5144388170111807, -2.8020048669486837, 0.06754078049938883, -1.8778468722931971, -3.6159929953607435, -3.1676190566395213, -2.986657940757184, -0.8513381621029562, -1.3118518822074814, -3.330246396425327, -2.4314786156696573, 0.24698261905093416, -1.2114789028134882, -2.998202343122846, -3.8339605120094125, -3.5164134022591376},
    {0.6900813125827187, -2.2996578658631317, -2.3998215535735676, -3.2125784718432016, -4.250697036390671, -0.25566540092081097, -3.031350408407209, -0.04392165301736114, 2.9430641526216235, -3.820723698001119, -2.1642756802335184, -3.2058545428190386, -3.3092801153777804, -3.361350265767652, -2.891537372269552, -2.320470018216784, -2.037278078603322, -2.930001546606344, 0.6277903575056257, -1.0133172472542875, -3.746128839714503, -2.8282456767601643, -2.8691252053272054, -0.1385719565521492, -0.5089099847025299, -3.614736210364333, -2.173370949006259, 0.6913220089252774, -0.763117743182016, -3.104139748323744, -4.818821867769289, -3.6504369228378057},
    {0.5016258188731961, -1.4984074807760692, -1.0673387740830496, -3.5832597560318407, -4.659579364780772, 0.4115474195394969, -2.138956808733833, 0.19517404749916184, 3.4934707733518815, -2.8864529734333817, -1.3766233659127993, -2.5913243055532997, -2.6570498647761642, -2.432294761770083, -2.2255799514869685, -1.4054233414931145, -1.2631719464588294, -2.2784966122101142, 1.009609246875661, 0.6068736674978756, -3.4957587541181896, -2.04933435495399, -2.311645836731712, 0.1811746815953539, -0.4144568093160021, -2.943213677641961, -1.4710497498251334, 2.1964638175719147, 1.130470608354865, -2.2743681283335726, -4.97687900393931, -4.258474719478503},
    {-0.06600350934308802, -2.6215411466950993, -2.1204075140813536, -3.7494185273092566, -4.592083287305213, -0.6223297649979403, -2.992568398113159, -0.20958156856274415, 2.5736455780222456, -3.3331459571614257, -2.2772976795499136, -3.2388721386060277, -3.062007906084164, -3.0241925277576325, -2.756219137994632, -2.3645896924505103, -2.1835324380577683, -2.853605876022083, -0.07277852084458186, -0.20186533175006693, -4.178596409808324, -2.5937712618048083, -3.240447723168864, -0.5656919886925543, -0.9179311115066836, -3.7918669810512804, -2.3097967976022327, 1.6136155164951411, -0.1850146437990822, -3.183661501800885, -5.112177881990522, -4.394554162529985},
    {-0.7038186999965795, -2.655665634699533, -2.4466087237865124, -3.3100438389099156, -4.304195467498826, -1.2872639519573914, -3.443815610435036, -1.1043385595192983, 2.0471060768410267, -3.734623756475128, -2.697486437410006, -3.72293525884736, -3.4172528966599622, -3.36203288723211, -3.2822817275461063, -2.7135023466050243, -3.2856464274018418, -3.4161150904520836, -0.27570053330038, -2.15206850079081, -3.8629918924204345, -2.9904004584083057, -3.380997849849296, -1.494227324800905, -1.3094577380471877, -3.8837531501601275, -2.994270455303155, 0.26663771115864304, -1.7600142867749369, -3.6148348193312607, -4.619217516350581, -3.804201586246384},
    {-0.287998242031458, -2.2945271958970195, -1.6424327112981274, -3.595701362513806, -4.939051610875798, -0.13428781923522215, -2.23994025444991, -0.4038072352903258, 2.31129974300248, -3.308773884574215, -1.7099969544318636, -2.8342756395840536, -3.1038798662555083, -2.9211786177270174, -2.4671893124251754, -1.5477205531350016, -1.7271429510812257, -2.64135936761014, 0.2253919812029172, -0.38873426971313624, -3.92481196879288, -2.3853980640064694, -2.804796998054461, -0.6968521930707638, -1.159736627961235, -3.410686593145974, -1.7679776312336264, 1.6255261434886812, 0.4720005460814911, -2.9726631697564643, -4.945376634276106, -4.371943421970218},
    {0.4132274081573114, -2.775034916790066, -1.7636612667527747, -3.9688946681756936, -4.686402302805946, -0.41159149745038914, -2.8999841424176984, 0.1763895897711672, 2.512411404570186, -3.6264450672679893, -1.9311555599323564, -3.386208412132197, -3.6701154550452126, -2.9973784110217236, -3.0684978770433697, -2.256753906962067, -2.263599623131378, -3.242939855588657, 0.9605022965274971, -0.43309632209562793, -3.8136754784283244, -2.660745435412224, -3.2445182034540734, -0.1748914120304196, -0.3758453987003005, -3.733240467496504, -2.763006432460697, 1.4571608032908774, -0.5318951436562191, -3.503061126016612, -4.865133741254678, -4.500933474417468},
    {-0.22964737146952452, -2.7508223282635464, -1.9920271573340167, -3.7633052703195236, -5.0008379757283725, -0.9041729598403847, -3.443834627648787, -0.3249134975250637, 2.2006298748578095, -3.8945201568124372, -2.1924537379273805, -3.6036210367257673, -3.554414025705312, -3.244471652097078, -3.2684156918135456, -2.8094583170016447, -2.5658161546313742, -3.51907432239538, 0.3663539727856013, -1.2285088214945719, -3.9326492135891997, -2.9010617939596486, -3.4964969481727217, -0.2103304503738631, -0.923156294852772, -3.84375823347667, -2.73856224312793, 0.9898672033799423, -0.8280638129961645, -3.9644299039215003, -5.159285813291726, -4.570963315612207},
    {0.178051093039652, -2.8821400007387843, -2.56500678446444, -3.970249416360796, -4.9729273403639835, -0.840791006106055, -3.6817994482447656, -0.6398568841286839, 2.499263361241044, -3.799673917142544, -2.2926827468675905, -3.672227731145839, -3.758429174830949, -3.4104905072077485, -3.1937006841369233, -2.3846052233694013, -2.5621388022940077, -3.3205114365182955, 0.30227396386404976, -1.0617413207497501, -3.953898822043754, -3.0353550233858915, -3.5955901863693427, -0.6307644033488378, -0.9952954131712275, -3.5964290856619794, -2.601598236635688, 1.2488388422536638, -0.426615563260225, -3.435720659197315, -5.572399668209387, -4.6434125488612725},
    {-0.1542608677881697, -2.829528375604772, -1.8009526599653125, -4.37519151717844, -5.202947658828436, -0.8150365230918194, -3.089216968508427, -0.5636498522057923, 2.6805118815523588, -3.3161229709821924, -2.292721539995131, -3.386982354895194, -3.134353999569858, -3.0970310817616413, -3.004526520071039, -2.416975750146795, -2.0860607848474335, -2.805608445475767, 0.46008003596413966, -0.493806697415383, -3.6943908212816816, -2.74098798811438, -2.880610033378435, -0.6030233403213013, -0.931031809560836, -3.5083998694900687, -2.3113076979148217, 1.3327140528277504, -0.34921492919672015, -3.1651649448509884, -5.27411252526814, -4.8840723556729015}
};

static const float b1[32] = {6.505722357728701, 6.203243883384099, 6.054235845437616, 6.078627160296928, 6.1466973620898955, 6.14072294042783, 6.041037543275135, 6.532571339443967, 6.20003208275708, 6.182787239584515, 5.995347533688078, 6.142748625797816, 6.113807473029936, 6.200344364565446, 6.072208223994778, 6.143797203906361, 6.101393335686281, 6.068154816083364, 6.231821284499342, 6.1977899372031215, 6.401226746716256, 6.226380230788851, 6.133587268652461, 6.335241379371186, 6.492415680869172, 6.100012483661146, 6.058701803354221, 6.279835415844112, 6.279348845313766, 5.9641795580309305, 6.182202215888755, 6.20136872367186};

static const float w2[32][16] = {
    {5.4254183517770205, 4.7637040908095445, 5.10341040965526, 4.34213017649442, 4.975524415801085, 5.3627582084175245, 5.1056290096902, 5.722542850005708, 5.196635884568546, 5.272138142214567, 4.776764997617759, 5.122286193833743, 5.019196214629916, 4.6771476759094135, 5.167687350871371, 4.852800001077405},
    {5.746846986324378, 5.416383064103772, 5.748405133755209, 4.836947278516628, 5.395050830006128, 5.871199445522933, 5.519014598272867, 5.60031495269727, 5.734435770403038, 5.636961875449933, 5.377892256890779, 5.1277301130838335, 5.493012466477738, 5.134658479473835, 4.961764328448972, 5.894956886236271},
    {4.7280916165776405, 5.114577318972974, 4.8320151904331174, 4.249089860618118, 4.668037232105746, 4.987244425509825, 5.35616735822389, 5.4091976230309, 4.801131578114712, 4.733867704078162, 5.5847266484532145, 4.671479989303784, 4.7200021242658545, 4.24909236649234, 5.359221270266544, 5.176553268497671},
    {5.9426699115974, 5.465042448583733, 4.876473271119786, 4.4985535323999315, 5.176547280061528, 5.5640343641212056, 5.69046595930171, 5.99958797405019, 5.812721792517393, 5.166171954915584, 5.21184493496009, 4.961007577322347, 5.519946661194943, 5.13539654526903, 5.026952209660642, 5.499189418022975},
    {5.47674836866844, 5.897523977898275, 5.8854764899040335, 4.980777006007106, 5.567945241720668, 5.688338594327199, 5.856893548906054, 5.463718573936441, 5.887741401050362, 5.051428639745896, 5.82030789737171, 5.7446949328311785, 5.555456052489116, 5.1399849757638485, 5.972221352469141, 6.221764707679185},
    {5.960858168251795, 5.342223525696434, 5.852396371660238, 4.9535104252365425, 5.617233349168163, 6.115776246030368, 5.705249141890516, 5.687385186106013, 5.778460987627043, 5.531264186515971, 6.059287896759585, 5.3522359222772975, 5.675670553589285, 5.287337886727211, 5.451295588849317, 4.998266447950332},
    {5.266993632985, 5.019410140522842, 5.438641215827536, 4.595782498265058, 4.662533357086635, 5.200213371199514, 4.950384093746291, 5.156629132636262, 5.338547198830494, 5.027771992230269, 5.247721199758284, 5.1089091884343665, 4.509644111944974, 4.705331159318926, 5.063217105361636, 5.1748555979714945},
    {5.0025190713499414, 4.642482127483927, 5.009178250500381, 4.562984112253348, 4.831639735501158, 5.2402984099419445, 5.29837824227024, 5.292772738778163, 5.369952515153851, 5.248256431943296, 5.505733839017507, 4.32083856603597, 5.208424411611579, 4.698174550323267, 4.80853208026281, 5.672237782843393},
    {5.455471791963089, 5.649644034696224, 5.591341593284751, 4.947074763098505, 4.953420181967514, 5.614179665258667, 5.422202379977388, 5.282623092261124, 5.543283683327377, 5.018490724801526, 5.278956282442887, 5.030278643713197, 5.470286675429492, 4.880572250464071, 5.265537134917932, 4.880600788523345},
    {5.199024743927543, 5.018584809073181, 5.193643367130561, 4.367906752365111, 5.039594022513736, 4.911386545894166, 5.01015327281771, 5.256282301897132, 5.444391655697939, 5.089343186394826, 5.177102613488741, 4.527543545802289, 5.095083137781583, 4.6953104721425385, 4.970760074113981, 5.136929734990029},
    {5.1857940071680435, 4.859875883248866, 5.283940678838871, 4.048088385989594, 4.979105305786183, 4.607944776524664, 4.674809612493169, 4.747363942158434, 5.166708331059337, 5.3147811873540665, 4.765750441574703, 4.237479428168318, 5.130783261626203, 4.619691686918956, 5.4563231181106255, 5.501169968517242},
    {5.246040491669515, 4.716977052543881, 5.280283431027058, 4.388029482608571, 4.810689641578313, 5.414980561725093, 4.621821955806018, 5.010525984132259, 5.530000246828348, 4.834347624468483, 4.7544520215652835, 4.584642545977528, 4.974486748288653, 4.01215991137833, 5.173309693070101, 5.114242468834599},
    {5.231077304672652, 4.812371651299481, 5.556784531155329, 4.1261538524807495, 4.388505043225169, 4.8651175779262275, 5.363293815343604, 5.8040126677810004, 5.190439430081191, 4.959595452618028, 4.882189147277682, 5.046658467654396, 5.008561769996803, 4.387574223007033, 5.34029108276248, 5.049168036523384},
    {5.074618560715275, 5.318096444469645, 5.3096722251836574, 4.325886277485688, 4.7784413378691655, 5.650111873277526, 5.474213670638647, 5.147222592849409, 5.119603948515942, 5.240842166816268, 5.377847424098295, 5.183254527144568, 5.14051966996703, 4.547841800095664, 4.862290809229176, 5.116010999851622},
    {4.780922419707426, 4.449467737700592, 5.429988415441947, 4.3747348456446655, 4.995706771475758, 5.258073244171862, 5.298357714841565, 5.138482666362619, 4.7017691738002645, 5.116189448818254, 5.381677946951886, 4.243354929857802, 5.118392345505501, 4.304276413164602, 5.437594444903193, 4.968480955339493},
    {4.973185890891468, 4.777039070185816, 5.043185240147429, 3.4962575306229273, 4.8409994418547635, 4.524042242004558, 5.517640704626807, 5.548737521553681, 5.336273694499512, 4.916268195293904, 5.355006985561022, 4.974311641031692, 4.588315581803775, 4.490059765192314, 4.65517218036823, 5.226877618194582},
    {5.132035827372221, 5.439998582365687, 5.1180793680027294, 4.024556446131867, 4.3912104323011985, 4.596918767776801, 4.791866538038291, 5.586364067422763, 5.1486342175122415, 4.965761145741924, 5.021540595623235, 4.969801446048454, 4.605096838102823, 4.544208999172123, 4.964283272479567, 5.152299544396558},
    {5.13259344057284, 5.354837588236666, 4.969896918631096, 4.541230030738579, 4.717050022989101, 5.395881562535069, 5.0933064317131995, 5.415014514987377, 5.179309047690957, 4.991395302463068, 5.367478106588486, 5.035638621477195, 5.088155305122165, 4.419963148558984, 5.519162371199903, 5.27082666523054},
    {5.523699118095997, 4.481183965006849, 4.832761631116667, 4.487997232716055, 4.947192661271897, 4.83020106184877, 5.1832999647758795, 4.681934436766635, 5.299300359987822, 5.159548503930705, 5.254640842832245, 4.232166701003852, 5.397316867451563, 4.836462500570528, 4.905102709454789, 4.857802855198148},
    {5.398793301738375, 5.1128544982145865, 5.333842574996941, 4.387262765482712, 5.068659191604898, 5.525211839377107, 5.30558636355762, 4.939035682616913, 5.1318055809936975, 5.083576841675976, 4.618256958366537, 4.86152552129605, 4.973549315518998, 4.385961963973983, 4.830767378277296, 5.073541365032451},
    {5.779663483258967, 5.491615751929893, 5.5231827164010605, 4.618483344918776, 5.508493103340016, 5.705649820575727, 5.503905016146015, 5.888801019079694, 5.946971221126459, 5.514571171359531, 5.521727650843793, 5.431150226367337, 5.653745447896186, 5.204682462360495, 5.719302082461053, 5.493393878475361},
    {5.622646672738178, 5.499700217011767, 5.484351704364231, 4.377051598617095, 5.09547154237796, 5.231597480937537, 5.6525331145903985, 5.7009621205877385, 5.6385582474270874, 5.403617472394162, 5.643952069721429, 5.077044711986811, 5.416198592694179, 4.933905416859413, 5.539022115319689, 5.494560398566304},
    {5.1249912701871185, 5.264739081714135, 5.104367318007715, 4.13922234640835, 5.039749744527512, 4.788080770752738, 5.24311324265168, 4.988300586436498, 5.446413351888384, 5.206300550989019, 4.836148353033048, 5.117867005965549, 4.739349683062464, 4.230355061368974, 5.3501944729798065, 4.846320349526205},
    {5.446253927872878, 5.054410021143979, 5.250322912640909, 4.69274886156975, 5.134275577114201, 5.641103501345199, 5.03001235075694, 5.12674694772806, 5.60472876512502, 5.040151851966005, 5.654945399851486, 5.229857358769192, 5.021308863781215, 4.883260537346284, 5.195888906055501, 5.196857096450604},
    {5.144799877766787, 5.247561365000289, 5.000425857308298, 4.503049402395951, 5.068902334894413, 5.104710641226393, 4.713747590374039, 5.772569202391706, 5.336555324925787, 5.249250895207348, 4.8624446445663345, 5.365706864612655, 4.831632125209463, 4.250929054287053, 5.119163913911548, 5.151722853515058},
    {5.004242006064901, 5.066121696845637, 5.124472046583312, 3.8792992441580587, 4.998400776045527, 5.353791633874505, 4.917475615100885, 5.368349161908454, 5.6373833267194255, 5.69110449154477, 5.626658536618211, 4.768646812773098, 4.998339099946128, 4.284884706570363, 5.749280727271216, 5.4382018050973056},
    {5.102994125858063, 5.177472735265183, 5.27512327197485, 3.8437053210473446, 4.567654065241425, 4.898150927412119, 5.243539563438126, 5.0896822561156565, 5.587621083103439, 5.310539972726933, 4.843683831978025, 4.968321367978842, 5.035610694600234, 4.0796052328988335, 5.59060794493469, 5.135674783533104},
    {5.180671823022683, 5.06813945753316, 4.92417247892846, 4.394496517655728, 5.11674413969663, 5.223710471658564, 5.5718533070725575, 5.443065426845642, 5.395198275432311, 5.187003946111955, 5.375381045389354, 5.051267008399449, 4.967552917065591, 4.3328836464835625, 5.085694952777466, 5.92383588232183},
    {4.9820432359953255, 5.302015654615574, 5.229993304597217, 4.416074085920548, 4.714408650297719, 5.551294373574572, 5.825787293331228, 5.317960905887105, 4.940200101607174, 5.200961257700728, 4.965231603587851, 5.037401977049171, 5.11783495057907, 4.726747791969082, 5.626782047121776, 5.359133753071952},
    {5.3580288700676535, 5.118714488898832, 5.2536482924469485, 4.476801655919612, 5.052123777962081, 5.24005883598312, 4.9747270463873345, 4.822250664502776, 5.53084992287481, 5.27721793356065, 5.276566818558793, 4.857946739424384, 5.266576984822276, 5.086540188144224, 5.232219428530918, 5.283217243890643},
    {5.691469926871109, 5.71077569271281, 5.81657977459045, 4.6562464873625515, 5.401700130094248, 5.712814815244928, 5.374493890483601, 5.659429348428543, 5.7770403010339475, 5.48672149705682, 5.685100714150593, 5.6441008116183475, 5.268864965361331, 5.334687481813409, 5.939264626739679, 5.949091336678235},
    {5.668536127435664, 5.016206481188633, 5.062021517050423, 4.576417205465837, 4.885131953811058, 5.638552573914898, 5.342084463696479, 5.6466667273113815, 5.485475799903213, 5.6466454679488205, 5.129846702777208, 5.106705665574681, 5.627404097724908, 5.272362385472996, 5.305848898206184, 5.596582506711453}
};

static const float b2[16] = {5.283039204729683, 5.1297083833093415, 5.2127815178802335, 5.358454637557278, 5.432280950674434, 5.116843169592782, 5.380896900382785, 5.142008460934436, 5.280794081977319, 4.973772151021221, 5.30552737415229, 5.307628802184001, 5.273488033156888, 5.149729738051314, 5.327132859866365, 5.151416933675684};

static const float w3[16][12] = {
    {-3.5386675103037875, -3.5060267314261226, -3.446840850766379, -3.124261060872252, -3.3884929552446232, -3.524333074165198, -3.8940309394945176, -3.462690418326563, -2.9375890946495757, -3.739027374599907, -3.5797134954751457, -3.600659485089173},
    {-2.8011861234547304, -3.8304627214839617, -3.6116292293224452, -4.06619715295732, -2.919850474880236, -3.2025128189092933, -4.304803133359281, -3.371936485389484, -3.116687718047589, -3.1361110219769737, -2.8334576879335684, -3.946638063438144},
    {-3.305128808120653, -3.0846752674155473, -3.2704304976648975, -3.181678426043145, -2.9751697813230304, -3.939558231353152, -3.9043834972182654, -3.9037066873889255, -3.417501715423285, -3.904684315345295, -4.414237075060628, -3.095464371758165},
    {-3.275844742007121, -3.4850132086398107, -3.35731282027518, -2.8818890082224726, -2.8067009860656427, -2.929360960446504, -3.534832813597335, -2.9366982053573203, -2.812637282801616, -2.9136593011513163, -2.83714994310266, -3.3043798393182606},
    {-3.2982657764073804, -3.48071489959471, -3.833568858774452, -3.7689883907818116, -3.6215851032154642, -3.380192513262959, -3.986213604458452, -2.666943328445543, -3.4486045520153548, -3.320238658032907, -3.3378381541822977, -3.813917756559167},
    {-3.920019678344618, -2.9292957838648097, -4.02923948404034, -3.8461169513193383, -4.150590886406315, -3.1382970146719398, -3.1423289878079115, -3.1365031597589703, -3.9298730404428674, -3.6941030925663, -3.9974954195001553, -3.4051183263898253},
    {-3.365258320106151, -3.2613229250519766, -3.3460743898266303, -3.3253615450905984, -4.220330675024508, -3.2306779418408245, -3.6223807636733056, -4.296369720008718, -3.2859576730077613, -3.817406740741332, -3.353741572183758, -3.88669150062513},
    {-4.034427422341614, -3.589126713583294, -3.9105283034576837, -2.940895605211433, -3.3695597068781917, -3.9339306744517795, -3.290663731895411, -3.562470070914943, -3.4193876311199283, -3.906908814597703, -3.728951510924043, -3.8323415738733098},
    {-3.504480669646936, -4.172133572031196, -3.3733710260359717, -3.601991314205976, -3.2840446932200145, -3.51517080330896, -3.093380908717761, -3.5422437944791305, -3.855262616819575, -3.6742367242537366, -3.567796135034037, -3.4516974616011353},
    {-2.899379716957889, -3.3692227400961263, -2.9295208222427696, -4.230275993965719, -4.304107859303751, -4.5637214854632555, -2.7306178863715136, -3.3962156649837554, -3.4484378722934674, -2.879310384295452, -3.6599663396049467, -3.1201198515466846},
    {-3.6225678528065735, -3.629683066159405, -3.1088792508791734, -3.6507266471823416, -3.723991423774438, -3.364912771960768, -3.0107131127149587, -3.47294310355856, -3.243990080262242, -3.067699857098032, -2.529392508865386, -3.1337706553868045},
    {-3.9690929250933946, -3.465072329387355, -3.902631029131005, -3.4683098853692376, -3.464432434490441, -2.6277577445390867, -3.370736319433614, -3.733914282802903, -4.086379278159588, -3.52711119378703, -3.6528367815757408, -3.163273057289023},
    {-3.6246161275304303, -3.230123217632174, -3.5358262123361035, -3.492140507839574, -2.8430443024832344, -4.208765893979187, -2.880911891416913, -4.206739915907268, -3.482794511348973, -3.4875379319557336, -4.274538639256283, -3.640452256645085},
    {-2.957088885185121, -3.2530738538900286, -2.9716411062916697, -3.012913724384679, -3.085122784077127, -3.080878426800505, -3.114959712880965, -2.8867319067852772, -3.2226364479110456, -3.02078269765555, -3.2927206610009505, -3.1192858672821995},
    {-3.4704203782630985, -2.8968671843991953, -3.2686542318948937, -3.3567341129136063, -4.047805948235892, -3.1858286582931883, -3.8046734215139826, -3.950382277101909, -3.5770624771493176, -3.281172346044465, -3.3859200088994155, -3.498037184904505},
    {-3.8310340160509604, -4.281878174019187, -3.6655093513760635, -3.5291784193159663, -3.1941346373884767, -3.527981737402306, -3.848089331228435, -2.8622850392469132, -4.15472637134647, -3.8668640197158513, -3.0689562453490558, -3.4132815898441304}
};

static const float b3[12] = {-2.1783974205777805, -2.1507174686330637, -2.0222553557072005, -1.5997631283875438, -1.737491685061434, -1.9170918521394016, -1.768163009346955, -1.7186609213411077, -1.803286193096745, -2.3078267852015526, -1.3224458249283266, -2.070296256131006};

    // Input Layer 
    float z1[32];
    for (int i = 0; i < 32; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[16];
    for (int i = 0; i < 16; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 32; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Output Layer
    float z3[12];
    for (int k = 0; k < 12; k++)
    {
        z3[k] = b3[k];
        for (int j = 0; j < 16; j++)
        {
            z3[k] += z2[j] * w3[j][k];
        }
    }
    softmax(z3, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
