#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][16] = {
    {5.447038286946939, 6.321269195698582, 3.0076406826885207, 3.3056965181180344, 0.7486683532251802, 1.1209421006777323, 1.1515758562077252, 0.9853843530879617, 0.9733689296433501, -0.4065015358428658, 0.8471661514391038, 1.4475603662622274, 0.8573162410062605, 5.309347694162868, 0.8118522050540735, -2.1610848308151014},
    {2.965392778875614, 4.803053095496747, -0.6591703297516297, -0.22117450197297964, -2.4352160727318157, -2.671378456858644, -3.1090899271228167, -0.13039830177461742, 0.014389641546946629, -2.8214992077144454, -4.024152764211387, -2.159958649489693, -1.7550588805535121, 3.724729777490306, -2.4126936420674197, -2.312432078311161},
    {0.8205977939759206, 5.2432789056299365, -3.2389051313299357, -1.9758724725434011, -5.093797524360545, -3.6137016368328956, -5.276378504358227, -4.367232341405158, -4.697900180676987, -5.032531638530051, -5.91126699871538, -2.4811066737439167, -4.886033908024408, 4.5740624331073185, -4.906256574788321, -4.759978748476138},
    {2.4686103963527035, 5.981561576721122, -1.6769084091224418, -1.8928177725048987, -3.5512596214445775, -3.1404817585660876, -4.693497935495283, -3.6375068101000116, -1.155916130318233, -4.022770793142233, -4.820904051697449, -1.7699875283505688, -3.677858344122491, 5.030495825858267, -4.548679762879, -5.191168760569091},
    {-0.7358184574788482, 5.075832319533639, -3.638742452530842, -2.2824546524659204, -5.20220637728072, -4.19950228552976, -5.130921958353821, -4.428057804424306, -1.9620624799686834, -5.11964338224889, -5.359782579077973, -2.837255761412321, -4.727142711764361, 5.195705666889971, -4.977802298498225, -5.481655460166544},
    {-1.943106761181339, 4.134554578708441, -3.9446120455190155, -2.2147811733957887, -5.404628753299409, -4.162437683313842, -4.912682250989011, -3.9348701807343183, -2.2907775481749093, -4.961003999366959, -5.012700716822978, -3.2733589230986304, -4.483274729216905, 3.889566860123869, -4.471961280440938, -4.887403239148352},
    {-1.3279309353256241, 4.188621265131751, -2.820230476878345, -1.2009996169025516, -4.813982756383467, -4.025252318572938, -4.447656104887654, -3.1718880303532466, -1.5313093947241347, -4.447607421138695, -4.897501697430078, -3.2358962063064056, -3.682985884682417, 3.3419225309633087, -3.9751387178570643, -3.9897699542118774},
    {-0.8856498091756556, 4.356148493580676, -2.664354140749962, -0.7143380683899052, -4.314623401231574, -3.774781335390695, -4.2415376909794285, -3.6929686566699464, -1.6700371405999457, -3.986657213561649, -4.938054422205132, -3.243748630316633, -3.294528523456427, 3.166011922101988, -4.454896031137274, -4.257511501713305},
    {0.3454554335549641, 5.085968153151633, -3.161869079105349, -1.1535202078981328, -3.2253498802771343, -2.9273977590618916, -4.379328174685145, -3.7957605337291125, -0.43211282702867987, -3.3765607502888733, -4.62314705133034, -2.8479461904469034, -3.078423649651224, 3.943759492662441, -4.316591695641676, -5.065222796019285},
    {1.4299912969653383, 5.8791768632313905, -3.2509834541777516, -0.8391144193478861, -4.308206885381569, -3.272251484810953, -4.553529365391608, -3.3548423491814967, 0.12845158153337669, -3.8257835665499087, -5.447561057578192, -3.1486778444837493, -3.5849456258112307, 4.579753362843273, -4.328232332033184, -4.7219778554383804},
    {1.4330826847760885, 5.362956856844374, -2.812224879938158, -1.0806921756105672, -4.120444788421208, -3.03555109786511, -4.189000320999282, -3.084453490406737, 0.46533501662522625, -3.3042334249274368, -5.033217840688527, -3.3802498546893482, -2.6198500443345867, 4.658790815831665, -3.588279555678873, -4.124023846655749},
    {0.4522846893743408, 4.975182337315314, -2.6729200545546328, -1.3946620963033534, -3.518741589684696, -2.6785264214742357, -3.45628907537689, -3.7136356486793063, 0.6776470027299292, -2.9875732677156144, -4.548570617677494, -3.4654902242715457, -2.95914374905572, 4.65473424422367, -3.3574048261947818, -4.3576600272776025},
    {-0.10420837352441294, 5.173132917065918, -2.905543034445166, -1.4996528524915815, -3.7674964579491976, -3.279387903846349, -4.152504693198361, -3.942688447905708, -0.6163969826153882, -3.4982527885235526, -5.2697785277752, -3.3308868890725125, -3.5576481115446845, 3.9341470641713108, -3.936873520496722, -4.308876566357316},
    {-0.892412437998707, 4.716156437861729, -3.3378054413012404, -1.9269270005986445, -4.117219755834366, -3.9601661399822263, -4.497825853911731, -4.686451689846593, -1.7491702385475691, -3.9964647160854097, -5.461274433411877, -3.6587569484029268, -4.236016066518795, 3.628513728381319, -4.291042278674992, -4.903932220836348},
    {-0.6663004159441, 5.370345741013802, -3.234187388064905, -1.0991589254008898, -3.7909798379949087, -3.8632536744241053, -4.094610728762075, -4.306831631106878, -1.9557680433152156, -3.8773516197685662, -5.285369234367944, -3.880905477354617, -3.5094983694577104, 3.554398488733077, -4.265166710215454, -4.386117956790797},
    {-0.657954911101208, 5.45236152120797, -4.486030998760432, -1.4733035555834313, -4.095257143379812, -4.099981382738852, -5.106240498789788, -4.180985255921939, -1.709891829555019, -4.2251275748791794, -5.979275013196982, -4.1931435621369815, -4.300925084184369, 3.9613242908912927, -4.863394522111496, -4.4416413379371695},
    {-0.9450376469154155, 5.765962781185592, -4.608577778903095, -1.8242239351421419, -3.588593626465179, -3.617505508307149, -4.8954004329004555, -4.175228495255175, -2.09074293711396, -4.105098408786825, -5.938486207445444, -4.125652855389145, -4.359878150875379, 4.488490097961313, -4.916587948292997, -4.835674971885155},
    {-0.37134087382078734, 5.855369554522031, -3.9397159114583062, -1.0109783235748084, -3.6195068235293424, -3.3479300383968478, -4.463730235178407, -4.338829212774018, -3.2595524035428687, -3.8692948863542265, -5.489751926536256, -3.5647594891256986, -4.330736204356969, 4.809932052856024, -4.208446483692485, -4.764311008641334},
    {-1.2989730436880962, 5.805765740579452, -4.154356986425049, -1.525661664350886, -4.4552447817832705, -3.4593512500586012, -4.093755490257698, -4.845504402144414, -3.0675797097091513, -4.05013499775854, -5.479862263891968, -3.1614956143392576, -4.053214147210606, 4.936147130038794, -4.1800992015709255, -5.059749954298829},
    {-0.8257829453645363, 5.760199388307746, -4.473046119976726, -1.5086539201777045, -4.506217973072064, -4.047711461453323, -4.516275732458931, -4.646500849318686, -1.829551973151146, -4.183989111025623, -5.082822642092504, -3.6753594183114737, -4.016922876241657, 5.106405773004857, -4.091617857909897, -5.241300578264385},
    {-0.32882411898289665, 6.126534568827958, -3.857531397538019, -1.6415011118711131, -4.237521469823731, -3.8328437390799657, -4.339639708504122, -4.155642346875309, -0.7603332702995533, -4.077714628652072, -5.554543295593822, -3.389841848398772, -3.863468386572009, 5.293511531085565, -3.814601520926407, -5.302547865673489},
    {0.8818867977524215, 6.467876503041803, -3.102885251384095, -1.006284159319252, -3.4753091576050306, -3.1337192218298746, -3.990554188468393, -3.517711430788726, -1.3994467530473267, -3.932806610509397, -5.0898595180655954, -2.789653534934517, -3.219630401641639, 5.796454423616315, -3.5474763617632163, -5.145036743032257},
    {1.7981760498219101, 6.579636638717452, -2.1734269553350387, -0.20218590802945346, -2.3980939836506563, -2.689111422560046, -3.364478773618944, -3.2911004921886176, -1.8990253418968237, -2.7504031445073567, -4.787136018245523, -2.626680695299979, -3.1146809919059546, 5.513242993128485, -3.178906636421805, -4.81541726059508},
    {0.6794396774408974, 6.1681721363814335, -3.3345794408089637, -1.2308419577409009, -3.099224618666354, -3.4321483590079045, -4.0547814082820635, -3.561318458675516, -1.9093942124860568, -3.508443899563348, -4.955158541423454, -3.562126639886848, -3.4817182922133854, 5.151540184579902, -3.9213922834694506, -5.142063153597673},
    {0.6608784282740385, 6.018302013145434, -4.067642532646263, -1.4604271686682824, -3.4666164292321917, -3.228167625586042, -4.6518599460027215, -3.2816597614555247, -1.1892382976854916, -3.7505663883326585, -5.1067159290239905, -3.1630980327323095, -3.7186050830521715, 5.120183093027503, -3.6976952422196847, -4.621502645990352},
    {0.3584600566151871, 6.1342941130613795, -3.5178839434382136, -1.340804315326861, -2.9349448116473393, -2.8311826323631046, -3.7472703605206696, -3.357186077071444, -0.9675716410164099, -3.3958505193253856, -4.625260277273735, -2.484043400298133, -3.487000107803632, 5.394382392159608, -3.19527820853186, -4.189270405465195},
    {0.935285683625968, 6.266067978338257, -3.5432528708102504, -1.284668230739493, -3.5153275424612813, -3.2907969007475586, -4.589375965698211, -3.4070430331755297, -2.2725333935302596, -3.6980096902038686, -5.417831926195572, -3.3292027890076747, -3.7901765780504695, 5.381516540720845, -3.7860485340319014, -4.219877715642786},
    {0.529761975705905, 6.47988301954029, -3.480061525025414, -1.8164027323037872, -3.9588904470382635, -3.604535106311901, -4.74447204934107, -3.861515810931317, -2.2815072347350287, -4.206787314705302, -5.519804717378936, -3.5178674149829163, -4.431005087325258, 5.465465769426095, -3.9135782461734556, -5.009590439088371},
    {-0.281762344272922, 6.010263247987791, -3.939779187099266, -1.7183616198611216, -4.113342093534061, -3.9422261412992117, -4.852668728336815, -3.614505291459727, -2.0781065660106615, -4.162334182766801, -5.7481781771634815, -3.6388126697611636, -4.35601172191842, 5.315265577659604, -3.863045186138795, -4.315376930740846},
    {-0.16743153500030908, 6.231460044708482, -4.034701054215285, -1.775618471112121, -3.7072979578238687, -3.4279549219751146, -4.934391404903389, -3.4892030346475695, -1.7525211802403275, -4.015144156596545, -5.695351138267651, -3.460168101643455, -4.95954173779959, 5.32192626189917, -3.6075146342982856, -4.666474689092391},
    {-0.0030505577371756224, -0.3977459416852237, -1.4193646063759626, -0.09620585746803277, -1.573758176389929, 1.1025484286660467, -0.38998924930467604, -0.10250776165509941, -0.7126130722230674, 0.5989295289993687, -0.9362529835502583, 0.7366373497588197, 0.13801232319009976, 1.068450709721476, 0.780402767144122, 1.1094277886404764},
    {2.208702347788464, 3.999847358855754, -0.0668028729319235, 0.3634576649671417, -2.4680634598155375, -0.9474807843335474, -2.729013305433172, -0.8820686352955056, -2.1322359589472, -1.8954303687341678, -3.0158169575094167, -1.5908688318533437, -1.7336253423655945, 3.1190407138012306, -0.3203239968786863, -2.235460235934497},
    {-4.371578043395613, -0.3540835067025662, -0.6686235261531283, -2.0531486532868977, -2.4755613147593922, -1.5824829856832723, -2.2113255157398166, -2.1990666964195937, -3.6092224805884308, -1.3639829047433463, -0.12436708121974795, -0.47972659426980496, -2.6120793819662502, -0.263061571347319, -1.4531723584407916, -1.4656023347364222},
    {-2.9016885439698474, 1.0259698384382825, -0.16882051351761185, -1.6216835918715533, -1.481086850652422, -1.603397838516565, -2.2424058448653166, -1.1762725514869528, -2.0502873033906055, -1.3750552698561425, -0.6984364562136154, -0.8600681308037492, -2.452944518121478, 1.0386600177742147, -1.2591142441814691, -1.3853244689489999},
    {-1.2541396561615994, 2.632524129467818, 0.10062954682430474, -2.1974156217070187, -3.2520089250901574, -2.426864685500441, -3.7469059337615285, -2.575095392462012, -2.6264032111304245, -2.9792084562064796, -2.5979376124377738, -0.03354486715695924, -3.4064122403256096, 2.716560592018679, -2.854682362404025, -2.5618101761155767},
    {-1.1013605354271687, 2.520974016589659, 0.8746675192655802, -1.3801138173090552, -2.7163362211867077, -1.9511422742942741, -2.9337211556199323, -2.2158677035213024, -2.8531457324500096, -2.5621946904518698, -1.228908084514329, 0.5125537062310266, -3.030047632190101, 2.0086281607336938, -2.119113306773037, -2.1123144484883536},
    {-1.2330825978108093, 2.5017654507160745, 0.2611266704138824, -1.4974123370139054, -2.7594402552824304, -2.106821043667363, -2.820520868195777, -1.8917655870657855, -2.2082495579088928, -2.2016073811482024, -1.7719491558840663, -0.4168635233306242, -2.385632836389622, 2.435896544160277, -2.323148044884563, -1.7015388490163865},
    {-2.3755646704270794, 2.0529713676404895, -0.5255397195264441, -1.5223720243962755, -2.4294149478511566, -2.4821684376998716, -3.168677009013066, -2.814760665337901, -3.895497350575818, -2.6155596036413473, -2.1935112127425405, -0.9285051928743184, -2.6243789236836563, 1.4523200565493088, -3.0071215360749486, -2.302753461501293},
    {-2.038016635353208, 2.562120382882256, 0.08088088632444547, -1.8905231908015727, -3.3166214791377304, -2.3944513542873502, -3.6084939941548435, -2.4702869264333263, -3.3646791929690147, -2.6731014252970007, -2.275997734379441, -0.517018668105585, -3.198961476529712, 1.951107344170549, -2.7360075983955934, -2.844001616851258},
    {-2.0146727173829713, 2.969131379802408, 0.11712163639045002, -2.7423566724055064, -3.3956248698268094, -2.9458299958925, -3.779420950161746, -2.948763666406321, -2.9220318301388244, -3.2967064593516424, -2.7281656119796964, -0.031162208976336148, -3.2153048763497307, 1.9064541880705212, -3.6545500992654523, -2.917089939100209},
    {-2.3684951125994833, 1.1956523517421564, 0.01898115771272829, -2.9160051161275082, -3.146708870988082, -2.4349625642880133, -3.6445549842512013, -2.2365834015492867, -3.168369442214766, -2.895969627861907, -2.5185832054610056, -0.957245527767281, -3.1348481394027337, 1.5702519997602806, -2.5543206135881267, -2.8003116424638406},
    {-3.616773747096717, 1.7964889392847818, -0.26209376815372604, -2.9442293317528847, -3.8497880468642682, -3.206098446425074, -4.167277486100819, -3.0509570879990195, -3.524685325308475, -3.3362700099086364, -3.160115098495982, -0.9532217706120933, -3.6710251036010884, 1.3275218454326358, -3.2456967575227766, -3.3897352169800854},
    {-2.4057626912881185, 1.6293690603137396, 0.9794168399402993, -2.6597889628848024, -2.9751414126316384, -2.4264690494542474, -2.742807658454392, -2.744321650554236, -2.651250103066276, -2.9673629263830934, -1.8703819249228395, 0.4575128763208815, -2.718477819522312, 1.3720936949051183, -3.2175488845144846, -2.248033861065489},
    {-3.8903255886221944, 1.5177875470166664, 0.41643509708001264, -2.7988315852928696, -3.377319643240337, -2.638418732389921, -3.744188235130024, -2.97038002588823, -3.7593207997649465, -2.8780946793775666, -2.1943818413007152, 0.026154823765909517, -3.458554925234833, 1.3805766603309517, -2.804916239633069, -2.6904064793677867},
    {-3.2349185093755173, 1.3012085489105074, -0.03360433711198103, -1.7661638352128934, -3.0423971839045305, -1.8362205153502942, -3.130479233350398, -2.0685087058759883, -4.005428461618054, -2.2940397170547215, -1.2604456547677716, -0.45306485126253676, -2.7896053126882805, 0.8209530876434593, -2.276579435675559, -2.128388284344441},
    {-4.285183252421586, 1.0272898512083597, -0.2934919205552175, -2.294245245328599, -3.3251543159962145, -2.422814756470431, -3.7933475019344285, -2.33477347634773, -3.967802482157309, -2.8588814253016137, -2.2095631491965855, -0.2010402234901113, -3.162399058926729, 0.3790241108728073, -2.525261997798221, -2.904005713373127},
    {-3.871486759900861, 0.8785709226836973, -0.33695213360299325, -3.258980341799522, -2.725667680270861, -2.787832133556773, -3.2763487965033407, -2.6117844867386517, -4.537630667475316, -2.8410883865608167, -1.3296236617276123, -0.8536211614264195, -3.1589059096199, 0.2779492299862199, -3.297135971949918, -2.4287458093770256},
    {-3.4260567111045974, 1.1069092659617312, -0.3494736184355748, -2.3558751750569784, -2.8522604728766825, -2.6758953379212596, -3.2662267426008866, -3.2387214741248425, -4.998358711626549, -3.02638465621569, -1.66465408374045, -0.5829740892689285, -3.2695259856167724, 0.18315291707417083, -3.22675845636693, -2.7022700252950727},
    {-4.703409140557606, -0.12381984001786309, -0.09404398782860104, -3.3178915793813606, -3.360458173817611, -2.5300720957198037, -3.5644688710803916, -2.7922992100882453, -5.053706044660648, -2.993383271377672, -1.573191627299061, -0.3833206758276634, -3.942702859406248, -0.7626801338943122, -3.152174044074229, -2.2012838492238367},
    {-3.9418874273772047, 1.1937955588239988, 0.32580863246285696, -2.744527226696684, -4.122923584381436, -2.6871410834705745, -3.835706069084641, -2.521183936605758, -4.657094794553351, -3.0104830336084727, -1.508375015367375, 0.18567022745941505, -3.8768009283746885, 0.3074845621865659, -3.0024769676496397, -1.8726298864372466},
    {-4.661007422288997, 1.3485636128823455, -0.4215098712230007, -4.655227597595228, -4.553049263685759, -4.013481689861078, -4.703374870391905, -3.3082669923513817, -4.173923437159412, -4.060684401802425, -2.758131721270177, -0.701313158888519, -4.519264052022762, 0.9600400385371591, -3.6463636988130808, -2.9486760416964723},
    {-3.5922905700890864, 2.816406794185556, -0.4156297675776744, -3.15697146521778, -4.761129957170816, -3.248148469942231, -4.3797096776462245, -3.2795900541486205, -5.0899251571108906, -4.142158172127713, -2.3274657762684052, -0.4428362870473922, -4.303411469228388, 2.7672058129789447, -3.3578276230485526, -3.519762367728156},
    {-2.933407640941215, 1.7852859420290619, 1.230216727586487, -1.878757076864134, -3.0915655613662616, -1.744478211661384, -2.103785538168609, -1.686306591238349, -4.322442313774349, -2.9813405017044183, 0.8757170639383365, 1.0790053077610098, -2.6702516713399898, 1.3756967641234557, -2.3225994988571688, -0.9031583253353603},
    {-4.597262703390863, 0.5129889784943739, 0.4550028221553732, -3.174693804757922, -3.5963327261207527, -3.0327983853090514, -3.3272553107707163, -2.8776912872070546, -5.414578323685754, -3.341818682889062, -0.06545376232076502, 0.5927788294735847, -3.6680697514649565, -0.4134565924418533, -3.3270480983198105, -1.399785378442649},
    {-4.107840844592435, 0.542618994594914, -0.2019109933999006, -3.641969124813205, -4.471442647359417, -3.625854590630326, -5.170458925539893, -3.7543065199674786, -5.679275065083665, -3.6864944809487117, -2.097339336459165, -0.2465445474247771, -4.628817381019037, -0.6898339121700175, -3.811137337933499, -2.92994062302152},
    {-4.328775745075143, 0.1853656350812105, 0.9397123629980143, -3.1945425798451517, -3.248442277817846, -2.054067181212167, -2.898936403893777, -2.234956135296415, -4.878408561242445, -2.3846255685916518, 0.21497285374604752, 0.7674504590933858, -3.636445849488377, 0.49083501966478155, -2.379718598741011, -1.3492030699054742},
    {-4.150831638691472, 0.8812344855096318, -0.4200855350995255, -2.959509308933685, -4.45443742068809, -2.998197756436183, -3.889686546737523, -2.0138125302197323, -5.854314178069294, -3.1384822743530894, -1.2782719657831654, -0.1488211051476576, -4.035770232250355, 0.299891033896634, -2.7327601587494015, -1.8168970883076958},
    {-4.458740667678882, 0.46769225975209616, -0.9235307276440325, -3.025015687981387, -4.028827289834228, -3.1208984278923575, -4.590128809451515, -2.371293605628929, -5.851065164045119, -3.5594825531575536, -1.0505999135312674, -0.44864395503469395, -4.0801002592573985, -0.10492124391558981, -2.6417297812822316, -2.145519882749042},
    {-4.655427463030426, 0.17633428010749702, -0.772202774526115, -2.743872746486007, -3.7855573665293347, -2.3253269214231778, -3.646665848231241, -2.8400401536574935, -5.537248206908607, -2.969603338874087, -0.7502994491549867, 0.07309592314046749, -4.0079151428999005, -0.23244388017259907, -2.9262805491730974, -1.5529122860560591},
    {-4.159822630460794, 0.9281935888792263, -0.2810883728503772, -2.4537793283504463, -3.6939483597550957, -3.0265781319084333, -3.112384497056216, -1.687652349131234, -4.964197110517696, -3.2891220909967265, -0.13662910047056281, 0.6578429669770318, -3.868647322273431, -0.4352073200352309, -3.157532872060808, -1.6902648222636902},
    {-0.8106573408603013, -1.8442604691031073, -2.8868526307237845, 2.723153022796081, 0.5824275388275831, 2.67059159299569, 0.09835895900854567, 2.4187542008997958, 0.13390804935698047, 2.0859163966352496, -0.2239265380757818, -2.7130144442365234, 0.46995913601424094, -1.1135918397171853, 2.3926728862633397, -0.19142527019964825},
    {-1.1260349057409127, -1.4343905813869087, -3.071465247123089, 2.904914218136824, 0.48345109924210583, 2.584021113194026, -0.6183167101774243, 2.119918850441801, -0.4998443320874655, 1.6732027299321672, -0.33650708256438067, -2.448943334357313, 0.4206449420247927, -0.6872110313494387, 2.249829924220287, -0.5683279595054254},
    {-1.6780545166058307, -1.5839598327243396, -3.665404057851922, 4.060261027190577, 0.45755374662493975, 3.435749606668347, -0.326138724188839, 2.954546192665803, -0.7446747145190425, 2.6307977482087557, -0.1462106123203375, -3.0964420465364317, 0.5656938237114875, -0.6332029081358366, 3.2416521023104083, -0.4758959228827511},
    {-0.19251912301843144, -0.23671039399236504, -2.7820386332493694, 4.002167970061163, 1.8040119205407974, 3.561229813865916, 1.3867578283360984, 3.392807906054689, 1.109559974219448, 3.23860167676028, 0.971604734024046, -2.4997394144770837, 2.1151418121197527, -0.18485049178165547, 3.3839319668082877, 0.994230507363689},
    {-0.7216235111371827, -0.16771560986110032, -2.926139948394637, 3.468115031178976, 1.285337234338251, 3.137380698943465, 1.08827255875387, 3.011563162836856, 0.5898902718133118, 2.497395259259109, 0.6523195823604189, -2.834562566493127, 1.5331825647569322, -0.08045976761071061, 2.892482785406324, 0.5540171981619536},
    {-1.53652310566462, -0.7506598052017871, -3.8109113176414757, 3.7825380322042044, 0.6021937861394484, 3.0387084934864643, 0.3246419773977645, 2.865688379943072, -0.798943047692302, 2.5044827221263857, 0.3516124698767131, -3.3299620774251877, 0.6938565766637598, -0.6209199448626447, 2.7954000802998573, 0.437328151091409},
    {-2.1645483106225694, -1.3181512619230096, -4.175171828563128, 3.7531808997103036, 0.3235413572157094, 3.173666593640102, -0.17427918983893093, 2.727517522072975, -1.4416893426093313, 2.4352892770985806, -0.009135530735417998, -3.9428957766912984, 0.7112902649019721, -0.8712241692742139, 2.6940077978955865, 0.1395346758095547},
    {-1.6693204096520808, -1.77360361970699, -4.170770572620792, 4.014208295773961, 0.8731725018550093, 3.1464974709411746, 0.5325780641166088, 3.04839347927247, -0.5830467561245029, 2.807888308553962, -0.20426694878114898, -3.7375726195348737, 1.0408273133562382, -0.5107387879168316, 3.1553596839507647, -0.06241146178350427},
    {-1.4108270463057424, -1.8244958871858405, -4.349615429363519, 3.923363351747368, 1.0965649500003618, 3.5491430500263257, 0.349111778169518, 3.4745447992103475, -0.26017718052878613, 3.0634312102342425, -0.21956551253059053, -3.9827486631152276, 1.4736852770737945, -1.0124813493314981, 3.3281197185744427, -0.1730164237049671},
    {-1.2829221752668103, -0.8468618921254213, -4.330912648844426, 4.2182191492626835, 1.5048029419186546, 3.771983094819492, 0.6785060214738433, 3.35407403406874, 0.11369757870775056, 3.547910428298171, -0.11608898164935216, -4.159562241436417, 1.631436796623395, 0.18252799706761424, 3.5922935381255914, -0.20074009807809526},
    {-0.272855894249453, 0.10829011504651236, -3.426816411467863, 4.367494980554262, 1.4993055753510707, 3.9270578873425666, 1.0660431268324921, 3.2379304291041895, 0.6722404547060337, 3.4408850121161048, -0.09049320397769774, -3.604186082449191, 2.212722774729961, 1.0105487696354312, 3.2791341907889566, 0.40916460146976324},
    {-0.3924246273453186, -0.30207961957560264, -4.048545682684592, 4.649824872803435, 1.5051885801525027, 4.102886778055768, 0.9826696560387898, 3.5978286535871193, 0.4708080717421234, 3.653745039499106, 0.19769058632262823, -3.3360725686376727, 1.898597154963069, 0.8056897698330637, 3.9324492991048254, 0.8109406733057041},
    {-1.2424159996911106, -1.30663228600413, -3.872550079383622, 4.600799556446498, 0.6647511106644777, 4.159247864404209, 0.7424925909734807, 3.773471271424616, 0.1099975751321048, 3.606180455816301, -0.07264747755853279, -3.58172213316087, 1.4089925231226983, -0.2862271576668361, 3.413876703815634, 0.05140790049508249},
    {-2.2161079188770914, -1.8092764842764129, -3.8115779830976604, 3.477938647788031, 0.42467197203973317, 2.9616802974805214, -0.4627281289148783, 2.5484419581356765, -1.2972896726165584, 2.310176464004419, -0.20513852046766626, -3.905164059426173, 0.18369886808726607, -0.8480482147475099, 2.3663202614968393, -0.6967454745555776},
    {-2.3831153882936666, -1.98474021630756, -4.297088507769528, 3.366227325753541, 0.4478755142006665, 3.2043676684925866, -0.483066307535714, 2.7724964034803157, -1.1575353709301246, 2.44247075412517, -0.5454524453898986, -4.033342961318829, 0.3346571510162056, -0.48668261744093855, 2.6655089411783903, -0.4717174194517746},
    {-1.931126277754485, -1.4760029302081328, -4.649516927006131, 4.4317729946362485, 0.4819154441654952, 3.6735356214277215, -0.38314074164371104, 3.218591403420971, -0.9603833054957536, 2.8923671051071906, -0.4061304165274981, -4.328097849920027, 0.759560792442763, -0.20736241502110112, 3.201509990337514, -0.745229813349251},
    {-0.6922490049788016, -0.351829518072377, -4.258396801692734, 4.89682358831898, 1.5314697838081832, 4.102202323971133, 0.8592163586113521, 3.548760063053412, 0.20443243849268086, 3.928248535009029, -0.2658385473051307, -3.8428844709267653, 1.8514080614438198, 0.5587551188771329, 3.8003124360362337, 0.29770404455310673},
    {-1.030684082260373, -1.7859090137540683, -3.8872544053175826, 4.706807166512084, 2.121371261003966, 3.9870502355039705, 1.3957476134453568, 3.7758367774096073, 0.6399909194945979, 3.52845754176467, 0.4302952211630894, -3.694239784185657, 2.6429211172477696, -0.7216890365564607, 3.675185139512147, 0.6604275109358898},
    {-1.6710640016336378, -1.863996341301128, -4.464602470105714, 4.551581764325024, 1.0766494367099622, 3.9655593263900353, 0.8863997890407376, 3.0281137734665298, -0.45106309495398844, 2.953244876022514, -0.30348500754164215, -4.182012585361343, 1.2949152400539352, -0.7299939232538616, 3.2111918033150118, 0.3100682842312273},
    {-0.7499059303695476, -1.5747215751517365, -4.28566573021867, 4.696262283494896, 1.0810093334768294, 4.406294391905177, 1.0091527345068, 3.5616672115251147, 0.4345002037250534, 3.700791880552136, -0.015555927444298616, -4.018456927676748, 1.6005837629176574, -0.3522085425601747, 3.688767924491304, 0.40882893899172873},
    {-0.8983440780568005, -1.58050080687516, -4.47659011889552, 4.812849299846462, 1.5309019826371366, 4.15563825657959, 0.8877904344263853, 3.577120299189246, 0.49652970398525, 3.8259602664157057, -0.27166585084529965, -3.9269077472760787, 1.860345825946569, -0.18531747962228606, 3.4381248318512747, 0.1001150381021006},
    {-0.9989286245603823, -1.2369011753109174, -4.302225608813805, 4.828387016051978, 1.2918330402160025, 4.189366108396036, 0.8067812443846675, 3.5304044024401056, -0.1503874610996586, 3.5933814034100258, -0.506276831172493, -4.030380474457539, 2.1057774180943536, 0.2733591141494611, 3.730422927140527, 0.12712846497382968},
    {-1.4924052040015259, -2.025889117785731, -4.648845968883092, 4.609200199923087, 1.3560520398561795, 4.413054241327653, 0.7213693024039394, 3.6416456179465038, -0.24387370195560457, 3.562083261517451, -0.2685824471221131, -4.309037605702845, 2.068269884722462, -0.23837122398190602, 3.3994825419134798, -0.13370790591557188},
    {-2.084020171428434, -2.1348517433484866, -4.639205297682881, 4.756261152389268, 0.7067577571034263, 4.584334489208215, 0.1846737563795374, 3.6218844916869077, -0.3647061051109586, 3.5277468508734957, -0.6683467051786992, -4.179113220182265, 1.1973259106401248, -0.5306508332941489, 3.8826264536537405, -0.21535570084451014},
    {-1.7236994678052735, -1.4462100742559698, -4.454229681800441, 4.792755196606526, 0.6919253624687215, 4.399371000490163, -0.31826652007026845, 3.587566291229531, -0.4739285616326828, 3.6157223960395126, -0.5181041928005725, -4.0778118624003685, 1.1007945061363966, 0.010945946995820395, 3.6568156340393725, -0.3957479041442351},
    {-1.9667098832950711, -2.2521758367113494, -4.700663106351806, 4.841735349492334, 1.3974907031912178, 4.542625747724357, 0.1965090497662968, 3.8492597678364957, -0.4664305658221094, 3.9871974993116974, -0.13695546372502362, -4.1970400114373465, 1.5835391894403854, -0.750619986153057, 4.004967564939954, -0.19654628055095755},
    {-1.750476495200562, -2.3934285936356567, -4.751495431844232, 4.940757590712799, 1.355217232487261, 4.457670068469585, 0.6110982880405902, 3.668826990746671, 0.022349677406116326, 3.9512055318684247, -0.3242051490394342, -4.504932011957145, 2.1893228189402234, -1.0868077187864087, 3.953089400492507, -0.4013750877421742},
    {-1.7452564792767462, -1.6101032661418488, -4.142841608110443, 4.7468259591167525, 1.5115407630424784, 4.5683197948268415, 0.5091076147910081, 4.075664598151585, 0.10622646143523794, 3.877465696762877, -0.1581928932251939, -3.973012798517771, 2.074809807699746, -0.29456665920053593, 4.151192247545869, 0.23124100646801432},
    {-2.079689205921818, -1.9028997314105864, -4.81168866299304, 4.860099632434361, 0.5939663370870374, 4.728720678548322, 0.08639461479448934, 3.398729907420918, -0.39622071077268617, 3.6159722747301672, -0.6060035637187112, -4.29231088145495, 1.637488552665146, -0.16460504278227642, 3.9067038402103162, -0.47485406785627077},
    {-1.5528391241503716, -2.2790512561922864, -4.58850492313703, 5.142603873265408, 1.1803488424056956, 4.670134426720491, 0.14407058345576992, 3.9765082451269955, -0.12285522102183985, 3.7956855015336273, -0.8381151410931988, -4.391202494579673, 1.6423055930991715, -0.47689891609289775, 4.071153942514257, -0.6182036662323026},
    {1.7483786134339376, -0.9437734136711704, 1.5081600191881017, 0.5902845100426936, 2.2760452153336077, 2.555360398764563, 3.121291715192245, 1.978216250293741, 2.1198545060047476, 3.314356311526546, 3.683782516539613, 2.790445939112785, 2.97166694789849, -0.6307627597980088, 1.9446116320964553, 2.472825793974596},
    {-0.958842669833035, 1.3109473275767556, 0.882842507683786, -0.19473671740344406, -0.38399592351534734, -0.4482282034108293, -0.1085521672595614, -0.27506399885570215, -1.7073324449005247, -0.1896324476830872, -0.23375871046313315, 0.025175034048906992, -0.3935170920362736, 1.6903233628027354, 0.2952901058480593, 0.6585608824290218},
    {-1.8765512772515944, 0.7146942718851479, 0.9373519432809995, -0.37074312750994914, -0.7050348154295044, -0.22274446065635906, -1.1216393796851842, -0.5097518883299132, -1.389703886730161, -0.058002014956410025, 1.4382223899046196, 1.0314638322169283, -0.951042352049646, 0.09131435043045108, -0.3619528207813387, 0.4257782479086803},
    {-1.433642447122101, 1.2520630977457212, 0.7599769538183556, -0.33591294090674284, -0.6750433886354739, -0.27419739421913464, -0.5498167838072809, -0.5922837952320652, -1.2058663802367628, -0.43578097660574233, 0.7634007453896188, 0.4109515985940935, -0.9429609695768234, 0.6033443251490672, -0.5927223028149481, -0.07880796096730162},
    {-1.9632300780879561, 2.2103974086954077, -0.13005347555908797, -1.5570073542166167, -2.557131268418927, -1.1065235515325327, -2.9751413842112573, -1.5751868286532709, -2.566041211303993, -2.0977797960939806, -0.8825544839093896, -0.0367016831650481, -2.7284423855931745, 1.8425035916886734, -2.1007721098982803, -1.6211537331588837},
    {-1.0457765112975779, 2.4703788203271624, 0.14338995577629524, -1.5769427743645679, -2.268982985866805, -2.217017703647762, -2.5048320922932192, -2.2136905339160142, -2.5204355925858892, -2.2085051554859123, -1.3493478368905196, 0.19664451317388196, -2.6580023811815265, 1.8489223505131638, -1.9431254780689384, -1.7129911658738377},
    {-0.8129003890267781, 2.394477406104851, 0.4398298360033349, -0.7258981914242719, -1.339316068423828, -0.9615963232958831, -1.5307205149412928, -0.7225973821693338, -0.9754200211442867, -0.9091062966570393, -0.8422751646838522, -0.17564048531436677, -1.4019399813342748, 2.4025472228943143, -1.3111166775901413, -1.1237031304285146},
    {-2.507892250754508, 2.09933587201247, 0.29026458099572794, -1.007230726342873, -1.810321775603734, -1.6889305470885156, -2.186038431729051, -1.993743587673078, -2.7723845952623476, -1.4974634894665224, -1.140259684005698, -0.15333818384033768, -1.8204959972072987, 1.8113198769113796, -2.1994617969015535, -1.6293373469422103},
    {-2.103657316881498, 2.013771014359899, 0.047615440135614154, -1.720024117271221, -2.6058892903175397, -1.4561792498964428, -2.546338684701402, -1.8768416981796192, -2.581304690432434, -1.9622167038228902, -1.134482399555122, -0.22962880457123014, -2.5951546352257107, 1.9047772667246146, -1.8288786612114551, -1.4542012524384005},
    {-1.4962645925067137, 2.6027037582810943, 1.219202341552905, -1.5931402316408763, -2.385138946942075, -1.270752202927376, -2.3860046634722276, -1.3350758442701431, -2.1601705771632673, -2.006582339712732, -0.1905334418198064, 1.3210434404693032, -2.116901348984568, 2.0170328204100163, -1.3783781012508962, -1.276095462408988},
    {-1.9461763528409393, 1.1384639408994461, 0.2321266183537303, -2.043459168653735, -2.8316724806374403, -1.9100528089564146, -2.3126022769992542, -1.0260065970385244, -2.509354642500963, -1.7339777710230642, -0.9821544143996017, -0.30247510187989457, -2.43293193558637, 1.2182746765659056, -1.223450828883816, -1.4778784159313458},
    {-2.967485637593719, 1.0906368696782087, 0.14034068635629113, -3.0130911080314045, -3.039479775293497, -2.605537885974354, -2.7530542131227795, -2.2595714525608, -3.8287461711676016, -2.3486774058042235, -1.5160738655752142, -0.3272289877773038, -2.8751584387435405, 0.7231587970459065, -2.623594190101814, -1.664699771221086},
    {-1.1127924327824574, 1.7074581447509027, 2.088499118077139, -1.899639158319768, -1.3434500355007883, -0.9615392320998809, -0.9105482753486802, -0.8562285059713196, -1.500714872185276, -1.6307454380332669, 0.43709143767710057, 1.7386843637575111, -0.980661154126563, 1.4086794016380118, -1.5303030617811413, 0.224642781221798},
    {-2.617469504530031, 1.5153126813235138, 1.6211758378843475, -1.9535544480161517, -1.7490616868196045, -1.1074697179885105, -1.6231893819029755, -1.1467738324783188, -2.3891946237423274, -1.1694141142168621, 0.23474928358801092, 1.5429754733120247, -1.7704394341461163, 1.0974815534094697, -1.4158683400701861, -0.4836152249329967},
    {-3.0430692567320037, 1.432460635868032, 0.9293114512499191, -1.0617965267088854, -2.0312154470790738, -1.0530613549499952, -1.5229798807726835, -1.0614016355507954, -3.0888612713103036, -1.5531125812847169, 0.506187149268471, 1.0783083203754749, -1.7863261914888058, 0.9192168634626559, -1.0797959685214427, -0.3583257556426129},
    {-2.8472266400880266, 1.067982505737699, 0.3868127476289897, -0.682482595267286, -0.8687969552577665, -0.25098313522625626, -0.9614118565109919, 0.05520196354956725, -2.2702911869682816, -0.7911357681101451, 0.8552672487966527, 0.8399986512625949, -0.9071686953169709, 0.9190676580780831, -0.5370500509824702, -0.4772108452432352},
    {-3.3098427411305287, 1.0497362941053379, 1.1484655675129691, -2.5510352284846145, -1.7409456454426249, -1.9953348333615117, -1.8410245980294206, -0.9298343598297362, -3.3205341486342035, -2.037476711201489, 0.7393977788628338, 0.596514333923955, -2.034927969703682, 0.4974447650673965, -2.2310133413103657, -0.5895998313027161},
    {-3.853232151367529, 0.940763077167769, 0.6550802608605416, -2.4726289723265653, -2.5276164851739167, -2.005664460133706, -2.6712951183814075, -1.820314078139411, -4.08270936023094, -2.600190030639673, 0.7391850183778157, 1.0309297176558767, -3.13996175941195, 0.7432425549616832, -2.482838503386769, -0.934857255476422},
    {-4.313549766776011, -0.22418698195429762, 1.0395068791350892, -1.95396930716716, -2.058164110442269, -0.7607544952959263, -1.6148760292695312, -1.0945973389661392, -3.436186509711596, -1.39775096078306, 0.5782935562078696, 0.8038544821351323, -2.2805073578581156, -0.4005958926716864, -1.1941860971410394, -0.2024493993249113},
    {-3.157651924171761, 0.6195907154140541, 1.414590409488492, -1.5865343148240165, -2.649432100228097, -1.0671313615042546, -1.9304804752220135, -0.6892918693376769, -3.3874121605315346, -1.465397074691079, 1.009756472033389, 1.234368244323717, -2.5018375798210597, 0.23088757540959892, -1.1500824565455867, -0.467531364341376},
    {-4.146588293795221, 0.7786987592517784, 1.304513980368125, -2.6713443199894353, -2.2604090734305857, -1.7411253867178518, -1.8120475602934132, -0.7794306564898855, -3.79222332978046, -1.6506423681198823, 1.1764444298445897, 1.307444400745715, -2.282012613138703, 0.021954072564022827, -2.233700443256713, -0.22414251481186384},
    {-4.996424107566401, 0.1306733507579897, 1.1031035920889358, -2.0673150241227294, -2.7355538436034332, -1.5250393905232824, -1.6221596932087157, -1.1973683374986572, -4.530648474871257, -2.0981272181266846, 2.098796963536472, 1.483399765883264, -2.648720129553012, -0.21143233845260612, -2.218674699614816, -0.1339108515288734},
    {-3.676119693500525, -0.6038521809624522, 2.553484198262933, -0.29566782676702075, -0.6708949545257313, 0.7769007344979927, 1.244880598569352, 0.8739286691618782, -2.6885231456120993, 0.09617761241263566, 3.7694849475133707, 2.6343916891699624, -0.43086102527322045, -0.5871950941738852, -0.32666708536845085, 2.2055917942065424},
    {-4.563502296243291, -0.6872885395034251, 1.574603022694226, -1.8598644914999076, -1.7513329697884237, -1.1158720606807497, -0.5546641380386452, -0.5771186518127752, -3.876837175049634, -1.0869611127941579, 2.799081909216613, 1.8469387956874377, -1.7735184692292494, -0.8665729690358998, -1.6719659423319215, 1.172487958360178},
    {-4.246758182744921, 0.1688111438309253, 0.8325442786580406, -2.318450324128578, -3.098093109110308, -1.8285262065591203, -2.607638680667202, -1.8354666731824272, -4.25675617437997, -1.9669777008392808, 0.9700043776320314, 1.2979046489109103, -3.409837103896864, -0.5225786570147988, -1.832581457452475, -0.8719338934883194},
    {-4.1729259545467645, 0.35972881941721285, 1.491024879069387, -1.369944751788729, -1.3476563004750761, -0.19030929175628628, -0.07443101021378437, 0.020816887484943498, -3.6338806446411938, -0.4423237603473085, 2.825028574356951, 2.249950749003694, -1.7015029733364357, 0.3763694119078371, -0.4012568423373354, 1.0713803692548962},
    {-5.179586143913062, -0.6786587875427457, 0.8485085328436553, -2.0437001005464768, -2.830632750919804, -1.1116060305386684, -0.7750393225181834, -0.40605300322933535, -4.808823013930044, -1.2566739210167113, 2.2001347456477434, 1.3935978645769707, -2.0664796282874707, -0.34373749194820635, -1.4246867795652243, 1.0645690449646734},
    {-5.445407568789455, -0.8034810505761171, 0.21378038830182067, -3.113272839402667, -2.9304617402263133, -1.7977988921858676, -1.5365330281599858, -1.1555500434673776, -5.169872583669176, -1.6760646762702274, 1.525531702361522, 1.0221286668537786, -2.7888310518488626, -1.0342090129370758, -1.6648085984159544, -0.19686537152195963},
    {-5.1565275095882495, -0.7227029026704885, 0.4061442080655647, -1.6052130351533336, -2.7550207637562343, -1.2219981130376538, -0.7334405279915899, -0.6620510798575822, -5.010524557567391, -0.9405097771851091, 2.137783139061272, 1.4349432229615784, -2.0325657008919724, -0.622940883068641, -1.4386062675969067, 0.6714666772462354},
    {-4.227569051343833, -1.1213269761895268, 1.5231665834185626, -1.4807287395433562, -0.8528353072027526, -0.9091181110824508, 0.4986057165362278, 0.7692791690330295, -3.625282711989793, -0.44194425677710075, 3.426164338864096, 2.375989033278778, -1.2178699445236798, -1.6899653456152615, -1.7094495441153807, 1.4262874455049304}
};

static const float b1[16] = {7.2604820764048545, 7.041332264560469, 6.797097964033131, 6.773401640820306, 6.45618729622087, 6.502858367946789, 6.467112675293563, 6.331842205240871, 6.977178235609141, 6.199824251868653, 6.564960627133704, 6.780432251989236, 6.223687401022002, 6.112634920485284, 6.2446256518739816, 6.4000740251017305};

static const float w2[16][12] = {
    {-3.217345159849166, -3.410332010664305, -2.7358773359221433, -3.270922937384559, -2.7204926482764504, -3.014877811786033, -2.7437392395251687, -3.931822485641042, -3.670847086245069, -3.202294559736743, -3.1450941627189133, -2.7809530196936976},
    {-4.536568929506986, -3.9468610877956216, -4.431002052082037, -4.302997217646768, -4.865851379262283, -4.261526725730209, -3.964678372672675, -3.9404958609012417, -4.2974613666979575, -4.6826143765769785, -4.64866107583643, -4.353690413417182},
    {-2.9200787941318262, -2.973183523028716, -2.9304672463569155, -3.0568717325119596, -3.012815865213343, -2.7993089989594115, -2.9507992990153347, -3.4637034973711693, -3.8638762752099907, -3.2039184689436437, -3.8884154291957866, -2.695723292614059},
    {-2.8843192310781713, -2.8312451894026305, -3.208045874328787, -2.795348524646477, -3.017925597688736, -2.824071889087304, -2.685428634516124, -3.230529543221311, -3.114817738741318, -3.397709129788366, -3.1133930737460735, -2.9028411733601773},
    {-2.9238538953175977, -2.7624988636406047, -1.8119730345689802, -2.599647656579254, -2.427282923337375, -2.260344615541063, -2.247289673451952, -1.9891387431655034, -3.031872153989029, -2.460239748736437, -3.7960906244030532, -3.3246401035215847},
    {-3.202724049231627, -2.8949166485690845, -2.251710348346305, -3.3638148605022784, -2.7218213533324143, -3.435873151176141, -2.579460104434925, -2.749516902813531, -2.258589753854207, -2.5928457174550923, -2.8342188293025754, -2.774643310311644},
    {-2.8354222041759587, -2.4569354587574876, -2.540914324969439, -3.734812087773123, -3.908331554198606, -3.0287268183645444, -2.7564450519691603, -2.7336821231312265, -2.172065005889789, -2.6025408529971283, -2.3479170279974344, -2.4988219093814203},
    {-3.1235088700767895, -3.060985178714236, -3.2175935716404993, -2.4433167154563007, -2.7053324834313095, -1.7896808770554582, -3.08694010715301, -2.1439314459995433, -2.688079438908129, -2.6039473746999935, -3.032278451556897, -2.378067636747426},
    {-2.710472960916141, -3.1534016502722757, -3.5987427935757617, -2.4120682965314653, -2.971539291278258, -3.084197907463714, -3.3098309717546615, -1.6795069757092305, -2.9474898969883836, -2.5237425719796405, -3.0355376240941934, -3.29525666761279},
    {-2.732246906143136, -2.494364327538184, -2.2027362569647226, -2.739827484495694, -2.4387490569204555, -2.351138599940602, -2.6889018929978117, -2.490267939300673, -2.7949776034076486, -2.9157454119576527, -2.438795750936282, -3.5187839791379183},
    {-2.515860040742214, -2.578139789542534, -3.521743088835918, -3.133235623532927, -2.8132549649187184, -2.5659688556197757, -2.9878585694501147, -3.048627204874366, -2.566831052383358, -3.274416028278013, -3.2106575814232134, -3.312918963832732},
    {-3.299639042210927, -3.387587427783908, -3.253114307090173, -3.2419753840187897, -3.25571660670759, -3.40195410268397, -3.4342538864988468, -3.2311633046735166, -2.2396824201031347, -2.8865375368183046, -2.292079990099907, -3.618484906267388},
    {-2.0768189676081774, -2.8865450089131475, -2.9962475575624588, -2.490181085205989, -2.2698125418101682, -2.52275582446055, -2.92394897650992, -3.8901345225708464, -2.6131929735969517, -3.174558161791956, -2.472381231782963, -1.9853425381261152},
    {-3.7730473002028297, -4.147807263015732, -3.8372579271706977, -4.0655181916727345, -3.8998007618729593, -3.9323191095831374, -4.3200236262694505, -4.002692729338688, -3.6812026080958944, -3.336334883364542, -3.4659097557792533, -3.841931393581215},
    {-2.2504732409203387, -2.7613865510000135, -3.1402392672419355, -2.7605282449038677, -3.1308078416125755, -3.6079787374196908, -2.9334727512862915, -3.350442372297039, -3.1354568763693287, -2.276593505768585, -2.3545577669369915, -2.497295708483253},
    {-3.363422701141475, -2.8226583254277724, -2.8403367367596757, -1.903632961779158, -2.344563620056402, -3.2636255887081753, -2.870179074544032, -2.964626374792692, -3.635570354276484, -3.0509156314076025, -2.2910668645581964, -2.545861375437658}
};

static const float b2[12] = {-3.2291302049251067, -4.54479783595721, -1.4804253313764577, -2.906230716676172, -3.4960953778358483, -2.4367624715682097, -2.6562411584462042, -3.810351984429792, -2.2570048368072855, -3.7857685101447216, -2.1960995162756913, -2.506175080273656};

    // Input Layer 
    float z1[16];
    for (int i = 0; i < 16; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Output Layer
    float z2[12];
    for (int k = 0; k < 12; k++)
    {
        z2[k] = b2[k];
        for (int j = 0; j < 16; j++)
        {
            z2[k] += z1[j] * w2[j][k];
        }
    }
    softmax(z2, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
