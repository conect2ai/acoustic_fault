#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][16] = {
    {-3.610924422506621, -2.193047441104717, -3.341558797252243, -4.648601372378693, -1.0823166987521209, -3.133583462134057, -5.0643673651535766, -2.0093722697147745, -4.342644917573435, -3.3406366642410004, -2.22556347817742, -1.437137953225857, -3.717542832295128, -2.3388118495913797, 1.4103687278622827, 0.7623642948829964},
    {1.05183505057984, -3.0646600025326505, -1.7348839671724867, 2.347200206081445, 1.9473494504177356, 2.244583253602845, -0.3920230246329172, -0.45053284563169305, 1.2998084095623224, 0.3080523223452433, -1.1473051289995266, 1.6685643854556245, 4.299051320108484, 1.0476121105696, -0.07901982007972885, -2.972626616612774},
    {-0.1012020526886472, 0.7350670230529829, 1.0714754373833855, 1.5237243492517976, 0.3893531580180741, 2.6567020226642377, -0.7107781243661674, 1.339237566373512, 0.4397347269074025, 2.322802988636988, 2.198778092054581, -1.0186120085570878, 1.9995907266666408, 0.7293510436118125, -2.5079190479402063, 1.3268793543740185},
    {1.1322949609163848, 2.9949825494551336, 0.5337208952102384, -0.16985425936451787, -0.3660929392129056, -0.8252058459906989, 2.895064056690636, 2.5228649406128185, -1.234561534435865, 2.535495911258793, 2.8108741758528772, -0.685289234863447, 1.3310985281166514, 1.0917604230380198, -3.0798591926081165, 1.3980018561057874},
    {-0.4313632561023728, 1.3266672576375675, 0.04339925478718358, -0.8334548595407408, -0.001414197591642011, 1.5485539632622984, 3.070075312992444, 3.5378295574095504, 0.9891262876044266, 0.06244424721208961, 2.4487755555481816, -0.196228149697754, -0.011268860354170736, 0.18889094315528912, -2.451573748169967, -0.19566499911504873},
    {4.0837948175956935, 4.797648894252894, 3.7169658379357506, 2.9199381365126356, 2.3382981926938355, 3.2053792099233025, 6.14413392715539, 4.946277185088956, 2.833837382671764, 3.4206942472795983, 2.895022592599763, 2.7787547321997352, 1.6454033730901716, 1.271667167223458, 0.8173355811571633, -0.41768979532735634},
    {3.1114407045209016, 4.686112246547545, 2.1680187850339947, 4.036708864239972, 2.5630855227635303, 2.5727357120724355, 5.674192482270851, 5.537823990041673, 3.4586362249716647, 2.299535142546963, 2.710712229894061, 4.1437807958952835, 2.1901918649194765, 1.1106453190975623, -1.2083690920744028, 0.6611453773889816},
    {0.6543386435922586, 0.13231329065853564, -1.387088538206142, -0.4017471794841787, -1.7159218901155433, 1.256560554753982, 1.8526533549346316, 2.2647954482606276, -0.03025127489971594, -2.3511424999890704, -1.2778568724467356, 0.0905699729607067, -0.03836215563939432, 0.9683551857006343, -0.43592612315920476, -2.0496522614944794},
    {0.5107412186838639, -0.9978705710140752, -0.9604936315342557, -0.09902145121850524, 0.42304233981660216, 1.5122322622573583, -0.37205826325767954, 0.15874755621759032, -1.5759077222624407, -1.9749751928939157, 0.9184838517345073, 0.8236666865803315, 0.6025483676428954, 2.0698702253966825, -2.4437124578779446, -1.3772091711702905},
    {2.991022248002111, -0.28862581290208306, 0.7814063323260996, 2.842172152207965, 3.079662267534111, 2.2342647882327253, 1.2093329554726417, -1.125072524035615, 0.9291216525358069, -0.680727485271562, -0.9826194654874753, 1.5162954002690912, 3.1451762420538065, 1.781477247502951, 2.3968117045138575, 1.3673942846023277},
    {3.3407614836532833, -0.1273639811164745, -0.5262878623198972, 0.7477336713328341, 0.7786305759111957, 2.051869310167693, 1.7488455904995428, -0.6081408172763481, -0.9454640537250734, 0.9620493901261392, 1.2535468718896403, 0.7793579802191476, -0.4531862465350576, 1.1967037221131187, 0.16200513597557928, -1.207220400750017},
    {0.8277214464572606, 0.5193628134076825, 1.2232003119421022, 2.235806337422148, 0.37250102230110727, 1.005460938291038, 1.6181181533845481, -0.5604391797107972, -0.9848459069724319, 2.96962153104029, 1.126888934986185, 1.1805829948465647, 2.800742161245015, 2.696579980688478, -1.7272119499580867, 2.5222179313639153},
    {-0.6466986483712308, -1.3863708986768746, 0.2461963891304358, 2.434938659588837, 2.125263449126645, 1.9736883324632901, -0.2071597925976195, -0.10274086737884, 1.467074159108064, 0.4937842560038287, 0.8831885155997513, 1.540516026487798, 1.347603666377914, -1.1906639932391552, 2.3875456699884596, -1.8281012723545453},
    {3.852464687293068, 1.6857291274901955, 2.3028597194869818, 2.6242344777124944, 0.05814596889985155, 0.43642580043513335, 1.0934608782804827, 2.9793916112765015, 0.8770631288712019, 3.3039437582956643, 0.8232791638416062, 1.3221407406905885, 0.6922691238262306, 1.5828013750895005, -0.8402877893502201, -1.8745085916375994},
    {2.0671251071159795, 4.186247787258293, 3.5745254290769966, 2.5107187649246137, 1.1780460477223718, 0.7908463210924982, 2.1901258130328447, 3.890858806027083, -1.0077739075320746, 3.8223697412685738, 2.0003984238084853, 1.0259217207324625, -3.2898480792787788, 2.0658773957333403, 0.5818189640846168, 0.7557718054456526},
    {-1.2713059256821215, 0.7468767149445845, 1.1217503455987123, 0.5107298182628373, 2.4924178705358124, 1.8715189041781635, 0.824612402021656, 2.3416913538189985, 2.761470912120529, 4.067820120509985, 1.1856229230677402, 1.4028771632854447, -0.09662196344427026, 1.246909852836773, 1.7558019997556769, -1.662798038053338},
    {4.5702408525837095, 4.249060076993357, 3.499371311091238, 2.724539501534863, 2.473874471595495, 0.7200812717145597, 5.3663339838794695, 4.650334979591688, 1.5816522820780212, 3.9668107616202426, 1.405088555233954, 3.507052930962123, 1.0674492076988626, 4.308859374377224, -0.3052522343324608, 1.8082152768887652},
    {3.014216565361025, 3.586794962527723, 2.739558505369468, 1.9071128959762371, 2.256894310312486, 2.611181806860413, 1.996301851845177, 2.1519392175878225, 0.7717847457683028, 3.177659518851486, 2.4124211898553045, 2.122214511536125, 0.5306973965773002, 1.502702506836012, -0.15268694224984627, 0.41959442101317984},
    {-0.8375940033645662, 1.8401812759415115, 1.316808857292321, 3.086404629721265, -0.009911986739619624, -2.1351044718271353, -0.026343554944737262, 1.6699505206909384, -0.8989412708683479, 0.7867504378735067, 2.4051524095835233, -0.14669746858648286, 0.10107222431814258, 2.5430894558769497, -0.6108126822172464, 1.382083731090272},
    {2.7759584004459428, 1.563275496065694, 0.5599053754730933, -0.9277305930267192, -0.9066530073846877, -1.1007688966988178, 2.2057188628236837, -0.21799299261346142, -1.32358314259449, 1.4404385864698246, -1.3507117578353454, 1.1554394149989802, -1.341768332762379, 1.6140681683617646, -1.7864332671256267, 0.7734423604063223},
    {1.5558240145590914, 2.7705187483445766, 0.3336462170191999, 1.0903505168359144, -2.5733273908052663, -3.123003922969044, 2.063382268882599, 0.9200854576254163, -0.7955704476393405, 2.1961320903283403, 1.9304168082136568, -1.9661740530826826, -0.6908824038705099, 1.776498320258183, -2.1641499667843673, 1.6250640459366057},
    {3.3273877960619846, 3.679445815071107, 1.8191218488661511, -0.7198587440241575, -1.38825383839991, -2.782655632255768, 1.5501913105764142, 0.3008564015893527, -2.9083656427709266, 2.1789270869239776, -0.5105853283586436, 0.04702502094389072, -1.8863967947719056, 1.5012422390790614, -1.6634778545603734, 0.6081434604108269},
    {1.0151060130206857, 3.0461438392236073, 3.038530009267037, 1.6990583433125015, -2.595521644438608, -2.8346680348485744, 2.1680608910567565, 1.6657370785549928, -1.656709031859578, 2.5096893760262433, 0.8354975053646518, -1.6426187462412867, -1.2899672782337184, 1.1952808061784876, -1.278201302245306, 1.2079477184906406},
    {3.0588842265496923, 1.7800755174474496, 0.7954182273590419, -1.636556186946364, -3.4031176069004516, -3.2865182987881334, 1.937126559015325, -1.5047971698069058, -3.381021754363997, -2.552852635156594, -1.9943212843003064, -2.2618103511106145, -0.5839380615729061, 2.4894791144513313, -0.16697037909070875, 1.3064052132593245},
    {4.352651354465011, 3.4289486428727494, 2.0916243979183484, -0.07426630358021268, -2.3142471016632653, -2.3322262657863653, 1.5814921062782485, -0.18535574796257787, -1.1712015793765265, -0.14834493490510772, 0.7191542059020467, -0.18397496105355002, 0.952584026166497, 3.0963984065370735, -0.1623748116620925, 3.386623940686574},
    {1.3417140864239916, 0.46367627900277825, 0.7623492474610082, -2.0176107914940276, -1.4397925376436973, -2.763764592158592, -1.6031840041862284, -2.502405053501843, -3.0885482586308557, -3.2391554775399896, 0.3091410882643307, -0.07800910422278393, -1.2351986242100421, 2.461196700288875, 1.2085846665457303, 3.1227710225080574},
    {1.2860792498945786, 0.20997157993837273, 1.1480839066898887, -0.21231122067823757, -2.0875127574184953, -2.973367604190095, -0.7076378083715076, -2.8501209895125004, -4.520013293908725, -0.8488501949321048, -1.3651427178390412, -1.2099255689201336, -1.5508440014215756, 1.1402113763284367, -0.2326960165817372, 1.1528171649898988},
    {-0.1125037865358271, 1.6654521663999524, 1.2217172303767354, -1.3097804620199005, -0.8397821837593706, -2.3169105561251033, 0.5085332227336148, -1.4957334727359988, -0.7904262657471112, -1.4284488515716263, -1.2165081910149016, -0.3117116233104301, -0.7751736209376733, 0.03356915620874408, -0.37637229763786106, 0.6185162467863317},
    {4.7516673036636945, 4.07820292298916, 3.237332928130273, 1.0292244987844785, -0.8189498803954379, -2.300778151863751, 3.338152065355686, -0.11177421897896575, -2.922781441714266, 1.941613255395054, 1.1100088492018882, 1.0778182507911434, 1.0305109726212045, 1.840115997138748, -0.5555314016686919, 3.744303997922375},
    {1.4942376196798475, 3.6767935401989575, 3.923940288949091, 1.2818235698528508, -2.3707677523949062, -0.8172928349779828, 1.9479661272156297, 1.2531185574959267, -2.1958869169598367, 1.8506143077304948, 1.1609683214530842, 0.5817190477278624, -0.6335083675442714, 2.393523429193341, -0.2438718007309434, 0.007525186397567533},
    {0.3709353023944732, -1.2280844983540955, -3.7070323826199725, -1.4259339858232192, -0.25929267082244406, -3.279293582039734, -1.7906969206975578, -5.319550130866092, -4.76370325814447, -2.63155254205456, -3.1247772616445197, -1.486981346554365, -4.222335209146388, -1.2393765803029986, -1.733045545292212, 2.4578859781462725},
    {0.4718076665075167, -1.562499106396682, -3.4610046691448018, 0.25363086667871265, -0.16665387347288216, -4.225845989930687, -1.0698617303628486, -2.9693538683266154, -4.24151724520692, -1.0647315323915876, -3.077917094247807, 0.3588641940831175, -2.6672873908224273, 1.250840750745598, -0.08842615103906393, 1.0751043405794833},
    {0.4792531576888979, -1.1377617976962024, -2.2252315562450082, -0.9051151112398595, 1.1046702795011851, -1.960959249160794, -2.007363376655694, -1.419938649643459, -1.7750408687165018, 0.4782354426401494, -2.349873714088643, 1.5812692302754925, -2.929148949221913, -1.2622644024800715, 1.2717686323154476, -0.10917962334980898},
    {-1.0447213371527884, -2.9966653798531158, -1.947412357308107, -0.8858000045785327, 1.0662234552181706, -0.046844372726715135, -3.9737950963896154, -3.515230773423884, -2.711257941998114, -1.6269324341924813, -1.0903768285755222, -0.4703580657198064, -1.5520882935533187, 0.24781237035093012, -0.21762108220912746, 1.1779613700288087},
    {-0.451618798145221, -1.5572362293347572, -1.4346493805193001, 0.6915213343361494, 1.8112035851842514, -0.5877084393554265, -2.2679797558169357, -3.6894070949126965, -0.8978213390262716, -0.5988418687226678, -0.2666450246445428, -0.6685314524542053, -0.7915250779932848, 1.3692993881129327, 1.8538898157587116, 0.6814808406248926},
    {1.0869975152874463, -2.1509031054661065, -0.13699139319219833, 0.6558627998229518, -0.8338196247262684, -1.937414061255794, -2.7046555147234526, -3.347463874169359, -3.4915524730981944, -2.420984700285198, -2.019723920664535, 0.674315308854806, -1.803665992644008, 0.9412545547385962, 0.8011752737358732, 3.6981959910750173},
    {0.3937915239731683, 0.7203163059975376, 1.7791345023377734, -0.6782786088120593, 1.2122502670607318, -1.661623363971852, 0.5372432025345898, -0.6318985113110772, 0.5869900647420947, -0.5598953488541784, 1.264195501154326, -0.1579184860227266, 0.763978286470253, 2.3817487876666092, 0.7021140632615807, 2.002444288740452},
    {-2.136160164269365, 1.1819547961357912, 2.69810418949765, 1.9572266159370926, -0.8232884517695815, -2.0110738734355578, -2.3665605989042833, -1.4207539368932964, -1.9480205351271513, -1.9163532115399247, 1.9693664972648137, -0.8301774844057039, 0.3625659402442797, -0.01920051755513651, -0.9766271379660268, 0.7880723867304364},
    {0.9622924472014682, -0.024091636438850872, -2.121385610123026, 1.3257374194852314, -1.518042940829033, -0.030550846597439413, -1.1615062796897093, -1.780852158216997, -2.6597926844886968, -1.0929798512523257, -2.450705216032053, -1.1971388812626087, -2.059375460882012, 0.5801260482924226, 0.8379166496074179, 1.0921282999698247},
    {-0.42267900535762776, -0.8638689019532639, -1.3272837393858072, -1.6303802111834862, 0.9268310654641112, 0.13764429937010753, 0.21932302108215296, -1.2231049080691345, -1.21306836751475, 0.7348388898514214, -0.39338908332201944, -1.1637736875523872, 0.9907027899874743, 1.970026276229582, -0.4077955043216094, -0.3167818246485768},
    {-0.8032492419172707, 0.48281215156054214, 1.0512932489764766, -0.6332465256401627, 2.6717733748414076, -0.4424161631060238, 0.11411106930087596, 0.16208757471497953, -0.23320494917318613, -0.33592094742925366, -0.02717904026037699, 0.8688558333517433, 1.9690871157365017, 2.050456365122598, 2.95505947871619, 0.5339160332597264},
    {-0.8359452019998637, -0.2923961525843162, 1.546699291587538, 1.267723427135429, 2.2443306972405037, 1.7503382244861756, 0.4928099678465814, -0.32587019338153683, 1.2975037627219483, -1.0577207206395631, 1.716637712587459, -2.2189801021017757, 2.602118396026352, 0.2479447771909936, 1.400980723422285, -0.44011418855903195},
    {-0.8039554609464585, -1.1986816410446652, 0.4483821162269311, 0.5435634564200598, -1.3041045552168171, -1.4250381842954825, -0.5934167698348028, -0.7446203745307285, -2.3519983376525144, -0.19206479658311057, 0.5118849785642771, -2.673169455400816, 0.9906874935158154, 1.731744051297878, -2.7590833005900035, 0.8680324279639623},
    {0.25368803855050265, 0.8620497357238041, 2.6110242102728516, -1.1239944655754046, 0.7150167908898031, -1.4873487121620885, -0.42372645220447974, 0.43487593588397283, 1.235148694796016, -2.2065095379068924, 1.1032955072469424, 0.860704057407659, 1.3563951986595542, 1.7629806429240966, 0.8361370945165584, 0.4675180375801142},
    {1.0716744561504137, -1.6019002286265143, 0.2193682971195671, 1.1925901152331255, 0.9453125806810079, -0.09742436956098015, -1.1503094117159118, -1.7050237120157081, 1.271094188596051, -1.2817241771052406, 2.0123224738068455, -1.404454308453555, 0.9968519126766023, 1.11600343934023, 1.1247927503823616, 0.14805447545704545},
    {1.263944484211098, -0.16862926354001267, 1.8685956902734366, -2.0595846042564103, -1.3210428972124366, -1.3486764766963784, 0.6220973747348519, -0.4807909215416019, -1.1377862294216898, -2.806915523563839, -0.9554265315081878, 0.0140073319374501, 0.6335214348407542, 2.268655751256719, -1.1009660624891056, 2.8359021515939866},
    {-0.08642850553341686, -0.7765494069557793, 0.25855172344915, 0.5980366851691773, -0.8386417388518004, 1.7587465490328928, 0.10500633335028176, 0.3284485213766852, 1.7829933738235244, 0.692218164149676, 1.2994085608878865, 0.3560526509631589, 1.1836160452621132, -0.38964460345121993, -2.606192575684292, 0.9474864180425753},
    {0.044985896211568045, -1.9103895959135393, -1.7693162189039418, 2.3197901958617066, 1.7030340117628269, -1.046002210168743, -0.5668972939366018, -0.9596236856536542, 0.6323311448890413, 1.6092153612994624, -1.1536413350026204, -0.29326632109294093, -0.47537504907069567, 0.535326106187506, 2.7323928176451653, -2.3632803197797103},
    {-0.3687392033799278, -0.06814790873496765, -0.3851976884887964, 1.2076905021510147, 0.6986668475158079, -1.1246339938359762, -0.4426097361037119, -0.23086886386725905, -0.09956209850576962, 0.1834749129187059, 0.8745579841699227, 0.6734964772130954, -0.22392264919832577, 0.35993723274123485, 1.0982260452281298, 1.3255698640129305},
    {-1.52632406486682, -1.509518219584817, -0.7012951013513024, -0.6147669721982233, 1.0016581342254702, 1.0840194769137637, 0.5606549049401479, 0.8337307180135334, 1.1312182826609534, 1.5740729911642084, -1.7052187073624563, -0.9065389504490208, 0.6930281199850347, 0.016240923906315513, -0.5201708310104253, 1.651548557494486},
    {-0.3745907004756949, -0.3324596733395627, 0.42041585764338396, 0.6750182318510665, 1.3397267385002196, 1.9599360863526487, 0.2410492196212581, -0.6750764909717741, -0.9554031257234945, 2.1587145257892626, 0.08375199340901382, 1.4303839740349884, 2.172195886120746, 1.068747256400333, -1.1952490723847038, 0.6698425013299083},
    {1.5584688935548028, 1.1803014938229544, -1.8599987615938989, 1.1786940778781307, 0.7493555297515999, 1.0291597089236417, -0.2506952759579836, 1.2841032038772429, -0.14246357918762623, 2.156837348631174, -1.9131878301716791, 0.8229276653134416, -0.46935186442743543, 0.15864379615106772, -0.554869936848399, -0.4333642596379737},
    {-1.019617268417106, 0.2960495916378879, 0.00504429977974221, 0.6464038950717526, 3.1244980331002736, 2.6829961309862793, 0.021586330500618058, -0.236120538282581, 1.1308151738120986, 2.3995313263995692, 1.9117703684259415, 0.9431379039745157, 1.3007696873036096, 0.3599034556877886, -0.5102259493119178, 1.705921957759337},
    {0.07861038310431506, 0.5651550366860764, -0.2282125511859416, -0.6253347728240262, 0.3200486724888686, -0.1260206970689232, -0.7424313885097222, -0.8285944464618397, 0.09610544636839863, -1.5449086981151616, 0.2503009560361348, -1.5259183480421237, -1.6861125232080731, 1.2733203560443085, 1.1626752663071254, 0.6421050743517909},
    {0.6688735094980504, 0.6277690263112465, 1.2551850964775408, -2.483576728381112, 0.09412327679763423, -0.021136031130433316, -1.0554682350200177, 0.7143834095650649, 0.40423934953824786, -0.9130051687928079, -0.27275384851436596, 1.6906395404211703, -1.9189749134144725, 0.9426179566949928, -1.3656886876299574, -0.8067321913619028},
    {2.184428159951551, 1.0071169024460398, 1.2252875104782235, 2.5434526062829206, -1.0499999599834864, 1.1246416511556105, 0.5394015103467631, -0.8537902198806262, -0.9607002346890469, -0.8028827156165695, 2.1451467410022453, 1.2902676946464708, 2.465710851381206, -0.15876422393912232, -0.6967435430619635, -0.7599520313560915},
    {-0.5526723317910667, -0.11667121378707442, 2.8953450211373064, 1.3414868611748914, 1.921098683377963, -1.501558231910458, 1.925969229499213, -0.31655583820095423, -3.036123172561364, 2.110972090585616, -0.2526219555175933, 2.7965418530872204, 1.654008009714918, 2.4385107117044504, 1.8804746699324593, 1.171588712156285},
    {2.1090832032028812, 2.7453590088346735, -0.1641999855340441, 1.9753733944679792, -0.6550487712274929, -0.5250473326628441, 0.4363644983184085, 1.3584456694792526, 2.133902331879746, -0.586418490844172, 1.3509107943603573, -0.07706016715321021, -0.02389280094507894, 0.9899443417060254, -1.2217600304140892, 1.3977198046647925},
    {0.6557059183902049, 1.9518855800095365, 0.7804789495001409, 0.7290784728828574, -0.7715419314451875, -0.8332885216585957, 1.6129370064260833, 1.375071948811, -1.4441080201333105, 0.014387563309307991, -0.1734562229614033, 0.009831754160617904, 0.6834935730079179, 3.262858599010718, 0.3228775804796354, 1.8398254031607957},
    {2.8795266992660293, 1.3492381517639225, 1.49627270740608, 0.9395896829198322, -2.185900398015952, -2.0600585504375366, 1.9259452417942458, -1.1027299636735104, -3.4436337812879323, -0.6778009840674658, -0.8107175137834124, -0.12279119195808523, 0.9428338386947468, 3.0543474211138824, -0.38124069632325874, 0.5379696108125153},
    {-0.9688398717102231, 0.6304835839087048, -1.7704278670170746, 0.014039956725759976, 1.3904107325719168, 0.9180917059583075, 0.9811204068910112, 1.6956139915560995, 1.2494646008340395, 2.261623416667133, -1.4741956979958295, -0.20144067776932464, -0.3447417201582089, -1.4733759351588367, 0.9515997636822675, -0.310155383650388},
    {1.3083954319248945, 0.04299464507774189, 0.9143876787977453, -0.4062772080517825, -1.7269388318583305, -0.10406902993883671, 0.25427552461158054, -1.4668477673444573, 0.7659086971202987, 0.24380215902354774, -2.103047777291882, 0.04678016626898377, -2.961246359016501, -0.7502320388170745, -1.1487767450870894, 2.2015777795977325},
    {2.2584139985200538, -0.8191425805465906, 1.0922179291633487, 2.8212660322226437, 0.5354490504325169, 0.1521394311298228, 0.9228621740374482, -0.3039787396181443, -0.24353197586930275, 0.06680984492170265, -0.9367367409702257, -0.07950856255909847, 0.8893432794718645, 1.416504604149952, 1.0176212063239214, 2.4888176708603074},
    {0.2562496867462483, 0.18922281262964105, 0.7799618172445361, -0.5831531575486227, -0.17878425981929008, -1.028340420237555, 1.8276251083873725, 0.3587047463808121, 0.44066413702743307, -1.1115255965939166, 1.5172448113402595, -0.5650013529240047, 0.6859021657644865, 1.501029863263432, 0.7128867772420598, 0.8199396203199062},
    {-0.2886536904628848, 1.0280712039435893, 0.6261163103515065, -0.5616082462794185, -1.8009218174532025, 0.27337900280546196, -0.018647745295008667, 0.20347970734766455, -1.5709041392503227, -1.886570049368039, 1.483646457655792, -0.5322033800607854, 0.48334330781310386, 0.5320133430098928, 0.14329389589205238, -1.3158781315152766},
    {-2.2545736710976643, 0.2534006841814937, -0.2318369942174433, -1.4908242620620535, 0.3291375042679439, 0.3211793686138481, -1.0562747322291168, 0.038415343620463754, -0.21322044320003802, -0.9143750283519975, 0.8615563509965825, 0.9554994749591896, 1.4425251443471847, -1.1631340073071736, -0.27241418960752856, -0.5142243622061647},
    {-1.9898137486050986, -1.7181388598456666, 0.6387332205291129, -1.1052367139633508, 1.0883922956377345, -1.7355431257926144, -0.6954379570004509, -0.42571001204752656, 1.7807265667152732, -0.645336140449034, 1.6610061492232424, 1.2187951323938797, -0.05625795392545647, -0.7233152209819947, -0.1543553921982756, -0.4588135639686556},
    {-0.79365254298895, 0.10029208956820554, 0.3556657682192541, -2.7900741694271116, -1.815433310096452, -0.6636432564583059, -0.3885922947866012, 0.0731982165381391, -0.02339453420280567, 0.594777237204049, -0.11090202701760579, 1.3368034906892603, -1.560149074556483, -1.8184509035590264, -0.870140076153565, -2.2011962219498598},
    {-2.1170616396874617, -0.020276164999423946, -0.5376519796323659, -1.073933352219746, -1.2784796183112896, -0.4818637544938771, -1.1886961570632273, -0.24878688463371854, -1.9833063066833676, -1.6569202156499243, -1.6459596028153718, -0.13606064483138483, -1.31648702396988, -2.4823293196473113, -0.024377036428629355, -1.570993513608307},
    {1.0842496596160667, 1.6100312870971654, 1.2008508825745647, 0.5935728484217573, 1.488396854814511, -1.4961904709130582, -0.8583805294257602, 1.1448520089400007, 1.546048729244394, -1.599745620781132, 0.24170027743381733, 1.5714555098311105, -0.27850268286211627, 1.097527908345487, 0.047281321115367834, 2.164802760994251},
    {-1.8993203174166833, -0.6972497001145335, -0.5708767761871746, -1.4361048295078376, 0.08416867877546227, 0.9120417150059813, -1.7669919145831607, 0.1897576489216801, 1.5537450740120504, -2.3348208917599766, 0.16592366911954454, 0.34182451359762134, -0.5088619609353949, -1.6389350038810095, -1.239939515813639, -0.39820587248662365},
    {0.7737960520409713, 0.1465700024991441, 0.5119578739683348, -1.8078045289747144, 0.8717628231516193, 1.2738481276563898, -0.04481116292381376, -1.5578137187394678, -0.25504823333078736, -0.9365888902248943, -0.2894370234536654, 0.5092666215536527, 1.7045395289938379, 0.8889493436420636, -1.377527087663257, 1.389072840945845},
    {-1.9528453529236987, 0.6467015157000705, -0.7344007638923405, 1.4305883854572767, 0.22243999007991047, -0.1446440730434321, -0.015317757545854278, 0.2418686405530783, -1.1773455959709798, -1.4104296151506044, 0.42294501712749544, -1.8515820524266395, -0.0825240000743277, -0.11568333757240057, 0.4450405829620541, 0.9162339914181802},
    {1.0221305066994855, -0.06674767553782908, -1.1129547836728015, 2.396362414194973, -0.3510696580452189, -0.8796725424637292, 0.5239150961528448, 0.8001725475912559, 0.5885048493957342, 0.9683392268406046, -0.3311880809144755, -1.361557102323114, -2.175608133030299, 0.030374656861985906, 0.8554774959860009, -0.6080491014379759},
    {-0.23738636520255468, 1.2339040384988997, 0.7251077818012228, 1.069626179631988, -1.0199104951868856, -1.4876192556006986, 1.4326413939987808, 0.5343433463026063, -2.0194495702834336, 1.1170367944842496, 0.7447660070200485, -1.1190289823929145, -1.1948630964600144, 1.9221786439500128, 2.125175622847001, 0.38758718147809706},
    {0.7404057551144376, 0.2792276065150651, 0.9850944656580307, 3.1228556838871864, -0.7184759907884086, -0.7794997868505694, -1.464674586989707, -1.0171887489788067, -1.6981944535153652, 0.6796361146379484, 0.5859507484136548, 0.9208153735464518, -0.8619353291518576, 1.5151495509344506, 1.7111624377781103, 1.1089191053085317},
    {-0.1847165359092937, 0.20584060591365386, -1.33404665795542, 1.6192049866218572, 1.6662867149846237, 1.5418299437580123, -0.6791960471361748, -0.7923199078687815, 0.615396444539059, -0.12886004989592104, -1.2329684799781782, 0.12647353958039537, 2.018620800964112, 1.511604006089377, 0.02994376539902775, 1.966033286660619},
    {-1.1488952412682671, -1.2993636988581705, 0.6932602720537107, 0.08550861593372863, 0.22436621275888857, -0.4755005873334241, -0.8927243488008119, -1.0334159527344948, -2.694554679468048, -0.20172872647265727, -0.6362117926205051, 0.44978811207535224, 0.8633387510448929, 0.27164052874919437, -1.2779875175049447, 2.0128016385232184},
    {1.3717942969018866, 0.007391949837305512, 2.1843187126525785, 1.9398139004568846, -0.6482420445482574, -1.3601844078831622, 0.6903398867305081, -1.7010856548394337, 0.10653970163380555, -0.3984042472334263, 2.0800739648444835, -0.7037162172668477, -0.4788489739385548, 1.6841033805989365, 0.21462951327622978, 2.855373991738593},
    {0.28937036386423876, -0.2677426432115391, -0.9298027075727912, 1.159684197217841, 0.1498349561400507, -1.299210805233293, 0.27492828112981654, 0.5028774567495539, 2.0963916963496607, 0.10564520073742671, 1.439317850474969, -1.517986860481182, -1.0855886285534475, 0.42365367365669204, 1.1910781827239756, -0.12199637476648624},
    {1.0682745804763945, 0.04580967216068757, -0.7972221247240331, 1.0425068108139623, -0.2933192609818876, 1.4854943308961333, 1.1847916113603807, 0.5498163246386162, 1.0217543415212256, -0.5360411184704053, 0.3780442754734953, 0.06217931804941444, 0.9244856089911805, 0.7687328887861159, -0.6984372027645063, -1.396523889471292},
    {0.04285660600012297, 1.300560176646752, 0.10485409199054686, -2.039849675304816, -0.43438115715130116, 0.7581110450503705, -0.3525914885142394, 0.8549229382220406, 1.9177214886467426, 1.4449508909165911, 1.4048137309404256, 1.117000974858974, 0.6753840749764711, -1.0502975929163156, -1.0224921421723474, -0.8623999055952724},
    {-0.9772594919524276, -0.9196551153946002, 0.4865523241979552, -1.6620222023120337, -1.4005061187711703, -0.20079629873158109, -1.6906725728659324, -1.2552885934157767, 1.5508098623034425, -1.851491925131613, 1.3010851424423464, -0.6432582394020119, -0.38306961726048117, -1.5298452878828932, -1.909992877315157, -0.6827717266358612},
    {-1.4392201574116976, 0.1496107193251096, -0.4186564791193692, -1.1673217612923146, -0.6552458969907856, -0.004730192507747099, 0.11629844655712925, 0.7622185759719008, -0.7589889226631642, 1.5422915521685894, -1.235823172230447, 1.3124899604919988, -0.6217447714190667, -1.8575311283567648, -0.16371467766361864, -0.0022952070334757},
    {0.62762995658728, 0.8660102594560167, 1.1435876182656757, 1.3941278632327674, 1.6590325665199364, -0.5565174496570884, -0.39512593795490275, -1.2276999285214145, -0.910501557091568, -1.1076160413654659, 1.2325806180171097, -0.24074707386248329, 1.6752828691916533, 2.0773760468413025, 1.859824530868948, -0.7921996015505292},
    {-0.28695982973877776, -0.9389878064140822, -1.1415296993544461, 1.0171269414921889, 1.0344295614483805, 1.8710371255111284, -0.9661609903465248, -1.443587560135289, 0.5252544384629286, 1.0450105277951578, 0.748102382549247, -2.120639039291086, 1.322700294563254, 0.9083708534478919, 1.164457610982312, -0.14299771243078102},
    {1.2119687468023794, 0.9441668727010493, -1.6117759362652686, 1.8490615674755344, -1.1342016937730726, 0.600408013310704, -1.412419861346731, -1.521238940183091, -1.6369633312513, -1.2846565962344028, -1.6104643800257237, 0.2527624048170112, -1.0287723772568378, -1.0012097499005819, 0.8781510458616184, -0.41544019565444024},
    {1.1393037261908987, 1.1245916522188741, 0.14218496265170769, 0.4409862886885923, -0.07857106273269496, -0.4855344289157072, 0.36638674991690257, 0.8638822058715464, 0.9691939914463267, -2.072537720166188, -0.9887120477877717, 1.5531199035335144, 0.22069055711459454, 0.7153489319399969, 1.62191635504895, 0.34469909583174957},
    {-0.5273639230452253, 0.7615335445237156, -0.22373354948679594, -1.7793205394090936, 2.044657361707685, -1.1737219982472984, 0.3926451612417713, 0.3659754832451411, 0.5224417458072773, 1.2746624783783058, 0.10725825460707104, 2.63246268541954, 0.696243962058468, 0.638979404643292, 0.7914789726535498, 1.516531544808898},
    {-0.6982031335390199, 1.0447842465413093, 2.1754233806354235, -0.16045321097532694, -0.7247354900675557, -1.110023413083203, 0.842398139951503, 1.0454365016257567, -1.7873944101371941, 1.1230612029191906, -1.389340061343668, 2.1372406153110086, 1.317164562098495, -0.2977799180385239, -2.3346727228420914, 1.9889652044582913},
    {0.05761146311345929, -0.3455831642536989, -2.9756304674526124, 0.13361017063463249, -0.33358800127610705, -3.8322788395383593, 0.6005807757261359, -5.49284049992211, -5.123389617630836, -3.5510008030157856, -3.7832344325678173, 1.6492372732393106, -4.666092081670587, -0.8432983426960605, -1.299812225349011, 2.26491297746363},
    {-0.226106032715816, -0.7566774894855407, -2.838462904017587, 0.10539816471709089, -0.20762165829306867, -4.355588120031523, -0.4539552352233392, -2.654485436081268, -5.111560676682087, -1.9523178760485203, -4.673091328071309, -0.24342288810953228, -2.636215242311795, 2.6388032705158913, -1.337195744574595, 2.927163185438195},
    {0.679745141302113, -1.050190927212078, -1.6346186060155425, -0.647904519971256, 1.0545021750344679, -0.5818435498317577, -2.8231079878841614, -2.6367709839661706, -1.7445869202147786, -0.4865079780081429, -2.288793612228182, 1.6717920262681003, -3.1303442402052877, -0.7115275917988018, 0.5421517568249441, -0.6898565018081623},
    {-1.7152286666593284, -0.3848768024576657, -1.907667888693267, -0.4629966071910021, 0.05648710228221261, 0.7051320652509713, -2.0331595591679847, -2.3919827605448574, -1.698007174897475, -1.2739482624823504, -1.6583559389653502, -1.520321999555043, -0.5126665365316102, -0.8089350579324943, -0.6868716319980441, 2.085362088080018},
    {0.6620481191993446, -0.5985140031936184, -1.0794886767664529, 1.4010789704159137, 0.9405264520410744, 0.012311994324841145, -1.8541078895700431, -3.7548654583872416, -2.5910314362779117, -0.7224739956875101, -1.11070699445683, -0.19467708070955939, -0.16761911642964444, -0.9072236493120012, 2.2316230308119525, 1.3071382146920294},
    {0.20358070490594748, -2.5803022522486136, -1.0851378065406319, 1.3683547802980542, -1.3660570196225064, -1.4779473636451712, -1.9859701072206326, -2.5725620867783228, -2.3547394831312456, -1.526895110310098, -3.4469229841912883, -0.09068457006630085, -1.5751548093715328, -1.6017827272085041, -0.5095795630695895, 2.4526925405572286},
    {0.6631503904892907, -0.3308579912155821, 1.504123504083686, -0.9764821451083944, -0.25888119379132507, -1.7484724465332147, -0.6106581137066533, -0.12243316133693277, -1.5703528826739115, -1.0904836339521804, 0.2785693103588068, 0.43109276836738847, 0.2623114855316032, 1.942451880747438, -0.27104160352407297, 2.200932244917923},
    {-0.5167983352319991, 0.07099248883517997, 1.6752543574904846, 2.26023642422807, -2.2296381346338454, 0.3618446133004527, -1.0420815149453087, 0.49790279062306064, -0.5099678190661572, -1.2691831023296514, 0.47344640461205867, -1.3042060115135525, 0.4462206593184454, 1.4907076069665273, -1.6384380032367745, 2.4756586611740916},
    {0.8308060849780243, 0.3792269767118477, -1.093082417166283, 1.5551002507247786, -1.4695631795282813, -1.0134327347603873, -0.25067639900992705, -0.4650683391430844, -1.7930820583830238, -0.11140153343132116, -2.3681746906840218, 0.6323831680110565, -1.0025784805746083, 1.4216943470004062, -0.38484014960556245, 2.2491469916033013},
    {0.929168796621405, -1.5561582367910276, -0.321367440889518, -1.7591119999368583, 1.7474493551990606, 0.612606994165502, -1.097918569152446, -1.296636995055743, 0.9112369826286222, -0.7834107363804723, 0.9220801663598112, -0.13213796722379587, 1.1873194301790628, 0.5333873158594709, 0.08065088445813927, 0.2937697412471076},
    {-0.7520524509321754, -0.2513414517906446, 0.7029103670292269, -1.4530931993526508, 3.145554531640198, -0.3834833464266897, 0.2861402692468891, 0.5442314901973843, -0.9166200458288019, -0.2358065026330044, 0.19041385908153252, 1.8548259939206029, 1.4527601028060686, 1.6381380745235827, 3.1379350190534065, 0.6426081948499852},
    {-1.3785625051482073, 0.43852801648098677, 1.926304288782287, 1.9306008553100011, 1.3786842195041145, -0.2501813883299983, -0.9261471432872198, 0.2644344259027002, 0.34918984558923744, -0.35177795640943194, 3.160637628603618, -2.230048180095523, 2.511030666080496, -0.149256106989277, 0.02565631006078747, -0.5048652658918754},
    {-0.8190475160058233, 0.23631380726870158, 1.5279208024873079, 1.1011211119694009, -1.119059003408935, -2.555636422044699, -0.9766549937152537, -0.30131044408919017, -3.345024522874686, -1.3425607283444163, 1.0464147061803926, -2.3112026951032294, 0.12441885952545913, 0.7962337171693933, -0.8008450530683087, 2.1181450756970848},
    {0.32305325197971985, 0.6916163955837676, 1.582042708394908, -0.5594725376151115, -1.5518756694579114, -2.0062616320902604, -0.46518507374959095, -0.4844640678227137, -0.2382832361416985, -2.8633833997242997, 1.1974151343546302, -0.8185185565155608, -1.3428440121058582, 0.7742042947557113, 0.186809346162142, 0.5567493220531976},
    {-1.0925259742245836, -0.19927580902769834, 1.6096599615622482, -0.7110191053927266, 0.5756280765365518, -0.6647648691108607, 0.3441913563848203, -0.6819909792096144, -0.3397560939635913, -0.5476647581354692, 0.7027645291520276, -1.7448927716297338, -0.7659134181632613, 1.7911038222111866, 2.0765557620339603, -0.34490088978783284},
    {0.9150628242100705, 0.28386029854982037, 1.7781466962729116, -0.6819362977372934, -1.4114477957803278, -0.7911818979026053, 1.3575879674358793, 0.06859351056172582, -1.590860627147801, -1.694361427420013, -0.5856122893174345, 0.2505507692885217, 1.6577896030652624, 2.3157882352578065, -0.8061865662258328, 1.8462633729770288},
    {1.9083565438689727, 1.636304146888585, 1.9417144174849303, -0.8072807001863916, -1.0899383426774834, 1.1525236693291798, -0.41143095476678254, -0.7191039475912113, 1.2162366125845763, -2.0120820163951065, 2.7605347486756195, -0.1906019454811953, 2.0549224022549777, 1.312614218351483, -2.2023013659254627, 1.8676623874865754},
    {1.0208215565896928, -0.7013322211459119, 0.27734678164804527, -0.5049520860822133, 1.2374630202723795, -0.5063325502976166, 1.2519510166340748, -0.7836329848384237, -1.200990825080783, 1.110459244899195, -0.9308769669303841, 1.2258345346081019, 0.5380580263266714, 0.837606643009623, 2.403305537503798, -2.5258652020644634},
    {1.3783095378890204, 0.18616626584333917, 0.6989618316363252, -0.14753053709572675, -0.16371345979969837, -1.606944939270955, -0.9867101455922498, -2.1072750489222027, -0.9538417240283559, -1.233196520390592, -0.6397592790895167, 0.5227502960011423, -0.41979440035630344, 0.9238377269760053, 2.0953261828453678, 0.3572140266442559},
    {0.5553053590581111, -0.5881740089580075, 0.035855078144739906, 0.4614306964409218, 1.224707604712978, -0.9372652513036843, 0.7837468642720968, -0.7994946540673799, -1.0173424426657982, 0.93756358930682, -0.6602371025327276, 1.0874179869465699, 1.1542964973629808, 1.2368909273024766, -1.8478551227861857, 2.032930146209559},
    {0.6798151867023701, -0.6689698192190591, -0.5794801895821169, 1.4885059553557825, 1.3069790304239275, -0.7597579067801571, -2.0304562443580187, -1.5320633946060456, -2.419503974517279, 0.9671599547629849, -1.8147092202238622, 1.6308427541650825, 0.6048957158239038, 1.0358443933691541, 1.271282438045431, 2.018355211109152},
    {1.322741824411979, 1.4626631081879677, 0.17049734399304853, 0.31921075858691034, 0.29450100968750065, 0.5732070354311467, 2.2686601465788083, 0.14576531566529474, 0.5111718137793201, 0.8338058744438543, -1.5744121174144787, 1.0753882543047246, 0.4632711523687391, 0.017451993417832413, -0.7781431762424537, 1.4769161782286475},
    {-1.7386833483300521, 1.0693120003373724, 0.2442582901883541, -2.372263361060665, 1.4175324984859812, 2.4665404593387334, -1.4387621316010346, 0.749763519713318, -0.4375042493676808, 0.3893628245004194, 0.9318176021129803, -0.46868387037812304, 1.3772053451405533, 1.0435552688535263, -1.2468232981584213, -0.1959884711868165},
    {0.4127076712845205, 0.15126352096139092, 1.3145523905583945, -1.7680125850965334, 0.5093128325657367, 0.8254537592647171, -0.4594252203533567, -0.06744159871526327, -1.376915277504742, -0.508580620959733, -0.2783765500774664, -0.0388624210790295, -1.2485178396311112, 1.424297439597637, 1.9819694110281474, 1.4822032456770196},
    {-0.17105764286262123, 0.8048918883991085, 0.9371883810599803, -2.1608043315093064, -0.26118414218195357, -0.9345106078028879, -1.3629460693010238, -0.4202234047369088, -1.0846725390295673, -2.20797083222484, -0.1518143782309406, 1.2543757486380256, 0.2816981350023322, 0.6261760738716199, 0.5532189076746872, -0.3488261355041735},
    {1.331438141948065, 0.36840337594206274, 1.7802168000380156, 0.1833171732131684, -0.46897471056168677, 1.2782257299400905, -0.6542334621256263, -1.000519599855621, 0.6435320244501262, -0.7612313821825097, 2.688051585804815, -0.23076751777880752, -0.16463388816586016, 0.4185685011907394, -0.3422738830676217, -1.181723605200218},
    {-0.5779281485713724, -1.5263545385698538, 2.2657260334199494, 0.17453859016631748, 0.2681857897567206, -0.5134399236273904, 1.6147512106421695, -0.6465809928724509, -2.5132846668804034, 0.26275435487817633, 0.8364314629578862, 1.5316526737610971, 1.9969331144265068, 2.0309532482905546, 1.8036009484296363, -0.02810557911660138},
    {1.9961654250439114, 1.10995883848232, -1.3350849098578697, 1.1182464491195736, -1.2220767317483179, -1.570182181779095, -0.4197451776871764, 0.494264414253946, 1.079212429829439, -1.1571291914990678, -1.4969202494722105, 0.33441392554799043, -0.24092912686612614, 0.27987392067017186, -0.06434244107783688, 1.3227958588699273},
    {0.9985044326789325, 2.9534228965190277, 0.2178916705459257, 0.22699246290951716, -0.27813184776303024, -1.5281632851024356, 2.1466293401236127, 1.5891960571440278, -0.0001632897713425166, -0.5599553259842563, -0.34669207825730963, 0.267048238829422, 0.07036675011335619, 0.011477968464951803, 0.5481550237274322, 2.084381654143611},
    {-0.49642611755062377, 1.3742098415697466, 2.2073065813198425, 0.9767192674771032, -2.696547269073643, -0.9298959428563187, 1.3200312740491753, 0.6277828554508281, -3.116386025288193, -0.5219558810651782, -0.10273688294690117, -0.9318175821891586, -0.04570829350667029, -0.18189583163373851, -1.4655615263674078, 1.3539554122796789}
};

static const float b1[16] = {7.292461802731446, 6.566893422665784, 6.8099198227202224, 7.461417184738971, 6.9672046067779725, 6.470204621432253, 6.925610550763068, 7.30352547600604, 7.310118689261294, 6.934149779405421, 7.171462388521678, 5.981644927879102, 6.8393099746074215, 6.96772330089514, 6.727695473563176, 7.159692349335146};

static const float w2[16][12] = {
    {-2.775764902854367, -3.0328716049582214, -3.2576246583999775, -4.53361329676739, -4.704619139676965, -4.680555939298568, -3.4088924616791707, -4.606820338743711, -3.386010012184872, -4.4765647644284785, -3.4647209330095787, -3.2438444974110996},
    {-4.4362382614478335, -4.139190650721882, -2.9150886036369412, -3.3656108726654397, -3.558261155838475, -3.714921095258773, -4.58689403874441, -3.708042302993646, -3.1084389897293194, -3.5517720749368213, -3.7400824837667987, -4.314334410272486},
    {-2.9205992993402092, -3.661257947196716, -2.940294747239904, -3.9851262217365924, -3.2461115674901793, -3.7815794117241195, -4.500421055593839, -3.5639984888136267, -4.028609946285434, -3.4576961484629485, -4.516090860928224, -4.340826608265254},
    {-3.8641560613403856, -3.989422276270643, -4.3403025050437165, -4.024185776911637, -3.7273081492245828, -3.3567700568194008, -4.324318934718336, -4.463957457031417, -4.281796818759163, -3.756194299721812, -4.039159059072944, -3.991954133376544},
    {-2.9020154080304135, -3.1635856737317205, -3.115114664150547, -4.62902084483663, -4.3316483884615895, -2.788359860914388, -3.8181638218667153, -4.190066173431718, -3.698151950303999, -3.0808355216761627, -3.305227062280388, -3.794013769359462},
    {-3.6131271945422414, -3.543555782649872, -3.9186706945001135, -3.1765023206241336, -3.0854546839634525, -2.9779620051866322, -3.2694751245760254, -2.8831325245680097, -4.651197679143793, -3.3641178214949905, -3.22627138502662, -3.4960835716783683},
    {-4.543378606222176, -3.8527681721340055, -4.322646936260871, -4.026085926746139, -3.8477401634161064, -3.2333577095923367, -4.335441002012768, -4.177885117132287, -4.440645140911891, -3.8774308026053355, -3.339147280438918, -4.74382563702387},
    {-3.332119935303707, -3.8046851318292494, -4.5634888241704585, -5.069508812007509, -4.4231765769825575, -4.638213303429778, -2.8660413956610005, -4.705531927747809, -5.088763521993335, -4.240773137358458, -4.521697767417012, -3.6217406758602353},
    {-4.140528988076732, -4.412074597390781, -4.275116072642267, -3.3280034460324366, -3.41340031942557, -3.9234273412087335, -4.828551735928144, -3.539848022460156, -3.596622480741627, -3.840498929219566, -4.788499580903909, -4.334511308950365},
    {-3.6291633497205527, -3.6970360500404382, -3.341502650559712, -3.7568022644544343, -3.396235297689519, -4.149250146900735, -3.6380170224922814, -3.349455643253707, -2.9554065423130225, -3.447903850787984, -4.310253569649521, -3.321448428843394},
    {-4.34869487969434, -3.6107798506586, -4.114062300192502, -4.413967063163133, -4.667811653568416, -3.871368002811898, -2.6789202358659936, -3.9159257660015694, -4.102901662833414, -3.5625677704943617, -3.2373311324729044, -3.787256384013841},
    {-3.6207469576199722, -3.0194824614911138, -4.240363075963969, -2.687621035296593, -3.285910891891557, -2.699659747013924, -2.979880442521805, -3.2384112513626913, -3.4252761760558412, -3.2717309326899704, -2.7605517586082233, -3.1754934608349763},
    {-3.2634060493686734, -3.785525461598281, -3.2477525738284028, -2.7163594316169033, -3.2959909538420993, -4.4120782223959765, -4.063237911190503, -3.7601599486315744, -3.2339413218575905, -4.351040096905126, -3.593629057565236, -2.603758305875078},
    {-3.9259927871323748, -3.7546357872632132, -4.214437294292046, -3.1874042388159176, -3.332657005060745, -2.8562504720583433, -3.286946544404023, -3.625531938767147, -3.0284552155721776, -3.846731949462962, -4.579629823536043, -3.516878297972856},
    {-3.4216875455077687, -3.568703867334141, -3.3933399396305077, -2.7245533428634663, -3.0553598480271624, -3.978991389831013, -3.3553146287399125, -2.4798958506328392, -3.767071217580302, -3.48623115033604, -2.8556106050362504, -3.3393370227620127},
    {-4.507900926794478, -3.7787471261188097, -3.889774019351072, -4.1352447289407985, -3.961359004821248, -4.140656160397863, -3.571701360235855, -3.5485061319147206, -3.7009800167841242, -3.509577961400444, -3.0976104498666226, -3.4289595708530958}
};

static const float b2[12] = {-4.544173265305041, -4.25804349011732, -4.143810582601013, -3.2400903264041796, -3.73377359621278, -3.715355133867831, -3.6036799027980577, -4.277449001457346, -3.8959695271647914, -4.180292795313625, -3.5467758715968456, -4.3900611467261355};

    // Input Layer 
    float z1[16];
    for (int i = 0; i < 16; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Output Layer
    float z2[12];
    for (int k = 0; k < 12; k++)
    {
        z2[k] = b2[k];
        for (int j = 0; j < 16; j++)
        {
            z2[k] += z1[j] * w2[j][k];
        }
    }
    softmax(z2, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
